#ifndef _NOTOSANS_SEMICONDENSED_LIGHTITALIC51PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHTITALIC51PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-LightItalic.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_LightItalic51pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xE0, 0x1C, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x06,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xE0, 0x18, 0x03,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x70, 0x1E, 0x03,
  0xC0, 0x78, 0x00, 0x3C, 0x39, 0xC1, 0xCE, 0x0C, 0x70, 0xE3, 0x07, 0x18,
  0x39, 0xC1, 0x8E, 0x0C, 0x60, 0x63, 0x07, 0x18, 0x30, 0xC1, 0x8C, 0x0C,
  0x00, 0x00, 0x06, 0x03, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x38, 0x0C, 0x00,
  0x06, 0x03, 0x80, 0x00, 0xC0, 0x70, 0x00, 0x38, 0x0C, 0x00, 0x06, 0x01,
  0x80, 0x00, 0xC0, 0x70, 0x00, 0x38, 0x0C, 0x00, 0x07, 0x01, 0x80, 0x3F,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x00, 0xC0, 0x30,
  0x00, 0x18, 0x0E, 0x00, 0x07, 0x01, 0x80, 0x00, 0xC0, 0x30, 0x00, 0x18,
  0x0E, 0x00, 0x03, 0x01, 0x80, 0x00, 0xE0, 0x30, 0x00, 0x18, 0x0E, 0x00,
  0x03, 0x01, 0xC0, 0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0x00, 0xE0, 0x30, 0x00, 0x1C, 0x06, 0x00, 0x03, 0x01, 0xC0, 0x00,
  0x60, 0x30, 0x00, 0x1C, 0x06, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x60, 0x38,
  0x00, 0x1C, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x60, 0x38, 0x00, 0x1C,
  0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x80,
  0xF1, 0x8E, 0x03, 0xC3, 0x04, 0x0F, 0x0C, 0x00, 0x1C, 0x18, 0x00, 0x38,
  0x30, 0x00, 0x60, 0x60, 0x00, 0xC0, 0xC0, 0x01, 0x83, 0x00, 0x03, 0x86,
  0x00, 0x07, 0x8C, 0x00, 0x07, 0x98, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x19, 0xE0,
  0x00, 0x30, 0xE0, 0x00, 0x61, 0xC0, 0x00, 0xC1, 0x80, 0x01, 0x83, 0x80,
  0x06, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x38, 0x00, 0x30, 0x70, 0x80,
  0xE1, 0xC1, 0xE1, 0x8F, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x00, 0x3C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x10, 0x1F, 0xC0, 0x01, 0x80,
  0xE7, 0x80, 0x0C, 0x07, 0x0E, 0x00, 0x70, 0x38, 0x18, 0x01, 0x80, 0xC0,
  0x60, 0x0E, 0x07, 0x01, 0x80, 0x70, 0x1C, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x0E, 0x03, 0x80, 0x60, 0x70, 0x0E, 0x01, 0x81, 0x80, 0x38, 0x0E, 0x0E,
  0x00, 0xC0, 0x38, 0x70, 0x03, 0x00, 0xC1, 0x80, 0x0C, 0x03, 0x0E, 0x00,
  0x30, 0x1C, 0x70, 0xF8, 0xC0, 0x61, 0x8F, 0xF3, 0x03, 0x8E, 0x78, 0xEC,
  0x0E, 0x71, 0xC1, 0xB8, 0x71, 0x8E, 0x06, 0xF3, 0x8E, 0x30, 0x1D, 0xFC,
  0x71, 0xC0, 0x63, 0xE1, 0x87, 0x01, 0x80, 0x0E, 0x18, 0x06, 0x00, 0x70,
  0xE0, 0x18, 0x01, 0x83, 0x80, 0x60, 0x0E, 0x0E, 0x03, 0x80, 0x30, 0x30,
  0x0E, 0x01, 0x80, 0xC0, 0x30, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x07,
  0x01, 0xC0, 0x30, 0x18, 0x0E, 0x00, 0xC0, 0xE0, 0x30, 0x03, 0x03, 0x01,
  0xC0, 0x0E, 0x1C, 0x0E, 0x00, 0x1F, 0xE0, 0x70, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xEF,
  0x80, 0x01, 0xC0, 0xE0, 0x00, 0xE0, 0x1C, 0x00, 0x38, 0x07, 0x00, 0x0E,
  0x01, 0xC0, 0x07, 0x00, 0x70, 0x01, 0xC0, 0x1C, 0x00, 0x70, 0x0E, 0x00,
  0x1C, 0x03, 0x80, 0x07, 0x01, 0xC0, 0x00, 0xE0, 0xF0, 0x00, 0x38, 0x78,
  0x00, 0x0E, 0x3C, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0x0E, 0x00, 0xC7,
  0x83, 0x80, 0x71, 0xC0, 0x70, 0x1C, 0xE0, 0x1C, 0x0E, 0x70, 0x03, 0x83,
  0x9C, 0x00, 0xF1, 0xCE, 0x00, 0x1C, 0xE3, 0x80, 0x07, 0xB8, 0xE0, 0x00,
  0xFC, 0x38, 0x00, 0x1E, 0x0E, 0x00, 0x07, 0x83, 0x80, 0x03, 0xE0, 0xF0,
  0x01, 0xF8, 0x1C, 0x00, 0xE7, 0x07, 0xC0, 0xF1, 0xE0, 0xFF, 0xF8, 0x38,
  0x0F, 0xF8, 0x07, 0x00, 0x60, 0x00, 0x00, 0x3C, 0xE3, 0x8E, 0x30, 0xC7,
  0x1C, 0x61, 0x86, 0x18, 0xC0, 0x00, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x03,
  0x00, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00,
  0x38, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x70, 0x00, 0x60, 0x00,
  0xE0, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0,
  0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x00, 0x20, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x01, 0x80, 0xC0, 0x3C, 0x18,
  0x07, 0xE3, 0x00, 0x1E, 0x40, 0x60, 0xFF, 0xFC, 0x03, 0xFF, 0x81, 0xF0,
  0x00, 0x76, 0x00, 0x1C, 0xE0, 0x07, 0x0C, 0x01, 0xC1, 0xC0, 0x70, 0x18,
  0x06, 0x03, 0x80, 0x00, 0x70, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x07, 0x0F, 0x0E, 0x0E, 0x1C, 0x1C, 0x38, 0x38, 0x30, 0x70,
  0x60, 0xE0, 0xC0, 0x7F, 0xF7, 0xFF, 0xFF, 0xF0, 0x27, 0xFF, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xFF,
  0x80, 0x0F, 0xFF, 0x00, 0x78, 0x1E, 0x01, 0xC0, 0x38, 0x0E, 0x00, 0xE0,
  0x70, 0x01, 0xC1, 0xC0, 0x07, 0x0E, 0x00, 0x1C, 0x38, 0x00, 0x71, 0xC0,
  0x01, 0xC7, 0x00, 0x07, 0x1C, 0x00, 0x1C, 0xE0, 0x00, 0x73, 0x80, 0x01,
  0xCE, 0x00, 0x07, 0x38, 0x00, 0x1D, 0xC0, 0x00, 0xE7, 0x00, 0x03, 0x9C,
  0x00, 0x0E, 0x70, 0x00, 0x39, 0xC0, 0x00, 0xE6, 0x00, 0x07, 0x38, 0x00,
  0x1C, 0xE0, 0x00, 0x73, 0x80, 0x03, 0x8E, 0x00, 0x0E, 0x38, 0x00, 0x38,
  0xE0, 0x01, 0xC3, 0x80, 0x07, 0x07, 0x00, 0x38, 0x1C, 0x00, 0xE0, 0x70,
  0x07, 0x00, 0xE0, 0x38, 0x03, 0xC3, 0xC0, 0x07, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x78, 0x0F, 0x80, 0xFC, 0x0F, 0xE1, 0xE7,
  0x1E, 0x33, 0xE3, 0x8C, 0x1C, 0x40, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x06,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x0E,
  0x00, 0x70, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xFC,
  0x01, 0xE0, 0x1E, 0x00, 0xC0, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xFC, 0x03, 0xE0, 0x1E, 0x01, 0x80, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x03, 0xE0, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0xC0, 0x03, 0xC0,
  0xF8, 0x0F, 0x80, 0xFF, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xEE, 0x00, 0x00, 0xCC, 0x00, 0x01, 0xDC,
  0x00, 0x03, 0x9C, 0x00, 0x07, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x18,
  0x00, 0x1C, 0x38, 0x00, 0x38, 0x38, 0x00, 0x70, 0x38, 0x00, 0x60, 0x30,
  0x00, 0xE0, 0x70, 0x01, 0xC0, 0x70, 0x03, 0x80, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x1C, 0x00, 0xE0, 0x38, 0x00, 0xE0,
  0x30, 0x00, 0xE0, 0x70, 0x00, 0xC0, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0xBF, 0x80, 0x07, 0xFF,
  0xC0, 0x0F, 0xDF, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x80,
  0x07, 0x81, 0xE0, 0x3E, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x1E,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x83, 0xC0, 0x1C, 0x7F, 0xC0, 0x73, 0xFF,
  0x81, 0xDC, 0x0F, 0x06, 0xC0, 0x1C, 0x3E, 0x00, 0x38, 0xF0, 0x00, 0xE3,
  0xC0, 0x03, 0x8E, 0x00, 0x0E, 0x38, 0x00, 0x38, 0xE0, 0x00, 0xE3, 0x00,
  0x03, 0x8C, 0x00, 0x0E, 0x30, 0x00, 0x38, 0xC0, 0x01, 0xC3, 0x00, 0x07,
  0x0E, 0x00, 0x1C, 0x38, 0x00, 0xE0, 0xE0, 0x07, 0x01, 0xC0, 0x3C, 0x07,
  0xC3, 0xE0, 0x0F, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x04, 0x00, 0x00, 0x3F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xF0, 0x07,
  0x00, 0xE0, 0x1C, 0x00, 0xE0, 0x70, 0x01, 0xC0, 0xE0, 0x03, 0x81, 0xC0,
  0x03, 0x03, 0x00, 0x06, 0x06, 0x00, 0x1C, 0x0C, 0x00, 0x38, 0x1C, 0x00,
  0x60, 0x38, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x70, 0x1C, 0x00, 0x70, 0xF0,
  0x00, 0x7F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x3C, 0x00,
  0x78, 0x3C, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x70,
  0x00, 0x70, 0xE0, 0x00, 0xE1, 0x80, 0x01, 0xC7, 0x00, 0x03, 0x8E, 0x00,
  0x07, 0x1C, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x78, 0x70, 0x00,
  0xE0, 0xF0, 0x03, 0x80, 0xF8, 0x1F, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xE0,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xC0, 0x03, 0xFF,
  0xC0, 0x0F, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x70, 0x03, 0x81, 0xC0, 0x07,
  0x07, 0x80, 0x06, 0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x70, 0x00, 0x38,
  0xE0, 0x00, 0x71, 0xC0, 0x00, 0xE3, 0x80, 0x03, 0x87, 0x00, 0x07, 0x0E,
  0x00, 0x0E, 0x1C, 0x00, 0x3C, 0x38, 0x00, 0x78, 0x38, 0x01, 0xF0, 0x78,
  0x0E, 0xC0, 0x7C, 0x7B, 0x80, 0x7F, 0xE7, 0x00, 0x7F, 0x0E, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x3C, 0x03, 0x01, 0xF0, 0x07, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x83, 0xC1, 0xE0, 0xE0, 0x20,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x81, 0xE0, 0xF0, 0x78, 0x3C,
  0x00, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x0E, 0x00,
  0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x06,
  0x00, 0xC0, 0x0C, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x70, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x03, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x0F,
  0xFE, 0x0F, 0xFF, 0x83, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x01, 0xF8, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x1C, 0x00, 0x00, 0x38, 0x0E, 0x00,
  0x00, 0x06, 0x07, 0x00, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x00, 0x70, 0xE0,
  0x07, 0xF8, 0x0C, 0x30, 0x07, 0xFF, 0x03, 0x1C, 0x03, 0x81, 0x80, 0xC6,
  0x01, 0xC0, 0x60, 0x33, 0x80, 0xE0, 0x38, 0x0C, 0xC0, 0x70, 0x0E, 0x03,
  0x70, 0x18, 0x03, 0x00, 0xDC, 0x0E, 0x00, 0xC0, 0x76, 0x03, 0x00, 0x70,
  0x1D, 0x81, 0xC0, 0x1C, 0x07, 0x60, 0x70, 0x06, 0x01, 0xB8, 0x18, 0x03,
  0x80, 0xEE, 0x06, 0x00, 0xE0, 0x3B, 0x81, 0x80, 0x38, 0x0C, 0xE0, 0x60,
  0x1C, 0x07, 0x38, 0x18, 0x07, 0x01, 0x8E, 0x07, 0x03, 0xC0, 0xE3, 0x81,
  0xC1, 0x98, 0x70, 0xE0, 0x3F, 0xC7, 0xF8, 0x18, 0x07, 0xE0, 0xFC, 0x06,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x03, 0x80, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x06, 0xC0, 0x00, 0x07, 0x60, 0x00, 0x03, 0x30, 0x00, 0x03, 0x98,
  0x00, 0x01, 0x8C, 0x00, 0x01, 0xC7, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xE1,
  0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x70, 0x38, 0x00, 0x38,
  0x1C, 0x00, 0x38, 0x0E, 0x00, 0x1C, 0x07, 0x00, 0x1C, 0x01, 0x80, 0x0E,
  0x00, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x38, 0x07, 0xFF, 0xFC, 0x03,
  0xFF, 0xFE, 0x03, 0x80, 0x07, 0x01, 0xC0, 0x03, 0x81, 0xC0, 0x01, 0xC0,
  0xE0, 0x00, 0xE0, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x38, 0x70, 0x00, 0x0C,
  0x38, 0x00, 0x06, 0x38, 0x00, 0x03, 0x1C, 0x00, 0x01, 0xDC, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x38, 0x01, 0xFF, 0xF0, 0x00, 0xFF,
  0xFE, 0x00, 0x60, 0x0F, 0x80, 0x70, 0x01, 0xE0, 0x38, 0x00, 0x70, 0x1C,
  0x00, 0x38, 0x0E, 0x00, 0x1C, 0x06, 0x00, 0x0F, 0x07, 0x00, 0x07, 0x03,
  0x80, 0x03, 0x81, 0xC0, 0x01, 0xC0, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0xE0,
  0x70, 0x00, 0xE0, 0x38, 0x00, 0xE0, 0x1C, 0x07, 0xE0, 0x0F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xE0, 0x07, 0x00, 0xF8, 0x03, 0x80, 0x0E, 0x01, 0xC0, 0x03,
  0x80, 0xC0, 0x01, 0xC0, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x38, 0x38, 0x00,
  0x1C, 0x1C, 0x00, 0x0E, 0x0C, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x87, 0x00,
  0x03, 0x83, 0x80, 0x03, 0xC1, 0xC0, 0x01, 0xC1, 0xC0, 0x01, 0xE0, 0xE0,
  0x03, 0xE0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xF0,
  0x06, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xF8, 0x1C, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x04, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x03,
  0x00, 0xFC, 0x00, 0xE0, 0x07, 0xC0, 0x1C, 0x00, 0x38, 0x03, 0x80, 0x03,
  0x80, 0x70, 0x00, 0x70, 0x0C, 0x00, 0x07, 0x03, 0x80, 0x00, 0xE0, 0x70,
  0x00, 0x1C, 0x0E, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x0E,
  0x0E, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x07, 0x06, 0x00,
  0x00, 0xE1, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x87, 0x00, 0x00, 0x70,
  0xE0, 0x00, 0x1C, 0x18, 0x00, 0x03, 0x87, 0x00, 0x00, 0x70, 0xE0, 0x00,
  0x1C, 0x1C, 0x00, 0x03, 0x83, 0x80, 0x00, 0xF0, 0xE0, 0x00, 0x1C, 0x1C,
  0x00, 0x07, 0x03, 0x80, 0x01, 0xE0, 0x70, 0x00, 0x78, 0x0E, 0x00, 0x1E,
  0x03, 0x80, 0x0F, 0x80, 0x70, 0x07, 0xE0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF,
  0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xC0, 0x0E, 0x00, 0xF0, 0x00, 0x20,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x01, 0xFF,
  0x87, 0x00, 0x1F, 0xF8, 0xE0, 0x01, 0xFF, 0x8E, 0x00, 0x00, 0x38, 0xE0,
  0x00, 0x03, 0x0E, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x07, 0x0E, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x07,
  0x00, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x03, 0x80, 0x00, 0xC0, 0x3C, 0x00,
  0x1C, 0x01, 0xE0, 0x01, 0xC0, 0x0F, 0x80, 0xFC, 0x00, 0x7F, 0xFF, 0xC0,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x0E,
  0x00, 0x01, 0xC0, 0x60, 0x00, 0x1C, 0x07, 0x00, 0x00, 0xE0, 0x38, 0x00,
  0x07, 0x01, 0xC0, 0x00, 0x38, 0x0E, 0x00, 0x01, 0x80, 0x60, 0x00, 0x1C,
  0x07, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x38, 0x0E,
  0x00, 0x01, 0x80, 0xE0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0xE0, 0x38, 0x00,
  0x07, 0x01, 0xC0, 0x00, 0x38, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC,
  0x07, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x38, 0x0C,
  0x00, 0x03, 0x80, 0xE0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0xE0, 0x38, 0x00,
  0x07, 0x01, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x1C,
  0x07, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x70, 0x1C,
  0x00, 0x03, 0x80, 0xE0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0xE0, 0x38, 0x00,
  0x07, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x01, 0xFF, 0xC0, 0x3F, 0xC0, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x0F, 0xFC,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00,
  0xC7, 0xC0, 0x0F, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xE0, 0x00, 0xF0,
  0x0E, 0x00, 0x1C, 0x00, 0xC0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x0F, 0x00, 0x1C, 0x01, 0xE0, 0x01, 0xC0, 0x3C, 0x00, 0x18, 0x07, 0x80,
  0x03, 0x80, 0xF0, 0x00, 0x38, 0x1E, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x38,
  0x78, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x07, 0x1C, 0x00,
  0x00, 0x73, 0x80, 0x00, 0x06, 0x7C, 0x00, 0x00, 0xEF, 0xC0, 0x00, 0x0F,
  0xDC, 0x00, 0x00, 0xF8, 0xE0, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0xC0, 0xF0,
  0x00, 0x1C, 0x07, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x1C, 0x03, 0x80, 0x01,
  0xC0, 0x38, 0x00, 0x38, 0x03, 0x80, 0x03, 0x80, 0x1C, 0x00, 0x38, 0x01,
  0xC0, 0x03, 0x80, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x0E, 0x00,
  0x70, 0x00, 0xF0, 0x07, 0x00, 0x07, 0x00, 0x70, 0x00, 0x70, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x3F, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x07, 0x80, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x1F, 0x80, 0x00, 0x3B, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x06,
  0xE0, 0x00, 0x1D, 0xC0, 0x37, 0x00, 0x00, 0xEE, 0x03, 0x98, 0x00, 0x0E,
  0x70, 0x1C, 0xC0, 0x00, 0x77, 0x00, 0xE6, 0x00, 0x07, 0x38, 0x06, 0x38,
  0x00, 0x39, 0xC0, 0x71, 0xC0, 0x03, 0x8E, 0x03, 0x8E, 0x00, 0x18, 0x70,
  0x1C, 0x70, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0x0C, 0x38, 0x06, 0x0C, 0x00,
  0xE1, 0xC0, 0x70, 0x60, 0x0E, 0x0E, 0x03, 0x83, 0x00, 0x70, 0x60, 0x1C,
  0x18, 0x07, 0x07, 0x00, 0xE0, 0xE0, 0x38, 0x38, 0x06, 0x07, 0x03, 0x81,
  0xC0, 0x70, 0x38, 0x1C, 0x0E, 0x03, 0x81, 0xC1, 0xC0, 0x60, 0x1C, 0x0E,
  0x0E, 0x07, 0x00, 0xC0, 0x30, 0xE0, 0x38, 0x0E, 0x01, 0x86, 0x01, 0xC0,
  0x70, 0x0C, 0x70, 0x0E, 0x03, 0x80, 0x63, 0x00, 0xE0, 0x1C, 0x03, 0xB8,
  0x07, 0x00, 0xC0, 0x1D, 0x80, 0x38, 0x0E, 0x00, 0xFC, 0x01, 0xC0, 0x70,
  0x07, 0xC0, 0x0E, 0x03, 0x80, 0x3E, 0x00, 0xE0, 0x1C, 0x00, 0xE0, 0x07,
  0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x01, 0xE0,
  0x00, 0x18, 0x03, 0xC0, 0x00, 0x70, 0x0F, 0x80, 0x00, 0xE0, 0x1F, 0x80,
  0x01, 0xC0, 0x3F, 0x00, 0x03, 0x80, 0x66, 0x00, 0x0E, 0x00, 0xCE, 0x00,
  0x1C, 0x03, 0x9C, 0x00, 0x38, 0x07, 0x18, 0x00, 0x70, 0x0E, 0x38, 0x00,
  0xC0, 0x18, 0x70, 0x03, 0x80, 0x70, 0x60, 0x07, 0x00, 0xE0, 0xE0, 0x0E,
  0x01, 0xC1, 0xC0, 0x1C, 0x03, 0x83, 0x80, 0x30, 0x06, 0x03, 0x80, 0xE0,
  0x1C, 0x07, 0x01, 0xC0, 0x38, 0x0E, 0x03, 0x80, 0x70, 0x0E, 0x07, 0x00,
  0xE0, 0x1C, 0x0C, 0x01, 0x80, 0x38, 0x38, 0x07, 0x00, 0x38, 0x70, 0x0E,
  0x00, 0x70, 0xE0, 0x1C, 0x00, 0xE1, 0x80, 0x30, 0x00, 0xE7, 0x00, 0xE0,
  0x01, 0xCE, 0x01, 0xC0, 0x03, 0x9C, 0x03, 0x80, 0x03, 0x38, 0x07, 0x00,
  0x07, 0x60, 0x0C, 0x00, 0x0E, 0xC0, 0x38, 0x00, 0x0F, 0x80, 0x70, 0x00,
  0x1F, 0x00, 0xE0, 0x00, 0x3E, 0x01, 0xC0, 0x00, 0x38, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0x00, 0x0F, 0x80, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x3C, 0x00, 0x1C, 0x07,
  0x80, 0x01, 0xE0, 0x70, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xE0, 0xE0, 0x00,
  0x0E, 0x1C, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x06, 0x38, 0x00, 0x00, 0x73,
  0x80, 0x00, 0x06, 0x38, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x0E, 0x70, 0x00,
  0x00, 0xE7, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x0E,
  0xE0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x01, 0xCE, 0x00,
  0x00, 0x1C, 0xE0, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x03,
  0x8E, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x07, 0x07, 0x00, 0x00, 0xE0, 0x70,
  0x00, 0x1E, 0x07, 0x80, 0x03, 0xC0, 0x38, 0x00, 0x78, 0x03, 0xE0, 0x0F,
  0x00, 0x1F, 0x83, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x30, 0x1F,
  0x80, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0x70, 0x0E, 0x00, 0x38, 0x07, 0x00,
  0x1C, 0x03, 0x00, 0x07, 0x03, 0x80, 0x03, 0x81, 0xC0, 0x01, 0xC0, 0xE0,
  0x01, 0xC0, 0x70, 0x00, 0xE0, 0x70, 0x00, 0x70, 0x38, 0x00, 0x38, 0x1C,
  0x00, 0x38, 0x0E, 0x00, 0x3C, 0x07, 0x00, 0x3C, 0x07, 0x00, 0x7C, 0x03,
  0x83, 0xFC, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x60, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0x80, 0xF8, 0x01, 0xE0,
  0x03, 0xC0, 0x3C, 0x00, 0x1C, 0x07, 0x80, 0x01, 0xE0, 0x70, 0x00, 0x0E,
  0x0E, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0xE1, 0xC0,
  0x00, 0x06, 0x38, 0x00, 0x00, 0x73, 0x80, 0x00, 0x06, 0x38, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x0E, 0x70,
  0x00, 0x00, 0xEF, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0x1C, 0xE0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x03, 0xCE,
  0x00, 0x00, 0x38, 0xE0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x70, 0xF0, 0x00,
  0x07, 0x07, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xC0,
  0x38, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x30, 0x1F, 0x80, 0x38,
  0x01, 0xE0, 0x1C, 0x00, 0x70, 0x0E, 0x00, 0x38, 0x07, 0x00, 0x1C, 0x03,
  0x00, 0x07, 0x03, 0x80, 0x03, 0x81, 0xC0, 0x03, 0x80, 0xE0, 0x01, 0xC0,
  0x70, 0x00, 0xE0, 0x70, 0x00, 0x70, 0x38, 0x00, 0x78, 0x1C, 0x00, 0x38,
  0x0E, 0x00, 0x38, 0x07, 0x00, 0x7C, 0x07, 0x00, 0xF8, 0x03, 0xFF, 0xF8,
  0x01, 0xFF, 0xE0, 0x00, 0xE0, 0x70, 0x00, 0x60, 0x38, 0x00, 0x70, 0x0C,
  0x00, 0x38, 0x07, 0x00, 0x1C, 0x03, 0x80, 0x0E, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x07, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x07, 0x00, 0xE0,
  0x03, 0x80, 0xE0, 0x01, 0xC0, 0x70, 0x00, 0xF0, 0x38, 0x00, 0x38, 0x1C,
  0x00, 0x1C, 0x1E, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xFE,
  0x00, 0xFF, 0xFF, 0x01, 0xF0, 0x0E, 0x01, 0xC0, 0x02, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x80, 0x07, 0xC0,
  0xF0, 0x1F, 0x80, 0xFF, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x80, 0x00,
  0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF8, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x70, 0x70, 0x00, 0x07, 0x07, 0x00,
  0x00, 0x60, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x0E,
  0x0E, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0C, 0x0E, 0x00, 0x01, 0xC0, 0xE0,
  0x00, 0x1C, 0x0C, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x1C, 0x1C, 0x00, 0x03,
  0x81, 0xC0, 0x00, 0x38, 0x1C, 0x00, 0x03, 0x83, 0x80, 0x00, 0x38, 0x38,
  0x00, 0x03, 0x03, 0x80, 0x00, 0x70, 0x38, 0x00, 0x07, 0x03, 0x80, 0x00,
  0x70, 0x70, 0x00, 0x07, 0x07, 0x00, 0x00, 0x60, 0x70, 0x00, 0x0E, 0x07,
  0x00, 0x00, 0xE0, 0x60, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xE0, 0xE0, 0x00,
  0x1C, 0x0E, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x3C, 0x0E, 0x00, 0x03, 0x80,
  0x70, 0x00, 0x78, 0x07, 0x00, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xE0,
  0x7C, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x1C, 0xE0, 0x00,
  0x1C, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x70, 0xE0, 0x00,
  0x70, 0xE0, 0x00, 0xE0, 0x60, 0x00, 0xE0, 0x60, 0x01, 0xC0, 0x60, 0x01,
  0xC0, 0x70, 0x03, 0x80, 0x70, 0x03, 0x80, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x0E, 0x00, 0x70, 0x0E, 0x00, 0x70, 0x1C, 0x00, 0x70, 0x1C,
  0x00, 0x70, 0x38, 0x00, 0x70, 0x38, 0x00, 0x30, 0x70, 0x00, 0x30, 0x70,
  0x00, 0x30, 0xE0, 0x00, 0x30, 0xE0, 0x00, 0x31, 0xC0, 0x00, 0x39, 0xC0,
  0x00, 0x3B, 0x80, 0x00, 0x3B, 0x80, 0x00, 0x3B, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x3F, 0x80, 0x01, 0xC0, 0x00, 0xEE, 0x00,
  0x0F, 0x80, 0x07, 0x38, 0x00, 0x3E, 0x00, 0x1C, 0xE0, 0x01, 0xF8, 0x00,
  0x73, 0x80, 0x07, 0xE0, 0x03, 0x8E, 0x00, 0x1B, 0x80, 0x0E, 0x18, 0x00,
  0xEE, 0x00, 0x70, 0x60, 0x03, 0x38, 0x01, 0xC1, 0x80, 0x1C, 0xE0, 0x0E,
  0x06, 0x00, 0x63, 0x80, 0x38, 0x18, 0x03, 0x8E, 0x00, 0xE0, 0x60, 0x0E,
  0x38, 0x07, 0x01, 0x80, 0x70, 0xE0, 0x1C, 0x06, 0x01, 0xC3, 0x80, 0xE0,
  0x18, 0x06, 0x0E, 0x03, 0x80, 0x60, 0x38, 0x38, 0x1C, 0x01, 0x80, 0xC0,
  0xE0, 0x70, 0x06, 0x07, 0x03, 0x81, 0xC0, 0x18, 0x1C, 0x0E, 0x0E, 0x00,
  0x60, 0xE0, 0x38, 0x38, 0x01, 0xC3, 0x80, 0xE1, 0xC0, 0x07, 0x1C, 0x03,
  0x87, 0x00, 0x1C, 0x70, 0x06, 0x38, 0x00, 0x71, 0x80, 0x18, 0xE0, 0x01,
  0xCE, 0x00, 0x63, 0x00, 0x07, 0x30, 0x01, 0x9C, 0x00, 0x1D, 0xC0, 0x06,
  0x70, 0x00, 0x77, 0x00, 0x1B, 0x80, 0x01, 0xF8, 0x00, 0x6E, 0x00, 0x07,
  0xE0, 0x01, 0xB0, 0x00, 0x1B, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x3C, 0x01, 0xC0, 0x01, 0xC0,
  0x03, 0x80, 0x0F, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x38, 0x01, 0xC0, 0x00,
  0x60, 0x0E, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x1C,
  0x0E, 0x00, 0x00, 0x30, 0x78, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x03, 0x8E,
  0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00,
  0xF3, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0xE0,
  0xE0, 0x00, 0x03, 0x81, 0x80, 0x00, 0x1C, 0x07, 0x00, 0x00, 0xE0, 0x1C,
  0x00, 0x07, 0x80, 0x70, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0xE0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x70, 0x07,
  0x00, 0x01, 0xC0, 0x3C, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x3F, 0x80, 0x01,
  0xCE, 0x00, 0x07, 0x38, 0x00, 0x38, 0x70, 0x01, 0xE1, 0xC0, 0x07, 0x07,
  0x00, 0x38, 0x1C, 0x01, 0xE0, 0x30, 0x07, 0x00, 0xE0, 0x38, 0x03, 0x80,
  0xE0, 0x0E, 0x07, 0x00, 0x38, 0x38, 0x00, 0x60, 0xE0, 0x01, 0xC7, 0x00,
  0x07, 0x1C, 0x00, 0x1C, 0xE0, 0x00, 0x77, 0x00, 0x00, 0xDC, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0xE0, 0x60, 0x60,
  0x60, 0x70, 0x70, 0x70, 0x70, 0x30, 0x30, 0x38, 0x38, 0x38, 0x38, 0x18,
  0x18, 0x18, 0x1C, 0x1C, 0x1C, 0x1C, 0x0C, 0x0C, 0x0E, 0x0E, 0x0E, 0x0E,
  0x06, 0x06, 0x06, 0x07, 0x07, 0x07, 0x07, 0x03, 0x03, 0x00, 0x3F, 0xF0,
  0x07, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x36,
  0x00, 0x01, 0xDC, 0x00, 0x06, 0x30, 0x00, 0x38, 0xE0, 0x01, 0xC1, 0x80,
  0x06, 0x06, 0x00, 0x38, 0x1C, 0x00, 0xC0, 0x30, 0x07, 0x00, 0xE0, 0x38,
  0x03, 0x80, 0xE0, 0x06, 0x07, 0x00, 0x1C, 0x18, 0x00, 0x70, 0xE0, 0x00,
  0xC3, 0x00, 0x03, 0x9C, 0x00, 0x06, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x70,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xF0, 0xE1, 0xE1, 0xC1, 0x83, 0x83, 0x83,
  0x00, 0x0C, 0x02, 0x01, 0xFE, 0x18, 0x07, 0xFE, 0x30, 0x1E, 0x0E, 0xE0,
  0x78, 0x0D, 0xC1, 0xE0, 0x0F, 0x83, 0x80, 0x1E, 0x0E, 0x00, 0x1C, 0x3C,
  0x00, 0x38, 0x70, 0x00, 0x70, 0xE0, 0x01, 0xC3, 0x80, 0x03, 0x87, 0x00,
  0x07, 0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x70, 0x00, 0x30, 0xE0, 0x00,
  0xE1, 0xC0, 0x01, 0xC3, 0x80, 0x03, 0x87, 0x00, 0x0F, 0x0E, 0x00, 0x1C,
  0x1C, 0x00, 0x78, 0x38, 0x01, 0xF0, 0x38, 0x07, 0xE0, 0x70, 0x1D, 0xC0,
  0xF0, 0x73, 0x00, 0xFF, 0xC6, 0x00, 0xFE, 0x0C, 0x00, 0x20, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x0C, 0x00, 0x30,
  0xFF, 0x00, 0xE3, 0xFF, 0x01, 0xDE, 0x0F, 0x03, 0xB0, 0x0E, 0x06, 0xC0,
  0x1C, 0x0F, 0x00, 0x1C, 0x3E, 0x00, 0x38, 0x78, 0x00, 0x70, 0xE0, 0x00,
  0xE1, 0xC0, 0x01, 0xC3, 0x80, 0x03, 0x8E, 0x00, 0x07, 0x1C, 0x00, 0x0C,
  0x38, 0x00, 0x38, 0x60, 0x00, 0x71, 0xC0, 0x00, 0xE3, 0x80, 0x01, 0x87,
  0x00, 0x07, 0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x38, 0x78, 0x00, 0x70, 0xF0,
  0x01, 0xC1, 0xF0, 0x07, 0x83, 0x60, 0x1E, 0x06, 0x70, 0x78, 0x1C, 0xFF,
  0xE0, 0x30, 0xFF, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x0F, 0xFC,
  0x07, 0xFF, 0x01, 0xE0, 0x20, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x81, 0xC0, 0x7F, 0xF8, 0x07,
  0xFE, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x80, 0x01, 0x81, 0xC0, 0x0F, 0xF0, 0xE0, 0x0F, 0xFE, 0x60,
  0x0F, 0x07, 0x30, 0x0F, 0x00, 0xF8, 0x0F, 0x00, 0x7C, 0x0F, 0x00, 0x1E,
  0x07, 0x00, 0x0E, 0x07, 0x80, 0x07, 0x03, 0x80, 0x03, 0x81, 0xC0, 0x01,
  0xC1, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x60, 0x70, 0x00, 0x70, 0x38, 0x00,
  0x38, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x1E, 0x0E, 0x00, 0x0E, 0x07, 0x00,
  0x07, 0x03, 0x80, 0x07, 0x81, 0xC0, 0x03, 0xC0, 0xE0, 0x03, 0xC0, 0x70,
  0x03, 0xE0, 0x1C, 0x03, 0xF0, 0x0E, 0x03, 0xB8, 0x07, 0x83, 0x9C, 0x01,
  0xFF, 0x8C, 0x00, 0x7F, 0x86, 0x00, 0x04, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x0F, 0xF0, 0x07, 0xFF, 0x01, 0xE0, 0xF0, 0x78, 0x0E, 0x1E, 0x01, 0xC3,
  0x80, 0x38, 0xE0, 0x07, 0x38, 0x00, 0xE7, 0x00, 0x3C, 0xE0, 0x07, 0x38,
  0x03, 0xC7, 0x03, 0xF0, 0xFF, 0xFC, 0x1F, 0xFC, 0x07, 0xC0, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x01, 0x07, 0x80, 0xE0, 0x7F,
  0xFC, 0x07, 0xFE, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xD8, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x8F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x1F, 0xF1, 0xC0, 0x1F,
  0xFC, 0xE0, 0x1E, 0x0E, 0x60, 0x1E, 0x01, 0xB0, 0x1E, 0x00, 0xF8, 0x0E,
  0x00, 0x3C, 0x0E, 0x00, 0x1C, 0x0F, 0x00, 0x0E, 0x07, 0x00, 0x07, 0x03,
  0x80, 0x03, 0x83, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0xC0, 0xE0, 0x00, 0xE0,
  0x70, 0x00, 0x70, 0x70, 0x00, 0x38, 0x38, 0x00, 0x3C, 0x1C, 0x00, 0x1C,
  0x0E, 0x00, 0x0E, 0x07, 0x00, 0x0F, 0x03, 0x80, 0x07, 0x81, 0xC0, 0x07,
  0x80, 0xE0, 0x07, 0xC0, 0x38, 0x07, 0xE0, 0x1C, 0x07, 0x70, 0x0F, 0x07,
  0x38, 0x03, 0xFF, 0x18, 0x00, 0xFF, 0x1C, 0x00, 0x08, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x0C, 0x00, 0xF0, 0x07,
  0xC1, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x60, 0x03, 0x0F, 0xF0, 0x1C, 0xFF, 0xE0,
  0x77, 0x83, 0xC1, 0xD8, 0x07, 0x06, 0xC0, 0x1C, 0x1E, 0x00, 0x70, 0xF0,
  0x01, 0xC3, 0xC0, 0x07, 0x0E, 0x00, 0x1C, 0x38, 0x00, 0x70, 0xC0, 0x03,
  0x87, 0x00, 0x0E, 0x1C, 0x00, 0x38, 0x70, 0x00, 0xE1, 0xC0, 0x03, 0x0E,
  0x00, 0x1C, 0x38, 0x00, 0x70, 0xE0, 0x01, 0xC3, 0x80, 0x07, 0x0C, 0x00,
  0x18, 0x70, 0x00, 0xE1, 0xC0, 0x03, 0x87, 0x00, 0x0E, 0x1C, 0x00, 0x38,
  0x60, 0x00, 0xC3, 0x80, 0x07, 0x0E, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x3C,
  0x07, 0x80, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x70, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x23, 0xC0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x3C, 0x1C, 0x01, 0xE0,
  0x70, 0x0F, 0x01, 0xC0, 0x78, 0x07, 0x03, 0xC0, 0x18, 0x0E, 0x00, 0xE0,
  0x70, 0x03, 0x83, 0x80, 0x0E, 0x1C, 0x00, 0x38, 0xE0, 0x00, 0xC7, 0x00,
  0x07, 0x3C, 0x00, 0x1D, 0xF0, 0x00, 0x6F, 0xC0, 0x01, 0xF3, 0x80, 0x0F,
  0x8E, 0x00, 0x3C, 0x38, 0x00, 0xE0, 0x70, 0x03, 0x81, 0xC0, 0x0C, 0x07,
  0x00, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x70, 0x1C, 0x01, 0xC0,
  0x60, 0x07, 0x03, 0x80, 0x0E, 0x0E, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x30, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x60, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x06, 0x01,
  0xC0, 0x38, 0x00, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x61, 0xFC, 0x0F, 0xF0,
  0x1C, 0xFF, 0xC3, 0xFF, 0x03, 0xB8, 0x38, 0xE0, 0xF0, 0x6E, 0x03, 0xB8,
  0x0E, 0x0D, 0x80, 0x7E, 0x01, 0xC1, 0xE0, 0x0F, 0x80, 0x38, 0x78, 0x01,
  0xE0, 0x07, 0x0F, 0x00, 0x3C, 0x00, 0xE1, 0xC0, 0x07, 0x00, 0x1C, 0x38,
  0x00, 0xE0, 0x03, 0x86, 0x00, 0x18, 0x00, 0x61, 0xC0, 0x07, 0x00, 0x1C,
  0x38, 0x00, 0xE0, 0x03, 0x87, 0x00, 0x1C, 0x00, 0x70, 0xE0, 0x03, 0x80,
  0x0E, 0x38, 0x00, 0x60, 0x01, 0x87, 0x00, 0x1C, 0x00, 0x70, 0xE0, 0x03,
  0x80, 0x0E, 0x1C, 0x00, 0x70, 0x01, 0xC3, 0x00, 0x0C, 0x00, 0x30, 0xE0,
  0x03, 0x80, 0x0E, 0x1C, 0x00, 0x70, 0x01, 0xC3, 0x80, 0x0E, 0x00, 0x38,
  0x70, 0x01, 0xC0, 0x07, 0x0C, 0x00, 0x30, 0x00, 0xC3, 0x80, 0x0E, 0x00,
  0x38, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x0C, 0x3F, 0xC0,
  0x73, 0xFF, 0x81, 0xDE, 0x0F, 0x07, 0xE0, 0x1C, 0x1B, 0x00, 0x70, 0x78,
  0x01, 0xC3, 0xC0, 0x07, 0x0F, 0x00, 0x1C, 0x38, 0x00, 0x70, 0xE0, 0x01,
  0xC7, 0x80, 0x0E, 0x1C, 0x00, 0x38, 0x70, 0x00, 0xE1, 0xC0, 0x03, 0x87,
  0x00, 0x0E, 0x38, 0x00, 0x70, 0xE0, 0x01, 0xC3, 0x80, 0x07, 0x0E, 0x00,
  0x1C, 0x30, 0x00, 0xE1, 0xC0, 0x03, 0x87, 0x00, 0x0E, 0x1C, 0x00, 0x38,
  0x70, 0x00, 0xE3, 0x80, 0x07, 0x0E, 0x00, 0x1C, 0x38, 0x00, 0x70, 0x00,
  0x0C, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xF8, 0x07, 0x81, 0xE0, 0x70, 0x07,
  0x07, 0x00, 0x3C, 0x78, 0x00, 0xE3, 0x80, 0x07, 0x38, 0x00, 0x39, 0xC0,
  0x01, 0xCE, 0x00, 0x0E, 0xE0, 0x00, 0x77, 0x00, 0x03, 0xB8, 0x00, 0x1D,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x77, 0x00, 0x03, 0xB8, 0x00,
  0x1D, 0xC0, 0x01, 0xCE, 0x00, 0x0E, 0x70, 0x00, 0xF1, 0xC0, 0x07, 0x0E,
  0x00, 0x70, 0x78, 0x07, 0x81, 0xE0, 0xF8, 0x07, 0xFF, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x61, 0xFE, 0x00, 0x71, 0xFF, 0x80, 0x39,
  0xC1, 0xE0, 0x1D, 0x80, 0x70, 0x0D, 0x80, 0x38, 0x07, 0x80, 0x0E, 0x07,
  0xC0, 0x07, 0x03, 0xC0, 0x03, 0x81, 0xE0, 0x01, 0xC0, 0xE0, 0x00, 0xE0,
  0x70, 0x00, 0x70, 0x70, 0x00, 0x38, 0x38, 0x00, 0x18, 0x1C, 0x00, 0x1C,
  0x0C, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x07, 0x00, 0x03, 0x83, 0x80, 0x03,
  0x81, 0xC0, 0x01, 0xC0, 0xE0, 0x01, 0xC0, 0xF0, 0x00, 0xE0, 0x78, 0x00,
  0xE0, 0x3E, 0x00, 0xF0, 0x1B, 0x00, 0xF0, 0x0C, 0xE0, 0xF0, 0x0E, 0x7F,
  0xF0, 0x07, 0x0F, 0xE0, 0x03, 0x81, 0x80, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x01, 0xFF, 0x1C,
  0x07, 0xFF, 0x38, 0x1E, 0x0E, 0x60, 0x78, 0x06, 0xC1, 0xE0, 0x0F, 0x83,
  0x80, 0x0F, 0x0E, 0x00, 0x1C, 0x3C, 0x00, 0x38, 0x70, 0x00, 0x70, 0xE0,
  0x00, 0xE3, 0x80, 0x01, 0xC7, 0x00, 0x03, 0x0E, 0x00, 0x0E, 0x1C, 0x00,
  0x1C, 0x70, 0x00, 0x38, 0xE0, 0x00, 0xF1, 0xC0, 0x01, 0xC3, 0x80, 0x03,
  0x87, 0x00, 0x0F, 0x0E, 0x00, 0x1E, 0x1C, 0x00, 0x78, 0x38, 0x01, 0xF0,
  0x38, 0x07, 0xE0, 0x70, 0x1D, 0xC0, 0xF0, 0x73, 0x80, 0xFF, 0xC6, 0x00,
  0xFF, 0x1C, 0x00, 0x20, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x01, 0x80, 0xC3, 0xF0, 0x73, 0xFC, 0x1D, 0xE0, 0x06, 0x60,
  0x01, 0xB0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0x83,
  0xC0, 0x60, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x80, 0x0E, 0x1C, 0x07, 0x83, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x1F, 0xFF, 0x7F, 0xF8, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3C, 0x20, 0x7F, 0x80, 0xFE,
  0x00, 0x40, 0x00, 0x0E, 0x00, 0x1C, 0x38, 0x00, 0x70, 0xE0, 0x01, 0xC3,
  0x80, 0x07, 0x0C, 0x00, 0x38, 0x70, 0x00, 0xE1, 0xC0, 0x03, 0x87, 0x00,
  0x0E, 0x18, 0x00, 0x30, 0xE0, 0x01, 0xC3, 0x80, 0x07, 0x0E, 0x00, 0x1C,
  0x38, 0x00, 0x70, 0xC0, 0x01, 0x87, 0x00, 0x0E, 0x1C, 0x00, 0x38, 0x70,
  0x00, 0xE1, 0xC0, 0x07, 0x86, 0x00, 0x1C, 0x38, 0x00, 0xF0, 0xE0, 0x03,
  0xC3, 0x80, 0x1F, 0x0E, 0x00, 0xD8, 0x3C, 0x07, 0x60, 0x78, 0x39, 0x81,
  0xFF, 0xCE, 0x03, 0xFC, 0x38, 0x01, 0x80, 0x00, 0xE0, 0x00, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0x70, 0x01, 0xCE, 0x00, 0x39, 0xC0, 0x0E, 0x38, 0x01,
  0xC7, 0x00, 0x70, 0xE0, 0x0E, 0x0C, 0x03, 0x81, 0x80, 0x70, 0x30, 0x1C,
  0x06, 0x03, 0x80, 0xE0, 0xE0, 0x1C, 0x1C, 0x03, 0x87, 0x00, 0x70, 0xE0,
  0x0E, 0x38, 0x01, 0xC7, 0x00, 0x39, 0xC0, 0x03, 0x38, 0x00, 0x6E, 0x00,
  0x0D, 0xC0, 0x01, 0xB0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x00, 0xE0, 0x07, 0x80, 0x1F, 0xC0, 0x0F, 0x00, 0x3B, 0x80, 0x1E, 0x00,
  0xE7, 0x00, 0x6C, 0x01, 0xCE, 0x00, 0xD8, 0x03, 0x9C, 0x03, 0xB0, 0x0E,
  0x38, 0x06, 0x60, 0x1C, 0x70, 0x1C, 0xC0, 0x70, 0xE0, 0x31, 0x80, 0xE1,
  0xC0, 0xE3, 0x03, 0x83, 0x81, 0x86, 0x07, 0x07, 0x07, 0x0C, 0x0C, 0x0E,
  0x0E, 0x18, 0x38, 0x1C, 0x38, 0x30, 0x70, 0x38, 0x70, 0x61, 0xC0, 0x70,
  0xC0, 0xC3, 0x80, 0xE3, 0x81, 0x8E, 0x01, 0xC6, 0x03, 0x1C, 0x03, 0x9C,
  0x06, 0x30, 0x03, 0x30, 0x0E, 0xE0, 0x06, 0xE0, 0x1D, 0x80, 0x0D, 0x80,
  0x3F, 0x00, 0x1B, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x78, 0x01,
  0xF0, 0x00, 0xF0, 0x03, 0xC0, 0x01, 0xC0, 0x07, 0x80, 0x00, 0x03, 0x80,
  0x07, 0x01, 0xC0, 0x0E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x3C, 0x00, 0xE0,
  0x38, 0x00, 0xE0, 0x70, 0x00, 0x60, 0xE0, 0x00, 0x71, 0xC0, 0x00, 0x71,
  0xC0, 0x00, 0x33, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xEE,
  0x00, 0x01, 0xC7, 0x00, 0x01, 0xC7, 0x00, 0x03, 0x83, 0x00, 0x07, 0x03,
  0x80, 0x0E, 0x03, 0x80, 0x0E, 0x01, 0x80, 0x1C, 0x01, 0xC0, 0x38, 0x01,
  0xC0, 0x70, 0x00, 0xE0, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x0E,
  0x00, 0x0E, 0x00, 0xE0, 0x01, 0xC0, 0x0E, 0x00, 0x1C, 0x00, 0xE0, 0x03,
  0x80, 0x06, 0x00, 0x38, 0x00, 0x60, 0x07, 0x00, 0x06, 0x00, 0x70, 0x00,
  0x70, 0x0E, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x70, 0x1C, 0x00, 0x07, 0x01,
  0xC0, 0x00, 0x70, 0x38, 0x00, 0x07, 0x03, 0x80, 0x00, 0x30, 0x70, 0x00,
  0x03, 0x07, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x39,
  0xC0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x03, 0xB8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x8F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0x00,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x07, 0xE0,
  0x01, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7C, 0x00,
  0x0F, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00,
  0x07, 0xC0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x07, 0xE0,
  0x03, 0xF8, 0x00, 0x7C, 0x00, 0x00, 0x0E, 0x00, 0x04, 0xFF, 0x80, 0x1F,
  0xFF, 0x81, 0xF8, 0x1F, 0xFE, 0x80, 0x1F, 0xF2, 0x00, 0x0F, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_LightItalic51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 11, 36, 12, 1, -36 },
  { 51, 13, 13, 17, 5, -36 },
  { 73, 27, 36, 28, 1, -36 },
  { 195, 23, 42, 25, 1, -39 },
  { 316, 30, 38, 36, 4, -37 },
  { 459, 26, 38, 29, 1, -37 },
  { 583, 6, 13, 9, 5, -36 },
  { 593, 15, 44, 13, 2, -36 },
  { 676, 16, 44, 13, -4, -36 },
  { 764, 19, 20, 24, 6, -39 },
  { 812, 22, 24, 26, 3, -30 },
  { 878, 8, 13, 10, -2, -6 },
  { 891, 12, 3, 15, 1, -15 },
  { 896, 4, 5, 11, 1, -5 },
  { 899, 23, 36, 17, -2, -36 },
  { 1003, 22, 38, 25, 2, -37 },
  { 1108, 13, 36, 25, 7, -36 },
  { 1167, 24, 37, 25, 0, -37 },
  { 1278, 24, 38, 25, 0, -37 },
  { 1392, 24, 37, 25, 0, -37 },
  { 1503, 23, 37, 25, 1, -36 },
  { 1610, 22, 38, 25, 3, -37 },
  { 1715, 22, 36, 25, 4, -36 },
  { 1814, 23, 38, 25, 1, -37 },
  { 1924, 23, 38, 25, 1, -37 },
  { 2034, 9, 27, 11, 1, -27 },
  { 2065, 12, 34, 11, -2, -27 },
  { 2116, 22, 23, 26, 3, -30 },
  { 2180, 22, 12, 26, 3, -24 },
  { 2213, 22, 23, 26, 3, -30 },
  { 2277, 17, 37, 18, 3, -37 },
  { 2356, 34, 41, 37, 2, -36 },
  { 2531, 25, 37, 25, -3, -37 },
  { 2647, 25, 36, 27, 2, -36 },
  { 2760, 26, 38, 26, 3, -37 },
  { 2884, 27, 36, 30, 1, -36 },
  { 3006, 24, 36, 24, 1, -36 },
  { 3114, 24, 36, 22, 1, -36 },
  { 3222, 28, 38, 31, 3, -37 },
  { 3355, 29, 36, 31, 2, -36 },
  { 3486, 18, 36, 14, -1, -36 },
  { 3567, 20, 45, 11, -8, -36 },
  { 3680, 28, 36, 25, 1, -36 },
  { 3806, 17, 36, 22, 1, -36 },
  { 3883, 37, 36, 38, 1, -36 },
  { 4050, 31, 36, 31, 1, -36 },
  { 4190, 28, 38, 32, 3, -37 },
  { 4323, 25, 36, 25, 1, -36 },
  { 4436, 28, 46, 32, 3, -37 },
  { 4597, 25, 36, 26, 1, -36 },
  { 4710, 24, 38, 23, 0, -37 },
  { 4824, 22, 36, 22, 4, -36 },
  { 4923, 28, 37, 31, 3, -36 },
  { 5053, 24, 36, 25, 5, -36 },
  { 5161, 38, 36, 39, 5, -36 },
  { 5332, 30, 36, 23, -3, -36 },
  { 5467, 22, 36, 22, 5, -36 },
  { 5566, 27, 36, 23, -1, -36 },
  { 5688, 19, 44, 15, -1, -36 },
  { 5793, 8, 36, 17, 5, -36 },
  { 5829, 20, 44, 15, -4, -36 },
  { 5939, 22, 22, 26, 2, -37 },
  { 6000, 18, 2, 18, -4, 5 },
  { 6005, 7, 8, 12, 7, -39 },
  { 6012, 23, 29, 26, 2, -28 },
  { 6096, 23, 40, 26, 1, -39 },
  { 6211, 19, 29, 20, 2, -28 },
  { 6280, 25, 40, 26, 2, -39 },
  { 6405, 19, 29, 23, 2, -28 },
  { 6474, 26, 51, 13, -6, -39 },
  { 6640, 25, 40, 26, 0, -28 },
  { 6765, 22, 39, 25, 1, -39 },
  { 6873, 11, 37, 11, 1, -37 },
  { 6924, 19, 49, 11, -7, -37 },
  { 7041, 22, 39, 21, 1, -39 },
  { 7149, 11, 39, 11, 1, -39 },
  { 7203, 35, 28, 39, 1, -28 },
  { 7326, 22, 28, 25, 1, -28 },
  { 7403, 21, 28, 25, 2, -28 },
  { 7477, 25, 40, 26, -1, -28 },
  { 7602, 23, 40, 26, 2, -28 },
  { 7717, 18, 28, 17, 1, -28 },
  { 7780, 19, 29, 19, 0, -28 },
  { 7849, 14, 35, 14, 2, -34 },
  { 7911, 22, 28, 26, 2, -27 },
  { 7988, 19, 27, 20, 3, -27 },
  { 8053, 31, 27, 32, 3, -27 },
  { 8158, 24, 27, 21, -2, -27 },
  { 8239, 28, 39, 20, -5, -27 },
  { 8376, 21, 27, 19, -1, -27 },
  { 8447, 19, 44, 17, 1, -36 },
  { 8552, 2, 51, 24, 12, -39 },
  { 8565, 19, 44, 17, -3, -36 },
  { 8670, 22, 6, 26, 3, -21 },
};

const GFXfont NotoSans_SemiCondensed_LightItalic51pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_LightItalic51pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_LightItalic51pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHTITALIC51PT7B_H_
