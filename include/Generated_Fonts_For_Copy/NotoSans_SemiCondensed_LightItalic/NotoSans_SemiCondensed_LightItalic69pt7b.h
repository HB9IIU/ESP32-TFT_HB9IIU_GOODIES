#ifndef _NOTOSANS_SEMICONDENSED_LIGHTITALIC69PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHTITALIC69PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-LightItalic.ttf
// Size: 69pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_LightItalic69pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0x78, 0x00, 0x20, 0x00, 0x1E, 0x07, 0xC7, 0x81, 0xE1, 0xE0, 0x78,
  0x70, 0x1E, 0x3C, 0x07, 0x0F, 0x03, 0xC3, 0xC0, 0xF0, 0xE0, 0x3C, 0x38,
  0x0E, 0x0E, 0x03, 0x87, 0x80, 0xE1, 0xC0, 0x78, 0x70, 0x1C, 0x1C, 0x07,
  0x07, 0x01, 0xC1, 0x80, 0x70, 0xE0, 0x18, 0x38, 0x0E, 0x00, 0x00, 0x00,
  0x38, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x07, 0x00, 0x38, 0x00, 0x00, 0x78,
  0x03, 0xC0, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x00, 0x70, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x3C, 0x00, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x0E, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xC0,
  0x1E, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x38, 0x00, 0x00, 0x78, 0x03, 0x80, 0x00, 0x03, 0x80, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x0E,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x03, 0x80, 0x3C, 0x00,
  0x00, 0x38, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x38, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x07, 0x00, 0x38, 0x00, 0x00, 0x78,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00,
  0x01, 0xE0, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x00, 0x70, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x3C, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xF8, 0xE1, 0xF0, 0x0F,
  0x83, 0x80, 0x80, 0x78, 0x0C, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x0F, 0x01,
  0xC0, 0x00, 0x3C, 0x07, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x03, 0x80, 0xE0,
  0x00, 0x0E, 0x03, 0x80, 0x00, 0x38, 0x0E, 0x00, 0x00, 0xF0, 0x38, 0x00,
  0x03, 0xC0, 0xC0, 0x00, 0x0F, 0x87, 0x00, 0x00, 0x1F, 0x1C, 0x00, 0x00,
  0x3E, 0x70, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0D,
  0xF8, 0x00, 0x00, 0x33, 0xF0, 0x00, 0x01, 0xC3, 0xE0, 0x00, 0x07, 0x07,
  0x80, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0x60, 0x3C, 0x00, 0x03, 0x80, 0xF0,
  0x00, 0x0E, 0x03, 0xC0, 0x00, 0x38, 0x0F, 0x00, 0x00, 0xE0, 0x3C, 0x00,
  0x03, 0x00, 0xE0, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x70, 0x1E, 0x00, 0x01,
  0xC0, 0xF0, 0x20, 0x07, 0x07, 0xC0, 0xF0, 0x18, 0x7E, 0x03, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3C, 0x03, 0xFF, 0x80, 0x00, 0x78, 0x07, 0xC7, 0xC0, 0x00, 0x70, 0x0F,
  0x03, 0xC0, 0x00, 0xE0, 0x0F, 0x01, 0xC0, 0x01, 0xE0, 0x1E, 0x01, 0xC0,
  0x01, 0xC0, 0x1C, 0x01, 0xE0, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x07, 0x80,
  0x38, 0x01, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x01,
  0xC0, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x3C,
  0x00, 0x70, 0x01, 0xC0, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x70, 0x00, 0xF0,
  0x03, 0xC0, 0xF0, 0x00, 0xE0, 0x03, 0x81, 0xE0, 0x00, 0xE0, 0x03, 0x81,
  0xC0, 0x00, 0xE0, 0x07, 0x83, 0xC0, 0x00, 0xE0, 0x07, 0x87, 0x83, 0xF8,
  0xE0, 0x07, 0x07, 0x07, 0xFC, 0xE0, 0x0F, 0x0F, 0x0F, 0xFE, 0xE0, 0x0E,
  0x0E, 0x1E, 0x1F, 0xE0, 0x1E, 0x1C, 0x3C, 0x0F, 0xF0, 0x1C, 0x3C, 0x38,
  0x07, 0xF0, 0x3C, 0x38, 0x78, 0x07, 0x78, 0xF8, 0x70, 0xF0, 0x07, 0x7F,
  0xF0, 0xF0, 0xF0, 0x07, 0x3F, 0xE0, 0xE0, 0xE0, 0x07, 0x0F, 0x81, 0xC1,
  0xE0, 0x07, 0x00, 0x03, 0xC1, 0xC0, 0x07, 0x00, 0x03, 0x81, 0xC0, 0x07,
  0x00, 0x07, 0x01, 0xC0, 0x07, 0x00, 0x0F, 0x03, 0xC0, 0x0F, 0x00, 0x0E,
  0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x03, 0x80, 0x0E, 0x00, 0x3C, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x03, 0x80, 0x1E, 0x00,
  0xF0, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x03,
  0x80, 0x38, 0x03, 0xC0, 0x03, 0x80, 0x38, 0x03, 0x80, 0x03, 0x80, 0x70,
  0x07, 0x80, 0x03, 0x80, 0xF0, 0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x0E, 0x00,
  0x01, 0xE7, 0xE0, 0x1E, 0x00, 0x01, 0xFF, 0xC0, 0x3C, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xE1, 0xF8, 0x00,
  0x00, 0xF0, 0x0F, 0x00, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x1E,
  0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x07, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x0F, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x0F, 0x00, 0x00, 0x38, 0x03, 0xC0, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x00, 0xF0, 0x7C, 0x00, 0x00, 0x0F, 0x1F, 0x00, 0x00, 0x01, 0xEF,
  0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x07, 0xCF, 0x80, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0xF0, 0xF8, 0x1F, 0x00,
  0x1E, 0x3E, 0x01, 0xE0, 0x03, 0x87, 0x80, 0x1E, 0x00, 0xF1, 0xE0, 0x03,
  0xC0, 0x1C, 0x7C, 0x00, 0x3C, 0x07, 0x8F, 0x00, 0x07, 0xC0, 0xE3, 0xC0,
  0x00, 0x78, 0x3C, 0x78, 0x00, 0x0F, 0x8F, 0x0F, 0x00, 0x00, 0xF1, 0xE1,
  0xC0, 0x00, 0x1F, 0x78, 0x38, 0x00, 0x01, 0xFE, 0x07, 0x00, 0x00, 0x1F,
  0xC0, 0xE0, 0x00, 0x03, 0xF0, 0x1C, 0x00, 0x00, 0x7C, 0x03, 0xC0, 0x00,
  0x1F, 0xC0, 0x78, 0x00, 0x07, 0xF8, 0x0F, 0x80, 0x01, 0xFF, 0x80, 0xF8,
  0x00, 0xFC, 0xF0, 0x1F, 0x80, 0x7E, 0x0F, 0x01, 0xFF, 0xFF, 0x81, 0xE0,
  0x1F, 0xFF, 0xE0, 0x1E, 0x00, 0xFF, 0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x1E, 0x3C, 0x78, 0xF1, 0xC7, 0x8F, 0x1E, 0x38, 0x71, 0xE3,
  0x87, 0x0E, 0x1C, 0x30, 0xE1, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0x80, 0x06, 0x00, 0xE0, 0x03, 0xE0, 0x38, 0x00,
  0xFC, 0x0E, 0x00, 0x1F, 0xC3, 0x00, 0x01, 0xFC, 0xC0, 0x04, 0x0F, 0xF1,
  0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x07, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xE6, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x78, 0x70, 0x00,
  0x3C, 0x0E, 0x00, 0x3E, 0x03, 0x80, 0x1F, 0x00, 0xF0, 0x03, 0x80, 0x1C,
  0x00, 0x40, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x03,
  0xC0, 0x78, 0x1E, 0x03, 0xC0, 0x70, 0x1C, 0x03, 0x80, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3D, 0xF7, 0xFF, 0xFD, 0xE2, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xDF, 0xC0,
  0x03, 0xE0, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x03, 0xE0, 0x03, 0xC0, 0x1E,
  0x00, 0x0F, 0x01, 0xE0, 0x00, 0x78, 0x1F, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x1E, 0x0F, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x1C,
  0x3C, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x0F, 0x1F, 0x00, 0x00, 0x78, 0xF0,
  0x00, 0x03, 0xC7, 0x80, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0xF3, 0xC0, 0x00,
  0x07, 0x9E, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x0F,
  0x78, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x3C, 0xF0,
  0x00, 0x01, 0xE7, 0x80, 0x00, 0x0F, 0x38, 0x00, 0x00, 0xFB, 0xC0, 0x00,
  0x07, 0x9E, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x1E,
  0x3C, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x78, 0x78,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0x3E, 0x1E, 0x00, 0x01, 0xE0, 0xF0, 0x00,
  0x1F, 0x03, 0xC0, 0x00, 0xF0, 0x1E, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0xF8,
  0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0xF8, 0x00, 0xFC, 0x0F, 0x80, 0x03,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x3F,
  0xF0, 0x3F, 0x70, 0x3E, 0x78, 0x7E, 0x3C, 0x7C, 0x1E, 0x7C, 0x0F, 0x3C,
  0x0F, 0x08, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0x7F, 0xC0, 0x03, 0xF8, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0xF8,
  0x00, 0x20, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x3F, 0xF3, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x30, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x80, 0x00,
  0x0F, 0x80, 0xE0, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00,
  0x07, 0x9C, 0x00, 0x00, 0x0F, 0x1C, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00,
  0x1E, 0x3C, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x00, 0x78, 0x38, 0x00, 0x00,
  0x70, 0x78, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x03,
  0xC0, 0x70, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x0F,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x38,
  0x01, 0xE0, 0x00, 0x78, 0x01, 0xE0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x03, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80,
  0x03, 0xC0, 0x0F, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x03, 0x80, 0x1C, 0x00,
  0x03, 0x80, 0x3C, 0x00, 0x07, 0x80, 0x78, 0x00, 0x07, 0x80, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x80, 0x00, 0x1F, 0x00, 0xC0, 0x00, 0x3E, 0x00, 0xF8, 0x01,
  0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xF1, 0xE0, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x07, 0x00, 0x01,
  0xE0, 0xFF, 0xC0, 0x03, 0xC7, 0xFF, 0xC0, 0x07, 0x1F, 0xFF, 0xC0, 0x1E,
  0x78, 0x07, 0xC0, 0x3D, 0xC0, 0x07, 0xC0, 0x77, 0x00, 0x07, 0x80, 0xFC,
  0x00, 0x0F, 0x83, 0xF0, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x1E, 0x0F, 0x80,
  0x00, 0x3C, 0x1E, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0xF0, 0x78, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x07, 0x87, 0x80, 0x00,
  0x0F, 0x0F, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00,
  0xF0, 0x38, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x0F,
  0x01, 0xE0, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0xF8, 0x03, 0xC0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x07, 0xC0, 0x3E, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0x3F, 0xC0, 0x03, 0xE0, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x3E, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x78, 0x0F,
  0x00, 0x00, 0xF0, 0x1E, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x03, 0xC0, 0x78,
  0x00, 0x0F, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x78, 0x01, 0xE0,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x03, 0xC0, 0x1F, 0x00, 0x03, 0xC0,
  0xFC, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xF1, 0xF0,
  0x00, 0x1F, 0x81, 0xF0, 0x00, 0x7C, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0,
  0x07, 0x80, 0x01, 0xE0, 0x1E, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x0F, 0x0F,
  0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x78, 0x78,
  0x00, 0x00, 0xF0, 0xF0, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0x0F, 0x07, 0xC0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0xF8, 0x0F, 0x80,
  0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xF7,
  0xF8, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x1F, 0x00, 0x07,
  0x80, 0x78, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x78, 0x0F, 0x00, 0x00, 0xF0,
  0x78, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x3C, 0x3C,
  0x00, 0x00, 0xF0, 0xF0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x0F, 0x0F, 0x00,
  0x00, 0x3C, 0x38, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x03, 0xC7, 0x80, 0x00,
  0x1F, 0x1E, 0x00, 0x00, 0x7C, 0x38, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x0F,
  0x83, 0xC0, 0x00, 0x7E, 0x0F, 0x00, 0x03, 0xF8, 0x3E, 0x00, 0x1F, 0xE0,
  0x7C, 0x00, 0xF7, 0x00, 0xF8, 0x0F, 0xBC, 0x03, 0xFF, 0xFC, 0xF0, 0x03,
  0xFF, 0xC3, 0xC0, 0x07, 0xFC, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x08, 0x00, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x7C, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0xF8, 0x03, 0x00, 0x00, 0x0F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07,
  0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E,
  0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0,
  0xFF, 0xFF, 0xC0, 0xE0, 0x0F, 0xC1, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x78, 0x00,
  0x00, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00,
  0xC0, 0x00, 0xF0, 0x78, 0x00, 0x3F, 0xF8, 0x03, 0xC1, 0xC0, 0x03, 0xFF,
  0xF8, 0x07, 0x0F, 0x00, 0x1F, 0xCF, 0xC0, 0x1C, 0x38, 0x00, 0xF0, 0x07,
  0x00, 0x71, 0xE0, 0x07, 0x80, 0x3C, 0x01, 0xC7, 0x00, 0x3C, 0x00, 0xE0,
  0x07, 0x3C, 0x01, 0xE0, 0x03, 0x80, 0x1C, 0xF0, 0x07, 0x00, 0x1E, 0x00,
  0x73, 0x80, 0x3C, 0x00, 0x78, 0x01, 0xDE, 0x00, 0xE0, 0x01, 0xC0, 0x0F,
  0x78, 0x07, 0x80, 0x07, 0x00, 0x3D, 0xC0, 0x1C, 0x00, 0x3C, 0x00, 0xE7,
  0x00, 0x70, 0x00, 0xF0, 0x03, 0x9C, 0x03, 0xC0, 0x03, 0x80, 0x0E, 0xF0,
  0x0E, 0x00, 0x0E, 0x00, 0x7B, 0xC0, 0x38, 0x00, 0x78, 0x01, 0xCF, 0x00,
  0xE0, 0x01, 0xE0, 0x07, 0x38, 0x03, 0x80, 0x07, 0x00, 0x3C, 0xE0, 0x0E,
  0x00, 0x3C, 0x00, 0xE3, 0x80, 0x38, 0x00, 0xF0, 0x07, 0x8E, 0x00, 0xE0,
  0x07, 0xC0, 0x1C, 0x38, 0x03, 0x80, 0x3F, 0x00, 0xF0, 0xE0, 0x0F, 0x01,
  0xDC, 0x07, 0x83, 0x80, 0x3C, 0x0F, 0x78, 0x3C, 0x0F, 0x00, 0x7E, 0xF8,
  0xFF, 0xE0, 0x3C, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0xF0, 0x01, 0xFC, 0x07,
  0xF0, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x7F, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0x07,
  0x1C, 0x00, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x00,
  0x78, 0x70, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00,
  0x03, 0x81, 0xE0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0xF0, 0x1E, 0x00,
  0x00, 0x3C, 0x07, 0x80, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x78,
  0x00, 0x03, 0xC0, 0x0E, 0x00, 0x00, 0xF0, 0x03, 0x80, 0x00, 0x78, 0x00,
  0xE0, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x1F, 0x00, 0x00, 0x70, 0x07, 0x80, 0x00, 0x1C, 0x03, 0xE0, 0x00, 0x07,
  0x80, 0xF0, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00,
  0x1E, 0x0F, 0x80, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x01, 0xE1, 0xF0, 0x00,
  0x00, 0x78, 0x78, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x07, 0x8F, 0x00,
  0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x00, 0x0E, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xF0, 0x07, 0xFC, 0x00, 0x78, 0x00,
  0x1F, 0x80, 0x1E, 0x00, 0x03, 0xE0, 0x07, 0x80, 0x00, 0x78, 0x01, 0xE0,
  0x00, 0x1F, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0xF0, 0x0F,
  0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x38, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x1E,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x03,
  0xE0, 0x0F, 0x00, 0x01, 0xF0, 0x03, 0xC0, 0x01, 0xF8, 0x00, 0xF0, 0x0F,
  0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x01, 0xE0, 0x01, 0xF8, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x1C,
  0x00, 0x03, 0xE0, 0x0F, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x3C,
  0x07, 0x80, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00,
  0xF0, 0x1E, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0x07, 0xC0, 0xF0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0xF8, 0x0F, 0x00,
  0x00, 0x7C, 0x07, 0x80, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x1F, 0x80, 0x78,
  0x00, 0x1F, 0xC0, 0x1E, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x3C, 0x00, 0x3F, 0x00, 0x01, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x01, 0x00, 0x01, 0xFC, 0x01, 0xE0, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xC0, 0x1F, 0xE0, 0x00,
  0x78, 0x00, 0x3F, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x07,
  0xC0, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x03, 0xE0, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x1E, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x1E, 0x00,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x78, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x78, 0x00,
  0x00, 0x0F, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x00, 0x1E, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x07, 0xC1, 0xE0, 0x00,
  0x00, 0x78, 0x1E, 0x00, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x00, 0xF0, 0x1E,
  0x00, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x00, 0x7C,
  0x03, 0xC0, 0x00, 0x0F, 0xC0, 0x3C, 0x00, 0x01, 0xF8, 0x03, 0xC0, 0x00,
  0x3F, 0x00, 0x78, 0x00, 0x07, 0xE0, 0x07, 0x80, 0x01, 0xFC, 0x00, 0x78,
  0x00, 0x7F, 0x80, 0x07, 0x83, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xC0, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xC0, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x0F, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x00, 0xC0, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0xFF, 0x07, 0x80, 0x00,
  0xFF, 0xFC, 0x1E, 0x00, 0x03, 0xFF, 0xF0, 0x78, 0x00, 0x00, 0x03, 0x83,
  0xC0, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x00, 0x3C, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00,
  0x0F, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x03, 0xE0, 0x00, 0x01, 0xC0, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x1F,
  0x80, 0x00, 0x3C, 0x00, 0x3F, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x01, 0xE0, 0x00, 0x00, 0x70, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFF, 0xE0, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x07, 0x00, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x1E,
  0x00, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x3C, 0x00, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x70,
  0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x08, 0x1F, 0x80, 0x03, 0xFF, 0xE0, 0x00,
  0x7F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF8, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x0F, 0x00, 0x00,
  0xF8, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x3C,
  0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x0F, 0x80,
  0x00, 0x78, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x0F, 0x80, 0x00, 0x3C, 0x00,
  0xF8, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x00,
  0xF0, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x00, 0x3C, 0x07, 0xC0,
  0x00, 0x01, 0xE0, 0x7C, 0x00, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x00, 0xF0,
  0x7C, 0x00, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x00, 0x3C, 0x7C, 0x00, 0x00,
  0x01, 0xE7, 0xC0, 0x00, 0x00, 0x0F, 0x7F, 0x00, 0x00, 0x00, 0xF7, 0xF8,
  0x00, 0x00, 0x07, 0xBF, 0xE0, 0x00, 0x00, 0x3F, 0x8F, 0x00, 0x00, 0x01,
  0xF8, 0x78, 0x00, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x00, 0xF8, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x01, 0xC0, 0x00, 0x0F, 0x80,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x00,
  0x07, 0xF0, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x00,
  0x00, 0x1F, 0xE0, 0x07, 0x78, 0x00, 0x00, 0x0F, 0x78, 0x01, 0xDE, 0x00,
  0x00, 0x03, 0xDC, 0x00, 0x77, 0x80, 0x00, 0x01, 0xEF, 0x00, 0x3D, 0xE0,
  0x00, 0x00, 0x7B, 0xC0, 0x0F, 0x38, 0x00, 0x00, 0x3C, 0xF0, 0x03, 0xCE,
  0x00, 0x00, 0x0F, 0x3C, 0x00, 0xE3, 0x80, 0x00, 0x07, 0x9E, 0x00, 0x78,
  0xE0, 0x00, 0x01, 0xE7, 0x80, 0x1E, 0x3C, 0x00, 0x00, 0xF1, 0xE0, 0x07,
  0x8F, 0x00, 0x00, 0x38, 0x78, 0x01, 0xE3, 0xC0, 0x00, 0x1E, 0x1E, 0x00,
  0x70, 0xF0, 0x00, 0x07, 0x0F, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0xC3, 0xC0,
  0x0F, 0x07, 0x00, 0x01, 0xE0, 0xF0, 0x03, 0xC1, 0xC0, 0x00, 0x78, 0x3C,
  0x00, 0xF0, 0x70, 0x00, 0x3C, 0x0E, 0x00, 0x38, 0x1C, 0x00, 0x0F, 0x07,
  0x80, 0x1E, 0x07, 0x80, 0x07, 0x81, 0xE0, 0x07, 0x81, 0xE0, 0x01, 0xE0,
  0x78, 0x01, 0xE0, 0x78, 0x00, 0xF0, 0x1E, 0x00, 0x78, 0x1E, 0x00, 0x3C,
  0x0F, 0x00, 0x1C, 0x07, 0x80, 0x1E, 0x03, 0xC0, 0x0F, 0x00, 0xE0, 0x07,
  0x00, 0xF0, 0x03, 0xC0, 0x38, 0x03, 0xC0, 0x3C, 0x00, 0xF0, 0x0E, 0x00,
  0xE0, 0x0F, 0x00, 0x38, 0x03, 0x80, 0x78, 0x07, 0x80, 0x1E, 0x00, 0xF0,
  0x1C, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0F,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xC1, 0xE0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x1C, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x07, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xC7, 0x80, 0x0F, 0x00, 0x3C,
  0x00, 0x73, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1E, 0xE0, 0x01, 0xE0, 0x07,
  0x80, 0x07, 0xF8, 0x00, 0x78, 0x01, 0xE0, 0x01, 0xFC, 0x00, 0x1E, 0x00,
  0x78, 0x00, 0x7F, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x0F, 0x80, 0x03, 0xC0,
  0x07, 0x00, 0x03, 0xE0, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0x80, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x0F, 0x80, 0x00, 0x01, 0xC0,
  0x07, 0xE0, 0x00, 0x01, 0xE0, 0x07, 0xF0, 0x00, 0x00, 0xF0, 0x03, 0xF8,
  0x00, 0x00, 0x78, 0x01, 0xDE, 0x00, 0x00, 0x3C, 0x00, 0xEF, 0x00, 0x00,
  0x1C, 0x00, 0x73, 0x80, 0x00, 0x1E, 0x00, 0x79, 0xE0, 0x00, 0x0F, 0x00,
  0x3C, 0xF0, 0x00, 0x07, 0x80, 0x1E, 0x78, 0x00, 0x03, 0xC0, 0x0E, 0x1E,
  0x00, 0x03, 0xC0, 0x0F, 0x0F, 0x00, 0x01, 0xE0, 0x07, 0x87, 0x80, 0x00,
  0xF0, 0x03, 0xC1, 0xE0, 0x00, 0x78, 0x01, 0xE0, 0xF0, 0x00, 0x38, 0x00,
  0xE0, 0x78, 0x00, 0x3C, 0x00, 0xF0, 0x1E, 0x00, 0x1E, 0x00, 0x78, 0x0F,
  0x00, 0x0F, 0x00, 0x3C, 0x07, 0x80, 0x07, 0x80, 0x1E, 0x01, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xC0, 0x07,
  0x80, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x3C, 0x00, 0xF0, 0x00, 0xF0, 0x1E,
  0x00, 0x78, 0x00, 0x78, 0x0F, 0x00, 0x3C, 0x00, 0x1C, 0x07, 0x00, 0x1C,
  0x00, 0x0F, 0x07, 0x80, 0x1E, 0x00, 0x07, 0x83, 0xC0, 0x0F, 0x00, 0x03,
  0xC1, 0xE0, 0x07, 0x80, 0x00, 0xF0, 0xF0, 0x03, 0xC0, 0x00, 0x78, 0x70,
  0x01, 0xC0, 0x00, 0x3C, 0x78, 0x01, 0xE0, 0x00, 0x0F, 0x3C, 0x00, 0xF0,
  0x00, 0x07, 0x9E, 0x00, 0x78, 0x00, 0x03, 0xCF, 0x00, 0x3C, 0x00, 0x00,
  0xF7, 0x00, 0x1C, 0x00, 0x00, 0x7B, 0x80, 0x1E, 0x00, 0x00, 0x3F, 0xC0,
  0x0F, 0x00, 0x00, 0x0F, 0xE0, 0x07, 0x80, 0x00, 0x07, 0xE0, 0x03, 0x80,
  0x00, 0x03, 0xF0, 0x01, 0xC0, 0x00, 0x00, 0xF8, 0x01, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x0F, 0x00, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x00, 0x3E, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x00,
  0x3C, 0x3C, 0x00, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0x0F, 0x1F, 0x00,
  0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x00, 0x1E,
  0x78, 0x00, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00,
  0x00, 0x3D, 0xF0, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x00, 0x0F, 0x78,
  0x00, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x00,
  0x3C, 0xF0, 0x00, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x00, 0x0F, 0x7C, 0x00,
  0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x00, 0x3C,
  0xF0, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0x1F, 0x3C, 0x00, 0x00,
  0x00, 0xF1, 0xE0, 0x00, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x00, 0x78, 0x3C,
  0x00, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x03,
  0xE0, 0x78, 0x00, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x0F, 0x00,
  0x00, 0x1F, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0x80, 0x7F, 0x80, 0x07, 0x80, 0x07,
  0xE0, 0x03, 0xC0, 0x01, 0xF0, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x07, 0x80, 0x3C, 0x00,
  0x03, 0xE0, 0x1E, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x78, 0x0F, 0x00,
  0x00, 0x78, 0x07, 0x80, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x1E, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0xF0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x07, 0x80, 0x78,
  0x00, 0x03, 0xC0, 0x3C, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x03, 0xE0, 0x0F,
  0x00, 0x03, 0xE0, 0x0F, 0x00, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0xE0, 0x03,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x01, 0xF8,
  0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x1F, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0xF8, 0x00, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x78,
  0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x01,
  0xE1, 0xE0, 0x00, 0x00, 0x0F, 0x1F, 0x00, 0x00, 0x00, 0x78, 0xF0, 0x00,
  0x00, 0x03, 0xC7, 0x80, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x00, 0xF3,
  0xC0, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x00, 0x3D, 0xF0, 0x00, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x00, 0x7B, 0xC0,
  0x00, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x01,
  0xEF, 0x80, 0x00, 0x00, 0x0F, 0x7C, 0x00, 0x00, 0x00, 0x7B, 0xC0, 0x00,
  0x00, 0x07, 0xDE, 0x00, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0x00, 0x1F, 0x3C, 0x00, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00,
  0x0F, 0x8F, 0x80, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x00, 0x1E,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00,
  0x3F, 0x80, 0x7F, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x07, 0x80, 0x7F, 0x80, 0x07, 0x80, 0x07, 0xE0, 0x03,
  0xC0, 0x01, 0xF0, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x70, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x01, 0xE0,
  0x1E, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0x78,
  0x07, 0x80, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0xF0, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x07,
  0xC0, 0x3C, 0x00, 0x07, 0xC0, 0x1E, 0x00, 0x07, 0xC0, 0x0F, 0x00, 0x07,
  0xE0, 0x0F, 0x00, 0x0F, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xF0, 0x07,
  0x80, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x0F, 0x80, 0x1E, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x01, 0xE0, 0x0F,
  0x00, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x1E, 0x01,
  0xC0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0x80, 0x1E, 0x00, 0x7E, 0x00,
  0x02, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0xC0, 0x00, 0x3F, 0x00, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x78, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00,
  0x1C, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x3C,
  0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0x1E, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x0E, 0x00,
  0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x00, 0x1E, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00,
  0x00, 0xE0, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0x1E, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x00,
  0x0F, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0xB8, 0x00, 0x00, 0x07, 0x9C, 0x00, 0x00, 0x07, 0xCF, 0x00, 0x00,
  0x03, 0xC7, 0x80, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x01, 0xE1, 0xE0, 0x00,
  0x01, 0xF0, 0xF0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0xF8, 0x3C, 0x00,
  0x00, 0x78, 0x1E, 0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x3C, 0x07, 0x80,
  0x00, 0x3E, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x1F, 0x00, 0x70,
  0x00, 0x0F, 0x00, 0x38, 0x00, 0x0F, 0x80, 0x1E, 0x00, 0x07, 0x80, 0x0F,
  0x00, 0x07, 0xC0, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x3C, 0x00,
  0x03, 0x80, 0x3C, 0x00, 0x01, 0xC0, 0x1E, 0x00, 0x00, 0xE0, 0x1E, 0x00,
  0x00, 0x70, 0x0F, 0x00, 0x00, 0x38, 0x0F, 0x00, 0x00, 0x1E, 0x07, 0x80,
  0x00, 0x0F, 0x07, 0x80, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0x78, 0xF0,
  0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x07, 0x78,
  0x00, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0x78, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xCF, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1E, 0x3C, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xF0, 0xF0,
  0x00, 0x0E, 0xF0, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0xDE, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0x73, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E,
  0x07, 0x00, 0x03, 0xCF, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x71, 0xE0, 0x00,
  0xF0, 0x1C, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x03, 0x80, 0x03, 0x87, 0x80,
  0x07, 0x80, 0x70, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0x0E, 0x00, 0x1C, 0x1E,
  0x00, 0x3C, 0x01, 0xC0, 0x07, 0x81, 0xC0, 0x07, 0x80, 0x38, 0x00, 0xE0,
  0x38, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x07,
  0x80, 0xE0, 0x0F, 0x00, 0x1C, 0x00, 0xE0, 0x1C, 0x01, 0xE0, 0x03, 0x80,
  0x3C, 0x03, 0x80, 0x38, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0x0E,
  0x01, 0xE0, 0x0E, 0x01, 0xE0, 0x01, 0xC0, 0x38, 0x01, 0xC0, 0x78, 0x00,
  0x38, 0x0F, 0x00, 0x38, 0x0F, 0x00, 0x07, 0x01, 0xE0, 0x07, 0x03, 0xC0,
  0x00, 0xF0, 0x78, 0x00, 0xE0, 0x78, 0x00, 0x1E, 0x0F, 0x00, 0x1C, 0x0E,
  0x00, 0x03, 0xC1, 0xC0, 0x03, 0x83, 0xC0, 0x00, 0x78, 0x78, 0x00, 0x70,
  0x78, 0x00, 0x0F, 0x0E, 0x00, 0x0E, 0x1E, 0x00, 0x01, 0xE3, 0xC0, 0x01,
  0xC3, 0xC0, 0x00, 0x3C, 0x70, 0x00, 0x38, 0xF0, 0x00, 0x07, 0x9E, 0x00,
  0x07, 0x1E, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0xE3, 0x80, 0x00, 0x1E, 0x70,
  0x00, 0x1C, 0xF0, 0x00, 0x03, 0xDE, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x7B,
  0x80, 0x00, 0x73, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x01,
  0xDC, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x1F, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x1F, 0x00, 0x00, 0x00, 0xE0,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x00, 0x00,
  0x79, 0xE0, 0x00, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x00, 0x00, 0x3B, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x00, 0x03,
  0xC7, 0x80, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00, 0x00, 0x07, 0x83, 0x80,
  0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x00,
  0x3E, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0x00,
  0x3C, 0x00, 0xF0, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0x0F, 0x1E, 0x00, 0x00, 0x7C, 0x78, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x0F, 0x80,
  0xF0, 0x00, 0x3C, 0x01, 0xC0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x80, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x01, 0xE0, 0x07, 0x80, 0x03, 0x80,
  0x3C, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0xF0, 0x3C,
  0x00, 0x03, 0xC1, 0xE0, 0x00, 0x07, 0x07, 0x80, 0x00, 0x1E, 0x3C, 0x00,
  0x00, 0x78, 0xF0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x03, 0xBC, 0x00, 0x00,
  0x0E, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF,
  0xE0, 0x00, 0xF0, 0x1E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1E, 0x03,
  0xC0, 0x78, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0F, 0x01, 0xE0, 0x3C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x80,
  0xF0, 0x1E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xF0, 0x1E, 0x03, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0xE0, 0x00, 0x07,
  0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xF7, 0x80,
  0x00, 0x01, 0xE7, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x0E, 0x0E, 0x00,
  0x00, 0x3C, 0x1C, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x01, 0xE0, 0x38, 0x00,
  0x07, 0x80, 0x78, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0xE0, 0x00,
  0x70, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x0F,
  0x00, 0x07, 0x80, 0x3C, 0x00, 0x07, 0x00, 0x78, 0x00, 0x0F, 0x01, 0xE0,
  0x00, 0x1E, 0x03, 0x80, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x3C, 0x3C, 0x00,
  0x00, 0x38, 0x78, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0xF7, 0xC0, 0x00,
  0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xC0,
  0xF0, 0x7C, 0x1E, 0x0F, 0x83, 0xC0, 0xE0, 0x78, 0x1C, 0x07, 0x03, 0xC0,
  0xE0, 0x00, 0x0F, 0xF8, 0x1C, 0x00, 0xFF, 0xF0, 0x70, 0x07, 0xFF, 0xE1,
  0xC0, 0x3F, 0x03, 0xCF, 0x01, 0xF0, 0x07, 0x38, 0x0F, 0x80, 0x0E, 0xE0,
  0x7C, 0x00, 0x1F, 0x81, 0xE0, 0x00, 0x7E, 0x0F, 0x80, 0x01, 0xF0, 0x3C,
  0x00, 0x07, 0xC1, 0xE0, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x7C, 0x3C, 0x00,
  0x01, 0xF0, 0xF0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x1E, 0x1E, 0x00, 0x00,
  0x78, 0x78, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x3C,
  0x3C, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x0F, 0x0F,
  0x00, 0x00, 0x78, 0x3C, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0x3E, 0x0F, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x07, 0xC0, 0xF0, 0x00,
  0x3F, 0x03, 0xC0, 0x00, 0xFC, 0x0F, 0x00, 0x07, 0xF0, 0x1E, 0x00, 0x3B,
  0xC0, 0x7C, 0x01, 0xCE, 0x01, 0xF8, 0x1E, 0x38, 0x03, 0xFF, 0xF0, 0xE0,
  0x07, 0xFF, 0x83, 0x80, 0x0F, 0xFC, 0x1E, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78,
  0x1F, 0xE0, 0x00, 0xF0, 0xFF, 0xE0, 0x01, 0xC3, 0xFF, 0xE0, 0x07, 0x8F,
  0x03, 0xE0, 0x0F, 0x38, 0x03, 0xE0, 0x1E, 0xE0, 0x03, 0xC0, 0x3B, 0x80,
  0x07, 0xC0, 0x7E, 0x00, 0x07, 0x81, 0xF8, 0x00, 0x0F, 0x03, 0xF0, 0x00,
  0x1E, 0x07, 0xC0, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0x78, 0x1E, 0x00, 0x00,
  0xF0, 0x7C, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x38,
  0x3C, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x3C, 0x1E,
  0x00, 0x00, 0xF0, 0x3C, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x07, 0xC1, 0xF0,
  0x00, 0x0F, 0x03, 0xE0, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0xF8, 0x0E, 0xC0,
  0x03, 0xE0, 0x3D, 0xC0, 0x0F, 0x80, 0x71, 0xC0, 0x3E, 0x00, 0xE3, 0xFF,
  0xF8, 0x01, 0xC3, 0xFF, 0xE0, 0x07, 0x83, 0xFF, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0,
  0x1F, 0xC0, 0x60, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x10, 0x1F, 0x80, 0x30,
  0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0xE0, 0x78, 0x00, 0x3F, 0xFC,
  0x1C, 0x00, 0x1F, 0xFF, 0x8F, 0x00, 0x0F, 0xC0, 0xF3, 0xC0, 0x07, 0xC0,
  0x0E, 0xF0, 0x03, 0xE0, 0x01, 0xB8, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x78,
  0x00, 0x0F, 0x80, 0x3C, 0x00, 0x03, 0xE0, 0x0F, 0x00, 0x00, 0xF8, 0x07,
  0x80, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x3C, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x0E,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00,
  0x78, 0x0F, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x3C, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x7C, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x03, 0xE0, 0x0F,
  0x00, 0x01, 0xF8, 0x03, 0xC0, 0x00, 0xFE, 0x00, 0xF0, 0x00, 0x3F, 0x00,
  0x3C, 0x00, 0x1D, 0xC0, 0x07, 0x80, 0x0E, 0x70, 0x01, 0xF0, 0x07, 0x3C,
  0x00, 0x7E, 0x07, 0xCF, 0x00, 0x0F, 0xFF, 0xE3, 0x80, 0x01, 0xFF, 0xE0,
  0xE0, 0x00, 0x3F, 0xF0, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x03, 0xF0, 0x3E,
  0x01, 0xF0, 0x07, 0x80, 0xF8, 0x00, 0xF0, 0x7C, 0x00, 0x3C, 0x1E, 0x00,
  0x0F, 0x0F, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF1, 0xE0, 0x00, 0x78, 0x78,
  0x00, 0x1E, 0x3C, 0x00, 0x0F, 0x8F, 0x00, 0x07, 0xC3, 0x80, 0x03, 0xE1,
  0xE0, 0x03, 0xF0, 0x78, 0x0F, 0xF8, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xF8,
  0x03, 0xFF, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x08, 0x0F, 0xC0,
  0x1E, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x07, 0x80, 0x07,
  0xFF, 0xC3, 0x80, 0x07, 0xFF, 0xF1, 0xC0, 0x07, 0xE0, 0x78, 0xE0, 0x07,
  0xC0, 0x0E, 0xF0, 0x07, 0xC0, 0x03, 0x78, 0x07, 0xC0, 0x01, 0xF8, 0x03,
  0xC0, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x1F, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x03, 0xC0,
  0x78, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x70,
  0x1E, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0xF0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x01,
  0xE0, 0x1E, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0xF8, 0x07, 0x80, 0x00,
  0xFC, 0x03, 0xC0, 0x00, 0xFE, 0x01, 0xE0, 0x00, 0x7E, 0x00, 0xF0, 0x00,
  0x77, 0x00, 0x3C, 0x00, 0x77, 0x80, 0x1F, 0x00, 0x7B, 0xC0, 0x0F, 0xC0,
  0xF9, 0xE0, 0x03, 0xFF, 0xF8, 0xE0, 0x00, 0xFF, 0xF0, 0xF0, 0x00, 0x3F,
  0xF0, 0x78, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x80, 0x01, 0xF0, 0x00, 0x78, 0x03, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x0F,
  0xF0, 0x00, 0xF0, 0xFF, 0xF0, 0x03, 0x8F, 0xFF, 0xE0, 0x1E, 0x7C, 0x0F,
  0x80, 0x7B, 0xC0, 0x1F, 0x01, 0xEE, 0x00, 0x3C, 0x07, 0x70, 0x00, 0xF0,
  0x1F, 0x80, 0x03, 0xC0, 0xFC, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x3C, 0x0F,
  0x80, 0x00, 0xF0, 0x3C, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x07, 0xC0,
  0x00, 0x38, 0x1E, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0x1E, 0x0F, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x03, 0xC1,
  0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x78, 0x1E, 0x00, 0x01, 0xE0, 0x70,
  0x00, 0x07, 0x83, 0xC0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0xF0, 0x3C, 0x00,
  0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x3C, 0x1E, 0x00, 0x00,
  0xE0, 0x78, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x78,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xC0, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x78,
  0x03, 0x80, 0x03, 0xC0, 0x1E, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x07, 0x80, 0x07, 0x80, 0x3C, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0xF0,
  0x0F, 0x80, 0x03, 0xC0, 0x7C, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x3C, 0x1F,
  0x00, 0x00, 0xE0, 0xF8, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x1E, 0x1E, 0x00,
  0x00, 0x78, 0xF0, 0x00, 0x01, 0xC7, 0xC0, 0x00, 0x0F, 0x3F, 0x80, 0x00,
  0x3D, 0xFE, 0x00, 0x00, 0xFF, 0x78, 0x00, 0x03, 0xF8, 0xF0, 0x00, 0x0F,
  0xC3, 0xC0, 0x00, 0x7E, 0x0F, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x07, 0x80,
  0x78, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x70, 0x03, 0xC0, 0x03, 0xC0, 0x0F,
  0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0x80, 0x03, 0xC0, 0x1E, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x3C, 0x01,
  0xE0, 0x00, 0x78, 0x07, 0x80, 0x01, 0xE0, 0x3C, 0x00, 0x07, 0xC0, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80,
  0x00, 0x00, 0xE0, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0xE1, 0xFF, 0xE0, 0x3F,
  0xFC, 0x00, 0xE3, 0xFF, 0xE0, 0x7F, 0xFE, 0x01, 0xE7, 0xC1, 0xF0, 0xF0,
  0x7E, 0x01, 0xEF, 0x00, 0xF1, 0xC0, 0x1E, 0x01, 0xDC, 0x00, 0x73, 0x80,
  0x0F, 0x01, 0xD8, 0x00, 0x7F, 0x00, 0x0F, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x0F, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x07, 0xC0, 0x00, 0xF0, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x3C, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x0E, 0x00, 0x01, 0xE0, 0x00,
  0x38, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x38, 0x00, 0x07, 0x00, 0x01,
  0xE0, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x7F, 0xE0, 0x03,
  0x83, 0xFF, 0xC0, 0x0E, 0x3F, 0xFF, 0x80, 0x79, 0xF0, 0x3E, 0x01, 0xEF,
  0x00, 0x7C, 0x07, 0x78, 0x00, 0xF0, 0x1D, 0xC0, 0x03, 0xC0, 0x7E, 0x00,
  0x0F, 0x03, 0xF0, 0x00, 0x3C, 0x0F, 0xC0, 0x00, 0xF0, 0x3E, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0xF0,
  0x78, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x78, 0x3C,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x3C, 0x0F, 0x00,
  0x00, 0xF0, 0x3C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x0F, 0x07, 0x80, 0x00,
  0x78, 0x1E, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x1E,
  0x0F, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0x78, 0x1E, 0x00, 0x01, 0xE0, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x80, 0x0F, 0xC0, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x3E, 0x00, 0x1E, 0x07,
  0xC0, 0x01, 0xE0, 0x78, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF1, 0xF0, 0x00,
  0x0F, 0x1E, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x73,
  0xC0, 0x00, 0x0F, 0x78, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x0F, 0x78, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0x1E, 0xF0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x07,
  0xCF, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0xF0, 0x78,
  0x00, 0x1E, 0x07, 0x80, 0x03, 0xE0, 0x3C, 0x00, 0x7C, 0x03, 0xF0, 0x1F,
  0x80, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x1C, 0x07, 0xF8, 0x00, 0x07, 0x07, 0xFF, 0x00,
  0x01, 0xC3, 0xFF, 0xF0, 0x00, 0xF1, 0xE0, 0x7C, 0x00, 0x3C, 0xE0, 0x0F,
  0x80, 0x0E, 0x70, 0x01, 0xE0, 0x03, 0xB8, 0x00, 0x7C, 0x00, 0xFC, 0x00,
  0x0F, 0x00, 0x7F, 0x00, 0x03, 0xC0, 0x1F, 0x80, 0x00, 0xF0, 0x07, 0xC0,
  0x00, 0x3C, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x3E,
  0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x3C,
  0x07, 0x80, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x70, 0x00, 0x01,
  0xE0, 0x3C, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x01, 0xE0, 0x1F, 0x00,
  0x00, 0xF8, 0x07, 0xC0, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x7E,
  0x00, 0x0F, 0x80, 0x1D, 0x80, 0x07, 0xC0, 0x0F, 0x70, 0x03, 0xE0, 0x03,
  0xCE, 0x01, 0xF8, 0x00, 0xF3, 0xFF, 0xF8, 0x00, 0x3C, 0x7F, 0xFC, 0x00,
  0x0E, 0x0F, 0xFC, 0x00, 0x07, 0x80, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x1E, 0x00, 0x7F, 0xFC, 0x38, 0x01, 0xFF, 0xFC,
  0x70, 0x07, 0xE0, 0x78, 0xE0, 0x1F, 0x00, 0x3B, 0xC0, 0x7C, 0x00, 0x77,
  0x81, 0xF0, 0x00, 0x7E, 0x03, 0xC0, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0xF8,
  0x1E, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x07, 0x83,
  0xC0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x3C, 0x3C,
  0x00, 0x00, 0x70, 0x78, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x07, 0x87, 0x80, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x3C, 0x1E, 0x00,
  0x00, 0x78, 0x3C, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x03, 0xE0, 0xF0, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x3E, 0x07, 0x80, 0x00,
  0xFC, 0x0F, 0x00, 0x03, 0xF8, 0x1E, 0x00, 0x07, 0xE0, 0x3C, 0x00, 0x1D,
  0xC0, 0x3C, 0x00, 0x77, 0x80, 0x7C, 0x01, 0xEF, 0x00, 0xFC, 0x0F, 0x9E,
  0x00, 0xFF, 0xFE, 0x38, 0x00, 0xFF, 0xF0, 0xF0, 0x00, 0xFF, 0xC1, 0xE0,
  0x00, 0x38, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xE0, 0x7F, 0x80, 0x70, 0x7F, 0x80, 0x38, 0xFF,
  0xC0, 0x3C, 0xFC, 0x20, 0x1E, 0xF0, 0x00, 0x0E, 0x70, 0x00, 0x07, 0x70,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x3E, 0x01, 0xF0,
  0x3E, 0x00, 0x10, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xF0, 0x80, 0x01, 0xF0, 0x78, 0x01, 0xF0, 0x3F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x0F, 0x00, 0x0F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFC, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xFE, 0x01, 0xFF,
  0x80, 0x3F, 0xE0, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x0E, 0x00,
  0x00, 0xF0, 0x78, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0x78, 0x1E, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x1C,
  0x0F, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0x38, 0x1E, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0x1E, 0x07, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x01, 0xC0, 0xF0, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x03,
  0xC1, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x78, 0x1E, 0x00, 0x01, 0xE0,
  0x70, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x3E, 0x0F, 0x00, 0x01, 0xF0, 0x3C,
  0x00, 0x07, 0xC0, 0xF0, 0x00, 0x3F, 0x03, 0xC0, 0x00, 0xFC, 0x0F, 0x00,
  0x07, 0xE0, 0x3C, 0x00, 0x3B, 0x80, 0xF8, 0x01, 0xCE, 0x01, 0xF0, 0x1E,
  0x78, 0x07, 0xFF, 0xF1, 0xE0, 0x0F, 0xFF, 0x87, 0x00, 0x1F, 0xF8, 0x1C,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7B, 0xC0, 0x00, 0x3E, 0xF0, 0x00, 0x0F, 0x3C, 0x00, 0x07,
  0xCF, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0xF8, 0xF0, 0x00, 0x3C, 0x3C, 0x00,
  0x1E, 0x07, 0x00, 0x07, 0x81, 0xC0, 0x03, 0xC0, 0x70, 0x00, 0xF0, 0x1C,
  0x00, 0x78, 0x07, 0x80, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x01, 0xE0, 0x07, 0x80, 0x78, 0x01, 0xE0, 0x3C, 0x00, 0x78, 0x0F,
  0x00, 0x0E, 0x07, 0x80, 0x03, 0x81, 0xE0, 0x00, 0xE0, 0xF0, 0x00, 0x38,
  0x3C, 0x00, 0x0E, 0x1E, 0x00, 0x03, 0xC7, 0x80, 0x00, 0xF3, 0xC0, 0x00,
  0x3C, 0xF0, 0x00, 0x0F, 0x78, 0x00, 0x03, 0xDE, 0x00, 0x00, 0xF7, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0x80, 0x03, 0xDE, 0x00, 0x0F,
  0xC0, 0x01, 0xEF, 0x00, 0x07, 0xE0, 0x00, 0xF7, 0x80, 0x07, 0xF0, 0x00,
  0xF3, 0xC0, 0x03, 0xB8, 0x00, 0x79, 0xE0, 0x03, 0xDC, 0x00, 0x78, 0xF0,
  0x01, 0xCE, 0x00, 0x3C, 0x78, 0x01, 0xE7, 0x00, 0x3C, 0x3C, 0x00, 0xE3,
  0x80, 0x1E, 0x1E, 0x00, 0x71, 0xC0, 0x0E, 0x0F, 0x00, 0x78, 0xE0, 0x0F,
  0x07, 0x80, 0x38, 0x70, 0x07, 0x83, 0xC0, 0x3C, 0x38, 0x07, 0x81, 0xE0,
  0x1C, 0x1C, 0x03, 0xC0, 0xF0, 0x1E, 0x0E, 0x03, 0xC0, 0x78, 0x0E, 0x07,
  0x01, 0xE0, 0x1C, 0x0F, 0x03, 0x80, 0xE0, 0x0E, 0x07, 0x01, 0xE0, 0xF0,
  0x07, 0x07, 0x80, 0xF0, 0x70, 0x03, 0x83, 0x80, 0x78, 0x78, 0x01, 0xC3,
  0xC0, 0x3C, 0x3C, 0x00, 0xE1, 0xE0, 0x1E, 0x3C, 0x00, 0x70, 0xE0, 0x0F,
  0x1E, 0x00, 0x38, 0xF0, 0x07, 0x8E, 0x00, 0x1C, 0x70, 0x03, 0xCF, 0x00,
  0x0E, 0x78, 0x01, 0xE7, 0x00, 0x07, 0x38, 0x00, 0xF7, 0x80, 0x03, 0xBC,
  0x00, 0x3B, 0x80, 0x01, 0xDC, 0x00, 0x1D, 0xC0, 0x00, 0xEE, 0x00, 0x0F,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x07,
  0x80, 0x1E, 0x00, 0x07, 0xC0, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x3C, 0x03,
  0xE0, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x03, 0xC1,
  0xE0, 0x00, 0x00, 0xE1, 0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x3C,
  0xF0, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x00,
  0x3D, 0xE0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00,
  0x3C, 0x1E, 0x00, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00,
  0x1E, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x70, 0x00, 0x1F, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x0F, 0x80, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x78, 0x0F, 0x80, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x03,
  0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x00, 0x70, 0x03, 0xC0,
  0x00, 0x01, 0xC0, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x78, 0x00, 0x00, 0x1C,
  0x01, 0xE0, 0x00, 0x00, 0x70, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x3C, 0x00,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x3C, 0x00, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x00, 0x03, 0x87, 0x80, 0x00,
  0x00, 0x0E, 0x1E, 0x00, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x00, 0x00, 0xE3,
  0xC0, 0x00, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x00,
  0x00, 0x3B, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x09, 0xFF, 0xE0, 0x00, 0x5F, 0xFF, 0xC0, 0x07, 0xF8, 0x7F,
  0xC0, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFA, 0x00, 0x01, 0xFF,
  0x00,
};

const GFXglyph NotoSans_SemiCondensed_LightItalic69pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 16, 50, 16, 1, -49 },
  { 101, 18, 18, 23, 7, -49 },
  { 142, 37, 49, 38, 1, -49 },
  { 369, 30, 56, 33, 2, -52 },
  { 579, 40, 51, 48, 5, -50 },
  { 834, 35, 51, 39, 2, -50 },
  { 1058, 7, 18, 13, 7, -49 },
  { 1074, 21, 60, 18, 2, -49 },
  { 1232, 21, 60, 18, -5, -49 },
  { 1390, 26, 26, 32, 8, -52 },
  { 1475, 29, 33, 35, 4, -41 },
  { 1595, 11, 17, 14, -3, -8 },
  { 1619, 16, 3, 20, 2, -20 },
  { 1625, 6, 7, 15, 1, -6 },
  { 1631, 31, 49, 22, -3, -49 },
  { 1821, 29, 51, 33, 3, -50 },
  { 2006, 17, 49, 33, 10, -49 },
  { 2111, 33, 50, 33, -1, -50 },
  { 2318, 32, 51, 33, 0, -50 },
  { 2522, 32, 50, 33, 0, -50 },
  { 2722, 32, 50, 33, 1, -49 },
  { 2922, 31, 51, 33, 3, -50 },
  { 3120, 30, 49, 33, 5, -49 },
  { 3304, 31, 51, 33, 2, -50 },
  { 3502, 30, 51, 33, 2, -50 },
  { 3694, 12, 38, 15, 1, -37 },
  { 3751, 16, 46, 15, -3, -37 },
  { 3843, 29, 31, 35, 4, -40 },
  { 3956, 29, 17, 35, 4, -33 },
  { 4018, 29, 31, 35, 4, -40 },
  { 4131, 23, 51, 25, 4, -50 },
  { 4278, 46, 55, 51, 3, -49 },
  { 4595, 34, 49, 33, -4, -49 },
  { 4804, 34, 49, 36, 2, -49 },
  { 5013, 35, 51, 35, 4, -50 },
  { 5237, 36, 49, 40, 2, -49 },
  { 5458, 32, 49, 32, 2, -49 },
  { 5654, 32, 49, 29, 2, -49 },
  { 5850, 38, 51, 42, 4, -50 },
  { 6093, 40, 49, 41, 2, -49 },
  { 6338, 24, 49, 19, -2, -49 },
  { 6485, 27, 62, 16, -11, -49 },
  { 6695, 37, 49, 34, 2, -49 },
  { 6922, 22, 49, 29, 2, -49 },
  { 7057, 50, 49, 52, 2, -49 },
  { 7364, 41, 49, 43, 2, -49 },
  { 7616, 37, 51, 43, 4, -50 },
  { 7852, 33, 49, 34, 2, -49 },
  { 8055, 37, 62, 43, 4, -50 },
  { 8342, 33, 49, 35, 2, -49 },
  { 8545, 32, 51, 31, 0, -50 },
  { 8749, 29, 49, 30, 6, -49 },
  { 8927, 38, 50, 41, 4, -49 },
  { 9165, 33, 49, 33, 6, -49 },
  { 9368, 51, 49, 53, 7, -49 },
  { 9681, 40, 49, 31, -4, -49 },
  { 9926, 30, 49, 30, 6, -49 },
  { 10110, 36, 49, 31, -1, -49 },
  { 10331, 26, 60, 20, -1, -49 },
  { 10526, 11, 49, 23, 7, -49 },
  { 10594, 26, 60, 20, -5, -49 },
  { 10789, 31, 28, 35, 2, -49 },
  { 10898, 25, 3, 24, -6, 7 },
  { 10908, 9, 11, 17, 10, -53 },
  { 10921, 30, 38, 35, 3, -37 },
  { 11064, 31, 53, 35, 1, -52 },
  { 11270, 25, 38, 27, 3, -37 },
  { 11389, 34, 53, 35, 3, -52 },
  { 11615, 26, 38, 31, 3, -37 },
  { 11739, 36, 70, 18, -9, -53 },
  { 12054, 33, 54, 35, 1, -37 },
  { 12277, 30, 52, 34, 1, -52 },
  { 12472, 15, 50, 15, 1, -50 },
  { 12566, 25, 67, 15, -9, -50 },
  { 12776, 30, 52, 29, 1, -52 },
  { 12971, 15, 52, 14, 1, -52 },
  { 13069, 48, 37, 52, 1, -37 },
  { 13291, 30, 37, 34, 1, -37 },
  { 13430, 28, 38, 34, 3, -37 },
  { 13563, 34, 53, 35, -2, -37 },
  { 13789, 31, 53, 35, 3, -37 },
  { 13995, 25, 37, 23, 1, -37 },
  { 14111, 25, 38, 26, 0, -37 },
  { 14230, 18, 46, 19, 3, -45 },
  { 14334, 30, 38, 35, 3, -37 },
  { 14477, 26, 37, 27, 4, -37 },
  { 14598, 41, 37, 43, 4, -37 },
  { 14788, 33, 37, 28, -3, -37 },
  { 14941, 38, 54, 27, -7, -37 },
  { 15198, 28, 37, 26, -2, -37 },
  { 15328, 25, 60, 23, 2, -49 },
  { 15516, 3, 70, 33, 16, -53 },
  { 15543, 25, 60, 23, -4, -49 },
  { 15731, 29, 7, 35, 4, -28 },
};

const GFXfont NotoSans_SemiCondensed_LightItalic69pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_LightItalic69pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_LightItalic69pt7bGlyphs,
  0x20, 0x7E, 94
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHTITALIC69PT7B_H_
