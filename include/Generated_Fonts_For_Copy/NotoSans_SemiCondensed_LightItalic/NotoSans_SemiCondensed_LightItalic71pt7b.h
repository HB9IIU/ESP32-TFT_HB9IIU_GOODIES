#ifndef _NOTOSANS_SEMICONDENSED_LIGHTITALIC71PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHTITALIC71PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-LightItalic.ttf
// Size: 71pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_LightItalic71pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0xFC, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x30, 0x00, 0x0F, 0x03, 0xC7,
  0xC0, 0xF1, 0xE0, 0x3C, 0x78, 0x1E, 0x1E, 0x07, 0x87, 0x81, 0xE1, 0xC0,
  0x78, 0xF0, 0x1C, 0x3C, 0x07, 0x0F, 0x03, 0xC3, 0x80, 0xF0, 0xE0, 0x38,
  0x78, 0x0E, 0x1C, 0x03, 0x87, 0x00, 0xE1, 0xC0, 0x70, 0x70, 0x1C, 0x18,
  0x07, 0x0E, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0x78,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x0E, 0x00,
  0x00, 0x07, 0x80, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x00, 0x1C,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x07, 0x80,
  0x00, 0x01, 0xC0, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x0F,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x01, 0xC0,
  0x00, 0x00, 0xF0, 0x03, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x01,
  0xE0, 0x07, 0x00, 0x00, 0x03, 0x80, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x38,
  0x00, 0x00, 0x1E, 0x00, 0x70, 0x00, 0x00, 0x38, 0x01, 0xE0, 0x00, 0x00,
  0x70, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x00,
  0x3C, 0x00, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0x04, 0x07, 0x80, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00,
  0x07, 0x80, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x0F, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xF0, 0x60, 0x70, 0x07, 0xC1, 0xC0, 0x20,
  0x1F, 0x03, 0x80, 0x00, 0x3C, 0x07, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x01,
  0xE0, 0x38, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x0F,
  0x01, 0xC0, 0x00, 0x1E, 0x03, 0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x78,
  0x1C, 0x00, 0x00, 0x78, 0x38, 0x00, 0x00, 0xF8, 0x70, 0x00, 0x00, 0xF8,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xDF, 0x80, 0x00, 0x03, 0x8F, 0x80, 0x00, 0x06, 0x0F,
  0x80, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x70, 0x1E,
  0x00, 0x00, 0xE0, 0x3C, 0x00, 0x01, 0x80, 0x78, 0x00, 0x07, 0x00, 0xF0,
  0x00, 0x0E, 0x01, 0xC0, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x38, 0x0F, 0x00,
  0x00, 0xE0, 0x3C, 0x00, 0x01, 0xC0, 0xF8, 0x18, 0x03, 0x83, 0xE0, 0x3E,
  0x07, 0x1F, 0x80, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1E, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xC0, 0x1F, 0x0F, 0x80, 0x00, 0xE0, 0x07, 0x81, 0xE0, 0x00, 0x70,
  0x03, 0xC0, 0x38, 0x00, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x0E, 0x00, 0x78,
  0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x00, 0xE0, 0x03, 0x80, 0x3C,
  0x00, 0x78, 0x00, 0xE0, 0x0E, 0x00, 0x1E, 0x00, 0x78, 0x07, 0x80, 0x07,
  0x00, 0x1E, 0x03, 0xC0, 0x01, 0xC0, 0x07, 0x80, 0xE0, 0x00, 0xF0, 0x01,
  0xC0, 0x78, 0x00, 0x3C, 0x00, 0x70, 0x3C, 0x00, 0x0F, 0x00, 0x3C, 0x0E,
  0x00, 0x03, 0x80, 0x0F, 0x07, 0x80, 0x00, 0xE0, 0x03, 0x83, 0xC0, 0xFC,
  0x38, 0x01, 0xE0, 0xE0, 0xFF, 0x8E, 0x00, 0x70, 0x78, 0x7F, 0xF3, 0x80,
  0x1C, 0x3C, 0x3E, 0x3E, 0xE0, 0x0F, 0x0E, 0x1E, 0x07, 0xBC, 0x07, 0x87,
  0x87, 0x00, 0xEF, 0x01, 0xC3, 0xC3, 0xC0, 0x3D, 0xE1, 0xF0, 0xE0, 0xE0,
  0x0F, 0x7F, 0xF8, 0x78, 0x78, 0x03, 0xCF, 0xFC, 0x3C, 0x1C, 0x00, 0xF1,
  0xFC, 0x0E, 0x0F, 0x00, 0x3C, 0x00, 0x07, 0x83, 0xC0, 0x0E, 0x00, 0x03,
  0xC0, 0xE0, 0x03, 0x80, 0x00, 0xE0, 0x78, 0x00, 0xE0, 0x00, 0x78, 0x1E,
  0x00, 0x38, 0x00, 0x1C, 0x07, 0x80, 0x1E, 0x00, 0x0E, 0x01, 0xC0, 0x07,
  0x80, 0x07, 0x80, 0x70, 0x01, 0xE0, 0x01, 0xC0, 0x1C, 0x00, 0x70, 0x00,
  0xF0, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x1C, 0x00,
  0xF0, 0x03, 0x80, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00,
  0x78, 0x01, 0xC0, 0x03, 0xC0, 0x1C, 0x00, 0xF0, 0x00, 0x70, 0x0F, 0x00,
  0x78, 0x00, 0x1C, 0x07, 0x80, 0x1C, 0x00, 0x07, 0x83, 0xC0, 0x0F, 0x00,
  0x01, 0xFB, 0xF0, 0x07, 0x80, 0x00, 0x3F, 0xF8, 0x03, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFC, 0x1F,
  0x80, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x78, 0x00, 0x03, 0x80, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x1F, 0x00, 0x00, 0x3C, 0x03, 0xE0, 0x00,
  0x03, 0xC0, 0x7C, 0x00, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x01, 0xE1, 0xF0,
  0x00, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x01, 0xF9, 0xE0, 0x00, 0x00, 0x3F, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0xF0, 0x00, 0xF0, 0xF8, 0x0F, 0x80, 0x0F, 0x1F, 0x00,
  0x78, 0x01, 0xE3, 0xE0, 0x07, 0xC0, 0x1E, 0x3C, 0x00, 0x3C, 0x03, 0xC7,
  0x80, 0x01, 0xE0, 0x3C, 0x78, 0x00, 0x1E, 0x07, 0x8F, 0x00, 0x00, 0xF0,
  0x78, 0xF0, 0x00, 0x0F, 0x8F, 0x0F, 0x00, 0x00, 0x79, 0xE0, 0xF0, 0x00,
  0x07, 0xFE, 0x0F, 0x00, 0x00, 0x3F, 0xC0, 0xE0, 0x00, 0x03, 0xF8, 0x0F,
  0x00, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x3F,
  0x80, 0xF0, 0x00, 0x07, 0xF8, 0x0F, 0x80, 0x01, 0xF7, 0xC0, 0x7C, 0x00,
  0x3E, 0x3C, 0x07, 0xF0, 0x0F, 0xC3, 0xE0, 0x3F, 0xFF, 0xF8, 0x1E, 0x01,
  0xFF, 0xFE, 0x00, 0xF0, 0x07, 0xFF, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x00,
  0x00, 0x1E, 0x7C, 0xF1, 0xE3, 0xC7, 0x8E, 0x3C, 0x78, 0xF1, 0xC3, 0x87,
  0x1E, 0x38, 0x70, 0xE1, 0xC3, 0x00, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0E, 0x00, 0x10, 0x01, 0xC0, 0x03, 0x80, 0x38, 0x00, 0x78,
  0x06, 0x00, 0x1F, 0xC1, 0xC0, 0x00, 0xFE, 0x38, 0x00, 0x07, 0xF7, 0x00,
  0x70, 0x1F, 0xCF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x01,
  0xF0, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x0F, 0x0E, 0x00,
  0x03, 0xC1, 0xC0, 0x00, 0xF8, 0x3C, 0x00, 0x3E, 0x03, 0x80, 0x1F, 0x80,
  0x78, 0x01, 0xE0, 0x0F, 0x00, 0x18, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x7C, 0x0F, 0x01,
  0xE0, 0x78, 0x0F, 0x03, 0xC0, 0x78, 0x0E, 0x03, 0xC0, 0x70, 0x1E, 0x03,
  0x80, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xE0,
  0x3C, 0xF9, 0xFF, 0xEF, 0xCF, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x3E,
  0x00, 0xF8, 0x01, 0xF0, 0x01, 0xE0, 0x0F, 0x80, 0x07, 0x80, 0x3C, 0x00,
  0x0F, 0x01, 0xF0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0xF0,
  0xF8, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x3C, 0x78,
  0x00, 0x00, 0xF1, 0xE0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x0F, 0x3E, 0x00,
  0x00, 0x3C, 0xF0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x03, 0xCF, 0x00, 0x00,
  0x0F, 0x3C, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x07,
  0x9E, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x03, 0xC7,
  0x80, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0xF3, 0xC0,
  0x00, 0x07, 0x8F, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x78, 0xF0, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x01,
  0xE0, 0xF0, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x3C, 0x07, 0x80, 0x01, 0xF0,
  0x1E, 0x00, 0x07, 0x80, 0x78, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xF0, 0x03,
  0xE0, 0x0F, 0x80, 0x07, 0xC0, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x07, 0xC0, 0x07, 0xE0, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xBC, 0x1F, 0x9E, 0x3F, 0x0F, 0x3F, 0x0F, 0x3E, 0x07, 0x8E, 0x03, 0xC6,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x3F, 0x81, 0xFC, 0x00, 0x1F, 0x80, 0x1F, 0x00, 0x07, 0x80, 0x03,
  0xE0, 0x00, 0x80, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x07, 0xF8, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x01, 0xC0, 0x00,
  0x78, 0x00, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x3E, 0x04, 0x00, 0x00, 0x3E, 0x03, 0x80, 0x00,
  0x7E, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x07, 0x9C, 0x00, 0x00, 0x03, 0xDE,
  0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x00, 0xF0,
  0x3C, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0xF0,
  0x07, 0x80, 0x00, 0x78, 0x03, 0x80, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x78,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x38, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x1E,
  0x00, 0x03, 0xC0, 0x1E, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xC0, 0x0F,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x04,
  0x00, 0x00, 0xFC, 0x03, 0x80, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xC0, 0x60, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x06, 0x00, 0x03, 0xC0,
  0xFF, 0x80, 0x07, 0x87, 0xFF, 0xC0, 0x0F, 0x3F, 0xFF, 0xC0, 0x3C, 0xF8,
  0x0F, 0xC0, 0x7B, 0xC0, 0x0F, 0x80, 0xFE, 0x00, 0x0F, 0x81, 0xF8, 0x00,
  0x0F, 0x03, 0xE0, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x1E, 0x1F, 0x00, 0x00,
  0x3C, 0x3E, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x01,
  0xE1, 0xE0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x0F,
  0x0E, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x78, 0x38, 0x00, 0x00, 0xF0,
  0x78, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0xF8, 0x07, 0x80, 0x01, 0xE0, 0x0F,
  0x00, 0x07, 0xC0, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0x80,
  0xFC, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0xE0, 0x00,
  0x0F, 0x01, 0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x00,
  0x0F, 0x01, 0xE0, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x78, 0x00,
  0xF8, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x1F, 0x1F,
  0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0x7C, 0x00, 0x01, 0xF8, 0x3E,
  0x00, 0x07, 0xE0, 0x1F, 0x00, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x07,
  0xC0, 0x3E, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x01,
  0xE0, 0x78, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00,
  0xF0, 0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00,
  0xF0, 0xF0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x01,
  0xE0, 0xF8, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x07,
  0x80, 0x3E, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3D, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0x80, 0x01, 0xFC, 0x1F, 0x80, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x0F,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x3C,
  0x07, 0x80, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0xF0,
  0x78, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x07, 0x87,
  0x80, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x3C, 0x3C,
  0x00, 0x00, 0xF8, 0x78, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x0F, 0x83, 0xC0, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x7E, 0x0F, 0x00,
  0x01, 0xFC, 0x0F, 0x00, 0x07, 0xF8, 0x1F, 0x00, 0x1F, 0xE0, 0x1F, 0x00,
  0xFB, 0xC0, 0x3F, 0xFF, 0xE7, 0x80, 0x3F, 0xFF, 0x8F, 0x00, 0x1F, 0xFC,
  0x3C, 0x00, 0x0F, 0xC0, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x60, 0x07, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x3C,
  0x00, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00,
  0x07, 0x00, 0x07, 0x80, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x04, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xC1, 0xFC, 0x0E,
  0x00, 0x7E, 0x08, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xCF, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x1E, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x05, 0x00, 0x03, 0x83, 0xC0, 0x00, 0xFF, 0xE0, 0x07, 0x07, 0x80, 0x07,
  0xFF, 0xF0, 0x0E, 0x1E, 0x00, 0x1F, 0xDF, 0xC0, 0x1C, 0x3C, 0x00, 0x78,
  0x03, 0x80, 0x38, 0xF0, 0x01, 0xE0, 0x0F, 0x00, 0x71, 0xE0, 0x07, 0x80,
  0x1C, 0x00, 0xE3, 0x80, 0x1E, 0x00, 0x38, 0x01, 0xCF, 0x00, 0x78, 0x00,
  0xF0, 0x03, 0x9C, 0x00, 0xE0, 0x01, 0xE0, 0x07, 0x38, 0x03, 0xC0, 0x03,
  0x80, 0x0E, 0xF0, 0x07, 0x00, 0x07, 0x00, 0x1D, 0xE0, 0x0E, 0x00, 0x1E,
  0x00, 0x7B, 0x80, 0x3C, 0x00, 0x3C, 0x00, 0xF7, 0x00, 0x70, 0x00, 0x70,
  0x01, 0xCE, 0x00, 0xE0, 0x00, 0xE0, 0x03, 0xBC, 0x03, 0xC0, 0x03, 0xC0,
  0x0F, 0x78, 0x07, 0x80, 0x07, 0x80, 0x1C, 0xF0, 0x0F, 0x00, 0x0E, 0x00,
  0x39, 0xE0, 0x1C, 0x00, 0x3C, 0x00, 0xF3, 0xC0, 0x38, 0x00, 0x78, 0x01,
  0xC7, 0x80, 0x70, 0x01, 0xF0, 0x07, 0x8F, 0x00, 0xF0, 0x03, 0xE0, 0x0E,
  0x1E, 0x01, 0xE0, 0x0F, 0xC0, 0x3C, 0x3C, 0x03, 0xC0, 0x3B, 0x80, 0xF0,
  0x78, 0x03, 0xC0, 0xE7, 0x83, 0xC0, 0xF0, 0x07, 0xFF, 0x87, 0xFF, 0x01,
  0xE0, 0x07, 0xFE, 0x0F, 0xFC, 0x01, 0xC0, 0x03, 0xF8, 0x07, 0xE0, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x20, 0x00, 0x00, 0x3F,
  0x80, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x07, 0x9E,
  0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0x3C,
  0x78, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x07, 0x83, 0x80, 0x00, 0x03,
  0xC0, 0xE0, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00,
  0x1E, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x3C, 0x00,
  0x01, 0xE0, 0x0F, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x01, 0xE0, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x07, 0x80, 0x01, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1E, 0x00, 0x01, 0xE0, 0x0F,
  0x80, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x07, 0x80,
  0x78, 0x00, 0x01, 0xE0, 0x3E, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x0E,
  0x07, 0xC0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x00,
  0x3C, 0x3C, 0x00, 0x00, 0x0F, 0x1F, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x00,
  0x00, 0xF3, 0xE0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x0F, 0x78, 0x00,
  0x00, 0x03, 0xDE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xC0, 0x03, 0xF8, 0x00, 0x78, 0x00,
  0x1F, 0x80, 0x1E, 0x00, 0x01, 0xF0, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x78,
  0x00, 0x03, 0xE0, 0x0F, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x78, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x3C, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x1E, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x3C, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x3E, 0x00, 0xF0,
  0x00, 0x0F, 0x80, 0x1E, 0x00, 0x03, 0xE0, 0x07, 0x80, 0x01, 0xF8, 0x00,
  0xF0, 0x03, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1E, 0x00, 0x3F, 0xC0, 0x03, 0xC0, 0x00,
  0xFC, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x0F, 0x00, 0x00, 0x78, 0x03, 0xC0,
  0x00, 0x0F, 0x80, 0x78, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x1E, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x0F,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00,
  0x07, 0x80, 0xF0, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x00, 0x3C, 0x07, 0x80,
  0x00, 0x0F, 0x80, 0xF0, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x7C, 0x07,
  0x80, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x0F, 0xC0, 0x1E, 0x00, 0x07, 0xF0,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xE0,
  0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xE0, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x40, 0x00, 0x7F, 0x00, 0x3C, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x3C, 0x00, 0x7F,
  0x80, 0x00, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x1E,
  0x00, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x01, 0xE0, 0x00, 0x07,
  0xC0, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x3C, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x07, 0x80,
  0x00, 0x01, 0xF0, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x00, 0x1F,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0x00, 0x3E, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x00, 0x3C, 0x07,
  0x80, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x00,
  0x3E, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x3C,
  0x00, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x03, 0xC0, 0x00, 0x0F,
  0x80, 0x0F, 0x00, 0x00, 0x7E, 0x00, 0x78, 0x00, 0x07, 0xE0, 0x01, 0xE0,
  0x00, 0x7F, 0x00, 0x07, 0x80, 0x07, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xF0, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xF0,
  0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xC0, 0x03, 0xF8, 0x00, 0x01, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xFF,
  0xC1, 0xE0, 0x00, 0x1F, 0xFF, 0x83, 0xC0, 0x00, 0x3F, 0xFF, 0x07, 0x80,
  0x00, 0xFF, 0xFE, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x00, 0x03, 0xC1, 0xF0,
  0x00, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x07, 0x80, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x00,
  0x0F, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x01,
  0xF0, 0x00, 0x00, 0xF0, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x01, 0xF0, 0x00,
  0x03, 0xC0, 0x03, 0xF8, 0x00, 0x07, 0x80, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF,
  0xC0, 0x07, 0xFF, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x01, 0xE0, 0x00,
  0x0F, 0x80, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00,
  0x3E, 0x00, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x03, 0xE0, 0x00,
  0x07, 0x80, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00,
  0xF8, 0x00, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x0F, 0x80, 0x00,
  0x01, 0xE0, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0xFC, 0x00, 0x00, 0x07, 0x83,
  0xF0, 0x00, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x1F, 0x00, 0x00,
  0x00, 0x78, 0x7C, 0x00, 0x00, 0x00, 0xF1, 0xF0, 0x00, 0x00, 0x01, 0xE7,
  0xE0, 0x00, 0x00, 0x03, 0xDF, 0xE0, 0x00, 0x00, 0x0F, 0x7B, 0xC0, 0x00,
  0x00, 0x1F, 0xE7, 0x80, 0x00, 0x00, 0x3F, 0x87, 0x80, 0x00, 0x00, 0x7E,
  0x0F, 0x00, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x00, 0x1E,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x01, 0xF0,
  0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x0F,
  0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x01, 0xF0, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x3F, 0xC0, 0x07, 0xB8, 0x00, 0x00, 0x03, 0xBC, 0x00, 0x7B,
  0x80, 0x00, 0x00, 0x7B, 0xC0, 0x07, 0xB8, 0x00, 0x00, 0x0F, 0x3C, 0x00,
  0x73, 0xC0, 0x00, 0x00, 0xF7, 0x80, 0x0F, 0x3C, 0x00, 0x00, 0x1E, 0x78,
  0x00, 0xF3, 0xC0, 0x00, 0x01, 0xE7, 0x80, 0x0F, 0x3C, 0x00, 0x00, 0x3C,
  0x78, 0x00, 0xF3, 0xC0, 0x00, 0x03, 0xC7, 0x80, 0x0E, 0x3C, 0x00, 0x00,
  0x78, 0xF0, 0x01, 0xE1, 0xC0, 0x00, 0x07, 0x8F, 0x00, 0x1E, 0x1C, 0x00,
  0x00, 0xF0, 0xF0, 0x01, 0xE1, 0xC0, 0x00, 0x0F, 0x0F, 0x00, 0x1E, 0x1E,
  0x00, 0x01, 0xE1, 0xE0, 0x01, 0xC1, 0xE0, 0x00, 0x1E, 0x1E, 0x00, 0x3C,
  0x1E, 0x00, 0x03, 0xC1, 0xE0, 0x03, 0xC1, 0xE0, 0x00, 0x38, 0x1E, 0x00,
  0x3C, 0x1E, 0x00, 0x07, 0x81, 0xE0, 0x03, 0x81, 0xE0, 0x00, 0xF0, 0x3C,
  0x00, 0x78, 0x0E, 0x00, 0x0F, 0x03, 0xC0, 0x07, 0x80, 0xE0, 0x01, 0xE0,
  0x3C, 0x00, 0x78, 0x0E, 0x00, 0x1E, 0x03, 0xC0, 0x07, 0x80, 0xF0, 0x03,
  0xC0, 0x3C, 0x00, 0x70, 0x0F, 0x00, 0x3C, 0x07, 0x80, 0x0F, 0x00, 0xF0,
  0x07, 0x80, 0x78, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0x78, 0x00, 0xF0, 0x07, 0x00, 0xF0, 0x07, 0x80, 0x0E,
  0x00, 0x70, 0x1E, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x01, 0xC0, 0x0F, 0x00,
  0x1E, 0x00, 0x70, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x87, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x78, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x8F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x9E,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x39, 0xE0, 0x01, 0xE0, 0x03, 0x80, 0x03,
  0xBC, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x3B, 0xC0, 0x03, 0xC0, 0x07, 0x80,
  0x03, 0xF8, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x3F, 0x80, 0x03, 0xC0, 0x07,
  0x80, 0x03, 0xF0, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x3E, 0x00, 0x07, 0x80,
  0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x03, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0x80, 0x0F, 0xE0, 0x00, 0x01, 0xE0, 0x07, 0xF8,
  0x00, 0x00, 0x78, 0x01, 0xFE, 0x00, 0x00, 0x1E, 0x00, 0x7B, 0xC0, 0x00,
  0x07, 0x00, 0x1E, 0xF0, 0x00, 0x03, 0xC0, 0x07, 0x3C, 0x00, 0x00, 0xF0,
  0x03, 0xC7, 0x80, 0x00, 0x3C, 0x00, 0xF1, 0xE0, 0x00, 0x0F, 0x00, 0x3C,
  0x78, 0x00, 0x03, 0x80, 0x0F, 0x0F, 0x00, 0x01, 0xE0, 0x03, 0x83, 0xC0,
  0x00, 0x78, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x00, 0x78, 0x1E, 0x00, 0x07,
  0x80, 0x1E, 0x07, 0x80, 0x03, 0xC0, 0x07, 0x81, 0xE0, 0x00, 0xF0, 0x01,
  0xC0, 0x38, 0x00, 0x3C, 0x00, 0xF0, 0x0F, 0x00, 0x0F, 0x00, 0x3C, 0x03,
  0xC0, 0x03, 0xC0, 0x0F, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x3C, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0xF0, 0x01, 0xC0,
  0x03, 0xC0, 0x3C, 0x00, 0xF0, 0x00, 0x78, 0x0F, 0x00, 0x3C, 0x00, 0x1E,
  0x03, 0xC0, 0x0F, 0x00, 0x07, 0x81, 0xE0, 0x03, 0xC0, 0x00, 0xF0, 0x78,
  0x00, 0xE0, 0x00, 0x3C, 0x1E, 0x00, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x1E,
  0x00, 0x01, 0xE1, 0xE0, 0x07, 0x80, 0x00, 0x78, 0xF0, 0x01, 0xE0, 0x00,
  0x1E, 0x3C, 0x00, 0xF0, 0x00, 0x03, 0xCF, 0x00, 0x3C, 0x00, 0x00, 0xF3,
  0xC0, 0x0F, 0x00, 0x00, 0x3C, 0xE0, 0x03, 0xC0, 0x00, 0x07, 0xB8, 0x00,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x78, 0x00, 0x00, 0x7F, 0x80, 0x1E, 0x00,
  0x00, 0x1F, 0xE0, 0x07, 0x80, 0x00, 0x03, 0xF0, 0x01, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x70, 0x00, 0x00, 0x3F, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0,
  0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFC, 0x0F,
  0xF0, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x07,
  0xE0, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x00,
  0x78, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0xF0,
  0x00, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0xF8, 0x00, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00, 0x0F, 0x1F, 0x00,
  0x00, 0x00, 0x3C, 0x7C, 0x00, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0x03,
  0xCF, 0x80, 0x00, 0x00, 0x0F, 0x3E, 0x00, 0x00, 0x00, 0x3C, 0xF0, 0x00,
  0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x03, 0xDF, 0x00, 0x00, 0x00, 0x0F,
  0x7C, 0x00, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x00, 0xF7, 0x80, 0x00,
  0x00, 0x07, 0xDE, 0x00, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x00, 0x79,
  0xE0, 0x00, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00,
  0x00, 0x3C, 0xF8, 0x00, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x00, 0x07, 0xCF,
  0x80, 0x00, 0x00, 0x1E, 0x3E, 0x00, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00,
  0x03, 0xE1, 0xE0, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x00,
  0x7C, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3C, 0x00, 0xFE, 0x00, 0x0F,
  0x00, 0x0F, 0xC0, 0x07, 0x80, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x3E, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x78,
  0x03, 0xC0, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x01,
  0xF0, 0x0F, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x1E, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x78, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0xF8, 0x07, 0x80,
  0x00, 0x3C, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x3C,
  0x00, 0x03, 0xE0, 0x0F, 0x00, 0x01, 0xF0, 0x03, 0xC0, 0x00, 0xF8, 0x01,
  0xE0, 0x00, 0xFE, 0x00, 0x78, 0x07, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x1F, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x07, 0xC0, 0x00,
  0x01, 0xE0, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x00, 0x0F, 0x07,
  0xC0, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0x00, 0x0F, 0x1F, 0x00, 0x00, 0x00, 0x3C, 0x7C,
  0x00, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0x03, 0xCF, 0x80, 0x00, 0x00,
  0x0F, 0x3E, 0x00, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x00, 0xF3, 0xC0,
  0x00, 0x00, 0x03, 0xDF, 0x00, 0x00, 0x00, 0x0F, 0x7C, 0x00, 0x00, 0x00,
  0x3D, 0xE0, 0x00, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0x07, 0xDE, 0x00,
  0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x01,
  0xEF, 0x80, 0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x00, 0x3C, 0xF8, 0x00,
  0x00, 0x00, 0xF3, 0xE0, 0x00, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x00, 0x1E,
  0x3E, 0x00, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x03, 0xE1, 0xE0, 0x00,
  0x00, 0x0F, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x00, 0x7C, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x03,
  0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3C, 0x00, 0xFE, 0x00,
  0x0F, 0x00, 0x0F, 0xC0, 0x07, 0x80, 0x00, 0xF8, 0x01, 0xE0, 0x00, 0x3E,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00,
  0x7C, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x3C, 0x00,
  0x01, 0xF0, 0x0F, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x1E, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x78, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0xF8, 0x07,
  0x80, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x0F, 0x80,
  0x3C, 0x00, 0x07, 0xE0, 0x0F, 0x00, 0x03, 0xF0, 0x03, 0xC0, 0x03, 0xF8,
  0x01, 0xE0, 0x0F, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xE0, 0x1F, 0x00, 0x00, 0xF0, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x07, 0x80, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x01, 0xE0,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x1E, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x3E, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x78, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x7C, 0x0F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFE, 0x0F, 0xF0, 0x03, 0xF0, 0x00, 0x70,
  0x03, 0xF0, 0x00, 0x08, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x04, 0x00, 0x00, 0x7C,
  0x03, 0x80, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x78,
  0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x3C, 0x00, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x0F,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0x00, 0x3C, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x78, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x3C, 0x00, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x1E, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00,
  0x0F, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x03, 0xC0,
  0x00, 0x03, 0xE0, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0x7C,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x1F, 0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xBC,
  0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x3C,
  0x0E, 0x00, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1E,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x3C, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x03,
  0xC0, 0x07, 0x80, 0x01, 0xE0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x1C, 0x00,
  0x78, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x3E, 0x00, 0x03, 0xC0,
  0x1E, 0x00, 0x01, 0xE0, 0x1F, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x78,
  0x0F, 0x80, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x01,
  0xE1, 0xF0, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x00, 0x38, 0x78, 0x00, 0x00,
  0x1C, 0x78, 0x00, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0x07, 0x3C, 0x00, 0x00,
  0x03, 0x9E, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xBC,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xC7, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1E, 0x38, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xE1, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xF0, 0x70, 0x00, 0x07, 0x78, 0x00, 0x07, 0x83, 0x80, 0x00,
  0x7B, 0xC0, 0x00, 0x7C, 0x1C, 0x00, 0x03, 0xDE, 0x00, 0x03, 0xC0, 0xE0,
  0x00, 0x1C, 0xF0, 0x00, 0x1E, 0x07, 0x00, 0x01, 0xE7, 0x80, 0x01, 0xE0,
  0x3C, 0x00, 0x0E, 0x3C, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0xF1, 0xE0, 0x00,
  0xF0, 0x0F, 0x00, 0x07, 0x8F, 0x00, 0x07, 0x80, 0x78, 0x00, 0x78, 0x78,
  0x00, 0x78, 0x03, 0xC0, 0x03, 0xC3, 0xC0, 0x03, 0xC0, 0x1E, 0x00, 0x3C,
  0x1E, 0x00, 0x1E, 0x00, 0xF0, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0x07, 0x80,
  0x0E, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x3C, 0x00, 0xF0, 0x01,
  0xE0, 0x07, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x78, 0x07, 0x00, 0x78,
  0x00, 0x78, 0x03, 0xC0, 0x38, 0x03, 0xC0, 0x03, 0xC0, 0x3C, 0x01, 0xC0,
  0x1E, 0x00, 0x1E, 0x01, 0xE0, 0x0E, 0x01, 0xE0, 0x00, 0xF0, 0x1E, 0x00,
  0x70, 0x0F, 0x00, 0x07, 0x80, 0xF0, 0x03, 0x80, 0xF0, 0x00, 0x3C, 0x07,
  0x00, 0x1C, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0xE0, 0x78, 0x00, 0x0F,
  0x03, 0x80, 0x07, 0x03, 0xC0, 0x00, 0x78, 0x3C, 0x00, 0x38, 0x1C, 0x00,
  0x03, 0xC1, 0xE0, 0x01, 0xC1, 0xE0, 0x00, 0x1E, 0x1E, 0x00, 0x0E, 0x0F,
  0x00, 0x00, 0xF0, 0xF0, 0x00, 0x70, 0xF0, 0x00, 0x07, 0x8F, 0x00, 0x03,
  0x87, 0x80, 0x00, 0x3C, 0x78, 0x00, 0x1C, 0x78, 0x00, 0x01, 0xE3, 0x80,
  0x00, 0xE3, 0xC0, 0x00, 0x0F, 0x3C, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x79,
  0xC0, 0x00, 0x39, 0xE0, 0x00, 0x03, 0xDE, 0x00, 0x01, 0xCF, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x77, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0xF8, 0x00,
  0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x00,
  0x78, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x3C,
  0x00, 0x00, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0x78, 0x00, 0x00, 0x00, 0x0F, 0xBC, 0x00, 0x00, 0x00, 0x07,
  0x9E, 0x00, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x00, 0x01, 0xE0,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x01, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0xF0,
  0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0xF0, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x01, 0xF3, 0xC0, 0x00,
  0x03, 0xC7, 0x80, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x3E, 0x0F, 0x00, 0x00,
  0x78, 0x1E, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x0F,
  0x00, 0x78, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x78, 0x01, 0xE0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x07, 0x80, 0x3C, 0x00,
  0x0F, 0x00, 0x78, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x3C, 0x07, 0xC0, 0x00,
  0x38, 0x0F, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x01,
  0xE1, 0xE0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x07,
  0xBC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF,
  0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xF0, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x01, 0xC0, 0x1C, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x07, 0x00, 0x70, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x07, 0x8E,
  0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x1E, 0x07,
  0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x3C, 0x03,
  0x80, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x70, 0x01, 0xC0, 0x00, 0xF0, 0x01,
  0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xE0, 0x03, 0xC0, 0x00,
  0xF0, 0x03, 0xC0, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x70, 0x07, 0x00, 0x00,
  0x78, 0x0F, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00,
  0x3C, 0x3C, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0xF8, 0x1E, 0x07, 0xC0, 0xF0, 0x1E, 0x07, 0x80, 0xF0,
  0x1C, 0x07, 0x80, 0xE0, 0x1C, 0x00, 0x07, 0xFC, 0x0E, 0x00, 0x3F, 0xFC,
  0x1C, 0x01, 0xFF, 0xFC, 0x78, 0x07, 0xF0, 0x7C, 0xE0, 0x1F, 0x80, 0x39,
  0xC0, 0x7E, 0x00, 0x37, 0x80, 0xF8, 0x00, 0x7F, 0x03, 0xE0, 0x00, 0x7E,
  0x0F, 0x80, 0x00, 0xF8, 0x1E, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xE0,
  0xF0, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x0F, 0x87, 0x80, 0x00, 0x1E, 0x0F,
  0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0xF0, 0xF0,
  0x00, 0x01, 0xC1, 0xE0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x0F, 0x0F, 0x00,
  0x00, 0x1E, 0x1E, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0xF0, 0x78, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x0F, 0x83, 0xC0, 0x00,
  0x1F, 0x07, 0x80, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x03,
  0xF0, 0x3C, 0x00, 0x0F, 0xE0, 0x7C, 0x00, 0x3B, 0xC0, 0x78, 0x00, 0xF7,
  0x00, 0xF8, 0x03, 0xCE, 0x00, 0xF8, 0x0F, 0x1C, 0x01, 0xFF, 0xFC, 0x78,
  0x01, 0xFF, 0xF0, 0xE0, 0x00, 0xFF, 0x81, 0xC0, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x3F, 0xE0, 0x00, 0xF0, 0xFF,
  0xF0, 0x00, 0xF1, 0xFF, 0xF8, 0x00, 0xF3, 0xE0, 0xFC, 0x00, 0xE7, 0x80,
  0x3E, 0x01, 0xEF, 0x00, 0x1E, 0x01, 0xFE, 0x00, 0x1E, 0x01, 0xFC, 0x00,
  0x0F, 0x01, 0xF8, 0x00, 0x0F, 0x03, 0xF0, 0x00, 0x0F, 0x03, 0xF0, 0x00,
  0x0F, 0x03, 0xE0, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0x0F, 0x07, 0xC0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x0F, 0x07, 0x80, 0x00,
  0x0F, 0x07, 0x80, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00,
  0x1E, 0x0F, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00,
  0x3E, 0x1E, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00,
  0x7C, 0x1E, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00,
  0xF0, 0x3E, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x01, 0xE0, 0x3B, 0x00, 0x03,
  0xE0, 0x3B, 0x80, 0x07, 0xC0, 0x7B, 0x80, 0x0F, 0x80, 0x79, 0xE0, 0x3F,
  0x00, 0x71, 0xFF, 0xFE, 0x00, 0x70, 0xFF, 0xFC, 0x00, 0xF0, 0x3F, 0xF0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xF0,
  0x03, 0xFF, 0xFC, 0x03, 0xF8, 0x0E, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x04, 0x01, 0xF8, 0x07, 0x00, 0x7F,
  0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x07,
  0xFC, 0x0F, 0x00, 0x03, 0xFF, 0xC3, 0xC0, 0x01, 0xFF, 0xFC, 0x78, 0x00,
  0x7F, 0x03, 0xCF, 0x00, 0x1F, 0x80, 0x3D, 0xE0, 0x07, 0xE0, 0x03, 0xB8,
  0x00, 0xF0, 0x00, 0x37, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x0F, 0x80, 0x00,
  0x7C, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x01, 0xE0, 0x0F, 0x00,
  0x00, 0x3C, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0xF0, 0x0F,
  0x00, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0xF0,
  0x0F, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00,
  0xF0, 0x0F, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x3C, 0x00,
  0x00, 0xF8, 0x07, 0x80, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x1E,
  0x00, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x07, 0xE0,
  0x0F, 0x00, 0x00, 0xFC, 0x01, 0xE0, 0x00, 0x3F, 0x00, 0x3C, 0x00, 0x0E,
  0xE0, 0x07, 0xC0, 0x03, 0xFC, 0x00, 0x78, 0x00, 0xF7, 0x80, 0x0F, 0x80,
  0x3C, 0xF0, 0x00, 0xF8, 0x0F, 0x1C, 0x00, 0x1F, 0xFF, 0xC3, 0x80, 0x01,
  0xFF, 0xF0, 0x70, 0x00, 0x0F, 0xF8, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00,
  0x7F, 0x07, 0xE0, 0x1F, 0x80, 0x3C, 0x03, 0xE0, 0x07, 0x80, 0xF0, 0x00,
  0x78, 0x3E, 0x00, 0x0F, 0x0F, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0x38, 0x7C,
  0x00, 0x0F, 0x0F, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x1F,
  0x0F, 0x00, 0x07, 0xC3, 0xC0, 0x03, 0xF0, 0x78, 0x03, 0xFC, 0x0F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x01, 0x00, 0x7E, 0x00, 0xE0, 0x07,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x60, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xCF,
  0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x03, 0xC0, 0x01,
  0xFF, 0xE0, 0xE0, 0x01, 0xFF, 0xFC, 0x38, 0x00, 0xFE, 0x07, 0x8E, 0x00,
  0x7E, 0x00, 0xF7, 0x80, 0x3F, 0x00, 0x1D, 0xC0, 0x0F, 0x80, 0x03, 0x70,
  0x07, 0xC0, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x07,
  0xC0, 0x7C, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00,
  0x1E, 0x03, 0xC0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x01, 0xE0, 0x7C, 0x00,
  0x00, 0xF0, 0x1E, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x0F, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x78, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x00, 0x78, 0x0F,
  0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x03, 0xE0,
  0x3C, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x1F,
  0x00, 0xF0, 0x00, 0x0F, 0xC0, 0x3C, 0x00, 0x03, 0xF0, 0x0F, 0x00, 0x01,
  0xF8, 0x03, 0xC0, 0x00, 0xEE, 0x00, 0xF8, 0x00, 0x7F, 0x80, 0x1E, 0x00,
  0x3D, 0xE0, 0x07, 0xC0, 0x1E, 0x78, 0x00, 0xF8, 0x1F, 0x1C, 0x00, 0x3F,
  0xFF, 0x8F, 0x00, 0x07, 0xFF, 0xC3, 0xC0, 0x00, 0xFF, 0xC0, 0xF0, 0x00,
  0x03, 0x80, 0x38, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x20, 0x00,
  0x3E, 0x00, 0x0E, 0x00, 0x1F, 0x80, 0x03, 0xFC, 0x7F, 0xC0, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xF0, 0x3F, 0xE0, 0x01, 0xE1, 0xFF, 0xF0, 0x03, 0xC7,
  0xFF, 0xF0, 0x07, 0x1F, 0x07, 0xE0, 0x0E, 0x78, 0x03, 0xE0, 0x3D, 0xC0,
  0x07, 0xC0, 0x7F, 0x00, 0x07, 0x80, 0xFC, 0x00, 0x0F, 0x01, 0xF8, 0x00,
  0x1E, 0x07, 0xE0, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0x78, 0x1F, 0x00, 0x00,
  0xF0, 0x3C, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x78,
  0x1C, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x78, 0x1E,
  0x00, 0x00, 0xF0, 0x3C, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x3C, 0x0F, 0x00,
  0x00, 0x78, 0x1E, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0x3C, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0C, 0x00, 0x3C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x67, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x3E, 0x01, 0xE0, 0x00, 0xF8, 0x03, 0xC0, 0x03, 0xE0, 0x07, 0x80,
  0x0F, 0x80, 0x0E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x01,
  0xE0, 0x00, 0xF0, 0x07, 0x80, 0x01, 0xE0, 0x1E, 0x00, 0x07, 0x80, 0x78,
  0x00, 0x0F, 0x01, 0xF0, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x3C, 0x1F, 0x00,
  0x00, 0x70, 0x7C, 0x00, 0x01, 0xE1, 0xF0, 0x00, 0x03, 0xC7, 0xC0, 0x00,
  0x07, 0x9F, 0x00, 0x00, 0x0E, 0x7F, 0x00, 0x00, 0x1C, 0xFE, 0x00, 0x00,
  0x7B, 0xFE, 0x00, 0x00, 0xFF, 0x3C, 0x00, 0x01, 0xFC, 0x78, 0x00, 0x03,
  0xE0, 0x78, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x3C,
  0x01, 0xE0, 0x00, 0x78, 0x03, 0xC0, 0x00, 0xE0, 0x07, 0xC0, 0x03, 0xC0,
  0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x38, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x3C, 0x01, 0xE0, 0x00,
  0x78, 0x03, 0xC0, 0x00, 0xF8, 0x07, 0x80, 0x00, 0xF0, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x70, 0x7F, 0xF0,
  0x0F, 0xFF, 0x00, 0x38, 0x7F, 0xFC, 0x0F, 0xFF, 0xC0, 0x1C, 0x78, 0x3F,
  0x0F, 0x03, 0xE0, 0x0E, 0x70, 0x07, 0x8F, 0x00, 0xF8, 0x0F, 0x70, 0x03,
  0xCE, 0x00, 0x3C, 0x07, 0xF0, 0x00, 0xEE, 0x00, 0x1E, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0x81, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x7C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x78,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x38, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x02, 0x00, 0x01,
  0xE0, 0x7F, 0xC0, 0x03, 0x83, 0xFF, 0xE0, 0x07, 0x0F, 0xFF, 0xE0, 0x0E,
  0x3E, 0x0F, 0xC0, 0x3C, 0xF0, 0x07, 0xC0, 0x7B, 0x80, 0x0F, 0x80, 0xFE,
  0x00, 0x0F, 0x01, 0xFC, 0x00, 0x1E, 0x03, 0xF0, 0x00, 0x3C, 0x0F, 0xC0,
  0x00, 0x78, 0x1F, 0x00, 0x00, 0xF0, 0x3E, 0x00, 0x01, 0xE0, 0x78, 0x00,
  0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0x3C, 0x0F, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0xF0, 0x3C,
  0x00, 0x01, 0xE0, 0xF8, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF8, 0x3E, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xF0, 0x01, 0xFC, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x01, 0xF0, 0x00,
  0xF8, 0x0F, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x78,
  0x78, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0xF3, 0xE0,
  0x00, 0x07, 0x9E, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0x0F, 0x78, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7B, 0xC0,
  0x00, 0x03, 0xDE, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0x0F, 0x3C, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x3C,
  0x78, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x3E, 0x0F, 0x00, 0x03, 0xE0, 0x7C,
  0x00, 0x3E, 0x01, 0xF0, 0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x1E, 0x07, 0xFC, 0x00, 0x03, 0x83, 0xFF, 0xC0, 0x00, 0x70,
  0xFF, 0xFC, 0x00, 0x0E, 0x3E, 0x0F, 0xC0, 0x01, 0xCF, 0x00, 0x7C, 0x00,
  0x7B, 0xC0, 0x07, 0x80, 0x0F, 0xF0, 0x00, 0xF0, 0x01, 0xFC, 0x00, 0x0F,
  0x00, 0x3F, 0x00, 0x01, 0xE0, 0x0F, 0xE0, 0x00, 0x3C, 0x01, 0xF8, 0x00,
  0x07, 0x80, 0x3E, 0x00, 0x00, 0xF0, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x3E, 0x00, 0x00, 0x78, 0x07, 0xC0, 0x00, 0x0F, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x0F,
  0x80, 0xF0, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x78, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x00, 0x3C, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x78, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x3C, 0x01,
  0xE0, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x01, 0xE0, 0x0F, 0x80, 0x00, 0x7C,
  0x01, 0xF8, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x07, 0x70, 0x00,
  0xF8, 0x01, 0xEE, 0x00, 0x3E, 0x00, 0x3C, 0xF0, 0x1F, 0x80, 0x07, 0x8F,
  0xFF, 0xE0, 0x00, 0xF1, 0xFF, 0xF8, 0x00, 0x1C, 0x0F, 0xFC, 0x00, 0x07,
  0x80, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x0F, 0x00, 0x1F, 0xFE, 0x0E, 0x00, 0x7F,
  0xFF, 0x0E, 0x00, 0xFE, 0x0F, 0x8E, 0x01, 0xF8, 0x03, 0xDE, 0x03, 0xF0,
  0x01, 0xDC, 0x03, 0xC0, 0x00, 0xDC, 0x07, 0xC0, 0x00, 0xFC, 0x0F, 0x80,
  0x00, 0xFC, 0x0F, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x78, 0x1E, 0x00,
  0x00, 0x78, 0x1E, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x78, 0x3C, 0x00,
  0x00, 0x78, 0x3C, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0xF0, 0x78, 0x00,
  0x00, 0xF0, 0x78, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x01, 0xE0, 0xF0, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x01, 0xE0, 0xF0, 0x00,
  0x03, 0xE0, 0xF0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x07, 0xC0, 0xF0, 0x00,
  0x07, 0xC0, 0xF0, 0x00, 0x0F, 0xC0, 0xF0, 0x00, 0x0F, 0xC0, 0xF0, 0x00,
  0x1F, 0x80, 0xF0, 0x00, 0x3B, 0x80, 0xF8, 0x00, 0x7F, 0x80, 0x78, 0x00,
  0xF7, 0x80, 0x7C, 0x01, 0xE7, 0x80, 0x3E, 0x03, 0xCF, 0x00, 0x3F, 0xFF,
  0x8F, 0x00, 0x1F, 0xFF, 0x0F, 0x00, 0x0F, 0xFC, 0x0F, 0x00, 0x00, 0xE0,
  0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x3F, 0x80, 0x70, 0x7F,
  0xC0, 0x38, 0x7F, 0xE0, 0x1C, 0x7E, 0x20, 0x0E, 0x78, 0x00, 0x0F, 0x78,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFC, 0x07, 0xE0, 0x1E, 0x03, 0xE0, 0x01, 0x80, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x30, 0x00, 0x3E, 0x0F, 0x00, 0x3F, 0x03, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xFF, 0xFD,
  0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0x00, 0xFF,
  0xE0, 0x0F, 0xFC, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x07, 0x80,
  0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x01, 0xE0, 0x78, 0x00,
  0x03, 0xC0, 0xF0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x0E, 0x03, 0x80, 0x00,
  0x3C, 0x0F, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x01,
  0xE0, 0x78, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0xF0, 0x3C,
  0x00, 0x01, 0xE0, 0x78, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x3E, 0x07, 0x80, 0x00, 0x7C, 0x0F, 0x00, 0x01, 0xF8, 0x1E, 0x00,
  0x03, 0xF0, 0x3C, 0x00, 0x0F, 0xC0, 0x78, 0x00, 0x3B, 0x80, 0xF8, 0x00,
  0xEF, 0x00, 0xF0, 0x03, 0xDE, 0x01, 0xF0, 0x1F, 0x3C, 0x03, 0xFF, 0xFC,
  0x70, 0x03, 0xFF, 0xE0, 0xE0, 0x01, 0xFF, 0x81, 0xC0, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x0F,
  0x78, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x1E, 0x3C, 0x00,
  0x03, 0xC7, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x1E, 0x0E, 0x00, 0x07, 0x81,
  0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x3C, 0x07, 0x80, 0x07, 0x80, 0xF0, 0x01,
  0xE0, 0x1E, 0x00, 0x3C, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x03, 0xC0, 0x03, 0x80, 0x78,
  0x00, 0x70, 0x1E, 0x00, 0x0E, 0x07, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x3C,
  0x3E, 0x00, 0x07, 0x87, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x1E, 0x3C, 0x00,
  0x03, 0xC7, 0x80, 0x00, 0x79, 0xE0, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0xEF,
  0x00, 0x00, 0x1D, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xC0, 0x00, 0x7B, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0x78, 0x00, 0x1F, 0x80, 0x03, 0xCF, 0x00, 0x07, 0xF0,
  0x00, 0x79, 0xE0, 0x00, 0xFE, 0x00, 0x1E, 0x3C, 0x00, 0x3F, 0xC0, 0x03,
  0xC7, 0x80, 0x07, 0x78, 0x00, 0xF8, 0xF0, 0x00, 0xEF, 0x00, 0x1E, 0x1E,
  0x00, 0x3D, 0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x3C, 0x00, 0xF0, 0x78, 0x01,
  0xE3, 0x80, 0x1E, 0x0F, 0x00, 0x38, 0x70, 0x07, 0x81, 0xE0, 0x0F, 0x0E,
  0x00, 0xF0, 0x1C, 0x01, 0xC1, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x38, 0x07,
  0x80, 0x70, 0x0E, 0x07, 0x00, 0xF0, 0x0E, 0x03, 0xC0, 0xE0, 0x3C, 0x01,
  0xC0, 0x78, 0x1C, 0x07, 0x80, 0x38, 0x1E, 0x03, 0x81, 0xE0, 0x07, 0x03,
  0xC0, 0x70, 0x3C, 0x00, 0xE0, 0x70, 0x0E, 0x0F, 0x00, 0x1C, 0x1E, 0x01,
  0xC1, 0xE0, 0x03, 0x83, 0x80, 0x38, 0x38, 0x00, 0x70, 0xF0, 0x07, 0x0F,
  0x00, 0x0E, 0x1C, 0x00, 0xF1, 0xE0, 0x01, 0xC7, 0x80, 0x1E, 0x78, 0x00,
  0x38, 0xE0, 0x03, 0xCF, 0x00, 0x07, 0x3C, 0x00, 0x7B, 0xC0, 0x00, 0xE7,
  0x00, 0x0F, 0x78, 0x00, 0x1C, 0xE0, 0x01, 0xEE, 0x00, 0x03, 0xBC, 0x00,
  0x3F, 0xC0, 0x00, 0x77, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x07, 0xC0, 0x1E, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x07, 0x80,
  0x0F, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x0F,
  0x01, 0xF0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00,
  0x1E, 0x1E, 0x00, 0x00, 0x07, 0x8F, 0x80, 0x00, 0x00, 0xE3, 0xC0, 0x00,
  0x00, 0x3D, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xF7,
  0x80, 0x00, 0x00, 0x7C, 0xE0, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x0F,
  0x0F, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x00,
  0xF0, 0x1E, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0xF0, 0x00,
  0x1F, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x01, 0xE0, 0x00, 0x38, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x03,
  0xC0, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x3C,
  0x00, 0x00, 0x70, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x78, 0x00,
  0x00, 0x03, 0x83, 0xC0, 0x00, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x00, 0x38,
  0x78, 0x00, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00,
  0x00, 0x0F, 0x38, 0x00, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x00, 0xF7,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x21, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x80, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x3F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x7E, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x04, 0x7F, 0xF0, 0x00, 0x17, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8,
  0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xE8, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x03, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_LightItalic71pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 16, 52, 16, 1, -51 },
  { 105, 18, 19, 24, 7, -51 },
  { 148, 39, 51, 39, 1, -51 },
  { 397, 31, 58, 34, 2, -54 },
  { 622, 42, 52, 50, 5, -51 },
  { 895, 36, 52, 40, 2, -51 },
  { 1129, 7, 19, 13, 8, -51 },
  { 1146, 21, 62, 18, 2, -51 },
  { 1309, 21, 62, 18, -5, -51 },
  { 1472, 27, 28, 33, 8, -54 },
  { 1567, 30, 34, 37, 4, -42 },
  { 1695, 11, 17, 15, -3, -8 },
  { 1719, 17, 4, 21, 2, -21 },
  { 1728, 7, 7, 15, 1, -6 },
  { 1735, 32, 51, 23, -3, -51 },
  { 1939, 30, 52, 34, 3, -51 },
  { 2134, 17, 51, 34, 10, -51 },
  { 2243, 34, 51, 34, -1, -51 },
  { 2460, 33, 52, 34, 0, -51 },
  { 2675, 33, 51, 34, 0, -51 },
  { 2886, 33, 52, 34, 1, -51 },
  { 3101, 31, 52, 34, 4, -51 },
  { 3303, 31, 51, 34, 5, -51 },
  { 3501, 32, 52, 34, 2, -51 },
  { 3709, 31, 52, 34, 2, -51 },
  { 3911, 13, 39, 15, 1, -38 },
  { 3975, 17, 47, 15, -3, -38 },
  { 4075, 30, 33, 37, 4, -42 },
  { 4199, 30, 18, 37, 4, -34 },
  { 4267, 30, 33, 37, 4, -42 },
  { 4391, 24, 52, 26, 4, -51 },
  { 4547, 47, 57, 52, 3, -51 },
  { 4882, 34, 51, 34, -4, -51 },
  { 5099, 35, 51, 37, 2, -51 },
  { 5323, 36, 52, 36, 4, -51 },
  { 5557, 38, 51, 42, 2, -51 },
  { 5800, 33, 51, 33, 2, -51 },
  { 6011, 33, 51, 30, 2, -51 },
  { 6222, 39, 52, 43, 4, -51 },
  { 6476, 41, 51, 43, 2, -51 },
  { 6738, 25, 51, 19, -2, -51 },
  { 6898, 28, 64, 16, -11, -51 },
  { 7122, 39, 51, 35, 2, -51 },
  { 7371, 23, 51, 30, 2, -51 },
  { 7518, 52, 51, 53, 2, -51 },
  { 7850, 42, 51, 44, 2, -51 },
  { 8118, 38, 52, 45, 4, -51 },
  { 8365, 34, 51, 35, 2, -51 },
  { 8582, 38, 63, 45, 4, -51 },
  { 8882, 34, 51, 36, 2, -51 },
  { 9099, 33, 52, 32, 0, -51 },
  { 9314, 31, 51, 30, 6, -51 },
  { 9512, 38, 52, 42, 5, -51 },
  { 9759, 33, 51, 34, 7, -51 },
  { 9970, 53, 51, 54, 7, -51 },
  { 10308, 41, 51, 32, -4, -51 },
  { 10570, 31, 51, 31, 6, -51 },
  { 10768, 37, 51, 32, -1, -51 },
  { 11004, 27, 62, 21, -1, -51 },
  { 11214, 12, 51, 23, 7, -51 },
  { 11291, 27, 62, 21, -5, -51 },
  { 11501, 32, 30, 36, 2, -51 },
  { 11621, 25, 3, 25, -6, 7 },
  { 11631, 10, 11, 17, 10, -54 },
  { 11645, 31, 39, 36, 3, -38 },
  { 11797, 32, 55, 36, 1, -54 },
  { 12017, 26, 39, 28, 3, -38 },
  { 12144, 35, 55, 36, 3, -54 },
  { 12385, 27, 39, 31, 3, -38 },
  { 12517, 37, 71, 18, -9, -54 },
  { 12846, 34, 55, 36, 1, -38 },
  { 13080, 31, 54, 35, 1, -54 },
  { 13290, 15, 52, 15, 1, -52 },
  { 13388, 25, 69, 15, -9, -52 },
  { 13604, 31, 54, 30, 1, -54 },
  { 13814, 16, 54, 15, 1, -54 },
  { 13922, 49, 38, 54, 1, -38 },
  { 14155, 31, 39, 35, 1, -39 },
  { 14307, 29, 39, 35, 3, -38 },
  { 14449, 35, 55, 36, -2, -38 },
  { 14690, 32, 55, 36, 3, -38 },
  { 14910, 25, 38, 24, 1, -38 },
  { 15029, 26, 39, 27, 0, -38 },
  { 15156, 19, 48, 20, 3, -47 },
  { 15270, 31, 39, 36, 3, -38 },
  { 15422, 27, 38, 28, 4, -38 },
  { 15551, 43, 38, 44, 4, -38 },
  { 15756, 34, 38, 29, -3, -38 },
  { 15918, 38, 55, 28, -7, -38 },
  { 16180, 29, 38, 26, -2, -38 },
  { 16318, 25, 62, 24, 2, -51 },
  { 16512, 4, 71, 34, 16, -54 },
  { 16548, 26, 62, 24, -4, -51 },
  { 16750, 30, 8, 37, 4, -29 },
};

const GFXfont NotoSans_SemiCondensed_LightItalic71pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_LightItalic71pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_LightItalic71pt7bGlyphs,
  0x20, 0x7E, 97
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHTITALIC71PT7B_H_
