#ifndef _NOTOSANS_SEMICONDENSED_LIGHTITALIC41PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHTITALIC41PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-LightItalic.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_LightItalic41pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0x81, 0x80, 0xC0, 0xE0, 0x70, 0x38, 0x18, 0x0C, 0x0E, 0x07,
  0x03, 0x01, 0x80, 0xC0, 0xE0, 0x60, 0x30, 0x18, 0x0C, 0x0C, 0x06, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x38, 0x1C, 0x0E, 0x00, 0x38, 0xE6,
  0x18, 0xC3, 0x38, 0xE6, 0x18, 0xC3, 0x18, 0x63, 0x0C, 0x41, 0x18, 0x60,
  0x00, 0x30, 0x30, 0x00, 0xC1, 0x80, 0x02, 0x06, 0x00, 0x18, 0x18, 0x00,
  0x60, 0x60, 0x01, 0x83, 0x00, 0x0C, 0x0C, 0x00, 0x30, 0x30, 0x1F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xF2, 0x18, 0x18, 0x00, 0x60, 0xC0, 0x01, 0x03, 0x00,
  0x0C, 0x0C, 0x00, 0x30, 0x30, 0x00, 0xC1, 0x80, 0x06, 0x06, 0x00, 0x18,
  0x18, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x0C, 0x0C, 0x00, 0x30, 0x20,
  0x00, 0x81, 0x80, 0x06, 0x06, 0x00, 0x18, 0x18, 0x00, 0x60, 0xC0, 0x03,
  0x03, 0x00, 0x0C, 0x0C, 0x00, 0x30, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0xF8, 0x01, 0xFF, 0xC0, 0xF6, 0xF0, 0x61, 0x04,
  0x30, 0xC0, 0x0C, 0x30, 0x03, 0x0C, 0x00, 0xC3, 0x00, 0x30, 0x80, 0x0C,
  0x60, 0x03, 0x98, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x3F,
  0x00, 0x0D, 0xE0, 0x03, 0x18, 0x00, 0x86, 0x00, 0x21, 0xC0, 0x18, 0x60,
  0x06, 0x18, 0x01, 0x86, 0x00, 0x43, 0x8C, 0x33, 0xC3, 0xFF, 0xE0, 0x3F,
  0xC0, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x02, 0x0F, 0xC0, 0x0C, 0x1C, 0xE0, 0x18, 0x38, 0x60, 0x18, 0x30,
  0x60, 0x30, 0x60, 0x60, 0x60, 0x60, 0x60, 0x60, 0x60, 0x60, 0xC0, 0xC0,
  0x61, 0x80, 0xC0, 0x61, 0x80, 0xC0, 0xC3, 0x00, 0xC0, 0xC6, 0x00, 0xC0,
  0xC6, 0x3C, 0xC1, 0x8C, 0x7E, 0xC1, 0x9C, 0xC7, 0xC3, 0x19, 0x83, 0xE7,
  0x31, 0x83, 0x7E, 0x73, 0x03, 0x18, 0x63, 0x03, 0x00, 0xC3, 0x03, 0x01,
  0xC6, 0x03, 0x01, 0x86, 0x06, 0x03, 0x06, 0x06, 0x03, 0x06, 0x06, 0x06,
  0x06, 0x06, 0x0C, 0x06, 0x0C, 0x0C, 0x06, 0x0C, 0x18, 0x06, 0x18, 0x30,
  0x07, 0x70, 0x70, 0x03, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0xF8, 0x00, 0x78,
  0xE0, 0x03, 0x03, 0x00, 0x38, 0x18, 0x01, 0x80, 0xC0, 0x0C, 0x06, 0x00,
  0x60, 0x30, 0x03, 0x03, 0x80, 0x18, 0x18, 0x00, 0xC1, 0x80, 0x07, 0x38,
  0x00, 0x1B, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xFC, 0x00, 0x0E,
  0x60, 0x00, 0xC1, 0x81, 0xCC, 0x0E, 0x0C, 0xE0, 0x30, 0x66, 0x01, 0xC6,
  0x70, 0x06, 0x73, 0x00, 0x3B, 0x18, 0x00, 0xF0, 0xC0, 0x07, 0x86, 0x00,
  0x3C, 0x38, 0x03, 0xE0, 0xE0, 0x73, 0x87, 0xFF, 0x0C, 0x0F, 0xE0, 0x70,
  0x39, 0x8C, 0xE6, 0x31, 0x8C, 0x46, 0x00, 0x00, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x80, 0x30, 0x06, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x18, 0x01,
  0x80, 0x38, 0x03, 0x00, 0x30, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xE0, 0x0E,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0x00, 0x38, 0x00,
  0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x60, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x0C,
  0x01, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x07, 0x00, 0x60, 0x0C, 0x01, 0xC0,
  0x18, 0x03, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x04, 0x0C,
  0x0C, 0x18, 0x1E, 0x20, 0x0F, 0x41, 0x87, 0xFF, 0x07, 0x00, 0x1B, 0x00,
  0x76, 0x01, 0xC6, 0x0F, 0x0C, 0x0C, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x0E, 0x1C, 0x30, 0xE1, 0x87, 0x0C,
  0x38, 0x61, 0x80, 0xFF, 0xFF, 0xE0, 0x5F, 0xF0, 0x00, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18,
  0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0xFF, 0x00, 0xF3, 0xC0,
  0xE0, 0x60, 0xE0, 0x38, 0x60, 0x0C, 0x70, 0x06, 0x30, 0x03, 0x38, 0x01,
  0x98, 0x00, 0xCC, 0x00, 0x6E, 0x00, 0x37, 0x00, 0x1B, 0x00, 0x0D, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0x70, 0x01, 0xB0, 0x00, 0xD8, 0x00, 0xEC,
  0x00, 0x66, 0x00, 0x33, 0x00, 0x39, 0x80, 0x18, 0xC0, 0x1C, 0x70, 0x0C,
  0x18, 0x0C, 0x0E, 0x0E, 0x03, 0xFE, 0x00, 0xFC, 0x00, 0x01, 0xC1, 0xE0,
  0xF8, 0xF6, 0x71, 0xB8, 0xEC, 0x30, 0x0C, 0x03, 0x01, 0xC0, 0x70, 0x18,
  0x06, 0x01, 0x80, 0xE0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x70, 0x18, 0x06,
  0x01, 0x80, 0xE0, 0x38, 0x0C, 0x03, 0x00, 0xC0, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x1F, 0xF0, 0x0F, 0x9F, 0x01, 0x80, 0xE0, 0x20, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x00, 0x00, 0x1E,
  0x00, 0x1F, 0xF0, 0x0F, 0x8F, 0x03, 0x80, 0x70, 0x20, 0x0E, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03,
  0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x3C, 0x00, 0xFE, 0x00, 0x1F, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0,
  0x00, 0x38, 0x60, 0x0E, 0x0F, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x60, 0x00, 0xEC, 0x00, 0x19,
  0x80, 0x06, 0x70, 0x01, 0x8C, 0x00, 0x71, 0x80, 0x0C, 0x30, 0x03, 0x0E,
  0x00, 0xC1, 0xC0, 0x38, 0x30, 0x0E, 0x06, 0x01, 0x80, 0xC0, 0x60, 0x38,
  0x18, 0x06, 0x07, 0x00, 0xC0, 0xC0, 0x18, 0x30, 0x03, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x01, 0xFF, 0xE0, 0x7F, 0xF8,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0xF0, 0x01,
  0xFF, 0x80, 0x38, 0x7C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x03, 0x82, 0x00, 0xE0, 0x7F,
  0xF8, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0xF0, 0x0F, 0x8C, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00,
  0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x31, 0xF8, 0x1D, 0xFF, 0x06,
  0xC0, 0xE1, 0xE0, 0x18, 0x70, 0x07, 0x38, 0x01, 0xCE, 0x00, 0x33, 0x80,
  0x0C, 0xC0, 0x07, 0x30, 0x01, 0xCC, 0x00, 0x63, 0x00, 0x18, 0xE0, 0x0E,
  0x38, 0x03, 0x06, 0x01, 0xC1, 0xC0, 0xE0, 0x3F, 0xF0, 0x07, 0xF0, 0x00,
  0x3F, 0xFF, 0xDF, 0xFF, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00,
  0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00,
  0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03,
  0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00,
  0x01, 0x80, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x1F, 0xE0, 0x0F,
  0x1E, 0x01, 0x80, 0xE0, 0x60, 0x0C, 0x0C, 0x01, 0xC3, 0x80, 0x38, 0x70,
  0x07, 0x0E, 0x00, 0xC0, 0xC0, 0x18, 0x18, 0x06, 0x03, 0x81, 0xC0, 0x38,
  0xE0, 0x03, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0xC0, 0x0F, 0x1C, 0x03, 0x81,
  0xC0, 0xC0, 0x18, 0x38, 0x03, 0x86, 0x00, 0x31, 0xC0, 0x06, 0x30, 0x00,
  0xC6, 0x00, 0x18, 0xC0, 0x03, 0x1C, 0x00, 0xE1, 0x80, 0x38, 0x38, 0x0E,
  0x03, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x7F, 0x80, 0x3C,
  0x70, 0x1C, 0x0E, 0x0E, 0x01, 0x83, 0x00, 0x71, 0xC0, 0x0C, 0x60, 0x03,
  0x18, 0x00, 0xCE, 0x00, 0x33, 0x80, 0x0C, 0xE0, 0x07, 0x38, 0x01, 0xCE,
  0x00, 0x71, 0x80, 0x38, 0x70, 0x1E, 0x1E, 0x1D, 0x83, 0xFE, 0xE0, 0x3E,
  0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0xFF, 0xC0, 0x3F,
  0xC0, 0x00, 0x0E, 0x1C, 0x78, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x07, 0x0E, 0x1C, 0x00, 0x01, 0xC0,
  0x70, 0x1C, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0xC0, 0x70, 0x18,
  0x06, 0x03, 0x80, 0xC0, 0x60, 0x18, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x70, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x30, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x38, 0x00, 0x08, 0x00, 0x00, 0x01,
  0x80, 0x7F, 0xC3, 0xE7, 0x84, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x1C, 0x00,
  0xF0, 0x03, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x03,
  0xC0, 0x1C, 0x00, 0xE0, 0x00, 0xC0, 0x30, 0x00, 0x1C, 0x0C, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x03, 0x18, 0x07, 0xF0, 0x66, 0x03,
  0xFE, 0x0C, 0xC0, 0xE0, 0xC1, 0xB0, 0x38, 0x18, 0x36, 0x06, 0x06, 0x06,
  0xC1, 0x80, 0xC0, 0xF8, 0x30, 0x18, 0x1E, 0x0C, 0x03, 0x03, 0xC1, 0x80,
  0xC0, 0xD8, 0x30, 0x18, 0x1B, 0x06, 0x03, 0x03, 0x60, 0xC0, 0xE0, 0xCC,
  0x18, 0x1C, 0x19, 0x83, 0x05, 0x86, 0x30, 0x73, 0xB1, 0x86, 0x07, 0xE3,
  0xE0, 0xC0, 0x20, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x80, 0x03, 0xC0, 0x70,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0D, 0xC0, 0x00, 0xDC, 0x00,
  0x18, 0xC0, 0x01, 0x8C, 0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x60, 0xC0,
  0x0E, 0x0C, 0x00, 0xC0, 0xC0, 0x1C, 0x0C, 0x01, 0x80, 0xC0, 0x38, 0x0C,
  0x03, 0x00, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0xE0, 0x0E, 0x0C, 0x00,
  0x61, 0xC0, 0x06, 0x18, 0x00, 0x63, 0x80, 0x06, 0x30, 0x00, 0x67, 0x00,
  0x06, 0x60, 0x00, 0x6E, 0x00, 0x06, 0xC0, 0x00, 0x70, 0x03, 0xFF, 0x80,
  0x3F, 0xFE, 0x03, 0x00, 0xE0, 0x30, 0x07, 0x07, 0x00, 0x30, 0x60, 0x03,
  0x06, 0x00, 0x30, 0x60, 0x03, 0x06, 0x00, 0x70, 0xE0, 0x07, 0x0C, 0x00,
  0xE0, 0xC0, 0x1C, 0x0C, 0x0F, 0x81, 0xFF, 0xE0, 0x1F, 0xFF, 0x01, 0x80,
  0x38, 0x18, 0x01, 0x81, 0x80, 0x1C, 0x38, 0x00, 0xC3, 0x80, 0x0C, 0x30,
  0x00, 0xC3, 0x00, 0x0C, 0x30, 0x01, 0xC7, 0x00, 0x18, 0x60, 0x03, 0x86,
  0x00, 0x70, 0x60, 0x1E, 0x07, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x07, 0xFF, 0x01, 0xF9, 0xF0, 0x3C, 0x02, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00,
  0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x40, 0x1F, 0xFC, 0x00, 0xFF,
  0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x30, 0x1E, 0x00, 0xC0, 0x1C,
  0x07, 0x00, 0x38, 0x18, 0x00, 0x60, 0x60, 0x01, 0x81, 0x80, 0x07, 0x06,
  0x00, 0x1C, 0x38, 0x00, 0x70, 0xC0, 0x01, 0xC3, 0x00, 0x07, 0x0C, 0x00,
  0x1C, 0x70, 0x00, 0x71, 0xC0, 0x01, 0x86, 0x00, 0x06, 0x18, 0x00, 0x18,
  0x60, 0x00, 0xE3, 0x80, 0x03, 0x0E, 0x00, 0x1C, 0x30, 0x00, 0x70, 0xC0,
  0x03, 0x83, 0x00, 0x1C, 0x1C, 0x00, 0x70, 0x60, 0x07, 0x81, 0x80, 0x3C,
  0x06, 0x03, 0xE0, 0x3F, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0,
  0x7F, 0xFC, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x7F, 0xFE, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x18, 0x00, 0x03, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x01, 0xFF, 0xE0, 0x1F, 0xDF, 0xC0,
  0xF0, 0x06, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x07, 0xFC, 0xC0,
  0x1F, 0xE3, 0x00, 0x01, 0x8C, 0x00, 0x06, 0x30, 0x00, 0x38, 0xC0, 0x00,
  0xE3, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x30, 0xE0, 0x01, 0xC1,
  0x80, 0x06, 0x07, 0x00, 0x18, 0x0F, 0x00, 0xE0, 0x1F, 0xFF, 0x80, 0x3F,
  0xF8, 0x00, 0x03, 0x80, 0x07, 0x03, 0x00, 0x06, 0x03, 0x00, 0x06, 0x03,
  0x00, 0x06, 0x07, 0x00, 0x06, 0x06, 0x00, 0x0E, 0x06, 0x00, 0x0C, 0x06,
  0x00, 0x0C, 0x06, 0x00, 0x0C, 0x0E, 0x00, 0x1C, 0x0C, 0x00, 0x1C, 0x0C,
  0x00, 0x18, 0x0C, 0x00, 0x18, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x18,
  0x00, 0x38, 0x18, 0x00, 0x30, 0x18, 0x00, 0x30, 0x38, 0x00, 0x30, 0x38,
  0x00, 0x70, 0x30, 0x00, 0x60, 0x30, 0x00, 0x60, 0x30, 0x00, 0x60, 0x70,
  0x00, 0x60, 0x60, 0x00, 0xE0, 0x60, 0x00, 0xC0, 0x60, 0x00, 0xC0, 0x60,
  0x00, 0xC0, 0xE0, 0x01, 0xC0, 0x03, 0xFC, 0x03, 0xC0, 0x06, 0x00, 0x38,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x1C,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x01, 0xC0, 0x1F, 0xC0, 0xFF, 0x00, 0x00, 0x07, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x07, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x03, 0x80, 0x1C, 0x0C,
  0x00, 0xE0, 0x30, 0x07, 0x00, 0xC0, 0x38, 0x07, 0x01, 0xC0, 0x18, 0x0E,
  0x00, 0x60, 0x70, 0x01, 0x83, 0x80, 0x06, 0x1C, 0x00, 0x38, 0xE0, 0x00,
  0xC7, 0x00, 0x03, 0x38, 0x00, 0x0C, 0xE0, 0x00, 0x77, 0x80, 0x01, 0xF6,
  0x00, 0x07, 0x9C, 0x00, 0x1C, 0x30, 0x00, 0x60, 0xC0, 0x03, 0x83, 0x80,
  0x0E, 0x06, 0x00, 0x30, 0x18, 0x00, 0xC0, 0x70, 0x03, 0x00, 0xC0, 0x1C,
  0x03, 0x80, 0x60, 0x0E, 0x01, 0x80, 0x18, 0x06, 0x00, 0x70, 0x38, 0x01,
  0xC0, 0xE0, 0x03, 0x80, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x70,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xF0,
  0x3C, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x3E, 0x06, 0xC0, 0x00, 0xD8, 0x1B,
  0x00, 0x07, 0xE0, 0x6C, 0x00, 0x1B, 0x01, 0xB0, 0x00, 0xCC, 0x06, 0x60,
  0x03, 0x30, 0x39, 0x80, 0x18, 0xC0, 0xC6, 0x00, 0x67, 0x03, 0x18, 0x03,
  0x18, 0x0C, 0x60, 0x0C, 0x60, 0x71, 0x80, 0x61, 0x81, 0x86, 0x03, 0x8E,
  0x06, 0x18, 0x0C, 0x38, 0x18, 0x60, 0x70, 0xC0, 0x60, 0xC1, 0x83, 0x03,
  0x83, 0x0E, 0x0C, 0x0C, 0x0C, 0x30, 0x70, 0x30, 0x31, 0xC1, 0xC0, 0xC0,
  0xC6, 0x06, 0x03, 0x03, 0x30, 0x18, 0x1C, 0x0C, 0xC0, 0x60, 0x60, 0x36,
  0x03, 0x81, 0x80, 0xF8, 0x0C, 0x06, 0x01, 0xC0, 0x30, 0x38, 0x07, 0x00,
  0xC0, 0xE0, 0x18, 0x07, 0x00, 0x03, 0x80, 0x03, 0x81, 0xC0, 0x01, 0x80,
  0xF0, 0x00, 0xC0, 0x78, 0x00, 0xE0, 0x6C, 0x00, 0x70, 0x37, 0x00, 0x30,
  0x19, 0x80, 0x18, 0x0C, 0xC0, 0x0C, 0x06, 0x70, 0x0E, 0x07, 0x18, 0x06,
  0x03, 0x0C, 0x03, 0x01, 0x87, 0x01, 0x80, 0xC1, 0x80, 0xC0, 0xE0, 0xC0,
  0xE0, 0x60, 0x70, 0x60, 0x30, 0x18, 0x30, 0x18, 0x0C, 0x18, 0x0C, 0x07,
  0x0C, 0x0E, 0x01, 0x8E, 0x06, 0x00, 0xC6, 0x03, 0x00, 0x63, 0x01, 0x80,
  0x19, 0x80, 0xC0, 0x0C, 0xC0, 0xE0, 0x06, 0xC0, 0x60, 0x03, 0xE0, 0x30,
  0x00, 0xF0, 0x18, 0x00, 0x78, 0x1C, 0x00, 0x3C, 0x0E, 0x00, 0x0C, 0x00,
  0x00, 0x1E, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0x3E, 0x01, 0xE0, 0x1C, 0x0F,
  0x00, 0x30, 0x38, 0x00, 0xE1, 0xC0, 0x01, 0x8E, 0x00, 0x06, 0x38, 0x00,
  0x18, 0xC0, 0x00, 0x67, 0x00, 0x01, 0xD8, 0x00, 0x06, 0x60, 0x00, 0x1B,
  0x80, 0x00, 0x6E, 0x00, 0x01, 0xB0, 0x00, 0x06, 0xC0, 0x00, 0x3B, 0x00,
  0x00, 0xEC, 0x00, 0x03, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x73, 0x00, 0x01,
  0x8C, 0x00, 0x0E, 0x30, 0x00, 0x30, 0xE0, 0x01, 0xC3, 0x80, 0x0E, 0x07,
  0x00, 0x70, 0x0E, 0x03, 0xC0, 0x1F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFF, 0x00, 0x3F, 0xFC, 0x03, 0x01, 0xC0, 0x30, 0x0E, 0x07, 0x00, 0x60,
  0x60, 0x06, 0x06, 0x00, 0x70, 0x60, 0x07, 0x06, 0x00, 0x60, 0xE0, 0x06,
  0x0C, 0x00, 0xE0, 0xC0, 0x0E, 0x0C, 0x01, 0xC1, 0xC0, 0x38, 0x1C, 0x0F,
  0x01, 0xFF, 0xE0, 0x1F, 0xF8, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0x3E, 0x01, 0xE0, 0x1C, 0x0F,
  0x00, 0x30, 0x38, 0x00, 0xE1, 0xC0, 0x01, 0x8E, 0x00, 0x06, 0x38, 0x00,
  0x18, 0xC0, 0x00, 0x67, 0x00, 0x01, 0xD8, 0x00, 0x06, 0x60, 0x00, 0x1B,
  0x80, 0x00, 0x6E, 0x00, 0x01, 0xB0, 0x00, 0x06, 0xC0, 0x00, 0x3B, 0x00,
  0x00, 0xEC, 0x00, 0x03, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x73, 0x00, 0x01,
  0x8C, 0x00, 0x0E, 0x30, 0x00, 0x30, 0xE0, 0x01, 0xC3, 0x80, 0x0E, 0x07,
  0x00, 0x70, 0x0E, 0x03, 0x80, 0x1F, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFC, 0x03,
  0x01, 0xE0, 0x30, 0x0E, 0x07, 0x00, 0x60, 0x60, 0x06, 0x06, 0x00, 0x70,
  0x60, 0x07, 0x06, 0x00, 0x60, 0xE0, 0x06, 0x0C, 0x00, 0xE0, 0xC0, 0x0C,
  0x0C, 0x01, 0xC1, 0xC0, 0x78, 0x1F, 0xFF, 0x01, 0xFF, 0xC0, 0x18, 0x38,
  0x01, 0x81, 0x80, 0x38, 0x18, 0x03, 0x81, 0x80, 0x30, 0x1C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x07, 0x00, 0xE0, 0x60, 0x06, 0x06, 0x00, 0x60, 0x60,
  0x07, 0x0E, 0x00, 0x70, 0xE0, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x1F, 0xFC,
  0x0F, 0xDF, 0x81, 0xC0, 0x20, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x60,
  0x1E, 0x0F, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x0C,
  0x30, 0x00, 0x70, 0xC0, 0x01, 0x87, 0x00, 0x06, 0x18, 0x00, 0x18, 0x60,
  0x00, 0xE1, 0x80, 0x03, 0x8E, 0x00, 0x0C, 0x38, 0x00, 0x30, 0xC0, 0x00,
  0xC3, 0x00, 0x07, 0x0C, 0x00, 0x18, 0x70, 0x00, 0x61, 0xC0, 0x01, 0x86,
  0x00, 0x06, 0x18, 0x00, 0x38, 0x60, 0x00, 0xC3, 0x80, 0x03, 0x0C, 0x00,
  0x0C, 0x30, 0x00, 0x70, 0xC0, 0x01, 0xC3, 0x00, 0x06, 0x0C, 0x00, 0x38,
  0x30, 0x00, 0xC0, 0xC0, 0x07, 0x03, 0x80, 0x38, 0x07, 0x01, 0xE0, 0x0F,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xC0, 0x00, 0xF8, 0x00, 0x1B, 0x00, 0x07,
  0x60, 0x00, 0xCC, 0x00, 0x39, 0xC0, 0x06, 0x38, 0x01, 0xC7, 0x00, 0x30,
  0x60, 0x0E, 0x0C, 0x01, 0x81, 0x80, 0x70, 0x30, 0x0C, 0x06, 0x03, 0x80,
  0xC0, 0x60, 0x18, 0x1C, 0x03, 0x03, 0x00, 0x60, 0xE0, 0x0C, 0x18, 0x01,
  0x87, 0x00, 0x30, 0xC0, 0x07, 0x38, 0x00, 0xE6, 0x00, 0x0D, 0xC0, 0x01,
  0xB0, 0x00, 0x36, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x03, 0x00, 0x0F, 0x80, 0x1C, 0x00, 0x7E, 0x00, 0x78,
  0x01, 0xB8, 0x01, 0xE0, 0x0E, 0xE0, 0x0D, 0x80, 0x33, 0x80, 0x36, 0x01,
  0xCE, 0x01, 0x98, 0x06, 0x38, 0x06, 0x60, 0x18, 0xE0, 0x31, 0x80, 0xE1,
  0x80, 0xC6, 0x03, 0x06, 0x07, 0x18, 0x1C, 0x18, 0x18, 0x60, 0x60, 0x60,
  0x61, 0x83, 0x81, 0x83, 0x06, 0x0C, 0x06, 0x0C, 0x18, 0x30, 0x18, 0x60,
  0x61, 0x80, 0x61, 0x81, 0x86, 0x01, 0x8E, 0x06, 0x38, 0x06, 0x30, 0x18,
  0xC0, 0x19, 0xC0, 0x67, 0x00, 0x66, 0x01, 0x98, 0x01, 0x98, 0x06, 0x60,
  0x06, 0xC0, 0x1B, 0x00, 0x1B, 0x00, 0x6C, 0x00, 0x78, 0x01, 0xF0, 0x01,
  0xE0, 0x07, 0x80, 0x07, 0x80, 0x1E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x70,
  0x01, 0xC0, 0x00, 0x01, 0x80, 0x0E, 0x03, 0x00, 0x18, 0x07, 0x00, 0x60,
  0x06, 0x01, 0xC0, 0x0C, 0x07, 0x00, 0x1C, 0x0C, 0x00, 0x18, 0x38, 0x00,
  0x30, 0xE0, 0x00, 0x61, 0x80, 0x00, 0x66, 0x00, 0x00, 0xDC, 0x00, 0x01,
  0xB0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x6C, 0x00, 0x01, 0x98, 0x00, 0x07, 0x38, 0x00, 0x1C, 0x30,
  0x00, 0x30, 0x60, 0x00, 0xE0, 0xC0, 0x03, 0x81, 0xC0, 0x06, 0x01, 0x80,
  0x18, 0x03, 0x00, 0x70, 0x07, 0x01, 0xC0, 0x06, 0x03, 0x00, 0x0C, 0x0E,
  0x00, 0x1C, 0x00, 0xC0, 0x03, 0xE0, 0x01, 0xB8, 0x01, 0xDC, 0x01, 0xC6,
  0x00, 0xC3, 0x00, 0xE1, 0x80, 0x60, 0xE0, 0x60, 0x30, 0x70, 0x18, 0x30,
  0x0C, 0x38, 0x06, 0x38, 0x03, 0x98, 0x00, 0xDC, 0x00, 0x6C, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x07, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0xFE, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x80, 0x7F, 0x00, 0xFF,
  0x00, 0xC0, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x30, 0x60, 0xC1, 0x83,
  0x06, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x30, 0x60, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x18, 0x00, 0x70, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0xE0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x00,
  0x30, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0x60, 0x01, 0xCC, 0x00, 0x63,
  0x00, 0x30, 0xC0, 0x0C, 0x18, 0x06, 0x06, 0x01, 0x80, 0xC0, 0xC0, 0x30,
  0x70, 0x0C, 0x18, 0x01, 0x8C, 0x00, 0x63, 0x00, 0x1D, 0x80, 0x03, 0xE0,
  0x00, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0xE3, 0x1C, 0x61, 0x8C, 0x01, 0xF0,
  0xC1, 0xFF, 0x20, 0xE0, 0xD8, 0x70, 0x1E, 0x18, 0x07, 0x8E, 0x00, 0xE3,
  0x00, 0x31, 0xC0, 0x0C, 0x60, 0x03, 0x38, 0x01, 0xCE, 0x00, 0x73, 0x00,
  0x18, 0xC0, 0x06, 0x30, 0x03, 0x8C, 0x00, 0xE3, 0x00, 0x30, 0xC0, 0x1C,
  0x30, 0x0F, 0x0E, 0x06, 0xC3, 0x83, 0x30, 0x7F, 0xC8, 0x0F, 0xC6, 0x00,
  0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x8F, 0x80, 0xCF,
  0xF8, 0x37, 0x0E, 0x0F, 0x01, 0xC3, 0x80, 0x31, 0xE0, 0x0C, 0x70, 0x03,
  0x1C, 0x00, 0xC6, 0x00, 0x33, 0x80, 0x0C, 0xE0, 0x07, 0x30, 0x01, 0xCC,
  0x00, 0x63, 0x00, 0x19, 0xC0, 0x0E, 0x70, 0x03, 0x1C, 0x01, 0xC7, 0x00,
  0x61, 0xC0, 0x38, 0xD8, 0x1C, 0x33, 0xFE, 0x0C, 0x7F, 0x00, 0x01, 0xFE,
  0x0F, 0xF8, 0x38, 0x10, 0xE0, 0x01, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x30,
  0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x83,
  0xFE, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x1F, 0x8C, 0x07, 0xFD, 0xC0, 0xE0, 0xD8, 0x1C, 0x07,
  0x81, 0x80, 0x38, 0x38, 0x03, 0x87, 0x00, 0x38, 0x70, 0x03, 0x06, 0x00,
  0x30, 0xE0, 0x03, 0x0E, 0x00, 0x70, 0xC0, 0x07, 0x0C, 0x00, 0x60, 0xC0,
  0x06, 0x0C, 0x00, 0xE0, 0xC0, 0x0E, 0x0C, 0x01, 0xE0, 0xC0, 0x3C, 0x0E,
  0x02, 0xC0, 0xE0, 0xEC, 0x07, 0xFC, 0xC0, 0x3F, 0x18, 0x00, 0x01, 0xF8,
  0x0F, 0xF8, 0x38, 0x38, 0xE0, 0x31, 0x80, 0x66, 0x00, 0xCC, 0x03, 0xB0,
  0x06, 0x60, 0x1D, 0xC1, 0xF3, 0xFF, 0x87, 0xF8, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x83,
  0xFF, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x18, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x70, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x02, 0x70, 0x00, 0x1F, 0x80,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x30, 0x1F, 0xF3, 0x03, 0x83, 0x60,
  0x70, 0x1E, 0x06, 0x00, 0xE0, 0xE0, 0x0E, 0x0C, 0x00, 0xE1, 0xC0, 0x0C,
  0x18, 0x00, 0xC3, 0x80, 0x0C, 0x38, 0x01, 0xC3, 0x00, 0x1C, 0x30, 0x01,
  0x83, 0x00, 0x18, 0x30, 0x03, 0x83, 0x00, 0x38, 0x30, 0x07, 0x83, 0x00,
  0xF0, 0x38, 0x1F, 0x03, 0x83, 0xB0, 0x1F, 0xF7, 0x00, 0xFC, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x01, 0xC0, 0x80, 0x38, 0x0E, 0x0F, 0x00, 0xFF, 0xE0, 0x01, 0xF8, 0x00,
  0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x8F, 0xC0, 0xCF,
  0xF8, 0x37, 0x0E, 0x0F, 0x01, 0x83, 0x80, 0x71, 0xE0, 0x18, 0x70, 0x06,
  0x1C, 0x01, 0x86, 0x00, 0x63, 0x80, 0x38, 0xE0, 0x0E, 0x30, 0x03, 0x0C,
  0x00, 0xC3, 0x00, 0x31, 0xC0, 0x1C, 0x60, 0x07, 0x18, 0x01, 0x86, 0x00,
  0x61, 0x80, 0x18, 0xE0, 0x0E, 0x30, 0x03, 0x0C, 0x00, 0xC0, 0x03, 0x03,
  0x07, 0x03, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x0C, 0x0C, 0x0C, 0x0C, 0x1C,
  0x18, 0x18, 0x18, 0x38, 0x38, 0x30, 0x30, 0x30, 0x70, 0x60, 0x60, 0x60,
  0x60, 0xE0, 0xC0, 0xC0, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0xC0, 0x13, 0x80, 0x3E, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x03, 0x80, 0x70, 0xC0, 0x30, 0x30, 0x18, 0x0C, 0x0C,
  0x03, 0x07, 0x01, 0xC3, 0x80, 0x61, 0xC0, 0x18, 0xE0, 0x06, 0x70, 0x03,
  0xB8, 0x00, 0xDE, 0x00, 0x3F, 0xC0, 0x0F, 0x30, 0x03, 0x8E, 0x01, 0xC1,
  0x80, 0x60, 0x60, 0x18, 0x1C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0xE0, 0x38,
  0x30, 0x06, 0x0C, 0x01, 0xC0, 0x03, 0x81, 0x80, 0xC0, 0x60, 0x70, 0x30,
  0x18, 0x0C, 0x06, 0x07, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x70, 0x30, 0x18,
  0x0C, 0x0E, 0x07, 0x03, 0x01, 0x80, 0xC0, 0xE0, 0x60, 0x30, 0x18, 0x0C,
  0x0E, 0x06, 0x03, 0x00, 0x0C, 0x7E, 0x0F, 0xC0, 0xCF, 0xF1, 0xFE, 0x0D,
  0x83, 0x30, 0x70, 0xF0, 0x3E, 0x03, 0x0E, 0x03, 0xC0, 0x31, 0xC0, 0x3C,
  0x03, 0x1C, 0x03, 0x80, 0x31, 0x80, 0x38, 0x07, 0x18, 0x03, 0x00, 0x73,
  0x80, 0x30, 0x06, 0x38, 0x03, 0x00, 0x63, 0x00, 0x70, 0x06, 0x30, 0x06,
  0x00, 0xE3, 0x00, 0x60, 0x0C, 0x70, 0x06, 0x00, 0xC6, 0x00, 0xE0, 0x0C,
  0x60, 0x0E, 0x00, 0xC6, 0x00, 0xC0, 0x1C, 0x60, 0x0C, 0x01, 0x8E, 0x00,
  0xC0, 0x18, 0xC0, 0x1C, 0x01, 0x8C, 0x01, 0x80, 0x38, 0x0C, 0x3F, 0x03,
  0x3F, 0xE0, 0xDC, 0x38, 0x3C, 0x06, 0x1E, 0x01, 0xC7, 0x80, 0x71, 0xC0,
  0x18, 0x70, 0x06, 0x18, 0x01, 0x8E, 0x00, 0xE3, 0x80, 0x38, 0xC0, 0x0C,
  0x30, 0x03, 0x0C, 0x00, 0xC7, 0x00, 0x71, 0x80, 0x1C, 0x60, 0x06, 0x18,
  0x01, 0x86, 0x00, 0x63, 0x80, 0x38, 0xC0, 0x0C, 0x30, 0x03, 0x00, 0x01,
  0xF8, 0x03, 0xFF, 0x03, 0x83, 0x83, 0x80, 0xE1, 0x80, 0x31, 0x80, 0x1D,
  0xC0, 0x0E, 0xC0, 0x07, 0x60, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xD8, 0x00,
  0x6C, 0x00, 0x36, 0x00, 0x3B, 0x00, 0x19, 0x80, 0x0C, 0xC0, 0x0E, 0x60,
  0x06, 0x38, 0x06, 0x0E, 0x07, 0x03, 0xFF, 0x00, 0xFE, 0x00, 0x03, 0x0F,
  0x80, 0x33, 0xFE, 0x03, 0x70, 0xE0, 0x3C, 0x07, 0x03, 0xC0, 0x30, 0x78,
  0x03, 0x07, 0x00, 0x30, 0x70, 0x03, 0x06, 0x00, 0x30, 0xE0, 0x03, 0x0E,
  0x00, 0x70, 0xC0, 0x07, 0x0C, 0x00, 0x60, 0xC0, 0x06, 0x1C, 0x00, 0xE1,
  0xC0, 0x0C, 0x1C, 0x01, 0xC1, 0xC0, 0x18, 0x1C, 0x03, 0x83, 0xE0, 0x70,
  0x33, 0xFE, 0x03, 0x1F, 0xC0, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xF8, 0xC1, 0xFF, 0x30, 0xE0,
  0xD8, 0x70, 0x1E, 0x18, 0x03, 0x8E, 0x00, 0xE7, 0x00, 0x39, 0xC0, 0x0C,
  0x60, 0x03, 0x38, 0x00, 0xCE, 0x00, 0x73, 0x00, 0x1C, 0xC0, 0x06, 0x30,
  0x01, 0x8C, 0x00, 0xE3, 0x00, 0x38, 0xC0, 0x1E, 0x30, 0x0F, 0x0E, 0x02,
  0xC3, 0x83, 0xB0, 0x7F, 0xDC, 0x0F, 0xC6, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x0C, 0x7C, 0x33, 0xF0, 0xDC, 0x03,
  0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03,
  0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x03, 0xFC, 0x1F,
  0xFC, 0x38, 0x18, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC4, 0x03, 0x8F, 0xFE,
  0x0F, 0xF8, 0x00, 0x06, 0x00, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x7F, 0xFF,
  0xF0, 0xC0, 0x18, 0x07, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x1C, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x1F, 0xC1, 0xF8, 0x00, 0x1C, 0x01, 0xC6, 0x00, 0x61, 0x80, 0x18,
  0x60, 0x06, 0x38, 0x03, 0x8C, 0x00, 0xC3, 0x00, 0x30, 0xC0, 0x0C, 0x70,
  0x07, 0x1C, 0x01, 0xC6, 0x00, 0x61, 0x80, 0x18, 0x60, 0x06, 0x38, 0x03,
  0x8C, 0x00, 0xE3, 0x00, 0x70, 0xC0, 0x1C, 0x30, 0x0F, 0x0C, 0x06, 0xC3,
  0x83, 0x60, 0x7F, 0x98, 0x1F, 0xC6, 0x00, 0xC0, 0x07, 0xE0, 0x06, 0xE0,
  0x0E, 0xE0, 0x0C, 0x60, 0x1C, 0x60, 0x18, 0x60, 0x38, 0x60, 0x30, 0x60,
  0x70, 0x60, 0x60, 0x60, 0xE0, 0x60, 0xC0, 0x61, 0xC0, 0x61, 0x80, 0x73,
  0x80, 0x33, 0x00, 0x37, 0x00, 0x36, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x38, 0x00, 0xE0, 0x1C, 0x03, 0xF0, 0x0E, 0x01, 0xB8, 0x0F, 0x00,
  0xDC, 0x07, 0x80, 0xEE, 0x06, 0xC0, 0x63, 0x03, 0x60, 0x71, 0x81, 0xB0,
  0x30, 0xC1, 0x98, 0x38, 0x60, 0xCC, 0x18, 0x30, 0xC6, 0x0C, 0x18, 0x63,
  0x0C, 0x0C, 0x61, 0x86, 0x06, 0x30, 0xC7, 0x03, 0x30, 0x63, 0x01, 0x98,
  0x33, 0x80, 0xDC, 0x09, 0x80, 0x6C, 0x04, 0xC0, 0x36, 0x03, 0xC0, 0x1E,
  0x01, 0x60, 0x0F, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x38, 0x00,
  0x07, 0x00, 0x70, 0x30, 0x0E, 0x03, 0x00, 0xC0, 0x18, 0x18, 0x01, 0x83,
  0x80, 0x18, 0x70, 0x00, 0xC6, 0x00, 0x0C, 0xC0, 0x00, 0xFC, 0x00, 0x07,
  0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x1B, 0x80, 0x03,
  0x98, 0x00, 0x71, 0x80, 0x06, 0x1C, 0x00, 0xC0, 0xC0, 0x1C, 0x0C, 0x03,
  0x80, 0x60, 0x30, 0x06, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x0C, 0x06, 0x00,
  0x70, 0x18, 0x01, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0x80,
  0x18, 0x06, 0x00, 0x60, 0x30, 0x01, 0x80, 0xC0, 0x07, 0x06, 0x00, 0x1C,
  0x18, 0x00, 0x30, 0xC0, 0x00, 0xC3, 0x00, 0x03, 0x18, 0x00, 0x0C, 0x60,
  0x00, 0x33, 0x00, 0x00, 0xCC, 0x00, 0x03, 0x60, 0x00, 0x0D, 0x80, 0x00,
  0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30,
  0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x0F, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0xFF, 0x83, 0xFF, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x70, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x18, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0E, 0x00, 0x0F, 0xFF, 0x87, 0xFF, 0xC0, 0x00, 0x3E,
  0x00, 0xFC, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0,
  0x01, 0x80, 0x07, 0x00, 0x7C, 0x01, 0xC0, 0x03, 0xE0, 0x00, 0xE0, 0x00,
  0xC0, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x7E, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x01, 0xE0, 0x03, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x38, 0x00,
  0x3C, 0x01, 0xF0, 0x07, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01,
  0x80, 0x03, 0x00, 0x0E, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0x1C, 0x00, 0x1F,
  0xE0, 0x1F, 0x3F, 0x1F, 0x01, 0xFE, 0x80, 0x0E, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_LightItalic41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 9, 29, 9, 1, -29 },
  { 34, 11, 10, 14, 4, -29 },
  { 48, 22, 29, 22, 1, -29 },
  { 128, 18, 33, 20, 1, -31 },
  { 203, 24, 30, 29, 3, -30 },
  { 293, 21, 30, 23, 1, -30 },
  { 372, 5, 10, 8, 4, -29 },
  { 379, 12, 35, 11, 1, -29 },
  { 432, 12, 35, 11, -3, -29 },
  { 485, 15, 16, 19, 5, -31 },
  { 515, 18, 19, 21, 2, -24 },
  { 558, 7, 10, 8, -2, -5 },
  { 567, 10, 2, 12, 1, -12 },
  { 570, 3, 4, 9, 1, -4 },
  { 572, 19, 29, 13, -2, -29 },
  { 641, 17, 30, 20, 2, -30 },
  { 705, 10, 29, 20, 6, -29 },
  { 742, 19, 30, 20, 0, -30 },
  { 814, 19, 30, 20, 0, -30 },
  { 886, 19, 29, 20, 0, -29 },
  { 955, 19, 29, 20, 1, -29 },
  { 1024, 18, 30, 20, 2, -30 },
  { 1092, 18, 29, 20, 3, -29 },
  { 1158, 19, 30, 20, 1, -30 },
  { 1230, 18, 30, 20, 1, -30 },
  { 1298, 7, 22, 9, 1, -22 },
  { 1318, 10, 27, 9, -2, -22 },
  { 1352, 18, 19, 21, 2, -24 },
  { 1395, 18, 11, 21, 2, -20 },
  { 1420, 18, 19, 21, 2, -24 },
  { 1463, 14, 30, 15, 2, -30 },
  { 1516, 27, 33, 30, 2, -29 },
  { 1628, 20, 29, 20, -2, -29 },
  { 1701, 20, 29, 22, 1, -29 },
  { 1774, 20, 30, 21, 3, -30 },
  { 1849, 22, 29, 24, 1, -29 },
  { 1929, 19, 29, 19, 1, -29 },
  { 1998, 19, 29, 17, 1, -29 },
  { 2067, 22, 30, 25, 3, -30 },
  { 2150, 24, 29, 25, 1, -29 },
  { 2237, 14, 29, 11, -1, -29 },
  { 2288, 16, 36, 9, -6, -29 },
  { 2360, 22, 29, 20, 1, -29 },
  { 2440, 13, 29, 17, 1, -29 },
  { 2488, 30, 29, 31, 1, -29 },
  { 2597, 25, 29, 25, 1, -29 },
  { 2688, 22, 30, 26, 3, -30 },
  { 2771, 20, 29, 20, 1, -29 },
  { 2844, 22, 37, 26, 3, -30 },
  { 2946, 20, 29, 21, 1, -29 },
  { 3019, 19, 30, 18, 0, -30 },
  { 3091, 17, 29, 18, 4, -29 },
  { 3153, 22, 29, 25, 3, -29 },
  { 3233, 19, 29, 20, 4, -29 },
  { 3302, 30, 29, 31, 4, -29 },
  { 3411, 23, 29, 18, -2, -29 },
  { 3495, 17, 29, 18, 4, -29 },
  { 3557, 22, 29, 19, -1, -29 },
  { 3637, 16, 36, 12, -1, -29 },
  { 3709, 7, 29, 14, 4, -29 },
  { 3735, 15, 36, 12, -3, -29 },
  { 3803, 18, 17, 21, 1, -29 },
  { 3842, 15, 2, 14, -4, 4 },
  { 3846, 5, 6, 10, 6, -31 },
  { 3850, 18, 22, 21, 2, -22 },
  { 3900, 18, 31, 21, 1, -31 },
  { 3970, 15, 22, 16, 2, -22 },
  { 4012, 20, 31, 21, 2, -31 },
  { 4090, 15, 22, 18, 2, -22 },
  { 4132, 21, 41, 11, -5, -31 },
  { 4240, 20, 32, 21, 0, -22 },
  { 4320, 18, 31, 20, 1, -31 },
  { 4390, 8, 30, 9, 1, -30 },
  { 4420, 15, 40, 9, -5, -30 },
  { 4495, 18, 31, 17, 1, -31 },
  { 4565, 9, 31, 9, 1, -31 },
  { 4600, 28, 22, 31, 1, -22 },
  { 4677, 18, 22, 20, 1, -22 },
  { 4727, 17, 22, 20, 2, -22 },
  { 4774, 20, 32, 21, -1, -22 },
  { 4854, 18, 32, 21, 2, -22 },
  { 4926, 14, 22, 14, 1, -22 },
  { 4965, 15, 22, 16, 0, -22 },
  { 5007, 11, 27, 11, 2, -27 },
  { 5045, 18, 22, 21, 2, -22 },
  { 5095, 16, 22, 16, 2, -22 },
  { 5139, 25, 22, 25, 2, -22 },
  { 5208, 20, 22, 17, -2, -22 },
  { 5263, 22, 32, 16, -4, -22 },
  { 5351, 17, 22, 15, -1, -22 },
  { 5398, 15, 35, 14, 1, -29 },
  { 5464, 2, 41, 19, 9, -31 },
  { 5475, 15, 35, 14, -2, -29 },
  { 5541, 18, 5, 21, 2, -17 },
};

const GFXfont NotoSans_SemiCondensed_LightItalic41pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_LightItalic41pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_LightItalic41pt7bGlyphs,
  0x20, 0x7E, 56
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHTITALIC41PT7B_H_
