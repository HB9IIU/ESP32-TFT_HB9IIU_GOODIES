#ifndef _NOTOSANS_SEMICONDENSED_LIGHTITALIC26PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHTITALIC26PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-LightItalic.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_LightItalic26pt7bBitmaps[] PROGMEM = {
  0x00, 0x08, 0xC6, 0x31, 0x08, 0xC6, 0x21, 0x08, 0xC4, 0x20, 0x00, 0x06,
  0x30, 0x45, 0x14, 0xF2, 0x8A, 0x28, 0x80, 0x02, 0x10, 0x10, 0x80, 0x8C,
  0x0C, 0x40, 0x42, 0x02, 0x11, 0xFF, 0xE1, 0x08, 0x08, 0x40, 0x46, 0x04,
  0x20, 0x21, 0x0F, 0xFF, 0x18, 0x80, 0x84, 0x04, 0x20, 0x63, 0x02, 0x10,
  0x10, 0x80, 0x01, 0x00, 0x20, 0x0C, 0x07, 0xF1, 0x22, 0x64, 0x08, 0x81,
  0x10, 0x32, 0x03, 0x80, 0x38, 0x03, 0x80, 0x58, 0x09, 0x02, 0x20, 0x44,
  0x09, 0x9D, 0xE1, 0xF0, 0x08, 0x01, 0x00, 0x20, 0x00, 0x1C, 0x04, 0x6C,
  0x11, 0x88, 0x22, 0x10, 0x8C, 0x23, 0x10, 0xC4, 0x21, 0x90, 0x42, 0x60,
  0x84, 0xBD, 0x12, 0x47, 0x6D, 0x0B, 0x92, 0x10, 0x4C, 0x21, 0x98, 0x42,
  0x21, 0x88, 0x42, 0x30, 0x84, 0x41, 0x91, 0x01, 0xC0, 0x03, 0x80, 0x76,
  0x02, 0x18, 0x30, 0xC1, 0x86, 0x0C, 0x20, 0x62, 0x01, 0x20, 0x0E, 0x00,
  0xE0, 0x0D, 0x82, 0xC6, 0x3C, 0x31, 0x40, 0xDA, 0x03, 0x90, 0x18, 0x81,
  0xC6, 0x1B, 0x1F, 0x8C, 0x57, 0xA8, 0x03, 0x06, 0x0C, 0x08, 0x10, 0x30,
  0x20, 0x60, 0x60, 0x40, 0xC0, 0xC0, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0xC0, 0xC0, 0x40, 0x60, 0x04, 0x06, 0x02, 0x02, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x02, 0x02, 0x06, 0x04, 0x04, 0x0C, 0x08,
  0x10, 0x30, 0x20, 0xC0, 0x04, 0x01, 0x00, 0x43, 0x10, 0x38, 0xC3, 0xF1,
  0x40, 0x90, 0xC6, 0x10, 0x80, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC1,
  0xFF, 0xC3, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0x33, 0x26,
  0x4C, 0xFF, 0xF0, 0xF0, 0x00, 0x30, 0x06, 0x00, 0x40, 0x0C, 0x00, 0x80,
  0x18, 0x01, 0x00, 0x30, 0x02, 0x00, 0x60, 0x04, 0x00, 0x80, 0x18, 0x01,
  0x00, 0x30, 0x02, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x00, 0x03, 0x81, 0xD8,
  0x61, 0x88, 0x13, 0x02, 0x40, 0x58, 0x0B, 0x01, 0x40, 0x28, 0x0F, 0x01,
  0xE0, 0x2C, 0x05, 0x81, 0xB0, 0x26, 0x0C, 0x41, 0x0C, 0x60, 0xF0, 0x00,
  0x04, 0x73, 0xFA, 0x88, 0x61, 0x86, 0x10, 0x43, 0x0C, 0x20, 0x82, 0x18,
  0x61, 0x04, 0x00, 0x03, 0x80, 0xFE, 0x08, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x02, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x00, 0xFF, 0xC0, 0x03, 0xC1, 0xFE, 0x08,
  0x30, 0x01, 0x00, 0x10, 0x01, 0x00, 0x30, 0x06, 0x01, 0xC0, 0xF0, 0x00,
  0xC0, 0x04, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0xCC, 0x18, 0x7F,
  0x00, 0x00, 0x30, 0x07, 0x00, 0x70, 0x0A, 0x01, 0xA0, 0x32, 0x02, 0x60,
  0x46, 0x08, 0x41, 0x84, 0x30, 0x42, 0x0C, 0x40, 0xCF, 0xFF, 0xFF, 0xF0,
  0x18, 0x01, 0x80, 0x10, 0x01, 0x00, 0x07, 0xF0, 0x7F, 0x0C, 0x00, 0x80,
  0x08, 0x01, 0x80, 0x18, 0x01, 0x00, 0x3F, 0x80, 0x0C, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0xCC, 0x18, 0x7F, 0x00, 0x01,
  0xF0, 0x7A, 0x0C, 0x01, 0x80, 0x10, 0x03, 0x00, 0x20, 0x06, 0x20, 0x6F,
  0x85, 0x0C, 0x60, 0x4C, 0x04, 0xC0, 0x4C, 0x04, 0xC0, 0xCC, 0x0C, 0x41,
  0x86, 0x30, 0x3E, 0x00, 0x7F, 0xEF, 0xFC, 0x01, 0x00, 0x60, 0x08, 0x03,
  0x00, 0x40, 0x18, 0x02, 0x00, 0xC0, 0x10, 0x06, 0x01, 0x80, 0x30, 0x0C,
  0x01, 0x00, 0x60, 0x08, 0x03, 0x00, 0x00, 0x07, 0x81, 0xDC, 0x60, 0x88,
  0x13, 0x02, 0x60, 0x44, 0x18, 0xC6, 0x0F, 0x81, 0xC0, 0xC4, 0x30, 0x4C,
  0x0D, 0x01, 0xA0, 0x34, 0x06, 0xC0, 0x98, 0x31, 0xF8, 0x00, 0x07, 0x81,
  0xB8, 0x41, 0x98, 0x32, 0x02, 0xC0, 0x58, 0x0B, 0x03, 0x60, 0x6C, 0x1C,
  0xCD, 0x0F, 0x20, 0x0C, 0x01, 0x00, 0x60, 0x08, 0x03, 0x00, 0xC3, 0xE0,
  0x00, 0x18, 0xC4, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x60, 0x0C, 0x30,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x21, 0x86, 0x10, 0x80, 0x00,
  0x60, 0x38, 0x1C, 0x0E, 0x07, 0x01, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x10, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0xC0, 0x70, 0x38,
  0x1C, 0x0E, 0x03, 0x00, 0x40, 0x00, 0x1E, 0x1F, 0x80, 0x60, 0x10, 0x08,
  0x0C, 0x04, 0x06, 0x06, 0x06, 0x06, 0x06, 0x02, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x30, 0x00, 0x00, 0x30, 0x00, 0xFF, 0x01, 0x80, 0xC1, 0x80,
  0x31, 0x80, 0x09, 0x80, 0x04, 0x83, 0xE2, 0xC2, 0x11, 0x42, 0x18, 0xA3,
  0x08, 0x71, 0x04, 0x38, 0x86, 0x18, 0xC3, 0x1C, 0x61, 0x0A, 0x11, 0xC9,
  0x8F, 0x38, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x02, 0x00, 0xFE,
  0x00, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x01, 0xA0, 0x09, 0x00, 0xC8, 0x04,
  0x40, 0x62, 0x02, 0x10, 0x30, 0x81, 0x04, 0x1F, 0xF0, 0xFF, 0x8C, 0x0C,
  0x40, 0x66, 0x03, 0x20, 0x1B, 0x00, 0x70, 0x02, 0x0F, 0x00, 0xFF, 0x06,
  0x0C, 0x30, 0x21, 0x01, 0x88, 0x08, 0xC0, 0xC6, 0x04, 0x20, 0xC1, 0xFC,
  0x08, 0x30, 0xC0, 0xC6, 0x02, 0x20, 0x11, 0x01, 0x88, 0x0C, 0xC0, 0xC6,
  0x1C, 0x3F, 0xC0, 0x01, 0xE0, 0x3F, 0xC7, 0x00, 0x20, 0x03, 0x00, 0x30,
  0x01, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x04, 0x0F, 0xE0, 0x0F, 0x00,
  0xFF, 0x06, 0x0C, 0x30, 0x31, 0x00, 0x88, 0x04, 0xC0, 0x26, 0x01, 0x20,
  0x09, 0x00, 0x48, 0x02, 0xC0, 0x36, 0x01, 0xA0, 0x19, 0x00, 0xD8, 0x0C,
  0xC0, 0xC6, 0x3C, 0x3F, 0x80, 0x0F, 0xF1, 0xFF, 0x18, 0x01, 0x80, 0x10,
  0x01, 0x00, 0x30, 0x03, 0x00, 0x20, 0x03, 0xFC, 0x20, 0x06, 0x00, 0x60,
  0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xFF, 0x00, 0x0F, 0xF1,
  0xFF, 0x18, 0x01, 0x80, 0x10, 0x01, 0x00, 0x30, 0x03, 0x00, 0x20, 0x03,
  0xFC, 0x3F, 0x86, 0x00, 0x60, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0x80, 0x00, 0x01, 0xF0, 0x1F, 0xF1, 0xC0, 0x8C, 0x00, 0x30, 0x01,
  0x80, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x1F, 0x20, 0x04,
  0x80, 0x32, 0x00, 0xC8, 0x02, 0x30, 0x08, 0xC0, 0x61, 0xC1, 0x83, 0xFC,
  0x00, 0x08, 0x06, 0x30, 0x0C, 0x60, 0x10, 0xC0, 0x21, 0x00, 0xC2, 0x01,
  0x8C, 0x02, 0x18, 0x04, 0x20, 0x08, 0x7F, 0xF0, 0x80, 0x63, 0x00, 0x86,
  0x01, 0x08, 0x02, 0x10, 0x0C, 0x20, 0x18, 0xC0, 0x21, 0x80, 0x42, 0x01,
  0x80, 0x0F, 0x83, 0x80, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x08, 0x0C, 0x06,
  0x02, 0x01, 0x00, 0x80, 0xC0, 0x60, 0x20, 0x10, 0x08, 0x3F, 0x00, 0x00,
  0x40, 0x30, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x18, 0x06, 0x01, 0x00, 0x40,
  0x10, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x08, 0x06, 0x01, 0x80, 0x40, 0x10,
  0x0C, 0x02, 0x0F, 0x83, 0x80, 0x08, 0x0C, 0x60, 0x61, 0x83, 0x06, 0x18,
  0x10, 0xC0, 0x46, 0x03, 0x30, 0x0D, 0x80, 0x2C, 0x00, 0xB8, 0x03, 0x60,
  0x18, 0x80, 0x63, 0x01, 0x04, 0x04, 0x10, 0x30, 0x60, 0xC0, 0x83, 0x03,
  0x08, 0x0C, 0x00, 0x08, 0x18, 0x18, 0x18, 0x10, 0x10, 0x30, 0x30, 0x20,
  0x20, 0x20, 0x60, 0x60, 0x40, 0x40, 0xC0, 0xC0, 0xC0, 0xFF, 0x0C, 0x00,
  0xE3, 0x80, 0x18, 0x70, 0x07, 0x0A, 0x00, 0xA1, 0x40, 0x3C, 0x28, 0x05,
  0x8D, 0x01, 0xA1, 0xB0, 0x24, 0x26, 0x09, 0x84, 0xC3, 0x30, 0x88, 0x44,
  0x31, 0x18, 0x86, 0x22, 0x10, 0x84, 0xC6, 0x10, 0x90, 0xC6, 0x16, 0x10,
  0xC3, 0x82, 0x10, 0x70, 0x42, 0x0C, 0x18, 0x00, 0x08, 0x02, 0x38, 0x04,
  0x70, 0x18, 0xA0, 0x31, 0x60, 0x42, 0xC0, 0x8C, 0x83, 0x19, 0x06, 0x23,
  0x08, 0x42, 0x10, 0x84, 0x23, 0x0C, 0xC6, 0x09, 0x88, 0x12, 0x10, 0x34,
  0x60, 0x28, 0xC0, 0x71, 0x00, 0xE2, 0x00, 0x80, 0x03, 0xC0, 0x3F, 0xC1,
  0x81, 0x8C, 0x06, 0x20, 0x09, 0x80, 0x24, 0x00, 0xF0, 0x03, 0xC0, 0x0A,
  0x00, 0x28, 0x00, 0xA0, 0x06, 0x80, 0x1A, 0x00, 0x48, 0x03, 0x30, 0x18,
  0xC0, 0x61, 0x87, 0x03, 0xF0, 0x00, 0x0F, 0x01, 0xFE, 0x18, 0x21, 0x83,
  0x10, 0x31, 0x03, 0x30, 0x33, 0x03, 0x20, 0x62, 0x0C, 0x3F, 0x86, 0x00,
  0x60, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x00, 0x03,
  0xC0, 0x3F, 0xC1, 0x81, 0x8C, 0x06, 0x20, 0x09, 0x80, 0x24, 0x00, 0xF0,
  0x03, 0xC0, 0x0A, 0x00, 0x28, 0x00, 0xA0, 0x06, 0x80, 0x1A, 0x00, 0x48,
  0x03, 0x30, 0x18, 0xC0, 0x61, 0x87, 0x03, 0xF0, 0x00, 0x80, 0x03, 0x00,
  0x04, 0x00, 0x18, 0x00, 0x0F, 0x01, 0xFE, 0x18, 0x31, 0x83, 0x10, 0x11,
  0x03, 0x30, 0x33, 0x03, 0x20, 0x62, 0x1C, 0x3F, 0x06, 0x30, 0x61, 0x04,
  0x10, 0x41, 0x8C, 0x18, 0xC0, 0x8C, 0x0C, 0x80, 0xC0, 0x03, 0xE0, 0xFF,
  0x18, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x80, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC8, 0x38,
  0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x10, 0x02, 0x00, 0xC0, 0x18, 0x02, 0x00,
  0x40, 0x08, 0x03, 0x00, 0x60, 0x08, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x20, 0x04, 0x01, 0x80, 0x00, 0x30, 0x0C, 0xC0, 0x33, 0x00, 0x88, 0x02,
  0x20, 0x09, 0x80, 0x66, 0x01, 0x90, 0x04, 0x40, 0x11, 0x00, 0xCC, 0x03,
  0x30, 0x08, 0x80, 0x22, 0x00, 0x88, 0x06, 0x20, 0x10, 0xC0, 0xC3, 0x86,
  0x07, 0xF0, 0x00, 0xC0, 0x1A, 0x00, 0x90, 0x0C, 0x80, 0x44, 0x06, 0x20,
  0x21, 0x03, 0x08, 0x10, 0x41, 0x83, 0x08, 0x18, 0xC0, 0xC4, 0x06, 0x60,
  0x32, 0x01, 0xB0, 0x05, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x80, 0x40,
  0x70, 0x18, 0x0A, 0x03, 0x03, 0x40, 0xE0, 0x48, 0x14, 0x19, 0x06, 0x83,
  0x20, 0x90, 0x44, 0x32, 0x18, 0x84, 0x42, 0x10, 0x88, 0xC2, 0x21, 0x10,
  0x44, 0x22, 0x09, 0x84, 0xC1, 0x20, 0x90, 0x2C, 0x16, 0x05, 0x02, 0x80,
  0xA0, 0x70, 0x18, 0x0C, 0x03, 0x01, 0x80, 0x00, 0x08, 0x06, 0x18, 0x18,
  0x10, 0x60, 0x20, 0x80, 0x63, 0x00, 0xCC, 0x00, 0x90, 0x01, 0x60, 0x03,
  0x80, 0x06, 0x00, 0x0C, 0x00, 0x2C, 0x00, 0xC8, 0x03, 0x10, 0x04, 0x30,
  0x18, 0x60, 0x60, 0x40, 0x80, 0x82, 0x01, 0x80, 0xC0, 0x34, 0x06, 0x40,
  0x44, 0x0C, 0x61, 0x86, 0x10, 0x23, 0x02, 0x20, 0x24, 0x03, 0xC0, 0x18,
  0x01, 0x80, 0x10, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00, 0x60,
  0x00, 0x07, 0xFC, 0x3F, 0xF0, 0x01, 0x80, 0x04, 0x00, 0x30, 0x01, 0x80,
  0x04, 0x00, 0x30, 0x01, 0x80, 0x04, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x20, 0x01, 0x80, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x0F, 0xFE, 0x00, 0x0F,
  0x87, 0xC2, 0x01, 0x00, 0x80, 0xC0, 0x60, 0x20, 0x10, 0x08, 0x0C, 0x06,
  0x02, 0x01, 0x01, 0x80, 0xC0, 0x40, 0x20, 0x10, 0x18, 0x0C, 0x04, 0x03,
  0xE0, 0x88, 0x88, 0xCC, 0x44, 0x44, 0x66, 0x22, 0x22, 0x23, 0x30, 0x07,
  0xC1, 0xF0, 0x08, 0x02, 0x00, 0x80, 0x60, 0x18, 0x04, 0x01, 0x00, 0x40,
  0x30, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x18, 0x04, 0x01, 0x00, 0x40, 0x30,
  0x0C, 0x02, 0x0F, 0x80, 0x02, 0x00, 0xE0, 0x14, 0x06, 0x80, 0x98, 0x31,
  0x04, 0x21, 0x02, 0x60, 0x48, 0x0F, 0x00, 0x80, 0xFF, 0xFF, 0xC0, 0xD9,
  0x10, 0x0F, 0x31, 0x8A, 0x30, 0x62, 0x06, 0x60, 0x64, 0x04, 0xC0, 0x4C,
  0x0C, 0xC0, 0xCC, 0x0C, 0xC1, 0x8C, 0x18, 0x46, 0x87, 0xD8, 0x08, 0x03,
  0x00, 0x60, 0x08, 0x01, 0x00, 0x20, 0x0C, 0xF1, 0xE6, 0x28, 0x66, 0x04,
  0x80, 0xB0, 0x16, 0x06, 0x80, 0xD0, 0x16, 0x02, 0xC0, 0xD8, 0x32, 0x8C,
  0x5F, 0x00, 0x0F, 0xC6, 0x23, 0x01, 0x80, 0x60, 0x10, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0x61, 0x0F, 0x80, 0x00, 0x18, 0x00, 0xC0,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x18, 0x3C, 0xC3, 0x14, 0x30, 0x61, 0x03,
  0x18, 0x18, 0x80, 0xCC, 0x04, 0x60, 0x23, 0x03, 0x18, 0x18, 0xC1, 0x86,
  0x0C, 0x11, 0xA0, 0xF9, 0x00, 0x0F, 0x86, 0x33, 0x0C, 0x83, 0x60, 0x90,
  0x6F, 0xF3, 0xC0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x61, 0x0F, 0xC0, 0x00,
  0x78, 0x06, 0x40, 0x20, 0x03, 0x00, 0x18, 0x00, 0x80, 0x1F, 0x81, 0x60,
  0x03, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x60, 0x03, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x60, 0x03, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x60,
  0x02, 0x00, 0x30, 0x07, 0x00, 0x00, 0x07, 0x98, 0x62, 0x86, 0x0C, 0x20,
  0x63, 0x03, 0x10, 0x19, 0x80, 0x8C, 0x04, 0x60, 0x63, 0x03, 0x18, 0x30,
  0xC1, 0x82, 0x34, 0x1F, 0x60, 0x03, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x20,
  0xC1, 0xFC, 0x00, 0x08, 0x03, 0x00, 0x60, 0x08, 0x01, 0x00, 0x20, 0x0C,
  0xF1, 0xE6, 0x38, 0x66, 0x0C, 0x81, 0xB0, 0x26, 0x04, 0x80, 0x90, 0x36,
  0x06, 0xC0, 0x98, 0x12, 0x06, 0x40, 0xC0, 0x18, 0xC0, 0x00, 0x18, 0xC4,
  0x21, 0x18, 0xC4, 0x23, 0x18, 0xC4, 0x20, 0x01, 0x80, 0xC0, 0x00, 0x00,
  0x00, 0x18, 0x0C, 0x04, 0x02, 0x01, 0x01, 0x80, 0xC0, 0x40, 0x20, 0x30,
  0x18, 0x0C, 0x04, 0x02, 0x03, 0x01, 0x80, 0x80, 0x40, 0x60, 0xE0, 0x00,
  0x08, 0x03, 0x00, 0x60, 0x08, 0x01, 0x00, 0x20, 0x0C, 0x19, 0x86, 0x21,
  0x84, 0x60, 0x98, 0x36, 0x05, 0xC0, 0xF8, 0x19, 0x06, 0x30, 0xC6, 0x10,
  0x42, 0x0C, 0x40, 0x80, 0x08, 0xC6, 0x21, 0x08, 0xC6, 0x21, 0x08, 0xC6,
  0x21, 0x18, 0xC4, 0x21, 0x00, 0x37, 0x8F, 0x16, 0x6C, 0xCC, 0x1C, 0x26,
  0x0C, 0x12, 0x04, 0x0B, 0x06, 0x05, 0x83, 0x06, 0x81, 0x83, 0x40, 0x81,
  0x60, 0x40, 0xB0, 0x60, 0x58, 0x30, 0x68, 0x10, 0x34, 0x08, 0x10, 0x1B,
  0xE1, 0x67, 0x1C, 0x31, 0x83, 0x10, 0x33, 0x02, 0x30, 0x22, 0x06, 0x20,
  0x66, 0x06, 0x60, 0x46, 0x04, 0x40, 0xCC, 0x0C, 0x0F, 0x83, 0x18, 0xC1,
  0x10, 0x36, 0x06, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x58, 0x1B, 0x03, 0x60,
  0xC6, 0x30, 0x7C, 0x00, 0x0C, 0xF0, 0x59, 0x82, 0x86, 0x18, 0x10, 0x80,
  0x8C, 0x04, 0x60, 0x62, 0x03, 0x10, 0x19, 0x80, 0x8C, 0x0C, 0x60, 0xC2,
  0x8C, 0x13, 0xC1, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x80,
  0x00, 0x0F, 0x31, 0x8A, 0x30, 0x62, 0x06, 0x60, 0x64, 0x06, 0xC0, 0x4C,
  0x04, 0xC0, 0xCC, 0x0C, 0xC1, 0x8C, 0x18, 0x46, 0x87, 0xD8, 0x01, 0x80,
  0x10, 0x01, 0x00, 0x10, 0x03, 0x00, 0x30, 0x37, 0x96, 0x0A, 0x06, 0x02,
  0x03, 0x01, 0x80, 0x80, 0x40, 0x60, 0x30, 0x18, 0x08, 0x04, 0x00, 0x0F,
  0xCE, 0x22, 0x00, 0x80, 0x20, 0x0C, 0x01, 0xC0, 0x38, 0x03, 0x00, 0xC0,
  0x10, 0x0C, 0x86, 0x3F, 0x00, 0x18, 0x20, 0x43, 0xFB, 0x04, 0x08, 0x30,
  0x60, 0x81, 0x02, 0x0C, 0x18, 0x30, 0x60, 0x70, 0x30, 0x24, 0x04, 0x81,
  0x90, 0x36, 0x04, 0xC0, 0x90, 0x12, 0x06, 0x40, 0xD8, 0x13, 0x06, 0x61,
  0xCC, 0x78, 0xFB, 0x00, 0xC0, 0x70, 0x34, 0x09, 0x06, 0x41, 0x10, 0xC4,
  0x21, 0x18, 0x44, 0x1B, 0x06, 0x81, 0xE0, 0x70, 0x0C, 0x00, 0x83, 0x07,
  0x06, 0x0E, 0x1C, 0x14, 0x28, 0x68, 0x50, 0x91, 0x23, 0x22, 0x44, 0x48,
  0x98, 0x91, 0x21, 0x62, 0x42, 0x85, 0x87, 0x0A, 0x0C, 0x1C, 0x18, 0x30,
  0x00, 0x18, 0x30, 0x82, 0x08, 0x60, 0xCC, 0x05, 0x80, 0x50, 0x06, 0x00,
  0x60, 0x0F, 0x01, 0x90, 0x11, 0x03, 0x18, 0x60, 0x8C, 0x0C, 0x04, 0x06,
  0x08, 0x18, 0x10, 0x20, 0x20, 0xC0, 0x41, 0x00, 0x86, 0x01, 0x88, 0x03,
  0x30, 0x06, 0x40, 0x05, 0x80, 0x0A, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60,
  0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x60, 0x07, 0x80, 0x00,
  0x0F, 0xE2, 0x0C, 0x03, 0x00, 0x40, 0x10, 0x06, 0x01, 0x80, 0x20, 0x08,
  0x03, 0x00, 0xC0, 0x10, 0x06, 0x09, 0xFE, 0x00, 0x00, 0x83, 0xC1, 0x01,
  0x80, 0x80, 0x40, 0x20, 0x30, 0x18, 0x08, 0x0C, 0x18, 0x0E, 0x01, 0x00,
  0x80, 0x40, 0x60, 0x30, 0x10, 0x08, 0x04, 0x03, 0x00, 0xE0, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0C, 0x07, 0x00, 0xC0, 0x60, 0x30, 0x18, 0x08, 0x04, 0x06,
  0x03, 0x00, 0x80, 0x70, 0x70, 0x20, 0x30, 0x10, 0x08, 0x04, 0x06, 0x03,
  0x01, 0x01, 0x83, 0x80, 0x20, 0x1F, 0x8E, 0x1F, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_LightItalic26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 5, 19, 6, 1, -19 },
  { 13, 6, 7, 9, 3, -19 },
  { 19, 13, 19, 14, 1, -19 },
  { 50, 11, 22, 13, 1, -20 },
  { 81, 15, 19, 18, 2, -19 },
  { 117, 13, 19, 15, 1, -19 },
  { 148, 2, 7, 5, 3, -19 },
  { 150, 8, 23, 7, 1, -19 },
  { 173, 8, 23, 7, -2, -19 },
  { 196, 10, 10, 12, 3, -20 },
  { 209, 11, 12, 13, 2, -15 },
  { 226, 4, 6, 5, -1, -3 },
  { 229, 6, 2, 8, 1, -8 },
  { 231, 2, 2, 6, 1, -2 },
  { 232, 12, 19, 8, -1, -19 },
  { 261, 11, 19, 13, 1, -19 },
  { 288, 6, 19, 13, 4, -19 },
  { 303, 12, 19, 13, 0, -19 },
  { 332, 12, 19, 13, 0, -19 },
  { 361, 12, 19, 13, 0, -19 },
  { 390, 12, 19, 13, 0, -19 },
  { 419, 12, 19, 13, 1, -19 },
  { 448, 11, 19, 13, 2, -19 },
  { 475, 11, 19, 13, 1, -19 },
  { 502, 11, 19, 13, 1, -19 },
  { 529, 5, 14, 6, 0, -14 },
  { 538, 6, 17, 6, -1, -14 },
  { 551, 11, 12, 13, 2, -15 },
  { 568, 11, 6, 13, 2, -12 },
  { 577, 11, 12, 13, 2, -15 },
  { 594, 9, 19, 9, 1, -19 },
  { 616, 17, 21, 19, 1, -19 },
  { 661, 13, 19, 13, -2, -19 },
  { 692, 13, 19, 14, 1, -19 },
  { 723, 13, 19, 13, 2, -19 },
  { 754, 13, 19, 15, 1, -19 },
  { 785, 12, 19, 12, 1, -19 },
  { 814, 12, 19, 11, 1, -19 },
  { 843, 14, 19, 16, 2, -19 },
  { 877, 15, 19, 16, 1, -19 },
  { 913, 9, 19, 7, -1, -19 },
  { 935, 10, 24, 6, -4, -19 },
  { 965, 14, 19, 13, 1, -19 },
  { 999, 8, 19, 11, 1, -19 },
  { 1018, 19, 19, 19, 1, -19 },
  { 1064, 15, 19, 16, 1, -19 },
  { 1100, 14, 19, 16, 2, -19 },
  { 1134, 12, 19, 13, 1, -19 },
  { 1163, 14, 23, 16, 2, -19 },
  { 1204, 12, 19, 13, 1, -19 },
  { 1233, 12, 19, 12, 0, -19 },
  { 1262, 11, 19, 11, 2, -19 },
  { 1289, 14, 19, 16, 2, -19 },
  { 1323, 13, 19, 13, 2, -19 },
  { 1354, 19, 19, 20, 3, -19 },
  { 1400, 15, 19, 12, -1, -19 },
  { 1436, 12, 19, 11, 2, -19 },
  { 1465, 14, 19, 12, -1, -19 },
  { 1499, 9, 23, 8, 0, -19 },
  { 1525, 4, 19, 9, 3, -19 },
  { 1535, 10, 23, 8, -2, -19 },
  { 1564, 11, 11, 13, 1, -19 },
  { 1580, 9, 2, 9, -2, 2 },
  { 1583, 3, 4, 6, 4, -20 },
  { 1585, 12, 14, 13, 1, -14 },
  { 1606, 11, 20, 13, 1, -20 },
  { 1634, 10, 14, 10, 1, -14 },
  { 1652, 13, 20, 13, 1, -20 },
  { 1685, 10, 14, 12, 1, -14 },
  { 1703, 13, 26, 7, -3, -20 },
  { 1746, 13, 20, 13, 0, -14 },
  { 1779, 11, 20, 13, 1, -20 },
  { 1807, 5, 19, 5, 1, -19 },
  { 1819, 9, 25, 6, -3, -19 },
  { 1848, 11, 20, 11, 1, -20 },
  { 1876, 5, 20, 5, 1, -20 },
  { 1889, 17, 14, 20, 1, -14 },
  { 1919, 12, 14, 13, 0, -14 },
  { 1940, 11, 14, 13, 1, -14 },
  { 1960, 13, 20, 13, -1, -14 },
  { 1993, 12, 20, 13, 1, -14 },
  { 2023, 9, 14, 9, 1, -14 },
  { 2039, 10, 14, 10, 0, -14 },
  { 2057, 7, 17, 7, 1, -17 },
  { 2072, 11, 14, 13, 1, -14 },
  { 2092, 10, 14, 10, 1, -14 },
  { 2110, 15, 14, 16, 2, -14 },
  { 2137, 12, 14, 11, -1, -14 },
  { 2158, 15, 20, 10, -3, -14 },
  { 2196, 11, 14, 10, -1, -14 },
  { 2216, 9, 23, 9, 1, -19 },
  { 2242, 1, 26, 12, 6, -20 },
  { 2246, 9, 23, 9, -1, -19 },
  { 2272, 11, 3, 13, 2, -11 },
};

const GFXfont NotoSans_SemiCondensed_LightItalic26pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_LightItalic26pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_LightItalic26pt7bGlyphs,
  0x20, 0x7E, 35
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHTITALIC26PT7B_H_
