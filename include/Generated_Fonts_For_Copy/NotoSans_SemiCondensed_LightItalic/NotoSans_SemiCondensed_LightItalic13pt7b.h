#ifndef _NOTOSANS_SEMICONDENSED_LIGHTITALIC13PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHTITALIC13PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-LightItalic.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_LightItalic13pt7bBitmaps[] PROGMEM = {
  0x00, 0x24, 0xA4, 0x90, 0x80, 0x5A, 0xA0, 0x12, 0x29, 0xF9, 0x22, 0x97,
  0x92, 0x24, 0x50, 0x08, 0x73, 0x14, 0x30, 0x41, 0x8A, 0xB9, 0x82, 0x00,
  0x72, 0x94, 0xA8, 0xAA, 0xB5, 0x69, 0x29, 0x4A, 0xCE, 0x3C, 0x48, 0x91,
  0xC3, 0x0A, 0x63, 0x46, 0x74, 0x68, 0x12, 0x44, 0x48, 0x88, 0x88, 0x40,
  0x31, 0x11, 0x11, 0x12, 0x24, 0x80, 0x14, 0x9E, 0xA5, 0x00, 0x21, 0x09,
  0xF2, 0x10, 0x6A, 0x00, 0xE0, 0x80, 0x04, 0x20, 0x84, 0x10, 0x82, 0x10,
  0xC0, 0x7A, 0x63, 0x18, 0xC6, 0x52, 0xE0, 0x74, 0xA4, 0x94, 0x80, 0x3C,
  0x10, 0x41, 0x08, 0x42, 0x10, 0xF8, 0x3C, 0x10, 0x42, 0x38, 0x20, 0x82,
  0xF0, 0x04, 0x31, 0x4A, 0x4A, 0x2F, 0xC2, 0x10, 0x3C, 0x84, 0x1C, 0x08,
  0x10, 0x42, 0xF0, 0x3A, 0x21, 0xE8, 0xC6, 0x32, 0xE0, 0xFC, 0x21, 0x04,
  0x20, 0x84, 0x10, 0x80, 0x3C, 0x92, 0x4A, 0x31, 0x28, 0x62, 0x78, 0x3D,
  0x14, 0x51, 0x4C, 0xD0, 0x82, 0xF0, 0x60, 0x00, 0x20, 0x30, 0x00, 0x00,
  0x44, 0x80, 0x08, 0x99, 0x06, 0x0C, 0xF8, 0x3E, 0x82, 0x0C, 0x13, 0x60,
  0xF1, 0x12, 0x48, 0x80, 0x80, 0x3E, 0x41, 0x9D, 0xA5, 0xA5, 0xA9, 0xA9,
  0x96, 0x80, 0x78, 0x04, 0x18, 0x50, 0xA2, 0x47, 0x91, 0x21, 0x82, 0x3C,
  0x44, 0x8A, 0x27, 0x88, 0x91, 0x22, 0xF8, 0x3D, 0x08, 0x20, 0x82, 0x08,
  0x20, 0x70, 0x3C, 0x44, 0x8A, 0x14, 0x28, 0x51, 0x22, 0xF8, 0x3C, 0x82,
  0x10, 0x79, 0x04, 0x10, 0xF8, 0x3C, 0x82, 0x10, 0x79, 0x04, 0x10, 0x80,
  0x3E, 0x82, 0x04, 0x09, 0xD0, 0xA1, 0x42, 0x78, 0x21, 0x21, 0x22, 0x42,
  0x7E, 0x42, 0x42, 0x44, 0x84, 0x32, 0x22, 0x44, 0x44, 0xC0, 0x08, 0x42,
  0x21, 0x08, 0x42, 0x21, 0x38, 0x22, 0x48, 0xA2, 0x87, 0x0A, 0x12, 0x24,
  0x8C, 0x21, 0x08, 0x84, 0x21, 0x08, 0xF8, 0x20, 0xCC, 0x23, 0x19, 0x46,
  0x52, 0x95, 0x25, 0x51, 0x64, 0x89, 0x00, 0x21, 0x31, 0x31, 0x52, 0x4A,
  0x4A, 0x4A, 0x44, 0x84, 0x3C, 0x86, 0x0C, 0x18, 0x30, 0xA1, 0x42, 0x78,
  0x3C, 0x44, 0x8A, 0x27, 0x88, 0x10, 0x20, 0x80, 0x3C, 0x86, 0x0C, 0x18,
  0x30, 0xA1, 0x42, 0x78, 0x20, 0x60, 0x3C, 0x44, 0x8A, 0x27, 0x89, 0x12,
  0x24, 0x8C, 0x3D, 0x04, 0x08, 0x10, 0x20, 0x82, 0xF0, 0xFC, 0x82, 0x08,
  0x41, 0x04, 0x10, 0x40, 0x42, 0x85, 0x14, 0x28, 0x50, 0xA1, 0x44, 0xF0,
  0x86, 0x18, 0xA2, 0x92, 0x46, 0x10, 0x40, 0x8C, 0x63, 0x29, 0x4A, 0x54,
  0xA5, 0x29, 0x4A, 0x61, 0x10, 0x44, 0x00, 0x33, 0x12, 0x14, 0x08, 0x18,
  0x18, 0x28, 0x44, 0xC4, 0x8E, 0x25, 0x18, 0x61, 0x04, 0x10, 0x40, 0x3E,
  0x08, 0x20, 0x81, 0x04, 0x10, 0x40, 0xF8, 0x39, 0x10, 0x84, 0x21, 0x10,
  0x84, 0x30, 0xA5, 0x55, 0x40, 0x38, 0x42, 0x21, 0x08, 0x44, 0x21, 0x38,
  0x10, 0xA2, 0x91, 0xC4, 0xF8, 0xB0, 0x7C, 0x63, 0x19, 0x4B, 0xC0, 0x20,
  0x82, 0x17, 0x65, 0x14, 0x51, 0x4A, 0xC0, 0x78, 0x88, 0x88, 0xE0, 0x04,
  0x10, 0x5E, 0x8A, 0x28, 0xA4, 0x93, 0xC0, 0x79, 0x9E, 0x88, 0xE0, 0x06,
  0x10, 0x20, 0xE1, 0x02, 0x04, 0x08, 0x10, 0x40, 0x81, 0x0C, 0x00, 0x3D,
  0x14, 0x51, 0x8A, 0x27, 0x82, 0x0B, 0xC0, 0x20, 0x82, 0x17, 0x65, 0x14,
  0x52, 0x8A, 0x20, 0x21, 0x24, 0x94, 0x80, 0x08, 0x04, 0x21, 0x08, 0x44,
  0x21, 0x09, 0x80, 0x20, 0x82, 0x11, 0x49, 0x46, 0x14, 0x92, 0x20, 0x24,
  0xA4, 0x92, 0x90, 0x5B, 0xB2, 0x51, 0x29, 0x14, 0x8C, 0x46, 0x24, 0x5D,
  0x94, 0x51, 0x4A, 0x28, 0x80, 0x74, 0x63, 0x18, 0xCB, 0x80, 0x5D, 0x94,
  0x51, 0x45, 0x2B, 0x20, 0x82, 0x00, 0x7C, 0x63, 0x19, 0x4B, 0xC2, 0x11,
  0x00, 0x5B, 0x10, 0x84, 0x42, 0x00, 0x7A, 0x10, 0x41, 0x0B, 0xC0, 0x4B,
  0xC9, 0x24, 0xC0, 0x8C, 0x63, 0x19, 0x4B, 0xC0, 0x8C, 0xA5, 0x4A, 0x62,
  0x00, 0x93, 0x92, 0xB2, 0xB4, 0xD4, 0x88, 0x88, 0x26, 0x48, 0x60, 0x82,
  0x85, 0x32, 0x00, 0x22, 0x48, 0x91, 0x42, 0x86, 0x08, 0x10, 0x21, 0x80,
  0x78, 0x84, 0x44, 0x43, 0xC0, 0x19, 0x08, 0x42, 0x61, 0x08, 0x42, 0x18,
  0xFF, 0xF8, 0x10, 0x44, 0x21, 0x04, 0x44, 0x21, 0x30, 0xF8,
};

const GFXglyph NotoSans_SemiCondensed_LightItalic13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 3, 9, 3, 0, -9 },
  { 5, 4, 3, 4, 1, -9 },
  { 7, 7, 9, 7, 0, -9 },
  { 15, 6, 11, 6, 0, -10 },
  { 24, 8, 9, 9, 1, -9 },
  { 33, 7, 9, 7, 0, -9 },
  { 41, 2, 3, 2, 1, -9 },
  { 42, 4, 11, 3, 0, -9 },
  { 48, 4, 11, 3, -1, -9 },
  { 54, 5, 5, 6, 1, -10 },
  { 58, 5, 6, 7, 1, -8 },
  { 62, 3, 3, 3, -1, -1 },
  { 64, 3, 1, 4, 0, -4 },
  { 65, 1, 1, 3, 0, -1 },
  { 66, 6, 9, 4, -1, -9 },
  { 73, 5, 9, 6, 1, -9 },
  { 79, 3, 9, 6, 2, -9 },
  { 83, 6, 9, 6, 0, -9 },
  { 90, 6, 9, 6, 0, -9 },
  { 97, 6, 9, 6, 0, -9 },
  { 104, 6, 9, 6, 0, -9 },
  { 111, 5, 9, 6, 1, -9 },
  { 117, 6, 9, 6, 1, -9 },
  { 124, 6, 9, 6, 0, -9 },
  { 131, 6, 9, 6, 0, -9 },
  { 138, 3, 7, 3, 0, -7 },
  { 141, 4, 9, 3, -1, -7 },
  { 146, 5, 6, 7, 1, -8 },
  { 150, 5, 3, 7, 1, -6 },
  { 152, 5, 6, 7, 1, -8 },
  { 156, 4, 9, 5, 1, -9 },
  { 161, 8, 10, 10, 1, -9 },
  { 171, 7, 9, 6, -1, -9 },
  { 179, 7, 9, 7, 0, -9 },
  { 187, 6, 9, 7, 1, -9 },
  { 194, 7, 9, 8, 0, -9 },
  { 202, 6, 9, 6, 0, -9 },
  { 209, 6, 9, 6, 0, -9 },
  { 216, 7, 9, 8, 1, -9 },
  { 224, 8, 9, 8, 0, -9 },
  { 233, 4, 9, 4, 0, -9 },
  { 238, 5, 11, 3, -2, -9 },
  { 245, 7, 9, 6, 0, -9 },
  { 253, 5, 9, 6, 0, -9 },
  { 259, 10, 9, 10, 0, -9 },
  { 271, 8, 9, 8, 0, -9 },
  { 280, 7, 9, 8, 1, -9 },
  { 288, 7, 9, 6, 0, -9 },
  { 296, 7, 11, 8, 1, -9 },
  { 306, 7, 9, 7, 0, -9 },
  { 314, 6, 9, 6, 0, -9 },
  { 321, 6, 9, 6, 1, -9 },
  { 328, 7, 9, 8, 1, -9 },
  { 336, 6, 9, 6, 1, -9 },
  { 343, 10, 9, 10, 1, -9 },
  { 355, 8, 9, 6, -1, -9 },
  { 364, 6, 9, 6, 1, -9 },
  { 371, 7, 9, 6, 0, -9 },
  { 379, 5, 11, 4, 0, -9 },
  { 386, 2, 9, 4, 1, -9 },
  { 389, 5, 11, 4, -1, -9 },
  { 396, 6, 5, 7, 0, -9 },
  { 400, 5, 1, 5, -1, 1 },
  { 401, 2, 2, 3, 2, -10 },
  { 402, 5, 7, 7, 1, -7 },
  { 407, 6, 10, 7, 0, -10 },
  { 415, 4, 7, 5, 1, -7 },
  { 419, 6, 10, 7, 1, -10 },
  { 427, 4, 7, 6, 1, -7 },
  { 431, 7, 13, 3, -2, -10 },
  { 443, 6, 10, 7, 0, -7 },
  { 451, 6, 10, 6, 0, -10 },
  { 459, 3, 9, 3, 0, -9 },
  { 463, 5, 12, 3, -2, -9 },
  { 471, 6, 10, 5, 0, -10 },
  { 479, 3, 10, 3, 0, -10 },
  { 483, 9, 7, 10, 0, -7 },
  { 491, 6, 7, 6, 0, -7 },
  { 497, 5, 7, 6, 1, -7 },
  { 502, 6, 10, 7, 0, -7 },
  { 510, 5, 10, 7, 1, -7 },
  { 517, 5, 7, 4, 0, -7 },
  { 522, 5, 7, 5, 0, -7 },
  { 527, 3, 9, 4, 1, -9 },
  { 531, 5, 7, 7, 1, -7 },
  { 536, 5, 7, 5, 1, -7 },
  { 541, 8, 7, 8, 1, -7 },
  { 548, 7, 7, 5, -1, -7 },
  { 555, 7, 10, 5, -1, -7 },
  { 564, 5, 7, 5, 0, -7 },
  { 569, 5, 11, 4, 0, -9 },
  { 576, 1, 13, 6, 3, -10 },
  { 578, 5, 11, 4, -1, -9 },
  { 585, 5, 1, 7, 1, -5 },
};

const GFXfont NotoSans_SemiCondensed_LightItalic13pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_LightItalic13pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_LightItalic13pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHTITALIC13PT7B_H_
