#ifndef _NOTOSANS_SEMICONDENSED_LIGHTITALIC27PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHTITALIC27PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-LightItalic.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_LightItalic27pt7bBitmaps[] PROGMEM = {
  0x00, 0x08, 0xC6, 0x31, 0x08, 0xC6, 0x21, 0x08, 0xC6, 0x20, 0x00, 0x06,
  0x30, 0x66, 0x89, 0x36, 0x68, 0x91, 0x22, 0x00, 0x03, 0x18, 0x08, 0x40,
  0x21, 0x01, 0x8C, 0x04, 0x21, 0xFF, 0xF7, 0xFF, 0xC2, 0x10, 0x08, 0x40,
  0x21, 0x01, 0x8C, 0x04, 0x20, 0xFF, 0xF0, 0xC6, 0x02, 0x10, 0x08, 0x40,
  0x61, 0x01, 0x0C, 0x04, 0x20, 0x00, 0x00, 0x80, 0x18, 0x01, 0x00, 0xFF,
  0x19, 0x23, 0x10, 0x32, 0x02, 0x20, 0x32, 0x01, 0xA0, 0x1E, 0x00, 0x70,
  0x05, 0x80, 0x4C, 0x04, 0xC0, 0xCC, 0x08, 0xC8, 0x98, 0xFF, 0x03, 0xC0,
  0x10, 0x01, 0x00, 0x10, 0x00, 0x08, 0x02, 0x3E, 0x04, 0x62, 0x0C, 0x42,
  0x08, 0x42, 0x10, 0xC2, 0x30, 0x82, 0x20, 0x86, 0x40, 0x84, 0xCC, 0x84,
  0x92, 0x8D, 0x23, 0xFB, 0x63, 0x22, 0x43, 0x04, 0x43, 0x0C, 0x42, 0x08,
  0xC2, 0x10, 0xC6, 0x30, 0xC4, 0x20, 0x4C, 0x60, 0x78, 0x01, 0x00, 0x1F,
  0x00, 0xC6, 0x02, 0x08, 0x18, 0x20, 0x61, 0x81, 0x84, 0x02, 0x20, 0x0F,
  0x00, 0x38, 0x01, 0xE0, 0x0C, 0x83, 0x43, 0x1B, 0x06, 0x48, 0x1B, 0x20,
  0x38, 0x80, 0x42, 0x03, 0x8C, 0x32, 0x1F, 0x8C, 0x69, 0x69, 0x20, 0x03,
  0x04, 0x0C, 0x18, 0x10, 0x30, 0x20, 0x60, 0x40, 0x40, 0xC0, 0xC0, 0xC0,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xC0, 0xC0, 0x40, 0x40, 0x06, 0x02,
  0x02, 0x03, 0x03, 0x01, 0x01, 0x01, 0x01, 0x01, 0x03, 0x03, 0x03, 0x02,
  0x06, 0x06, 0x04, 0x0C, 0x08, 0x18, 0x30, 0x20, 0xC0, 0x04, 0x01, 0x80,
  0x43, 0x10, 0x74, 0x07, 0xF0, 0xC0, 0xD0, 0x62, 0x10, 0x80, 0x30, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x3F, 0xF8, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x33, 0x26, 0x4C, 0xFC, 0xF0, 0x00, 0x30,
  0x06, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x00, 0x30, 0x02, 0x00,
  0x60, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x00, 0x30, 0x02, 0x00, 0x60, 0x04,
  0x00, 0xC0, 0x00, 0x01, 0x00, 0x7C, 0x0C, 0x61, 0x82, 0x10, 0x33, 0x03,
  0x20, 0x36, 0x03, 0x60, 0x34, 0x02, 0x40, 0x2C, 0x06, 0xC0, 0x6C, 0x06,
  0xC0, 0x4C, 0x0C, 0xC0, 0x84, 0x18, 0x63, 0x03, 0xE0, 0x0C, 0x76, 0xF3,
  0x88, 0x21, 0x86, 0x18, 0x41, 0x0C, 0x30, 0x82, 0x08, 0x61, 0x84, 0x00,
  0x00, 0x80, 0x3F, 0x03, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x08, 0x00, 0x40,
  0x06, 0x00, 0x20, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x01, 0xFF, 0x80, 0x00, 0x80, 0x7F,
  0x06, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x60,
  0x7E, 0x03, 0xE0, 0x01, 0x80, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x06, 0x30, 0x61, 0xFE, 0x00, 0x00, 0x38, 0x03, 0x80, 0x34, 0x01,
  0x60, 0x13, 0x01, 0x90, 0x18, 0x80, 0x8C, 0x08, 0x60, 0xC2, 0x0C, 0x10,
  0xC0, 0x84, 0x0C, 0x7F, 0xF8, 0x02, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x07, 0xF8, 0x20, 0x03, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x60,
  0x02, 0xE0, 0x1F, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x01, 0x80, 0x0C, 0x00, 0xC6, 0x0C, 0x1F, 0xC0, 0x00, 0x60, 0x3F, 0x06,
  0x00, 0xC0, 0x18, 0x01, 0x00, 0x30, 0x02, 0x00, 0x67, 0x87, 0xDC, 0x70,
  0x46, 0x06, 0xC0, 0x6C, 0x06, 0xC0, 0x6C, 0x04, 0xC0, 0xC4, 0x08, 0x63,
  0x83, 0xE0, 0x7F, 0xF0, 0x02, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x18, 0x01,
  0x00, 0x30, 0x02, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x30,
  0x03, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x00, 0x01, 0x00, 0xFE, 0x18, 0x21,
  0x03, 0x10, 0x31, 0x03, 0x10, 0x21, 0x86, 0x08, 0xC0, 0x70, 0x1F, 0x03,
  0x18, 0x60, 0xCC, 0x04, 0x80, 0x48, 0x04, 0x80, 0x4C, 0x0C, 0x61, 0x83,
  0xF0, 0x01, 0x00, 0xFC, 0x18, 0x63, 0x02, 0x20, 0x26, 0x03, 0x60, 0x36,
  0x02, 0x60, 0x26, 0x06, 0x20, 0xE3, 0xF6, 0x0C, 0x40, 0x04, 0x00, 0xC0,
  0x08, 0x01, 0x80, 0x30, 0x86, 0x0F, 0xC0, 0x08, 0xC6, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x33, 0x80, 0x04, 0x30, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x30, 0xC6, 0x18, 0x42, 0x00, 0x00, 0x20, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x30,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x80, 0x18,
  0x01, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x18, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0x60, 0x00, 0x04, 0x0F, 0xE2, 0x18, 0x02, 0x00, 0xC0, 0x20, 0x18,
  0x04, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x08, 0x02, 0x00, 0x00, 0x00,
  0x00, 0x06, 0x03, 0x80, 0x00, 0xFE, 0x00, 0xC0, 0xC0, 0x40, 0x18, 0x20,
  0x03, 0x10, 0x00, 0x4C, 0x1E, 0x12, 0x18, 0xC5, 0x8C, 0x21, 0x42, 0x08,
  0x51, 0x86, 0x1C, 0x41, 0x0F, 0x10, 0x42, 0xC4, 0x30, 0xA1, 0x0C, 0x6C,
  0x65, 0x33, 0x0E, 0x78, 0x40, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x40, 0x0F, 0xF0, 0x00, 0x00, 0x30, 0x01, 0xC0, 0x05, 0x00, 0x34, 0x00,
  0x90, 0x06, 0x40, 0x11, 0x80, 0xC6, 0x02, 0x18, 0x18, 0x60, 0x41, 0x83,
  0xFE, 0x08, 0x08, 0x60, 0x21, 0x00, 0x8C, 0x02, 0x20, 0x09, 0x80, 0x2C,
  0x00, 0xC0, 0x0F, 0xE0, 0xC1, 0x86, 0x06, 0x30, 0x31, 0x01, 0x88, 0x0C,
  0xC0, 0x46, 0x06, 0x3F, 0xC1, 0xFE, 0x08, 0x18, 0xC0, 0x46, 0x03, 0x20,
  0x19, 0x00, 0x88, 0x0C, 0xC0, 0xE6, 0x1E, 0x3F, 0xC0, 0x00, 0xC0, 0x3F,
  0xC3, 0x02, 0x30, 0x03, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x18, 0x00, 0xC0,
  0x02, 0x00, 0x1C, 0x20, 0x7F, 0x00, 0x0F, 0xE0, 0x60, 0xC1, 0x81, 0x86,
  0x03, 0x10, 0x0C, 0x40, 0x33, 0x00, 0xCC, 0x03, 0x30, 0x0C, 0x80, 0x32,
  0x00, 0xD8, 0x02, 0x60, 0x19, 0x00, 0x44, 0x03, 0x10, 0x18, 0xC0, 0xC3,
  0x1E, 0x0F, 0xE0, 0x00, 0x0F, 0xF1, 0x80, 0x18, 0x01, 0x80, 0x10, 0x01,
  0x00, 0x30, 0x03, 0x00, 0x3F, 0xC3, 0xFC, 0x20, 0x06, 0x00, 0x60, 0x04,
  0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x08, 0xFF, 0x00, 0x0F, 0xF1, 0x80,
  0x18, 0x01, 0x80, 0x10, 0x01, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0xFC,
  0x20, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00,
  0x80, 0x00, 0x00, 0x40, 0x1F, 0xF0, 0xE0, 0x46, 0x00, 0x30, 0x00, 0x80,
  0x06, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x1F, 0xA0, 0x7E, 0x80,
  0x12, 0x00, 0x48, 0x03, 0x30, 0x0C, 0xC0, 0x31, 0x80, 0x87, 0x06, 0x07,
  0xF0, 0x08, 0x02, 0x10, 0x0C, 0x60, 0x18, 0xC0, 0x31, 0x00, 0x42, 0x00,
  0x8C, 0x03, 0x18, 0x06, 0x3F, 0xFC, 0x7F, 0xF0, 0x80, 0x23, 0x00, 0xC6,
  0x01, 0x88, 0x02, 0x10, 0x04, 0x20, 0x18, 0xC0, 0x31, 0x80, 0x62, 0x00,
  0x80, 0x0F, 0xC0, 0x80, 0x20, 0x08, 0x06, 0x01, 0x80, 0x40, 0x10, 0x0C,
  0x03, 0x00, 0xC0, 0x20, 0x08, 0x06, 0x01, 0x80, 0x60, 0x10, 0x04, 0x0F,
  0xC0, 0x00, 0x40, 0x10, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x18, 0x06, 0x01,
  0x80, 0x40, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x06, 0x01, 0x80,
  0x40, 0x10, 0x0C, 0x03, 0x0B, 0x83, 0xC0, 0x08, 0x0C, 0x60, 0x61, 0x83,
  0x06, 0x18, 0x10, 0xC0, 0x46, 0x03, 0x30, 0x0D, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0x20, 0x18, 0xC0, 0x61, 0x01, 0x06, 0x04, 0x18, 0x10, 0x20, 0xC0,
  0xC3, 0x03, 0x08, 0x06, 0x00, 0x08, 0x0C, 0x06, 0x03, 0x01, 0x00, 0x80,
  0xC0, 0x60, 0x30, 0x10, 0x08, 0x0C, 0x06, 0x02, 0x01, 0x00, 0x80, 0xC0,
  0x60, 0x7F, 0xC0, 0x0C, 0x00, 0x63, 0x80, 0x1C, 0x70, 0x03, 0x8A, 0x00,
  0xF1, 0x60, 0x34, 0x2C, 0x04, 0x8D, 0x81, 0xB1, 0xB0, 0x26, 0x22, 0x0C,
  0xC4, 0x41, 0x10, 0x88, 0x62, 0x31, 0x08, 0xC6, 0x23, 0x18, 0x86, 0x42,
  0x10, 0xD8, 0x42, 0x1A, 0x18, 0xC1, 0xC3, 0x18, 0x30, 0x62, 0x04, 0x08,
  0x00, 0x0C, 0x03, 0x1C, 0x02, 0x1C, 0x02, 0x16, 0x02, 0x12, 0x06, 0x12,
  0x06, 0x33, 0x04, 0x33, 0x04, 0x21, 0x0C, 0x21, 0x8C, 0x21, 0x8C, 0x60,
  0x88, 0x60, 0xC8, 0x40, 0xD8, 0x40, 0x58, 0x40, 0x70, 0xC0, 0x70, 0xC0,
  0x30, 0x80, 0x30, 0x00, 0xC0, 0x1F, 0xC0, 0xC1, 0x86, 0x03, 0x30, 0x0D,
  0x80, 0x36, 0x00, 0x50, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03,
  0x80, 0x0A, 0x00, 0x68, 0x01, 0xA0, 0x0C, 0xC0, 0x33, 0x01, 0x87, 0x1C,
  0x0F, 0xE0, 0x0F, 0xE0, 0xC3, 0x86, 0x04, 0x30, 0x21, 0x01, 0x88, 0x08,
  0xC0, 0x46, 0x06, 0x30, 0x61, 0x0E, 0x0F, 0xE0, 0xC0, 0x06, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x1F,
  0xC0, 0xC1, 0x86, 0x03, 0x30, 0x0D, 0x80, 0x36, 0x00, 0x50, 0x01, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0A, 0x00, 0x68, 0x01, 0xA0,
  0x0C, 0xC0, 0x33, 0x01, 0x87, 0x1C, 0x0F, 0xE0, 0x03, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x60, 0x00, 0xC0, 0x0F, 0xE0, 0xC3, 0x86, 0x04, 0x30, 0x21,
  0x01, 0x88, 0x08, 0xC0, 0x46, 0x06, 0x30, 0x61, 0xFE, 0x0F, 0xC0, 0xC2,
  0x06, 0x10, 0x30, 0xC1, 0x06, 0x08, 0x10, 0xC0, 0xC6, 0x06, 0x20, 0x10,
  0x00, 0x80, 0x3F, 0xC3, 0x04, 0x30, 0x01, 0x00, 0x08, 0x00, 0x40, 0x03,
  0x00, 0x1C, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x06, 0x30, 0xE1, 0xFE, 0x00, 0xFF, 0xF0, 0x60,
  0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x08, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x10, 0x01, 0x00, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00,
  0x60, 0x00, 0x10, 0x04, 0xC0, 0x13, 0x00, 0xC8, 0x03, 0x20, 0x09, 0x80,
  0x26, 0x01, 0x98, 0x06, 0x40, 0x19, 0x00, 0x4C, 0x01, 0x30, 0x0C, 0xC0,
  0x32, 0x00, 0xC8, 0x02, 0x20, 0x18, 0xC0, 0xC1, 0x86, 0x03, 0xF0, 0x00,
  0x80, 0x38, 0x02, 0x80, 0x68, 0x04, 0x80, 0xC8, 0x08, 0xC1, 0x8C, 0x10,
  0xC3, 0x0C, 0x20, 0xC6, 0x0C, 0x40, 0xCC, 0x04, 0x80, 0x58, 0x05, 0x00,
  0x70, 0x06, 0x00, 0x60, 0x00, 0x80, 0x40, 0x38, 0x0E, 0x06, 0x80, 0xE0,
  0x48, 0x1E, 0x0C, 0x81, 0x60, 0xC8, 0x36, 0x08, 0x82, 0x61, 0x88, 0x26,
  0x10, 0x86, 0x63, 0x08, 0x46, 0x20, 0x8C, 0x66, 0x0C, 0x86, 0x60, 0xD8,
  0x64, 0x0D, 0x06, 0xC0, 0xF0, 0x68, 0x0E, 0x03, 0x80, 0xA0, 0x30, 0x0E,
  0x03, 0x00, 0xC0, 0x20, 0x00, 0x06, 0x03, 0x02, 0x06, 0x02, 0x0C, 0x03,
  0x08, 0x03, 0x18, 0x01, 0x30, 0x01, 0xA0, 0x01, 0xE0, 0x00, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x02, 0x40, 0x06, 0x40, 0x0C, 0x60, 0x08, 0x60, 0x18,
  0x20, 0x30, 0x30, 0x20, 0x30, 0xE0, 0x10, 0xC0, 0x34, 0x06, 0x60, 0x46,
  0x0C, 0x61, 0x82, 0x10, 0x23, 0x03, 0x20, 0x36, 0x01, 0xC0, 0x18, 0x01,
  0x80, 0x10, 0x01, 0x00, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00, 0x60, 0x00,
  0x07, 0xFE, 0x00, 0x18, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x0C, 0x00,
  0x10, 0x00, 0x60, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x01, 0x00, 0x06, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x03, 0xFF, 0x80,
  0x0F, 0xC3, 0x00, 0xC0, 0x20, 0x08, 0x06, 0x01, 0x80, 0x40, 0x10, 0x04,
  0x03, 0x00, 0xC0, 0x20, 0x08, 0x06, 0x01, 0x80, 0x60, 0x10, 0x04, 0x03,
  0x00, 0xC0, 0x20, 0x0F, 0x80, 0x88, 0xCC, 0x44, 0x44, 0x46, 0x62, 0x22,
  0x23, 0x31, 0x10, 0x07, 0xC0, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x18,
  0x06, 0x01, 0x00, 0x40, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x18, 0x06,
  0x01, 0x00, 0x40, 0x10, 0x0C, 0x03, 0x0F, 0x80, 0x03, 0x00, 0x70, 0x05,
  0x80, 0xC8, 0x08, 0x81, 0x0C, 0x30, 0x42, 0x04, 0x60, 0x64, 0x02, 0xC0,
  0x30, 0xFF, 0x80, 0xD9, 0x12, 0x02, 0x00, 0xF9, 0x18, 0x73, 0x06, 0x60,
  0x66, 0x06, 0x40, 0x6C, 0x06, 0xC0, 0x4C, 0x0C, 0xC0, 0xCC, 0x1C, 0xC1,
  0x86, 0x28, 0x7C, 0x80, 0x08, 0x00, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x00, 0x10, 0x83, 0x7E, 0x3C, 0x63, 0x82, 0x30, 0x32, 0x03, 0x60, 0x26,
  0x02, 0x40, 0x24, 0x06, 0xC0, 0x6C, 0x0C, 0xC0, 0x8A, 0x38, 0x9F, 0x00,
  0x03, 0x83, 0xF1, 0x80, 0xC0, 0x60, 0x18, 0x04, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x18, 0x43, 0xF0, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x30, 0x01, 0x80, 0x08, 0x08, 0x41, 0xF2, 0x18, 0x71, 0x83, 0x98,
  0x08, 0xC0, 0x44, 0x06, 0x60, 0x33, 0x01, 0x18, 0x08, 0xC0, 0xC6, 0x0E,
  0x30, 0x70, 0xC5, 0x07, 0xC8, 0x00, 0x03, 0x03, 0xF1, 0x84, 0xC1, 0x60,
  0x58, 0x34, 0x1B, 0xF8, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x40, 0x18, 0x43,
  0xF0, 0x00, 0x1C, 0x01, 0xE0, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00,
  0x10, 0x03, 0xF8, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00,
  0x08, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00,
  0x00, 0x01, 0x00, 0x3E, 0x43, 0x0E, 0x30, 0x73, 0x01, 0x18, 0x08, 0x80,
  0xCC, 0x06, 0x60, 0x23, 0x01, 0x18, 0x18, 0xC1, 0xC6, 0x0E, 0x18, 0xA0,
  0xF9, 0x00, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x61, 0x06, 0x0F, 0xE0, 0x00,
  0x08, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20, 0x04, 0x21, 0xBF, 0x38,
  0x66, 0x04, 0xC0, 0x90, 0x36, 0x06, 0xC0, 0xD0, 0x12, 0x02, 0xC0, 0xD8,
  0x1B, 0x03, 0x40, 0x48, 0x18, 0x08, 0xC6, 0x00, 0x00, 0xC6, 0x21, 0x08,
  0xC6, 0x21, 0x18, 0xC6, 0x21, 0x00, 0x00, 0x40, 0x30, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x18, 0x06, 0x01, 0x80, 0x40, 0x10, 0x0C, 0x03, 0x00, 0x80,
  0x20, 0x08, 0x06, 0x01, 0x80, 0x40, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x20,
  0x18, 0x3C, 0x00, 0x08, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20, 0x04,
  0x01, 0x83, 0x30, 0x84, 0x30, 0x8C, 0x13, 0x06, 0xC0, 0xF8, 0x1D, 0x03,
  0x30, 0xC6, 0x18, 0x43, 0x0C, 0x41, 0x88, 0x18, 0x08, 0x46, 0x31, 0x88,
  0x46, 0x31, 0x08, 0x46, 0x31, 0x08, 0xC6, 0x31, 0x08, 0x00, 0x01, 0x83,
  0x0D, 0xF3, 0xF3, 0x85, 0x8C, 0xC1, 0xC1, 0x30, 0x60, 0x48, 0x18, 0x36,
  0x04, 0x0D, 0x81, 0x03, 0x40, 0xC0, 0x90, 0x30, 0x2C, 0x08, 0x1B, 0x02,
  0x06, 0xC1, 0x81, 0x20, 0x60, 0x48, 0x18, 0x30, 0x01, 0x86, 0xFC, 0xE1,
  0x98, 0x13, 0x02, 0x40, 0xD8, 0x1B, 0x03, 0x40, 0x48, 0x0B, 0x03, 0x60,
  0x6C, 0x0D, 0x01, 0x20, 0x60, 0x03, 0x01, 0xF8, 0x61, 0x98, 0x36, 0x02,
  0xC0, 0x50, 0x0E, 0x01, 0xC0, 0x78, 0x0F, 0x01, 0x60, 0x6C, 0x08, 0xC7,
  0x0F, 0x80, 0x00, 0x20, 0x37, 0xE0, 0xF1, 0x83, 0x82, 0x0C, 0x0C, 0x20,
  0x31, 0x80, 0xC6, 0x02, 0x10, 0x08, 0x40, 0x63, 0x01, 0x8C, 0x0C, 0x30,
  0x30, 0xA1, 0x82, 0x7C, 0x18, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x10,
  0x00, 0xC0, 0x00, 0x02, 0x00, 0xF9, 0x18, 0x73, 0x07, 0x60, 0x26, 0x02,
  0x40, 0x6C, 0x06, 0xC0, 0x4C, 0x04, 0xC0, 0xCC, 0x1C, 0xC1, 0xC6, 0x28,
  0x7C, 0x80, 0x08, 0x01, 0x80, 0x18, 0x01, 0x00, 0x10, 0x03, 0x00, 0x01,
  0x9B, 0xCB, 0x06, 0x03, 0x01, 0x01, 0x80, 0xC0, 0x40, 0x20, 0x30, 0x18,
  0x0C, 0x04, 0x02, 0x00, 0x06, 0x07, 0xF3, 0x04, 0x80, 0x20, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x04, 0x01, 0x20, 0xCF, 0xE0, 0x08,
  0x20, 0x40, 0x8F, 0xE6, 0x08, 0x10, 0x60, 0xC1, 0x82, 0x04, 0x18, 0x30,
  0x60, 0xC0, 0xF0, 0x30, 0x33, 0x02, 0x20, 0x22, 0x02, 0x60, 0x66, 0x06,
  0x40, 0x44, 0x04, 0x40, 0xCC, 0x0C, 0xC1, 0xCC, 0x18, 0xC6, 0x87, 0xC8,
  0xC0, 0x68, 0x19, 0x02, 0x20, 0xC4, 0x10, 0x86, 0x10, 0x83, 0x30, 0x64,
  0x0D, 0x81, 0xA0, 0x3C, 0x03, 0x00, 0x60, 0x00, 0x83, 0x03, 0x83, 0x06,
  0x83, 0x86, 0x85, 0x84, 0x85, 0x8C, 0x8D, 0x88, 0x89, 0x98, 0x99, 0x90,
  0x90, 0xB0, 0xB0, 0xA0, 0xA0, 0xA0, 0xE0, 0xE0, 0xC0, 0xC0, 0xC0, 0xC0,
  0x18, 0x38, 0x41, 0x03, 0x18, 0x09, 0x80, 0x58, 0x03, 0x80, 0x0C, 0x00,
  0xE0, 0x0D, 0x00, 0xC8, 0x04, 0x60, 0x61, 0x06, 0x08, 0x60, 0x60, 0x04,
  0x06, 0x08, 0x18, 0x10, 0x30, 0x20, 0xC0, 0x41, 0x00, 0xC6, 0x01, 0x88,
  0x03, 0x30, 0x02, 0x40, 0x05, 0x80, 0x0A, 0x00, 0x1C, 0x00, 0x30, 0x00,
  0x60, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x60, 0x07, 0x80,
  0x04, 0x00, 0x00, 0x0F, 0xE0, 0x0C, 0x03, 0x00, 0xC0, 0x10, 0x06, 0x01,
  0x80, 0x20, 0x0C, 0x03, 0x00, 0xC0, 0x10, 0x06, 0x01, 0xFF, 0x00, 0x03,
  0x83, 0x01, 0x01, 0x80, 0xC0, 0x40, 0x20, 0x30, 0x18, 0x08, 0x0C, 0x18,
  0x06, 0x01, 0x00, 0x80, 0x40, 0x20, 0x30, 0x18, 0x08, 0x04, 0x03, 0x00,
  0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x01, 0x80, 0x40, 0x20, 0x30, 0x18,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x30, 0x60, 0x20, 0x30, 0x18, 0x08,
  0x04, 0x06, 0x03, 0x01, 0x01, 0x83, 0x80, 0x78, 0x39, 0xCE, 0x0F, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_LightItalic27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 5, 19, 6, 1, -19 },
  { 13, 7, 7, 9, 3, -19 },
  { 20, 14, 19, 15, 1, -19 },
  { 54, 12, 23, 13, 1, -21 },
  { 89, 16, 20, 19, 2, -20 },
  { 129, 14, 20, 15, 1, -20 },
  { 164, 3, 7, 5, 3, -19 },
  { 167, 8, 23, 7, 1, -19 },
  { 190, 8, 23, 7, -2, -19 },
  { 213, 10, 11, 13, 3, -21 },
  { 227, 11, 13, 14, 2, -16 },
  { 245, 4, 6, 6, -1, -3 },
  { 248, 6, 1, 8, 1, -8 },
  { 249, 2, 2, 6, 1, -2 },
  { 250, 12, 19, 9, -1, -19 },
  { 279, 12, 20, 13, 1, -20 },
  { 309, 6, 19, 13, 4, -19 },
  { 324, 13, 20, 13, 0, -20 },
  { 357, 13, 20, 13, 0, -20 },
  { 390, 13, 19, 13, 0, -19 },
  { 421, 13, 19, 13, 0, -19 },
  { 452, 12, 20, 13, 1, -20 },
  { 482, 12, 19, 13, 2, -19 },
  { 511, 12, 20, 13, 1, -20 },
  { 541, 12, 20, 13, 1, -20 },
  { 571, 5, 15, 6, 0, -15 },
  { 581, 6, 18, 6, -1, -15 },
  { 595, 11, 12, 14, 2, -16 },
  { 612, 11, 7, 14, 2, -13 },
  { 622, 11, 12, 14, 2, -16 },
  { 639, 10, 20, 10, 1, -20 },
  { 664, 18, 21, 20, 1, -19 },
  { 712, 14, 19, 13, -2, -19 },
  { 746, 13, 19, 14, 1, -19 },
  { 777, 13, 20, 14, 2, -20 },
  { 810, 14, 19, 16, 1, -19 },
  { 844, 12, 19, 12, 1, -19 },
  { 873, 12, 19, 12, 1, -19 },
  { 902, 14, 20, 16, 2, -20 },
  { 937, 15, 19, 16, 1, -19 },
  { 973, 10, 19, 7, -1, -19 },
  { 997, 10, 24, 6, -4, -19 },
  { 1027, 14, 19, 13, 1, -19 },
  { 1061, 9, 19, 11, 1, -19 },
  { 1083, 19, 19, 20, 1, -19 },
  { 1129, 16, 19, 17, 1, -19 },
  { 1167, 14, 20, 17, 2, -20 },
  { 1202, 13, 19, 13, 1, -19 },
  { 1233, 14, 25, 17, 2, -20 },
  { 1277, 13, 19, 14, 1, -19 },
  { 1308, 13, 20, 12, 0, -20 },
  { 1341, 12, 19, 12, 2, -19 },
  { 1370, 14, 19, 16, 2, -19 },
  { 1404, 12, 19, 13, 3, -19 },
  { 1433, 20, 19, 21, 3, -19 },
  { 1481, 16, 19, 12, -2, -19 },
  { 1519, 12, 19, 12, 2, -19 },
  { 1548, 15, 19, 12, -1, -19 },
  { 1584, 10, 23, 8, 0, -19 },
  { 1613, 4, 19, 9, 3, -19 },
  { 1623, 10, 23, 8, -2, -19 },
  { 1652, 12, 11, 14, 1, -19 },
  { 1669, 9, 1, 9, -2, 3 },
  { 1671, 3, 5, 7, 4, -21 },
  { 1673, 12, 15, 14, 1, -15 },
  { 1696, 12, 21, 14, 1, -21 },
  { 1728, 10, 15, 11, 1, -15 },
  { 1747, 13, 21, 14, 1, -21 },
  { 1782, 10, 15, 12, 1, -15 },
  { 1801, 14, 27, 7, -3, -21 },
  { 1849, 13, 21, 14, 0, -15 },
  { 1884, 11, 21, 13, 1, -21 },
  { 1913, 5, 20, 6, 1, -20 },
  { 1926, 10, 26, 6, -4, -20 },
  { 1959, 11, 21, 11, 1, -21 },
  { 1988, 5, 21, 6, 1, -21 },
  { 2002, 18, 15, 20, 1, -15 },
  { 2036, 11, 15, 13, 1, -15 },
  { 2057, 11, 15, 13, 1, -15 },
  { 2078, 14, 21, 14, -1, -15 },
  { 2115, 12, 21, 14, 1, -15 },
  { 2147, 9, 15, 9, 1, -15 },
  { 2164, 10, 15, 10, 0, -15 },
  { 2183, 7, 18, 8, 1, -18 },
  { 2199, 12, 14, 14, 1, -14 },
  { 2220, 11, 14, 11, 1, -14 },
  { 2240, 16, 14, 17, 2, -14 },
  { 2268, 13, 14, 11, -1, -14 },
  { 2291, 15, 21, 11, -3, -14 },
  { 2331, 11, 14, 10, -1, -14 },
  { 2351, 9, 23, 9, 1, -19 },
  { 2377, 1, 28, 13, 6, -21 },
  { 2381, 9, 23, 9, -1, -19 },
  { 2407, 11, 3, 14, 2, -11 },
};

const GFXfont NotoSans_SemiCondensed_LightItalic27pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_LightItalic27pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_LightItalic27pt7bGlyphs,
  0x20, 0x7E, 37
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHTITALIC27PT7B_H_
