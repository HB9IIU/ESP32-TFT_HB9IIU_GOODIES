#ifndef _NOTOSANS_SEMICONDENSED_LIGHTITALIC61PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHTITALIC61PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-LightItalic.ttf
// Size: 61pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_LightItalic61pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x78,
  0x03, 0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x20, 0x00, 0x1E, 0x0F, 0x1C, 0x0E,
  0x1C, 0x0E, 0x1C, 0x0E, 0x3C, 0x1E, 0x38, 0x1C, 0x38, 0x1C, 0x38, 0x1C,
  0x38, 0x1C, 0x30, 0x18, 0x70, 0x38, 0x70, 0x38, 0x70, 0x38, 0x60, 0x30,
  0x60, 0x30, 0xE0, 0x70, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x60, 0x0E,
  0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x1C, 0x03,
  0x80, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0xE0, 0x00, 0x03, 0x00, 0x70, 0x00, 0x03, 0x80, 0x30, 0x00, 0x01, 0xC0,
  0x38, 0x00, 0x00, 0xC0, 0x1C, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x7F, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x1C,
  0x03, 0x80, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x60, 0x00, 0x03, 0x80, 0x70, 0x00, 0x01, 0x80, 0x38, 0x00, 0x01,
  0xC0, 0x1C, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00,
  0x70, 0x07, 0x00, 0x00, 0x38, 0x03, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x0F,
  0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xE0,
  0x03, 0x80, 0x70, 0x00, 0x03, 0x80, 0x38, 0x00, 0x01, 0xC0, 0x18, 0x00,
  0x00, 0xE0, 0x1C, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x70, 0x06, 0x00,
  0x00, 0x38, 0x07, 0x00, 0x00, 0x18, 0x03, 0x80, 0x00, 0x1C, 0x01, 0xC0,
  0x00, 0x0E, 0x01, 0xC0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x01, 0xF0, 0xC3,
  0xC0, 0x7C, 0x38, 0x08, 0x0F, 0x07, 0x00, 0x03, 0xC0, 0xC0, 0x00, 0x70,
  0x18, 0x00, 0x0E, 0x03, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x38, 0x1C, 0x00,
  0x07, 0x03, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x1E, 0x0C, 0x00, 0x01, 0xE3,
  0x80, 0x00, 0x3E, 0x70, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x37,
  0xC0, 0x00, 0x06, 0x3C, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x38, 0x38, 0x00,
  0x06, 0x07, 0x00, 0x00, 0xC0, 0xF0, 0x00, 0x18, 0x1E, 0x00, 0x07, 0x03,
  0xC0, 0x00, 0xE0, 0x70, 0x00, 0x18, 0x0E, 0x00, 0x03, 0x03, 0xC0, 0x00,
  0xE0, 0xF0, 0x20, 0x1C, 0x3E, 0x07, 0x83, 0x9F, 0x80, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xC0,
  0x3F, 0xE0, 0x00, 0x38, 0x07, 0xFF, 0x00, 0x03, 0x80, 0x70, 0x70, 0x00,
  0x70, 0x0E, 0x03, 0x80, 0x0E, 0x01, 0xE0, 0x38, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x1C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x38, 0x07, 0x00, 0x78, 0x03, 0x80, 0xE0, 0x07, 0x00, 0x38, 0x0E,
  0x00, 0x70, 0x07, 0x01, 0xC0, 0x07, 0x00, 0x70, 0x38, 0x00, 0x70, 0x07,
  0x03, 0x80, 0x06, 0x00, 0x70, 0x70, 0x00, 0xE0, 0x06, 0x0E, 0x00, 0x0E,
  0x00, 0xE0, 0xE0, 0x60, 0xE0, 0x0E, 0x1C, 0x3F, 0xCE, 0x01, 0xC3, 0x87,
  0xFE, 0xE0, 0x1C, 0x38, 0xF0, 0xEE, 0x03, 0xC7, 0x1E, 0x07, 0x70, 0x38,
  0xF1, 0xC0, 0x77, 0x07, 0x0E, 0x38, 0x07, 0x7F, 0xF1, 0xC3, 0x80, 0x73,
  0xFE, 0x3C, 0x38, 0x07, 0x1F, 0x83, 0x87, 0x00, 0x70, 0x00, 0x70, 0x70,
  0x07, 0x00, 0x0F, 0x07, 0x00, 0x70, 0x00, 0xE0, 0xE0, 0x07, 0x00, 0x1C,
  0x0E, 0x00, 0x70, 0x01, 0xC0, 0xE0, 0x0E, 0x00, 0x38, 0x0E, 0x00, 0xE0,
  0x07, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x0C, 0x00, 0xE0, 0x0E, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80,
  0x0C, 0x03, 0x80, 0x70, 0x00, 0xE0, 0x78, 0x07, 0x00, 0x0E, 0x07, 0x00,
  0xE0, 0x00, 0xF1, 0xE0, 0x1C, 0x00, 0x07, 0xFC, 0x03, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1C,
  0x03, 0xC0, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x78,
  0x01, 0xC0, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x70,
  0x01, 0xC0, 0x00, 0x70, 0x03, 0xC0, 0x00, 0x70, 0x07, 0x80, 0x00, 0x70,
  0x07, 0x80, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x38,
  0x7C, 0x00, 0x00, 0x3C, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xE3, 0x80, 0x00, 0x07, 0xC3, 0xC0, 0x0F, 0x0F, 0x81,
  0xC0, 0x0E, 0x1E, 0x01, 0xE0, 0x1E, 0x1C, 0x00, 0xF0, 0x1C, 0x3C, 0x00,
  0xF0, 0x3C, 0x78, 0x00, 0x78, 0x38, 0x78, 0x00, 0x38, 0x78, 0x70, 0x00,
  0x3C, 0x70, 0x70, 0x00, 0x1C, 0xF0, 0xF0, 0x00, 0x1F, 0xE0, 0xF0, 0x00,
  0x0F, 0xC0, 0xF0, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x0F, 0x80, 0x70, 0x00,
  0x1F, 0x80, 0x78, 0x00, 0x3F, 0xC0, 0x78, 0x00, 0x79, 0xC0, 0x3C, 0x01,
  0xF1, 0xE0, 0x3F, 0x8F, 0xE0, 0xF0, 0x1F, 0xFF, 0x80, 0xF0, 0x07, 0xFF,
  0x00, 0x78, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x3C, 0x70, 0xE3, 0xC7, 0x8E,
  0x1C, 0x38, 0x71, 0xC3, 0x87, 0x0C, 0x18, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03,
  0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00,
  0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07,
  0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x08, 0x03, 0x80, 0x3C, 0x06, 0x00, 0x7E, 0x0C, 0x00, 0x7E,
  0x38, 0x00, 0x3F, 0x60, 0x1C, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x07,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF7, 0x00, 0x03, 0xCE, 0x00, 0x0F, 0x0E,
  0x00, 0x3C, 0x1C, 0x00, 0xF0, 0x1C, 0x03, 0xC0, 0x38, 0x01, 0x00, 0x78,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0xC0, 0xF0, 0x38, 0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x38,
  0x1E, 0x07, 0x03, 0xC0, 0xE0, 0x70, 0x1C, 0x0E, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7B, 0xFF, 0xF7, 0x90, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFF, 0x00,
  0x03, 0xFF, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x01,
  0xE0, 0x3C, 0x00, 0x78, 0x0F, 0x00, 0x0E, 0x07, 0x80, 0x03, 0x81, 0xC0,
  0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x38, 0x00, 0x0F, 0x1E, 0x00, 0x03, 0xC7,
  0x80, 0x00, 0xF1, 0xC0, 0x00, 0x3C, 0xF0, 0x00, 0x0F, 0x3C, 0x00, 0x03,
  0x8E, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x39, 0xE0, 0x00, 0x0E, 0x78, 0x00,
  0x07, 0x9C, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x1C, 0xF0,
  0x00, 0x07, 0x3C, 0x00, 0x03, 0xCF, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x3C,
  0xE0, 0x00, 0x0E, 0x38, 0x00, 0x07, 0x8E, 0x00, 0x01, 0xE3, 0x80, 0x00,
  0x70, 0xE0, 0x00, 0x3C, 0x38, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x83, 0x80,
  0x01, 0xE0, 0xF0, 0x00, 0xF0, 0x3C, 0x00, 0x38, 0x07, 0x00, 0x1E, 0x01,
  0xE0, 0x0F, 0x00, 0x3C, 0x07, 0x80, 0x0F, 0xEF, 0xC0, 0x01, 0xFF, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x1E,
  0x00, 0x3E, 0x00, 0xFE, 0x01, 0xFE, 0x07, 0xDC, 0x0F, 0x9C, 0x1F, 0x1C,
  0x7C, 0x3C, 0xF8, 0x3C, 0x60, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x0F,
  0xE0, 0x3E, 0x00, 0x70, 0x01, 0xE0, 0x06, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xF8, 0x07,
  0xC0, 0x0F, 0x00, 0x1F, 0x00, 0x20, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x10, 0x00, 0x0F, 0x80, 0xF0,
  0x00, 0xF8, 0x07, 0xF8, 0x7F, 0x80, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x01, 0xCE, 0x00, 0x00,
  0x39, 0xE0, 0x00, 0x07, 0x1C, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x0E, 0x1C,
  0x00, 0x01, 0xC3, 0xC0, 0x00, 0x38, 0x3C, 0x00, 0x07, 0x83, 0x80, 0x00,
  0xF0, 0x38, 0x00, 0x0E, 0x03, 0x80, 0x01, 0xC0, 0x78, 0x00, 0x38, 0x07,
  0x00, 0x07, 0x80, 0x70, 0x00, 0xF0, 0x07, 0x00, 0x0E, 0x00, 0xF0, 0x01,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x0E, 0x00, 0x70, 0x00,
  0xE0, 0x0E, 0x00, 0x1E, 0x01, 0xC0, 0x01, 0xE0, 0x3C, 0x00, 0x1C, 0x07,
  0x80, 0x01, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x20, 0x07, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x08, 0x00, 0x0F, 0x80,
  0xE0, 0x03, 0xF0, 0x0F, 0xE3, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x7F,
  0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xC0, 0x20, 0x03, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x83, 0xF8, 0x00, 0xF1, 0xFF, 0xC0, 0x1C, 0xFF,
  0xFC, 0x03, 0xBC, 0x07, 0xC0, 0xFE, 0x00, 0x78, 0x1D, 0x80, 0x07, 0x83,
  0xE0, 0x00, 0x70, 0x78, 0x00, 0x0E, 0x0F, 0x00, 0x01, 0xE3, 0xC0, 0x00,
  0x3C, 0x78, 0x00, 0x07, 0x8F, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x1C, 0x3C,
  0x00, 0x03, 0x87, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x1E, 0x1C, 0x00, 0x03,
  0xC3, 0x80, 0x00, 0x70, 0x78, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0x80, 0xE0,
  0x00, 0xF0, 0x1E, 0x00, 0x3C, 0x03, 0xC0, 0x0F, 0x80, 0x3C, 0x03, 0xE0,
  0x03, 0xF3, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00,
  0x3E, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x03, 0xC0, 0x03, 0xC0, 0x70, 0x00,
  0x78, 0x1E, 0x00, 0x07, 0x03, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x1C, 0x0E,
  0x00, 0x03, 0x81, 0xC0, 0x00, 0xF0, 0x38, 0x00, 0x1E, 0x07, 0x80, 0x03,
  0x80, 0xF0, 0x00, 0xF0, 0x0E, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x1E,
  0x07, 0xC0, 0x01, 0xE1, 0xF0, 0x00, 0x1E, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0x8F, 0x00, 0x07, 0xC0,
  0xF0, 0x03, 0xE0, 0x0F, 0x00, 0xF8, 0x00, 0xF0, 0x1E, 0x00, 0x0F, 0x07,
  0x80, 0x01, 0xE1, 0xE0, 0x00, 0x1C, 0x3C, 0x00, 0x03, 0x87, 0x00, 0x00,
  0x78, 0xE0, 0x00, 0x0F, 0x1C, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x38, 0x70,
  0x00, 0x07, 0x0E, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x0F,
  0x03, 0xC0, 0x03, 0xC0, 0x7C, 0x00, 0xF8, 0x07, 0xF1, 0xFE, 0x00, 0x7F,
  0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x06, 0x80, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xE0, 0x7C, 0x01, 0xE0,
  0x07, 0x80, 0xF0, 0x01, 0xE0, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x07,
  0x00, 0x01, 0xC3, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x07,
  0x1E, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x1C, 0x70, 0x00,
  0x07, 0x1C, 0x00, 0x03, 0xC7, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x3C, 0x70,
  0x00, 0x1F, 0x1E, 0x00, 0x0F, 0x87, 0x80, 0x03, 0xE0, 0xF0, 0x01, 0xB8,
  0x3E, 0x01, 0xFE, 0x07, 0xE3, 0xF7, 0x80, 0xFF, 0xF1, 0xC0, 0x1F, 0xF8,
  0x70, 0x00, 0x40, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x3E, 0x7F,
  0x80, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x7C, 0x0F, 0x81, 0xF0, 0x3C, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x04, 0x00, 0x00,
  0x1C, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0E,
  0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x3F, 0xFE, 0x07, 0xFF, 0xF8, 0x1E, 0x07, 0xC0, 0x80, 0x0F,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78,
  0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x00, 0x0E,
  0x03, 0xC0, 0x00, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x00, 0x07, 0x07, 0x00,
  0x00, 0x00, 0x07, 0x0E, 0x00, 0x1F, 0xF8, 0x07, 0x0E, 0x00, 0x7F, 0xFC,
  0x07, 0x1C, 0x00, 0xF8, 0x3C, 0x07, 0x1C, 0x01, 0xE0, 0x1C, 0x07, 0x38,
  0x03, 0xC0, 0x38, 0x07, 0x38, 0x07, 0x80, 0x38, 0x07, 0x38, 0x07, 0x00,
  0x38, 0x07, 0x70, 0x0E, 0x00, 0x30, 0x07, 0x70, 0x0E, 0x00, 0x70, 0x07,
  0x70, 0x1C, 0x00, 0x70, 0x07, 0xE0, 0x1C, 0x00, 0x70, 0x07, 0xE0, 0x1C,
  0x00, 0xE0, 0x06, 0xE0, 0x38, 0x00, 0xE0, 0x0E, 0xE0, 0x38, 0x00, 0xE0,
  0x0E, 0xE0, 0x38, 0x00, 0xE0, 0x0E, 0xE0, 0x38, 0x01, 0xC0, 0x1C, 0xE0,
  0x38, 0x01, 0xC0, 0x1C, 0xE0, 0x38, 0x03, 0xC0, 0x38, 0xE0, 0x38, 0x03,
  0xC0, 0x38, 0xE0, 0x38, 0x06, 0xC0, 0x70, 0xE0, 0x3C, 0x0E, 0xE0, 0xE0,
  0xE0, 0x1E, 0x3C, 0xF3, 0xE0, 0xE0, 0x0F, 0xF8, 0x7F, 0x80, 0xE0, 0x07,
  0xE0, 0x3F, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xE0, 0x00,
  0x03, 0xFC, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3B, 0x80, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x3C,
  0xE0, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x1C, 0x38,
  0x00, 0x00, 0xF0, 0xE0, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x1E, 0x0F, 0x00,
  0x00, 0x70, 0x1C, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x0E, 0x01, 0xC0, 0x00,
  0x78, 0x07, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x38,
  0x01, 0xC0, 0x01, 0xE0, 0x07, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xE0, 0x01, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xC0, 0x00, 0xE0, 0x1E, 0x00, 0x03, 0x80,
  0x78, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x38, 0x0E, 0x00, 0x00, 0xE0, 0x78,
  0x00, 0x03, 0x81, 0xC0, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x3C, 0x38, 0x00,
  0x00, 0xF1, 0xE0, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00,
  0x1C, 0xE0, 0x00, 0x00, 0x77, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0xF0, 0x01, 0xF0, 0x03, 0x80, 0x01, 0xE0, 0x0E,
  0x00, 0x07, 0x80, 0x78, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x3C, 0x07, 0x80,
  0x00, 0xF0, 0x1C, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0x38, 0x0F, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x3C,
  0x03, 0x80, 0x00, 0xF0, 0x1E, 0x00, 0x07, 0x80, 0x78, 0x00, 0x7C, 0x01,
  0xC0, 0x1F, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x0E, 0x00, 0x07, 0x80, 0x38, 0x00,
  0x0F, 0x01, 0xE0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x70, 0x1E, 0x00, 0x01,
  0xC0, 0x70, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x70,
  0x3C, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x3C, 0x0E,
  0x00, 0x00, 0xF0, 0x78, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x3E, 0x07, 0x00,
  0x01, 0xF0, 0x1C, 0x00, 0x0F, 0x80, 0x70, 0x01, 0xFC, 0x03, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xF0, 0x0E,
  0x00, 0x7E, 0x00, 0x08, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x80, 0x0C, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0xF0, 0x03, 0xF0, 0x00, 0xE0, 0x00, 0xF8, 0x00, 0xE0,
  0x00, 0x7C, 0x01, 0xE0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x1E, 0x01, 0xE0,
  0x00, 0x1E, 0x01, 0xC0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x0F, 0x03, 0x80,
  0x00, 0x0F, 0x03, 0x80, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0x0F, 0x07, 0x00, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x0F, 0x07, 0x00,
  0x00, 0x0F, 0x0F, 0x00, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x0E, 0x0E, 0x00,
  0x00, 0x1E, 0x0E, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x1E, 0x1E, 0x00,
  0x00, 0x3C, 0x1E, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x38, 0x1C, 0x00,
  0x00, 0x78, 0x3C, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x00, 0xF0, 0x38, 0x00,
  0x01, 0xE0, 0x38, 0x00, 0x03, 0xE0, 0x38, 0x00, 0x07, 0xC0, 0x78, 0x00,
  0x0F, 0x80, 0x78, 0x00, 0x1F, 0x00, 0x70, 0x00, 0x3E, 0x00, 0x70, 0x00,
  0xFC, 0x00, 0xF0, 0x07, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xF0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFE, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0x03, 0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x70, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x01, 0xFF,
  0xF1, 0xE0, 0x00, 0xFF, 0xF0, 0xF0, 0x00, 0x7F, 0xF8, 0x70, 0x00, 0x00,
  0x1C, 0x38, 0x00, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0x0F, 0x0E, 0x00, 0x00,
  0x07, 0x07, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x00, 0x70, 0x3C, 0x00,
  0x00, 0x38, 0x0F, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x1E, 0x03, 0xE0,
  0x00, 0x0E, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x3E, 0x00, 0x03, 0x80, 0x1F,
  0x80, 0x07, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x0E, 0x00, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x78, 0x00,
  0x00, 0xE0, 0x0F, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x38,
  0x00, 0x00, 0xF0, 0x07, 0x00, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x03, 0x80,
  0x3C, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x03,
  0xC0, 0x3C, 0x00, 0x00, 0x70, 0x07, 0x80, 0x00, 0x0E, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x1C, 0x00, 0x00, 0x78, 0x03, 0x80, 0x00, 0x0F, 0x00, 0xF0,
  0x00, 0x01, 0xC0, 0x1E, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0x78, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x3C, 0x01, 0xC0, 0x00,
  0x07, 0x80, 0x38, 0x00, 0x00, 0xE0, 0x0F, 0x00, 0x00, 0x1C, 0x01, 0xE0,
  0x00, 0x03, 0x80, 0x38, 0x00, 0x00, 0xF0, 0x07, 0x00, 0x00, 0x1E, 0x01,
  0xE0, 0x00, 0x03, 0x80, 0x3C, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0xE0, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00,
  0x0E, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x78, 0x03, 0x80,
  0x00, 0x0F, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x38, 0x03,
  0xC0, 0x00, 0x07, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7F, 0xF8,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0xFC, 0x00, 0x3F,
  0xFC, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x08, 0x3E, 0x00, 0x07,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x80, 0x38, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x07, 0x80, 0x1E, 0x00,
  0x07, 0x80, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x00, 0x07, 0x80, 0x03, 0x80,
  0x07, 0x80, 0x03, 0xC0, 0x07, 0x80, 0x01, 0xE0, 0x07, 0x80, 0x00, 0xF0,
  0x07, 0x80, 0x00, 0x70, 0x07, 0x80, 0x00, 0x38, 0x07, 0xC0, 0x00, 0x3C,
  0x07, 0xC0, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x0E, 0x07, 0xC0, 0x00, 0x07,
  0x07, 0xC0, 0x00, 0x03, 0x87, 0xC0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x01,
  0xE3, 0xC0, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x00, 0x73, 0xE0, 0x00, 0x00,
  0x3B, 0xF8, 0x00, 0x00, 0x3F, 0xDC, 0x00, 0x00, 0x1F, 0x8F, 0x00, 0x00,
  0x0F, 0x87, 0x80, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x03, 0xC0, 0x78, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0xE0, 0x0F, 0x00,
  0x00, 0x70, 0x07, 0x80, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0xF0,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xC0, 0x00,
  0xF0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFE, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x00, 0xEE, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x01, 0xDE, 0x01, 0xCE, 0x00,
  0x00, 0x3D, 0xC0, 0x1C, 0xE0, 0x00, 0x03, 0x9C, 0x01, 0xCE, 0x00, 0x00,
  0x7B, 0xC0, 0x1C, 0xE0, 0x00, 0x07, 0x3C, 0x03, 0xCE, 0x00, 0x00, 0xF3,
  0x80, 0x3C, 0xE0, 0x00, 0x0E, 0x38, 0x03, 0x8E, 0x00, 0x01, 0xE3, 0x80,
  0x38, 0xE0, 0x00, 0x1C, 0x78, 0x03, 0x8F, 0x00, 0x03, 0xC7, 0x80, 0x78,
  0x70, 0x00, 0x38, 0x70, 0x07, 0x07, 0x00, 0x07, 0x07, 0x00, 0x70, 0x70,
  0x00, 0x70, 0x70, 0x07, 0x07, 0x00, 0x0E, 0x0F, 0x00, 0x70, 0x70, 0x01,
  0xE0, 0xF0, 0x0F, 0x07, 0x00, 0x1C, 0x0E, 0x00, 0xE0, 0x70, 0x03, 0xC0,
  0xE0, 0x0E, 0x07, 0x00, 0x38, 0x1E, 0x00, 0xE0, 0x38, 0x07, 0x81, 0xE0,
  0x1E, 0x03, 0x80, 0x70, 0x1C, 0x01, 0xE0, 0x38, 0x0F, 0x01, 0xC0, 0x1C,
  0x03, 0x80, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x1E, 0x03, 0xC0, 0x1C, 0x03,
  0x81, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x38, 0x03, 0x80, 0x3C, 0x03, 0x83,
  0x80, 0x38, 0x03, 0x80, 0x38, 0x70, 0x03, 0x80, 0x38, 0x01, 0xC7, 0x00,
  0x78, 0x03, 0x80, 0x1C, 0xE0, 0x07, 0x80, 0x78, 0x01, 0xDE, 0x00, 0x70,
  0x07, 0x00, 0x1D, 0xC0, 0x07, 0x00, 0x70, 0x01, 0xFC, 0x00, 0x70, 0x07,
  0x00, 0x1F, 0x80, 0x0F, 0x00, 0xF0, 0x01, 0xF8, 0x00, 0xF0, 0x0F, 0x00,
  0x1F, 0x00, 0x0E, 0x00, 0xE0, 0x01, 0xF0, 0x00, 0xE0, 0x0E, 0x00, 0x0E,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x0F, 0xC0, 0x00, 0x0E, 0x00, 0xFC, 0x00,
  0x00, 0xE0, 0x0F, 0xC0, 0x00, 0x0E, 0x00, 0xFE, 0x00, 0x01, 0xE0, 0x1E,
  0xE0, 0x00, 0x1E, 0x01, 0xCE, 0x00, 0x01, 0xC0, 0x1C, 0xF0, 0x00, 0x1C,
  0x01, 0xCF, 0x00, 0x03, 0xC0, 0x1C, 0x70, 0x00, 0x3C, 0x03, 0xC7, 0x00,
  0x03, 0x80, 0x3C, 0x78, 0x00, 0x38, 0x03, 0x83, 0x80, 0x03, 0x80, 0x38,
  0x38, 0x00, 0x78, 0x03, 0x83, 0xC0, 0x07, 0x80, 0x78, 0x1C, 0x00, 0x70,
  0x07, 0x01, 0xC0, 0x07, 0x00, 0x70, 0x1E, 0x00, 0x70, 0x07, 0x00, 0xE0,
  0x0F, 0x00, 0x70, 0x0E, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0,
  0x07, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x07, 0x81, 0xE0,
  0x1E, 0x00, 0x38, 0x1C, 0x01, 0xE0, 0x03, 0x81, 0xC0, 0x1C, 0x00, 0x3C,
  0x1C, 0x01, 0xC0, 0x01, 0xC3, 0xC0, 0x1C, 0x00, 0x1C, 0x3C, 0x03, 0xC0,
  0x01, 0xE3, 0x80, 0x3C, 0x00, 0x1E, 0x38, 0x03, 0x80, 0x00, 0xE3, 0x80,
  0x38, 0x00, 0x0F, 0x38, 0x03, 0x80, 0x00, 0xF7, 0x80, 0x78, 0x00, 0x07,
  0x70, 0x07, 0x00, 0x00, 0x77, 0x00, 0x70, 0x00, 0x07, 0xF0, 0x07, 0x00,
  0x00, 0x3F, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x0F, 0x00, 0x00, 0x3E, 0x00,
  0xE0, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0x01,
  0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0x3C, 0x01, 0xE0, 0x00,
  0x1E, 0x03, 0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x0F, 0x07, 0x80, 0x00,
  0x0F, 0x0F, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x07, 0x1E, 0x00, 0x00,
  0x07, 0x1E, 0x00, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x07, 0x3C, 0x00, 0x00,
  0x07, 0x38, 0x00, 0x00, 0x07, 0x78, 0x00, 0x00, 0x07, 0x78, 0x00, 0x00,
  0x07, 0x78, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0E, 0xF0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00,
  0x1E, 0xE0, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x00,
  0x3C, 0xE0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00,
  0xF0, 0xF0, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x03,
  0xE0, 0x78, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x07, 0x80, 0x3E, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x3E, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80,
  0x0F, 0x00, 0x3E, 0x00, 0x70, 0x00, 0xF0, 0x03, 0x80, 0x03, 0xC0, 0x3C,
  0x00, 0x1E, 0x01, 0xE0, 0x00, 0x70, 0x0F, 0x00, 0x03, 0x80, 0x70, 0x00,
  0x1E, 0x03, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x38,
  0x0E, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x1E, 0x03, 0x80, 0x00, 0xF0, 0x3C,
  0x00, 0x07, 0x01, 0xE0, 0x00, 0x78, 0x0E, 0x00, 0x07, 0x80, 0x70, 0x00,
  0x7C, 0x03, 0x80, 0x07, 0xC0, 0x3C, 0x01, 0xFC, 0x01, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF0, 0x00,
  0x3C, 0x01, 0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0x0F, 0x07, 0x80, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00,
  0x07, 0x1E, 0x00, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x07, 0x3C, 0x00, 0x00,
  0x07, 0x3C, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x07, 0x78, 0x00, 0x00,
  0x07, 0x78, 0x00, 0x00, 0x07, 0x78, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00,
  0x1E, 0xE0, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00,
  0x3C, 0xE0, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00,
  0x78, 0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x01,
  0xE0, 0x78, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x07,
  0x80, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x70, 0x00, 0xF8, 0x03,
  0x80, 0x03, 0xC0, 0x3C, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x70, 0x0F, 0x00,
  0x03, 0xC0, 0x70, 0x00, 0x1E, 0x03, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x07,
  0x01, 0xE0, 0x00, 0x38, 0x0E, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x1E, 0x03,
  0x80, 0x00, 0xF0, 0x3C, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x78, 0x0E, 0x00,
  0x07, 0x80, 0x70, 0x00, 0xF8, 0x03, 0x80, 0x1F, 0x80, 0x3F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x70, 0x0E, 0x00, 0x07,
  0x80, 0x78, 0x00, 0x3C, 0x03, 0xC0, 0x01, 0xE0, 0x0E, 0x00, 0x0E, 0x00,
  0x70, 0x00, 0x70, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x70,
  0x01, 0xC0, 0x03, 0xC0, 0x0E, 0x00, 0x1E, 0x00, 0x70, 0x00, 0x70, 0x07,
  0x80, 0x03, 0xC0, 0x3C, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0xF0, 0x0E, 0x00,
  0x03, 0x80, 0xF0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x03,
  0x81, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0xFE, 0x03, 0xE0, 0x0F, 0x80, 0x02, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x10, 0x00, 0x0F, 0x00, 0xE0, 0x01, 0xF8, 0x07, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x01,
  0xE0, 0x70, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00,
  0x38, 0x1E, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x1E, 0x07, 0x00, 0x00,
  0x0E, 0x03, 0x80, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x03, 0x81, 0xE0, 0x00,
  0x03, 0xC0, 0xE0, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x00, 0xE0, 0x38, 0x00,
  0x00, 0x70, 0x3C, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x3C, 0x0E, 0x00,
  0x00, 0x1E, 0x07, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x07, 0x03, 0xC0,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x01, 0xC0, 0x70,
  0x00, 0x00, 0xE0, 0x78, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x00, 0x78, 0x1C,
  0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x0E, 0x07,
  0x80, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x03, 0x80,
  0xE0, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x00, 0xF0,
  0x1C, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x78,
  0x01, 0xE0, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x01, 0xCE,
  0x00, 0x00, 0x3C, 0xF0, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x78, 0xF0, 0x00,
  0x07, 0x0F, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xE0,
  0x70, 0x00, 0x1C, 0x07, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x38, 0x07, 0x00,
  0x07, 0x80, 0x70, 0x00, 0x70, 0x07, 0x00, 0x0F, 0x00, 0x70, 0x00, 0xE0,
  0x07, 0x00, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x80, 0x3C, 0x00, 0x78,
  0x03, 0x80, 0x07, 0x80, 0x78, 0x00, 0x38, 0x07, 0x00, 0x03, 0x80, 0xF0,
  0x00, 0x38, 0x0E, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x38, 0x1C, 0x00, 0x03,
  0x83, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x03, 0x87, 0x80, 0x00, 0x38, 0x70,
  0x00, 0x03, 0x8F, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x03, 0xCE, 0x00, 0x00,
  0x3D, 0xC0, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x38, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0x1D, 0xE0, 0x00, 0x1F,
  0x00, 0x01, 0xEF, 0x00, 0x01, 0xF8, 0x00, 0x0E, 0x38, 0x00, 0x0F, 0xC0,
  0x00, 0xF1, 0xC0, 0x00, 0xEE, 0x00, 0x07, 0x8E, 0x00, 0x07, 0x70, 0x00,
  0x78, 0x70, 0x00, 0x3B, 0x80, 0x03, 0xC3, 0x80, 0x03, 0x9C, 0x00, 0x1C,
  0x1C, 0x00, 0x1C, 0xE0, 0x01, 0xE0, 0xE0, 0x01, 0xC7, 0x00, 0x0E, 0x07,
  0x00, 0x0E, 0x38, 0x00, 0xF0, 0x38, 0x00, 0xE1, 0xC0, 0x07, 0x01, 0xC0,
  0x07, 0x0E, 0x00, 0x78, 0x0E, 0x00, 0x78, 0x70, 0x03, 0xC0, 0x70, 0x03,
  0x83, 0x80, 0x1C, 0x03, 0x80, 0x1C, 0x1C, 0x01, 0xE0, 0x1C, 0x01, 0xC0,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x07, 0x00, 0xF0, 0x07, 0x00, 0xE0, 0x38,
  0x07, 0x00, 0x38, 0x07, 0x01, 0xC0, 0x78, 0x01, 0xC0, 0x78, 0x0E, 0x03,
  0xC0, 0x0E, 0x03, 0x80, 0x70, 0x1C, 0x00, 0x70, 0x3C, 0x03, 0x81, 0xE0,
  0x03, 0x81, 0xC0, 0x1C, 0x0E, 0x00, 0x1C, 0x1E, 0x00, 0xE0, 0xF0, 0x00,
  0xE0, 0xE0, 0x07, 0x07, 0x00, 0x07, 0x07, 0x00, 0x38, 0x38, 0x00, 0x38,
  0x70, 0x01, 0xC3, 0x80, 0x01, 0xC3, 0x80, 0x0E, 0x1C, 0x00, 0x0E, 0x3C,
  0x00, 0x71, 0xE0, 0x00, 0x71, 0xC0, 0x03, 0x8E, 0x00, 0x03, 0x9E, 0x00,
  0x1C, 0xF0, 0x00, 0x1C, 0xE0, 0x00, 0xE7, 0x00, 0x00, 0xE7, 0x00, 0x07,
  0x38, 0x00, 0x07, 0x70, 0x00, 0x3B, 0x80, 0x00, 0x3B, 0x80, 0x01, 0xDC,
  0x00, 0x01, 0xF8, 0x00, 0x0E, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x78, 0x00, 0xF0, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x03, 0x80, 0x07, 0x00, 0x00, 0x70, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x1C, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x00, 0x07, 0x07,
  0x80, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x01,
  0xCE, 0x00, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x00, 0x0F,
  0x1E, 0x00, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x00, 0x78, 0x38, 0x00, 0x00,
  0x1E, 0x07, 0x00, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0xE0, 0x0E, 0x00,
  0x00, 0x3C, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x0F,
  0x00, 0x00, 0x78, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x0F, 0x3C,
  0x00, 0x03, 0xC7, 0x80, 0x00, 0x70, 0x70, 0x00, 0x1E, 0x0E, 0x00, 0x07,
  0x81, 0xC0, 0x00, 0xE0, 0x3C, 0x00, 0x3C, 0x07, 0x80, 0x0F, 0x00, 0x70,
  0x01, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x0E, 0x00, 0x3C, 0x03, 0xC0,
  0x03, 0x80, 0xF0, 0x00, 0x70, 0x1C, 0x00, 0x0E, 0x07, 0x80, 0x01, 0xC1,
  0xE0, 0x00, 0x3C, 0x38, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x71, 0xC0, 0x00,
  0x0E, 0x70, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0xE0, 0x3C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x3C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0xC0, 0x70, 0x1C, 0x07, 0x00, 0x1F, 0xFE,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x01, 0x00, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x07,
  0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x07, 0x38, 0x00, 0x00, 0xE3, 0x80,
  0x00, 0x38, 0x70, 0x00, 0x0F, 0x07, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x70,
  0x1C, 0x00, 0x0E, 0x01, 0xC0, 0x03, 0x80, 0x38, 0x00, 0x70, 0x07, 0x80,
  0x1C, 0x00, 0x70, 0x07, 0x80, 0x0E, 0x00, 0xE0, 0x00, 0xE0, 0x3C, 0x00,
  0x1C, 0x07, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x38, 0x78, 0x00, 0x07, 0x0E,
  0x00, 0x00, 0xF3, 0xC0, 0x00, 0x0E, 0x70, 0x00, 0x01, 0xDE, 0x00, 0x00,
  0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF0, 0xF0, 0x70,
  0x78, 0x38, 0x3C, 0x1C, 0x0E, 0x06, 0x07, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xFE, 0x1C, 0x01, 0xFF, 0xE3, 0x80, 0xFC, 0x1E, 0x70, 0x1E, 0x00, 0xDE,
  0x07, 0x80, 0x1F, 0x81, 0xE0, 0x01, 0xF0, 0x78, 0x00, 0x3E, 0x0F, 0x00,
  0x07, 0xC3, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x1E, 0x0E, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0x78, 0x78, 0x00, 0x0F, 0x0E, 0x00, 0x01, 0xC3, 0xC0, 0x00,
  0x38, 0x78, 0x00, 0x07, 0x0F, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x3C, 0x38,
  0x00, 0x07, 0x07, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x07,
  0x87, 0x80, 0x01, 0xE0, 0x70, 0x00, 0x3C, 0x0E, 0x00, 0x0F, 0x81, 0xC0,
  0x03, 0xF0, 0x3C, 0x00, 0xEE, 0x07, 0x80, 0x3B, 0x80, 0x78, 0x0E, 0x70,
  0x0F, 0xCF, 0x8E, 0x00, 0xFF, 0xE1, 0xC0, 0x0F, 0xF8, 0x38, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x81,
  0xF8, 0x00, 0x70, 0xFF, 0xC0, 0x0E, 0x3F, 0xFC, 0x03, 0xCF, 0x07, 0xC0,
  0x73, 0x80, 0x78, 0x0E, 0xE0, 0x07, 0x81, 0xF8, 0x00, 0xF0, 0x3E, 0x00,
  0x0E, 0x0F, 0x80, 0x01, 0xC1, 0xF0, 0x00, 0x38, 0x3C, 0x00, 0x07, 0x07,
  0x80, 0x00, 0xE0, 0xE0, 0x00, 0x1C, 0x3C, 0x00, 0x03, 0x87, 0x80, 0x00,
  0x70, 0xE0, 0x00, 0x0E, 0x1C, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x78, 0xF0,
  0x00, 0x0E, 0x1C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x78, 0x70, 0x00, 0x0F,
  0x1E, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x78, 0x78, 0x00, 0x0E, 0x0F, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0xF0, 0x76, 0x00, 0x1E, 0x0E, 0xC0, 0x07, 0x81,
  0xDC, 0x03, 0xE0, 0x39, 0xF1, 0xF8, 0x06, 0x1F, 0xFE, 0x01, 0xC1, 0xFF,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0xF0, 0x0F,
  0xFF, 0xC0, 0x7C, 0x06, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xF0, 0x02, 0x03, 0xF8, 0xF8, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x01, 0xFC, 0x1E, 0x00, 0x0F, 0xFC,
  0x3C, 0x00, 0x3F, 0xFC, 0x70, 0x01, 0xF8, 0x1C, 0xE0, 0x07, 0xC0, 0x1D,
  0xC0, 0x0F, 0x00, 0x1F, 0x80, 0x3C, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x3C,
  0x01, 0xE0, 0x00, 0x78, 0x07, 0x80, 0x00, 0xF0, 0x0F, 0x00, 0x01, 0xE0,
  0x1C, 0x00, 0x03, 0x80, 0x78, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x0E, 0x01,
  0xC0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x78, 0x0F, 0x00, 0x00, 0xE0, 0x1E,
  0x00, 0x01, 0xC0, 0x38, 0x00, 0x07, 0x80, 0x70, 0x00, 0x0F, 0x00, 0xE0,
  0x00, 0x1C, 0x01, 0xC0, 0x00, 0x78, 0x07, 0x80, 0x00, 0xF0, 0x0F, 0x00,
  0x03, 0xE0, 0x0E, 0x00, 0x07, 0xC0, 0x1C, 0x00, 0x1F, 0x00, 0x38, 0x00,
  0x7E, 0x00, 0x78, 0x01, 0xDC, 0x00, 0xF0, 0x07, 0x38, 0x00, 0xF0, 0x1E,
  0x70, 0x01, 0xF8, 0xF9, 0xC0, 0x01, 0xFF, 0xC3, 0x80, 0x01, 0xFF, 0x07,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xC0,
  0x0F, 0xFF, 0x80, 0x7C, 0x1F, 0x03, 0xC0, 0x3C, 0x1E, 0x00, 0x70, 0xF0,
  0x01, 0xC7, 0x80, 0x07, 0x1E, 0x00, 0x1C, 0xF0, 0x00, 0x73, 0x80, 0x03,
  0xCE, 0x00, 0x1E, 0x78, 0x00, 0xF9, 0xC0, 0x07, 0xC7, 0x00, 0xFE, 0x3F,
  0xFF, 0xE0, 0xFF, 0xFE, 0x03, 0xFF, 0x80, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x03, 0x03, 0xF8, 0x7C, 0x07, 0xFF, 0xF0, 0x07, 0xFF,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xC6, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC7, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0xC1, 0xC0, 0x0F, 0xFF, 0x1C, 0x01,
  0xF8, 0x1C, 0xE0, 0x0F, 0x00, 0x77, 0x00, 0xF0, 0x01, 0xB8, 0x0F, 0x00,
  0x0F, 0x80, 0xF0, 0x00, 0x3C, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0x78, 0x1C, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x1C, 0x0E,
  0x00, 0x00, 0xE0, 0x70, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x78, 0x3C, 0x00,
  0x03, 0x81, 0xE0, 0x00, 0x1C, 0x0E, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x0F,
  0x03, 0x80, 0x00, 0x70, 0x1C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x3C, 0x0F,
  0x00, 0x03, 0xE0, 0x38, 0x00, 0x1F, 0x01, 0xC0, 0x01, 0xF0, 0x0E, 0x00,
  0x1F, 0x80, 0x78, 0x01, 0xDC, 0x03, 0xC0, 0x1C, 0xE0, 0x0F, 0x01, 0xEF,
  0x00, 0x7E, 0x3E, 0x70, 0x01, 0xFF, 0xE3, 0x80, 0x07, 0xFC, 0x1C, 0x00,
  0x02, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x20, 0x00, 0xF0, 0x01,
  0x80, 0x0F, 0x80, 0x0F, 0xC3, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0x81, 0xFC, 0x00, 0x70, 0xFF, 0xC0, 0x0E, 0x3F, 0xFC,
  0x03, 0xCF, 0x07, 0xC0, 0x73, 0x80, 0x78, 0x0E, 0xE0, 0x07, 0x01, 0xF8,
  0x00, 0xF0, 0x3E, 0x00, 0x1E, 0x0F, 0x80, 0x03, 0xC1, 0xF0, 0x00, 0x70,
  0x3C, 0x00, 0x0E, 0x07, 0x80, 0x01, 0xC0, 0xE0, 0x00, 0x78, 0x3C, 0x00,
  0x0F, 0x07, 0x80, 0x01, 0xC0, 0xE0, 0x00, 0x38, 0x1C, 0x00, 0x07, 0x07,
  0x80, 0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x1C, 0x00, 0x07, 0x03, 0x80, 0x00,
  0xE0, 0x70, 0x00, 0x1C, 0x1E, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF0, 0x70,
  0x00, 0x1C, 0x0E, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x70, 0x78, 0x00, 0x1E,
  0x0F, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x0E, 0x07, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0x78, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x00,
  0xF0, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01,
  0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C,
  0x00, 0x23, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x40, 0x70, 0x00, 0xF0, 0x0E, 0x00, 0x3C, 0x03, 0xC0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x0E, 0x00, 0xF0, 0x01, 0xC0, 0x3C, 0x00, 0x38, 0x0F, 0x00,
  0x0F, 0x03, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x38, 0x3C, 0x00, 0x07, 0x0F,
  0x00, 0x00, 0xE1, 0xC0, 0x00, 0x3C, 0x78, 0x00, 0x07, 0x1E, 0x00, 0x00,
  0xE7, 0xC0, 0x00, 0x1D, 0xFC, 0x00, 0x07, 0xF3, 0x80, 0x00, 0xFC, 0x70,
  0x00, 0x1F, 0x0F, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x70, 0x1E, 0x00, 0x1E,
  0x03, 0xC0, 0x03, 0xC0, 0x38, 0x00, 0x70, 0x07, 0x80, 0x0E, 0x00, 0xF0,
  0x01, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x1C, 0x01, 0xC0,
  0x03, 0xC0, 0x38, 0x00, 0x78, 0x07, 0x00, 0x07, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03,
  0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xE0,
  0x07, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03,
  0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x78, 0x00, 0x00, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x70, 0xFF,
  0x80, 0xFF, 0xC0, 0x1C, 0xFF, 0xF0, 0x7F, 0xF8, 0x0E, 0x78, 0x3E, 0x3C,
  0x1F, 0x03, 0x98, 0x07, 0x9C, 0x03, 0xC0, 0xEC, 0x00, 0xEE, 0x00, 0xF0,
  0x3E, 0x00, 0x3F, 0x00, 0x1C, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xC1, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x78, 0x00, 0x3C,
  0x00, 0x1C, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x07, 0x00, 0x07, 0x80, 0x03,
  0xC3, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x38,
  0x00, 0x1C, 0x00, 0x1E, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x87, 0x80, 0x03,
  0xC0, 0x01, 0xC1, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC3,
  0xC0, 0x01, 0xE0, 0x00, 0xE0, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x83, 0x80, 0x03, 0xC0,
  0x01, 0xE1, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x78, 0x00, 0x38, 0x00, 0x1C,
  0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC1, 0xC0,
  0x01, 0xE0, 0x00, 0xE0, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0xFE, 0x00, 0x38, 0x7F, 0xE0, 0x07, 0x1F, 0xFE, 0x01, 0xCF, 0x83, 0xE0,
  0x39, 0xC0, 0x3C, 0x07, 0x70, 0x03, 0xC0, 0xFC, 0x00, 0x78, 0x1F, 0x00,
  0x0F, 0x07, 0xC0, 0x01, 0xE0, 0xF8, 0x00, 0x38, 0x1E, 0x00, 0x07, 0x03,
  0xC0, 0x00, 0xE0, 0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0xF0, 0x70, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x83, 0xC0, 0x00, 0xF0, 0x78,
  0x00, 0x1E, 0x0F, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x1E,
  0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x78, 0x38, 0x00, 0x0E, 0x07, 0x00,
  0x01, 0xC0, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xC0,
  0xE0, 0x00, 0x38, 0x1C, 0x00, 0x07, 0x07, 0x80, 0x01, 0xE0, 0xF0, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFF, 0x00,
  0x3E, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x3C, 0x00, 0x78, 0x3C, 0x00, 0x3C,
  0x3C, 0x00, 0x0E, 0x1E, 0x00, 0x07, 0x9E, 0x00, 0x03, 0xCF, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x7B, 0x80, 0x00, 0x3D, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0x70, 0x00, 0x03, 0xB8, 0x00,
  0x03, 0xDC, 0x00, 0x01, 0xEE, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x73, 0x80,
  0x00, 0x79, 0xC0, 0x00, 0x38, 0xE0, 0x00, 0x3C, 0x70, 0x00, 0x1C, 0x3C,
  0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x07, 0x80, 0x1E, 0x03, 0xE0, 0x1F, 0x00,
  0xFC, 0x7F, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xE1, 0xFF, 0x80, 0x03, 0x8F, 0xFF,
  0x00, 0x1C, 0x78, 0x3E, 0x00, 0x73, 0x80, 0x78, 0x01, 0xDC, 0x00, 0xF0,
  0x07, 0xE0, 0x03, 0xC0, 0x1F, 0x00, 0x07, 0x00, 0xFC, 0x00, 0x1C, 0x03,
  0xE0, 0x00, 0x70, 0x0F, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0x1C, 0x07, 0x80, 0x00, 0x70, 0x1E, 0x00, 0x01, 0xC0, 0x70, 0x00,
  0x07, 0x01, 0xC0, 0x00, 0x3C, 0x07, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x78, 0x0E, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0xE0, 0x1E,
  0x00, 0x07, 0x80, 0x78, 0x00, 0x3C, 0x03, 0xF0, 0x00, 0xF0, 0x0E, 0xC0,
  0x07, 0x80, 0x3B, 0x80, 0x7C, 0x00, 0xE7, 0xC7, 0xE0, 0x03, 0x8F, 0xFF,
  0x00, 0x1E, 0x1F, 0xF0, 0x00, 0x70, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xFF, 0x07, 0x00, 0x7F, 0xF8, 0xE0, 0x1F, 0x81, 0xCE,
  0x01, 0xE0, 0x0E, 0xE0, 0x3C, 0x00, 0x6E, 0x07, 0x80, 0x07, 0xC0, 0xF0,
  0x00, 0x3C, 0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x3C, 0x1E, 0x00, 0x03,
  0xC1, 0xC0, 0x00, 0x38, 0x3C, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x38, 0x38,
  0x00, 0x07, 0x87, 0x80, 0x00, 0x78, 0x78, 0x00, 0x07, 0x07, 0x80, 0x00,
  0x70, 0x70, 0x00, 0x0F, 0x07, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x0E, 0x07,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xE0, 0x70, 0x00,
  0x3E, 0x07, 0x00, 0x07, 0xC0, 0x70, 0x00, 0xFC, 0x07, 0x80, 0x1D, 0xC0,
  0x78, 0x03, 0xDC, 0x03, 0xC0, 0x7B, 0xC0, 0x3F, 0x9F, 0x38, 0x01, 0xFF,
  0xC3, 0x80, 0x0F, 0xF8, 0x38, 0x00, 0x08, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x07, 0x0F,
  0xE0, 0x18, 0xFF, 0x80, 0xE3, 0xC2, 0x03, 0x9C, 0x00, 0x0E, 0xE0, 0x00,
  0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F,
  0x01, 0xE0, 0x78, 0x00, 0x40, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x08, 0x00,
  0x3C, 0x18, 0x00, 0xF0, 0x3F, 0x0F, 0xE0, 0x7F, 0xFF, 0x80, 0x3F, 0xFC,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x01, 0x3F, 0xFF, 0x3F,
  0xFF, 0x81, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0xE3,
  0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x02, 0x00, 0x00, 0x07, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x38, 0x38, 0x00, 0x0E, 0x0E, 0x00, 0x03,
  0x83, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0x78, 0x70, 0x00, 0x1C, 0x1C, 0x00,
  0x07, 0x07, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x38,
  0x00, 0x0E, 0x0E, 0x00, 0x03, 0x83, 0x80, 0x00, 0xE1, 0xE0, 0x00, 0x78,
  0x78, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x07, 0x00, 0x01, 0xC1, 0xC0, 0x00,
  0xF0, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x0E, 0x00, 0x07, 0x83, 0x80,
  0x03, 0xE0, 0xE0, 0x00, 0xF8, 0x38, 0x00, 0x7E, 0x0E, 0x00, 0x3F, 0x03,
  0xC0, 0x1D, 0xC0, 0xF0, 0x0E, 0x70, 0x1F, 0x9F, 0x1C, 0x07, 0xFF, 0x86,
  0x00, 0xFF, 0x83, 0x80, 0x03, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x1E, 0xF0, 0x00, 0x1C, 0x70, 0x00, 0x3C, 0x70, 0x00, 0x38, 0x70,
  0x00, 0x78, 0x70, 0x00, 0x70, 0x70, 0x00, 0xF0, 0x70, 0x00, 0xE0, 0x70,
  0x01, 0xE0, 0x70, 0x01, 0xC0, 0x78, 0x03, 0xC0, 0x78, 0x07, 0x80, 0x78,
  0x07, 0x80, 0x38, 0x0F, 0x00, 0x38, 0x0F, 0x00, 0x38, 0x1E, 0x00, 0x38,
  0x1C, 0x00, 0x38, 0x3C, 0x00, 0x38, 0x38, 0x00, 0x38, 0x78, 0x00, 0x38,
  0x70, 0x00, 0x38, 0xF0, 0x00, 0x38, 0xE0, 0x00, 0x3D, 0xE0, 0x00, 0x1D,
  0xC0, 0x00, 0x1D, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0x00, 0x0E, 0xE0, 0x01, 0xF0, 0x01, 0xEE, 0x00, 0x3F,
  0x00, 0x1C, 0xE0, 0x03, 0xF0, 0x03, 0xCE, 0x00, 0x77, 0x00, 0x3C, 0xE0,
  0x07, 0x70, 0x03, 0x8E, 0x00, 0xE7, 0x00, 0x78, 0xE0, 0x0E, 0x70, 0x07,
  0x0E, 0x01, 0xE7, 0x00, 0xF0, 0xE0, 0x1C, 0x70, 0x0E, 0x0E, 0x01, 0xC7,
  0x01, 0xE0, 0xE0, 0x38, 0x70, 0x1C, 0x0E, 0x03, 0x87, 0x01, 0xC0, 0xE0,
  0x70, 0x70, 0x3C, 0x0E, 0x07, 0x07, 0x03, 0x80, 0xE0, 0xE0, 0x70, 0x78,
  0x0E, 0x0E, 0x07, 0x07, 0x00, 0xE1, 0xC0, 0x70, 0xF0, 0x0E, 0x1C, 0x07,
  0x0E, 0x00, 0xE3, 0xC0, 0x70, 0xE0, 0x0E, 0x38, 0x03, 0x1C, 0x00, 0xE7,
  0x80, 0x39, 0xC0, 0x0E, 0x70, 0x03, 0xBC, 0x00, 0xE7, 0x00, 0x3B, 0x80,
  0x0E, 0xE0, 0x03, 0xB8, 0x00, 0xEE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0xF8,
  0x07, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x07, 0x80, 0x07,
  0x00, 0x78, 0x00, 0x38, 0x07, 0x80, 0x01, 0xE0, 0x38, 0x00, 0x07, 0x03,
  0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x07, 0x1C, 0x00,
  0x00, 0x3D, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x07, 0x1C, 0x00,
  0x00, 0x70, 0xF0, 0x00, 0x07, 0x83, 0x80, 0x00, 0x78, 0x1C, 0x00, 0x07,
  0x80, 0xF0, 0x00, 0x38, 0x03, 0x80, 0x03, 0xC0, 0x1C, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x03, 0x80, 0x1C, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0xF0,
  0x1E, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x07,
  0x80, 0x0E, 0x00, 0x03, 0xC0, 0x07, 0x00, 0x03, 0xC0, 0x03, 0x80, 0x01,
  0xE0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x78, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x07, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x3C, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0xE0,
  0x1E, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x38, 0x0F, 0x00, 0x00, 0x1C,
  0x07, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x03, 0x83, 0x80, 0x00, 0x01,
  0xC3, 0xC0, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x00,
  0x38, 0xE0, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00,
  0x07, 0x78, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x00, 0xDC, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x11, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0B, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x18, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x03,
  0xF8, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x01, 0xF8,
  0x00, 0x3F, 0xC0, 0x00, 0xFC, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x4F, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0xC1, 0xFE, 0x1F, 0xC0,
  0x1F, 0xFF, 0xA0, 0x01, 0xFF, 0x88, 0x00, 0x07, 0x80,
};

const GFXglyph NotoSans_SemiCondensed_LightItalic61pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 14, 45, 14, 1, -44 },
  { 80, 16, 16, 20, 6, -44 },
  { 112, 33, 44, 33, 1, -44 },
  { 294, 27, 50, 29, 2, -46 },
  { 463, 36, 45, 43, 4, -44 },
  { 666, 32, 45, 35, 1, -44 },
  { 846, 7, 16, 11, 6, -44 },
  { 860, 18, 54, 16, 2, -44 },
  { 982, 18, 54, 16, -4, -44 },
  { 1104, 23, 23, 28, 7, -46 },
  { 1171, 25, 29, 31, 4, -36 },
  { 1262, 10, 15, 13, -3, -7 },
  { 1281, 14, 3, 18, 2, -18 },
  { 1287, 5, 6, 13, 1, -5 },
  { 1291, 28, 44, 20, -3, -44 },
  { 1445, 26, 45, 29, 3, -44 },
  { 1592, 16, 44, 29, 8, -44 },
  { 1680, 28, 44, 29, 0, -44 },
  { 1834, 29, 45, 29, 0, -44 },
  { 1998, 28, 44, 29, 0, -44 },
  { 2152, 28, 45, 29, 1, -44 },
  { 2310, 27, 45, 29, 3, -44 },
  { 2462, 26, 44, 29, 5, -44 },
  { 2605, 27, 45, 29, 2, -44 },
  { 2757, 26, 45, 29, 2, -44 },
  { 2904, 11, 34, 13, 1, -33 },
  { 2951, 15, 41, 13, -3, -33 },
  { 3028, 25, 28, 31, 4, -36 },
  { 3116, 25, 15, 31, 4, -29 },
  { 3163, 25, 28, 31, 4, -36 },
  { 3251, 21, 45, 22, 3, -44 },
  { 3370, 40, 49, 45, 3, -44 },
  { 3615, 30, 44, 30, -4, -44 },
  { 3780, 30, 44, 32, 2, -44 },
  { 3945, 30, 45, 31, 4, -44 },
  { 4114, 32, 44, 36, 2, -44 },
  { 4290, 28, 44, 28, 2, -44 },
  { 4444, 28, 44, 26, 2, -44 },
  { 4598, 33, 45, 37, 4, -44 },
  { 4784, 35, 44, 37, 2, -44 },
  { 4977, 21, 44, 16, -1, -44 },
  { 5093, 25, 55, 14, -10, -44 },
  { 5265, 33, 44, 30, 2, -44 },
  { 5447, 20, 44, 26, 2, -44 },
  { 5557, 44, 44, 46, 2, -44 },
  { 5799, 36, 44, 38, 2, -44 },
  { 5997, 32, 45, 38, 4, -44 },
  { 6177, 29, 44, 30, 2, -44 },
  { 6337, 32, 54, 38, 4, -44 },
  { 6553, 29, 44, 31, 2, -44 },
  { 6713, 29, 45, 27, 0, -44 },
  { 6877, 26, 44, 26, 5, -44 },
  { 7020, 33, 45, 36, 4, -44 },
  { 7206, 28, 44, 29, 6, -44 },
  { 7360, 45, 44, 46, 6, -44 },
  { 7608, 35, 44, 27, -3, -44 },
  { 7801, 27, 44, 26, 5, -44 },
  { 7950, 32, 44, 28, -1, -44 },
  { 8126, 23, 54, 18, -1, -44 },
  { 8282, 10, 44, 20, 6, -44 },
  { 8337, 23, 54, 18, -4, -44 },
  { 8493, 27, 26, 31, 2, -44 },
  { 8581, 21, 3, 21, -5, 6 },
  { 8589, 8, 10, 15, 9, -47 },
  { 8599, 27, 34, 31, 2, -33 },
  { 8714, 27, 47, 31, 1, -46 },
  { 8873, 22, 34, 24, 3, -33 },
  { 8967, 31, 47, 31, 2, -46 },
  { 9150, 22, 34, 27, 3, -33 },
  { 9244, 32, 62, 16, -8, -47 },
  { 9492, 29, 48, 31, 1, -33 },
  { 9666, 27, 46, 30, 1, -46 },
  { 9822, 13, 44, 13, 1, -44 },
  { 9894, 22, 59, 13, -8, -44 },
  { 10057, 27, 46, 25, 1, -46 },
  { 10213, 13, 46, 13, 1, -46 },
  { 10288, 42, 33, 46, 1, -33 },
  { 10462, 27, 33, 30, 1, -33 },
  { 10574, 25, 34, 30, 3, -33 },
  { 10681, 30, 47, 31, -2, -33 },
  { 10858, 28, 47, 31, 2, -33 },
  { 11023, 22, 33, 21, 1, -33 },
  { 11114, 23, 34, 23, 0, -33 },
  { 11212, 17, 41, 17, 2, -40 },
  { 11300, 26, 33, 31, 3, -32 },
  { 11408, 24, 32, 24, 3, -32 },
  { 11504, 36, 32, 38, 4, -32 },
  { 11648, 29, 32, 25, -2, -32 },
  { 11764, 33, 47, 24, -6, -32 },
  { 11958, 24, 32, 23, -1, -32 },
  { 12054, 23, 54, 20, 1, -44 },
  { 12210, 3, 61, 29, 14, -46 },
  { 12233, 22, 54, 20, -3, -44 },
  { 12382, 26, 7, 31, 4, -25 },
};

const GFXfont NotoSans_SemiCondensed_LightItalic61pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_LightItalic61pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_LightItalic61pt7bGlyphs,
  0x20, 0x7E, 83
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHTITALIC61PT7B_H_
