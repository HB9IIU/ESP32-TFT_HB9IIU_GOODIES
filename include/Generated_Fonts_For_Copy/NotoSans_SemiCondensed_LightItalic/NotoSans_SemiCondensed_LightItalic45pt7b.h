#ifndef _NOTOSANS_SEMICONDENSED_LIGHTITALIC45PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHTITALIC45PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-LightItalic.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_LightItalic45pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xC0, 0x60, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x30, 0x1C, 0x07,
  0x01, 0xC0, 0x60, 0x18, 0x0E, 0x03, 0x80, 0xC0, 0x30, 0x0C, 0x07, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x03, 0x80, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x3C, 0x0F, 0x03, 0x80, 0x30, 0xEE, 0x1D, 0xC3, 0x30, 0x66, 0x0C,
  0xC3, 0x98, 0x66, 0x0C, 0xC1, 0x98, 0x33, 0x0C, 0x00, 0x00, 0x1C, 0x0C,
  0x00, 0x18, 0x18, 0x00, 0x18, 0x18, 0x00, 0x30, 0x18, 0x00, 0x30, 0x38,
  0x00, 0x30, 0x30, 0x00, 0x70, 0x30, 0x00, 0x60, 0x30, 0x00, 0x60, 0x60,
  0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x00, 0xC0, 0xC0, 0x00, 0xC0, 0xC0,
  0x01, 0xC0, 0xC0, 0x01, 0x80, 0xC0, 0x01, 0x81, 0x80, 0x01, 0x81, 0x80,
  0x03, 0x01, 0x80, 0x03, 0x03, 0x00, 0x03, 0x03, 0x00, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF8, 0x06, 0x06, 0x00, 0x0E, 0x06, 0x00, 0x0C, 0x06, 0x00,
  0x0C, 0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x0C, 0x00, 0x18, 0x18, 0x00,
  0x18, 0x18, 0x00, 0x30, 0x18, 0x00, 0x30, 0x38, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x7F, 0xE0, 0x1F, 0xFF,
  0x03, 0x8C, 0x70, 0x70, 0xC0, 0x0E, 0x08, 0x00, 0xE1, 0x80, 0x0C, 0x18,
  0x00, 0xC1, 0x80, 0x0C, 0x18, 0x00, 0xE3, 0x00, 0x07, 0x30, 0x00, 0x7B,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00,
  0x67, 0x00, 0x06, 0x38, 0x00, 0x41, 0x80, 0x0C, 0x18, 0x00, 0xC1, 0x80,
  0x0C, 0x18, 0x00, 0xC3, 0x80, 0x08, 0x30, 0x81, 0x8F, 0x0F, 0x9B, 0xE0,
  0xFF, 0xF8, 0x00, 0xFC, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x70, 0x3B, 0xC0, 0x0C, 0x0E, 0x18, 0x03, 0x03, 0x83, 0x00, 0xE0, 0x60,
  0x60, 0x18, 0x0C, 0x0C, 0x06, 0x03, 0x01, 0x81, 0xC0, 0x60, 0x30, 0x30,
  0x0C, 0x06, 0x0C, 0x01, 0x80, 0xC3, 0x80, 0x70, 0x38, 0x60, 0x0C, 0x06,
  0x18, 0x01, 0x80, 0xC7, 0x0C, 0x30, 0x18, 0xC7, 0xE6, 0x06, 0x31, 0xCE,
  0xC0, 0xCE, 0x70, 0xDC, 0x31, 0x8C, 0x19, 0xDE, 0x63, 0x03, 0x9F, 0x8C,
  0x60, 0x70, 0x83, 0x1C, 0x0C, 0x00, 0xE3, 0x01, 0x80, 0x18, 0x60, 0x30,
  0x06, 0x0C, 0x06, 0x01, 0xC1, 0x80, 0xC0, 0x30, 0x70, 0x38, 0x0C, 0x0C,
  0x06, 0x03, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x38, 0x18, 0x07, 0x06, 0x07,
  0x00, 0x61, 0x80, 0xC0, 0x0F, 0xF0, 0x30, 0x00, 0xFC, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0x00, 0x07, 0x07,
  0x00, 0x1C, 0x06, 0x00, 0x30, 0x0C, 0x00, 0x60, 0x18, 0x01, 0xC0, 0x30,
  0x03, 0x80, 0xE0, 0x07, 0x01, 0x80, 0x0E, 0x07, 0x00, 0x0C, 0x1C, 0x00,
  0x1C, 0x70, 0x00, 0x3B, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0x60, 0x00, 0x38, 0xE0, 0x18, 0xE0, 0xC0, 0x73, 0x81,
  0xC0, 0xCE, 0x01, 0xC3, 0x98, 0x03, 0x86, 0x70, 0x03, 0x9C, 0xE0, 0x07,
  0x71, 0xC0, 0x07, 0xC3, 0x00, 0x07, 0x87, 0x00, 0x0E, 0x0E, 0x00, 0x3E,
  0x1C, 0x00, 0xFC, 0x1E, 0x07, 0x9C, 0x1F, 0xFC, 0x38, 0x1F, 0xF0, 0x38,
  0x37, 0x77, 0x66, 0x6E, 0xCC, 0xC0, 0x00, 0x1C, 0x00, 0xC0, 0x06, 0x00,
  0x38, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x38, 0x00,
  0xE0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x01,
  0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60,
  0x01, 0x80, 0x00, 0x00, 0xE0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xE0, 0x07, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01,
  0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x00,
  0x30, 0x03, 0x80, 0x38, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x38, 0x00, 0x18, 0x04, 0x0C, 0x07, 0x86, 0x01, 0xF3, 0x00, 0x1F, 0x1F,
  0x03, 0xFF, 0x81, 0xE0, 0x01, 0xB0, 0x01, 0xCC, 0x01, 0xC6, 0x01, 0xC3,
  0x81, 0xC0, 0xC0, 0x40, 0x70, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x0E, 0x1C,
  0x30, 0xE1, 0x87, 0x0C, 0x18, 0x60, 0xC3, 0x00, 0xFF, 0xFF, 0xF8, 0x6F,
  0xFE, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00,
  0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x06, 0x00,
  0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80,
  0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60,
  0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x30,
  0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x0F, 0xE0, 0x07, 0xFE, 0x01, 0xE0, 0xE0, 0x70, 0x0C, 0x0E, 0x01, 0xC3,
  0x80, 0x38, 0x60, 0x03, 0x1C, 0x00, 0x63, 0x00, 0x0C, 0xE0, 0x01, 0x9C,
  0x00, 0x33, 0x00, 0x0E, 0x60, 0x01, 0xDC, 0x00, 0x3B, 0x80, 0x07, 0x60,
  0x00, 0xEC, 0x00, 0x19, 0x80, 0x03, 0x70, 0x00, 0xEE, 0x00, 0x1D, 0xC0,
  0x03, 0x38, 0x00, 0xE7, 0x00, 0x1C, 0xE0, 0x03, 0x1C, 0x00, 0xE3, 0x80,
  0x1C, 0x70, 0x07, 0x06, 0x01, 0xC0, 0xE0, 0x38, 0x1E, 0x1E, 0x01, 0xFF,
  0x80, 0x1F, 0xC0, 0x00, 0x00, 0xE0, 0x3C, 0x1F, 0x87, 0xF1, 0xCC, 0xF1,
  0xB8, 0x72, 0x0E, 0x01, 0xC0, 0x30, 0x06, 0x01, 0xC0, 0x38, 0x06, 0x00,
  0xC0, 0x18, 0x07, 0x00, 0xE0, 0x18, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x60, 0x0C, 0x03, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x0E, 0x01, 0xC0,
  0x00, 0x06, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xF8, 0x07, 0x80, 0xE0, 0x10,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0xC0,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x80, 0x00, 0x06, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xF8, 0x07,
  0x80, 0xE0, 0x30, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x06, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x3F, 0xE0, 0x01, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x40, 0x03, 0x83, 0x80, 0x7C,
  0x1F, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0x60, 0x00, 0x3B, 0x00, 0x03, 0xB8, 0x00, 0x19,
  0x80, 0x01, 0x8C, 0x00, 0x1C, 0x60, 0x01, 0xC7, 0x00, 0x0C, 0x38, 0x00,
  0xC1, 0x80, 0x0C, 0x0C, 0x00, 0xE0, 0x60, 0x0E, 0x07, 0x00, 0x60, 0x38,
  0x06, 0x01, 0x80, 0x70, 0x0C, 0x07, 0x00, 0xE0, 0x70, 0x07, 0x03, 0x00,
  0x30, 0x30, 0x01, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0C, 0x00, 0x00, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x80, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x80, 0x0E, 0x0C, 0x03, 0xC0, 0xFF, 0xF8, 0x07,
  0xFE, 0x00, 0x00, 0x01, 0xC0, 0x01, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00,
  0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x8F,
  0xC0, 0x33, 0xFE, 0x07, 0x70, 0xF0, 0x7C, 0x03, 0x87, 0x80, 0x38, 0x70,
  0x01, 0x87, 0x00, 0x1C, 0xE0, 0x01, 0xCE, 0x00, 0x1C, 0xE0, 0x01, 0xCE,
  0x00, 0x18, 0xE0, 0x01, 0x8E, 0x00, 0x38, 0xE0, 0x03, 0x06, 0x00, 0x70,
  0x60, 0x07, 0x07, 0x00, 0xE0, 0x38, 0x3C, 0x03, 0xFF, 0x80, 0x0F, 0xE0,
  0x00, 0x3F, 0xFF, 0xF3, 0xFF, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00,
  0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x03, 0xFE, 0x00, 0x7F, 0xF8, 0x03, 0x81, 0xE0, 0x38, 0x07, 0x03, 0x80,
  0x18, 0x1C, 0x00, 0xE0, 0xC0, 0x07, 0x06, 0x00, 0x30, 0x30, 0x01, 0x81,
  0xC0, 0x1C, 0x0E, 0x01, 0xC0, 0x38, 0x1C, 0x01, 0xC1, 0xC0, 0x07, 0xBC,
  0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x1E, 0xE0, 0x03, 0xC3, 0xC0, 0x38,
  0x0E, 0x03, 0x80, 0x38, 0x38, 0x00, 0xC1, 0x80, 0x07, 0x1C, 0x00, 0x38,
  0xE0, 0x01, 0xC7, 0x00, 0x0E, 0x38, 0x00, 0x71, 0xC0, 0x03, 0x0E, 0x00,
  0x38, 0x38, 0x03, 0x80, 0xE0, 0x3C, 0x07, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0x00, 0x08, 0x00, 0x07, 0xF8, 0x01, 0xFF, 0xC0, 0x38, 0x1E, 0x07, 0x00,
  0xE0, 0x60, 0x06, 0x0E, 0x00, 0x70, 0xC0, 0x07, 0x1C, 0x00, 0x71, 0xC0,
  0x07, 0x18, 0x00, 0x71, 0x80, 0x07, 0x18, 0x00, 0x71, 0x80, 0x07, 0x18,
  0x00, 0xE1, 0x80, 0x0E, 0x1C, 0x01, 0xE1, 0xE0, 0x3E, 0x0F, 0x9E, 0xE0,
  0x7F, 0xCC, 0x01, 0xF0, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x80, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x06,
  0x0F, 0x0F, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0xF0, 0xE0, 0xE0, 0x00,
  0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x00, 0xC0, 0x38, 0x06, 0x01, 0xC0,
  0x30, 0x0E, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0x80, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00,
  0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x03, 0x80, 0x00, 0x40, 0x00, 0x00, 0x00, 0xC0,
  0x0F, 0xF8, 0x3F, 0xFC, 0x18, 0x1E, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00,
  0x0E, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x70, 0x00,
  0xF0, 0x00, 0x70, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x03, 0xC0, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x70, 0x0E,
  0x00, 0x00, 0xE0, 0x70, 0x00, 0x01, 0x81, 0x80, 0x00, 0x06, 0x0C, 0x00,
  0x00, 0x1C, 0x70, 0x0F, 0xF0, 0x31, 0x80, 0x7F, 0xC0, 0xCE, 0x03, 0x83,
  0x03, 0x30, 0x18, 0x0C, 0x0C, 0xC0, 0xC0, 0x70, 0x36, 0x07, 0x01, 0x80,
  0xD8, 0x18, 0x06, 0x03, 0x60, 0xE0, 0x18, 0x1F, 0x83, 0x00, 0xE0, 0x6C,
  0x0C, 0x03, 0x01, 0xB0, 0x30, 0x0C, 0x06, 0xC0, 0xC0, 0x70, 0x33, 0x07,
  0x01, 0xC0, 0xCC, 0x0C, 0x0F, 0x06, 0x30, 0x30, 0x2C, 0x38, 0xC0, 0xE3,
  0xB1, 0xC3, 0x01, 0xFC, 0xFE, 0x0E, 0x03, 0xC1, 0xF0, 0x18, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x01, 0xC0, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x6C, 0x00, 0x03, 0xB0, 0x00, 0x0C, 0xC0,
  0x00, 0x73, 0x00, 0x01, 0x8C, 0x00, 0x0E, 0x30, 0x00, 0x30, 0xC0, 0x01,
  0xC3, 0x00, 0x06, 0x0E, 0x00, 0x38, 0x38, 0x00, 0xC0, 0xE0, 0x07, 0x03,
  0x80, 0x18, 0x0E, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x1F, 0xFF, 0x80,
  0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x0C, 0x00, 0x60, 0x70, 0x01, 0xC1, 0x80,
  0x07, 0x0E, 0x00, 0x1C, 0x30, 0x00, 0x71, 0xC0, 0x01, 0xC6, 0x00, 0x07,
  0x38, 0x00, 0x0C, 0xC0, 0x00, 0x37, 0x00, 0x00, 0xF8, 0x00, 0x03, 0x01,
  0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x18, 0x07, 0x80, 0xE0, 0x07, 0x03, 0x80,
  0x1C, 0x0C, 0x00, 0x30, 0x30, 0x00, 0xC1, 0xC0, 0x03, 0x07, 0x00, 0x0C,
  0x1C, 0x00, 0x70, 0x60, 0x01, 0xC1, 0x80, 0x0E, 0x0E, 0x00, 0x70, 0x38,
  0x07, 0x80, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x0C, 0x07, 0xC0, 0x70, 0x03,
  0x81, 0xC0, 0x06, 0x07, 0x00, 0x1C, 0x18, 0x00, 0x70, 0x60, 0x01, 0xC3,
  0x80, 0x07, 0x0E, 0x00, 0x1C, 0x30, 0x00, 0x70, 0xC0, 0x01, 0x87, 0x00,
  0x0E, 0x1C, 0x00, 0x70, 0x70, 0x03, 0xC1, 0x80, 0x7E, 0x07, 0xFF, 0xE0,
  0x3F, 0xFC, 0x00, 0x00, 0x03, 0x80, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0xC0,
  0x7C, 0x02, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0xE0, 0x30, 0x07, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0xC0, 0x01, 0xFF, 0xF0, 0x01, 0x80, 0xF8, 0x03, 0x80, 0x3C, 0x03, 0x80,
  0x1E, 0x03, 0x00, 0x0E, 0x03, 0x00, 0x06, 0x07, 0x00, 0x07, 0x07, 0x00,
  0x07, 0x07, 0x00, 0x07, 0x06, 0x00, 0x07, 0x06, 0x00, 0x07, 0x0E, 0x00,
  0x07, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x0C, 0x00, 0x07, 0x0C, 0x00,
  0x07, 0x1C, 0x00, 0x06, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x18, 0x00,
  0x0E, 0x18, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x38, 0x30, 0x00,
  0x78, 0x30, 0x00, 0x70, 0x70, 0x00, 0xE0, 0x70, 0x03, 0xC0, 0x70, 0x07,
  0x80, 0x60, 0x3F, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC0, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3F,
  0xFF, 0x01, 0xFF, 0xF0, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x30, 0x00, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x01, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC0, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xFF, 0x01, 0xF0, 0x07, 0x03, 0xC0,
  0x02, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x07, 0xFC, 0xE0, 0x0F, 0xFC, 0xE0, 0x00, 0x18, 0xC0, 0x00,
  0x18, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x38, 0xE0, 0x00, 0x30, 0xE0, 0x00,
  0x30, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x70, 0x70, 0x00,
  0x60, 0x38, 0x00, 0x60, 0x1E, 0x01, 0xE0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF,
  0x80, 0x01, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0x70, 0x18, 0x00, 0x1C, 0x0E,
  0x00, 0x07, 0x03, 0x80, 0x01, 0x80, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x38,
  0x0C, 0x00, 0x0E, 0x07, 0x00, 0x03, 0x01, 0xC0, 0x00, 0xC0, 0x60, 0x00,
  0x30, 0x18, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x03, 0x80, 0x01, 0x80, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x0C, 0x00, 0x0E, 0x07, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x18, 0x00, 0x1C, 0x06, 0x00, 0x07,
  0x03, 0x80, 0x01, 0xC0, 0xE0, 0x00, 0x60, 0x30, 0x00, 0x18, 0x0C, 0x00,
  0x0E, 0x07, 0x00, 0x03, 0x81, 0xC0, 0x00, 0xC0, 0x70, 0x00, 0x30, 0x18,
  0x00, 0x1C, 0x06, 0x00, 0x07, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xFF, 0x03,
  0xFE, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0xFF, 0x80, 0xFF,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x21, 0xE0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0x01, 0xC0, 0x07, 0x80, 0xC0,
  0x07, 0x00, 0x60, 0x07, 0x00, 0x70, 0x07, 0x00, 0x38, 0x07, 0x00, 0x18,
  0x07, 0x00, 0x0C, 0x07, 0x80, 0x0E, 0x07, 0x80, 0x07, 0x07, 0x80, 0x03,
  0x83, 0x80, 0x01, 0x83, 0x80, 0x00, 0xC3, 0x80, 0x00, 0xE3, 0x80, 0x00,
  0x73, 0x80, 0x00, 0x3B, 0xC0, 0x00, 0x1B, 0xE0, 0x00, 0x0F, 0xB8, 0x00,
  0x0F, 0x1C, 0x00, 0x07, 0x06, 0x00, 0x03, 0x03, 0x80, 0x01, 0x81, 0xC0,
  0x00, 0xC0, 0x60, 0x00, 0xE0, 0x38, 0x00, 0x70, 0x1C, 0x00, 0x30, 0x07,
  0x00, 0x18, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x00,
  0x38, 0x03, 0x00, 0x0C, 0x01, 0x80, 0x07, 0x01, 0xC0, 0x03, 0x80, 0x01,
  0xC0, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x03, 0xC0,
  0x7C, 0x00, 0x03, 0xE0, 0x36, 0x00, 0x01, 0xB0, 0x1B, 0x00, 0x01, 0xF8,
  0x0D, 0x80, 0x01, 0xDC, 0x0E, 0xE0, 0x00, 0xCC, 0x07, 0x70, 0x00, 0xE6,
  0x03, 0x38, 0x00, 0x67, 0x01, 0x8C, 0x00, 0x73, 0x80, 0xC6, 0x00, 0x31,
  0xC0, 0xE3, 0x00, 0x38, 0xC0, 0x71, 0x80, 0x18, 0x60, 0x30, 0xC0, 0x1C,
  0x70, 0x18, 0x60, 0x0C, 0x38, 0x0C, 0x38, 0x0E, 0x18, 0x0E, 0x1C, 0x06,
  0x0C, 0x07, 0x0E, 0x07, 0x0E, 0x03, 0x03, 0x03, 0x07, 0x01, 0x81, 0x83,
  0x03, 0x80, 0xC0, 0xC3, 0x81, 0x80, 0xE0, 0x61, 0x80, 0xC0, 0x70, 0x31,
  0xC0, 0xE0, 0x30, 0x18, 0xC0, 0x70, 0x18, 0x0E, 0xE0, 0x38, 0x1C, 0x07,
  0x60, 0x18, 0x0E, 0x03, 0xF0, 0x0C, 0x06, 0x00, 0xF0, 0x0E, 0x03, 0x00,
  0x78, 0x07, 0x01, 0x80, 0x38, 0x03, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x38, 0x00, 0x1C, 0x07, 0x80, 0x03, 0x01, 0xF0, 0x00,
  0x60, 0x36, 0x00, 0x0C, 0x06, 0xE0, 0x03, 0x80, 0xDC, 0x00, 0x70, 0x39,
  0x80, 0x0C, 0x07, 0x38, 0x01, 0x80, 0xE7, 0x00, 0x30, 0x18, 0x60, 0x0E,
  0x03, 0x0E, 0x01, 0xC0, 0xE1, 0xC0, 0x30, 0x1C, 0x18, 0x06, 0x03, 0x03,
  0x01, 0xC0, 0x60, 0x70, 0x38, 0x0C, 0x06, 0x06, 0x03, 0x80, 0xC0, 0xC0,
  0x70, 0x1C, 0x18, 0x0C, 0x01, 0x87, 0x01, 0x80, 0x30, 0xE0, 0x30, 0x07,
  0x18, 0x0E, 0x00, 0x63, 0x01, 0xC0, 0x0C, 0x60, 0x30, 0x01, 0xDC, 0x06,
  0x00, 0x3B, 0x81, 0xC0, 0x03, 0x60, 0x38, 0x00, 0x7C, 0x06, 0x00, 0x0F,
  0x80, 0xC0, 0x00, 0xF0, 0x18, 0x00, 0x1E, 0x07, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xF8, 0x01, 0xE0, 0x3C, 0x03,
  0x80, 0x1C, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x06, 0x1C,
  0x00, 0x07, 0x38, 0x00, 0x07, 0x38, 0x00, 0x07, 0x30, 0x00, 0x07, 0x70,
  0x00, 0x07, 0x70, 0x00, 0x07, 0x60, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xC0,
  0x00, 0x0E, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x1C, 0xE0,
  0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x70, 0x60, 0x00, 0xF0, 0x70,
  0x00, 0xE0, 0x38, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x1F, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x18, 0x1F, 0x00, 0xE0,
  0x1E, 0x03, 0x80, 0x38, 0x0C, 0x00, 0x60, 0x30, 0x01, 0x81, 0xC0, 0x07,
  0x07, 0x00, 0x1C, 0x1C, 0x00, 0x60, 0x60, 0x01, 0x81, 0x80, 0x0E, 0x0E,
  0x00, 0x38, 0x38, 0x01, 0xC0, 0xE0, 0x0E, 0x03, 0x00, 0x78, 0x0C, 0x1F,
  0xC0, 0x7F, 0xFC, 0x01, 0xFF, 0x80, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0xF8, 0x01, 0xE0, 0x3C, 0x03, 0x80, 0x1C, 0x07, 0x00, 0x0E,
  0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x06, 0x1C, 0x00, 0x07, 0x38, 0x00, 0x07,
  0x38, 0x00, 0x07, 0x30, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x07,
  0x60, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x06,
  0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x0C,
  0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x1C, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38,
  0xE0, 0x00, 0x70, 0x60, 0x00, 0xF0, 0x70, 0x00, 0xE0, 0x38, 0x03, 0xC0,
  0x3C, 0x07, 0x80, 0x1F, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x01, 0xFF, 0x80,
  0x07, 0xFF, 0x80, 0x18, 0x1F, 0x00, 0xE0, 0x1E, 0x03, 0x80, 0x38, 0x0C,
  0x00, 0x60, 0x30, 0x01, 0xC1, 0xC0, 0x07, 0x07, 0x00, 0x1C, 0x1C, 0x00,
  0x60, 0x60, 0x03, 0x81, 0x80, 0x0E, 0x0E, 0x00, 0x30, 0x38, 0x01, 0xC0,
  0xE0, 0x0E, 0x03, 0x01, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xF0, 0x01, 0xC1,
  0xC0, 0x07, 0x03, 0x00, 0x18, 0x0E, 0x00, 0x60, 0x38, 0x03, 0x80, 0x60,
  0x0E, 0x01, 0x80, 0x30, 0x07, 0x00, 0xC0, 0x1C, 0x07, 0x00, 0x30, 0x1C,
  0x00, 0xE0, 0x70, 0x03, 0x81, 0x80, 0x06, 0x06, 0x00, 0x1C, 0x38, 0x00,
  0x70, 0x00, 0x06, 0x00, 0x03, 0xFF, 0x80, 0x3F, 0xFE, 0x07, 0xC0, 0x60,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x40, 0x07, 0x83, 0x80, 0x78, 0x1F, 0xFF,
  0x80, 0x7F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0x80, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x03, 0x0E,
  0x00, 0x03, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x0C, 0x00, 0x06, 0x0C,
  0x00, 0x06, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x18,
  0x00, 0x0C, 0x18, 0x00, 0x0C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x30,
  0x00, 0x1C, 0x30, 0x00, 0x18, 0x70, 0x00, 0x18, 0x70, 0x00, 0x38, 0x70,
  0x00, 0x38, 0x60, 0x00, 0x30, 0x60, 0x00, 0x30, 0xE0, 0x00, 0x70, 0xE0,
  0x00, 0x70, 0xE0, 0x00, 0x70, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0xE0, 0xC0,
  0x00, 0xE0, 0xE0, 0x01, 0xC0, 0xE0, 0x01, 0xC0, 0x70, 0x03, 0x80, 0x78,
  0x0F, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x1C, 0xC0, 0x00, 0xE6, 0x00, 0x0E, 0x30, 0x00, 0x71,
  0x80, 0x07, 0x0C, 0x00, 0x38, 0x60, 0x03, 0x83, 0x00, 0x1C, 0x18, 0x01,
  0xC0, 0xE0, 0x0E, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x70, 0x0E,
  0x03, 0x80, 0x70, 0x38, 0x01, 0x81, 0xC0, 0x0C, 0x1C, 0x00, 0x60, 0xE0,
  0x03, 0x06, 0x00, 0x18, 0x70, 0x00, 0xC3, 0x00, 0x06, 0x38, 0x00, 0x31,
  0x80, 0x01, 0x9C, 0x00, 0x0E, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0xE0, 0x01, 0xC0, 0x03, 0xB0, 0x00, 0xF0, 0x01, 0xD8, 0x00, 0xF8, 0x01,
  0xCC, 0x00, 0x7C, 0x00, 0xE6, 0x00, 0x7E, 0x00, 0x63, 0x00, 0x37, 0x00,
  0x71, 0x80, 0x1B, 0x80, 0x30, 0xC0, 0x1D, 0xC0, 0x38, 0x60, 0x0C, 0xE0,
  0x1C, 0x30, 0x0E, 0x30, 0x0C, 0x18, 0x06, 0x18, 0x0E, 0x0C, 0x07, 0x0C,
  0x06, 0x06, 0x03, 0x06, 0x07, 0x03, 0x03, 0x83, 0x03, 0x01, 0x81, 0x81,
  0x83, 0x80, 0xC0, 0xC0, 0xC1, 0x80, 0x60, 0xE0, 0x60, 0xC0, 0x30, 0x60,
  0x30, 0xE0, 0x1C, 0x70, 0x18, 0x60, 0x0E, 0x30, 0x0C, 0x70, 0x07, 0x38,
  0x06, 0x30, 0x03, 0x98, 0x03, 0x38, 0x01, 0xCC, 0x01, 0x98, 0x00, 0xEC,
  0x00, 0xCC, 0x00, 0x76, 0x00, 0x6E, 0x00, 0x3F, 0x00, 0x36, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03,
  0xC0, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x01, 0xC0,
  0x18, 0x00, 0x60, 0x06, 0x00, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0x70, 0x0E,
  0x00, 0x0C, 0x03, 0x00, 0x03, 0x81, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x18,
  0x30, 0x00, 0x06, 0x1C, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x77, 0x00, 0x00,
  0x0D, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x03, 0xB0, 0x00, 0x01, 0xCE,
  0x00, 0x00, 0x63, 0x80, 0x00, 0x38, 0x60, 0x00, 0x1C, 0x18, 0x00, 0x06,
  0x07, 0x00, 0x03, 0x81, 0xC0, 0x01, 0xC0, 0x30, 0x00, 0xE0, 0x0E, 0x00,
  0x30, 0x03, 0x80, 0x1C, 0x00, 0x60, 0x0E, 0x00, 0x18, 0x07, 0x00, 0x07,
  0x03, 0xC0, 0x01, 0xC0, 0xE0, 0x00, 0xFE, 0x00, 0x0E, 0x60, 0x01, 0xC6,
  0x00, 0x38, 0x70, 0x03, 0x87, 0x00, 0x70, 0x70, 0x06, 0x03, 0x00, 0xE0,
  0x30, 0x1C, 0x03, 0x81, 0x80, 0x38, 0x38, 0x01, 0x87, 0x00, 0x18, 0x60,
  0x01, 0x8E, 0x00, 0x1C, 0xC0, 0x01, 0xDC, 0x00, 0x0F, 0x80, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0xC1,
  0x83, 0x06, 0x0E, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0xC3, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x70, 0x60, 0xC1, 0x83, 0x06, 0x0E, 0x1C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x87, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x00, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x07, 0xFC, 0x03,
  0xFC, 0x00, 0x00, 0x30, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00,
  0x0C, 0xC0, 0x03, 0x18, 0x00, 0xE3, 0x80, 0x18, 0x30, 0x07, 0x06, 0x00,
  0xC0, 0x60, 0x38, 0x0C, 0x06, 0x01, 0xC1, 0x80, 0x18, 0x70, 0x03, 0x0C,
  0x00, 0x73, 0x80, 0x06, 0x60, 0x00, 0xDC, 0x00, 0x0C, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE7, 0x18, 0x63, 0x0C, 0x20, 0x01, 0xFC, 0x30, 0x3F, 0xE6, 0x07,
  0x87, 0x60, 0xE0, 0x36, 0x1C, 0x01, 0xE1, 0x80, 0x1E, 0x38, 0x01, 0xC3,
  0x00, 0x1C, 0x70, 0x01, 0xC7, 0x00, 0x1C, 0x60, 0x01, 0x8E, 0x00, 0x18,
  0xE0, 0x03, 0x8E, 0x00, 0x38, 0xE0, 0x03, 0x8C, 0x00, 0x30, 0xC0, 0x07,
  0x0C, 0x00, 0x70, 0xE0, 0x0F, 0x0E, 0x01, 0xF0, 0xE0, 0x36, 0x07, 0x07,
  0x60, 0x7F, 0xC6, 0x03, 0xF8, 0x60, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x1F, 0x80, 0x67, 0xFC,
  0x0E, 0xE0, 0xE0, 0xF8, 0x06, 0x0D, 0x80, 0x70, 0xF0, 0x07, 0x0E, 0x00,
  0x71, 0xE0, 0x07, 0x1C, 0x00, 0x71, 0xC0, 0x07, 0x18, 0x00, 0x71, 0x80,
  0x07, 0x38, 0x00, 0x63, 0x80, 0x06, 0x30, 0x00, 0xE3, 0x00, 0x0E, 0x70,
  0x00, 0xC7, 0x00, 0x1C, 0x70, 0x03, 0x87, 0x80, 0x38, 0x78, 0x07, 0x0E,
  0xC0, 0xE0, 0xCF, 0xFC, 0x0C, 0x3F, 0x80, 0x00, 0xFF, 0x03, 0xFF, 0x07,
  0x81, 0x0E, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70,
  0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x78, 0x18, 0x3F, 0xF8, 0x1F, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x1F,
  0xC7, 0x00, 0xFF, 0x9C, 0x07, 0x03, 0x60, 0x38, 0x05, 0x81, 0xC0, 0x1E,
  0x06, 0x00, 0x78, 0x38, 0x00, 0xE0, 0xC0, 0x03, 0x07, 0x00, 0x1C, 0x1C,
  0x00, 0x70, 0x60, 0x01, 0xC3, 0x80, 0x06, 0x0E, 0x00, 0x18, 0x38, 0x00,
  0xE0, 0xE0, 0x03, 0x83, 0x00, 0x0E, 0x0C, 0x00, 0x70, 0x30, 0x01, 0xC0,
  0xE0, 0x0F, 0x03, 0x80, 0x7C, 0x0E, 0x03, 0xF0, 0x1C, 0x1D, 0x80, 0x7F,
  0xE6, 0x00, 0xFE, 0x18, 0x00, 0x00, 0xFE, 0x01, 0xFF, 0x81, 0xC1, 0xC1,
  0xC0, 0x71, 0xC0, 0x38, 0xC0, 0x1C, 0xE0, 0x0E, 0x60, 0x06, 0x70, 0x07,
  0x30, 0x0F, 0x18, 0x3F, 0x1F, 0xFE, 0x0F, 0xF8, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x03, 0xC0, 0x40, 0xFF, 0xE0, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07,
  0x00, 0x00, 0xDE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x7F, 0x0C, 0x03, 0xFE, 0x30, 0x1C, 0x0D, 0x80, 0xE0, 0x16, 0x07, 0x00,
  0x78, 0x18, 0x01, 0xE0, 0xE0, 0x03, 0x83, 0x00, 0x0C, 0x1C, 0x00, 0x70,
  0x70, 0x01, 0xC1, 0x80, 0x07, 0x0E, 0x00, 0x1C, 0x38, 0x00, 0x60, 0xE0,
  0x03, 0x83, 0x80, 0x0E, 0x0C, 0x00, 0x38, 0x30, 0x01, 0xC0, 0xC0, 0x07,
  0x03, 0x80, 0x3C, 0x0E, 0x01, 0xF0, 0x38, 0x0F, 0xC0, 0x70, 0x76, 0x01,
  0xFF, 0x98, 0x03, 0xF8, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0,
  0x30, 0x07, 0x00, 0xF9, 0xF8, 0x01, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x18, 0x7E, 0x03, 0x3F, 0xE0, 0xEE, 0x0E, 0x1F, 0x01, 0xC3, 0x40, 0x18,
  0x78, 0x03, 0x0E, 0x00, 0x63, 0x80, 0x0C, 0x70, 0x03, 0x8E, 0x00, 0x71,
  0x80, 0x0C, 0x30, 0x01, 0x8E, 0x00, 0x31, 0xC0, 0x0E, 0x30, 0x01, 0xC6,
  0x00, 0x31, 0xC0, 0x06, 0x38, 0x01, 0xC7, 0x00, 0x38, 0xC0, 0x07, 0x18,
  0x00, 0xC7, 0x00, 0x18, 0xE0, 0x07, 0x18, 0x00, 0xE0, 0x01, 0x81, 0xC0,
  0xE0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x01, 0x81, 0xC0, 0xE0,
  0x70, 0x30, 0x18, 0x1C, 0x0E, 0x06, 0x03, 0x01, 0x81, 0xC0, 0xE0, 0x60,
  0x30, 0x38, 0x1C, 0x0E, 0x06, 0x03, 0x03, 0x81, 0xC0, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x9E, 0x00, 0xFC,
  0x00, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x18, 0x03, 0x83, 0x00, 0xE0, 0xE0, 0x38, 0x1C, 0x0E,
  0x03, 0x03, 0x80, 0x60, 0xE0, 0x0C, 0x38, 0x03, 0x86, 0x00, 0x71, 0x80,
  0x0C, 0x70, 0x01, 0x9C, 0x00, 0x37, 0xC0, 0x0F, 0xB8, 0x01, 0xE3, 0x00,
  0x38, 0x70, 0x06, 0x0E, 0x01, 0xC0, 0xC0, 0x38, 0x1C, 0x07, 0x03, 0x80,
  0xC0, 0x30, 0x18, 0x07, 0x07, 0x00, 0x60, 0xE0, 0x0E, 0x18, 0x01, 0xC0,
  0x01, 0xC0, 0x60, 0x18, 0x0E, 0x03, 0x80, 0xC0, 0x30, 0x1C, 0x07, 0x01,
  0xC0, 0x60, 0x18, 0x0E, 0x03, 0x80, 0xE0, 0x30, 0x0C, 0x07, 0x01, 0xC0,
  0x60, 0x18, 0x06, 0x03, 0x80, 0xE0, 0x30, 0x0C, 0x07, 0x01, 0xC0, 0x70,
  0x18, 0x06, 0x03, 0x80, 0xE0, 0x30, 0x00, 0x06, 0x3F, 0x83, 0xF8, 0x0C,
  0xFF, 0x0F, 0xF8, 0x3B, 0x07, 0x38, 0x78, 0x6C, 0x06, 0xC0, 0x70, 0xF0,
  0x0F, 0x00, 0xE1, 0xC0, 0x1E, 0x01, 0xC3, 0x80, 0x38, 0x03, 0x8E, 0x00,
  0x70, 0x07, 0x1C, 0x00, 0xC0, 0x0C, 0x38, 0x03, 0x80, 0x18, 0x60, 0x07,
  0x00, 0x30, 0xC0, 0x0C, 0x00, 0xE3, 0x80, 0x18, 0x01, 0xC7, 0x00, 0x30,
  0x03, 0x0C, 0x00, 0xE0, 0x06, 0x18, 0x01, 0xC0, 0x1C, 0x70, 0x03, 0x00,
  0x38, 0xE0, 0x06, 0x00, 0x71, 0xC0, 0x1C, 0x00, 0xC3, 0x00, 0x38, 0x01,
  0x86, 0x00, 0x70, 0x07, 0x1C, 0x00, 0xC0, 0x0E, 0x38, 0x01, 0x80, 0x18,
  0x60, 0x07, 0x00, 0x30, 0x06, 0x3F, 0x80, 0xCF, 0xF8, 0x3B, 0x83, 0x87,
  0xC0, 0x70, 0xF0, 0x06, 0x1E, 0x00, 0xC3, 0x80, 0x18, 0xE0, 0x07, 0x1C,
  0x00, 0xE3, 0x80, 0x1C, 0x60, 0x03, 0x9C, 0x00, 0x63, 0x80, 0x1C, 0x70,
  0x03, 0x8C, 0x00, 0x71, 0x80, 0x0C, 0x70, 0x01, 0x8E, 0x00, 0x71, 0xC0,
  0x0E, 0x30, 0x01, 0xC6, 0x00, 0x31, 0xC0, 0x06, 0x38, 0x01, 0xC7, 0x00,
  0x38, 0x00, 0xFE, 0x00, 0x7F, 0xE0, 0x1C, 0x0E, 0x07, 0x00, 0xE1, 0xC0,
  0x1C, 0x30, 0x01, 0x8E, 0x00, 0x31, 0x80, 0x07, 0x70, 0x00, 0xEC, 0x00,
  0x19, 0x80, 0x03, 0x70, 0x00, 0x6E, 0x00, 0x1D, 0xC0, 0x03, 0xB0, 0x00,
  0x76, 0x00, 0x0C, 0xC0, 0x03, 0x98, 0x00, 0x73, 0x80, 0x1C, 0x70, 0x03,
  0x07, 0x00, 0xE0, 0xF0, 0x78, 0x0F, 0xFE, 0x00, 0xFF, 0x00, 0x01, 0x87,
  0xE0, 0x06, 0x7F, 0xC0, 0x3B, 0x83, 0x80, 0xD8, 0x06, 0x03, 0x60, 0x1C,
  0x0F, 0x00, 0x70, 0x38, 0x01, 0xC1, 0xE0, 0x07, 0x07, 0x00, 0x1C, 0x1C,
  0x00, 0x70, 0x60, 0x01, 0xC1, 0x80, 0x07, 0x0E, 0x00, 0x18, 0x38, 0x00,
  0x60, 0xC0, 0x03, 0x83, 0x00, 0x0E, 0x1C, 0x00, 0x30, 0x70, 0x01, 0xC1,
  0xC0, 0x0E, 0x07, 0x80, 0x38, 0x1E, 0x01, 0xC0, 0xEC, 0x0E, 0x03, 0xBF,
  0xF0, 0x0C, 0x3F, 0x80, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x30, 0x3F, 0xE3, 0x07, 0x03, 0x60, 0xE0, 0x16, 0x1C, 0x01, 0xE1,
  0x80, 0x1E, 0x38, 0x00, 0xE3, 0x00, 0x0C, 0x70, 0x00, 0xC7, 0x00, 0x1C,
  0x60, 0x01, 0xCE, 0x00, 0x1C, 0xE0, 0x01, 0x8E, 0x00, 0x38, 0xE0, 0x03,
  0x8C, 0x00, 0x38, 0xC0, 0x07, 0x0C, 0x00, 0x70, 0xE0, 0x0F, 0x0E, 0x01,
  0xF0, 0xE0, 0x3F, 0x07, 0x07, 0x60, 0x7F, 0xE6, 0x03, 0xF8, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x06, 0x3F, 0x06, 0x7E, 0x0E, 0xE0, 0x0D, 0x80, 0x0D,
  0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xC0, 0x00, 0x03, 0xFE, 0x03, 0xFF, 0xC3, 0x80, 0xC3, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x86,
  0x03, 0xC3, 0xFF, 0xC0, 0xFF, 0xC0, 0x03, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x0E, 0x00, 0xE0, 0x7F, 0xFF, 0xFE, 0x1C, 0x01, 0xC0, 0x18, 0x01, 0x80,
  0x38, 0x03, 0x80, 0x38, 0x03, 0x00, 0x30, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0E, 0x00,
  0xFE, 0x07, 0xE0, 0x0C, 0x00, 0x63, 0x80, 0x0C, 0x70, 0x03, 0x8E, 0x00,
  0x71, 0x80, 0x0C, 0x30, 0x01, 0x8E, 0x00, 0x31, 0xC0, 0x0E, 0x30, 0x01,
  0xC6, 0x00, 0x30, 0xC0, 0x06, 0x38, 0x00, 0xC7, 0x00, 0x38, 0xC0, 0x07,
  0x18, 0x00, 0xC7, 0x00, 0x38, 0xE0, 0x07, 0x1C, 0x01, 0xE3, 0x80, 0x3C,
  0x70, 0x0F, 0x0E, 0x03, 0x61, 0xC0, 0xCC, 0x1F, 0xF1, 0x81, 0xFC, 0x60,
  0xE0, 0x01, 0xF8, 0x00, 0xE6, 0x00, 0x31, 0x80, 0x1C, 0x60, 0x06, 0x18,
  0x03, 0x86, 0x00, 0xC1, 0x80, 0x70, 0x70, 0x18, 0x1C, 0x0E, 0x07, 0x03,
  0x01, 0xC1, 0xC0, 0x70, 0x60, 0x0C, 0x38, 0x03, 0x0C, 0x00, 0xC7, 0x00,
  0x31, 0x80, 0x0C, 0xE0, 0x03, 0x30, 0x00, 0xDC, 0x00, 0x36, 0x00, 0x0F,
  0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0xC0, 0x0C, 0x00, 0xF8, 0x03, 0x80,
  0x3B, 0x00, 0x70, 0x07, 0x60, 0x1B, 0x00, 0xCC, 0x03, 0xE0, 0x39, 0x80,
  0xDC, 0x06, 0x30, 0x19, 0x81, 0xC6, 0x07, 0x30, 0x30, 0xC0, 0xC6, 0x0E,
  0x18, 0x38, 0xC1, 0x83, 0x06, 0x18, 0x70, 0x60, 0xC3, 0x0E, 0x0C, 0x30,
  0x61, 0x81, 0x86, 0x0C, 0x70, 0x31, 0x81, 0x8C, 0x06, 0x30, 0x33, 0x80,
  0xCE, 0x06, 0x60, 0x19, 0x80, 0xDC, 0x03, 0x70, 0x1B, 0x00, 0x6C, 0x03,
  0x60, 0x0D, 0x80, 0x7C, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07,
  0x00, 0x38, 0x00, 0x03, 0x00, 0x1C, 0x0E, 0x00, 0xE0, 0x18, 0x07, 0x00,
  0x60, 0x38, 0x01, 0xC1, 0xC0, 0x03, 0x06, 0x00, 0x0C, 0x38, 0x00, 0x39,
  0xC0, 0x00, 0x6E, 0x00, 0x01, 0xB0, 0x00, 0x07, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0D, 0xC0, 0x00, 0x77, 0x00, 0x03,
  0x8C, 0x00, 0x1C, 0x38, 0x00, 0x60, 0x60, 0x03, 0x81, 0x80, 0x1C, 0x07,
  0x00, 0xE0, 0x0C, 0x07, 0x00, 0x38, 0x3C, 0x00, 0xE0, 0x00, 0xC0, 0x03,
  0x80, 0x60, 0x01, 0x80, 0x30, 0x01, 0xC0, 0x18, 0x00, 0xC0, 0x0E, 0x00,
  0xE0, 0x07, 0x00, 0x60, 0x03, 0x80, 0x70, 0x01, 0xC0, 0x30, 0x00, 0x60,
  0x38, 0x00, 0x30, 0x18, 0x00, 0x18, 0x1C, 0x00, 0x0C, 0x0C, 0x00, 0x06,
  0x0E, 0x00, 0x03, 0x06, 0x00, 0x01, 0x87, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0x73, 0x80, 0x00, 0x39, 0x80, 0x00, 0x0D, 0xC0, 0x00, 0x06, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x8F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xC1, 0xFF, 0xF0, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01,
  0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x06,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00,
  0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0x78, 0x00,
  0x70, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x00, 0x07, 0x00, 0x0E, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0xF0, 0x01, 0xF8, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1E,
  0x00, 0xFC, 0x00, 0xF0, 0x00, 0x7F, 0x00, 0x3F, 0xFC, 0x0F, 0x07, 0xFF,
  0xC0, 0x1F, 0xC0, 0x00, 0x40,
};

const GFXglyph NotoSans_SemiCondensed_LightItalic45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 10, 32, 10, 1, -32 },
  { 41, 11, 11, 15, 5, -32 },
  { 57, 24, 32, 24, 1, -32 },
  { 153, 20, 37, 22, 1, -34 },
  { 246, 27, 34, 32, 3, -33 },
  { 361, 23, 33, 26, 1, -33 },
  { 456, 4, 11, 8, 5, -32 },
  { 462, 14, 39, 12, 1, -32 },
  { 531, 13, 39, 12, -3, -32 },
  { 595, 17, 17, 21, 5, -34 },
  { 632, 19, 21, 23, 3, -26 },
  { 682, 7, 11, 9, -2, -5 },
  { 692, 11, 2, 13, 1, -13 },
  { 695, 4, 4, 10, 1, -4 },
  { 697, 20, 32, 15, -2, -32 },
  { 777, 19, 33, 22, 2, -33 },
  { 856, 11, 32, 22, 6, -32 },
  { 900, 21, 33, 22, 0, -33 },
  { 987, 21, 33, 22, 0, -33 },
  { 1074, 21, 32, 22, 0, -32 },
  { 1158, 20, 32, 22, 1, -32 },
  { 1238, 20, 33, 22, 2, -33 },
  { 1321, 20, 32, 22, 3, -32 },
  { 1401, 21, 33, 22, 1, -33 },
  { 1488, 20, 33, 22, 1, -33 },
  { 1571, 8, 24, 10, 1, -24 },
  { 1595, 11, 30, 10, -2, -24 },
  { 1637, 19, 20, 23, 3, -26 },
  { 1685, 19, 12, 23, 3, -22 },
  { 1714, 19, 20, 23, 3, -26 },
  { 1762, 16, 33, 16, 2, -33 },
  { 1828, 30, 36, 33, 2, -32 },
  { 1963, 22, 32, 22, -3, -32 },
  { 2051, 22, 32, 24, 1, -32 },
  { 2139, 22, 33, 23, 3, -33 },
  { 2230, 24, 32, 26, 1, -32 },
  { 2326, 21, 32, 21, 1, -32 },
  { 2410, 21, 32, 19, 1, -32 },
  { 2494, 24, 33, 27, 3, -33 },
  { 2593, 26, 32, 27, 1, -32 },
  { 2697, 16, 32, 12, -1, -32 },
  { 2761, 18, 40, 10, -7, -32 },
  { 2851, 25, 32, 22, 1, -32 },
  { 2951, 15, 32, 19, 1, -32 },
  { 3011, 33, 32, 34, 1, -32 },
  { 3143, 27, 32, 28, 1, -32 },
  { 3251, 24, 33, 28, 3, -33 },
  { 3350, 22, 32, 22, 1, -32 },
  { 3438, 24, 41, 28, 3, -33 },
  { 3561, 22, 32, 23, 1, -32 },
  { 3649, 21, 33, 20, 0, -33 },
  { 3736, 19, 32, 19, 4, -32 },
  { 3812, 24, 32, 27, 3, -32 },
  { 3908, 21, 32, 22, 4, -32 },
  { 3992, 33, 32, 34, 5, -32 },
  { 4124, 26, 32, 20, -3, -32 },
  { 4228, 20, 32, 19, 4, -32 },
  { 4308, 24, 32, 21, -1, -32 },
  { 4404, 17, 39, 13, -1, -32 },
  { 4487, 7, 32, 15, 5, -32 },
  { 4515, 17, 39, 13, -3, -32 },
  { 4598, 19, 18, 23, 2, -32 },
  { 4641, 16, 2, 16, -4, 4 },
  { 4645, 5, 7, 11, 7, -34 },
  { 4650, 20, 24, 23, 2, -24 },
  { 4710, 20, 34, 23, 1, -34 },
  { 4795, 16, 24, 18, 2, -24 },
  { 4843, 22, 34, 23, 2, -34 },
  { 4937, 17, 24, 20, 2, -24 },
  { 4988, 24, 45, 12, -6, -34 },
  { 5123, 22, 35, 23, 0, -24 },
  { 5220, 19, 34, 22, 1, -34 },
  { 5301, 9, 33, 10, 1, -33 },
  { 5339, 16, 44, 10, -6, -33 },
  { 5427, 19, 34, 19, 1, -34 },
  { 5508, 10, 34, 9, 1, -34 },
  { 5551, 31, 24, 34, 1, -24 },
  { 5644, 19, 24, 22, 1, -24 },
  { 5701, 19, 24, 22, 2, -24 },
  { 5758, 22, 35, 23, -1, -24 },
  { 5855, 20, 35, 23, 2, -24 },
  { 5943, 16, 24, 15, 1, -24 },
  { 5991, 17, 24, 17, 0, -24 },
  { 6042, 12, 30, 13, 2, -30 },
  { 6087, 19, 24, 23, 2, -24 },
  { 6144, 18, 24, 18, 2, -24 },
  { 6198, 27, 24, 28, 3, -24 },
  { 6279, 22, 24, 19, -2, -24 },
  { 6345, 25, 35, 18, -5, -24 },
  { 6455, 18, 24, 17, -1, -24 },
  { 6509, 16, 39, 15, 1, -32 },
  { 6587, 2, 45, 21, 10, -34 },
  { 6599, 16, 39, 15, -2, -32 },
  { 6677, 19, 5, 23, 3, -18 },
};

const GFXfont NotoSans_SemiCondensed_LightItalic45pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_LightItalic45pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_LightItalic45pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHTITALIC45PT7B_H_
