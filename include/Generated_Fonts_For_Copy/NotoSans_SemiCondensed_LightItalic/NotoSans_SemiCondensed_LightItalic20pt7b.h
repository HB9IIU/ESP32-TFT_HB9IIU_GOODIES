#ifndef _NOTOSANS_SEMICONDENSED_LIGHTITALIC20PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHTITALIC20PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-LightItalic.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_LightItalic20pt7bBitmaps[] PROGMEM = {
  0x00, 0x18, 0x84, 0x21, 0x10, 0x84, 0x21, 0x10, 0x04, 0x60, 0x4A, 0x65,
  0x29, 0x00, 0x04, 0x40, 0x88, 0x12, 0x04, 0x43, 0xFE, 0x11, 0x04, 0x40,
  0x88, 0x11, 0x1F, 0xF8, 0x88, 0x11, 0x02, 0x40, 0x88, 0x00, 0x02, 0x01,
  0x07, 0xE2, 0x42, 0x41, 0x20, 0x50, 0x18, 0x06, 0x04, 0x82, 0x41, 0x28,
  0xA3, 0xE0, 0x40, 0x20, 0x3C, 0x24, 0x44, 0x44, 0x44, 0x48, 0x85, 0x08,
  0x96, 0x8A, 0x95, 0x49, 0x25, 0x10, 0x91, 0x11, 0x11, 0x12, 0x21, 0x24,
  0x1C, 0x02, 0x01, 0xB0, 0x22, 0x08, 0x41, 0x18, 0x32, 0x03, 0x80, 0x60,
  0x34, 0x2C, 0xC9, 0x09, 0x60, 0xCC, 0x10, 0x85, 0x1F, 0x30, 0x5A, 0x80,
  0x0C, 0x42, 0x08, 0x41, 0x0C, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20,
  0x40, 0x18, 0x20, 0x82, 0x08, 0x30, 0x82, 0x08, 0x20, 0x84, 0x10, 0x82,
  0x10, 0x80, 0x08, 0x08, 0xC8, 0x3F, 0x18, 0x68, 0x44, 0x04, 0x08, 0x04,
  0x02, 0x01, 0x0F, 0xF8, 0x40, 0x20, 0x10, 0x08, 0x04, 0x00, 0x2D, 0x28,
  0xF0, 0x70, 0x00, 0x80, 0x80, 0xC0, 0x40, 0x40, 0x20, 0x20, 0x10, 0x10,
  0x08, 0x08, 0x0C, 0x04, 0x04, 0x00, 0x04, 0x1F, 0x31, 0x21, 0x41, 0x41,
  0x41, 0x81, 0x81, 0x81, 0x82, 0x82, 0x86, 0xC4, 0x78, 0x1B, 0xA4, 0x21,
  0x10, 0x84, 0x21, 0x10, 0x84, 0x20, 0x1F, 0x88, 0x40, 0x20, 0x10, 0x08,
  0x08, 0x0C, 0x04, 0x04, 0x04, 0x04, 0x04, 0x04, 0x07, 0xF8, 0x3F, 0x88,
  0x40, 0x20, 0x10, 0x08, 0x08, 0x78, 0x04, 0x01, 0x00, 0x80, 0x40, 0x28,
  0x27, 0xE0, 0x01, 0x80, 0xC0, 0xA0, 0xA0, 0x90, 0xC8, 0x44, 0x42, 0x42,
  0x41, 0x3F, 0xE0, 0x40, 0x60, 0x20, 0x0F, 0xC4, 0x01, 0x00, 0x40, 0x20,
  0x0F, 0x02, 0x30, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x82, 0x3F, 0x00,
  0x01, 0x07, 0xC4, 0x04, 0x02, 0x02, 0x01, 0x71, 0xC4, 0xC3, 0x40, 0xA0,
  0x50, 0x48, 0x26, 0x21, 0xE0, 0x7F, 0x80, 0x80, 0x40, 0x40, 0x20, 0x20,
  0x10, 0x10, 0x18, 0x08, 0x0C, 0x04, 0x06, 0x06, 0x00, 0x0F, 0x84, 0x21,
  0x0C, 0x42, 0x10, 0x86, 0xC0, 0xC0, 0xC8, 0x61, 0x10, 0x4C, 0x11, 0x04,
  0x43, 0x0F, 0x80, 0x1E, 0x21, 0x41, 0x41, 0x41, 0x41, 0x43, 0x65, 0x1A,
  0x02, 0x02, 0x04, 0x08, 0xF0, 0x13, 0x00, 0x00, 0x00, 0x04, 0xC0, 0x08,
  0xC0, 0x00, 0x00, 0x00, 0x01, 0x18, 0x84, 0x40, 0x00, 0x81, 0x83, 0x06,
  0x0C, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xF8, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x18, 0x30, 0x60, 0xC0, 0x00,
  0x7C, 0x0C, 0x08, 0x10, 0x41, 0x04, 0x10, 0x40, 0x80, 0x00, 0x0C, 0x18,
  0x00, 0x07, 0xE0, 0xC0, 0x8C, 0x02, 0x40, 0x14, 0x7C, 0xA2, 0x26, 0x22,
  0x32, 0x11, 0x90, 0x8C, 0x8C, 0xA4, 0xAD, 0x19, 0xC8, 0x00, 0x20, 0x00,
  0x82, 0x03, 0xE0, 0x01, 0x00, 0xA0, 0x28, 0x12, 0x04, 0x82, 0x20, 0x88,
  0x42, 0x1F, 0x88, 0x22, 0x09, 0x02, 0x40, 0xA0, 0x30, 0x3F, 0x10, 0x48,
  0x24, 0x12, 0x0B, 0x09, 0xF8, 0x86, 0x41, 0x20, 0xA0, 0x50, 0x28, 0x27,
  0xE0, 0x0F, 0xC6, 0x03, 0x00, 0x80, 0x40, 0x10, 0x04, 0x03, 0x00, 0x80,
  0x20, 0x0C, 0x01, 0x00, 0x60, 0x0F, 0x80, 0x3F, 0x08, 0x22, 0x04, 0x81,
  0x20, 0x58, 0x14, 0x05, 0x01, 0x40, 0xD0, 0x28, 0x1A, 0x0C, 0x86, 0x3E,
  0x00, 0x3F, 0x90, 0x08, 0x04, 0x02, 0x03, 0x01, 0xF8, 0x80, 0x40, 0x20,
  0x20, 0x10, 0x08, 0x07, 0xE0, 0x3F, 0x90, 0x08, 0x04, 0x02, 0x03, 0x01,
  0x00, 0xFC, 0x40, 0x20, 0x20, 0x10, 0x08, 0x04, 0x00, 0x0F, 0xE3, 0x00,
  0xC0, 0x10, 0x04, 0x00, 0x80, 0x10, 0x06, 0x1E, 0x80, 0x50, 0x13, 0x02,
  0x20, 0x46, 0x08, 0x7F, 0x00, 0x30, 0x24, 0x04, 0x81, 0x90, 0x22, 0x04,
  0xC0, 0x9F, 0xF2, 0x04, 0x40, 0x88, 0x12, 0x02, 0x40, 0x48, 0x11, 0x02,
  0x00, 0x3E, 0x10, 0x40, 0x81, 0x02, 0x04, 0x10, 0x20, 0x40, 0x83, 0x04,
  0x1E, 0x00, 0x03, 0x02, 0x02, 0x02, 0x02, 0x06, 0x04, 0x04, 0x04, 0x04,
  0x08, 0x08, 0x08, 0x08, 0x18, 0x10, 0xB0, 0xC0, 0x30, 0xC8, 0x62, 0x30,
  0x98, 0x24, 0x1A, 0x05, 0x81, 0xA0, 0x4C, 0x11, 0x08, 0x42, 0x18, 0x82,
  0x20, 0xC0, 0x30, 0x82, 0x08, 0x21, 0x84, 0x10, 0x41, 0x08, 0x20, 0x83,
  0xF0, 0x30, 0x0C, 0xC0, 0x73, 0x01, 0x8A, 0x0A, 0x28, 0x29, 0x21, 0x24,
  0x84, 0x92, 0x24, 0x48, 0x91, 0x24, 0x48, 0x91, 0x22, 0x8C, 0x86, 0x22,
  0x10, 0x80, 0x30, 0x26, 0x04, 0xA0, 0x94, 0x12, 0x84, 0x88, 0x91, 0x12,
  0x22, 0x46, 0xC8, 0x52, 0x0A, 0x41, 0xC8, 0x19, 0x03, 0x00, 0x02, 0x01,
  0xF8, 0x41, 0x10, 0x16, 0x02, 0x80, 0x50, 0x0E, 0x01, 0xC0, 0x70, 0x0A,
  0x01, 0x60, 0x64, 0x08, 0xC2, 0x0F, 0x80, 0x3F, 0x10, 0xC8, 0x24, 0x12,
  0x0B, 0x0D, 0x0C, 0xFC, 0x40, 0x20, 0x20, 0x10, 0x08, 0x04, 0x00, 0x02,
  0x01, 0xF8, 0x41, 0x10, 0x16, 0x02, 0x80, 0x50, 0x0E, 0x01, 0xC0, 0x70,
  0x0A, 0x01, 0x60, 0x64, 0x08, 0xC2, 0x0F, 0x80, 0x20, 0x06, 0x00, 0x60,
  0x3F, 0x10, 0xC8, 0x24, 0x12, 0x0B, 0x09, 0x0C, 0xF8, 0x44, 0x22, 0x21,
  0x10, 0x48, 0x24, 0x10, 0x1F, 0x98, 0x08, 0x04, 0x02, 0x00, 0x80, 0x20,
  0x0C, 0x02, 0x00, 0x80, 0x40, 0x68, 0x67, 0xE0, 0xFF, 0x10, 0x10, 0x10,
  0x10, 0x20, 0x20, 0x20, 0x20, 0x60, 0x40, 0x40, 0x40, 0x40, 0x30, 0x24,
  0x04, 0x81, 0x90, 0x26, 0x04, 0x80, 0x90, 0x12, 0x06, 0x40, 0x98, 0x12,
  0x02, 0x60, 0x84, 0x30, 0x7C, 0x00, 0x80, 0xC0, 0xA0, 0x50, 0x48, 0x24,
  0x22, 0x11, 0x90, 0x48, 0x28, 0x14, 0x0C, 0x06, 0x02, 0x00, 0x81, 0x07,
  0x06, 0x0A, 0x0C, 0x34, 0x28, 0x48, 0x50, 0x91, 0x22, 0x22, 0x44, 0x48,
  0x90, 0x91, 0x21, 0x22, 0xC2, 0x85, 0x05, 0x0A, 0x0C, 0x18, 0x18, 0x30,
  0x00, 0x18, 0x21, 0x08, 0x22, 0x04, 0x40, 0x50, 0x0C, 0x01, 0x80, 0x30,
  0x0A, 0x02, 0x40, 0xC4, 0x10, 0x84, 0x11, 0x03, 0x00, 0x81, 0x82, 0xC6,
  0x44, 0x48, 0x48, 0x50, 0x60, 0x20, 0x20, 0x40, 0x40, 0x40, 0x40, 0x1F,
  0xC0, 0x20, 0x18, 0x04, 0x02, 0x01, 0x00, 0xC0, 0x20, 0x10, 0x0C, 0x02,
  0x01, 0x00, 0x80, 0x3F, 0x80, 0x1E, 0x20, 0x40, 0x82, 0x04, 0x08, 0x10,
  0x20, 0x81, 0x02, 0x04, 0x08, 0x20, 0x40, 0xF0, 0x92, 0x24, 0x92, 0x44,
  0x92, 0x40, 0x1E, 0x04, 0x10, 0x20, 0x40, 0x81, 0x04, 0x08, 0x10, 0x20,
  0x41, 0x02, 0x04, 0x08, 0xF0, 0x0C, 0x14, 0x14, 0x22, 0x22, 0x42, 0x41,
  0x81, 0xFE, 0x89, 0x80, 0x1C, 0x99, 0x98, 0x48, 0x28, 0x14, 0x1A, 0x09,
  0x04, 0x86, 0x45, 0x1D, 0x80, 0x18, 0x08, 0x04, 0x02, 0x01, 0x71, 0x4C,
  0xC2, 0x41, 0x20, 0x90, 0x50, 0x28, 0x34, 0x13, 0x1A, 0x78, 0x1E, 0x65,
  0x02, 0x08, 0x10, 0x20, 0x40, 0x81, 0x81, 0xE0, 0x00, 0xC0, 0x20, 0x08,
  0x02, 0x1C, 0x8C, 0xC4, 0x11, 0x04, 0x81, 0x20, 0x48, 0x22, 0x08, 0x86,
  0x22, 0x87, 0x20, 0x1C, 0x65, 0x0A, 0x18, 0x7F, 0x20, 0x40, 0x81, 0x81,
  0xF0, 0x03, 0xC0, 0x80, 0x40, 0x10, 0x1F, 0x01, 0x00, 0xC0, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x20, 0x08, 0x06,
  0x03, 0x00, 0x0E, 0x46, 0x52, 0x08, 0x82, 0x40, 0x90, 0x24, 0x11, 0x04,
  0x43, 0x11, 0x43, 0x90, 0x08, 0x02, 0x00, 0x88, 0xC1, 0xE0, 0x18, 0x08,
  0x04, 0x02, 0x01, 0x71, 0x4C, 0xC2, 0x41, 0x20, 0x90, 0xD0, 0x48, 0x24,
  0x12, 0x0B, 0x08, 0x10, 0xC0, 0x01, 0x18, 0x84, 0x21, 0x10, 0x84, 0x23,
  0x00, 0x01, 0x03, 0x00, 0x00, 0x02, 0x06, 0x04, 0x04, 0x04, 0x04, 0x08,
  0x08, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x30, 0xE0, 0x18, 0x08, 0x04,
  0x02, 0x01, 0x09, 0x88, 0x88, 0x48, 0x28, 0x1C, 0x1A, 0x08, 0x84, 0x42,
  0x33, 0x08, 0x18, 0x84, 0x21, 0x18, 0x84, 0x21, 0x10, 0x84, 0x23, 0x00,
  0x17, 0x38, 0xA5, 0x13, 0x08, 0x48, 0x61, 0x21, 0x04, 0x84, 0x14, 0x10,
  0x90, 0x42, 0x43, 0x09, 0x08, 0x2C, 0x21, 0x80, 0x17, 0x14, 0xCC, 0x24,
  0x12, 0x09, 0x0D, 0x04, 0x82, 0x41, 0x20, 0xB0, 0x80, 0x1C, 0x33, 0x41,
  0x41, 0x81, 0x81, 0x81, 0x82, 0x82, 0xC4, 0x78, 0x0B, 0x85, 0x31, 0x84,
  0x41, 0x10, 0x44, 0x12, 0x04, 0x83, 0x20, 0x8C, 0x62, 0xF1, 0x00, 0x40,
  0x10, 0x04, 0x03, 0x00, 0x1C, 0x99, 0x50, 0x48, 0x28, 0x14, 0x0A, 0x09,
  0x04, 0x86, 0x45, 0x1C, 0x80, 0x80, 0x40, 0x20, 0x10, 0x18, 0x16, 0x50,
  0xC1, 0x02, 0x04, 0x10, 0x20, 0x40, 0x83, 0x00, 0x1E, 0x45, 0x03, 0x02,
  0x03, 0x03, 0x02, 0x05, 0x0B, 0xE0, 0x21, 0x3E, 0x84, 0x21, 0x08, 0x84,
  0x21, 0x0E, 0x00, 0x21, 0xA0, 0x90, 0x48, 0x24, 0x16, 0x12, 0x09, 0x04,
  0x86, 0x45, 0x3D, 0x00, 0x81, 0x82, 0x86, 0x84, 0x8C, 0x48, 0x58, 0x50,
  0x70, 0x60, 0x60, 0x82, 0x18, 0x61, 0x86, 0x28, 0xA2, 0x8A, 0x49, 0x24,
  0x92, 0x8A, 0x28, 0xA2, 0x8C, 0x30, 0xC3, 0x00, 0x10, 0xC4, 0x21, 0x10,
  0x28, 0x0E, 0x03, 0x00, 0xC0, 0x50, 0x22, 0x18, 0x8C, 0x30, 0x10, 0x22,
  0x08, 0x41, 0x0C, 0x40, 0x88, 0x12, 0x02, 0x40, 0x50, 0x0A, 0x01, 0x80,
  0x30, 0x04, 0x01, 0x80, 0x20, 0x08, 0x06, 0x00, 0x3F, 0x02, 0x06, 0x04,
  0x08, 0x10, 0x30, 0x20, 0x40, 0x80, 0xFC, 0x07, 0x08, 0x08, 0x08, 0x08,
  0x10, 0x10, 0x30, 0xC0, 0x20, 0x20, 0x20, 0x20, 0x20, 0x40, 0x60, 0x30,
  0xFF, 0xFF, 0xF0, 0x1C, 0x08, 0x10, 0x20, 0x40, 0x82, 0x06, 0x06, 0x10,
  0x60, 0x81, 0x02, 0x04, 0x10, 0xE0, 0x78, 0xC7, 0x80,
};

const GFXglyph NotoSans_SemiCondensed_LightItalic20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 5, 14, 5, 0, -14 },
  { 10, 5, 5, 7, 2, -14 },
  { 14, 11, 14, 11, 0, -14 },
  { 34, 9, 16, 10, 0, -15 },
  { 52, 12, 14, 14, 1, -14 },
  { 73, 11, 15, 11, 0, -15 },
  { 94, 2, 5, 4, 2, -14 },
  { 96, 6, 17, 5, 1, -14 },
  { 109, 6, 17, 5, -1, -14 },
  { 122, 8, 8, 9, 2, -15 },
  { 130, 9, 10, 10, 1, -12 },
  { 142, 3, 5, 4, -1, -2 },
  { 144, 4, 1, 6, 1, -6 },
  { 145, 2, 2, 4, 0, -2 },
  { 146, 9, 14, 6, -1, -14 },
  { 162, 8, 15, 10, 1, -15 },
  { 177, 5, 14, 10, 3, -14 },
  { 186, 9, 14, 10, 0, -14 },
  { 202, 9, 14, 10, 0, -14 },
  { 218, 9, 14, 10, 0, -14 },
  { 234, 10, 14, 10, 0, -14 },
  { 252, 9, 15, 10, 1, -15 },
  { 269, 9, 14, 10, 1, -14 },
  { 285, 10, 14, 10, 0, -14 },
  { 303, 8, 14, 10, 1, -14 },
  { 317, 4, 11, 4, 0, -11 },
  { 323, 5, 14, 4, -1, -11 },
  { 332, 9, 9, 10, 1, -12 },
  { 343, 9, 5, 10, 1, -10 },
  { 349, 9, 9, 10, 1, -12 },
  { 360, 7, 14, 7, 1, -14 },
  { 373, 13, 16, 15, 1, -14 },
  { 399, 10, 14, 10, -1, -14 },
  { 417, 9, 14, 11, 1, -14 },
  { 433, 10, 14, 10, 1, -14 },
  { 451, 10, 14, 12, 1, -14 },
  { 469, 9, 14, 9, 1, -14 },
  { 485, 9, 14, 9, 1, -14 },
  { 501, 11, 14, 12, 1, -14 },
  { 521, 11, 14, 12, 1, -14 },
  { 541, 7, 14, 5, 0, -14 },
  { 554, 8, 18, 5, -3, -14 },
  { 572, 10, 14, 10, 1, -14 },
  { 590, 6, 14, 8, 1, -14 },
  { 601, 14, 14, 15, 1, -14 },
  { 626, 11, 14, 12, 1, -14 },
  { 646, 11, 15, 13, 1, -15 },
  { 667, 9, 14, 10, 1, -14 },
  { 683, 11, 18, 13, 1, -15 },
  { 708, 9, 14, 10, 1, -14 },
  { 724, 9, 14, 9, 0, -14 },
  { 740, 8, 14, 9, 2, -14 },
  { 754, 11, 14, 12, 1, -14 },
  { 774, 9, 14, 10, 2, -14 },
  { 790, 15, 14, 15, 2, -14 },
  { 817, 11, 14, 9, -1, -14 },
  { 837, 8, 14, 9, 2, -14 },
  { 851, 10, 14, 9, 0, -14 },
  { 869, 7, 17, 6, 0, -14 },
  { 884, 3, 14, 7, 2, -14 },
  { 890, 7, 17, 6, -1, -14 },
  { 905, 8, 8, 10, 1, -14 },
  { 913, 7, 1, 7, -2, 2 },
  { 914, 3, 3, 5, 3, -15 },
  { 916, 9, 11, 10, 1, -11 },
  { 929, 9, 15, 10, 0, -15 },
  { 946, 7, 11, 8, 1, -11 },
  { 956, 10, 15, 10, 1, -15 },
  { 975, 7, 11, 9, 1, -11 },
  { 985, 10, 20, 5, -2, -15 },
  { 1010, 10, 16, 10, 0, -11 },
  { 1030, 9, 15, 10, 0, -15 },
  { 1047, 5, 15, 4, 0, -15 },
  { 1057, 8, 20, 4, -3, -15 },
  { 1077, 9, 15, 8, 0, -15 },
  { 1094, 5, 15, 4, 0, -15 },
  { 1104, 14, 11, 15, 0, -11 },
  { 1124, 9, 11, 10, 0, -11 },
  { 1137, 8, 11, 10, 1, -11 },
  { 1148, 10, 16, 10, -1, -11 },
  { 1168, 9, 16, 10, 1, -11 },
  { 1186, 7, 11, 7, 0, -11 },
  { 1196, 7, 11, 8, 0, -11 },
  { 1206, 5, 13, 6, 1, -13 },
  { 1215, 9, 11, 10, 1, -11 },
  { 1228, 8, 11, 8, 1, -11 },
  { 1239, 12, 11, 12, 1, -11 },
  { 1256, 10, 11, 8, -1, -11 },
  { 1270, 11, 16, 8, -2, -11 },
  { 1292, 8, 11, 7, 0, -11 },
  { 1303, 8, 17, 7, 0, -14 },
  { 1320, 1, 20, 9, 5, -15 },
  { 1323, 7, 17, 7, -1, -14 },
  { 1338, 9, 2, 10, 1, -8 },
};

const GFXfont NotoSans_SemiCondensed_LightItalic20pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_LightItalic20pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_LightItalic20pt7bGlyphs,
  0x20, 0x7E, 27
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHTITALIC20PT7B_H_
