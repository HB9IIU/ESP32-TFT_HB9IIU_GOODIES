#ifndef _NOTOSANS_SEMICONDENSED_LIGHTITALIC37PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHTITALIC37PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-LightItalic.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_LightItalic37pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x06, 0x06, 0x06, 0x0E, 0x0E, 0x0C, 0x0C, 0x0C, 0x0C, 0x18,
  0x18, 0x18, 0x18, 0x10, 0x30, 0x30, 0x30, 0x20, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0xE0, 0xC0, 0x71, 0xB0, 0xD8, 0xCC, 0x64, 0x36, 0x1B, 0x09, 0x84,
  0x86, 0x00, 0x00, 0x60, 0xC0, 0x04, 0x08, 0x00, 0xC1, 0x80, 0x0C, 0x18,
  0x00, 0xC1, 0x00, 0x18, 0x30, 0x01, 0x83, 0x03, 0xFF, 0xFF, 0x3F, 0xFF,
  0xF0, 0x30, 0x60, 0x03, 0x06, 0x00, 0x20, 0x40, 0x06, 0x0C, 0x00, 0x60,
  0xC0, 0x06, 0x08, 0x00, 0x41, 0x80, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x08,
  0x10, 0x01, 0x83, 0x00, 0x18, 0x30, 0x01, 0x02, 0x00, 0x30, 0x60, 0x03,
  0x06, 0x00, 0x30, 0x40, 0x06, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x30, 0x00,
  0x30, 0x00, 0xFC, 0x03, 0xFF, 0x0E, 0x23, 0x0C, 0x60, 0x18, 0x60, 0x18,
  0x40, 0x18, 0x40, 0x18, 0x40, 0x1C, 0xC0, 0x0E, 0xC0, 0x07, 0x80, 0x03,
  0xC0, 0x00, 0xF0, 0x01, 0xB8, 0x01, 0x98, 0x01, 0x0C, 0x01, 0x0C, 0x03,
  0x0C, 0x03, 0x0C, 0x03, 0x18, 0x82, 0x38, 0xFF, 0xF0, 0x7F, 0xC0, 0x06,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x10, 0xFC, 0x01,
  0x0C, 0x60, 0x18, 0x61, 0x81, 0x86, 0x0C, 0x08, 0x30, 0x60, 0xC3, 0x03,
  0x0C, 0x18, 0x10, 0x40, 0xC1, 0x86, 0x06, 0x0C, 0x60, 0x20, 0x63, 0x01,
  0x02, 0x33, 0xE8, 0x33, 0x3B, 0xC1, 0x99, 0x8F, 0x19, 0x98, 0x7F, 0x98,
  0x81, 0x38, 0xCC, 0x18, 0x0C, 0x60, 0xC0, 0xC3, 0x06, 0x06, 0x10, 0x30,
  0x61, 0x81, 0x86, 0x0C, 0x18, 0x30, 0x60, 0xC3, 0x03, 0x06, 0x30, 0x18,
  0x61, 0x80, 0x66, 0x18, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x3F, 0x80, 0x0E,
  0x18, 0x01, 0x83, 0x00, 0x60, 0x30, 0x0C, 0x06, 0x01, 0x81, 0x80, 0x30,
  0x30, 0x06, 0x0C, 0x00, 0xC3, 0x80, 0x0C, 0xE0, 0x01, 0xF0, 0x00, 0x1C,
  0x00, 0x0F, 0x80, 0x03, 0xB0, 0x01, 0xC7, 0x03, 0x30, 0x60, 0xCC, 0x06,
  0x1B, 0x80, 0xC6, 0x60, 0x0D, 0xCC, 0x01, 0xB1, 0x80, 0x1C, 0x30, 0x03,
  0x86, 0x00, 0xF0, 0xE0, 0x37, 0x0F, 0x7C, 0x60, 0xFF, 0x06, 0x00, 0x76,
  0x66, 0x64, 0xCC, 0xC0, 0x00, 0xE0, 0x38, 0x06, 0x01, 0x80, 0x60, 0x0C,
  0x03, 0x00, 0xE0, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80,
  0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x18, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0xC0,
  0x38, 0x06, 0x01, 0x80, 0x60, 0x0C, 0x07, 0x00, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x10, 0x40, 0xE1, 0x01, 0xE4, 0x00, 0xFF, 0xC0, 0xFF, 0x05, 0x00,
  0x76, 0x03, 0x88, 0x1C, 0x30, 0x20, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x0C, 0x71, 0x86,
  0x30, 0xC6, 0x18, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0x03, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x07, 0xF8, 0x1C, 0x30, 0x70,
  0x70, 0xC0, 0x63, 0x00, 0xCE, 0x01, 0x98, 0x03, 0x30, 0x06, 0xC0, 0x0D,
  0x80, 0x1B, 0x00, 0x36, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x06, 0xC0,
  0x0D, 0x80, 0x1B, 0x00, 0x76, 0x00, 0xCC, 0x01, 0x98, 0x06, 0x30, 0x0C,
  0x60, 0x30, 0x60, 0xE0, 0xFF, 0x80, 0xFC, 0x00, 0x03, 0x83, 0xC7, 0x67,
  0x6F, 0x32, 0x18, 0x0C, 0x06, 0x06, 0x03, 0x01, 0x80, 0xC0, 0xE0, 0x60,
  0x30, 0x18, 0x0C, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0xC0, 0x60, 0x30,
  0x18, 0x00, 0x00, 0x78, 0x00, 0xFF, 0x01, 0xE1, 0xC0, 0x40, 0x70, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x7F, 0xFE, 0x3F, 0xFF, 0x00,
  0x00, 0x7C, 0x01, 0xFF, 0x81, 0xE1, 0xC0, 0xC0, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0,
  0x01, 0xC0, 0x3F, 0x80, 0x1F, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x0E,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x38, 0x80, 0x38, 0x7E, 0xF8, 0x1F, 0xF8, 0x00, 0x00, 0x01,
  0x80, 0x01, 0xC0, 0x01, 0xE0, 0x01, 0xB0, 0x00, 0xF0, 0x00, 0xD8, 0x00,
  0xCC, 0x00, 0xC6, 0x00, 0xE6, 0x00, 0x63, 0x00, 0x61, 0x80, 0x60, 0xC0,
  0x60, 0x60, 0x30, 0x60, 0x30, 0x30, 0x30, 0x18, 0x30, 0x0C, 0x38, 0x06,
  0x18, 0x06, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0xFF, 0x83, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE1, 0x00, 0xE0, 0xFB,
  0xE0, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0xFF, 0x01, 0xC0, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x70, 0x00, 0x67, 0xF0, 0x6E, 0x78, 0x78, 0x1C, 0xF0, 0x0C, 0xE0, 0x0C,
  0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x1C, 0xC0, 0x18,
  0xC0, 0x18, 0xE0, 0x30, 0x60, 0x70, 0x7F, 0xE0, 0x1F, 0x80, 0x7F, 0xFF,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80,
  0x01, 0x80, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00,
  0x1C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00,
  0xC0, 0x00, 0x00, 0x78, 0x01, 0xFF, 0x01, 0xC1, 0xC0, 0xC0, 0x60, 0xC0,
  0x38, 0x60, 0x0C, 0x30, 0x06, 0x18, 0x06, 0x0C, 0x03, 0x06, 0x03, 0x01,
  0x83, 0x80, 0x67, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x39, 0xC0, 0x38, 0x70,
  0x30, 0x1C, 0x30, 0x06, 0x38, 0x03, 0x18, 0x01, 0x8C, 0x00, 0xE6, 0x00,
  0x63, 0x00, 0x31, 0xC0, 0x38, 0x60, 0x38, 0x1E, 0x78, 0x07, 0xF8, 0x00,
  0x00, 0xF0, 0x03, 0xFC, 0x07, 0x0E, 0x0E, 0x06, 0x0C, 0x03, 0x18, 0x03,
  0x18, 0x03, 0x30, 0x03, 0x30, 0x03, 0x30, 0x03, 0x30, 0x03, 0x30, 0x07,
  0x30, 0x07, 0x38, 0x0E, 0x18, 0x1E, 0x0F, 0xF6, 0x07, 0xC6, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0xEF, 0x80, 0xFF, 0x00, 0x0C, 0x71, 0xC2, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x8E, 0x30, 0x01, 0x81, 0xC0,
  0xE0, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0C, 0x0E, 0x06, 0x03, 0x03, 0x01, 0x81, 0x80, 0xC0,
  0xC0, 0x00, 0x00, 0x01, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xE0, 0x00, 0x80, 0x00, 0x07, 0x83, 0xFE, 0x30, 0x70, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x06, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x02, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0xF0, 0x78, 0x01, 0xC0, 0x0C, 0x07, 0x00, 0x06, 0x06,
  0x00, 0x06, 0x0C, 0x00, 0x03, 0x18, 0x00, 0x03, 0x30, 0x1F, 0x83, 0x30,
  0x3F, 0xC1, 0x60, 0x60, 0xC1, 0x60, 0xC0, 0x81, 0x41, 0x81, 0x83, 0xC1,
  0x81, 0x83, 0xC3, 0x01, 0x83, 0xC3, 0x01, 0x03, 0xC3, 0x03, 0x02, 0x83,
  0x03, 0x06, 0x83, 0x07, 0x06, 0x83, 0x07, 0x0C, 0x83, 0x0F, 0x18, 0xC1,
  0xF9, 0xF0, 0xC0, 0xE1, 0xE0, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x01, 0x00, 0x0F, 0x0F, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x6C, 0x00,
  0x1B, 0x00, 0x0C, 0xC0, 0x03, 0x30, 0x01, 0x8C, 0x00, 0x63, 0x00, 0x30,
  0x40, 0x0C, 0x18, 0x06, 0x06, 0x01, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x1F, 0xFE, 0x07, 0xFF, 0x83, 0x00, 0x60, 0xC0, 0x18, 0x60, 0x06, 0x18,
  0x01, 0x8C, 0x00, 0x63, 0x00, 0x0D, 0x80, 0x03, 0x60, 0x00, 0xF0, 0x00,
  0x30, 0x07, 0xFF, 0x01, 0x83, 0xE0, 0x60, 0x1C, 0x18, 0x03, 0x06, 0x00,
  0xC3, 0x80, 0x30, 0xC0, 0x0C, 0x30, 0x03, 0x0C, 0x01, 0x83, 0x00, 0xE1,
  0x80, 0x70, 0x7F, 0xF0, 0x1F, 0xF8, 0x06, 0x03, 0x81, 0x80, 0x70, 0xC0,
  0x0C, 0x30, 0x03, 0x0C, 0x00, 0xC3, 0x00, 0x31, 0xC0, 0x0C, 0x60, 0x03,
  0x18, 0x01, 0x86, 0x00, 0xE1, 0x80, 0xF0, 0xFF, 0xF8, 0x3F, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x1F, 0xFC, 0x07, 0x83, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01,
  0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x61, 0xF8, 0x06, 0x01,
  0xC0, 0x60, 0x0C, 0x06, 0x00, 0xE0, 0xE0, 0x06, 0x0C, 0x00, 0x60, 0xC0,
  0x07, 0x0C, 0x00, 0x70, 0xC0, 0x07, 0x18, 0x00, 0x71, 0x80, 0x06, 0x18,
  0x00, 0x61, 0x80, 0x06, 0x38, 0x00, 0x63, 0x00, 0x0E, 0x30, 0x00, 0xC3,
  0x00, 0x0C, 0x30, 0x01, 0x87, 0x00, 0x38, 0x60, 0x03, 0x06, 0x00, 0x60,
  0x60, 0x1E, 0x06, 0x07, 0x80, 0xFF, 0xF0, 0x0F, 0xF8, 0x00, 0x07, 0xFF,
  0x83, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0xFF, 0x81,
  0xFF, 0xC0, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x83, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0xFF, 0xC0, 0xFF, 0xE0,
  0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0xFF, 0x01, 0xE0, 0x70, 0x38, 0x01,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x02, 0x60, 0x1F, 0xCE, 0x00, 0x0C, 0xE0, 0x00, 0xCC, 0x00, 0x0C, 0xC0,
  0x01, 0x8E, 0x00, 0x18, 0x60, 0x01, 0x86, 0x00, 0x18, 0x70, 0x03, 0x83,
  0x00, 0x30, 0x38, 0x03, 0x01, 0xFF, 0xF0, 0x07, 0xFC, 0x00, 0x07, 0x00,
  0x18, 0x30, 0x00, 0xC1, 0x80, 0x06, 0x0C, 0x00, 0x30, 0x60, 0x03, 0x07,
  0x00, 0x18, 0x30, 0x00, 0xC1, 0x80, 0x06, 0x0C, 0x00, 0x70, 0x60, 0x03,
  0x06, 0x00, 0x18, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0C, 0x00, 0x60, 0x60,
  0x03, 0x06, 0x00, 0x18, 0x30, 0x00, 0xC1, 0x80, 0x06, 0x0C, 0x00, 0x60,
  0xE0, 0x03, 0x06, 0x00, 0x18, 0x30, 0x00, 0xC1, 0x80, 0x0E, 0x0C, 0x00,
  0x60, 0xE0, 0x03, 0x06, 0x00, 0x18, 0x00, 0x07, 0xF8, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x3C, 0x07,
  0xF8, 0x00, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01,
  0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x23, 0xC0,
  0x7F, 0x00, 0x78, 0x00, 0x07, 0x00, 0x70, 0x60, 0x0C, 0x06, 0x01, 0x80,
  0x60, 0x30, 0x06, 0x07, 0x00, 0xE0, 0xE0, 0x0C, 0x1C, 0x00, 0xC3, 0x80,
  0x0C, 0x70, 0x00, 0xCE, 0x00, 0x19, 0xC0, 0x01, 0xBC, 0x00, 0x1B, 0xC0,
  0x01, 0xEC, 0x00, 0x38, 0xE0, 0x03, 0x06, 0x00, 0x30, 0x60, 0x03, 0x07,
  0x00, 0x30, 0x30, 0x07, 0x03, 0x00, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x1C, 0x06, 0x00, 0xC0, 0xC0, 0x0C, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x38, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xFF, 0xFF, 0xFF,
  0x07, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x03, 0xC0,
  0x01, 0xE0, 0x78, 0x00, 0x6C, 0x1B, 0x00, 0x0D, 0x83, 0x60, 0x03, 0x60,
  0x64, 0x00, 0xEC, 0x0C, 0xC0, 0x19, 0x81, 0x98, 0x06, 0x30, 0x63, 0x00,
  0xC6, 0x0C, 0x60, 0x31, 0x81, 0x8C, 0x06, 0x30, 0x31, 0x81, 0x86, 0x0E,
  0x30, 0x30, 0xC1, 0x86, 0x0C, 0x38, 0x30, 0x41, 0x86, 0x06, 0x0C, 0x60,
  0xC0, 0xC1, 0x8C, 0x18, 0x30, 0x33, 0x03, 0x06, 0x06, 0x60, 0xC0, 0xC0,
  0xD8, 0x18, 0x18, 0x1E, 0x03, 0x03, 0x03, 0xC0, 0x60, 0xC0, 0x30, 0x0C,
  0x18, 0x06, 0x03, 0x00, 0x07, 0x00, 0x0C, 0x1C, 0x00, 0x30, 0x78, 0x01,
  0x81, 0xE0, 0x06, 0x07, 0x80, 0x18, 0x33, 0x00, 0x60, 0xCC, 0x01, 0x83,
  0x30, 0x0C, 0x0C, 0x60, 0x30, 0x31, 0x80, 0xC1, 0x86, 0x03, 0x06, 0x0C,
  0x1C, 0x18, 0x30, 0x60, 0x60, 0xC1, 0x83, 0x81, 0x86, 0x0C, 0x06, 0x18,
  0x30, 0x18, 0xC0, 0xC0, 0x33, 0x03, 0x00, 0xCC, 0x18, 0x03, 0x30, 0x60,
  0x0E, 0xC1, 0x80, 0x1E, 0x06, 0x00, 0x78, 0x18, 0x01, 0xE0, 0xC0, 0x03,
  0x83, 0x00, 0x0E, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0xF8, 0x03, 0xC3, 0xC0,
  0x70, 0x0E, 0x0E, 0x00, 0x60, 0xC0, 0x07, 0x18, 0x00, 0x31, 0x80, 0x03,
  0x30, 0x00, 0x33, 0x00, 0x03, 0x70, 0x00, 0x36, 0x00, 0x03, 0x60, 0x00,
  0x36, 0x00, 0x03, 0x60, 0x00, 0x7E, 0x00, 0x06, 0xE0, 0x00, 0x6E, 0x00,
  0x06, 0xC0, 0x00, 0xEE, 0x00, 0x0C, 0xE0, 0x01, 0xC6, 0x00, 0x18, 0x60,
  0x03, 0x87, 0x00, 0x70, 0x38, 0x0E, 0x01, 0xFF, 0xC0, 0x0F, 0xF0, 0x00,
  0x07, 0xFE, 0x01, 0x87, 0xC0, 0x60, 0x38, 0x18, 0x06, 0x06, 0x01, 0x83,
  0x80, 0x70, 0xC0, 0x1C, 0x30, 0x06, 0x0C, 0x01, 0x83, 0x00, 0x61, 0x80,
  0x38, 0x60, 0x1C, 0x18, 0x0E, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x0F, 0xF8, 0x03, 0xC3, 0xC0, 0x70, 0x0E, 0x0E, 0x00, 0x60,
  0xC0, 0x07, 0x18, 0x00, 0x31, 0x80, 0x03, 0x30, 0x00, 0x33, 0x00, 0x03,
  0x70, 0x00, 0x36, 0x00, 0x03, 0x60, 0x00, 0x36, 0x00, 0x03, 0x60, 0x00,
  0x7E, 0x00, 0x06, 0xE0, 0x00, 0x6E, 0x00, 0x06, 0xC0, 0x00, 0xEE, 0x00,
  0x0C, 0xE0, 0x01, 0xC6, 0x00, 0x18, 0x60, 0x03, 0x87, 0x00, 0x70, 0x38,
  0x0E, 0x01, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x07, 0xFE,
  0x01, 0x87, 0xC0, 0x60, 0x38, 0x18, 0x06, 0x06, 0x01, 0x83, 0x80, 0x70,
  0xC0, 0x1C, 0x30, 0x06, 0x0C, 0x01, 0x83, 0x00, 0x61, 0x80, 0x30, 0x60,
  0x1C, 0x18, 0x1E, 0x07, 0xFE, 0x03, 0xFE, 0x00, 0xC1, 0x80, 0x30, 0x30,
  0x0C, 0x0C, 0x03, 0x03, 0x01, 0xC0, 0xE0, 0x60, 0x18, 0x18, 0x06, 0x06,
  0x01, 0xC1, 0x80, 0x30, 0xE0, 0x0C, 0x30, 0x03, 0x80, 0x00, 0x3C, 0x00,
  0xFF, 0xC0, 0xE0, 0xE0, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38,
  0x80, 0x38, 0x7F, 0xF8, 0x1F, 0xF0, 0x00, 0xFF, 0xFF, 0x01, 0x80, 0x01,
  0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x07,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x0E,
  0x00, 0x38, 0x60, 0x01, 0x83, 0x00, 0x0C, 0x18, 0x00, 0x61, 0x80, 0x07,
  0x0C, 0x00, 0x30, 0x60, 0x01, 0x83, 0x00, 0x0C, 0x18, 0x00, 0x61, 0x80,
  0x06, 0x0C, 0x00, 0x30, 0x60, 0x01, 0x83, 0x00, 0x0C, 0x38, 0x00, 0xE1,
  0x80, 0x06, 0x0C, 0x00, 0x30, 0x60, 0x01, 0x83, 0x00, 0x0C, 0x38, 0x00,
  0xC1, 0xC0, 0x06, 0x0E, 0x00, 0x30, 0x30, 0x03, 0x01, 0x80, 0x38, 0x0E,
  0x03, 0x80, 0x3F, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0xE0, 0x01, 0xD8, 0x00,
  0x66, 0x00, 0x31, 0x80, 0x0C, 0x60, 0x06, 0x18, 0x01, 0x86, 0x00, 0xC1,
  0x80, 0x30, 0x60, 0x18, 0x18, 0x06, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x60, 0x08, 0x18, 0x03, 0x0C, 0x00, 0xC3, 0x00, 0x31, 0x80, 0x0C, 0x60,
  0x03, 0x30, 0x00, 0xCC, 0x00, 0x36, 0x00, 0x0D, 0x80, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0xF8, 0x01,
  0xC0, 0x1B, 0x00, 0x78, 0x03, 0x60, 0x0F, 0x00, 0xCC, 0x03, 0x60, 0x19,
  0x80, 0x6C, 0x06, 0x30, 0x19, 0x80, 0xC6, 0x03, 0x30, 0x38, 0xC0, 0xC6,
  0x06, 0x18, 0x18, 0xC0, 0xC3, 0x03, 0x18, 0x30, 0x60, 0xC3, 0x06, 0x0C,
  0x18, 0x61, 0x81, 0x86, 0x0C, 0x30, 0x30, 0xC1, 0x8E, 0x06, 0x30, 0x31,
  0x80, 0xC6, 0x06, 0x30, 0x19, 0x80, 0xCC, 0x03, 0x30, 0x19, 0x80, 0x66,
  0x03, 0x60, 0x0D, 0x80, 0x6C, 0x01, 0xB0, 0x0D, 0x00, 0x3C, 0x01, 0xE0,
  0x07, 0x80, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x38, 0x0C, 0x01, 0x80, 0x60, 0x18, 0x03, 0x01, 0xC0, 0x0C, 0x0C,
  0x00, 0x60, 0xC0, 0x03, 0x0C, 0x00, 0x1C, 0xE0, 0x00, 0x66, 0x00, 0x03,
  0x60, 0x00, 0x1F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x3C, 0x00,
  0x03, 0x60, 0x00, 0x3B, 0x00, 0x01, 0x98, 0x00, 0x18, 0x60, 0x01, 0xC3,
  0x00, 0x0C, 0x18, 0x00, 0xC0, 0xE0, 0x0C, 0x03, 0x00, 0xE0, 0x18, 0x06,
  0x00, 0xC0, 0x60, 0x03, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x07, 0x60, 0x06,
  0x60, 0x0C, 0x60, 0x0C, 0x60, 0x18, 0x30, 0x38, 0x30, 0x30, 0x30, 0x60,
  0x30, 0xE0, 0x30, 0xC0, 0x19, 0x80, 0x19, 0x80, 0x1B, 0x00, 0x1E, 0x00,
  0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00,
  0x7F, 0xFE, 0x0F, 0xFF, 0xC0, 0x01, 0xFC, 0x06, 0x00, 0x18, 0x00, 0x40,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x07, 0xF0, 0x3F,
  0xC0, 0xC3, 0x0C, 0x30, 0x41, 0x86, 0x18, 0x61, 0x86, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0x41, 0x86, 0x18, 0x61, 0x86, 0x0C, 0x30, 0x01, 0xFC, 0x00,
  0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x01,
  0xB0, 0x01, 0xB0, 0x03, 0x10, 0x03, 0x18, 0x06, 0x18, 0x04, 0x0C, 0x0C,
  0x0C, 0x18, 0x04, 0x18, 0x06, 0x30, 0x06, 0x30, 0x03, 0x60, 0x03, 0xE0,
  0x03, 0xFF, 0xF8, 0xE3, 0x0C, 0x61, 0x84, 0x03, 0xE3, 0x0F, 0xF3, 0x1C,
  0x1A, 0x18, 0x0E, 0x30, 0x0E, 0x70, 0x0E, 0x60, 0x0C, 0x60, 0x0C, 0xC0,
  0x0C, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x18, 0xC0,
  0x38, 0xC0, 0x78, 0xC0, 0x50, 0xE0, 0xB0, 0x77, 0xB0, 0x3E, 0x30, 0x03,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x7C, 0x0D, 0xFE, 0x1B, 0x06, 0x1A, 0x03, 0x1C,
  0x03, 0x1C, 0x03, 0x18, 0x03, 0x38, 0x03, 0x30, 0x03, 0x30, 0x03, 0x30,
  0x03, 0x30, 0x07, 0x60, 0x06, 0x60, 0x06, 0x60, 0x0E, 0x60, 0x0C, 0xF0,
  0x18, 0xD0, 0x38, 0xDE, 0xF0, 0x8F, 0xC0, 0x03, 0xF0, 0x3F, 0xC7, 0x02,
  0x30, 0x03, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x07, 0x00,
  0x1E, 0x70, 0x7F, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x03, 0xE3,
  0x03, 0xFC, 0xC1, 0xC1, 0xB0, 0x60, 0x38, 0x30, 0x0E, 0x1C, 0x03, 0x86,
  0x00, 0xE1, 0x80, 0x38, 0xC0, 0x0C, 0x30, 0x03, 0x0C, 0x00, 0xC3, 0x00,
  0x70, 0xC0, 0x18, 0x30, 0x06, 0x0C, 0x03, 0x83, 0x01, 0xE0, 0xC0, 0x58,
  0x38, 0x34, 0x07, 0x3B, 0x00, 0xF8, 0xC0, 0x03, 0xE0, 0x3F, 0xC7, 0x06,
  0x30, 0x33, 0x01, 0xB8, 0x0D, 0x80, 0x6C, 0x06, 0xC0, 0xE7, 0xFE, 0x3F,
  0x81, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x01,
  0x1F, 0x78, 0x7F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0xEC, 0x00, 0x30, 0x00,
  0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00,
  0x7F, 0x00, 0x3F, 0xE0, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x7E, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0xC0, 0xFF,
  0x30, 0x70, 0x6C, 0x18, 0x0E, 0x0C, 0x03, 0x87, 0x00, 0xE1, 0x80, 0x38,
  0x60, 0x0E, 0x30, 0x03, 0x0C, 0x00, 0xC3, 0x00, 0x30, 0xC0, 0x1C, 0x30,
  0x06, 0x0C, 0x01, 0x83, 0x00, 0xE0, 0xC0, 0x78, 0x30, 0x16, 0x0E, 0x0F,
  0x01, 0xCE, 0xC0, 0x3E, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x0C, 0x0E, 0x03, 0xFF, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x7C, 0x0D, 0xFE, 0x1B, 0x06,
  0x1E, 0x03, 0x1C, 0x03, 0x1C, 0x03, 0x18, 0x07, 0x38, 0x06, 0x30, 0x06,
  0x30, 0x06, 0x30, 0x06, 0x30, 0x0C, 0x60, 0x0C, 0x60, 0x0C, 0x60, 0x0C,
  0x60, 0x0C, 0xE0, 0x18, 0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x18, 0x06, 0x07,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x0C, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x30, 0x30, 0x30, 0x30, 0x30, 0x60, 0x60, 0x60, 0x60, 0xE0, 0xC0, 0xC0,
  0xC0, 0x00, 0x18, 0x00, 0x70, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x30,
  0x0F, 0x80, 0x3C, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x07, 0x0C, 0x0E,
  0x18, 0x1C, 0x18, 0x38, 0x18, 0x70, 0x18, 0x60, 0x18, 0xC0, 0x31, 0x80,
  0x33, 0x00, 0x37, 0x00, 0x3D, 0x80, 0x39, 0x80, 0x71, 0x80, 0x60, 0xC0,
  0x60, 0xC0, 0x60, 0xE0, 0xE0, 0x60, 0xC0, 0x60, 0xC0, 0x70, 0xC0, 0x30,
  0x03, 0x06, 0x06, 0x06, 0x06, 0x0E, 0x0C, 0x0C, 0x0C, 0x0C, 0x1C, 0x18,
  0x18, 0x18, 0x18, 0x30, 0x30, 0x30, 0x30, 0x30, 0x60, 0x60, 0x60, 0x60,
  0xE0, 0xC0, 0xC0, 0xC0, 0x0C, 0x78, 0x1E, 0x04, 0xFE, 0x3F, 0x86, 0xC3,
  0xB0, 0xE3, 0xC0, 0xF0, 0x31, 0xC0, 0x70, 0x18, 0xC0, 0x38, 0x0C, 0x60,
  0x18, 0x06, 0x70, 0x0C, 0x03, 0x30, 0x0C, 0x01, 0x98, 0x06, 0x01, 0x8C,
  0x03, 0x00, 0xC6, 0x01, 0x80, 0x66, 0x00, 0xC0, 0x33, 0x00, 0xC0, 0x39,
  0x80, 0x60, 0x18, 0xC0, 0x30, 0x0C, 0xE0, 0x18, 0x06, 0x60, 0x1C, 0x03,
  0x30, 0x0C, 0x03, 0x18, 0x06, 0x01, 0x80, 0x0C, 0x7C, 0x09, 0xFE, 0x1B,
  0x06, 0x1E, 0x07, 0x1C, 0x03, 0x1C, 0x03, 0x18, 0x07, 0x38, 0x06, 0x30,
  0x06, 0x30, 0x06, 0x30, 0x06, 0x70, 0x0C, 0x60, 0x0C, 0x60, 0x0C, 0x60,
  0x0C, 0x60, 0x1C, 0xE0, 0x18, 0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x18, 0x03,
  0xF0, 0x0F, 0xF0, 0x70, 0x70, 0xC0, 0x63, 0x00, 0xEE, 0x00, 0xD8, 0x01,
  0xB0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x6C, 0x00, 0xD8,
  0x01, 0xB0, 0x06, 0x60, 0x0C, 0xC0, 0x31, 0xC0, 0xC1, 0xEF, 0x01, 0xFC,
  0x00, 0x03, 0x1F, 0x00, 0x9F, 0xE0, 0x6C, 0x18, 0x1A, 0x03, 0x07, 0x00,
  0xC1, 0xC0, 0x30, 0x60, 0x0C, 0x38, 0x03, 0x0C, 0x00, 0xC3, 0x00, 0x30,
  0xC0, 0x0C, 0x30, 0x07, 0x18, 0x01, 0x86, 0x00, 0x61, 0x80, 0x38, 0x60,
  0x0C, 0x3C, 0x06, 0x0D, 0x03, 0x83, 0x73, 0xC0, 0xCF, 0xC0, 0x30, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0xE3, 0x0F, 0xF3, 0x1C,
  0x1B, 0x18, 0x0E, 0x30, 0x0E, 0x70, 0x0E, 0x60, 0x0E, 0x60, 0x0C, 0xC0,
  0x0C, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x1C, 0xC0, 0x18, 0xC0, 0x18, 0xC0,
  0x38, 0xC0, 0x78, 0xC0, 0x58, 0xE0, 0xF0, 0x73, 0xB0, 0x3E, 0x30, 0x00,
  0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x0C, 0x78, 0x4F, 0x86, 0xC0, 0x34, 0x01,
  0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x00, 0x03, 0xF0, 0x3F, 0xF1, 0xC0, 0x86, 0x00, 0x18, 0x00, 0xE0,
  0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x62, 0x03, 0x8F, 0x7C, 0x1F,
  0xE0, 0x0C, 0x04, 0x06, 0x03, 0x03, 0xFF, 0xFC, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x0C, 0x06, 0x03, 0x01, 0x81, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0xB1, 0xF8, 0x18, 0x03, 0x38, 0x06, 0x30, 0x06, 0x30, 0x06,
  0x30, 0x06, 0x30, 0x0E, 0x60, 0x0C, 0x60, 0x0C, 0x60, 0x0C, 0x60, 0x0C,
  0x60, 0x18, 0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x38, 0xC0, 0x38, 0xC0, 0x70,
  0xC0, 0x70, 0xC0, 0xB0, 0xF7, 0x30, 0x7E, 0x30, 0xC0, 0x0F, 0x00, 0x7C,
  0x01, 0xB0, 0x0E, 0xC0, 0x33, 0x01, 0xCC, 0x06, 0x18, 0x38, 0x60, 0xC1,
  0x86, 0x06, 0x18, 0x18, 0xC0, 0x63, 0x01, 0x98, 0x06, 0x60, 0x1B, 0x00,
  0x6C, 0x01, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0xC0, 0x30, 0x0F, 0x00, 0xC0,
  0x3C, 0x07, 0x01, 0xB0, 0x14, 0x06, 0xC0, 0xD0, 0x3B, 0x03, 0x60, 0xCC,
  0x19, 0x83, 0x30, 0x66, 0x18, 0xC3, 0x18, 0x63, 0x0C, 0x63, 0x0C, 0x61,
  0x8C, 0x31, 0x86, 0x60, 0xC4, 0x19, 0x81, 0x30, 0x6E, 0x04, 0xC1, 0xB0,
  0x16, 0x06, 0xC0, 0x58, 0x1E, 0x01, 0xC0, 0x78, 0x07, 0x01, 0xC0, 0x18,
  0x07, 0x00, 0x0C, 0x01, 0x87, 0x01, 0x81, 0x81, 0xC0, 0xC1, 0xC0, 0x30,
  0xC0, 0x18, 0xC0, 0x0C, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x78, 0x00, 0x76, 0x00, 0x33, 0x00, 0x31, 0x80, 0x30, 0x60,
  0x38, 0x30, 0x18, 0x18, 0x18, 0x06, 0x18, 0x03, 0x00, 0x03, 0x00, 0x30,
  0x30, 0x03, 0x03, 0x00, 0x60, 0x30, 0x06, 0x01, 0x80, 0xC0, 0x18, 0x0C,
  0x01, 0x81, 0x80, 0x18, 0x18, 0x01, 0x83, 0x00, 0x18, 0x30, 0x01, 0x86,
  0x00, 0x18, 0x60, 0x01, 0x8C, 0x00, 0x08, 0xC0, 0x00, 0x98, 0x00, 0x0D,
  0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0E, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xFE,
  0x0F, 0xFC, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x06, 0x00, 0x1C, 0x00,
  0x70, 0x00, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x07, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xFF, 0xC7, 0xFF, 0x00,
  0x00, 0x78, 0x07, 0x80, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0xE0,
  0x1C, 0x00, 0xF0, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xF8, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x03, 0xE0, 0x03, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x06, 0x40, 0x0E, 0x00, 0x78, 0x03, 0x00, 0x18, 0x00,
  0x60, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x0C, 0x00, 0x70, 0x0F, 0x80, 0x38, 0x00, 0x3E, 0x01,
  0xFF, 0x83, 0xC1, 0xFF, 0x80, 0x7C,
};

const GFXglyph NotoSans_SemiCondensed_LightItalic37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 8, 26, 8, 1, -26 },
  { 27, 9, 9, 12, 4, -26 },
  { 38, 20, 26, 20, 1, -26 },
  { 103, 16, 30, 18, 1, -28 },
  { 163, 21, 27, 26, 3, -27 },
  { 234, 19, 27, 21, 1, -27 },
  { 299, 4, 9, 7, 4, -26 },
  { 304, 11, 32, 10, 1, -26 },
  { 348, 11, 32, 10, -3, -26 },
  { 392, 14, 14, 17, 4, -28 },
  { 417, 16, 18, 19, 2, -22 },
  { 453, 6, 9, 8, -2, -4 },
  { 460, 9, 2, 11, 1, -11 },
  { 463, 3, 3, 8, 1, -3 },
  { 465, 17, 26, 12, -2, -26 },
  { 521, 15, 27, 18, 2, -27 },
  { 572, 9, 26, 18, 5, -26 },
  { 602, 17, 27, 18, 0, -27 },
  { 660, 17, 27, 18, 0, -27 },
  { 718, 17, 27, 18, 0, -27 },
  { 776, 17, 26, 18, 1, -26 },
  { 832, 16, 27, 18, 2, -27 },
  { 886, 16, 26, 18, 3, -26 },
  { 938, 17, 27, 18, 1, -27 },
  { 996, 16, 27, 18, 1, -27 },
  { 1050, 6, 20, 8, 1, -20 },
  { 1065, 9, 25, 8, -2, -20 },
  { 1094, 16, 17, 19, 2, -22 },
  { 1128, 16, 10, 19, 2, -18 },
  { 1148, 16, 17, 19, 2, -22 },
  { 1182, 12, 27, 13, 2, -27 },
  { 1223, 24, 29, 27, 2, -26 },
  { 1310, 18, 26, 18, -2, -26 },
  { 1369, 18, 26, 20, 1, -26 },
  { 1428, 19, 27, 19, 2, -27 },
  { 1493, 20, 26, 22, 1, -26 },
  { 1558, 17, 26, 17, 1, -26 },
  { 1614, 17, 26, 16, 1, -26 },
  { 1670, 20, 27, 22, 2, -27 },
  { 1738, 21, 26, 22, 1, -26 },
  { 1807, 13, 26, 10, -1, -26 },
  { 1850, 15, 33, 8, -6, -26 },
  { 1912, 20, 26, 18, 1, -26 },
  { 1977, 12, 26, 16, 1, -26 },
  { 2016, 27, 26, 28, 1, -26 },
  { 2104, 22, 26, 23, 1, -26 },
  { 2176, 20, 27, 23, 2, -27 },
  { 2244, 18, 26, 18, 1, -26 },
  { 2303, 20, 33, 23, 2, -27 },
  { 2386, 18, 26, 19, 1, -26 },
  { 2445, 17, 27, 17, 0, -27 },
  { 2503, 16, 26, 16, 3, -26 },
  { 2555, 21, 26, 22, 2, -26 },
  { 2624, 18, 26, 18, 3, -26 },
  { 2683, 27, 26, 28, 4, -26 },
  { 2771, 21, 26, 16, -2, -26 },
  { 2840, 16, 26, 16, 3, -26 },
  { 2892, 20, 26, 17, -1, -26 },
  { 2957, 14, 32, 11, -1, -26 },
  { 3013, 6, 26, 12, 4, -26 },
  { 3033, 14, 32, 11, -3, -26 },
  { 3089, 16, 16, 19, 1, -27 },
  { 3121, 13, 1, 13, -3, 4 },
  { 3123, 5, 6, 9, 5, -28 },
  { 3127, 16, 20, 19, 2, -20 },
  { 3167, 16, 28, 19, 1, -28 },
  { 3223, 13, 20, 15, 2, -20 },
  { 3256, 18, 28, 19, 2, -28 },
  { 3319, 13, 20, 16, 2, -20 },
  { 3352, 19, 37, 10, -5, -28 },
  { 3440, 18, 29, 19, 0, -20 },
  { 3506, 16, 28, 18, 1, -28 },
  { 3562, 8, 27, 8, 1, -27 },
  { 3589, 14, 36, 8, -5, -27 },
  { 3652, 16, 28, 15, 1, -28 },
  { 3708, 8, 28, 8, 1, -28 },
  { 3736, 25, 20, 28, 1, -20 },
  { 3799, 16, 20, 18, 1, -20 },
  { 3839, 15, 20, 18, 2, -20 },
  { 3877, 18, 29, 19, -1, -20 },
  { 3943, 16, 29, 19, 2, -20 },
  { 4001, 13, 20, 12, 1, -20 },
  { 4034, 14, 20, 14, 0, -20 },
  { 4069, 9, 24, 10, 2, -24 },
  { 4096, 16, 20, 19, 2, -20 },
  { 4136, 14, 20, 14, 2, -20 },
  { 4171, 22, 20, 23, 2, -20 },
  { 4226, 17, 20, 15, -1, -20 },
  { 4269, 20, 29, 15, -4, -20 },
  { 4342, 15, 20, 14, -1, -20 },
  { 4380, 13, 32, 12, 1, -26 },
  { 4432, 2, 37, 18, 8, -28 },
  { 4442, 14, 32, 12, -2, -26 },
  { 4498, 16, 4, 19, 2, -15 },
};

const GFXfont NotoSans_SemiCondensed_LightItalic37pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_LightItalic37pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_LightItalic37pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHTITALIC37PT7B_H_
