#ifndef _NOTOSANS_SEMICONDENSED_LIGHTITALIC59PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHTITALIC59PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-LightItalic.ttf
// Size: 59pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_LightItalic59pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x0E, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x08, 0x00, 0x1C,
  0x1E, 0x38, 0x3C, 0xF0, 0x71, 0xC0, 0xE3, 0x81, 0xC7, 0x07, 0x8E, 0x0E,
  0x38, 0x1C, 0x70, 0x38, 0xE0, 0x71, 0xC0, 0xC3, 0x03, 0x86, 0x07, 0x1C,
  0x0E, 0x38, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x01, 0xC0, 0x38,
  0x00, 0x01, 0x80, 0x30, 0x00, 0x03, 0x80, 0x70, 0x00, 0x03, 0x80, 0x70,
  0x00, 0x03, 0x00, 0x60, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0xE0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x0E, 0x01, 0xC0,
  0x00, 0x0E, 0x01, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x18, 0x03, 0x00, 0x00, 0x38, 0x07, 0x00,
  0x00, 0x38, 0x07, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x30, 0x06, 0x00,
  0x00, 0x70, 0x0E, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x60, 0x0C, 0x00,
  0x00, 0xE0, 0x1C, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0xC0, 0x18, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0,
  0x01, 0x80, 0x30, 0x00, 0x03, 0x80, 0x70, 0x00, 0x03, 0x80, 0x70, 0x00,
  0x03, 0x00, 0x60, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x07, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0xE0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x0E, 0x01, 0xC0, 0x00,
  0x0E, 0x01, 0xC0, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x1C, 0x03, 0x80, 0x00,
  0x1C, 0x03, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0xFC, 0xC3, 0xC0, 0x3E,
  0x18, 0x18, 0x07, 0x03, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x38, 0x1C, 0x00,
  0x07, 0x03, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x1C, 0x0C, 0x00, 0x03, 0x83,
  0x80, 0x00, 0x70, 0x70, 0x00, 0x0F, 0x0C, 0x00, 0x00, 0xF1, 0x80, 0x00,
  0x1F, 0x30, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3B, 0xE0, 0x00,
  0x06, 0x3E, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x18, 0x3C, 0x00, 0x07, 0x03,
  0x80, 0x00, 0xE0, 0x70, 0x00, 0x18, 0x0E, 0x00, 0x03, 0x01, 0xC0, 0x00,
  0x60, 0x70, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x83, 0xC1, 0x00, 0x60, 0xF0,
  0x1C, 0x0C, 0x7C, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xF0, 0x1F, 0xF8, 0x00, 0x1C, 0x03,
  0x87, 0x80, 0x07, 0x00, 0xE0, 0x70, 0x01, 0xC0, 0x38, 0x0E, 0x00, 0x38,
  0x07, 0x01, 0xC0, 0x0E, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x07, 0x00,
  0x70, 0x07, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x07, 0x00, 0x38, 0x03,
  0x80, 0xE0, 0x07, 0x00, 0x70, 0x38, 0x00, 0xE0, 0x0E, 0x0E, 0x00, 0x38,
  0x03, 0x81, 0xC0, 0x07, 0x00, 0x70, 0x70, 0x00, 0xE0, 0x0E, 0x1C, 0x00,
  0x1C, 0x01, 0xC3, 0x83, 0xC3, 0x80, 0x70, 0xE1, 0xFE, 0x70, 0x0E, 0x1C,
  0x7F, 0xEE, 0x03, 0x87, 0x1E, 0x1D, 0xC0, 0x71, 0xC7, 0x83, 0xB8, 0x1C,
  0x38, 0xE0, 0x3B, 0x87, 0x8E, 0x38, 0x07, 0x7F, 0xE3, 0x87, 0x00, 0xE7,
  0xF8, 0x70, 0xC0, 0x1C, 0x1C, 0x1C, 0x38, 0x03, 0x80, 0x07, 0x07, 0x00,
  0x70, 0x00, 0xE0, 0xE0, 0x0C, 0x00, 0x38, 0x38, 0x03, 0x80, 0x0E, 0x07,
  0x00, 0x70, 0x01, 0xC0, 0xE0, 0x0E, 0x00, 0x70, 0x1C, 0x01, 0xC0, 0x1C,
  0x03, 0x80, 0x70, 0x03, 0x80, 0x70, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xC0,
  0x38, 0x01, 0x80, 0x70, 0x07, 0x00, 0x38, 0x0E, 0x01, 0xC0, 0x07, 0x03,
  0x80, 0x70, 0x00, 0xE0, 0x70, 0x0E, 0x00, 0x1E, 0x3C, 0x03, 0x80, 0x01,
  0xFF, 0x00, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0xF8, 0x7C, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x07, 0x00, 0x70, 0x00, 0x1E,
  0x00, 0xE0, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x70, 0x03, 0x80, 0x00, 0xE0,
  0x07, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x03, 0x80, 0x3C, 0x00, 0x07, 0x00,
  0x70, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x3C, 0x1E,
  0x00, 0x00, 0x38, 0x78, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7D, 0xC0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x07, 0x83, 0xC0, 0x1E,
  0x1E, 0x07, 0x80, 0x38, 0x78, 0x07, 0x80, 0xF1, 0xE0, 0x07, 0x01, 0xC3,
  0x80, 0x0F, 0x07, 0x8F, 0x00, 0x0E, 0x0E, 0x1C, 0x00, 0x1E, 0x38, 0x38,
  0x00, 0x1C, 0xF0, 0xF0, 0x00, 0x3D, 0xC1, 0xE0, 0x00, 0x3F, 0x03, 0xC0,
  0x00, 0x7E, 0x07, 0x80, 0x00, 0x78, 0x0F, 0x00, 0x01, 0xF0, 0x0E, 0x00,
  0x07, 0xF0, 0x1E, 0x00, 0x1E, 0xE0, 0x3E, 0x00, 0xF9, 0xE0, 0x3F, 0x0F,
  0xC1, 0xE0, 0x3F, 0xFF, 0x03, 0xC0, 0x3F, 0xF8, 0x03, 0xC0, 0x06, 0x00,
  0x00, 0x00, 0x1C, 0x73, 0xCE, 0x38, 0xE3, 0x8C, 0x71, 0xC7, 0x18, 0x63,
  0x8E, 0x00, 0x00, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00,
  0xF0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00,
  0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0,
  0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x78, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x38, 0x02, 0x00, 0xE0, 0x0E, 0x03, 0x80, 0x3E,
  0x0C, 0x00, 0xFC, 0x30, 0x00, 0x7C, 0xC0, 0x10, 0x7F, 0x7F, 0xC0, 0x7F,
  0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xC0, 0x00, 0x39, 0x80, 0x01, 0xC6, 0x00,
  0x0E, 0x1C, 0x00, 0x70, 0x30, 0x07, 0xC0, 0xE0, 0x1E, 0x03, 0x80, 0x30,
  0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x03, 0xC0, 0xF0, 0x38, 0x1E, 0x07, 0x03, 0xC0, 0xE0,
  0x38, 0x1C, 0x07, 0x03, 0x80, 0xE0, 0x70, 0x1C, 0x0E, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x7B, 0xFF, 0xFF, 0x10, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x0F, 0x87, 0xC0, 0x0F, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x0F, 0x00, 0x1C, 0x07, 0x00, 0x0E, 0x07, 0x80, 0x07, 0x87, 0x80, 0x03,
  0xC3, 0xC0, 0x01, 0xE1, 0xC0, 0x00, 0xF1, 0xE0, 0x00, 0x78, 0xE0, 0x00,
  0x3C, 0xF0, 0x00, 0x1E, 0x78, 0x00, 0x0F, 0x38, 0x00, 0x07, 0x9C, 0x00,
  0x03, 0x9E, 0x00, 0x01, 0xCE, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x73, 0x80,
  0x00, 0x79, 0xC0, 0x00, 0x3D, 0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x0E, 0x70,
  0x00, 0x07, 0x38, 0x00, 0x07, 0x9C, 0x00, 0x03, 0xCE, 0x00, 0x01, 0xC7,
  0x00, 0x01, 0xE3, 0x80, 0x00, 0xF1, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x78,
  0x70, 0x00, 0x38, 0x38, 0x00, 0x3C, 0x1C, 0x00, 0x1C, 0x0F, 0x00, 0x1E,
  0x07, 0x80, 0x1E, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x1F, 0x00, 0x3E, 0x3F,
  0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x7D, 0xC1, 0xF7, 0x8F, 0x8E,
  0x3E, 0x1C, 0xF8, 0x38, 0xC0, 0xF1, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0x07, 0xE0, 0x0F, 0x80, 0x3C, 0x00,
  0xC0, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xE0, 0xFC, 0x01, 0xF0,
  0x03, 0xE0, 0x0C, 0x00, 0x1E, 0x00, 0x80, 0x00, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x80, 0x00, 0x78,
  0x0E, 0x00, 0x1F, 0x80, 0xFE, 0x0F, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0x70, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3B, 0x80, 0x00, 0x0E, 0x70, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x73,
  0xC0, 0x00, 0x1C, 0x70, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xE1, 0xC0, 0x00,
  0x78, 0x78, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x81, 0xC0, 0x00, 0xE0, 0x38,
  0x00, 0x3C, 0x07, 0x00, 0x07, 0x01, 0xE0, 0x01, 0xC0, 0x38, 0x00, 0x70,
  0x07, 0x00, 0x1E, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x80,
  0x38, 0x00, 0xE0, 0x0E, 0x00, 0x1C, 0x03, 0xC0, 0x03, 0x80, 0x70, 0x00,
  0x70, 0x1C, 0x00, 0x1C, 0x07, 0x00, 0x03, 0x81, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x80, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xF1, 0xFC, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x81, 0x00, 0x01, 0xE0,
  0x38, 0x00, 0xF8, 0x07, 0xE0, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0x02, 0x00, 0x3E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0F, 0x0F, 0xF0, 0x03, 0x8F, 0xFE, 0x00, 0xE7, 0xFF, 0xE0, 0x7B,
  0x80, 0x78, 0x1D, 0xC0, 0x0F, 0x07, 0xE0, 0x03, 0xC1, 0xF0, 0x00, 0x70,
  0x78, 0x00, 0x1E, 0x3C, 0x00, 0x07, 0x8F, 0x00, 0x01, 0xE3, 0xC0, 0x00,
  0x78, 0xE0, 0x00, 0x1E, 0x38, 0x00, 0x07, 0x8E, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0x70, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x0F, 0x0E, 0x00, 0x03, 0x83,
  0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x70, 0x1C, 0x00, 0x3C, 0x07, 0x80, 0x1E,
  0x00, 0xF0, 0x0F, 0x00, 0x3F, 0x1F, 0x80, 0x07, 0xFF, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0x07, 0xE0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x03, 0xC0, 0x38, 0x00, 0x78, 0x0F, 0x00,
  0x07, 0x01, 0xC0, 0x00, 0xE0, 0x38, 0x00, 0x1C, 0x07, 0x00, 0x03, 0x80,
  0xE0, 0x00, 0x70, 0x1C, 0x00, 0x1E, 0x03, 0x80, 0x03, 0x80, 0x78, 0x00,
  0xF0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x0F, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0xF1, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xF8, 0x00, 0x1F, 0x87, 0x80, 0x07, 0xC0, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x78, 0x00, 0x70, 0x1E, 0x00, 0x0F, 0x03, 0x80, 0x00, 0xE0,
  0xF0, 0x00, 0x1E, 0x1C, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x78, 0xF0, 0x00,
  0x0F, 0x1E, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x07, 0x07,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x38, 0x0F, 0x00, 0x0F, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0xC3, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFF,
  0x00, 0x1F, 0x87, 0xC0, 0x1E, 0x00, 0xF0, 0x1E, 0x00, 0x78, 0x0E, 0x00,
  0x1E, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0x87, 0x80, 0x01, 0xC3, 0x80,
  0x00, 0xE3, 0xC0, 0x00, 0x71, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x1C, 0x70,
  0x00, 0x0E, 0x38, 0x00, 0x07, 0x1C, 0x00, 0x03, 0x8E, 0x00, 0x03, 0xC7,
  0x00, 0x01, 0xE3, 0x80, 0x01, 0xF1, 0xE0, 0x00, 0xF8, 0xF0, 0x00, 0xF8,
  0x3C, 0x01, 0xDC, 0x1F, 0x01, 0xEE, 0x07, 0xFF, 0xCF, 0x01, 0xFF, 0xC7,
  0x00, 0x3F, 0x83, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0xF0,
  0x3C, 0x1F, 0x07, 0xC0, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xC0, 0x20, 0x00, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF8, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x03,
  0xC0, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80,
  0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0C, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0xC1, 0xF8, 0x7E, 0x0C, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x00, 0x70,
  0xE0, 0x01, 0xFF, 0x00, 0xE3, 0xC0, 0x0F, 0xFF, 0x01, 0xC7, 0x00, 0x7C,
  0x1E, 0x03, 0x9C, 0x01, 0xE0, 0x18, 0x07, 0x38, 0x03, 0x80, 0x70, 0x0E,
  0x70, 0x0E, 0x00, 0xE0, 0x1D, 0xC0, 0x38, 0x01, 0xC0, 0x3B, 0x80, 0x70,
  0x03, 0x00, 0x77, 0x01, 0xC0, 0x0E, 0x00, 0xFC, 0x03, 0x80, 0x1C, 0x01,
  0xB8, 0x0E, 0x00, 0x38, 0x07, 0x70, 0x1C, 0x00, 0xE0, 0x0E, 0xE0, 0x38,
  0x01, 0xC0, 0x1D, 0xC0, 0x70, 0x03, 0x80, 0x73, 0x80, 0xC0, 0x0F, 0x00,
  0xE6, 0x03, 0x80, 0x1C, 0x01, 0xCC, 0x07, 0x00, 0x38, 0x07, 0x18, 0x0E,
  0x00, 0xF0, 0x0E, 0x30, 0x0E, 0x03, 0xE0, 0x38, 0x60, 0x1C, 0x0E, 0xC0,
  0xE0, 0xE0, 0x3C, 0x39, 0xC3, 0xC1, 0xC0, 0x3F, 0xE1, 0xFF, 0x03, 0x80,
  0x3F, 0x83, 0xF8, 0x07, 0x00, 0x08, 0x00, 0x80, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x0E, 0x00, 0x00,
  0x3F, 0xC1, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xB8,
  0x00, 0x00, 0x3B, 0x80, 0x00, 0x07, 0x38, 0x00, 0x00, 0x73, 0x80, 0x00,
  0x0E, 0x3C, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1C, 0x1C, 0x00, 0x01, 0xC1,
  0xC0, 0x00, 0x38, 0x1C, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x70, 0x1C, 0x00,
  0x07, 0x01, 0xC0, 0x00, 0xE0, 0x1C, 0x00, 0x1E, 0x01, 0xC0, 0x01, 0xC0,
  0x1C, 0x00, 0x3C, 0x01, 0xC0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x00, 0x0E, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xE0, 0x1C, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0xE0, 0x38, 0x00, 0x0E,
  0x07, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0xF0, 0xE0,
  0x00, 0x0F, 0x1E, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x0F, 0x3C, 0x00, 0x00,
  0x73, 0x80, 0x00, 0x07, 0x78, 0x00, 0x00, 0x77, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xC0, 0x07, 0xC0, 0x0E, 0x00, 0x1F,
  0x00, 0xF0, 0x00, 0x78, 0x07, 0x80, 0x01, 0xC0, 0x38, 0x00, 0x0F, 0x01,
  0xC0, 0x00, 0x78, 0x0E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1E, 0x07, 0x80,
  0x00, 0xE0, 0x38, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x78, 0x0E, 0x00, 0x03,
  0x80, 0xF0, 0x00, 0x3C, 0x07, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x7C, 0x01,
  0xC0, 0x7F, 0x80, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0x00,
  0xFE, 0x00, 0x38, 0x00, 0x7C, 0x01, 0xC0, 0x01, 0xE0, 0x1E, 0x00, 0x07,
  0x80, 0xF0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x07, 0x81,
  0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x0E, 0x07, 0x00,
  0x00, 0x70, 0x38, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x01,
  0xC0, 0xE0, 0x00, 0x1E, 0x07, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x3E, 0x03,
  0xC0, 0x07, 0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x3F, 0xC7, 0xE0, 0x07, 0xE0, 0x03, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x01, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0x00, 0x3F, 0x00, 0x0E,
  0x00, 0x1F, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x1E, 0x00, 0xE0,
  0x00, 0x1E, 0x01, 0xC0, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x38, 0x0F, 0x00,
  0x00, 0x70, 0x1E, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x01, 0xE0, 0x70, 0x00,
  0x03, 0xC0, 0xE0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x0F, 0x07, 0x00, 0x00,
  0x1E, 0x0E, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00,
  0xF0, 0xF0, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x07,
  0x07, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x70,
  0x70, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x00, 0xF0, 0x38,
  0x00, 0x03, 0xC0, 0x70, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x3E, 0x03, 0x80,
  0x00, 0xF8, 0x07, 0x00, 0x07, 0xE0, 0x0E, 0x00, 0x1F, 0x80, 0x3C, 0x01,
  0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0x80, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xC0, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x1F,
  0xE0, 0xFE, 0x00, 0x7E, 0x00, 0x1E, 0x00, 0xF8, 0x00, 0x04, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x08, 0xF0, 0x00, 0x7F, 0xF0, 0xE0, 0x00, 0xFF, 0xF0, 0xE0, 0x00,
  0xFF, 0xF0, 0xE0, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0xF0, 0xE0, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0xE0, 0xE0, 0x00,
  0x01, 0xE0, 0xE0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x01, 0xC0, 0xF0, 0x00,
  0x01, 0xC0, 0xF0, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x03, 0xC0, 0x78, 0x00,
  0x03, 0x80, 0x3C, 0x00, 0x03, 0x80, 0x3E, 0x00, 0x03, 0x80, 0x1F, 0x80,
  0x07, 0x80, 0x0F, 0xF9, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x3C,
  0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x78, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x70,
  0x07, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x70, 0x00, 0x03,
  0xC0, 0x3C, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x38, 0x00, 0x01, 0xE0, 0x1E, 0x00,
  0x00, 0x70, 0x07, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x38, 0x00, 0x01, 0xE0,
  0x1E, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00,
  0x3C, 0x03, 0x80, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x38, 0x00,
  0x00, 0xE0, 0x0E, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x1C, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0xF0, 0x0F,
  0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x0F,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xF0, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x01, 0x87,
  0xC0, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x78, 0x00,
  0xE0, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x01,
  0xE0, 0x07, 0xC0, 0x01, 0xC0, 0x0F, 0x80, 0x01, 0xC0, 0x0F, 0x00, 0x01,
  0xC0, 0x1E, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x03,
  0x80, 0xF0, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x07,
  0x87, 0x80, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x07,
  0x3E, 0x00, 0x00, 0x0F, 0x7E, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0E,
  0xEF, 0x00, 0x00, 0x0F, 0xC7, 0x00, 0x00, 0x0F, 0x87, 0x00, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x1C,
  0x03, 0xC0, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x38,
  0x01, 0xE0, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x38,
  0x00, 0x70, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x78, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x70, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0xF0,
  0x00, 0x1C, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00,
  0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x77, 0x00, 0x00, 0x0F, 0xE0, 0x1D,
  0xC0, 0x00, 0x03, 0xB8, 0x07, 0x70, 0x00, 0x01, 0xEE, 0x01, 0xDC, 0x00,
  0x00, 0x77, 0x80, 0x77, 0x00, 0x00, 0x3D, 0xC0, 0x3D, 0xC0, 0x00, 0x0E,
  0x70, 0x0E, 0x38, 0x00, 0x07, 0x1C, 0x03, 0x8E, 0x00, 0x01, 0xC7, 0x00,
  0xE3, 0x80, 0x00, 0xE3, 0xC0, 0x38, 0xE0, 0x00, 0x38, 0xE0, 0x1E, 0x38,
  0x00, 0x1C, 0x38, 0x07, 0x0E, 0x00, 0x0F, 0x0E, 0x01, 0xC3, 0x80, 0x03,
  0x87, 0x80, 0x70, 0xE0, 0x01, 0xE1, 0xE0, 0x3C, 0x38, 0x00, 0x70, 0x70,
  0x0E, 0x07, 0x00, 0x3C, 0x1C, 0x03, 0x81, 0xC0, 0x0E, 0x07, 0x00, 0xE0,
  0x70, 0x07, 0x83, 0xC0, 0x38, 0x1C, 0x01, 0xC0, 0xF0, 0x1E, 0x07, 0x00,
  0xE0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x70, 0x1C, 0x03,
  0x80, 0x70, 0x1C, 0x07, 0x01, 0xE0, 0x1C, 0x03, 0x03, 0x80, 0x70, 0x0F,
  0x00, 0xE0, 0xE0, 0x1C, 0x03, 0x80, 0x38, 0x70, 0x07, 0x00, 0xE0, 0x0E,
  0x3C, 0x03, 0xC0, 0x38, 0x03, 0x8E, 0x00, 0xF0, 0x0E, 0x00, 0xE7, 0x80,
  0x38, 0x07, 0x00, 0x39, 0xC0, 0x0E, 0x01, 0xC0, 0x0E, 0xF0, 0x03, 0x80,
  0x70, 0x03, 0xB8, 0x01, 0xE0, 0x1C, 0x00, 0x7C, 0x00, 0x78, 0x0F, 0x00,
  0x1F, 0x00, 0x1C, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0xE0, 0x01, 0xE0,
  0x01, 0xC0, 0x38, 0x00, 0x70, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x1F, 0x00, 0x00, 0x38, 0x03, 0xE0, 0x00, 0x07, 0x00, 0x7C, 0x00,
  0x00, 0xE0, 0x0F, 0xC0, 0x00, 0x1C, 0x03, 0xB8, 0x00, 0x07, 0x80, 0x77,
  0x00, 0x00, 0xE0, 0x0E, 0xF0, 0x00, 0x1C, 0x01, 0xCE, 0x00, 0x03, 0x80,
  0x39, 0xC0, 0x00, 0xF0, 0x0F, 0x3C, 0x00, 0x1C, 0x01, 0xC3, 0x80, 0x03,
  0x80, 0x38, 0x70, 0x00, 0x70, 0x07, 0x0F, 0x00, 0x0E, 0x00, 0xE0, 0xE0,
  0x03, 0xC0, 0x3C, 0x1C, 0x00, 0x70, 0x07, 0x03, 0x80, 0x0E, 0x00, 0xE0,
  0x78, 0x01, 0xC0, 0x1C, 0x07, 0x00, 0x38, 0x07, 0x80, 0xE0, 0x0F, 0x00,
  0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x07,
  0x00, 0x70, 0x07, 0x81, 0xE0, 0x1E, 0x00, 0x70, 0x3C, 0x03, 0x80, 0x0E,
  0x07, 0x00, 0x70, 0x01, 0xE0, 0xE0, 0x0E, 0x00, 0x1C, 0x1C, 0x01, 0xC0,
  0x03, 0x87, 0x80, 0x78, 0x00, 0x78, 0xE0, 0x0E, 0x00, 0x07, 0x1C, 0x01,
  0xC0, 0x00, 0xE3, 0x80, 0x38, 0x00, 0x1E, 0x70, 0x07, 0x00, 0x01, 0xDE,
  0x01, 0xE0, 0x00, 0x3B, 0x80, 0x38, 0x00, 0x07, 0xF0, 0x07, 0x00, 0x00,
  0x7E, 0x00, 0xE0, 0x00, 0x0F, 0xC0, 0x3C, 0x00, 0x01, 0xF8, 0x07, 0x00,
  0x00, 0x1E, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x01, 0xF8, 0x3F, 0x80, 0x0F, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x0F, 0x00,
  0x78, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x1C, 0x0E,
  0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x71, 0xE0,
  0x00, 0x00, 0xE3, 0x80, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x03, 0x9C, 0x00,
  0x00, 0x07, 0x78, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x1D, 0xE0, 0x00,
  0x00, 0x3B, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00,
  0x1D, 0xC0, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x01,
  0xCE, 0x00, 0x00, 0x07, 0x9C, 0x00, 0x00, 0x0F, 0x38, 0x00, 0x00, 0x1C,
  0x70, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x78, 0x0F,
  0x80, 0x01, 0xE0, 0x0F, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x0F,
  0xF7, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0x80, 0x0E, 0x00, 0xFC, 0x00, 0xE0, 0x03, 0xC0, 0x1E, 0x00, 0x1E,
  0x01, 0xE0, 0x01, 0xE0, 0x1C, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0xE0, 0x1C,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x0F, 0x03, 0x80, 0x00,
  0xE0, 0x38, 0x00, 0x0E, 0x03, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x07,
  0x00, 0x01, 0xC0, 0x70, 0x00, 0x3C, 0x07, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0xF8, 0x0F, 0x00, 0x3F, 0x00, 0xE0, 0x1F, 0xE0, 0x0F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xF8, 0x3F, 0x80, 0x0F, 0xC0,
  0x0F, 0x80, 0x3E, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x0F, 0x01, 0xE0, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00,
  0x78, 0xF0, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x01,
  0xCF, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x07, 0x78, 0x00, 0x00, 0x0E,
  0xF0, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x7B, 0x80,
  0x00, 0x00, 0xF7, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x07, 0x9C, 0x00,
  0x00, 0x0F, 0x38, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x78, 0xE0, 0x00,
  0x00, 0xE1, 0xE0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x07, 0x03, 0x80, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0x78, 0x0F, 0x80, 0x01, 0xE0, 0x0F, 0x00, 0x07,
  0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x0E, 0x00, 0xFC, 0x00, 0xE0,
  0x03, 0xC0, 0x1E, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0xE0, 0x1C, 0x00, 0x0E,
  0x01, 0xC0, 0x00, 0xF0, 0x1C, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0xF0, 0x3C,
  0x00, 0x0E, 0x03, 0x80, 0x00, 0xE0, 0x38, 0x00, 0x0E, 0x03, 0x80, 0x01,
  0xE0, 0x78, 0x00, 0x1E, 0x07, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x3C, 0x07,
  0x00, 0x07, 0x80, 0xF0, 0x01, 0xF0, 0x0F, 0x00, 0x7E, 0x00, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x1E, 0x03, 0xC0, 0x01,
  0xE0, 0x1C, 0x00, 0x1C, 0x01, 0xC0, 0x01, 0xC0, 0x1E, 0x00, 0x1C, 0x01,
  0xE0, 0x03, 0xC0, 0x0E, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00,
  0x38, 0x00, 0x70, 0x03, 0x80, 0x07, 0x00, 0x78, 0x00, 0x78, 0x07, 0x00,
  0x07, 0x80, 0x70, 0x00, 0x38, 0x07, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x3C,
  0x0F, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x1E, 0x0E, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xF0,
  0x7E, 0x00, 0xF8, 0x00, 0xE0, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0,
  0x80, 0x00, 0xF8, 0x0E, 0x00, 0x1F, 0x00, 0xFF, 0x1F, 0xE0, 0x0F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x03, 0x80, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x0E, 0x07, 0x80, 0x00,
  0x0E, 0x07, 0x80, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x1E, 0x07, 0x00, 0x00,
  0x1E, 0x07, 0x00, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x1C, 0x0F, 0x00, 0x00,
  0x1C, 0x0E, 0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00,
  0x38, 0x1E, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00,
  0x78, 0x1C, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x00,
  0x70, 0x38, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x00,
  0xE0, 0x78, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x01,
  0xE0, 0x70, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x01,
  0xC0, 0xF0, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x07,
  0x00, 0xE0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x3F, 0xCF, 0xF0,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x0F, 0x70,
  0x00, 0x01, 0xCE, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x0E, 0x38, 0x00, 0x03,
  0xC7, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x1E, 0x1C, 0x00, 0x03, 0x83, 0xC0,
  0x00, 0xF0, 0x78, 0x00, 0x1C, 0x0F, 0x00, 0x07, 0x80, 0xE0, 0x00, 0xE0,
  0x1C, 0x00, 0x3C, 0x03, 0x80, 0x07, 0x80, 0x70, 0x00, 0xE0, 0x0E, 0x00,
  0x3C, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x38, 0x00,
  0xE0, 0x0F, 0x00, 0x1C, 0x01, 0xC0, 0x03, 0x80, 0x78, 0x00, 0x78, 0x0E,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x1C, 0x1E, 0x00, 0x03,
  0x83, 0x80, 0x00, 0x70, 0xF0, 0x00, 0x0E, 0x1C, 0x00, 0x01, 0xC7, 0x80,
  0x00, 0x38, 0xE0, 0x00, 0x07, 0x3C, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x1D,
  0xE0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7C, 0x00, 0x07, 0x70, 0x00, 0x0F, 0x80, 0x01, 0xEE, 0x00, 0x03, 0xF0,
  0x00, 0x39, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0x38, 0x00, 0x1D, 0xC0, 0x01,
  0xE7, 0x80, 0x03, 0xB8, 0x00, 0x38, 0xF0, 0x00, 0xE7, 0x00, 0x0F, 0x1E,
  0x00, 0x1C, 0xE0, 0x01, 0xC3, 0xC0, 0x07, 0x9C, 0x00, 0x78, 0x78, 0x00,
  0xE3, 0x80, 0x0E, 0x0F, 0x00, 0x1C, 0x70, 0x01, 0xC1, 0xE0, 0x07, 0x0E,
  0x00, 0x78, 0x3C, 0x00, 0xE1, 0xC0, 0x0E, 0x03, 0x80, 0x38, 0x38, 0x03,
  0xC0, 0x70, 0x07, 0x07, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0xE0, 0x1E, 0x01,
  0xC0, 0x38, 0x1C, 0x03, 0x80, 0x38, 0x0F, 0x03, 0x80, 0x70, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x00, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0x1C, 0x0E, 0x01,
  0xC0, 0xF0, 0x03, 0x81, 0xC0, 0x38, 0x1C, 0x00, 0x70, 0x70, 0x07, 0x07,
  0x80, 0x0E, 0x0E, 0x00, 0xE0, 0xE0, 0x01, 0xC3, 0xC0, 0x1C, 0x1C, 0x00,
  0x38, 0x70, 0x03, 0x87, 0x00, 0x07, 0x1E, 0x00, 0x70, 0xE0, 0x00, 0xE3,
  0x80, 0x0E, 0x3C, 0x00, 0x1C, 0x70, 0x01, 0xC7, 0x00, 0x03, 0x9C, 0x00,
  0x39, 0xE0, 0x00, 0x73, 0x80, 0x07, 0x38, 0x00, 0x0E, 0xE0, 0x00, 0xE7,
  0x00, 0x01, 0xDC, 0x00, 0x1D, 0xC0, 0x00, 0x3B, 0x80, 0x03, 0xB8, 0x00,
  0x07, 0xE0, 0x00, 0x77, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x03, 0xC0, 0x0E, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x00,
  0xE0, 0x07, 0x80, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x78, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x1C, 0x0E, 0x00,
  0x00, 0x07, 0x87, 0x80, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x00, 0x38, 0xE0,
  0x00, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1D, 0xC0, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x07, 0x8E, 0x00, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x00, 0x78, 0x3C, 0x00,
  0x00, 0x1C, 0x07, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x78,
  0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x78, 0x00,
  0xE0, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80,
  0x01, 0xC0, 0x03, 0xC0, 0x00, 0x70, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x03, 0xDC,
  0x00, 0x01, 0xE7, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x3C, 0x78, 0x00, 0x1E,
  0x0E, 0x00, 0x07, 0x03, 0x80, 0x03, 0xC0, 0xE0, 0x01, 0xE0, 0x38, 0x00,
  0x70, 0x0F, 0x00, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0x70, 0x07, 0x00, 0x1C,
  0x03, 0xC0, 0x07, 0x00, 0xE0, 0x01, 0xE0, 0x78, 0x00, 0x38, 0x3C, 0x00,
  0x0E, 0x0E, 0x00, 0x03, 0x87, 0x80, 0x00, 0xF1, 0xC0, 0x00, 0x1C, 0xE0,
  0x00, 0x07, 0x78, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0x00, 0xE0, 0x38, 0x0E, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x00, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xF0, 0x00, 0x1F,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0,
  0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0x38, 0x00, 0x03, 0x8E, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x70, 0x70,
  0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x03, 0x80, 0x07, 0x80, 0xE0, 0x01, 0xC0,
  0x38, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0x30, 0x0F,
  0x00, 0x0E, 0x03, 0x80, 0x03, 0x81, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x1C,
  0x38, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x3B, 0xC0, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE1, 0xE1, 0xC3, 0xC3, 0x83,
  0x87, 0x07, 0x06, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xF8, 0x30, 0x0F, 0xFF,
  0x1C, 0x07, 0xC0, 0xE7, 0x03, 0xE0, 0x19, 0xC1, 0xF0, 0x03, 0xE0, 0x78,
  0x00, 0xF8, 0x3C, 0x00, 0x3E, 0x0E, 0x00, 0x0F, 0x87, 0x80, 0x01, 0xE1,
  0xC0, 0x00, 0x70, 0xF0, 0x00, 0x1C, 0x38, 0x00, 0x0F, 0x0E, 0x00, 0x03,
  0xC7, 0x80, 0x00, 0xE1, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x0E, 0x1C, 0x00,
  0x07, 0x87, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x70, 0xF0, 0x00, 0x1C, 0x3C,
  0x00, 0x0F, 0x0F, 0x00, 0x03, 0xC3, 0xC0, 0x01, 0xF0, 0x70, 0x00, 0xF8,
  0x1C, 0x00, 0x3E, 0x07, 0x00, 0x1B, 0x81, 0xE0, 0x0E, 0xE0, 0x3C, 0x07,
  0x30, 0x0F, 0xCF, 0x9C, 0x01, 0xFF, 0xC7, 0x00, 0x3F, 0xC1, 0xC0, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x81, 0xF0, 0x00, 0x70, 0xFF, 0x80, 0x1E, 0x7F, 0xF8, 0x03, 0x9E, 0x0F,
  0x80, 0x77, 0x00, 0x70, 0x0E, 0xC0, 0x0F, 0x01, 0xF0, 0x00, 0xE0, 0x7E,
  0x00, 0x1C, 0x0F, 0x80, 0x03, 0x81, 0xE0, 0x00, 0x70, 0x3C, 0x00, 0x0F,
  0x07, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x38, 0x3C, 0x00, 0x07, 0x07, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x1C, 0x3C, 0x00, 0x07, 0x87, 0x00, 0x00, 0xF0,
  0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0x83, 0x80, 0x00, 0xF0, 0xF0, 0x00,
  0x1C, 0x1E, 0x00, 0x03, 0x83, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x0F,
  0x00, 0x07, 0x83, 0xF0, 0x01, 0xE0, 0x76, 0x00, 0x78, 0x0E, 0xE0, 0x1E,
  0x01, 0x8F, 0x0F, 0x80, 0x70, 0xFF, 0xE0, 0x0E, 0x0F, 0xF8, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x07,
  0xE0, 0x60, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x10, 0x1F, 0x87, 0x80, 0x7F, 0xFC,
  0x01, 0xFF, 0xC0, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x3F, 0x03, 0x80, 0x03,
  0xFF, 0x1E, 0x00, 0x3F, 0xFE, 0x70, 0x01, 0xF0, 0x39, 0xC0, 0x0F, 0x80,
  0x77, 0x00, 0x78, 0x00, 0xDC, 0x01, 0xE0, 0x01, 0xE0, 0x0F, 0x00, 0x07,
  0x80, 0x38, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x78, 0x07, 0x00, 0x01, 0xE0,
  0x3C, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x70, 0x1E,
  0x00, 0x01, 0xC0, 0x78, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x38, 0x07, 0x00,
  0x00, 0xE0, 0x1C, 0x00, 0x07, 0x80, 0x70, 0x00, 0x1E, 0x03, 0xC0, 0x00,
  0x78, 0x0F, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x7C,
  0x01, 0xC0, 0x03, 0xF0, 0x07, 0x00, 0x0F, 0x80, 0x1C, 0x00, 0x7E, 0x00,
  0x78, 0x03, 0xB8, 0x00, 0xF0, 0x1C, 0xE0, 0x03, 0xF1, 0xE3, 0x80, 0x07,
  0xFF, 0x0C, 0x00, 0x0F, 0xF0, 0x70, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xF8, 0x1E, 0x07, 0xC0,
  0x38, 0x1E, 0x00, 0xF0, 0xF0, 0x03, 0xC7, 0x80, 0x0F, 0x1C, 0x00, 0x38,
  0xF0, 0x00, 0xE3, 0x80, 0x07, 0x9E, 0x00, 0x3C, 0x70, 0x01, 0xF1, 0xC0,
  0x1F, 0x8F, 0x07, 0xF8, 0x3F, 0xFF, 0x80, 0xFF, 0xF8, 0x03, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x80, 0xFC, 0x1E, 0x01, 0xFF, 0xF8,
  0x01, 0xFF, 0xC0, 0x00, 0x60, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x82, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xFF, 0x87, 0x00, 0x7F, 0xFC, 0x60, 0x0F,
  0x81, 0xCE, 0x01, 0xF0, 0x0E, 0xE0, 0x3E, 0x00, 0x6E, 0x03, 0xC0, 0x03,
  0xE0, 0x78, 0x00, 0x3C, 0x07, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x3C, 0x0E,
  0x00, 0x03, 0xC1, 0xE0, 0x00, 0x38, 0x1C, 0x00, 0x03, 0x81, 0xC0, 0x00,
  0x38, 0x3C, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x78, 0x38, 0x00, 0x07, 0x03,
  0x80, 0x00, 0x70, 0x38, 0x00, 0x0F, 0x03, 0x80, 0x00, 0xF0, 0x78, 0x00,
  0x0F, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xE0,
  0x38, 0x00, 0x7E, 0x03, 0x80, 0x07, 0xC0, 0x38, 0x00, 0xFC, 0x03, 0xC0,
  0x1D, 0xC0, 0x1E, 0x03, 0x9C, 0x01, 0xF8, 0xF3, 0xC0, 0x0F, 0xFE, 0x38,
  0x00, 0x7F, 0xC3, 0x80, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x08,
  0x00, 0x7C, 0x00, 0xE0, 0x0F, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x3F, 0x00, 0x1C, 0x3F, 0xE0, 0x0F, 0x3F, 0xFC, 0x03, 0x9E, 0x0F,
  0x80, 0xEE, 0x00, 0xE0, 0x3F, 0x00, 0x3C, 0x0F, 0x80, 0x0F, 0x07, 0xC0,
  0x03, 0xC1, 0xF0, 0x00, 0xF0, 0x78, 0x00, 0x38, 0x1E, 0x00, 0x0E, 0x07,
  0x00, 0x03, 0x83, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x78, 0x38, 0x00, 0x1C,
  0x0E, 0x00, 0x07, 0x07, 0x80, 0x01, 0xC1, 0xE0, 0x00, 0x70, 0x70, 0x00,
  0x3C, 0x1C, 0x00, 0x0E, 0x07, 0x00, 0x03, 0x83, 0xC0, 0x00, 0xE0, 0xE0,
  0x00, 0x38, 0x38, 0x00, 0x1E, 0x0E, 0x00, 0x07, 0x03, 0x80, 0x01, 0xC1,
  0xE0, 0x00, 0x70, 0x70, 0x00, 0x3C, 0x1C, 0x00, 0x0F, 0x07, 0x00, 0x03,
  0x83, 0xC0, 0x00, 0xE0, 0xF0, 0x00, 0x38, 0x00, 0x00, 0x30, 0x03, 0xC0,
  0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x10, 0x1C, 0x00, 0x78, 0x0F, 0x00, 0x3C, 0x03,
  0x80, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x38, 0x07, 0x80, 0x0E, 0x03, 0xC0,
  0x07, 0x81, 0xE0, 0x01, 0xC0, 0x70, 0x00, 0x70, 0x38, 0x00, 0x1C, 0x1C,
  0x00, 0x07, 0x0F, 0x00, 0x03, 0x87, 0x80, 0x00, 0xE3, 0xC0, 0x00, 0x39,
  0xF0, 0x00, 0x0E, 0xFC, 0x00, 0x07, 0x77, 0x00, 0x01, 0xF9, 0xE0, 0x00,
  0x7C, 0x38, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x03, 0xC0, 0x03, 0xC0, 0x70,
  0x00, 0xE0, 0x1E, 0x00, 0x38, 0x03, 0x80, 0x0E, 0x00, 0xE0, 0x03, 0x80,
  0x3C, 0x01, 0xE0, 0x07, 0x00, 0x70, 0x01, 0xC0, 0x1C, 0x00, 0x78, 0x07,
  0x00, 0x0E, 0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x38,
  0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x78,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x00,
  0x00, 0x41, 0xF8, 0x01, 0xF8, 0x00, 0xC3, 0xFE, 0x03, 0xFF, 0x00, 0xE3,
  0xFF, 0x83, 0xFF, 0xC0, 0x73, 0xC3, 0xE3, 0xC1, 0xE0, 0x3B, 0x80, 0x73,
  0x80, 0x78, 0x1F, 0x80, 0x3B, 0x80, 0x3C, 0x0F, 0x80, 0x1D, 0x80, 0x1E,
  0x0F, 0x80, 0x0F, 0x80, 0x07, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x83, 0xC0,
  0x03, 0xC0, 0x03, 0xC1, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0xF0, 0x00, 0x70, 0x00, 0x70, 0x70, 0x00, 0x78, 0x00, 0x38,
  0x38, 0x00, 0x38, 0x00, 0x3C, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x1E, 0x00,
  0x0E, 0x00, 0x0E, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x07, 0x00, 0x07, 0x80,
  0x07, 0x83, 0x80, 0x03, 0x80, 0x03, 0xC1, 0xC0, 0x01, 0xC0, 0x01, 0xC1,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x70, 0x00,
  0x78, 0x00, 0x78, 0x38, 0x00, 0x38, 0x00, 0x38, 0x1C, 0x00, 0x1C, 0x00,
  0x1C, 0x1E, 0x00, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x83, 0x80, 0x03, 0x80, 0x03, 0x83, 0xC0, 0x01,
  0xC0, 0x01, 0xC1, 0xE0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x41, 0xFC, 0x00,
  0x61, 0xFF, 0xC0, 0x38, 0xFF, 0xF0, 0x0E, 0x78, 0x3E, 0x03, 0xB8, 0x03,
  0x80, 0xFC, 0x00, 0xF0, 0x3E, 0x00, 0x3C, 0x1F, 0x00, 0x0F, 0x07, 0xC0,
  0x03, 0xC1, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x38, 0x3C, 0x00, 0x0E, 0x0F,
  0x00, 0x03, 0x83, 0xC0, 0x01, 0xE0, 0xE0, 0x00, 0x78, 0x38, 0x00, 0x1C,
  0x1E, 0x00, 0x07, 0x07, 0x80, 0x03, 0xC1, 0xC0, 0x00, 0xF0, 0x70, 0x00,
  0x38, 0x1C, 0x00, 0x0E, 0x0F, 0x00, 0x03, 0x83, 0xC0, 0x01, 0xE0, 0xE0,
  0x00, 0x78, 0x38, 0x00, 0x1C, 0x1E, 0x00, 0x07, 0x07, 0x80, 0x01, 0xC1,
  0xC0, 0x00, 0xF0, 0x70, 0x00, 0x3C, 0x1C, 0x00, 0x0E, 0x0F, 0x00, 0x03,
  0x83, 0xC0, 0x01, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x3F,
  0xFF, 0x00, 0x3E, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x3C, 0x00, 0x78, 0x1E,
  0x00, 0x1C, 0x1E, 0x00, 0x0F, 0x0E, 0x00, 0x07, 0x8F, 0x00, 0x03, 0xC7,
  0x00, 0x00, 0xE7, 0x80, 0x00, 0x73, 0x80, 0x00, 0x79, 0xC0, 0x00, 0x3D,
  0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x0F, 0x70, 0x00, 0x07, 0x38, 0x00, 0x03,
  0x9C, 0x00, 0x01, 0xCE, 0x00, 0x01, 0xEF, 0x00, 0x00, 0xE7, 0x80, 0x00,
  0x71, 0xC0, 0x00, 0x78, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x3C, 0x38, 0x00,
  0x3C, 0x1E, 0x00, 0x1E, 0x07, 0x00, 0x1E, 0x03, 0xC0, 0x3E, 0x00, 0xFC,
  0x7E, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x08, 0x1F, 0x00, 0x00, 0xC1, 0xFF, 0x00, 0x07, 0x1F, 0xFE, 0x00,
  0x1C, 0xF0, 0x7C, 0x00, 0x77, 0x80, 0x70, 0x01, 0xD8, 0x01, 0xE0, 0x07,
  0xE0, 0x03, 0x80, 0x3F, 0x00, 0x0E, 0x00, 0xF8, 0x00, 0x38, 0x03, 0xC0,
  0x00, 0xF0, 0x0F, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x0F, 0x01, 0xE0, 0x00,
  0x38, 0x07, 0x80, 0x00, 0xE0, 0x1C, 0x00, 0x03, 0x80, 0x70, 0x00, 0x0E,
  0x03, 0xC0, 0x00, 0x38, 0x0E, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x07, 0x00,
  0xE0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0xF0, 0x1E, 0x00, 0x03, 0x80, 0x78,
  0x00, 0x0E, 0x01, 0xE0, 0x00, 0x78, 0x07, 0x80, 0x03, 0xC0, 0x1E, 0x00,
  0x0F, 0x00, 0xF8, 0x00, 0x78, 0x03, 0xB0, 0x03, 0xC0, 0x0E, 0xE0, 0x1E,
  0x00, 0x39, 0xE1, 0xF8, 0x00, 0xE3, 0xFF, 0x80, 0x07, 0x87, 0xFC, 0x00,
  0x1C, 0x07, 0x80, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xFE, 0x1C,
  0x03, 0xFF, 0xE3, 0x00, 0xF8, 0x1C, 0xE0, 0x3E, 0x01, 0xDC, 0x0F, 0x80,
  0x1B, 0x81, 0xE0, 0x03, 0xF0, 0x78, 0x00, 0x3C, 0x0E, 0x00, 0x07, 0x83,
  0xC0, 0x00, 0xF0, 0x70, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0x83, 0x80, 0x00,
  0x70, 0x70, 0x00, 0x0E, 0x1E, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x78, 0x70,
  0x00, 0x0E, 0x0E, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x78, 0x38, 0x00, 0x0F,
  0x0F, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x0F, 0x07, 0x80,
  0x03, 0xE0, 0x70, 0x00, 0xFC, 0x0E, 0x00, 0x1F, 0x01, 0xC0, 0x07, 0xE0,
  0x3C, 0x01, 0xDC, 0x03, 0xC0, 0x73, 0x80, 0x7E, 0x3C, 0xF0, 0x07, 0xFF,
  0x1C, 0x00, 0x7F, 0x83, 0x80, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x0C, 0x3F, 0xC0, 0xE3,
  0xFC, 0x07, 0x3E, 0x20, 0x3B, 0x80, 0x01, 0xD8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0xE0, 0x3F,
  0xFF, 0xC0, 0xF0, 0x0E, 0x07, 0x80, 0x08, 0x3C, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0xC0, 0x07,
  0x83, 0xE0, 0xFC, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80,
  0x03, 0x80, 0x07, 0x80, 0x7F, 0xFF, 0x7F, 0xFF, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x70, 0x00,
  0x78, 0x40, 0x7F, 0xC0, 0x3F, 0xC0, 0x07, 0x00, 0x0F, 0x00, 0x03, 0x87,
  0x00, 0x03, 0xC3, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0xE1, 0xE0, 0x00, 0x70,
  0xF0, 0x00, 0x38, 0x70, 0x00, 0x3C, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x0E,
  0x1E, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x87, 0x00, 0x03, 0xC3, 0x80, 0x01,
  0xC1, 0xC0, 0x00, 0xE1, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x78, 0x70, 0x00,
  0x3C, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x1E, 0x00, 0x0F, 0x0E, 0x00,
  0x07, 0x87, 0x00, 0x07, 0x83, 0x80, 0x03, 0xC1, 0xC0, 0x03, 0xE0, 0xE0,
  0x01, 0xF0, 0x70, 0x01, 0xB8, 0x38, 0x01, 0xF8, 0x1E, 0x01, 0xDC, 0x0F,
  0xC7, 0xCE, 0x03, 0xFF, 0xC7, 0x00, 0xFF, 0x83, 0x80, 0x04, 0x00, 0x00,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7B, 0xC0, 0x00, 0xE7, 0x80, 0x03, 0xC7,
  0x00, 0x07, 0x0E, 0x00, 0x1E, 0x1C, 0x00, 0x38, 0x38, 0x00, 0xF0, 0x70,
  0x01, 0xC0, 0xE0, 0x07, 0x81, 0xC0, 0x0E, 0x03, 0x80, 0x3C, 0x07, 0x00,
  0x70, 0x0E, 0x01, 0xE0, 0x1E, 0x03, 0x80, 0x1C, 0x0F, 0x00, 0x38, 0x1C,
  0x00, 0x70, 0x78, 0x00, 0xE0, 0xE0, 0x01, 0xC3, 0xC0, 0x03, 0x87, 0x00,
  0x07, 0x1E, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0xF0, 0x00, 0x39, 0xC0, 0x00,
  0x77, 0x80, 0x00, 0xEE, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0x00, 0x0E, 0x70, 0x01, 0xF0, 0x01, 0xE7, 0x00, 0x1F, 0x00, 0x1C,
  0x70, 0x03, 0xF0, 0x03, 0xC7, 0x00, 0x3F, 0x00, 0x38, 0x70, 0x07, 0x70,
  0x07, 0x87, 0x00, 0x77, 0x00, 0x70, 0x70, 0x0E, 0x70, 0x07, 0x07, 0x00,
  0xE7, 0x00, 0xE0, 0x70, 0x1C, 0x70, 0x0E, 0x07, 0x01, 0xC7, 0x01, 0xE0,
  0x70, 0x38, 0x70, 0x1C, 0x07, 0x03, 0x83, 0x03, 0xC0, 0x70, 0x38, 0x30,
  0x38, 0x07, 0x07, 0x03, 0x03, 0x80, 0x70, 0x70, 0x38, 0x70, 0x07, 0x0E,
  0x03, 0x87, 0x00, 0x70, 0xE0, 0x38, 0xE0, 0x07, 0x1C, 0x03, 0x8E, 0x00,
  0x71, 0xC0, 0x39, 0xE0, 0x07, 0x38, 0x03, 0x9C, 0x00, 0x73, 0x80, 0x39,
  0xC0, 0x07, 0x70, 0x03, 0xB8, 0x00, 0x77, 0x00, 0x3B, 0x80, 0x07, 0x70,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xC0, 0x01, 0xF0, 0x1E, 0x00, 0x1C, 0x00, 0xE0, 0x03,
  0xC0, 0x0E, 0x00, 0x78, 0x00, 0x70, 0x0F, 0x00, 0x07, 0x00, 0xE0, 0x00,
  0x78, 0x1E, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x38, 0x78, 0x00, 0x03, 0xC7,
  0x00, 0x00, 0x1C, 0xE0, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x07, 0x3C, 0x00,
  0x00, 0xE1, 0xC0, 0x00, 0x1E, 0x1C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x38,
  0x0E, 0x00, 0x07, 0x00, 0xE0, 0x00, 0xF0, 0x0F, 0x00, 0x1E, 0x00, 0x70,
  0x03, 0xC0, 0x07, 0x00, 0x38, 0x00, 0x38, 0x07, 0x80, 0x03, 0x80, 0xF0,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x38, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x3C, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x38, 0x00, 0x70, 0x00,
  0x38, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x1C, 0x01, 0xE0, 0x00,
  0x1C, 0x01, 0xC0, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x1C, 0x03, 0x80, 0x00,
  0x1C, 0x07, 0x80, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x1C, 0x0F, 0x00, 0x00,
  0x1C, 0x0E, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00,
  0x0E, 0x38, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00,
  0x0E, 0x70, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3E, 0x00, 0x01,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x4F, 0xFE, 0x00, 0x37, 0xFF, 0xE0, 0x1F, 0xC0, 0xFF, 0xFE, 0xC0,
  0x0F, 0xFF, 0x20, 0x00, 0x7F, 0x80,
};

const GFXglyph NotoSans_SemiCondensed_LightItalic59pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 13, 43, 14, 1, -42 },
  { 71, 15, 15, 20, 6, -42 },
  { 100, 32, 42, 32, 1, -42 },
  { 268, 27, 48, 29, 1, -45 },
  { 430, 35, 44, 41, 4, -43 },
  { 623, 31, 44, 33, 1, -43 },
  { 794, 6, 15, 11, 6, -42 },
  { 806, 17, 51, 15, 2, -42 },
  { 915, 17, 51, 15, -4, -42 },
  { 1024, 22, 23, 28, 7, -45 },
  { 1088, 26, 28, 30, 3, -35 },
  { 1179, 10, 15, 12, -3, -7 },
  { 1198, 13, 3, 17, 2, -17 },
  { 1203, 5, 6, 13, 1, -5 },
  { 1207, 27, 42, 19, -3, -42 },
  { 1349, 25, 44, 29, 3, -43 },
  { 1487, 15, 42, 29, 8, -42 },
  { 1566, 27, 43, 29, 0, -43 },
  { 1712, 28, 44, 29, 0, -43 },
  { 1866, 27, 42, 29, 0, -42 },
  { 2008, 27, 43, 29, 1, -42 },
  { 2154, 26, 44, 29, 3, -43 },
  { 2297, 26, 42, 29, 4, -42 },
  { 2434, 27, 44, 29, 1, -43 },
  { 2583, 25, 44, 29, 2, -43 },
  { 2721, 10, 33, 13, 1, -32 },
  { 2763, 15, 40, 13, -3, -32 },
  { 2838, 26, 27, 30, 3, -35 },
  { 2926, 24, 15, 30, 4, -28 },
  { 2971, 26, 27, 30, 3, -35 },
  { 3059, 20, 44, 21, 3, -43 },
  { 3169, 39, 47, 43, 3, -42 },
  { 3399, 28, 42, 29, -3, -42 },
  { 3546, 29, 42, 31, 2, -42 },
  { 3699, 29, 44, 30, 4, -43 },
  { 3859, 31, 42, 35, 2, -42 },
  { 4022, 27, 42, 27, 2, -42 },
  { 4164, 27, 42, 25, 2, -42 },
  { 4306, 32, 44, 36, 4, -43 },
  { 4482, 34, 42, 35, 2, -42 },
  { 4661, 20, 42, 16, -1, -42 },
  { 4766, 23, 53, 13, -9, -42 },
  { 4919, 32, 42, 29, 2, -42 },
  { 5087, 19, 42, 25, 2, -42 },
  { 5187, 42, 42, 44, 2, -42 },
  { 5408, 35, 42, 36, 2, -42 },
  { 5592, 31, 44, 37, 4, -43 },
  { 5763, 28, 42, 29, 2, -42 },
  { 5910, 31, 53, 37, 4, -43 },
  { 6116, 28, 42, 30, 2, -42 },
  { 6263, 28, 44, 26, 0, -43 },
  { 6417, 25, 42, 25, 5, -42 },
  { 6549, 32, 43, 35, 4, -42 },
  { 6721, 27, 42, 28, 6, -42 },
  { 6863, 43, 42, 45, 6, -42 },
  { 7089, 34, 42, 26, -3, -42 },
  { 7268, 26, 42, 26, 5, -42 },
  { 7405, 31, 42, 27, -1, -42 },
  { 7568, 22, 51, 17, -1, -42 },
  { 7709, 10, 42, 19, 6, -42 },
  { 7762, 22, 51, 17, -4, -42 },
  { 7903, 26, 24, 30, 2, -42 },
  { 7981, 21, 2, 20, -5, 6 },
  { 7987, 7, 9, 14, 9, -45 },
  { 7995, 26, 33, 30, 2, -32 },
  { 8103, 27, 46, 30, 1, -45 },
  { 8259, 21, 33, 23, 3, -32 },
  { 8346, 30, 46, 30, 2, -45 },
  { 8519, 22, 33, 26, 3, -32 },
  { 8610, 30, 59, 15, -7, -45 },
  { 8832, 28, 46, 30, 1, -32 },
  { 8993, 26, 45, 29, 1, -45 },
  { 9140, 13, 43, 12, 1, -43 },
  { 9210, 22, 57, 13, -8, -43 },
  { 9367, 26, 45, 25, 1, -45 },
  { 9514, 13, 45, 12, 1, -45 },
  { 9588, 41, 32, 45, 1, -32 },
  { 9752, 26, 32, 29, 1, -32 },
  { 9856, 25, 33, 29, 2, -32 },
  { 9960, 30, 46, 30, -2, -32 },
  { 10133, 27, 46, 30, 2, -32 },
  { 10289, 21, 32, 20, 1, -32 },
  { 10373, 22, 33, 22, 0, -32 },
  { 10464, 16, 40, 17, 2, -39 },
  { 10544, 25, 32, 30, 3, -31 },
  { 10644, 23, 31, 23, 3, -31 },
  { 10734, 36, 31, 37, 3, -31 },
  { 10874, 28, 31, 24, -2, -31 },
  { 10983, 32, 45, 23, -6, -31 },
  { 11163, 24, 31, 22, -1, -31 },
  { 11256, 22, 51, 20, 1, -42 },
  { 11397, 3, 59, 28, 13, -45 },
  { 11420, 21, 51, 20, -3, -42 },
  { 11554, 26, 6, 30, 3, -24 },
};

const GFXfont NotoSans_SemiCondensed_LightItalic59pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_LightItalic59pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_LightItalic59pt7bGlyphs,
  0x20, 0x7E, 80
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHTITALIC59PT7B_H_
