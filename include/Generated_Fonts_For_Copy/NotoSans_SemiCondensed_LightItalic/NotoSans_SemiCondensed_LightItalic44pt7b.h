#ifndef _NOTOSANS_SEMICONDENSED_LIGHTITALIC44PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHTITALIC44PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-LightItalic.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_LightItalic44pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x00, 0xC0, 0x70, 0x1C, 0x06,
  0x01, 0x80, 0x60, 0x38, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x1C, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x0C, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80,
  0xF0, 0x3C, 0x0E, 0x00, 0x70, 0xEE, 0x19, 0x83, 0x30, 0xE6, 0x18, 0xC3,
  0x30, 0x66, 0x0C, 0xC3, 0x18, 0x62, 0x0C, 0x00, 0x00, 0x18, 0x18, 0x00,
  0x18, 0x18, 0x00, 0x30, 0x18, 0x00, 0x30, 0x30, 0x00, 0x30, 0x30, 0x00,
  0x60, 0x30, 0x00, 0x60, 0x60, 0x00, 0x60, 0x60, 0x00, 0x60, 0x60, 0x1F,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x00, 0xC0, 0xC0, 0x01, 0x80, 0xC0, 0x01,
  0x81, 0x80, 0x01, 0x81, 0x80, 0x03, 0x81, 0x80, 0x03, 0x03, 0x00, 0x03,
  0x03, 0x00, 0x03, 0x03, 0x00, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x06,
  0x06, 0x00, 0x0C, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x0C,
  0x0C, 0x00, 0x18, 0x18, 0x00, 0x18, 0x18, 0x00, 0x18, 0x18, 0x00, 0x30,
  0x38, 0x00, 0x30, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C,
  0x00, 0x01, 0xF0, 0x00, 0xFF, 0xF0, 0x3E, 0xFE, 0x07, 0x08, 0x20, 0x61,
  0x80, 0x0E, 0x18, 0x00, 0xC1, 0x80, 0x0C, 0x18, 0x00, 0xC1, 0x00, 0x0E,
  0x30, 0x00, 0xE3, 0x00, 0x07, 0x30, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x7E, 0x00, 0x06, 0xF0, 0x00, 0x47, 0x00, 0x0C, 0x38,
  0x00, 0xC3, 0x80, 0x0C, 0x38, 0x00, 0xC3, 0x80, 0x08, 0x30, 0x01, 0x87,
  0x08, 0x18, 0xE0, 0xF9, 0xBC, 0x0F, 0xFF, 0x80, 0x1F, 0xE0, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0xC1, 0xC7, 0x00, 0x60, 0x60, 0xC0, 0x30,
  0x30, 0x30, 0x0C, 0x0C, 0x0C, 0x06, 0x07, 0x03, 0x03, 0x81, 0x80, 0xC0,
  0xC0, 0x60, 0x30, 0x60, 0x18, 0x0C, 0x38, 0x0E, 0x06, 0x0C, 0x03, 0x01,
  0x86, 0x00, 0xC0, 0x63, 0x80, 0x30, 0x38, 0xC7, 0xCC, 0x0C, 0x63, 0xFB,
  0x03, 0x39, 0xC7, 0xC1, 0x8C, 0xE0, 0xD8, 0xE6, 0x30, 0x37, 0xF3, 0x9C,
  0x0C, 0xF0, 0xC6, 0x03, 0x00, 0x61, 0x80, 0xC0, 0x38, 0x60, 0x70, 0x0C,
  0x38, 0x18, 0x06, 0x0C, 0x06, 0x03, 0x83, 0x01, 0x80, 0xC0, 0xC0, 0x60,
  0x60, 0x30, 0x30, 0x18, 0x0C, 0x0C, 0x0C, 0x03, 0x06, 0x06, 0x00, 0xE3,
  0x81, 0x80, 0x1D, 0xC0, 0xC0, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFF,
  0x00, 0x03, 0xC7, 0x00, 0x0E, 0x06, 0x00, 0x18, 0x0E, 0x00, 0x70, 0x1C,
  0x00, 0xE0, 0x38, 0x01, 0xC0, 0x70, 0x03, 0x80, 0xC0, 0x07, 0x03, 0x80,
  0x0E, 0x0E, 0x00, 0x0C, 0x38, 0x00, 0x1C, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x1C, 0x60, 0x04, 0x70,
  0xE0, 0x31, 0xC0, 0xE0, 0xE7, 0x01, 0xC1, 0x8C, 0x01, 0xC7, 0x38, 0x03,
  0x8C, 0x70, 0x03, 0xB8, 0xC0, 0x03, 0xE1, 0x80, 0x07, 0x83, 0x00, 0x07,
  0x07, 0x00, 0x1E, 0x0E, 0x00, 0xEE, 0x0E, 0x03, 0x9C, 0x0F, 0xFE, 0x1C,
  0x0F, 0xF0, 0x1C, 0x77, 0x76, 0x66, 0xCC, 0xCC, 0x80, 0x00, 0x38, 0x03,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00,
  0x70, 0x03, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x70,
  0x03, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x00,
  0xE0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x07,
  0x00, 0x38, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01,
  0x80, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x18, 0x01, 0xC0,
  0x1C, 0x00, 0xC0, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x07, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x80, 0xC0, 0xE0, 0xC0, 0xF8,
  0x80, 0x3C, 0x81, 0x0F, 0xFF, 0x01, 0xFF, 0x07, 0x80, 0x0E, 0xC0, 0x1C,
  0x40, 0x38, 0x60, 0x70, 0x60, 0x20, 0x30, 0x00, 0x38, 0x00, 0x20, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x0E,
  0x1C, 0x30, 0xE1, 0x87, 0x0C, 0x18, 0x60, 0xC3, 0x00, 0x7F, 0xFF, 0xF8,
  0x6F, 0xFE, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0E,
  0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00,
  0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00,
  0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x1F,
  0xE0, 0x07, 0x9E, 0x01, 0xC0, 0xE0, 0x70, 0x1C, 0x1C, 0x01, 0x83, 0x80,
  0x38, 0xE0, 0x07, 0x1C, 0x00, 0xE3, 0x00, 0x1C, 0xE0, 0x03, 0x98, 0x00,
  0x73, 0x00, 0x0E, 0xE0, 0x01, 0x9C, 0x00, 0x33, 0x00, 0x06, 0x60, 0x01,
  0xDC, 0x00, 0x3B, 0x80, 0x07, 0x70, 0x00, 0xCE, 0x00, 0x39, 0xC0, 0x07,
  0x38, 0x00, 0xC6, 0x00, 0x38, 0xE0, 0x07, 0x1C, 0x01, 0xC3, 0x80, 0x38,
  0x70, 0x0E, 0x07, 0x03, 0x80, 0xE0, 0xE0, 0x0F, 0xF8, 0x00, 0xFE, 0x00,
  0x01, 0xE0, 0x7C, 0x1F, 0x0F, 0x63, 0x9D, 0xE3, 0x98, 0x72, 0x0C, 0x01,
  0x80, 0x70, 0x0E, 0x01, 0x80, 0x30, 0x06, 0x01, 0xC0, 0x38, 0x06, 0x00,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x18, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x00,
  0x60, 0x0C, 0x03, 0x80, 0x70, 0x0C, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0xFC,
  0x01, 0xF3, 0xE0, 0x38, 0x07, 0x01, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xFF,
  0x8F, 0xFF, 0xF0, 0x00, 0x1F, 0x00, 0x07, 0xFE, 0x01, 0xF8, 0x78, 0x07,
  0x00, 0xE0, 0x20, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00,
  0x0E, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x08, 0x00, 0x70, 0x70, 0x0F, 0x03, 0xFF, 0xF0,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00,
  0x1B, 0x00, 0x03, 0xF0, 0x00, 0x36, 0x00, 0x06, 0x60, 0x00, 0xC6, 0x00,
  0x1C, 0xE0, 0x03, 0x8E, 0x00, 0x30, 0xC0, 0x06, 0x0C, 0x00, 0xE1, 0xC0,
  0x1C, 0x1C, 0x01, 0x81, 0x80, 0x30, 0x18, 0x06, 0x01, 0x80, 0xE0, 0x38,
  0x1C, 0x03, 0x81, 0x80, 0x30, 0x30, 0x03, 0x07, 0x00, 0x30, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x01,
  0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xE0, 0x0C, 0x0F,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x08, 0x00, 0xE0, 0xC0, 0x3C, 0x0F,
  0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x07, 0xFC, 0x01, 0xF0,
  0x80, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x82, 0x00,
  0x63, 0xF8, 0x1D, 0xFF, 0xC3, 0xF0, 0x38, 0x68, 0x03, 0x8E, 0x00, 0x71,
  0xC0, 0x06, 0x70, 0x00, 0xCE, 0x00, 0x19, 0xC0, 0x03, 0x38, 0x00, 0xE7,
  0x00, 0x1C, 0xE0, 0x03, 0x1C, 0x00, 0x63, 0x80, 0x1C, 0x30, 0x07, 0x07,
  0x00, 0xE0, 0x70, 0x78, 0x0F, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xFF, 0xE7,
  0xFF, 0xFC, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00,
  0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00,
  0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60,
  0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x0F, 0xFC, 0x01, 0xE1, 0xE0, 0x38, 0x0E, 0x03, 0x00, 0x70,
  0x70, 0x07, 0x06, 0x00, 0x30, 0x60, 0x03, 0x06, 0x00, 0x70, 0x60, 0x07,
  0x07, 0x00, 0xE0, 0x70, 0x0C, 0x03, 0x83, 0x80, 0x1C, 0x70, 0x00, 0xFE,
  0x00, 0x0F, 0x80, 0x03, 0xFC, 0x00, 0xF0, 0xE0, 0x1C, 0x07, 0x03, 0x80,
  0x30, 0x70, 0x03, 0x86, 0x00, 0x18, 0xE0, 0x01, 0x8E, 0x00, 0x18, 0xE0,
  0x01, 0x8E, 0x00, 0x18, 0xE0, 0x03, 0x8E, 0x00, 0x38, 0x70, 0x07, 0x07,
  0x80, 0xE0, 0x3F, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x3E, 0x00, 0x1F, 0xF0,
  0x0F, 0x8F, 0x01, 0xC0, 0xE0, 0x70, 0x0E, 0x1C, 0x01, 0xC3, 0x00, 0x18,
  0xE0, 0x03, 0x1C, 0x00, 0x63, 0x00, 0x0C, 0x60, 0x01, 0x9C, 0x00, 0x33,
  0x80, 0x0E, 0x70, 0x01, 0xC6, 0x00, 0x38, 0xC0, 0x0F, 0x1C, 0x03, 0xC1,
  0xC1, 0xD8, 0x1F, 0xF3, 0x01, 0xF8, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0E, 0x00, 0x03, 0x81, 0x01, 0xE0, 0x3F, 0xF8, 0x07, 0xFC, 0x00, 0x06,
  0x1C, 0x38, 0x70, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x06, 0x1C, 0x38, 0x70, 0x00, 0xC0, 0x3C, 0x07,
  0x80, 0xE0, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00,
  0xE0, 0x38, 0x07, 0x00, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0x30, 0x0E, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC,
  0x80, 0x00, 0x30, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x1C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x3E, 0x00, 0x0E, 0x00, 0x02, 0x00, 0x00, 0x03, 0xE0, 0x3F,
  0xF0, 0xF9, 0xF0, 0x80, 0x70, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x60, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x01, 0xC0,
  0x18, 0x00, 0x07, 0x01, 0x80, 0x00, 0x18, 0x18, 0x00, 0x00, 0xE1, 0xC0,
  0x00, 0x03, 0x0C, 0x00, 0xE0, 0x18, 0xC0, 0x3F, 0xE0, 0xCE, 0x03, 0x87,
  0x06, 0x60, 0x30, 0x30, 0x33, 0x03, 0x01, 0x81, 0xB0, 0x38, 0x0C, 0x0D,
  0x81, 0x80, 0xE0, 0x6C, 0x1C, 0x06, 0x03, 0xE0, 0xC0, 0x30, 0x1E, 0x06,
  0x01, 0x81, 0xB0, 0x70, 0x1C, 0x0D, 0x83, 0x80, 0xC0, 0x6C, 0x18, 0x06,
  0x06, 0x60, 0xC0, 0x70, 0x33, 0x07, 0x07, 0x83, 0x18, 0x18, 0x6C, 0x38,
  0xC0, 0xFF, 0x3F, 0x86, 0x03, 0xE0, 0xF0, 0x38, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xF0, 0x00, 0x0D, 0xC0, 0x00, 0x77, 0x00,
  0x01, 0x8C, 0x00, 0x0E, 0x30, 0x00, 0x30, 0xC0, 0x01, 0xC3, 0x00, 0x06,
  0x0C, 0x00, 0x38, 0x30, 0x00, 0xC0, 0xC0, 0x07, 0x03, 0x00, 0x18, 0x0C,
  0x00, 0xE0, 0x38, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x7F, 0xFE, 0x03,
  0xFF, 0xF8, 0x0C, 0x00, 0x60, 0x70, 0x01, 0x81, 0x80, 0x06, 0x0E, 0x00,
  0x18, 0x30, 0x00, 0x61, 0xC0, 0x01, 0x86, 0x00, 0x06, 0x38, 0x00, 0x1C,
  0xC0, 0x00, 0x77, 0x00, 0x01, 0xF8, 0x00, 0x07, 0x01, 0xFF, 0xE0, 0x07,
  0xFF, 0xC0, 0x38, 0x07, 0x80, 0xE0, 0x0E, 0x03, 0x00, 0x1C, 0x0C, 0x00,
  0x70, 0x70, 0x01, 0xC1, 0xC0, 0x07, 0x07, 0x00, 0x1C, 0x18, 0x00, 0x60,
  0x60, 0x03, 0x83, 0x80, 0x1C, 0x0E, 0x00, 0xE0, 0x3F, 0xFF, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0xE0, 0x1C, 0x01, 0xC0, 0x70, 0x03, 0x81, 0x80, 0x06,
  0x06, 0x00, 0x18, 0x18, 0x00, 0x70, 0xE0, 0x01, 0xC3, 0x80, 0x07, 0x0C,
  0x00, 0x18, 0x30, 0x00, 0xE1, 0xC0, 0x03, 0x87, 0x00, 0x1C, 0x1C, 0x00,
  0xE0, 0x60, 0x1F, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0xFF, 0xF0, 0x0F, 0xCF, 0x80, 0x78, 0x02, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x0C, 0x01, 0xFF, 0xF0, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x03, 0x80, 0xF8, 0x03,
  0x80, 0x3C, 0x03, 0x00, 0x1C, 0x03, 0x00, 0x0E, 0x07, 0x00, 0x0E, 0x07,
  0x00, 0x06, 0x07, 0x00, 0x06, 0x06, 0x00, 0x06, 0x06, 0x00, 0x07, 0x0E,
  0x00, 0x07, 0x0E, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x0C,
  0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x18, 0x00, 0x0C, 0x18,
  0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x38, 0x38, 0x00, 0x38, 0x30,
  0x00, 0x70, 0x30, 0x00, 0xE0, 0x70, 0x01, 0xE0, 0x70, 0x03, 0xC0, 0x70,
  0x0F, 0x80, 0x60, 0x7E, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xFF, 0xC0,
  0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8,
  0x0F, 0xFF, 0xC0, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x7F,
  0xF8, 0x03, 0xFB, 0xF8, 0x0F, 0x00, 0x30, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x0F, 0xF9, 0xC0, 0x1F, 0xF3, 0x00,
  0x00, 0xE6, 0x00, 0x01, 0xCC, 0x00, 0x03, 0x18, 0x00, 0x06, 0x30, 0x00,
  0x1C, 0x60, 0x00, 0x38, 0xE0, 0x00, 0x71, 0xC0, 0x00, 0xC1, 0x80, 0x01,
  0x83, 0x80, 0x07, 0x03, 0x80, 0x0E, 0x07, 0xC0, 0x38, 0x07, 0xFF, 0xF0,
  0x03, 0xFF, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x60, 0x00, 0x60, 0x38, 0x00,
  0x18, 0x0E, 0x00, 0x0E, 0x03, 0x00, 0x03, 0x80, 0xC0, 0x00, 0xC0, 0x70,
  0x00, 0x30, 0x1C, 0x00, 0x0C, 0x07, 0x00, 0x07, 0x01, 0x80, 0x01, 0xC0,
  0x60, 0x00, 0x60, 0x38, 0x00, 0x18, 0x0E, 0x00, 0x0E, 0x03, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1C, 0x00, 0x0C, 0x07, 0x00,
  0x07, 0x01, 0x80, 0x01, 0xC0, 0x60, 0x00, 0x60, 0x18, 0x00, 0x18, 0x0E,
  0x00, 0x06, 0x03, 0x80, 0x03, 0x80, 0xC0, 0x00, 0xE0, 0x30, 0x00, 0x30,
  0x1C, 0x00, 0x0C, 0x07, 0x00, 0x03, 0x01, 0xC0, 0x01, 0xC0, 0x60, 0x00,
  0x70, 0x18, 0x00, 0x18, 0x0E, 0x00, 0x06, 0x00, 0x03, 0xFE, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x70, 0x08,
  0x78, 0x07, 0xF8, 0x03, 0xF0, 0x00, 0x01, 0x80, 0x0F, 0x01, 0x80, 0x1C,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x70, 0x03, 0x00, 0xF0, 0x03, 0x00, 0xE0,
  0x07, 0x01, 0xC0, 0x07, 0x03, 0x80, 0x07, 0x07, 0x00, 0x06, 0x0E, 0x00,
  0x06, 0x1C, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x70, 0x00, 0x0C, 0xE0, 0x00,
  0x0D, 0xF0, 0x00, 0x0F, 0xB0, 0x00, 0x1F, 0x38, 0x00, 0x1E, 0x38, 0x00,
  0x18, 0x18, 0x00, 0x18, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x0C, 0x00,
  0x38, 0x0E, 0x00, 0x30, 0x0E, 0x00, 0x30, 0x06, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x03, 0x00, 0x60, 0x03, 0x80, 0x60, 0x03, 0x80, 0x60, 0x01, 0x80,
  0xE0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30,
  0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00,
  0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x2F, 0xFF, 0xBF,
  0xFF, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x1F, 0x03, 0xE0,
  0x00, 0x1F, 0x03, 0x60, 0x00, 0x3E, 0x03, 0x60, 0x00, 0x36, 0x03, 0x60,
  0x00, 0x7E, 0x07, 0x60, 0x00, 0x6E, 0x07, 0x60, 0x00, 0xEE, 0x06, 0x60,
  0x00, 0xCC, 0x06, 0x70, 0x01, 0xCC, 0x06, 0x70, 0x01, 0x9C, 0x0E, 0x70,
  0x03, 0x1C, 0x0E, 0x30, 0x07, 0x18, 0x0C, 0x30, 0x06, 0x18, 0x0C, 0x30,
  0x0E, 0x18, 0x0C, 0x30, 0x0C, 0x38, 0x1C, 0x30, 0x1C, 0x38, 0x1C, 0x30,
  0x18, 0x30, 0x18, 0x38, 0x38, 0x30, 0x18, 0x38, 0x30, 0x70, 0x38, 0x18,
  0x70, 0x70, 0x38, 0x18, 0x60, 0x70, 0x30, 0x18, 0xE0, 0x60, 0x30, 0x18,
  0xC0, 0x60, 0x30, 0x19, 0x80, 0xE0, 0x70, 0x19, 0x80, 0xE0, 0x70, 0x1B,
  0x00, 0xE0, 0x60, 0x1F, 0x00, 0xC0, 0x60, 0x1E, 0x00, 0xC0, 0x60, 0x0E,
  0x01, 0xC0, 0xE0, 0x0C, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xC0, 0x70, 0x00,
  0x30, 0x3C, 0x00, 0x1C, 0x0F, 0x80, 0x07, 0x03, 0x60, 0x01, 0x80, 0xD8,
  0x00, 0x60, 0x77, 0x00, 0x38, 0x1C, 0xC0, 0x0E, 0x06, 0x30, 0x03, 0x81,
  0x8E, 0x00, 0xC0, 0x61, 0x80, 0x30, 0x38, 0x60, 0x1C, 0x0E, 0x1C, 0x07,
  0x03, 0x03, 0x01, 0x80, 0xC0, 0xC0, 0x60, 0x30, 0x38, 0x18, 0x1C, 0x06,
  0x0E, 0x07, 0x01, 0x83, 0x81, 0x80, 0x70, 0xC0, 0x60, 0x1C, 0x30, 0x38,
  0x03, 0x0C, 0x0E, 0x00, 0xE7, 0x03, 0x00, 0x39, 0xC0, 0xC0, 0x06, 0x60,
  0x30, 0x01, 0xD8, 0x1C, 0x00, 0x76, 0x07, 0x00, 0x0F, 0x81, 0x80, 0x03,
  0xC0, 0x60, 0x00, 0xF0, 0x18, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0xFF, 0xC0, 0x07, 0xC3, 0xE0, 0x1E, 0x01, 0xC0, 0x70,
  0x01, 0xC1, 0xC0, 0x01, 0x83, 0x80, 0x03, 0x8E, 0x00, 0x07, 0x18, 0x00,
  0x06, 0x70, 0x00, 0x0C, 0xC0, 0x00, 0x1B, 0x80, 0x00, 0x37, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x36, 0x00, 0x00, 0xEC, 0x00, 0x01, 0xD8,
  0x00, 0x03, 0xB0, 0x00, 0x0E, 0x60, 0x00, 0x1C, 0xE0, 0x00, 0x71, 0xC0,
  0x00, 0xE3, 0x80, 0x03, 0x83, 0x80, 0x0F, 0x07, 0x80, 0x3C, 0x07, 0x80,
  0xF0, 0x07, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x0F, 0xFF,
  0x00, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x30, 0x03, 0x81, 0x80, 0x1C, 0x1C,
  0x00, 0xE0, 0xE0, 0x07, 0x07, 0x00, 0x38, 0x30, 0x01, 0xC1, 0x80, 0x0E,
  0x1C, 0x00, 0x60, 0xE0, 0x07, 0x06, 0x00, 0x70, 0x30, 0x07, 0x81, 0x80,
  0xF8, 0x1F, 0xFF, 0x00, 0xFF, 0xE0, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xC0, 0x07,
  0xC3, 0xE0, 0x1E, 0x01, 0xC0, 0x70, 0x01, 0xC1, 0xC0, 0x01, 0x83, 0x80,
  0x03, 0x8E, 0x00, 0x07, 0x18, 0x00, 0x06, 0x70, 0x00, 0x0C, 0xC0, 0x00,
  0x1B, 0x80, 0x00, 0x37, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x36,
  0x00, 0x00, 0xEC, 0x00, 0x01, 0xD8, 0x00, 0x03, 0xB0, 0x00, 0x0E, 0x60,
  0x00, 0x1C, 0xE0, 0x00, 0x71, 0xC0, 0x00, 0xE3, 0x80, 0x03, 0x83, 0x80,
  0x0E, 0x07, 0x80, 0x3C, 0x07, 0x80, 0xF0, 0x07, 0xFF, 0x80, 0x03, 0xFC,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xFF,
  0x80, 0x0F, 0xFF, 0x00, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x30, 0x03, 0x81,
  0x80, 0x1C, 0x1C, 0x00, 0xE0, 0xE0, 0x07, 0x07, 0x00, 0x38, 0x30, 0x01,
  0xC1, 0x80, 0x0E, 0x1C, 0x00, 0xE0, 0xE0, 0x07, 0x06, 0x00, 0x70, 0x30,
  0x0F, 0x01, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0xE0, 0xE0, 0x06, 0x07, 0x00,
  0x30, 0x18, 0x03, 0x80, 0xC0, 0x1C, 0x07, 0x00, 0xE0, 0x38, 0x06, 0x00,
  0xC0, 0x30, 0x07, 0x03, 0x80, 0x38, 0x1C, 0x00, 0xC0, 0xE0, 0x07, 0x06,
  0x00, 0x38, 0x30, 0x01, 0xC3, 0x80, 0x07, 0x00, 0x00, 0x1F, 0x80, 0x07,
  0xFF, 0xC0, 0x7E, 0xFC, 0x07, 0x80, 0x20, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0,
  0x70, 0x0F, 0x03, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00,
  0x07, 0x0E, 0x00, 0x06, 0x0E, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x0C, 0x00,
  0x0E, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x18, 0x00,
  0x1C, 0x18, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x18, 0x30, 0x00,
  0x18, 0x30, 0x00, 0x38, 0x70, 0x00, 0x38, 0x70, 0x00, 0x30, 0x70, 0x00,
  0x30, 0x60, 0x00, 0x30, 0x60, 0x00, 0x70, 0xE0, 0x00, 0x70, 0xE0, 0x00,
  0x60, 0xE0, 0x00, 0x60, 0xC0, 0x00, 0xE0, 0xC0, 0x00, 0xE0, 0xC0, 0x01,
  0xC0, 0xE0, 0x01, 0xC0, 0xE0, 0x03, 0x80, 0x70, 0x07, 0x80, 0x78, 0x0F,
  0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xE0, 0x00, 0x3F, 0x00, 0x03,
  0xB8, 0x00, 0x19, 0xC0, 0x01, 0xC6, 0x00, 0x0C, 0x30, 0x00, 0xE1, 0x80,
  0x06, 0x0C, 0x00, 0x70, 0x60, 0x03, 0x03, 0x00, 0x38, 0x18, 0x01, 0x80,
  0xC0, 0x1C, 0x06, 0x00, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x60, 0x0E, 0x07,
  0x00, 0x70, 0x30, 0x03, 0x83, 0x80, 0x0C, 0x18, 0x00, 0x61, 0xC0, 0x03,
  0x0C, 0x00, 0x18, 0xE0, 0x00, 0xC6, 0x00, 0x06, 0x70, 0x00, 0x33, 0x00,
  0x01, 0xB8, 0x00, 0x0D, 0x80, 0x00, 0x6C, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x03, 0x80, 0x07, 0xC0, 0x03, 0x80,
  0x0E, 0xC0, 0x07, 0x80, 0x0E, 0xC0, 0x07, 0x80, 0x0C, 0xC0, 0x0F, 0x80,
  0x1C, 0xC0, 0x0D, 0x80, 0x18, 0xC0, 0x1D, 0x80, 0x38, 0xC0, 0x19, 0x80,
  0x30, 0xC0, 0x19, 0x80, 0x70, 0xC0, 0x31, 0x80, 0x70, 0xC0, 0x31, 0x80,
  0x60, 0xC0, 0x71, 0x80, 0xE0, 0xC0, 0x61, 0x80, 0xC0, 0xC0, 0xE1, 0x81,
  0xC0, 0xC0, 0xC1, 0x81, 0x80, 0xC1, 0xC1, 0x83, 0x80, 0xC1, 0x81, 0x83,
  0x80, 0xC1, 0x81, 0x83, 0x00, 0xC3, 0x01, 0x87, 0x00, 0xC3, 0x01, 0x86,
  0x00, 0xC7, 0x01, 0x8E, 0x00, 0xC6, 0x01, 0xCC, 0x00, 0xCE, 0x01, 0xDC,
  0x00, 0xCC, 0x01, 0xD8, 0x00, 0xCC, 0x01, 0xD8, 0x00, 0xD8, 0x01, 0xF8,
  0x00, 0xD8, 0x01, 0xF0, 0x00, 0xF8, 0x01, 0xB0, 0x00, 0xF0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x01,
  0xC0, 0x18, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x01, 0xC0, 0x38, 0x00, 0x70,
  0x0C, 0x00, 0x0C, 0x07, 0x00, 0x03, 0x03, 0x80, 0x00, 0xE0, 0xC0, 0x00,
  0x18, 0x70, 0x00, 0x06, 0x38, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x76, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x07, 0x30, 0x00, 0x01,
  0x8E, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x70, 0x60, 0x00, 0x18, 0x18, 0x00,
  0x0E, 0x07, 0x00, 0x07, 0x01, 0xC0, 0x03, 0x80, 0x30, 0x00, 0xC0, 0x0C,
  0x00, 0x70, 0x03, 0x80, 0x38, 0x00, 0x60, 0x0C, 0x00, 0x18, 0x0F, 0x00,
  0x07, 0x00, 0xE0, 0x00, 0xFC, 0x00, 0x39, 0x80, 0x0E, 0x30, 0x01, 0xC6,
  0x00, 0x70, 0xE0, 0x0C, 0x1C, 0x03, 0x81, 0x80, 0xE0, 0x30, 0x18, 0x07,
  0x07, 0x00, 0xE1, 0xC0, 0x0C, 0x30, 0x01, 0x8E, 0x00, 0x31, 0x80, 0x07,
  0x60, 0x00, 0xFC, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x7F, 0x80, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x07, 0xF8, 0x07, 0xFC, 0x00, 0xC1, 0x83, 0x06, 0x0E, 0x1C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x70, 0xE0,
  0xC1, 0x83, 0x06, 0x0C, 0x1C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x80, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00,
  0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0xFF,
  0x80, 0xFF, 0x00, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x07,
  0xC0, 0x00, 0x6C, 0x00, 0x0C, 0x60, 0x00, 0xC6, 0x00, 0x18, 0x60, 0x03,
  0x83, 0x00, 0x30, 0x30, 0x07, 0x03, 0x80, 0x60, 0x18, 0x0C, 0x01, 0x80,
  0xC0, 0x0C, 0x18, 0x00, 0xC3, 0x80, 0x0E, 0x30, 0x00, 0x67, 0x00, 0x06,
  0xE0, 0x00, 0x70, 0x7F, 0xFF, 0xFF, 0xFF, 0xE1, 0xC7, 0x0C, 0x18, 0x60,
  0xC0, 0x00, 0xF8, 0x00, 0x7F, 0x8C, 0x1F, 0x39, 0x87, 0x01, 0x71, 0xC0,
  0x3C, 0x38, 0x03, 0x8E, 0x00, 0x71, 0x80, 0x0E, 0x70, 0x01, 0x8E, 0x00,
  0x31, 0x80, 0x06, 0x70, 0x01, 0xCE, 0x00, 0x39, 0xC0, 0x06, 0x30, 0x00,
  0xC6, 0x00, 0x38, 0xC0, 0x07, 0x18, 0x01, 0xE3, 0x00, 0x38, 0x70, 0x0F,
  0x0E, 0x03, 0x60, 0xE0, 0xCC, 0x1F, 0xF3, 0x81, 0xFC, 0x60, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0xF0, 0x06,
  0x3F, 0x80, 0xEF, 0x3C, 0x0F, 0xC0, 0xE0, 0xD8, 0x0E, 0x0F, 0x00, 0x60,
  0xE0, 0x06, 0x1E, 0x00, 0x71, 0xC0, 0x06, 0x1C, 0x00, 0x61, 0x80, 0x06,
  0x18, 0x00, 0x63, 0x80, 0x0E, 0x38, 0x00, 0xE3, 0x00, 0x0E, 0x30, 0x00,
  0xC7, 0x00, 0x1C, 0x70, 0x01, 0x87, 0x00, 0x38, 0x70, 0x03, 0x07, 0x80,
  0x70, 0xEC, 0x1E, 0x0C, 0xFF, 0xC0, 0xC7, 0xF0, 0x00, 0x00, 0x7C, 0x03,
  0xFF, 0x07, 0xC6, 0x0F, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30,
  0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x78, 0x10, 0x3F, 0xF0, 0x1F, 0xF0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x03, 0xE1,
  0x80, 0x3F, 0xC6, 0x01, 0xF3, 0x98, 0x0E, 0x03, 0xE0, 0x70, 0x07, 0x81,
  0xC0, 0x1C, 0x0E, 0x00, 0x70, 0x30, 0x01, 0xC1, 0xC0, 0x07, 0x07, 0x00,
  0x1C, 0x18, 0x00, 0x60, 0xE0, 0x01, 0x83, 0x80, 0x0E, 0x0E, 0x00, 0x38,
  0x30, 0x00, 0xC0, 0xC0, 0x07, 0x03, 0x00, 0x1C, 0x0C, 0x00, 0xF0, 0x30,
  0x03, 0xC0, 0xE0, 0x1E, 0x03, 0x80, 0xD8, 0x07, 0x06, 0x60, 0x1F, 0xF1,
  0x80, 0x3F, 0x8E, 0x00, 0x00, 0x78, 0x03, 0xFE, 0x07, 0x8F, 0x0E, 0x07,
  0x1C, 0x03, 0x18, 0x03, 0x38, 0x03, 0x30, 0x07, 0x70, 0x06, 0x60, 0x1E,
  0x60, 0x7C, 0xFF, 0xF0, 0xFF, 0xC0, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x08,
  0x3F, 0xF8, 0x1F, 0xF0, 0x00, 0x00, 0x30, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0xC0, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x0F,
  0xC0, 0x00, 0x3E, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x07,
  0xF8, 0xC0, 0x7C, 0xE6, 0x07, 0x01, 0xB0, 0x70, 0x07, 0x83, 0x80, 0x38,
  0x38, 0x01, 0xC1, 0x80, 0x0E, 0x1C, 0x00, 0x70, 0xE0, 0x03, 0x86, 0x00,
  0x18, 0x70, 0x00, 0xC3, 0x80, 0x0E, 0x1C, 0x00, 0x70, 0xC0, 0x03, 0x06,
  0x00, 0x38, 0x30, 0x01, 0xC1, 0x80, 0x1E, 0x0C, 0x00, 0xF0, 0x70, 0x0F,
  0x03, 0x80, 0xD8, 0x0E, 0x0C, 0xC0, 0x7F, 0xCE, 0x01, 0xFC, 0x70, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x18, 0x07, 0x80, 0xFF, 0xF8, 0x03, 0xFF,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xC1, 0xE0, 0x18, 0xFE, 0x07, 0x79, 0xE0, 0xFC, 0x0E, 0x1B,
  0x01, 0xC3, 0xC0, 0x38, 0x70, 0x07, 0x1C, 0x00, 0xE3, 0x80, 0x1C, 0x70,
  0x03, 0x0C, 0x00, 0x61, 0x80, 0x1C, 0x70, 0x03, 0x8E, 0x00, 0x61, 0x80,
  0x0C, 0x30, 0x01, 0x8E, 0x00, 0x71, 0xC0, 0x0E, 0x30, 0x01, 0x86, 0x00,
  0x30, 0xC0, 0x06, 0x38, 0x01, 0xC7, 0x00, 0x38, 0xC0, 0x06, 0x00, 0x01,
  0x81, 0xC0, 0xE0, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x03, 0x81,
  0xC0, 0xC0, 0x60, 0x30, 0x38, 0x1C, 0x0C, 0x06, 0x03, 0x03, 0x81, 0xC0,
  0xC0, 0x60, 0x70, 0x38, 0x18, 0x0C, 0x06, 0x07, 0x03, 0x81, 0x80, 0x00,
  0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x00, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x04, 0x18, 0x07, 0x07, 0x01, 0xC0, 0xE0, 0x70, 0x18, 0x1C, 0x03, 0x07,
  0x00, 0x60, 0xC0, 0x1C, 0x30, 0x03, 0x8E, 0x00, 0x63, 0x80, 0x0C, 0xE0,
  0x01, 0xBC, 0x00, 0x7D, 0xC0, 0x0F, 0x38, 0x01, 0xC3, 0x00, 0x30, 0x70,
  0x0E, 0x0E, 0x01, 0xC0, 0xC0, 0x30, 0x1C, 0x06, 0x01, 0x80, 0xC0, 0x30,
  0x38, 0x07, 0x07, 0x00, 0x60, 0xC0, 0x0E, 0x00, 0x01, 0x80, 0xC0, 0xE0,
  0x70, 0x30, 0x18, 0x1C, 0x0E, 0x07, 0x03, 0x01, 0x81, 0xC0, 0xE0, 0x60,
  0x30, 0x18, 0x1C, 0x0E, 0x06, 0x03, 0x01, 0x81, 0xC0, 0xE0, 0x60, 0x30,
  0x38, 0x1C, 0x0C, 0x06, 0x03, 0x03, 0x81, 0xC0, 0xC0, 0x00, 0x00, 0x1E,
  0x01, 0xE0, 0x19, 0xFE, 0x1F, 0xE0, 0xEE, 0x38, 0xE3, 0xC3, 0x60, 0x76,
  0x07, 0x0D, 0x01, 0xF0, 0x0C, 0x38, 0x03, 0x80, 0x30, 0xE0, 0x0E, 0x00,
  0xC7, 0x00, 0x70, 0x03, 0x1C, 0x01, 0xC0, 0x1C, 0x70, 0x07, 0x00, 0x71,
  0x80, 0x18, 0x01, 0x86, 0x00, 0x60, 0x06, 0x38, 0x03, 0x80, 0x18, 0xE0,
  0x0E, 0x00, 0xE3, 0x00, 0x30, 0x03, 0x8C, 0x00, 0xC0, 0x0C, 0x70, 0x03,
  0x00, 0x31, 0xC0, 0x1C, 0x01, 0xC6, 0x00, 0x70, 0x07, 0x18, 0x01, 0x80,
  0x18, 0x60, 0x06, 0x00, 0x63, 0x80, 0x18, 0x01, 0x8E, 0x00, 0xE0, 0x0E,
  0x30, 0x03, 0x80, 0x38, 0x00, 0x1F, 0x00, 0xCF, 0xF8, 0x3B, 0xCF, 0x06,
  0xE0, 0x70, 0xD8, 0x0E, 0x1E, 0x01, 0xC3, 0x80, 0x38, 0xE0, 0x07, 0x1C,
  0x00, 0xE3, 0x80, 0x18, 0x60, 0x03, 0x1C, 0x00, 0xE3, 0x80, 0x1C, 0x70,
  0x03, 0x8C, 0x00, 0x61, 0x80, 0x0C, 0x70, 0x03, 0x8E, 0x00, 0x71, 0xC0,
  0x0C, 0x30, 0x01, 0x86, 0x00, 0x71, 0xC0, 0x0E, 0x38, 0x01, 0xC6, 0x00,
  0x30, 0x00, 0x78, 0x00, 0xFF, 0x80, 0x78, 0xF0, 0x38, 0x0E, 0x1C, 0x01,
  0x86, 0x00, 0x73, 0x80, 0x1C, 0xC0, 0x03, 0x70, 0x00, 0xD8, 0x00, 0x36,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x6C, 0x00, 0x1B, 0x00,
  0x0E, 0xC0, 0x03, 0xB0, 0x00, 0xCE, 0x00, 0x73, 0x80, 0x38, 0x60, 0x1C,
  0x1C, 0x0F, 0x03, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xC0, 0x06, 0x3F,
  0x80, 0x3B, 0xCF, 0x00, 0xCC, 0x0E, 0x03, 0x60, 0x38, 0x0F, 0x00, 0x60,
  0x38, 0x01, 0x81, 0xE0, 0x07, 0x07, 0x00, 0x1C, 0x1C, 0x00, 0x60, 0x60,
  0x01, 0x81, 0x80, 0x06, 0x0E, 0x00, 0x18, 0x38, 0x00, 0xE0, 0xC0, 0x03,
  0x83, 0x00, 0x0C, 0x1C, 0x00, 0x70, 0x70, 0x01, 0x81, 0xC0, 0x0E, 0x07,
  0x00, 0x70, 0x1E, 0x01, 0xC0, 0xEC, 0x1E, 0x03, 0xBF, 0xF0, 0x0C, 0x7F,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x7F, 0x8C, 0x1E, 0x39,
  0x87, 0x01, 0xB1, 0xC0, 0x1E, 0x38, 0x03, 0x8E, 0x00, 0x71, 0x80, 0x0E,
  0x70, 0x01, 0xCE, 0x00, 0x39, 0x80, 0x06, 0x70, 0x00, 0xCE, 0x00, 0x39,
  0xC0, 0x07, 0x30, 0x00, 0xC6, 0x00, 0x38, 0xC0, 0x07, 0x18, 0x01, 0xE3,
  0x00, 0x3C, 0x70, 0x0F, 0x0E, 0x03, 0x60, 0xE0, 0xCC, 0x1F, 0xF3, 0x81,
  0xFC, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x06, 0x00, 0x00, 0x1E, 0x0C, 0xFC, 0x3B, 0xF8, 0x6E, 0x00, 0xD8, 0x01,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x00, 0x00,
  0xF8, 0x07, 0xFF, 0x0F, 0x0F, 0x0E, 0x01, 0x1C, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x18, 0x00, 0x38, 0xC0, 0x78, 0xFF, 0xF0, 0x7F, 0xC0, 0x02,
  0x00, 0xC0, 0x18, 0x07, 0x00, 0xC0, 0x18, 0x1F, 0xFF, 0xFF, 0x1C, 0x03,
  0x00, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x70, 0x0E, 0x01,
  0x80, 0x30, 0x06, 0x01, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x80,
  0x7F, 0x07, 0xE0, 0x1C, 0x00, 0xE3, 0x80, 0x1C, 0x60, 0x03, 0x0C, 0x00,
  0x61, 0x80, 0x1C, 0x70, 0x03, 0x8E, 0x00, 0x61, 0x80, 0x0C, 0x30, 0x01,
  0x86, 0x00, 0x71, 0xC0, 0x0E, 0x38, 0x01, 0x86, 0x00, 0x30, 0xC0, 0x0E,
  0x38, 0x01, 0xC7, 0x00, 0x38, 0xE0, 0x0E, 0x18, 0x01, 0xC3, 0x00, 0x78,
  0x70, 0x1B, 0x0E, 0x06, 0xE0, 0xFF, 0x98, 0x0F, 0xE3, 0x00, 0xE0, 0x03,
  0xF0, 0x01, 0x98, 0x01, 0xCC, 0x00, 0xC6, 0x00, 0xE3, 0x00, 0x61, 0x80,
  0x70, 0xC0, 0x30, 0x60, 0x38, 0x38, 0x18, 0x1C, 0x1C, 0x0E, 0x0C, 0x07,
  0x0E, 0x01, 0x86, 0x00, 0xC7, 0x00, 0x63, 0x00, 0x33, 0x80, 0x19, 0x80,
  0x0D, 0xC0, 0x06, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xC0,
  0x1C, 0x01, 0xF0, 0x07, 0x00, 0x6C, 0x03, 0xC0, 0x3B, 0x00, 0xF0, 0x0C,
  0xC0, 0x6C, 0x07, 0x30, 0x1B, 0x01, 0x8C, 0x0E, 0xC0, 0xE3, 0x03, 0x30,
  0x30, 0xC1, 0xCC, 0x0C, 0x30, 0x63, 0x07, 0x0C, 0x38, 0xC1, 0x83, 0x0C,
  0x38, 0xE0, 0xC3, 0x0E, 0x30, 0x31, 0x83, 0x9C, 0x0C, 0x60, 0x66, 0x03,
  0x30, 0x19, 0x80, 0xCC, 0x06, 0xC0, 0x36, 0x01, 0xB0, 0x0D, 0x80, 0x7C,
  0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x00, 0x03, 0x00, 0x38, 0x1C, 0x03, 0x80, 0x60, 0x38, 0x03, 0x01,
  0x80, 0x1C, 0x18, 0x00, 0x61, 0xC0, 0x03, 0x1C, 0x00, 0x1D, 0xC0, 0x00,
  0x6C, 0x00, 0x03, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x6C, 0x00, 0x06, 0x70, 0x00, 0x71, 0x80, 0x07, 0x0C, 0x00, 0x30,
  0x70, 0x03, 0x01, 0x80, 0x38, 0x0C, 0x03, 0x80, 0x70, 0x38, 0x01, 0x83,
  0x80, 0x0E, 0x00, 0x00, 0xC0, 0x07, 0x00, 0xC0, 0x07, 0x00, 0xC0, 0x0E,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x1C, 0x00, 0xE0, 0x18, 0x00, 0xE0, 0x38,
  0x00, 0xE0, 0x30, 0x00, 0x60, 0x70, 0x00, 0x60, 0x60, 0x00, 0x60, 0xE0,
  0x00, 0x60, 0xC0, 0x00, 0x61, 0xC0, 0x00, 0x61, 0x80, 0x00, 0x63, 0x80,
  0x00, 0x63, 0x00, 0x00, 0x77, 0x00, 0x00, 0x76, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0xFF, 0xC1,
  0xFF, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x01, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x3F, 0xFF, 0x0F, 0xFF,
  0x80, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x3C,
  0x00, 0xF0, 0x00, 0xF8, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x38, 0x00, 0x3C,
  0x00, 0x1F, 0x00, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0x18, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x30, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x3E, 0x00, 0x70, 0x00, 0xE0,
  0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x0E, 0x00, 0x3C, 0x00, 0xFC, 0x00, 0xE0, 0x00, 0x3E, 0x00, 0x7F, 0xE0,
  0x1E, 0x3F, 0x1E, 0x01, 0xFE, 0x80, 0x1E, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_LightItalic44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 10, 31, 10, 1, -31 },
  { 40, 11, 11, 15, 5, -31 },
  { 56, 24, 31, 24, 1, -31 },
  { 149, 20, 36, 21, 1, -33 },
  { 239, 26, 32, 31, 3, -32 },
  { 343, 23, 32, 25, 1, -32 },
  { 435, 4, 11, 8, 5, -31 },
  { 441, 13, 38, 11, 1, -31 },
  { 503, 13, 38, 11, -3, -31 },
  { 565, 16, 17, 21, 5, -33 },
  { 599, 18, 21, 23, 3, -26 },
  { 647, 7, 11, 9, -2, -5 },
  { 657, 11, 2, 13, 1, -13 },
  { 660, 4, 4, 9, 1, -4 },
  { 662, 20, 31, 14, -2, -31 },
  { 740, 19, 32, 21, 2, -32 },
  { 816, 11, 31, 21, 6, -31 },
  { 859, 20, 32, 21, 0, -32 },
  { 939, 21, 32, 21, 0, -32 },
  { 1023, 20, 32, 21, 0, -32 },
  { 1103, 20, 31, 21, 1, -31 },
  { 1181, 19, 32, 21, 2, -32 },
  { 1257, 19, 31, 21, 3, -31 },
  { 1331, 20, 32, 21, 1, -32 },
  { 1411, 19, 32, 21, 1, -32 },
  { 1487, 7, 24, 9, 1, -24 },
  { 1508, 11, 30, 9, -2, -24 },
  { 1550, 18, 20, 23, 3, -26 },
  { 1595, 18, 11, 23, 3, -21 },
  { 1620, 18, 20, 23, 3, -26 },
  { 1665, 15, 32, 16, 2, -32 },
  { 1725, 29, 35, 32, 2, -31 },
  { 1852, 22, 32, 21, -3, -32 },
  { 1940, 22, 31, 23, 1, -31 },
  { 2026, 22, 32, 22, 3, -32 },
  { 2114, 24, 31, 26, 1, -31 },
  { 2207, 21, 31, 20, 1, -31 },
  { 2289, 21, 31, 19, 1, -31 },
  { 2371, 23, 32, 27, 3, -32 },
  { 2463, 26, 31, 26, 1, -31 },
  { 2564, 15, 31, 12, -1, -31 },
  { 2623, 17, 39, 10, -7, -31 },
  { 2706, 24, 31, 21, 1, -31 },
  { 2799, 15, 31, 19, 1, -31 },
  { 2858, 32, 31, 33, 1, -31 },
  { 2982, 26, 31, 27, 1, -31 },
  { 3083, 23, 32, 28, 3, -32 },
  { 3175, 21, 31, 22, 1, -31 },
  { 3257, 23, 39, 28, 3, -32 },
  { 3370, 21, 31, 22, 1, -31 },
  { 3452, 21, 32, 20, 0, -32 },
  { 3536, 19, 31, 19, 4, -31 },
  { 3610, 24, 31, 26, 3, -31 },
  { 3703, 21, 31, 21, 4, -31 },
  { 3785, 32, 31, 34, 5, -31 },
  { 3909, 26, 31, 20, -3, -31 },
  { 4010, 19, 31, 19, 4, -31 },
  { 4084, 23, 31, 20, -1, -31 },
  { 4174, 17, 38, 13, -1, -31 },
  { 4255, 7, 31, 15, 5, -31 },
  { 4283, 16, 38, 13, -3, -31 },
  { 4359, 20, 19, 22, 1, -32 },
  { 4407, 16, 2, 15, -4, 4 },
  { 4411, 6, 7, 11, 6, -34 },
  { 4417, 19, 24, 22, 2, -24 },
  { 4474, 20, 33, 22, 1, -33 },
  { 4557, 16, 24, 17, 2, -24 },
  { 4605, 22, 33, 22, 2, -33 },
  { 4696, 16, 24, 19, 2, -24 },
  { 4744, 22, 45, 11, -5, -34 },
  { 4868, 21, 35, 22, 0, -24 },
  { 4960, 19, 33, 22, 1, -33 },
  { 5039, 9, 32, 9, 1, -32 },
  { 5075, 16, 43, 9, -6, -32 },
  { 5161, 19, 33, 18, 1, -33 },
  { 5240, 9, 33, 9, 1, -33 },
  { 5278, 30, 24, 33, 1, -24 },
  { 5368, 19, 24, 22, 1, -24 },
  { 5425, 18, 24, 22, 2, -24 },
  { 5479, 22, 34, 22, -1, -24 },
  { 5573, 19, 34, 22, 2, -24 },
  { 5654, 15, 24, 15, 1, -24 },
  { 5699, 16, 24, 17, 0, -24 },
  { 5747, 11, 29, 12, 2, -29 },
  { 5787, 19, 23, 22, 2, -23 },
  { 5842, 17, 23, 17, 2, -23 },
  { 5891, 26, 23, 27, 3, -23 },
  { 5966, 21, 23, 18, -2, -23 },
  { 6027, 24, 34, 17, -5, -23 },
  { 6129, 18, 23, 16, -1, -23 },
  { 6181, 16, 38, 15, 1, -31 },
  { 6257, 2, 44, 21, 10, -33 },
  { 6268, 16, 38, 15, -2, -31 },
  { 6344, 18, 5, 23, 3, -18 },
};

const GFXfont NotoSans_SemiCondensed_LightItalic44pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_LightItalic44pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_LightItalic44pt7bGlyphs,
  0x20, 0x7E, 60
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHTITALIC44PT7B_H_
