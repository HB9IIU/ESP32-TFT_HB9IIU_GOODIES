#ifndef _NOTOSANS_SEMICONDENSED_LIGHTITALIC64PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHTITALIC64PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-LightItalic.ttf
// Size: 64pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_LightItalic64pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xF0,
  0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x01, 0xE0, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x01, 0xE0, 0x02, 0x00, 0x00,
  0x3C, 0x0F, 0x3C, 0x0E, 0x3C, 0x0E, 0x3C, 0x1E, 0x38, 0x1E, 0x38, 0x1C,
  0x78, 0x1C, 0x78, 0x1C, 0x70, 0x1C, 0x70, 0x38, 0x70, 0x38, 0x70, 0x38,
  0xE0, 0x38, 0xE0, 0x30, 0xE0, 0x70, 0xE0, 0x70, 0xC0, 0x70, 0x00, 0x00,
  0x70, 0x07, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x38, 0x00,
  0x00, 0x70, 0x07, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x38,
  0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x38, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x38, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x01,
  0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x38, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x38,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00,
  0x38, 0x03, 0x80, 0x00, 0x07, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x1C, 0x00,
  0x00, 0x38, 0x03, 0x80, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x1C,
  0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x0E, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xC6, 0x1E, 0x01, 0xF0, 0xE0, 0x20, 0x3C,
  0x0E, 0x00, 0x03, 0xC0, 0xC0, 0x00, 0x38, 0x0C, 0x00, 0x07, 0x81, 0xC0,
  0x00, 0x78, 0x1C, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x70, 0x18, 0x00, 0x07,
  0x81, 0x80, 0x00, 0x78, 0x38, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x3E, 0x38,
  0x00, 0x01, 0xF3, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x06,
  0xF8, 0x00, 0x00, 0xE7, 0xC0, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0xC1, 0xE0,
  0x00, 0x0C, 0x0F, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x1C, 0x0F, 0x00, 0x01,
  0xC0, 0xF0, 0x00, 0x18, 0x0F, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x38, 0x0E,
  0x00, 0x03, 0x81, 0xE0, 0x00, 0x38, 0x3C, 0x0C, 0x03, 0x07, 0x80, 0xFC,
  0x33, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xF0, 0x07, 0xFC, 0x00, 0x03, 0x80,
  0x3F, 0xF8, 0x00, 0x1C, 0x01, 0xE0, 0xE0, 0x00, 0xF0, 0x0F, 0x03, 0xC0,
  0x03, 0x80, 0x38, 0x07, 0x00, 0x1C, 0x01, 0xE0, 0x1C, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x03, 0x80, 0x0E, 0x00, 0xF0, 0x1C, 0x00, 0x70,
  0x03, 0x80, 0x70, 0x01, 0xC0, 0x0E, 0x03, 0x80, 0x07, 0x00, 0x38, 0x1E,
  0x00, 0x1C, 0x00, 0xE0, 0x70, 0x00, 0x70, 0x07, 0x83, 0x80, 0x01, 0xC0,
  0x1C, 0x1E, 0x00, 0x07, 0x00, 0x70, 0x70, 0x7E, 0x3C, 0x01, 0xC3, 0x87,
  0xFC, 0xE0, 0x0E, 0x1E, 0x3F, 0xF9, 0xC0, 0x38, 0x71, 0xE0, 0xE7, 0x01,
  0xC3, 0x87, 0x03, 0xDC, 0x0F, 0x1E, 0x3C, 0x07, 0x78, 0x78, 0x70, 0xE0,
  0x1C, 0xFF, 0xC3, 0x87, 0x00, 0x73, 0xFE, 0x1E, 0x1C, 0x01, 0xC7, 0xF0,
  0x70, 0xF0, 0x07, 0x00, 0x03, 0x83, 0x80, 0x1C, 0x00, 0x1E, 0x0E, 0x00,
  0x70, 0x00, 0x70, 0x38, 0x01, 0xC0, 0x03, 0x81, 0xC0, 0x0F, 0x00, 0x1E,
  0x07, 0x00, 0x38, 0x00, 0x70, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x70, 0x03,
  0x80, 0x0E, 0x01, 0xC0, 0x1E, 0x00, 0x70, 0x07, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x0F, 0x00, 0x70, 0x01, 0xC0, 0x38,
  0x03, 0xC0, 0x07, 0x01, 0xE0, 0x0E, 0x00, 0x1C, 0x07, 0x00, 0x70, 0x00,
  0x70, 0x3C, 0x03, 0xC0, 0x01, 0xF1, 0xE0, 0x0E, 0x00, 0x03, 0xFF, 0x00,
  0x70, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x3C, 0x0F, 0x80, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x0F, 0x00, 0x00, 0xE0, 0x03, 0xC0, 0x00, 0x38, 0x00, 0xF0,
  0x00, 0x0E, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x0E, 0x00, 0x01, 0xE0, 0x07,
  0x80, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x03, 0x80,
  0x78, 0x00, 0x00, 0xF0, 0x3E, 0x00, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0x07,
  0x0F, 0x80, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xEF, 0x00, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x00, 0xF0, 0x78, 0x00,
  0xF0, 0x78, 0x1E, 0x00, 0x78, 0x3C, 0x03, 0xC0, 0x1C, 0x1E, 0x00, 0x78,
  0x0F, 0x0F, 0x00, 0x1E, 0x03, 0xC3, 0xC0, 0x03, 0xC1, 0xE1, 0xE0, 0x00,
  0xF0, 0x70, 0x78, 0x00, 0x1E, 0x3C, 0x1C, 0x00, 0x07, 0x9E, 0x07, 0x00,
  0x00, 0xF7, 0x83, 0xC0, 0x00, 0x3F, 0xC0, 0xF0, 0x00, 0x07, 0xE0, 0x3C,
  0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x7C, 0x01, 0xC0, 0x00, 0x3F, 0x80,
  0x78, 0x00, 0x1F, 0xE0, 0x1F, 0x00, 0x0F, 0x3C, 0x03, 0xE0, 0x0F, 0x8F,
  0x00, 0x7F, 0x3F, 0xC1, 0xE0, 0x0F, 0xFF, 0xC0, 0x3C, 0x01, 0xFF, 0xC0,
  0x0F, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0xF3, 0xCF, 0x38, 0xE3, 0x9E,
  0x71, 0xC7, 0x1C, 0xE3, 0x8E, 0x38, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x01, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01,
  0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xC0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x40, 0x0E, 0x00, 0x70,
  0x0C, 0x00, 0xFC, 0x1C, 0x00, 0x7F, 0x1C, 0x00, 0x1F, 0x9C, 0x01, 0x03,
  0xF9, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x7C, 0x00, 0x01,
  0xEC, 0x00, 0x03, 0xCE, 0x00, 0x07, 0x86, 0x00, 0x0F, 0x07, 0x00, 0x1E,
  0x07, 0x00, 0x3C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x18, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0xC0, 0xF0, 0x3C, 0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x38, 0x1E, 0x07, 0x03,
  0xC0, 0xE0, 0x38, 0x1C, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x39, 0xF7, 0xFF, 0xF9, 0xE2, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0xFF, 0xFC, 0x00, 0x3F, 0x07, 0xC0, 0x0F, 0x80, 0x7C, 0x01, 0xE0,
  0x07, 0x80, 0x78, 0x00, 0x70, 0x1E, 0x00, 0x0F, 0x03, 0xC0, 0x01, 0xE0,
  0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x87, 0x80, 0x00, 0xF0, 0xF0, 0x00,
  0x1E, 0x1C, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x78, 0xF0, 0x00, 0x0F, 0x3C,
  0x00, 0x01, 0xE7, 0x80, 0x00, 0x3C, 0xF0, 0x00, 0x07, 0x9C, 0x00, 0x00,
  0xF7, 0x80, 0x00, 0x1E, 0xF0, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x73, 0x80,
  0x00, 0x1E, 0x70, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x0E,
  0x78, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x0F, 0x3C, 0x00,
  0x01, 0xC7, 0x80, 0x00, 0x78, 0xF0, 0x00, 0x0F, 0x1E, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0x78, 0x78, 0x00, 0x0E, 0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0x78, 0x3C, 0x00, 0x1E, 0x03, 0x80, 0x07, 0x80, 0x78, 0x01, 0xF0, 0x0F,
  0x00, 0x7C, 0x00, 0xF8, 0x1F, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x1E,
  0x00, 0x7E, 0x00, 0xFE, 0x01, 0xFE, 0x07, 0xDE, 0x0F, 0x9C, 0x3F, 0x1C,
  0x7C, 0x3C, 0xF8, 0x3C, 0x60, 0x3C, 0x40, 0x38, 0x00, 0x38, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0,
  0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1C, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xF8, 0x07, 0xC0, 0x03, 0xC0, 0x07, 0xC0,
  0x03, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x3F, 0x80, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0x80,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F,
  0x03, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x0F, 0xC0, 0x3F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xF7, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00,
  0xF3, 0xC0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0xE0,
  0xE0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x3C, 0x1E, 0x00, 0x01, 0xE0, 0x70,
  0x00, 0x07, 0x01, 0xC0, 0x00, 0x38, 0x07, 0x00, 0x01, 0xE0, 0x3C, 0x00,
  0x0F, 0x00, 0xF0, 0x00, 0x38, 0x03, 0x80, 0x01, 0xC0, 0x0E, 0x00, 0x0F,
  0x00, 0x78, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00,
  0x1C, 0x00, 0x70, 0x00, 0x70, 0x03, 0xC0, 0x03, 0xC0, 0x1E, 0x00, 0x0F,
  0x00, 0x70, 0x00, 0x38, 0x03, 0x80, 0x00, 0xE0, 0x1E, 0x00, 0x03, 0x80,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x38, 0x30, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x0F, 0xE7, 0xF8, 0x00, 0x20, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3E, 0x02, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x1F, 0x80, 0x3F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0xFC, 0x01, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x1F, 0xF0, 0x03, 0xC7, 0xFF, 0x80,
  0x3C, 0xFF, 0xFC, 0x03, 0x9E, 0x03, 0xE0, 0x3B, 0x80, 0x1F, 0x07, 0xF0,
  0x00, 0xF0, 0x7E, 0x00, 0x07, 0x07, 0xC0, 0x00, 0x78, 0x78, 0x00, 0x07,
  0x87, 0x80, 0x00, 0x78, 0x70, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x78, 0xF0,
  0x00, 0x07, 0x8F, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x07, 0x0F, 0x00, 0x00,
  0x70, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0E, 0x0F,
  0x00, 0x01, 0xE0, 0x70, 0x00, 0x1C, 0x07, 0x80, 0x03, 0xC0, 0x78, 0x00,
  0x78, 0x03, 0xC0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x01, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xF8,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x78, 0x00, 0x78, 0x07, 0x80, 0x01,
  0xC0, 0x3C, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x78, 0x1E, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xE0, 0x3C, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0x78, 0x07, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x3C, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x3C, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x78, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x3E, 0x03, 0xE0, 0x03, 0xE0, 0x0F,
  0x00, 0x3C, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x07, 0x87, 0x00,
  0x00, 0x3C, 0x38, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x0F, 0x0E, 0x00, 0x00,
  0x78, 0x70, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x01, 0xE0,
  0xF8, 0x00, 0x1E, 0x03, 0xE0, 0x01, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x7F,
  0xDF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xD0,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0x80, 0x0F, 0xC0, 0xF8, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x1C, 0x03,
  0xC0, 0x01, 0xE0, 0x3C, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xE0, 0x70, 0x00,
  0x0F, 0x0F, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0xF1,
  0xE0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x0F, 0x1E, 0x00,
  0x00, 0xF1, 0xE0, 0x00, 0x1E, 0x1E, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x1E,
  0x1E, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x7E, 0x0F, 0x00, 0x07, 0xE0, 0xF0,
  0x01, 0xDC, 0x07, 0x80, 0x3D, 0xC0, 0x7F, 0x1F, 0xBC, 0x03, 0xFF, 0xE3,
  0xC0, 0x0F, 0xFC, 0x38, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x80, 0x1F, 0x80, 0x0F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x40, 0x3C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0x70, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x1E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x10,
  0x00, 0x00, 0x04, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80,
  0x0F, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x7F,
  0xFE, 0x0F, 0xFF, 0xF8, 0x3C, 0x07, 0xE1, 0x80, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x00, 0x00, 0x1C, 0x0E, 0x00,
  0x07, 0xF0, 0x03, 0x83, 0xC0, 0x07, 0xFF, 0xC0, 0x70, 0x70, 0x01, 0xFF,
  0xF8, 0x0E, 0x1E, 0x00, 0x78, 0x0E, 0x01, 0xC3, 0x80, 0x1E, 0x01, 0xC0,
  0x3C, 0xF0, 0x07, 0x00, 0x38, 0x07, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0xE3,
  0x80, 0x78, 0x01, 0xC0, 0x1C, 0xF0, 0x0E, 0x00, 0x38, 0x03, 0x9C, 0x03,
  0xC0, 0x07, 0x00, 0x73, 0x80, 0x70, 0x01, 0xC0, 0x0E, 0x70, 0x0E, 0x00,
  0x38, 0x01, 0xDE, 0x03, 0x80, 0x07, 0x00, 0x7B, 0x80, 0x70, 0x00, 0xE0,
  0x0E, 0x70, 0x0E, 0x00, 0x38, 0x01, 0xCE, 0x01, 0xC0, 0x07, 0x00, 0x39,
  0xC0, 0x38, 0x01, 0xE0, 0x0E, 0x38, 0x0F, 0x00, 0x3C, 0x01, 0xC7, 0x01,
  0xE0, 0x07, 0x80, 0x70, 0xE0, 0x1C, 0x01, 0xF0, 0x0E, 0x1C, 0x03, 0x80,
  0x7E, 0x03, 0x83, 0x80, 0x70, 0x1D, 0xC0, 0xF0, 0x70, 0x0F, 0x07, 0x38,
  0x3C, 0x0E, 0x00, 0xFF, 0xE3, 0xFF, 0x01, 0xC0, 0x0F, 0xF0, 0x7F, 0xC0,
  0x3C, 0x00, 0xFC, 0x03, 0xE0, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x01, 0x80, 0x00, 0x03, 0xFC, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x07, 0x38, 0x00,
  0x00, 0x1E, 0x70, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0xF1, 0xC0, 0x00,
  0x01, 0xC3, 0xC0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x0E, 0x0F, 0x00, 0x00,
  0x3C, 0x1E, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x03,
  0x80, 0x70, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x78,
  0x03, 0x80, 0x00, 0xE0, 0x07, 0x00, 0x03, 0xC0, 0x0E, 0x00, 0x07, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0xF0, 0x00,
  0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0x80, 0x3C, 0x00, 0x07, 0x00, 0x78, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x1C,
  0x03, 0xC0, 0x00, 0x38, 0x0F, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0xF0,
  0x78, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x07, 0x87,
  0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x1E, 0x38, 0x00, 0x00, 0x1C, 0xF0,
  0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x77, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0x00, 0x0F, 0xC0, 0x1E,
  0x00, 0x07, 0x80, 0x3C, 0x00, 0x07, 0x80, 0x78, 0x00, 0x0F, 0x00, 0xE0,
  0x00, 0x1E, 0x01, 0xC0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x78, 0x0F, 0x00,
  0x00, 0xF0, 0x1E, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x03, 0xC0, 0x70, 0x00,
  0x07, 0x01, 0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x3C, 0x07, 0x80, 0x00,
  0xF0, 0x0E, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x1F, 0x00, 0x78, 0x0F, 0xFC,
  0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x0F, 0x00, 0x0F, 0x80, 0x1E, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x07, 0x80,
  0x70, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x00, 0xF0, 0x38,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x07, 0x03, 0xC0,
  0x00, 0x1E, 0x07, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0xF0, 0x3C, 0x00,
  0x03, 0xE0, 0x78, 0x00, 0x0F, 0x80, 0xE0, 0x00, 0x7E, 0x01, 0xC0, 0x07,
  0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x1F, 0xE0, 0x1E, 0x00, 0x3F, 0x00, 0x06, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x06, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x70, 0x01, 0xFC, 0x00, 0x3C, 0x00, 0x1F, 0x80,
  0x0F, 0x00, 0x03, 0xE0, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0xE0, 0x00, 0x0F,
  0x00, 0x38, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00,
  0x1E, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x70, 0x00, 0x00, 0xE0, 0x1C, 0x00,
  0x00, 0x3C, 0x0F, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x00, 0xF0, 0x38, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x78,
  0x1C, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x01,
  0xE0, 0xF0, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00,
  0x0F, 0x07, 0x80, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x01, 0xE0, 0x78, 0x00,
  0x00, 0x78, 0x1C, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x1F, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0xF0, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x01, 0xF0, 0x0E,
  0x00, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x7C, 0x01, 0xE0, 0x00, 0x3E, 0x00,
  0x78, 0x00, 0x3F, 0x00, 0x1C, 0x00, 0x3F, 0x80, 0x07, 0x00, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x70,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x0F, 0xF0, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x18, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0xFF, 0xF0, 0xF0, 0x00, 0x3F,
  0xFE, 0x1E, 0x00, 0x07, 0xFF, 0xC3, 0xC0, 0x00, 0x00, 0x78, 0x78, 0x00,
  0x00, 0x0E, 0x0F, 0x00, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x00, 0x78, 0x3C,
  0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x38,
  0x1E, 0x00, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x00,
  0x3C, 0x07, 0x80, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x1F, 0x00,
  0x00, 0x3C, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x3E, 0x00, 0x00, 0xF0, 0x03,
  0xE0, 0x00, 0x1C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x1E, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00,
  0x0F, 0x00, 0x78, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x1E,
  0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x07, 0x00, 0x00, 0x0F,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x1E, 0x00,
  0x00, 0x1C, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x07, 0x00, 0x00, 0x0F, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x1E, 0x00, 0x00,
  0x1C, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x7F,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x78, 0x00,
  0x00, 0x70, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x3C, 0x00,
  0xE0, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x00,
  0x70, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0xE0,
  0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x00, 0x70,
  0x03, 0xC0, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x00, 0x70, 0x03,
  0x80, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x1E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x0F, 0x00, 0x00, 0xF0, 0x01,
  0xE0, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x07, 0x00, 0x03, 0xE0,
  0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x0F,
  0x80, 0x00, 0xE0, 0x03, 0xE0, 0x00, 0x1C, 0x00, 0xF8, 0x00, 0x07, 0x80,
  0x1E, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x03,
  0x80, 0x78, 0x00, 0x00, 0x70, 0x1E, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0x00, 0x78, 0x7C, 0x00, 0x00, 0x0E, 0x1F, 0x00,
  0x00, 0x03, 0xC7, 0xC0, 0x00, 0x00, 0x79, 0xF0, 0x00, 0x00, 0x0F, 0x7E,
  0x00, 0x00, 0x01, 0xDF, 0xE0, 0x00, 0x00, 0x3B, 0xBC, 0x00, 0x00, 0x0F,
  0xE3, 0x80, 0x00, 0x01, 0xF8, 0x78, 0x00, 0x00, 0x3E, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0xF0, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0x00, 0x3C, 0x01, 0xC0,
  0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x1C, 0x00,
  0x70, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x0E, 0x00, 0x01, 0xE0, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x0F, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x03, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xF8, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x1F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x0E, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x3B, 0x80, 0x00, 0x01, 0xDE, 0x00,
  0xEE, 0x00, 0x00, 0x0F, 0x78, 0x03, 0xBC, 0x00, 0x00, 0x39, 0xC0, 0x1E,
  0xF0, 0x00, 0x01, 0xE7, 0x00, 0x79, 0xC0, 0x00, 0x07, 0x3C, 0x01, 0xC7,
  0x00, 0x00, 0x3C, 0xF0, 0x07, 0x1C, 0x00, 0x00, 0xE3, 0x80, 0x1C, 0x70,
  0x00, 0x07, 0x8E, 0x00, 0xF1, 0xC0, 0x00, 0x1C, 0x78, 0x03, 0xC7, 0x00,
  0x00, 0xF1, 0xE0, 0x0E, 0x1C, 0x00, 0x07, 0x87, 0x80, 0x38, 0x78, 0x00,
  0x1E, 0x1C, 0x01, 0xE1, 0xE0, 0x00, 0xF0, 0x70, 0x07, 0x83, 0x80, 0x03,
  0x83, 0xC0, 0x1C, 0x0E, 0x00, 0x1E, 0x0F, 0x00, 0x70, 0x38, 0x00, 0x70,
  0x3C, 0x01, 0xC0, 0xE0, 0x03, 0xC0, 0xE0, 0x0F, 0x03, 0x80, 0x0E, 0x03,
  0x80, 0x3C, 0x0E, 0x00, 0x78, 0x1E, 0x00, 0xE0, 0x38, 0x01, 0xC0, 0x78,
  0x03, 0x80, 0xF0, 0x0F, 0x01, 0xE0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0x78, 0x07, 0x01, 0xE0, 0x3C, 0x01, 0xE0, 0x1C, 0x07, 0x00, 0xF0, 0x07,
  0x00, 0x70, 0x3C, 0x03, 0xC0, 0x1C, 0x01, 0xC0, 0xE0, 0x0E, 0x00, 0xF0,
  0x07, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1C, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x70, 0xE0, 0x07, 0x80, 0x38, 0x01, 0xE7, 0x80, 0x1E, 0x00, 0xE0, 0x03,
  0x9C, 0x00, 0x70, 0x07, 0x80, 0x0E, 0xF0, 0x01, 0xC0, 0x1E, 0x00, 0x3B,
  0x80, 0x0F, 0x00, 0x70, 0x00, 0xFE, 0x00, 0x3C, 0x01, 0xC0, 0x03, 0xF0,
  0x00, 0xF0, 0x07, 0x00, 0x0F, 0xC0, 0x03, 0x80, 0x3C, 0x00, 0x3E, 0x00,
  0x0E, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x03, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0x00, 0xF0,
  0x07, 0xC0, 0x00, 0x03, 0x80, 0x1F, 0x00, 0x00, 0x0E, 0x00, 0x7E, 0x00,
  0x00, 0x78, 0x03, 0xF8, 0x00, 0x01, 0xE0, 0x0E, 0xE0, 0x00, 0x07, 0x80,
  0x3B, 0xC0, 0x00, 0x1C, 0x00, 0xEF, 0x00, 0x00, 0x70, 0x03, 0x9C, 0x00,
  0x03, 0xC0, 0x1E, 0x78, 0x00, 0x0F, 0x00, 0x79, 0xE0, 0x00, 0x3C, 0x01,
  0xC3, 0x80, 0x00, 0xE0, 0x07, 0x0F, 0x00, 0x03, 0x80, 0x1C, 0x3C, 0x00,
  0x1E, 0x00, 0xF0, 0x70, 0x00, 0x78, 0x03, 0xC1, 0xE0, 0x01, 0xC0, 0x0E,
  0x07, 0x80, 0x07, 0x00, 0x38, 0x0E, 0x00, 0x3C, 0x01, 0xE0, 0x38, 0x00,
  0xF0, 0x07, 0x80, 0xF0, 0x03, 0xC0, 0x1E, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0x38, 0x07,
  0x80, 0x3C, 0x00, 0xE0, 0x1E, 0x00, 0xE0, 0x03, 0xC0, 0x70, 0x03, 0x80,
  0x0F, 0x01, 0xC0, 0x0E, 0x00, 0x1C, 0x0F, 0x00, 0x78, 0x00, 0x78, 0x3C,
  0x01, 0xE0, 0x01, 0xE0, 0xE0, 0x07, 0x00, 0x03, 0x83, 0x80, 0x1C, 0x00,
  0x0F, 0x0E, 0x00, 0xF0, 0x00, 0x3C, 0x78, 0x03, 0xC0, 0x00, 0x71, 0xE0,
  0x0F, 0x00, 0x01, 0xE7, 0x00, 0x38, 0x00, 0x07, 0x9C, 0x00, 0xE0, 0x00,
  0x0E, 0x70, 0x07, 0x80, 0x00, 0x3F, 0xC0, 0x1E, 0x00, 0x00, 0xFF, 0x00,
  0x70, 0x00, 0x01, 0xF8, 0x01, 0xC0, 0x00, 0x07, 0xE0, 0x07, 0x00, 0x00,
  0x1F, 0x80, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x03,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x7E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x1F, 0x00, 0x00, 0xF8, 0x07,
  0x80, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x00, 0xF0,
  0x78, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x03,
  0xC7, 0x80, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0x1C, 0x78, 0x00, 0x00,
  0x07, 0x3C, 0x00, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x00, 0xF3, 0x80, 0x00,
  0x00, 0x3D, 0xE0, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x03, 0xDE, 0x00,
  0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x00, 0x7B,
  0xC0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x03,
  0xCF, 0x00, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00,
  0x1E, 0x3C, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0x00, 0xF0, 0x78, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x3E, 0x07, 0x80,
  0x00, 0x1F, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x3E, 0x00, 0x07, 0xC0, 0x07,
  0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x03, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x70, 0x01, 0xF0, 0x03, 0xC0, 0x03, 0xE0,
  0x0F, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x3C, 0x03,
  0x80, 0x00, 0xF0, 0x1E, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x0F, 0x01, 0xE0,
  0x00, 0x3C, 0x07, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0x38, 0x0F, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x3C, 0x07, 0x80, 0x01, 0xF0, 0x1E, 0x00, 0x0F, 0x80,
  0x70, 0x00, 0xFC, 0x01, 0xC0, 0x0F, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFE, 0x03, 0xF8, 0x00,
  0x7E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x1F, 0x00, 0x00, 0xF8,
  0x07, 0x80, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x00,
  0xF0, 0x78, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00,
  0x03, 0xC7, 0x80, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0x1C, 0x78, 0x00,
  0x00, 0x07, 0x3C, 0x00, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x00, 0xF3, 0x80,
  0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x03, 0xDE,
  0x00, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x00,
  0x7B, 0xC0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x07, 0x3C, 0x00, 0x00,
  0x03, 0xCF, 0x00, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x7C, 0xF0, 0x00,
  0x00, 0x1E, 0x3C, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x3E, 0x07,
  0x80, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x3E, 0x00, 0x07, 0xC0,
  0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x70, 0x01, 0xF0, 0x03, 0xC0, 0x03, 0xE0, 0x0F, 0x00, 0x07, 0x80,
  0x3C, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x3C, 0x03, 0x80, 0x00, 0xF0, 0x1E,
  0x00, 0x03, 0xC0, 0x78, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x3C, 0x07, 0x00,
  0x00, 0xF0, 0x1C, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0x78, 0x0F, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x3C,
  0x07, 0x80, 0x03, 0xE0, 0x1E, 0x00, 0x1F, 0x00, 0x70, 0x01, 0xF8, 0x01,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xF0,
  0x0E, 0x00, 0x03, 0x80, 0x38, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x78, 0x03,
  0xC0, 0x01, 0xE0, 0x07, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x1C, 0x00, 0x78,
  0x00, 0xF0, 0x00, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x0F, 0x00, 0x0F, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x78, 0x07, 0x80, 0x01, 0xE0, 0x1E,
  0x00, 0x07, 0x80, 0x78, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x3C, 0x07, 0x00,
  0x00, 0xF0, 0x3C, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xC0, 0x0F, 0xC0, 0x3E, 0x00, 0x7C, 0x00, 0x18, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x02,
  0x00, 0x01, 0xF0, 0x0F, 0x00, 0x1F, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xE0, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x00, 0x1C, 0x07, 0x80, 0x00,
  0x07, 0x80, 0xE0, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00, 0x1E, 0x07, 0x80,
  0x00, 0x03, 0x80, 0xF0, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x1E, 0x03,
  0x80, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x00, 0x70, 0x1E, 0x00, 0x00, 0x0E,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x00, 0x38, 0x0F, 0x00,
  0x00, 0x0F, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x00, 0x3C, 0x0F,
  0x00, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x3C,
  0x07, 0x00, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x00,
  0x1C, 0x07, 0x80, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0xF0, 0x1C, 0x00,
  0x00, 0x1E, 0x03, 0x80, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x00, 0xF0, 0x1E,
  0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0xF0,
  0x0F, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00,
  0xF0, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x07, 0x80,
  0x03, 0xE0, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xBC, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x03, 0xCF,
  0x00, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0x78, 0x70, 0x00, 0x03, 0xC1, 0xC0,
  0x00, 0x0F, 0x07, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x01, 0xE0, 0x70, 0x00,
  0x0F, 0x01, 0xC0, 0x00, 0x3C, 0x07, 0x80, 0x01, 0xE0, 0x1E, 0x00, 0x07,
  0x80, 0x78, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0xF0, 0x07, 0x80, 0x07, 0x80,
  0x1E, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x00, 0xE0, 0x03, 0xC0, 0x03,
  0x80, 0x1E, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x38, 0x03, 0xC0, 0x00, 0xE0,
  0x0F, 0x00, 0x03, 0x80, 0x78, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x3C, 0x0F,
  0x00, 0x00, 0xF0, 0x3C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0x3C, 0x3C, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x01, 0xC7, 0x80, 0x00,
  0x07, 0x1E, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x01,
  0xCE, 0x00, 0x00, 0x07, 0x78, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF7,
  0x00, 0x00, 0x7C, 0x00, 0x03, 0xCE, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x9C,
  0x00, 0x03, 0xF0, 0x00, 0x0E, 0x38, 0x00, 0x07, 0xE0, 0x00, 0x3C, 0x70,
  0x00, 0x1D, 0xC0, 0x00, 0x78, 0xE0, 0x00, 0x3B, 0x80, 0x01, 0xE1, 0xC0,
  0x00, 0xF7, 0x00, 0x03, 0xC3, 0x80, 0x01, 0xCE, 0x00, 0x0F, 0x07, 0x00,
  0x07, 0x9C, 0x00, 0x1E, 0x0E, 0x00, 0x0E, 0x38, 0x00, 0x38, 0x1C, 0x00,
  0x1C, 0x70, 0x00, 0xF0, 0x38, 0x00, 0x70, 0xE0, 0x01, 0xC0, 0x70, 0x00,
  0xE1, 0xC0, 0x07, 0x80, 0xE0, 0x03, 0xC3, 0x80, 0x0F, 0x01, 0xC0, 0x07,
  0x07, 0x00, 0x3C, 0x03, 0x80, 0x1E, 0x0E, 0x00, 0x78, 0x07, 0x80, 0x38,
  0x1C, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x38, 0x03, 0xC0, 0x1E, 0x01, 0xC0,
  0x70, 0x07, 0x00, 0x3C, 0x03, 0x80, 0xE0, 0x1E, 0x00, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x00, 0xF0, 0x1C, 0x03, 0xC0, 0x70, 0x01, 0xE0, 0x78, 0x07,
  0x81, 0xE0, 0x03, 0xC0, 0xE0, 0x0F, 0x03, 0x80, 0x07, 0x83, 0xC0, 0x1E,
  0x0F, 0x00, 0x0F, 0x07, 0x00, 0x3C, 0x1C, 0x00, 0x1E, 0x1E, 0x00, 0x38,
  0x78, 0x00, 0x3C, 0x38, 0x00, 0x70, 0xE0, 0x00, 0x78, 0x70, 0x00, 0xE1,
  0xC0, 0x00, 0xF1, 0xE0, 0x01, 0xC7, 0x80, 0x01, 0xE3, 0x80, 0x03, 0x8E,
  0x00, 0x03, 0xCF, 0x00, 0x07, 0x3C, 0x00, 0x07, 0x9C, 0x00, 0x0E, 0x70,
  0x00, 0x0F, 0x78, 0x00, 0x1D, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x3B, 0x80,
  0x00, 0x1D, 0xC0, 0x00, 0x77, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x01, 0xE0, 0x00, 0x03, 0x80, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0x1C, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00, 0x00,
  0x1C, 0x3C, 0x00, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x00, 0x07, 0xBC, 0x00,
  0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x00,
  0x78, 0xE0, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00, 0x00, 0x78, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0xE0, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x3C, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x07, 0x00, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x07,
  0x00, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0x78, 0x00, 0x03, 0xC7,
  0x00, 0x00, 0x78, 0xE0, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0xF0, 0x38, 0x00, 0x3C, 0x07, 0x00, 0x07, 0x80, 0xF0, 0x01, 0xE0, 0x1E,
  0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x03, 0xC0, 0x07, 0x00, 0x70,
  0x00, 0xF0, 0x1E, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xC0, 0xE0, 0x00, 0x38,
  0x3C, 0x00, 0x07, 0x0F, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x1E, 0x78, 0x00,
  0x01, 0xCE, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x3C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xE0, 0x78,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1E, 0x07, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x3C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xE0, 0x78, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0xC0, 0x70, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x0E, 0x70, 0x00,
  0x01, 0xE3, 0x80, 0x00, 0x1C, 0x38, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x38,
  0x1C, 0x00, 0x07, 0x01, 0xC0, 0x00, 0xF0, 0x0E, 0x00, 0x0E, 0x00, 0xE0,
  0x01, 0xE0, 0x0F, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x07, 0x00, 0x38,
  0x00, 0x78, 0x07, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x38, 0x0E, 0x00, 0x01,
  0xC1, 0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x0E, 0x78,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x70, 0x7F, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF0, 0x3C, 0x1E, 0x07, 0x83,
  0xC0, 0xF0, 0x38, 0x1E, 0x07, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03,
  0xFF, 0x07, 0x00, 0x7F, 0xF8, 0xE0, 0x0F, 0xEF, 0xCE, 0x03, 0xF0, 0x1C,
  0xE0, 0x3C, 0x00, 0xEE, 0x07, 0x80, 0x07, 0xE0, 0xF0, 0x00, 0x7C, 0x0F,
  0x00, 0x07, 0xC1, 0xE0, 0x00, 0x7C, 0x1E, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0x3C, 0x3C, 0x00, 0x07, 0x87, 0x80, 0x00, 0x78, 0x78, 0x00, 0x07, 0x87,
  0x80, 0x00, 0x78, 0x70, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x70, 0xF0, 0x00,
  0x0F, 0x0F, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0xE0,
  0xE0, 0x00, 0x1E, 0x0E, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x3E, 0x0E, 0x00,
  0x03, 0xE0, 0xE0, 0x00, 0x7C, 0x0F, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0xDC,
  0x0F, 0x00, 0x1D, 0xC0, 0x78, 0x03, 0xBC, 0x07, 0xC0, 0x73, 0x80, 0x3F,
  0x7E, 0x38, 0x03, 0xFF, 0xC3, 0x80, 0x0F, 0xF0, 0x38, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x60, 0x00, 0x3C, 0x1F, 0xF0, 0x01,
  0xE3, 0xFF, 0xC0, 0x0E, 0x3F, 0x7F, 0x00, 0x73, 0xC0, 0x78, 0x03, 0xB8,
  0x01, 0xE0, 0x3F, 0x80, 0x0F, 0x01, 0xD8, 0x00, 0x38, 0x0F, 0xC0, 0x01,
  0xE0, 0x7C, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x78, 0x3E, 0x00, 0x03, 0xC1,
  0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x07, 0x87, 0x80,
  0x00, 0x3C, 0x3C, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x0E, 0x0E, 0x00, 0x00,
  0xF0, 0x70, 0x00, 0x07, 0x87, 0x80, 0x00, 0x3C, 0x3C, 0x00, 0x01, 0xC1,
  0xE0, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0x78, 0x3C, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x3C, 0x0F, 0x80, 0x03,
  0xC0, 0xFC, 0x00, 0x3E, 0x07, 0x70, 0x03, 0xE0, 0x39, 0xC0, 0x3E, 0x01,
  0xCF, 0xDF, 0xE0, 0x0C, 0x3F, 0xFE, 0x00, 0xE0, 0x7F, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF8,
  0x07, 0xFB, 0xF0, 0x1F, 0x00, 0x40, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x60, 0x1F,
  0xCF, 0xC0, 0x1F, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x1F, 0xF8,
  0x38, 0x00, 0x7F, 0xF8, 0xF0, 0x03, 0xFD, 0xF9, 0xE0, 0x0F, 0xC0, 0x7B,
  0x80, 0x1E, 0x00, 0x77, 0x00, 0x78, 0x00, 0x6E, 0x01, 0xE0, 0x00, 0x7C,
  0x03, 0xC0, 0x00, 0xF8, 0x0F, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x03, 0xC0,
  0x78, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0x38, 0x0F, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x01, 0xE0, 0x78,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0x3C, 0x07, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x01, 0xF0, 0x1C, 0x00,
  0x03, 0xC0, 0x38, 0x00, 0x0F, 0x80, 0x70, 0x00, 0x1F, 0x00, 0xE0, 0x00,
  0x7E, 0x01, 0xC0, 0x00, 0xFC, 0x03, 0xC0, 0x03, 0xF0, 0x07, 0x80, 0x0E,
  0xE0, 0x07, 0x80, 0x39, 0xC0, 0x0F, 0x80, 0xE3, 0x80, 0x0F, 0xDF, 0x8E,
  0x00, 0x1F, 0xFE, 0x1C, 0x00, 0x0F, 0xF8, 0x38, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0xFE,
  0xFE, 0x01, 0xF0, 0x1E, 0x03, 0xC0, 0x0E, 0x07, 0x80, 0x0F, 0x0F, 0x00,
  0x0F, 0x0F, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x1C, 0x00, 0x0E, 0x3C, 0x00,
  0x1E, 0x38, 0x00, 0x3C, 0x78, 0x00, 0x7C, 0x78, 0x00, 0xF8, 0x70, 0x07,
  0xF0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x20, 0x3E, 0x00,
  0x60, 0x1F, 0xCF, 0xE0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0xF8, 0x20, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x70, 0x01, 0xFF, 0xE1,
  0xC0, 0x1F, 0xEF, 0xC7, 0x00, 0xFC, 0x07, 0xB8, 0x03, 0xC0, 0x0E, 0xE0,
  0x1E, 0x00, 0x1B, 0x80, 0xF0, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0xF8, 0x1E,
  0x00, 0x03, 0xC0, 0x78, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x3C, 0x0F, 0x00,
  0x00, 0xF0, 0x78, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x0E, 0x07, 0x80, 0x00,
  0x38, 0x1C, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x1C,
  0x0F, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x0F, 0x03,
  0x80, 0x00, 0x7C, 0x0E, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x0F, 0x80, 0xE0,
  0x00, 0x3E, 0x03, 0x80, 0x01, 0xF8, 0x0E, 0x00, 0x07, 0xE0, 0x3C, 0x00,
  0x3F, 0x00, 0xF0, 0x01, 0xDC, 0x01, 0xE0, 0x0E, 0x70, 0x07, 0xC0, 0xF3,
  0xC0, 0x0F, 0xDF, 0x8E, 0x00, 0x3F, 0xFC, 0x38, 0x00, 0x3F, 0xE0, 0xE0,
  0x00, 0x18, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x02, 0x00, 0x0F, 0x80, 0x0E, 0x00, 0x7C, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x1C, 0x00, 0x1E, 0x0F, 0xF8, 0x01, 0xE3, 0xFF, 0xC0, 0x1C, 0x7E, 0xFE,
  0x01, 0xCF, 0x01, 0xE0, 0x1D, 0xC0, 0x0F, 0x03, 0xF8, 0x00, 0xF0, 0x3B,
  0x00, 0x0F, 0x03, 0xE0, 0x00, 0xF0, 0x3E, 0x00, 0x0F, 0x07, 0xC0, 0x00,
  0xF0, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xE0, 0x78, 0x00, 0x0E, 0x07,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00,
  0x1C, 0x0E, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x3C, 0x1E, 0x00, 0x03, 0xC1,
  0xE0, 0x00, 0x38, 0x1C, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x38, 0x3C, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0x78, 0x3C, 0x00, 0x07, 0x03, 0x80, 0x00, 0x70,
  0x38, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0xE0, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1E,
  0x00, 0x00, 0x10, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x38,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x1F, 0x01, 0xE0, 0x03, 0xC0, 0x1C, 0x00, 0x7C, 0x01, 0xC0, 0x07,
  0x80, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x3C, 0x03, 0xC0, 0x03,
  0x80, 0x78, 0x00, 0x38, 0x0F, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x78, 0x3C,
  0x00, 0x07, 0x87, 0x80, 0x00, 0x70, 0xF0, 0x00, 0x07, 0x1E, 0x00, 0x00,
  0xF3, 0xE0, 0x00, 0x0F, 0x7E, 0x00, 0x00, 0xEF, 0xE0, 0x00, 0x0E, 0xEF,
  0x00, 0x00, 0xFC, 0xF0, 0x00, 0x1F, 0x87, 0x80, 0x01, 0xF0, 0x78, 0x00,
  0x1E, 0x03, 0x80, 0x01, 0xC0, 0x3C, 0x00, 0x3C, 0x03, 0xC0, 0x03, 0xC0,
  0x1C, 0x00, 0x3C, 0x01, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x38, 0x00, 0xF0,
  0x07, 0x80, 0x0F, 0x00, 0x78, 0x00, 0xF0, 0x07, 0x80, 0x07, 0x80, 0x70,
  0x00, 0x78, 0x07, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x1C,
  0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F,
  0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x07,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07,
  0x80, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x1F, 0xF0, 0x0F, 0xFC, 0x01,
  0xC3, 0xFF, 0x81, 0xFF, 0xE0, 0x1C, 0xFD, 0xFC, 0x3F, 0xFE, 0x01, 0xCE,
  0x03, 0xC7, 0x01, 0xF0, 0x1D, 0xC0, 0x1C, 0xE0, 0x0F, 0x03, 0xB8, 0x01,
  0xDC, 0x00, 0x70, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0x03, 0xE0, 0x01, 0xF8,
  0x00, 0x70, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x07, 0xC0, 0x01, 0xE0, 0x00,
  0x70, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0,
  0x78, 0x00, 0x3C, 0x00, 0x0F, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0xF0,
  0x00, 0x3C, 0x00, 0x0E, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0xF0, 0x00,
  0x38, 0x00, 0x1E, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0xE0, 0x00, 0x78,
  0x00, 0x1C, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC1, 0xE0, 0x00, 0x70, 0x00,
  0x3C, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0xF0, 0x00, 0x38,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0x83, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x3C,
  0x00, 0x0E, 0x00, 0x07, 0x83, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x38, 0x00,
  0x1E, 0x00, 0x07, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x78, 0x00, 0x1C,
  0x00, 0x0F, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x70, 0x00, 0x3C, 0x00,
  0x0F, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0xF0, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x1C, 0x1F, 0xF8, 0x01, 0xC3, 0xFF, 0xC0,
  0x1C, 0x7F, 0xFE, 0x01, 0xCF, 0x01, 0xE0, 0x3D, 0xC0, 0x0F, 0x03, 0xF8,
  0x00, 0xF0, 0x3F, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0xF0, 0x3E, 0x00, 0x0F,
  0x07, 0xC0, 0x00, 0xF0, 0x7C, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xE0, 0x78,
  0x00, 0x0E, 0x07, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x01,
  0xE0, 0xF0, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x3C, 0x1E,
  0x00, 0x03, 0xC1, 0xE0, 0x00, 0x3C, 0x1E, 0x00, 0x03, 0x81, 0xC0, 0x00,
  0x78, 0x3C, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x78, 0x3C, 0x00, 0x07, 0x03,
  0x80, 0x00, 0x70, 0x38, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0, 0x78, 0x00,
  0x0F, 0x07, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x1E, 0x07, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x1E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x07,
  0xFF, 0xC0, 0x03, 0xFB, 0xF8, 0x01, 0xF0, 0x1F, 0x00, 0xF0, 0x01, 0xE0,
  0x78, 0x00, 0x78, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xC7, 0x80, 0x00,
  0xF1, 0xC0, 0x00, 0x3C, 0xF0, 0x00, 0x07, 0x38, 0x00, 0x01, 0xDE, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x3D, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0E, 0xE0, 0x00, 0x07,
  0xB8, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x3C, 0xE0, 0x00,
  0x0F, 0x38, 0x00, 0x03, 0x8E, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0xF0, 0xF0,
  0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x07, 0x80, 0x0F, 0x00, 0xF8, 0x0F, 0xC0,
  0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x38, 0x1F, 0xF0, 0x00, 0x38, 0x7F,
  0xF8, 0x00, 0x38, 0xFD, 0xFC, 0x00, 0x39, 0xE0, 0x3C, 0x00, 0x3B, 0x80,
  0x1E, 0x00, 0x7F, 0x00, 0x1E, 0x00, 0x76, 0x00, 0x0F, 0x00, 0x7E, 0x00,
  0x0F, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0xF8, 0x00,
  0x0F, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0xF0, 0x00,
  0x0F, 0x01, 0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0E, 0x01, 0xE0, 0x00,
  0x0E, 0x01, 0xC0, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00,
  0x1E, 0x03, 0xC0, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x3C, 0x03, 0x80, 0x00,
  0x3C, 0x03, 0x80, 0x00, 0x78, 0x07, 0x80, 0x00, 0x78, 0x07, 0x80, 0x00,
  0xF0, 0x07, 0xC0, 0x00, 0xF0, 0x07, 0xC0, 0x01, 0xE0, 0x0F, 0xC0, 0x03,
  0xE0, 0x0F, 0xE0, 0x07, 0xC0, 0x0E, 0x70, 0x0F, 0x80, 0x0E, 0x3E, 0xFF,
  0x00, 0x0E, 0x3F, 0xFE, 0x00, 0x1E, 0x0F, 0xF8, 0x00, 0x1E, 0x01, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x03, 0xFF, 0x07, 0x00, 0x7F, 0xF8, 0x70, 0x0F, 0xEF, 0xC7, 0x03,
  0xF0, 0x1E, 0xE0, 0x3C, 0x00, 0xEE, 0x07, 0x80, 0x06, 0xE0, 0xF0, 0x00,
  0x7E, 0x0F, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x3C, 0x1E, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x3C, 0x78, 0x00,
  0x03, 0x87, 0x80, 0x00, 0x38, 0x70, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x78,
  0xF0, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x0F, 0x0E, 0x00,
  0x00, 0xF0, 0xE0, 0x00, 0x1F, 0x0E, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x3E,
  0x0E, 0x00, 0x03, 0xE0, 0xE0, 0x00, 0x7E, 0x0E, 0x00, 0x07, 0xE0, 0xF0,
  0x00, 0xFC, 0x0F, 0x00, 0x1D, 0xC0, 0x78, 0x03, 0x9C, 0x07, 0xC0, 0x73,
  0xC0, 0x3F, 0x7E, 0x38, 0x03, 0xFF, 0xC3, 0x80, 0x0F, 0xF8, 0x38, 0x00,
  0x18, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x03, 0x83, 0xFC, 0x07, 0x0F,
  0xF0, 0x0E, 0x3F, 0xE0, 0x1C, 0xF0, 0x00, 0x3B, 0x80, 0x00, 0xEE, 0x00,
  0x01, 0xD8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFF, 0x01, 0xFC, 0xFE, 0x03, 0xC0, 0x0E,
  0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x80, 0x01, 0xE0, 0xE0, 0x07, 0xC0, 0xFF, 0x7F, 0x80,
  0xFF, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x0F, 0x00, 0x3F, 0xFF, 0xBF, 0xFF, 0xBF, 0xFF, 0xC0, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80,
  0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x01, 0xFB, 0x80, 0x7F, 0xC0,
  0x1F, 0xE0, 0x01, 0x80, 0x00, 0x07, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x1C,
  0x1C, 0x00, 0x07, 0x87, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x1E, 0x1E, 0x00,
  0x03, 0x83, 0x80, 0x00, 0x70, 0x70, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0x70, 0x70, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0x78, 0x78, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x38, 0x38,
  0x00, 0x0F, 0x0F, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x07,
  0x07, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x87, 0x80,
  0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x1C, 0x00, 0x0F, 0x83, 0x80, 0x03, 0xF0,
  0x70, 0x00, 0x7E, 0x0F, 0x00, 0x1F, 0x81, 0xE0, 0x07, 0x70, 0x3E, 0x03,
  0xCE, 0x03, 0xFB, 0xF1, 0xC0, 0x3F, 0xFC, 0x38, 0x03, 0xFE, 0x0E, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0x9C, 0x00,
  0x03, 0xCE, 0x00, 0x03, 0xC7, 0x00, 0x01, 0xE3, 0x80, 0x01, 0xE1, 0xC0,
  0x00, 0xF0, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x78, 0x3C, 0x00, 0x78, 0x1E,
  0x00, 0x3C, 0x0F, 0x00, 0x3C, 0x07, 0x80, 0x1E, 0x01, 0xC0, 0x1E, 0x00,
  0xE0, 0x0F, 0x00, 0x70, 0x0F, 0x00, 0x38, 0x07, 0x80, 0x1C, 0x07, 0x80,
  0x0E, 0x03, 0x80, 0x07, 0x03, 0xC0, 0x03, 0xC1, 0xC0, 0x01, 0xE1, 0xE0,
  0x00, 0xF0, 0xE0, 0x00, 0x78, 0xF0, 0x00, 0x1C, 0x70, 0x00, 0x0E, 0x78,
  0x00, 0x07, 0x38, 0x00, 0x03, 0xBC, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x3F, 0x80, 0x03, 0xE0, 0x00,
  0xEE, 0x00, 0x0F, 0x80, 0x07, 0xB8, 0x00, 0x7E, 0x00, 0x1E, 0xE0, 0x01,
  0xF8, 0x00, 0xF3, 0x80, 0x0F, 0xE0, 0x03, 0xCE, 0x00, 0x3B, 0x80, 0x0E,
  0x38, 0x00, 0xEE, 0x00, 0x78, 0xE0, 0x07, 0x38, 0x01, 0xC3, 0x80, 0x1C,
  0xE0, 0x0F, 0x0E, 0x00, 0xE3, 0x80, 0x38, 0x38, 0x03, 0x8E, 0x01, 0xE0,
  0xE0, 0x1C, 0x38, 0x07, 0x83, 0x80, 0x70, 0xE0, 0x1C, 0x0E, 0x03, 0xC3,
  0x80, 0xF0, 0x38, 0x0E, 0x0E, 0x03, 0x80, 0xF0, 0x78, 0x38, 0x1E, 0x03,
  0xC1, 0xC0, 0xE0, 0x70, 0x0F, 0x07, 0x03, 0xC3, 0xC0, 0x3C, 0x38, 0x0F,
  0x0E, 0x00, 0xF0, 0xE0, 0x1C, 0x38, 0x03, 0xC7, 0x00, 0x71, 0xE0, 0x0F,
  0x1C, 0x01, 0xC7, 0x00, 0x3C, 0xE0, 0x07, 0x3C, 0x00, 0xF3, 0x80, 0x1C,
  0xE0, 0x03, 0xDE, 0x00, 0x77, 0x80, 0x0F, 0x70, 0x01, 0xDC, 0x00, 0x3F,
  0xC0, 0x07, 0x70, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0x78,
  0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x03, 0x80, 0x01, 0xE0, 0x0F, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0x70, 0x01, 0xE0, 0x01, 0xE0, 0x0F, 0x00, 0x03, 0x80, 0x78, 0x00,
  0x0E, 0x03, 0xC0, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x70, 0x78, 0x00, 0x01,
  0xC3, 0xC0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x3B,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0x70, 0x00,
  0x00, 0x3D, 0xC0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x0F, 0x0E, 0x00, 0x00,
  0x38, 0x3C, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x78,
  0x07, 0x80, 0x01, 0xC0, 0x0E, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x78, 0x00,
  0xF0, 0x03, 0xC0, 0x01, 0xC0, 0x1E, 0x00, 0x07, 0x80, 0x78, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x03, 0x80,
  0x00, 0x3C, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x00, 0x70, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x03,
  0x80, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x07, 0x80, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00,
  0x78, 0x07, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x38, 0x00,
  0x00, 0x1C, 0x0F, 0x00, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x00, 0x70, 0x78,
  0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x00, 0x38,
  0x70, 0x00, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x00,
  0x0E, 0xF0, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1C, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x7F, 0x00, 0x01, 0x7F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x27, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x03, 0xF8, 0x1F,
  0xE1, 0xFC, 0x00, 0xFF, 0xFD, 0x00, 0x07, 0xFF, 0x20, 0x00, 0x1F, 0x80,
};

const GFXglyph NotoSans_SemiCondensed_LightItalic64pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 14, 47, 15, 1, -46 },
  { 84, 16, 17, 21, 7, -46 },
  { 118, 35, 46, 35, 1, -46 },
  { 320, 28, 53, 31, 2, -49 },
  { 506, 38, 47, 45, 4, -46 },
  { 730, 34, 47, 36, 1, -46 },
  { 930, 6, 17, 12, 7, -46 },
  { 943, 19, 56, 17, 2, -46 },
  { 1076, 18, 56, 17, -4, -46 },
  { 1202, 24, 25, 30, 7, -49 },
  { 1277, 27, 30, 33, 4, -38 },
  { 1379, 10, 15, 13, -3, -7 },
  { 1398, 15, 3, 19, 2, -19 },
  { 1404, 6, 7, 14, 1, -6 },
  { 1410, 29, 46, 21, -3, -46 },
  { 1577, 27, 47, 31, 3, -46 },
  { 1736, 16, 46, 31, 9, -46 },
  { 1828, 31, 46, 31, -1, -46 },
  { 2007, 30, 47, 31, 0, -46 },
  { 2184, 30, 46, 31, 0, -46 },
  { 2357, 30, 47, 31, 1, -46 },
  { 2534, 28, 47, 31, 3, -46 },
  { 2699, 27, 46, 31, 5, -46 },
  { 2855, 29, 47, 31, 2, -46 },
  { 3026, 28, 47, 31, 2, -46 },
  { 3191, 11, 36, 14, 1, -35 },
  { 3241, 15, 43, 14, -3, -35 },
  { 3322, 27, 30, 33, 4, -38 },
  { 3424, 27, 17, 33, 4, -31 },
  { 3482, 27, 30, 33, 4, -38 },
  { 3584, 21, 47, 23, 4, -46 },
  { 3708, 43, 52, 47, 3, -46 },
  { 3988, 31, 46, 31, -4, -46 },
  { 4167, 31, 46, 34, 2, -46 },
  { 4346, 32, 47, 32, 4, -46 },
  { 4534, 34, 46, 38, 2, -46 },
  { 4730, 30, 46, 30, 2, -46 },
  { 4903, 30, 46, 27, 2, -46 },
  { 5076, 35, 47, 39, 4, -46 },
  { 5282, 37, 46, 38, 2, -46 },
  { 5495, 23, 46, 17, -2, -46 },
  { 5628, 25, 58, 14, -10, -46 },
  { 5810, 35, 46, 31, 2, -46 },
  { 6012, 21, 46, 27, 2, -46 },
  { 6133, 46, 46, 48, 2, -46 },
  { 6398, 38, 46, 39, 2, -46 },
  { 6617, 34, 47, 40, 4, -46 },
  { 6817, 30, 46, 32, 2, -46 },
  { 6990, 34, 57, 40, 4, -46 },
  { 7233, 30, 46, 32, 2, -46 },
  { 7406, 30, 47, 29, 0, -46 },
  { 7583, 27, 46, 27, 6, -46 },
  { 7739, 35, 47, 38, 4, -46 },
  { 7945, 30, 46, 31, 6, -46 },
  { 8118, 47, 46, 49, 7, -46 },
  { 8389, 37, 46, 28, -4, -46 },
  { 8602, 27, 46, 28, 6, -46 },
  { 8758, 33, 46, 29, -1, -46 },
  { 8948, 24, 56, 19, -1, -46 },
  { 9116, 10, 46, 21, 7, -46 },
  { 9174, 23, 56, 19, -4, -46 },
  { 9335, 28, 27, 32, 2, -46 },
  { 9430, 23, 3, 22, -6, 6 },
  { 9439, 9, 10, 16, 9, -49 },
  { 9451, 28, 36, 32, 3, -35 },
  { 9577, 29, 50, 33, 1, -49 },
  { 9759, 23, 36, 25, 3, -35 },
  { 9863, 31, 50, 33, 3, -49 },
  { 10057, 24, 36, 28, 3, -35 },
  { 10165, 33, 64, 17, -8, -49 },
  { 10429, 30, 50, 33, 1, -35 },
  { 10617, 28, 49, 32, 1, -49 },
  { 10789, 14, 47, 14, 1, -47 },
  { 10872, 24, 62, 14, -9, -47 },
  { 11058, 28, 49, 27, 1, -49 },
  { 11230, 14, 49, 13, 1, -49 },
  { 11316, 44, 35, 48, 1, -35 },
  { 11509, 28, 35, 32, 1, -35 },
  { 11632, 26, 36, 32, 3, -35 },
  { 11749, 32, 50, 33, -2, -35 },
  { 11949, 28, 50, 33, 3, -35 },
  { 12124, 23, 35, 22, 1, -35 },
  { 12225, 24, 36, 24, 0, -35 },
  { 12333, 17, 43, 18, 3, -42 },
  { 12425, 27, 35, 32, 3, -34 },
  { 12544, 25, 34, 25, 3, -34 },
  { 12651, 38, 34, 40, 4, -34 },
  { 12813, 30, 34, 26, -2, -34 },
  { 12941, 35, 49, 25, -7, -34 },
  { 13156, 26, 34, 24, -1, -34 },
  { 13267, 24, 56, 21, 1, -46 },
  { 13435, 3, 64, 30, 15, -49 },
  { 13459, 23, 56, 21, -3, -46 },
  { 13620, 27, 7, 33, 4, -26 },
};

const GFXfont NotoSans_SemiCondensed_LightItalic64pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_LightItalic64pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_LightItalic64pt7bGlyphs,
  0x20, 0x7E, 87
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHTITALIC64PT7B_H_
