#ifndef _NOTOSANS_SEMICONDENSED_LIGHTITALIC24PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHTITALIC24PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-LightItalic.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_LightItalic24pt7bBitmaps[] PROGMEM = {
  0x00, 0x0C, 0x20, 0x86, 0x18, 0x41, 0x04, 0x30, 0xC2, 0x08, 0x20, 0x00,
  0x18, 0xC0, 0xCF, 0x28, 0xA6, 0x92, 0x40, 0x03, 0x10, 0x10, 0x80, 0x88,
  0x04, 0x40, 0x42, 0x1F, 0xFC, 0x11, 0x01, 0x88, 0x08, 0x40, 0x44, 0x06,
  0x21, 0xFF, 0xE1, 0x18, 0x08, 0x80, 0x84, 0x04, 0x60, 0x22, 0x00, 0x03,
  0x00, 0x80, 0xFC, 0xC9, 0x22, 0x09, 0x02, 0x40, 0xD0, 0x1C, 0x03, 0x80,
  0xB0, 0x26, 0x09, 0x82, 0x60, 0x93, 0x58, 0x7C, 0x04, 0x03, 0x00, 0x3C,
  0x19, 0x10, 0x44, 0x42, 0x21, 0x18, 0x84, 0x42, 0x12, 0x08, 0xD8, 0x22,
  0x5E, 0x9A, 0x4F, 0xDA, 0x10, 0x48, 0x42, 0x23, 0x19, 0x88, 0x44, 0x22,
  0x10, 0x98, 0x64, 0xC0, 0xE0, 0x0F, 0x80, 0x8C, 0x10, 0xC1, 0x0C, 0x10,
  0x81, 0x18, 0x1B, 0x00, 0xC0, 0x14, 0x06, 0x63, 0xC2, 0x28, 0x36, 0x81,
  0x48, 0x1C, 0x81, 0x8C, 0x2C, 0x7C, 0x60, 0xFA, 0xA0, 0x06, 0x10, 0x60,
  0x83, 0x04, 0x18, 0x20, 0x41, 0x82, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x03, 0x02, 0x04, 0x00, 0x04, 0x0C, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x30, 0x60, 0x83, 0x04, 0x18, 0x20, 0xC3, 0x0C, 0x00, 0x0C,
  0x04, 0x22, 0x0D, 0x01, 0xF9, 0xC1, 0xB1, 0x88, 0x06, 0x00, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x41, 0xFF, 0xC1, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x00, 0x32, 0x24, 0x48, 0xF8, 0x78, 0x00, 0x60, 0x18, 0x02, 0x00,
  0xC0, 0x10, 0x06, 0x00, 0x80, 0x30, 0x04, 0x01, 0x00, 0x60, 0x08, 0x03,
  0x00, 0x40, 0x18, 0x02, 0x00, 0xC0, 0x00, 0x0F, 0x86, 0x31, 0x04, 0x81,
  0x20, 0x58, 0x14, 0x05, 0x01, 0xC0, 0xF0, 0x3C, 0x0A, 0x02, 0x81, 0xB0,
  0x4C, 0x31, 0x18, 0x3C, 0x00, 0x0C, 0x76, 0xF3, 0x08, 0x21, 0x86, 0x10,
  0x41, 0x0C, 0x30, 0x82, 0x08, 0x60, 0x0F, 0xC3, 0x0C, 0x00, 0x80, 0x10,
  0x02, 0x00, 0xC0, 0x10, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x00, 0xFF, 0x80, 0x0F, 0xC3, 0x0C, 0x00, 0x80, 0x10,
  0x02, 0x00, 0xC0, 0x30, 0x3C, 0x0F, 0x00, 0x30, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x24, 0x18, 0xFE, 0x00, 0x00, 0x60, 0x14, 0x07, 0x80, 0xA0,
  0x24, 0x08, 0x83, 0x30, 0x46, 0x10, 0x84, 0x11, 0x82, 0x60, 0xCF, 0xFE,
  0x02, 0x00, 0x40, 0x18, 0x03, 0x00, 0x0F, 0xE1, 0x00, 0x20, 0x0C, 0x01,
  0x00, 0x20, 0x04, 0x01, 0xFC, 0x00, 0xC0, 0x18, 0x01, 0x00, 0x20, 0x04,
  0x01, 0x80, 0x24, 0x18, 0x7E, 0x00, 0x07, 0xE1, 0x80, 0x60, 0x08, 0x02,
  0x00, 0x40, 0x19, 0x82, 0xFC, 0x60, 0x98, 0x13, 0x02, 0x60, 0x4C, 0x09,
  0x83, 0x30, 0x43, 0x18, 0x3E, 0x00, 0x7F, 0xC0, 0x30, 0x08, 0x06, 0x01,
  0x00, 0x80, 0x60, 0x10, 0x0C, 0x02, 0x01, 0x80, 0x40, 0x30, 0x08, 0x06,
  0x01, 0x00, 0xC0, 0x00, 0x0F, 0x84, 0x33, 0x04, 0x81, 0x20, 0x4C, 0x31,
  0x18, 0x38, 0x1E, 0x18, 0xCC, 0x1A, 0x02, 0x80, 0xA0, 0x28, 0x1B, 0x0C,
  0x7E, 0x00, 0x0F, 0x84, 0x32, 0x05, 0x81, 0x60, 0x50, 0x14, 0x0D, 0x03,
  0x61, 0xCF, 0xA0, 0x88, 0x06, 0x01, 0x00, 0xC0, 0x20, 0x30, 0xF8, 0x00,
  0x18, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x8C, 0x00, 0x0C, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x08, 0x61, 0x04, 0x20, 0x00, 0x60, 0x38,
  0x1C, 0x0E, 0x07, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0x80, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x02, 0x00, 0x00, 0x3E, 0x43, 0x01, 0x01, 0x01, 0x03, 0x06, 0x0C, 0x18,
  0x30, 0x20, 0x20, 0x40, 0x00, 0x00, 0xC0, 0xC0, 0x01, 0xF8, 0x06, 0x04,
  0x08, 0x02, 0x10, 0x03, 0x20, 0x01, 0x21, 0xF1, 0x42, 0x11, 0x44, 0x21,
  0xC4, 0x21, 0x8C, 0x23, 0x88, 0x62, 0x88, 0x62, 0x88, 0xA4, 0x87, 0xBC,
  0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x20, 0x1F, 0xC0, 0x00, 0xC0,
  0x38, 0x05, 0x01, 0xA0, 0x24, 0x0C, 0x81, 0x10, 0x62, 0x08, 0x63, 0x0C,
  0x7F, 0x98, 0x32, 0x02, 0xC0, 0x50, 0x0E, 0x01, 0x80, 0x20, 0x1F, 0xC2,
  0x0C, 0x40, 0x88, 0x13, 0x02, 0x60, 0x48, 0x11, 0xFC, 0x7F, 0x8C, 0x19,
  0x01, 0x20, 0x24, 0x05, 0x81, 0xB0, 0x24, 0x1C, 0xFE, 0x00, 0x07, 0xE3,
  0x04, 0xC0, 0x10, 0x06, 0x00, 0x80, 0x30, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x30, 0x03, 0x08, 0x3F, 0x00, 0x1F, 0xC1,
  0x06, 0x10, 0x31, 0x01, 0x30, 0x12, 0x01, 0x20, 0x12, 0x01, 0x60, 0x16,
  0x03, 0x40, 0x34, 0x02, 0x40, 0x6C, 0x0C, 0xC1, 0x88, 0x70, 0xFC, 0x00,
  0x1F, 0xE2, 0x00, 0x40, 0x08, 0x03, 0x00, 0x40, 0x08, 0x01, 0xFC, 0x7F,
  0x8C, 0x01, 0x00, 0x20, 0x04, 0x01, 0x80, 0x30, 0x04, 0x08, 0xFE, 0x00,
  0x1F, 0xE2, 0x00, 0x40, 0x08, 0x03, 0x00, 0x40, 0x08, 0x01, 0x00, 0x7F,
  0x8C, 0x01, 0x00, 0x20, 0x04, 0x01, 0x80, 0x30, 0x04, 0x00, 0x80, 0x00,
  0x07, 0xF1, 0xC1, 0x30, 0x02, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x08, 0x00,
  0x83, 0xE8, 0x02, 0x80, 0x68, 0x06, 0x80, 0x48, 0x04, 0xC0, 0x46, 0x0C,
  0x3F, 0x80, 0x18, 0x0C, 0x40, 0x21, 0x00, 0x84, 0x06, 0x30, 0x18, 0x80,
  0x42, 0x01, 0x0F, 0xFC, 0x3F, 0xF1, 0x80, 0xC4, 0x02, 0x10, 0x08, 0x40,
  0x23, 0x01, 0x8C, 0x04, 0x20, 0x10, 0x80, 0x40, 0x0F, 0x83, 0x01, 0x80,
  0x80, 0x40, 0x20, 0x30, 0x10, 0x08, 0x04, 0x02, 0x03, 0x01, 0x00, 0x80,
  0x40, 0x60, 0xF8, 0x00, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x01, 0x80, 0x60,
  0x10, 0x04, 0x01, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x01, 0x80, 0x60, 0x10,
  0x04, 0x01, 0x00, 0xC0, 0x20, 0xF0, 0x00, 0x18, 0x38, 0x81, 0x04, 0x10,
  0x21, 0x03, 0x10, 0x19, 0x00, 0x98, 0x05, 0x80, 0x74, 0x03, 0x30, 0x11,
  0x80, 0x84, 0x04, 0x30, 0x60, 0x83, 0x04, 0x10, 0x30, 0x80, 0x80, 0x18,
  0x20, 0x40, 0x83, 0x04, 0x08, 0x10, 0x60, 0xC1, 0x02, 0x04, 0x18, 0x30,
  0x40, 0xFE, 0x18, 0x01, 0x8C, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0xA3, 0x40,
  0x51, 0x20, 0x48, 0x90, 0x6C, 0x48, 0x24, 0x64, 0x32, 0x32, 0x11, 0x11,
  0x19, 0x88, 0xC8, 0xC4, 0x6C, 0x46, 0x14, 0x23, 0x0E, 0x11, 0x06, 0x18,
  0x82, 0x0C, 0x00, 0x18, 0x0C, 0x60, 0x31, 0xC0, 0x85, 0x02, 0x34, 0x08,
  0x98, 0x62, 0x21, 0x88, 0x84, 0x63, 0x11, 0x8C, 0x44, 0x13, 0x10, 0x48,
  0x41, 0xA3, 0x02, 0x8C, 0x0A, 0x20, 0x38, 0x80, 0x40, 0x07, 0xE0, 0x61,
  0x86, 0x06, 0x60, 0x12, 0x00, 0xB0, 0x05, 0x80, 0x28, 0x01, 0x40, 0x0A,
  0x00, 0xF0, 0x07, 0x80, 0x24, 0x03, 0x20, 0x11, 0x81, 0x86, 0x18, 0x1F,
  0x80, 0x1F, 0x82, 0x18, 0x41, 0x88, 0x13, 0x02, 0x60, 0xC8, 0x19, 0x06,
  0x61, 0x8F, 0xE1, 0x00, 0x20, 0x04, 0x01, 0x80, 0x30, 0x04, 0x00, 0x80,
  0x00, 0x07, 0xE0, 0x61, 0x86, 0x06, 0x60, 0x12, 0x00, 0xB0, 0x05, 0x80,
  0x28, 0x01, 0x40, 0x0A, 0x00, 0xF0, 0x07, 0x80, 0x24, 0x03, 0x20, 0x11,
  0x81, 0x86, 0x18, 0x1F, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00,
  0x1F, 0x82, 0x18, 0x41, 0x88, 0x13, 0x02, 0x40, 0xC8, 0x11, 0x06, 0x7F,
  0x8F, 0xC1, 0x08, 0x21, 0x04, 0x31, 0x82, 0x30, 0x44, 0x0C, 0x80, 0x80,
  0x0F, 0xE3, 0x04, 0x40, 0x18, 0x03, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x40, 0x08, 0x01, 0x00, 0x64, 0x18, 0xFE, 0x00,
  0xFF, 0xC3, 0x00, 0x80, 0x20, 0x08, 0x06, 0x01, 0x80, 0x40, 0x10, 0x04,
  0x03, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x01, 0x80, 0x60, 0x00, 0x30, 0x19,
  0x00, 0x88, 0x04, 0xC0, 0x26, 0x03, 0x20, 0x11, 0x00, 0x88, 0x04, 0xC0,
  0x64, 0x03, 0x20, 0x11, 0x00, 0x88, 0x0C, 0x40, 0x62, 0x06, 0x18, 0x60,
  0x7E, 0x00, 0xC0, 0x3C, 0x06, 0xC0, 0x44, 0x0C, 0x40, 0x84, 0x18, 0x41,
  0x04, 0x30, 0x42, 0x04, 0x60, 0x44, 0x04, 0xC0, 0x48, 0x07, 0x80, 0x70,
  0x07, 0x00, 0x60, 0x00, 0x81, 0x81, 0xC0, 0xC0, 0xA0, 0xE0, 0x50, 0x50,
  0x68, 0x28, 0x24, 0x24, 0x32, 0x12, 0x11, 0x19, 0x18, 0x88, 0x88, 0x4C,
  0x44, 0x24, 0x24, 0x16, 0x12, 0x0A, 0x0B, 0x05, 0x05, 0x03, 0x02, 0x81,
  0x81, 0x80, 0xC0, 0xC0, 0x00, 0x08, 0x0C, 0x30, 0x40, 0xC3, 0x01, 0x18,
  0x04, 0x40, 0x1B, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x14, 0x00, 0xD0,
  0x02, 0x60, 0x10, 0x80, 0xC2, 0x06, 0x08, 0x10, 0x30, 0xC0, 0x40, 0xC0,
  0x68, 0x19, 0x06, 0x20, 0x84, 0x30, 0xC4, 0x09, 0x01, 0x60, 0x28, 0x06,
  0x00, 0xC0, 0x18, 0x02, 0x00, 0x40, 0x08, 0x03, 0x00, 0x60, 0x00, 0x0F,
  0xF8, 0x00, 0x80, 0x0C, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x06, 0x00, 0x20,
  0x03, 0x00, 0x30, 0x01, 0x00, 0x10, 0x01, 0x80, 0x18, 0x00, 0x80, 0x0C,
  0x00, 0xFF, 0xC0, 0x0F, 0x84, 0x02, 0x03, 0x01, 0x00, 0x80, 0x40, 0x60,
  0x30, 0x10, 0x08, 0x04, 0x06, 0x03, 0x01, 0x00, 0x80, 0x40, 0x60, 0x20,
  0x10, 0x0F, 0x00, 0xC4, 0x44, 0x46, 0x62, 0x22, 0x22, 0x31, 0x11, 0x10,
  0x07, 0x80, 0x40, 0x60, 0x30, 0x10, 0x08, 0x04, 0x06, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x60, 0x20, 0x10, 0x08, 0x0C, 0x06, 0x02, 0x01, 0x0F, 0x80,
  0x06, 0x01, 0x80, 0xB0, 0x64, 0x11, 0x0C, 0x62, 0x09, 0x02, 0x40, 0x60,
  0x10, 0xFF, 0xC6, 0x30, 0x0F, 0x63, 0x28, 0x83, 0x30, 0x64, 0x0D, 0x81,
  0x30, 0x24, 0x04, 0x81, 0x90, 0x33, 0x0C, 0x62, 0x87, 0x90, 0x0C, 0x01,
  0x00, 0x20, 0x04, 0x01, 0x80, 0x27, 0x85, 0x18, 0xC1, 0x30, 0x26, 0x04,
  0xC0, 0x90, 0x12, 0x06, 0xC0, 0x98, 0x13, 0x06, 0x71, 0x9B, 0xE0, 0x0F,
  0x8C, 0x48, 0x0C, 0x04, 0x06, 0x03, 0x01, 0x00, 0x80, 0x40, 0x30, 0x08,
  0x43, 0xE0, 0x00, 0x30, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0xF6, 0x19,
  0xC2, 0x0C, 0x60, 0xC4, 0x0C, 0xC0, 0xCC, 0x08, 0xC0, 0x88, 0x18, 0x81,
  0x8C, 0x38, 0xC5, 0x07, 0x90, 0x0F, 0x0C, 0xC8, 0x2C, 0x14, 0x1E, 0x3B,
  0xF1, 0x00, 0x80, 0x40, 0x30, 0x08, 0x23, 0xE0, 0x00, 0xF0, 0x18, 0x01,
  0x00, 0x10, 0x01, 0x00, 0xFC, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x08,
  0x01, 0x80, 0x10, 0x01, 0x00, 0xB0, 0x0C, 0x00, 0x07, 0x90, 0xCE, 0x10,
  0x63, 0x06, 0x20, 0x66, 0x06, 0x60, 0x44, 0x04, 0x40, 0xC4, 0x0C, 0x61,
  0xC6, 0x28, 0x3C, 0x80, 0x08, 0x01, 0x80, 0x10, 0x03, 0x0C, 0xE0, 0x78,
  0x00, 0x0C, 0x01, 0x00, 0x20, 0x04, 0x01, 0x80, 0x27, 0x85, 0x18, 0xC3,
  0x30, 0x66, 0x0C, 0x81, 0x10, 0x22, 0x04, 0xC1, 0x98, 0x32, 0x04, 0x40,
  0x98, 0x10, 0x0C, 0x20, 0x00, 0x18, 0x41, 0x0C, 0x30, 0x82, 0x08, 0x61,
  0x84, 0x10, 0xC0, 0x01, 0x80, 0x80, 0x00, 0x00, 0x30, 0x10, 0x08, 0x04,
  0x06, 0x02, 0x01, 0x00, 0x80, 0xC0, 0x60, 0x20, 0x10, 0x08, 0x0C, 0x06,
  0x02, 0x01, 0x07, 0x03, 0x00, 0x0C, 0x01, 0x00, 0x20, 0x04, 0x01, 0x80,
  0x20, 0xC4, 0x30, 0x8C, 0x33, 0x06, 0xC0, 0xB0, 0x1E, 0x03, 0x60, 0xC4,
  0x18, 0x82, 0x18, 0x41, 0x18, 0x30, 0x0C, 0x20, 0x82, 0x18, 0x41, 0x04,
  0x30, 0xC2, 0x08, 0x21, 0x86, 0x10, 0x43, 0x00, 0x13, 0x8F, 0x0A, 0x6C,
  0xC6, 0x18, 0x26, 0x0C, 0x13, 0x04, 0x19, 0x02, 0x0C, 0x83, 0x04, 0x41,
  0x82, 0x60, 0x81, 0x30, 0x41, 0x90, 0x20, 0xC8, 0x30, 0x4C, 0x18, 0x20,
  0x13, 0xC2, 0x8C, 0x61, 0x98, 0x33, 0x06, 0x40, 0x88, 0x11, 0x02, 0x60,
  0xCC, 0x19, 0x02, 0x20, 0x4C, 0x18, 0x0F, 0x06, 0x62, 0x0D, 0x83, 0x40,
  0x70, 0x1C, 0x0E, 0x03, 0x80, 0xA0, 0x6C, 0x11, 0x0C, 0x3C, 0x00, 0x09,
  0xE0, 0xA3, 0x0C, 0x11, 0x81, 0x18, 0x11, 0x81, 0x10, 0x11, 0x03, 0x30,
  0x23, 0x02, 0x30, 0x63, 0x8C, 0x2F, 0x86, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x04, 0x00, 0xC0, 0x00, 0x0F, 0x23, 0x38, 0x83, 0x30, 0x64, 0x0D, 0x81,
  0xB0, 0x26, 0x04, 0x81, 0x90, 0x33, 0x0E, 0x62, 0x87, 0x90, 0x02, 0x00,
  0xC0, 0x10, 0x02, 0x00, 0x40, 0x18, 0x00, 0x13, 0x8B, 0x06, 0x06, 0x03,
  0x01, 0x00, 0x80, 0x40, 0x60, 0x30, 0x10, 0x08, 0x0C, 0x00, 0x1F, 0x18,
  0xC8, 0x04, 0x02, 0x01, 0x80, 0x70, 0x0C, 0x02, 0x01, 0x00, 0x90, 0xCF,
  0xC0, 0x10, 0x43, 0x3F, 0x20, 0x86, 0x18, 0x41, 0x04, 0x30, 0xC2, 0x08,
  0x3C, 0x20, 0x48, 0x12, 0x05, 0x83, 0x40, 0xD0, 0x24, 0x09, 0x02, 0xC1,
  0xA0, 0x4C, 0x33, 0x14, 0x79, 0x00, 0xC0, 0xF0, 0x6C, 0x11, 0x0C, 0x42,
  0x11, 0x84, 0x41, 0x30, 0x48, 0x16, 0x05, 0x01, 0xC0, 0x60, 0x00, 0xC1,
  0x07, 0x86, 0x0B, 0x0C, 0x36, 0x38, 0x44, 0x50, 0x89, 0xB2, 0x12, 0x64,
  0x24, 0xD8, 0x51, 0xA0, 0xA1, 0xC1, 0x83, 0x03, 0x06, 0x04, 0x08, 0x00,
  0x10, 0x31, 0x86, 0x08, 0xC0, 0x88, 0x0D, 0x00, 0x60, 0x06, 0x00, 0xE0,
  0x0A, 0x01, 0x30, 0x21, 0x06, 0x10, 0xC1, 0x80, 0x0C, 0x0C, 0x10, 0x20,
  0x41, 0x01, 0x04, 0x04, 0x20, 0x10, 0x80, 0x44, 0x01, 0x10, 0x04, 0x80,
  0x1A, 0x00, 0x70, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00,
  0x08, 0x02, 0x60, 0x0E, 0x00, 0x00, 0x1F, 0xC0, 0x30, 0x08, 0x04, 0x03,
  0x01, 0x80, 0x40, 0x20, 0x18, 0x04, 0x02, 0x01, 0x80, 0xFF, 0x00, 0x07,
  0x0C, 0x08, 0x08, 0x18, 0x18, 0x10, 0x10, 0x30, 0x60, 0xC0, 0x60, 0x20,
  0x20, 0x60, 0x40, 0x40, 0x40, 0x40, 0x60, 0x30, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x0E, 0x02, 0x02, 0x02, 0x02, 0x06, 0x06, 0x04, 0x04, 0x06,
  0x03, 0x04, 0x08, 0x08, 0x08, 0x18, 0x10, 0x10, 0x10, 0x60, 0xC0, 0x38,
  0x3D, 0xCE, 0x0E, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_LightItalic24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 6, 17, 6, 0, -17 },
  { 14, 6, 6, 8, 3, -17 },
  { 19, 13, 17, 13, 0, -17 },
  { 47, 10, 19, 12, 1, -18 },
  { 71, 14, 17, 17, 2, -17 },
  { 101, 12, 17, 14, 1, -17 },
  { 127, 2, 6, 4, 3, -17 },
  { 129, 7, 21, 6, 1, -17 },
  { 148, 7, 21, 6, -2, -17 },
  { 167, 9, 9, 11, 3, -18 },
  { 178, 11, 11, 12, 1, -14 },
  { 194, 4, 6, 5, -1, -3 },
  { 197, 5, 1, 7, 1, -7 },
  { 198, 3, 2, 5, 0, -2 },
  { 199, 11, 17, 8, -1, -17 },
  { 223, 10, 17, 12, 1, -17 },
  { 245, 6, 17, 12, 3, -17 },
  { 258, 11, 17, 12, 0, -17 },
  { 282, 11, 17, 12, 0, -17 },
  { 306, 11, 17, 12, 0, -17 },
  { 330, 11, 17, 12, 0, -17 },
  { 354, 11, 17, 12, 1, -17 },
  { 378, 10, 17, 12, 2, -17 },
  { 400, 10, 17, 12, 1, -17 },
  { 422, 10, 17, 12, 1, -17 },
  { 444, 5, 13, 5, 0, -13 },
  { 453, 6, 16, 5, -1, -13 },
  { 465, 11, 11, 12, 1, -14 },
  { 481, 11, 7, 12, 1, -12 },
  { 491, 11, 11, 12, 1, -14 },
  { 507, 8, 17, 9, 1, -17 },
  { 524, 16, 19, 18, 1, -17 },
  { 562, 11, 17, 12, -1, -17 },
  { 586, 11, 17, 13, 1, -17 },
  { 610, 11, 17, 12, 2, -17 },
  { 634, 12, 17, 14, 1, -17 },
  { 660, 11, 17, 11, 1, -17 },
  { 684, 11, 17, 10, 1, -17 },
  { 708, 12, 17, 15, 2, -17 },
  { 734, 14, 17, 14, 1, -17 },
  { 764, 9, 17, 6, -1, -17 },
  { 784, 10, 21, 5, -4, -17 },
  { 811, 13, 17, 12, 1, -17 },
  { 839, 7, 17, 10, 1, -17 },
  { 854, 17, 17, 18, 1, -17 },
  { 891, 14, 17, 15, 1, -17 },
  { 921, 13, 17, 15, 1, -17 },
  { 949, 11, 17, 12, 1, -17 },
  { 973, 13, 21, 15, 1, -17 },
  { 1008, 11, 17, 12, 1, -17 },
  { 1032, 11, 17, 11, 0, -17 },
  { 1056, 10, 17, 10, 2, -17 },
  { 1078, 13, 17, 14, 2, -17 },
  { 1106, 12, 17, 12, 2, -17 },
  { 1132, 17, 17, 18, 3, -17 },
  { 1169, 14, 17, 11, -1, -17 },
  { 1199, 11, 17, 10, 2, -17 },
  { 1223, 13, 17, 11, -1, -17 },
  { 1251, 9, 21, 7, 0, -17 },
  { 1275, 4, 17, 8, 2, -17 },
  { 1284, 9, 21, 7, -2, -17 },
  { 1308, 10, 10, 12, 1, -17 },
  { 1321, 8, 1, 8, -2, 2 },
  { 1322, 4, 3, 6, 3, -18 },
  { 1324, 11, 13, 12, 1, -13 },
  { 1342, 11, 18, 12, 0, -18 },
  { 1367, 9, 13, 9, 1, -13 },
  { 1382, 12, 18, 12, 1, -18 },
  { 1409, 9, 13, 11, 1, -13 },
  { 1424, 12, 24, 6, -3, -18 },
  { 1460, 12, 19, 12, 0, -13 },
  { 1489, 11, 18, 12, 0, -18 },
  { 1514, 6, 17, 5, 0, -17 },
  { 1527, 9, 23, 5, -3, -17 },
  { 1553, 11, 18, 10, 0, -18 },
  { 1578, 6, 18, 5, 0, -18 },
  { 1592, 17, 13, 18, 0, -13 },
  { 1620, 11, 13, 12, 0, -13 },
  { 1638, 10, 13, 12, 1, -13 },
  { 1655, 12, 19, 12, -1, -13 },
  { 1684, 11, 19, 12, 1, -13 },
  { 1711, 9, 13, 8, 0, -13 },
  { 1726, 9, 13, 9, 0, -13 },
  { 1741, 6, 16, 7, 1, -16 },
  { 1753, 10, 13, 12, 1, -13 },
  { 1770, 10, 13, 9, 1, -13 },
  { 1787, 15, 13, 15, 1, -13 },
  { 1812, 12, 13, 10, -1, -13 },
  { 1832, 14, 19, 9, -3, -13 },
  { 1866, 10, 13, 9, -1, -13 },
  { 1883, 8, 21, 8, 1, -17 },
  { 1904, 2, 24, 11, 5, -18 },
  { 1910, 8, 21, 8, -1, -17 },
  { 1931, 11, 3, 12, 1, -10 },
};

const GFXfont NotoSans_SemiCondensed_LightItalic24pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_LightItalic24pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_LightItalic24pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHTITALIC24PT7B_H_
