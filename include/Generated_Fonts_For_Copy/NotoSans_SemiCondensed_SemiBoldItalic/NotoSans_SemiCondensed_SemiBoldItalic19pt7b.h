#ifndef _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC19PT7B_H_
#define _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC19PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-SemiBoldItalic.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_SemiBoldItalic19pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0x61, 0x8E, 0x38, 0xC3, 0x0C, 0x71, 0x80, 0x18, 0xE3, 0x80,
  0x6F, 0xBC, 0xF2, 0xD8, 0x06, 0x40, 0x98, 0x33, 0x06, 0x43, 0xFE, 0xFF,
  0xC6, 0x60, 0xC8, 0xFF, 0xDF, 0xF8, 0xC8, 0x1B, 0x02, 0x60, 0xC8, 0x00,
  0x02, 0x03, 0xF1, 0xF8, 0xD2, 0x34, 0x0F, 0x01, 0xE0, 0x3C, 0x0B, 0x02,
  0xC8, 0xB3, 0xFC, 0xFE, 0x04, 0x01, 0x00, 0x18, 0x33, 0xE3, 0x1B, 0x18,
  0x99, 0x8C, 0xD8, 0x66, 0xC3, 0x6D, 0xFF, 0xDB, 0x66, 0x98, 0x6C, 0xC6,
  0x66, 0x33, 0x23, 0x1B, 0x30, 0x70, 0x07, 0x01, 0xF0, 0x66, 0x0C, 0xC1,
  0x98, 0x36, 0x03, 0x81, 0xF3, 0x76, 0x6C, 0xFB, 0x8F, 0x71, 0xC7, 0xFC,
  0xF9, 0xC0, 0x7F, 0x6C, 0x0C, 0x63, 0x8C, 0x61, 0x8E, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xE0, 0x18, 0x20, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x31, 0x86, 0x18, 0xC7, 0x18, 0xC0, 0x10, 0x18, 0x98, 0xF9, 0x7F, 0x39,
  0x68, 0xCC, 0x08, 0x18, 0x0C, 0x06, 0x1F, 0xFF, 0xF8, 0xC0, 0x60, 0x30,
  0x18, 0x00, 0x37, 0x6C, 0x7F, 0xC0, 0x7F, 0x80, 0x00, 0xC0, 0x60, 0x38,
  0x0C, 0x07, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x60,
  0x38, 0x00, 0x0E, 0x3F, 0x33, 0x63, 0x63, 0xE3, 0xC3, 0xC3, 0xC3, 0xC7,
  0xC6, 0xCE, 0xFC, 0x78, 0x0C, 0x73, 0xFB, 0x5C, 0x61, 0x86, 0x38, 0xC3,
  0x0C, 0x31, 0xC0, 0x0F, 0x1F, 0xCC, 0xE4, 0x30, 0x18, 0x1C, 0x0C, 0x0C,
  0x0C, 0x0C, 0x0C, 0x0C, 0x0F, 0xF7, 0xF8, 0x0F, 0x1F, 0xC4, 0x60, 0x30,
  0x18, 0x1C, 0x78, 0x3C, 0x03, 0x01, 0x80, 0xD0, 0xEF, 0xE7, 0xE0, 0x01,
  0x81, 0xC1, 0xE0, 0xF0, 0xF8, 0xD8, 0xCC, 0x66, 0x63, 0x7F, 0xFF, 0xE0,
  0xC0, 0x60, 0x70, 0x1F, 0xC7, 0xE1, 0x80, 0x60, 0x30, 0x0C, 0x03, 0xF0,
  0x9C, 0x03, 0x00, 0xE0, 0x32, 0x1C, 0xFE, 0x3F, 0x00, 0x07, 0x8F, 0xCE,
  0x06, 0x06, 0x03, 0x63, 0x79, 0xCE, 0xC3, 0x63, 0xB1, 0xD8, 0xCF, 0xE3,
  0xE0, 0x7F, 0xBF, 0xC0, 0xE0, 0x60, 0x70, 0x30, 0x30, 0x18, 0x18, 0x1C,
  0x0C, 0x0E, 0x06, 0x07, 0x00, 0x07, 0x07, 0xE3, 0x9C, 0xC7, 0x31, 0x86,
  0xE1, 0xF0, 0xF8, 0x73, 0x18, 0xEE, 0x3B, 0x8C, 0x7F, 0x0F, 0x80, 0x1C,
  0x3F, 0x73, 0x63, 0xE3, 0xC3, 0xE7, 0x7F, 0x7F, 0x06, 0x06, 0x0C, 0xF8,
  0xF0, 0x39, 0x80, 0x00, 0x00, 0x0C, 0xE7, 0x00, 0x1C, 0x60, 0x00, 0x00,
  0x00, 0x00, 0x31, 0x86, 0x30, 0x00, 0x81, 0xC3, 0xC7, 0x8F, 0x07, 0x01,
  0xE0, 0x3E, 0x03, 0x80, 0x40, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x60,
  0x3C, 0x07, 0x80, 0xF0, 0x1C, 0x78, 0xF0, 0xE0, 0x40, 0x00, 0x3C, 0xFD,
  0x18, 0x30, 0x61, 0x86, 0x18, 0x60, 0xC0, 0x02, 0x0E, 0x1C, 0x00, 0x01,
  0x80, 0x7F, 0x86, 0x0E, 0x60, 0x36, 0x3C, 0xA3, 0x67, 0x33, 0x3B, 0x11,
  0x99, 0x9C, 0xCC, 0xE6, 0xED, 0x9D, 0xCC, 0x00, 0x30, 0x20, 0xFE, 0x01,
  0xC0, 0x03, 0x80, 0xE0, 0x28, 0x1A, 0x06, 0xC3, 0x30, 0xCC, 0x63, 0x1F,
  0xCF, 0xF3, 0x0D, 0x83, 0x60, 0xF8, 0x30, 0x1F, 0x03, 0xF8, 0x67, 0x0C,
  0x73, 0x8C, 0x63, 0x8F, 0xE1, 0xFC, 0x31, 0x8E, 0x39, 0x86, 0x31, 0xC7,
  0xF1, 0xFC, 0x00, 0x07, 0x87, 0xF3, 0xC8, 0xC0, 0x70, 0x18, 0x0E, 0x03,
  0x80, 0xC0, 0x30, 0x0E, 0x03, 0x80, 0x7F, 0x0F, 0xC0, 0x1E, 0x03, 0xF8,
  0x67, 0x0C, 0x73, 0x86, 0x60, 0xCC, 0x19, 0x87, 0x30, 0xEE, 0x19, 0x87,
  0x31, 0xC7, 0xF1, 0xF8, 0x00, 0x1F, 0xC7, 0xF1, 0x80, 0x60, 0x38, 0x0C,
  0x03, 0xF0, 0xFC, 0x30, 0x1C, 0x06, 0x01, 0x80, 0x7E, 0x3F, 0x80, 0x1F,
  0xC7, 0xF1, 0x80, 0x60, 0x38, 0x0C, 0x03, 0xF0, 0xFC, 0x30, 0x1C, 0x06,
  0x01, 0x80, 0x60, 0x38, 0x00, 0x07, 0x83, 0xFC, 0xF1, 0x18, 0x07, 0x00,
  0xC0, 0x38, 0x07, 0x3E, 0xC1, 0xD8, 0x33, 0x86, 0x70, 0xC7, 0xF8, 0x7F,
  0x00, 0x1C, 0x31, 0x83, 0x18, 0x71, 0x87, 0x38, 0x63, 0x06, 0x3F, 0xE3,
  0xFE, 0x30, 0xC7, 0x0C, 0x60, 0xC6, 0x1C, 0x61, 0xCE, 0x18, 0x1F, 0x8F,
  0x83, 0x81, 0x80, 0xC0, 0x60, 0x70, 0x38, 0x18, 0x0C, 0x06, 0x07, 0x07,
  0x87, 0xE0, 0x03, 0x81, 0x80, 0xC0, 0x60, 0x70, 0x38, 0x18, 0x0C, 0x06,
  0x07, 0x03, 0x81, 0x80, 0xC0, 0x60, 0x70, 0x30, 0xF8, 0x78, 0x00, 0x1C,
  0x71, 0x8E, 0x18, 0xC1, 0x98, 0x3B, 0x83, 0x70, 0x3E, 0x03, 0xE0, 0x36,
  0x07, 0x70, 0x63, 0x06, 0x30, 0x63, 0x8E, 0x18, 0x1C, 0x30, 0x60, 0xC3,
  0x86, 0x0C, 0x18, 0x30, 0xE1, 0x83, 0x07, 0xFF, 0xC0, 0x1C, 0x0E, 0x38,
  0x1C, 0x70, 0x78, 0xF0, 0xF3, 0x63, 0xE6, 0xC7, 0x8D, 0x9B, 0x1B, 0x36,
  0x36, 0xCC, 0xCD, 0xB1, 0x9E, 0x63, 0x3C, 0xC6, 0x71, 0x9C, 0xE7, 0x00,
  0x1C, 0x18, 0xE0, 0xC7, 0x0C, 0x3C, 0x63, 0x63, 0x1B, 0x18, 0xDD, 0xC6,
  0x6C, 0x33, 0x63, 0x1B, 0x18, 0x78, 0xC3, 0xC6, 0x1C, 0x70, 0xE0, 0x07,
  0x03, 0xF8, 0xE7, 0x38, 0x77, 0x06, 0xC0, 0xF8, 0x3F, 0x07, 0xC0, 0xF8,
  0x1B, 0x87, 0x71, 0xC7, 0xF0, 0x7C, 0x00, 0x1E, 0x07, 0xF1, 0x9C, 0x63,
  0x38, 0xCC, 0x33, 0x1C, 0xFE, 0x3F, 0x1C, 0x06, 0x01, 0x80, 0x60, 0x38,
  0x00, 0x07, 0x03, 0xF8, 0xE3, 0x38, 0x77, 0x06, 0xC0, 0xF8, 0x3F, 0x07,
  0xC0, 0xF8, 0x1B, 0x87, 0x71, 0xC7, 0xF0, 0x7C, 0x01, 0x80, 0x38, 0x03,
  0x80, 0x1E, 0x07, 0xE1, 0x9C, 0x63, 0x38, 0xCC, 0x73, 0x38, 0xFC, 0x3E,
  0x1D, 0xC6, 0x31, 0x8C, 0x63, 0xB8, 0x60, 0x07, 0x07, 0xF3, 0x98, 0xC0,
  0x30, 0x0E, 0x03, 0xC0, 0x78, 0x07, 0x01, 0xC0, 0x32, 0x1C, 0xFE, 0x3F,
  0x00, 0xFF, 0xFF, 0x18, 0x38, 0x30, 0x30, 0x30, 0x30, 0x70, 0x60, 0x60,
  0x60, 0xE0, 0xE0, 0x30, 0x66, 0x0C, 0xC3, 0xB8, 0x67, 0x0C, 0xC1, 0x98,
  0x73, 0x0E, 0xE1, 0x9C, 0x33, 0x0E, 0x71, 0x87, 0xF0, 0xFC, 0x00, 0xC1,
  0xF0, 0x6C, 0x3B, 0x0C, 0xC7, 0x31, 0x8C, 0xE3, 0x30, 0xCC, 0x36, 0x0D,
  0x83, 0xC0, 0xF0, 0x18, 0x00, 0xC3, 0x07, 0x86, 0x1F, 0x1C, 0x36, 0x38,
  0xEC, 0x51, 0x99, 0xA3, 0x33, 0x4C, 0x6C, 0x98, 0xD9, 0x71, 0xE2, 0xC3,
  0xC5, 0x87, 0x8E, 0x0E, 0x1C, 0x1C, 0x30, 0x00, 0x18, 0x31, 0xC7, 0x0C,
  0xE0, 0xCC, 0x0D, 0x80, 0xF8, 0x07, 0x00, 0xF0, 0x0F, 0x01, 0xB0, 0x3B,
  0x83, 0x18, 0x61, 0x8E, 0x1C, 0xC3, 0xE1, 0xB1, 0xDC, 0xC6, 0xC3, 0x61,
  0xE0, 0xF0, 0x70, 0x38, 0x18, 0x0C, 0x06, 0x07, 0x00, 0x1F, 0xE3, 0xFC,
  0x03, 0x00, 0xE0, 0x38, 0x06, 0x01, 0xC0, 0x70, 0x0C, 0x03, 0x00, 0xE0,
  0x38, 0x07, 0xF9, 0xFE, 0x00, 0x1E, 0x3C, 0x61, 0x83, 0x06, 0x0C, 0x18,
  0x60, 0xC1, 0x83, 0x06, 0x18, 0x30, 0x78, 0xF0, 0xCC, 0xCC, 0x66, 0x66,
  0x66, 0x63, 0x33, 0x1E, 0x3C, 0x18, 0x30, 0xC1, 0x83, 0x06, 0x1C, 0x30,
  0x60, 0xC1, 0x86, 0x0C, 0x78, 0xF0, 0x06, 0x03, 0x03, 0x83, 0x61, 0xB1,
  0x98, 0xC6, 0xC3, 0xC1, 0x80, 0xFF, 0xDD, 0x80, 0x3D, 0xBB, 0xD8, 0xDC,
  0x6C, 0x36, 0x3B, 0x1D, 0x9C, 0xFE, 0x3B, 0x00, 0x1C, 0x06, 0x01, 0x80,
  0xE0, 0x37, 0x8E, 0x63, 0x1C, 0xC6, 0x71, 0x98, 0x66, 0x39, 0x8C, 0x7F,
  0x37, 0x80, 0x3E, 0xE5, 0x87, 0x0C, 0x18, 0x30, 0x60, 0xFC, 0xF8, 0x01,
  0xC0, 0x60, 0x18, 0x06, 0x3D, 0x9D, 0xE6, 0x33, 0x8C, 0xC3, 0x30, 0xCC,
  0x73, 0x18, 0xFE, 0x1D, 0x80, 0x3E, 0x73, 0x63, 0xC7, 0xFE, 0xF0, 0xC0,
  0xC0, 0xFC, 0x7C, 0x00, 0x80, 0xF0, 0x74, 0x18, 0x06, 0x07, 0xE0, 0xE0,
  0x30, 0x0C, 0x03, 0x01, 0xC0, 0x70, 0x18, 0x06, 0x01, 0x80, 0xE0, 0x30,
  0x2C, 0x0F, 0x03, 0x00, 0x1E, 0xCE, 0xF3, 0x19, 0xC6, 0x61, 0x98, 0xE6,
  0x39, 0x9C, 0x7F, 0x0E, 0xC0, 0x70, 0x18, 0xCE, 0x3F, 0x03, 0x00, 0x1C,
  0x0C, 0x06, 0x07, 0x03, 0x79, 0xEC, 0xE6, 0x63, 0x71, 0xB0, 0xD8, 0xEC,
  0x66, 0x37, 0x18, 0x18, 0xC0, 0x03, 0x98, 0xC6, 0x73, 0x18, 0xC6, 0x70,
  0x06, 0x0C, 0x00, 0x00, 0xE1, 0x83, 0x06, 0x1C, 0x30, 0x60, 0xC1, 0x87,
  0x0C, 0x18, 0xF1, 0xC3, 0x00, 0x1C, 0x06, 0x01, 0x80, 0xE0, 0x31, 0xCC,
  0xC3, 0x70, 0xF8, 0x7C, 0x1F, 0x86, 0x61, 0x98, 0x67, 0x38, 0xC0, 0x1C,
  0x61, 0x8E, 0x38, 0xC3, 0x0C, 0x71, 0x86, 0x18, 0x63, 0x80, 0x37, 0xBC,
  0xF7, 0xB3, 0x1C, 0xCC, 0x63, 0x71, 0x8D, 0x8E, 0x36, 0x31, 0xD8, 0xC6,
  0x63, 0x1B, 0x9C, 0x60, 0x01, 0x1B, 0xCF, 0x67, 0x33, 0x1B, 0x8D, 0x86,
  0xC7, 0x63, 0x31, 0xB8, 0xC0, 0x3E, 0x77, 0x63, 0xC3, 0xC3, 0xC3, 0xC7,
  0xC6, 0xFE, 0x7C, 0x1B, 0xC3, 0x98, 0x63, 0x8C, 0x63, 0x8C, 0x61, 0x8C,
  0x71, 0x8C, 0x3F, 0x8F, 0xE1, 0x80, 0x30, 0x06, 0x01, 0xC0, 0x38, 0x00,
  0x3D, 0xBB, 0xD8, 0xDC, 0x6C, 0x36, 0x1B, 0x1D, 0x8C, 0xFE, 0x3B, 0x03,
  0x81, 0x80, 0xC0, 0x60, 0x30, 0x37, 0x3E, 0x38, 0x30, 0x70, 0x60, 0x60,
  0x60, 0x60, 0xE0, 0x3F, 0x72, 0x70, 0x70, 0x3C, 0x1C, 0x0E, 0x0E, 0xFC,
  0xF8, 0x10, 0xC3, 0x3F, 0x61, 0x86, 0x18, 0xE3, 0x0C, 0x3C, 0xF0, 0x71,
  0xB1, 0xD8, 0xCC, 0x6E, 0x36, 0x3B, 0x1D, 0x9C, 0xFE, 0x7B, 0x00, 0xC3,
  0xE3, 0xB1, 0x99, 0xCC, 0xC7, 0xE1, 0xE0, 0xF0, 0x70, 0x38, 0x00, 0xC7,
  0x1E, 0x39, 0xB3, 0xCD, 0x9E, 0xCD, 0xB6, 0x6D, 0xF3, 0x4F, 0x1E, 0x78,
  0xE3, 0x87, 0x1C, 0x00, 0x38, 0xE3, 0x30, 0x7E, 0x07, 0x80, 0xE0, 0x1C,
  0x07, 0x81, 0xB8, 0x73, 0x1C, 0x70, 0x18, 0x71, 0x8E, 0x18, 0xC1, 0xDC,
  0x0D, 0x80, 0xD8, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0C, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xC0, 0x00, 0x3F, 0x07, 0x0E, 0x0C, 0x18, 0x38, 0x70,
  0x60, 0xFC, 0xFC, 0x03, 0x0F, 0x0C, 0x1C, 0x18, 0x18, 0x18, 0x30, 0xE0,
  0xF0, 0x30, 0x30, 0x30, 0x60, 0x60, 0x78, 0x38, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x10, 0x38, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x06, 0x3C, 0x60, 0xC3,
  0x06, 0x0C, 0x78, 0xE0, 0xF8, 0xFF, 0xE1, 0x80,
};

const GFXglyph NotoSans_SemiCondensed_SemiBoldItalic19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 6, 14, 5, 0, -14 },
  { 12, 6, 5, 8, 2, -14 },
  { 16, 11, 14, 11, 0, -14 },
  { 36, 10, 15, 10, 0, -14 },
  { 55, 13, 14, 15, 1, -14 },
  { 78, 11, 14, 12, 0, -14 },
  { 98, 3, 5, 4, 2, -14 },
  { 100, 6, 17, 6, 1, -14 },
  { 113, 6, 17, 6, -1, -14 },
  { 126, 8, 9, 9, 2, -15 },
  { 135, 9, 9, 10, 1, -11 },
  { 146, 4, 4, 5, -1, -2 },
  { 148, 5, 2, 6, 0, -6 },
  { 150, 3, 3, 5, 0, -3 },
  { 152, 10, 14, 7, -1, -14 },
  { 170, 8, 14, 10, 1, -14 },
  { 184, 6, 14, 10, 2, -14 },
  { 195, 9, 14, 10, 0, -14 },
  { 211, 9, 14, 10, 0, -14 },
  { 227, 9, 14, 10, 0, -14 },
  { 243, 10, 14, 10, 0, -14 },
  { 261, 9, 14, 10, 1, -14 },
  { 277, 9, 14, 10, 1, -14 },
  { 293, 10, 14, 10, 0, -14 },
  { 311, 8, 14, 10, 1, -14 },
  { 325, 5, 10, 5, 0, -10 },
  { 332, 6, 12, 5, -1, -10 },
  { 341, 9, 10, 10, 1, -12 },
  { 353, 8, 5, 10, 1, -9 },
  { 358, 9, 10, 10, 1, -12 },
  { 370, 7, 14, 8, 1, -14 },
  { 383, 13, 16, 15, 1, -14 },
  { 409, 10, 14, 10, -1, -14 },
  { 427, 11, 14, 11, 0, -14 },
  { 447, 10, 14, 10, 1, -14 },
  { 465, 11, 14, 12, 0, -14 },
  { 485, 10, 14, 9, 0, -14 },
  { 503, 10, 14, 9, 0, -14 },
  { 521, 11, 14, 12, 1, -14 },
  { 541, 12, 14, 12, 0, -14 },
  { 562, 9, 14, 6, -1, -14 },
  { 578, 9, 18, 5, -3, -14 },
  { 599, 12, 14, 10, 0, -14 },
  { 620, 7, 14, 9, 0, -14 },
  { 633, 15, 14, 15, 0, -14 },
  { 660, 13, 14, 13, 0, -14 },
  { 683, 11, 14, 12, 1, -14 },
  { 703, 10, 14, 10, 0, -14 },
  { 721, 11, 17, 12, 1, -14 },
  { 745, 10, 14, 10, 0, -14 },
  { 763, 10, 14, 9, 0, -14 },
  { 781, 8, 14, 9, 2, -14 },
  { 795, 11, 14, 12, 1, -14 },
  { 815, 10, 14, 10, 2, -14 },
  { 833, 15, 14, 15, 2, -14 },
  { 860, 12, 14, 10, -1, -14 },
  { 881, 9, 14, 9, 2, -14 },
  { 897, 11, 14, 9, -1, -14 },
  { 917, 7, 17, 6, 0, -14 },
  { 932, 4, 14, 7, 2, -14 },
  { 939, 7, 17, 6, -1, -14 },
  { 954, 9, 9, 10, 0, -14 },
  { 965, 8, 1, 7, -2, 2 },
  { 966, 3, 3, 6, 3, -15 },
  { 968, 9, 10, 10, 1, -10 },
  { 980, 10, 14, 10, 0, -14 },
  { 998, 7, 10, 8, 1, -10 },
  { 1007, 10, 14, 10, 1, -14 },
  { 1025, 8, 10, 9, 1, -10 },
  { 1035, 10, 20, 6, -2, -15 },
  { 1060, 10, 15, 10, 0, -10 },
  { 1079, 9, 14, 10, 0, -14 },
  { 1095, 5, 14, 5, 0, -14 },
  { 1104, 7, 19, 5, -2, -14 },
  { 1121, 10, 14, 9, 0, -14 },
  { 1139, 6, 14, 5, 0, -14 },
  { 1150, 14, 10, 15, 0, -10 },
  { 1168, 9, 11, 10, 0, -11 },
  { 1181, 8, 10, 10, 1, -10 },
  { 1191, 11, 15, 10, -1, -10 },
  { 1212, 9, 15, 10, 1, -10 },
  { 1229, 8, 10, 7, 0, -10 },
  { 1239, 8, 10, 8, 0, -10 },
  { 1249, 6, 13, 6, 1, -13 },
  { 1259, 9, 10, 10, 1, -10 },
  { 1271, 9, 10, 9, 1, -10 },
  { 1283, 13, 10, 13, 1, -10 },
  { 1300, 11, 10, 9, -1, -10 },
  { 1314, 12, 15, 9, -2, -10 },
  { 1337, 8, 10, 8, 0, -10 },
  { 1347, 8, 17, 7, 0, -14 },
  { 1364, 2, 18, 9, 4, -14 },
  { 1369, 7, 17, 7, -1, -14 },
  { 1384, 9, 3, 10, 1, -8 },
};

const GFXfont NotoSans_SemiCondensed_SemiBoldItalic19pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_SemiBoldItalic19pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_SemiBoldItalic19pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC19PT7B_H_
