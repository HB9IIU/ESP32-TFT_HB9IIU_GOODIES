#ifndef _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC65PT7B_H_
#define _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC65PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-SemiBoldItalic.ttf
// Size: 65pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_SemiBoldItalic65pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x80,
  0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xF8,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F,
  0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x03, 0x80, 0x00, 0x1F,
  0xE1, 0xFC, 0x7F, 0x0F, 0xF3, 0xFC, 0x3F, 0xCF, 0xE0, 0xFE, 0x3F, 0x83,
  0xF8, 0xFE, 0x0F, 0xE3, 0xF8, 0x3F, 0x0F, 0xC0, 0xFC, 0x3F, 0x07, 0xF1,
  0xFC, 0x1F, 0xC7, 0xE0, 0x7E, 0x1F, 0x81, 0xF8, 0x7E, 0x07, 0xE1, 0xF8,
  0x1F, 0x07, 0xC0, 0x7C, 0x3F, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x07, 0xC0,
  0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x1F, 0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x7C, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x3F,
  0x00, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0x0F,
  0xC0, 0xFC, 0x00, 0x00, 0x7C, 0x07, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xE0, 0x7E, 0x00, 0x00,
  0x3E, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x00, 0x1F, 0x81, 0xF8,
  0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x00, 0x7E,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0x80, 0xF8, 0x00, 0x00, 0xFC, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x1F, 0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x7C, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x3F,
  0x00, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xB9, 0xFC, 0x03, 0xFE, 0x78, 0x38, 0x03, 0xFC, 0x78, 0x08,
  0x03, 0xF8, 0x78, 0x00, 0x03, 0xF8, 0x78, 0x00, 0x07, 0xF8, 0x70, 0x00,
  0x07, 0xF8, 0xF0, 0x00, 0x03, 0xF8, 0xF0, 0x00, 0x03, 0xFC, 0xF0, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0x9F, 0xF0, 0x00, 0x07, 0x9F, 0xF0,
  0x00, 0x07, 0x8F, 0xF0, 0x00, 0x07, 0x8F, 0xF0, 0x00, 0x07, 0x0F, 0xF0,
  0x00, 0x07, 0x0F, 0xF0, 0x80, 0x0F, 0x0F, 0xF0, 0x60, 0x0F, 0x1F, 0xE0,
  0x78, 0x0F, 0x3F, 0xE0, 0xFF, 0x8E, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xF0, 0x03,
  0xFF, 0xC0, 0x00, 0x7E, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xC0, 0x0F, 0xFF,
  0xE0, 0x00, 0xFC, 0x01, 0xFE, 0xFF, 0x00, 0x1F, 0x80, 0x1F, 0xC7, 0xF0,
  0x03, 0xF0, 0x03, 0xF8, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x03, 0xF0, 0x07,
  0xE0, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x00, 0x7F, 0x03, 0xF0, 0x0F, 0xC0,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x3F, 0x00, 0x07,
  0xE0, 0x7F, 0x03, 0xF0, 0x00, 0xFE, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xC0,
  0x7E, 0x0F, 0xC0, 0x00, 0xFC, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0xC0, 0xFE,
  0x1F, 0x80, 0x00, 0xFC, 0x0F, 0xC3, 0xF0, 0x08, 0x0F, 0xC0, 0xFC, 0x3F,
  0x0F, 0xF0, 0xFC, 0x1F, 0xC7, 0xE1, 0xFF, 0xCF, 0xC1, 0xF8, 0xFC, 0x7F,
  0xFE, 0xFC, 0x3F, 0x8F, 0xC7, 0xFF, 0xEF, 0xE7, 0xF1, 0xF8, 0xFF, 0xFE,
  0x7F, 0xFE, 0x3F, 0x1F, 0xC7, 0xF7, 0xFF, 0xE3, 0xF1, 0xF8, 0x3F, 0x3F,
  0xFC, 0x7E, 0x3F, 0x83, 0xF1, 0xFF, 0x8F, 0xC3, 0xF0, 0x3F, 0x0F, 0xE0,
  0xFC, 0x7F, 0x03, 0xF0, 0x00, 0x1F, 0x87, 0xE0, 0x3F, 0x00, 0x03, 0xF0,
  0x7E, 0x03, 0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x7F, 0x00, 0x07, 0xE0, 0xFE,
  0x07, 0xF0, 0x00, 0xFC, 0x0F, 0xE0, 0x7E, 0x00, 0x0F, 0xC0, 0xFC, 0x07,
  0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x00, 0x3F, 0x00, 0xFC, 0x0F, 0xE0,
  0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x00, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x0F,
  0xE0, 0x0F, 0xC1, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x80,
  0x0F, 0xE3, 0xF8, 0x03, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0x00, 0x07,
  0xFF, 0xE0, 0x07, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0xFE, 0x00, 0x03, 0xFF,
  0x80, 0x1F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xFE, 0x1F, 0xE0, 0x00, 0x0F, 0xE0,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x01, 0xFE, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0x7F, 0x01,
  0xFE, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x00,
  0x1F, 0xE1, 0xFE, 0x00, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x00, 0xFE, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0x01, 0xFF, 0xF8, 0x03, 0xFC, 0x1F,
  0xFF, 0xF0, 0x0F, 0xE0, 0xFF, 0xFF, 0xE0, 0x7F, 0x87, 0xFE, 0x7F, 0x81,
  0xFE, 0x1F, 0xE1, 0xFF, 0x0F, 0xF0, 0xFF, 0x03, 0xFC, 0x3F, 0xC3, 0xFC,
  0x07, 0xF9, 0xFE, 0x1F, 0xE0, 0x1F, 0xF7, 0xF0, 0x7F, 0x80, 0x3F, 0xFF,
  0xC1, 0xFC, 0x00, 0xFF, 0xFE, 0x0F, 0xF0, 0x01, 0xFF, 0xF0, 0x3F, 0xC0,
  0x07, 0xFF, 0xC0, 0xFF, 0x00, 0x0F, 0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xF0,
  0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xFF, 0x80, 0x7F, 0xE0,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x7F, 0xC0, 0x3F, 0xFF,
  0xC1, 0xFF, 0x00, 0x3F, 0xFC, 0x03, 0xFE, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0xCF, 0xE3, 0xF9, 0xFE, 0x7F, 0x1F, 0xC7, 0xF1, 0xF8, 0x7E, 0x1F,
  0x8F, 0xE3, 0xF0, 0xFC, 0x3F, 0x0F, 0x83, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x08, 0x03,
  0xF0, 0x01, 0xC0, 0x7E, 0x00, 0x7E, 0x0F, 0x80, 0x0F, 0xF1, 0xF0, 0x01,
  0xFF, 0xBE, 0x00, 0x7F, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0,
  0x3F, 0xF8, 0x04, 0x0F, 0xFF, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0xFF, 0x7E,
  0x00, 0x3F, 0xC7, 0xE0, 0x1F, 0xF0, 0xFC, 0x01, 0xFC, 0x1F, 0xC0, 0x1F,
  0x83, 0xF8, 0x01, 0xE0, 0x3F, 0x80, 0x18, 0x07, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x7F, 0x81, 0xFE, 0x07,
  0xF0, 0x3F, 0xC0, 0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0x7F, 0x03, 0xF8, 0x0F,
  0xE0, 0x3F, 0x01, 0xFC, 0x07, 0xE0, 0x3F, 0x80, 0xFC, 0x00, 0x7F, 0xFF,
  0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF,
  0xFC, 0x1F, 0x3F, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xC1, 0xFE, 0x03, 0xFE, 0x03,
  0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F, 0xC0, 0x3F, 0xC1, 0xFE, 0x00, 0xFF,
  0x0F, 0xF0, 0x03, 0xFC, 0x3F, 0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x3F, 0xC7,
  0xF8, 0x00, 0xFF, 0x1F, 0xE0, 0x03, 0xFC, 0xFF, 0x80, 0x0F, 0xF3, 0xFC,
  0x00, 0x3F, 0xCF, 0xF0, 0x00, 0xFF, 0x3F, 0xC0, 0x03, 0xFD, 0xFE, 0x00,
  0x0F, 0xF7, 0xF8, 0x00, 0x3F, 0x9F, 0xE0, 0x01, 0xFE, 0x7F, 0x80, 0x07,
  0xF9, 0xFE, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x7F, 0x9F, 0xC0, 0x03, 0xFE,
  0xFF, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0xFF, 0x3F,
  0xC0, 0x07, 0xF8, 0xFF, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x7F, 0x8F, 0xF0,
  0x03, 0xFC, 0x3F, 0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x7F, 0x83, 0xFC, 0x01,
  0xFE, 0x07, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0xC0, 0x7F, 0xC3, 0xFE,
  0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xFE, 0xFE, 0x1F, 0xE3, 0xF8,
  0x7F, 0x1F, 0xE0, 0xF8, 0x7F, 0x83, 0x81, 0xFE, 0x04, 0x07, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0x03, 0xFF, 0x00, 0x7E, 0x00, 0xFF, 0x80,
  0x1C, 0x00, 0x3F, 0xC0, 0x04, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7C, 0x03, 0xFF, 0x00, 0x30, 0x01, 0xFF,
  0x00, 0x20, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x80, 0x00, 0x3F, 0xE0,
  0xE0, 0x00, 0x7F, 0xE0, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F,
  0xDF, 0xC0, 0x00, 0x0F, 0xDF, 0xE0, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x0F,
  0xE7, 0xF0, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x07,
  0xF1, 0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x03,
  0xF0, 0x7F, 0x80, 0x03, 0xF8, 0x3F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x03,
  0xF8, 0x0F, 0xE0, 0x01, 0xF8, 0x07, 0xF0, 0x01, 0xFC, 0x07, 0xF8, 0x01,
  0xFC, 0x03, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xF3,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x80, 0x00, 0x7F, 0xC0, 0xE0, 0x00,
  0xFF, 0xC0, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xBE, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0xFF, 0x1F, 0xF8, 0x01,
  0xFC, 0xFF, 0xF8, 0x03, 0xFB, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xF0, 0x3F, 0xE1, 0xFF,
  0x80, 0x3F, 0xC3, 0xFF, 0x00, 0x7F, 0x87, 0xFC, 0x00, 0xFF, 0x0F, 0xF0,
  0x01, 0xFE, 0x1F, 0xE0, 0x03, 0xFC, 0x3F, 0xC0, 0x07, 0xF8, 0x7F, 0x80,
  0x0F, 0xF0, 0xFE, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x3F, 0xC3, 0xF8, 0x00,
  0x7F, 0x07, 0xF0, 0x01, 0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x1F, 0xE0, 0x0F,
  0xF0, 0x3F, 0xC0, 0x1F, 0xE0, 0x7F, 0xC0, 0x7F, 0x80, 0x7F, 0xC3, 0xFF,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0x83, 0xFE,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0xFF,
  0x01, 0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFF,
  0x03, 0xFC, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE,
  0x01, 0xFE, 0x03, 0xFC, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x9F, 0xF0,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFE, 0xFF, 0xC0, 0x0F, 0xF8, 0x3F, 0xE0,
  0x1F, 0xF0, 0x3F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0, 0x3F, 0xC0, 0x0F, 0xF0,
  0x7F, 0x80, 0x0F, 0xF0, 0x7F, 0x80, 0x07, 0xF0, 0x7F, 0x00, 0x07, 0xF0,
  0xFF, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x0F, 0xF0,
  0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x0F, 0xF0, 0x7F, 0x80, 0x1F, 0xE0,
  0x7F, 0xC0, 0x3F, 0xE0, 0x7F, 0xFB, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF,
  0x03, 0xFE, 0x07, 0xF8, 0x07, 0xF8, 0x3F, 0xC0, 0x1F, 0xE0, 0xFF, 0x00,
  0x3F, 0x87, 0xF8, 0x00, 0xFF, 0x1F, 0xE0, 0x03, 0xFC, 0x7F, 0x80, 0x0F,
  0xF1, 0xFC, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0xFF, 0x3F, 0xC0, 0x03, 0xFC,
  0xFF, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x7F, 0x8F, 0xF0, 0x01, 0xFE, 0x3F,
  0xC0, 0x0F, 0xF8, 0xFF, 0x00, 0x7F, 0xE3, 0xFE, 0x03, 0xFF, 0x87, 0xFC,
  0x1F, 0xFE, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFB, 0xFC, 0x03, 0xFF, 0xCF, 0xE0, 0x07, 0xFC, 0x3F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x03, 0xF8,
  0x0F, 0xF8, 0x1F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x03, 0xFE, 0x03,
  0xF8, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x07, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03,
  0xFC, 0x07, 0xF0, 0x03, 0x80, 0x00, 0x00, 0x07, 0x80, 0x03, 0xF8, 0x00,
  0xFF, 0x80, 0x1F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x03,
  0xFE, 0x00, 0x3F, 0x80, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x04, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F,
  0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x03, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0x1F, 0xF7, 0xFF, 0x1F, 0x00, 0xFF, 0x18, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0xFE,
  0x00, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x1F, 0x80,
  0x0F, 0xFC, 0x03, 0xF0, 0xFE, 0x00, 0xFF, 0xFE, 0x0F, 0xC3, 0xF0, 0x0F,
  0xFF, 0xF8, 0x3F, 0x1F, 0x80, 0x7F, 0xFF, 0xE0, 0xFC, 0x7E, 0x03, 0xFF,
  0xFF, 0x03, 0xF3, 0xF0, 0x1F, 0xE0, 0xFC, 0x07, 0xCF, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x3E, 0x03, 0xF0, 0x0F, 0xC0, 0xFD, 0xF8, 0x1F, 0xC0, 0x7E,
  0x03, 0xF7, 0xE0, 0x7E, 0x01, 0xF8, 0x0F, 0xDF, 0x01, 0xF8, 0x07, 0xE0,
  0x3F, 0xFC, 0x0F, 0xC0, 0x1F, 0x80, 0xFF, 0xF0, 0x3F, 0x00, 0xFC, 0x03,
  0xEF, 0xC0, 0xFC, 0x03, 0xF0, 0x1F, 0xBF, 0x07, 0xE0, 0x0F, 0xC0, 0x7E,
  0xF8, 0x1F, 0x80, 0x7F, 0x01, 0xFB, 0xE0, 0x7E, 0x01, 0xF8, 0x0F, 0xCF,
  0x81, 0xF8, 0x07, 0xE0, 0x3F, 0x3E, 0x07, 0xE0, 0x3F, 0x81, 0xF8, 0xF8,
  0x1F, 0x80, 0xFE, 0x07, 0xE3, 0xE0, 0x7E, 0x07, 0xF8, 0x3F, 0x0F, 0x81,
  0xFC, 0x3F, 0xE1, 0xFC, 0x3E, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0xFC, 0x0F,
  0xFF, 0xBF, 0xFF, 0x03, 0xF0, 0x1F, 0xFC, 0x7F, 0xF8, 0x0F, 0xC0, 0x7F,
  0xE0, 0xFF, 0x80, 0x3F, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x04, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xF0,
  0x00, 0x01, 0xFF, 0xE0, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00, 0x3F,
  0xBF, 0x80, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00,
  0x0F, 0xE3, 0xF8, 0x00, 0x00, 0xFE, 0x1F, 0x80, 0x00, 0x1F, 0xC1, 0xF8,
  0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x03, 0xF8,
  0x1F, 0xC0, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00,
  0xFF, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x01, 0xFE, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xC0, 0x01, 0xFE, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x7F, 0x80, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0xFF,
  0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x01, 0xFE,
  0x1F, 0xE0, 0x00, 0x0F, 0xE3, 0xFE, 0x00, 0x00, 0xFE, 0x3F, 0xC0, 0x00,
  0x0F, 0xE7, 0xFC, 0x00, 0x00, 0xFE, 0x7F, 0x80, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xC0, 0x3F, 0xF8, 0x07, 0xF8,
  0x01, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x03, 0xFC, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x01, 0xFE,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x0F, 0xF0, 0x0F, 0xE0, 0x03,
  0xFE, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0xE0, 0x0F, 0xF0,
  0x3F, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xC0, 0x0F,
  0xF8, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x1F, 0xE0,
  0x01, 0xFE, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x07, 0xF8, 0x1F,
  0xE0, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x07, 0xF8,
  0x1F, 0xE0, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x0F,
  0xF8, 0x0F, 0xF0, 0x07, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x7C,
  0x01, 0xFF, 0xC0, 0x03, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x06, 0x00, 0x3F, 0xFE, 0x0F, 0xC0,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01,
  0xFE, 0x1F, 0xFF, 0x80, 0x1F, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xF0, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x07, 0xFC,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0xFF, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x01, 0xFE, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x07,
  0xFC, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x01, 0xFE, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x07, 0xFC,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00,
  0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x1F,
  0xE0, 0x00, 0xFF, 0xC0, 0xFF, 0x00, 0x07, 0xFC, 0x07, 0xF8, 0x00, 0x7F,
  0xC0, 0x7F, 0x80, 0x07, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xE0,
  0x0F, 0xFE, 0x00, 0xFF, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x03,
  0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xF0, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFE, 0x00,
  0xF8, 0x01, 0xFF, 0xC0, 0x01, 0xC0, 0x1F, 0xF8, 0x00, 0x02, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xFF, 0x1F, 0xE0,
  0x07, 0xFF, 0xF0, 0xFF, 0x00, 0x3F, 0xFF, 0x87, 0xF8, 0x01, 0xFF, 0xFC,
  0x3F, 0xC0, 0x0F, 0xFF, 0xE1, 0xFE, 0x00, 0xFF, 0xFF, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x03, 0xFC, 0x1F,
  0xE0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x3F, 0xC0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x03, 0xFC, 0x0F, 0xF8,
  0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x00, 0xFE, 0x01, 0xFF, 0x00, 0x0F, 0xF0,
  0x0F, 0xFC, 0x00, 0x7F, 0x80, 0x3F, 0xFC, 0x0F, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFF, 0xE0, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFF,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0x00, 0x3F,
  0x80, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x0F,
  0xF8, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x00,
  0x7F, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x03, 0xFE, 0x00,
  0x00, 0xFE, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x01, 0xFE,
  0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x1F, 0xF0, 0x00, 0x01, 0xFC, 0x3F, 0xE0,
  0x00, 0x01, 0xFC, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0xFF, 0x80, 0x00, 0x03,
  0xFC, 0xFF, 0x00, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x00, 0x03, 0xFB, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x00, 0x0F, 0xFE, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x0F,
  0xE0, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x3F, 0xE0, 0x00,
  0x1F, 0xC0, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x00, 0x3F, 0x80, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0x7F,
  0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x07,
  0xFC, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x00,
  0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80,
  0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x07, 0xFF,
  0x80, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x0F,
  0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0,
  0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0x80, 0x0F, 0xDF, 0x80, 0x01, 0xFB, 0xF8, 0x01, 0xFD, 0xF8, 0x00, 0x3F,
  0xBF, 0x80, 0x1F, 0xDF, 0x80, 0x03, 0xF7, 0xF8, 0x01, 0xFD, 0xFC, 0x00,
  0x7F, 0x7F, 0x00, 0x1F, 0xDF, 0xC0, 0x07, 0xE7, 0xF0, 0x03, 0xFD, 0xFC,
  0x00, 0xFE, 0x7F, 0x00, 0x3F, 0x9F, 0xC0, 0x0F, 0xCF, 0xF0, 0x03, 0xF9,
  0xFC, 0x01, 0xFC, 0xFF, 0x00, 0x3F, 0x9F, 0xC0, 0x1F, 0x8F, 0xE0, 0x03,
  0xF8, 0xFC, 0x03, 0xF8, 0xFE, 0x00, 0x7F, 0x8F, 0xC0, 0x3F, 0x0F, 0xE0,
  0x07, 0xF0, 0xFC, 0x07, 0xF1, 0xFE, 0x00, 0x7F, 0x0F, 0xC0, 0x7E, 0x1F,
  0xE0, 0x07, 0xF0, 0xFC, 0x0F, 0xE1, 0xFC, 0x00, 0x7F, 0x0F, 0xC0, 0xFC,
  0x1F, 0xC0, 0x0F, 0xF0, 0xFC, 0x1F, 0xC1, 0xFC, 0x00, 0xFE, 0x0F, 0xC1,
  0xF8, 0x3F, 0xC0, 0x0F, 0xE0, 0xFC, 0x3F, 0x83, 0xFC, 0x00, 0xFE, 0x0F,
  0xE3, 0xF0, 0x3F, 0x80, 0x1F, 0xE0, 0xFE, 0x7F, 0x03, 0xF8, 0x01, 0xFE,
  0x0F, 0xE7, 0xE0, 0x7F, 0x80, 0x1F, 0xC0, 0xFE, 0xFE, 0x07, 0xF8, 0x01,
  0xFC, 0x0F, 0xEF, 0xC0, 0x7F, 0x00, 0x1F, 0xC0, 0xFF, 0xFC, 0x07, 0xF0,
  0x03, 0xFC, 0x07, 0xFF, 0x80, 0x7F, 0x00, 0x3F, 0x80, 0x7F, 0xF8, 0x0F,
  0xF0, 0x03, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x7F, 0xF0,
  0x0F, 0xE0, 0x03, 0xF8, 0x07, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x7F,
  0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x00,
  0x7F, 0xC0, 0x1F, 0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xE0, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x01,
  0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x3F, 0xF8, 0x00, 0x0F, 0xE0, 0x07, 0xFF,
  0x00, 0x01, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0x80, 0x1F, 0xFE, 0x00,
  0x0F, 0xF0, 0x07, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x3F,
  0x80, 0x1F, 0xFF, 0x80, 0x07, 0xF0, 0x03, 0xF7, 0xF0, 0x00, 0xFE, 0x00,
  0x7E, 0xFE, 0x00, 0x3F, 0xC0, 0x1F, 0xDF, 0xE0, 0x07, 0xF0, 0x03, 0xF9,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE7, 0xF0,
  0x03, 0xF8, 0x03, 0xFC, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x0F, 0xE0, 0x1F,
  0xC0, 0x0F, 0xE1, 0xFC, 0x03, 0xF8, 0x01, 0xFC, 0x3F, 0xC0, 0x7F, 0x00,
  0x3F, 0x87, 0xF8, 0x1F, 0xE0, 0x0F, 0xF0, 0x7F, 0x03, 0xFC, 0x01, 0xFC,
  0x0F, 0xE0, 0x7F, 0x00, 0x3F, 0x81, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0x1F,
  0xC1, 0xFC, 0x00, 0xFE, 0x03, 0xF8, 0x7F, 0x80, 0x3F, 0xC0, 0x7F, 0x0F,
  0xF0, 0x07, 0xF0, 0x0F, 0xF1, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x3F, 0x80,
  0x1F, 0xC0, 0x1F, 0xC7, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0xFE, 0x00, 0xFF,
  0x00, 0x3F, 0xBF, 0x80, 0x1F, 0xC0, 0x07, 0xF7, 0xF0, 0x03, 0xF8, 0x00,
  0xFE, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0xE0, 0x01, 0xFF,
  0xF8, 0x03, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0xC0,
  0x0F, 0xE0, 0x00, 0x7F, 0xF8, 0x01, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x7F,
  0x80, 0x01, 0xFF, 0xE0, 0x0F, 0xE0, 0x00, 0x3F, 0xF8, 0x01, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xE0, 0x07, 0xF0, 0x00, 0x0F,
  0xFC, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xF8, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0x7F,
  0x81, 0xFF, 0x00, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x3F, 0xE0,
  0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x00, 0xFF,
  0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0x0F, 0xF3, 0xFE, 0x00,
  0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x03, 0xFD,
  0xFF, 0x00, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x00, 0x7F, 0xDF, 0xE0, 0x00,
  0x01, 0xFE, 0x7F, 0x80, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x00, 0x1F, 0xE7,
  0xF8, 0x00, 0x00, 0xFF, 0x9F, 0xE0, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00,
  0x0F, 0xF3, 0xFE, 0x00, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x01, 0xFF, 0x3F,
  0xE0, 0x00, 0x07, 0xF8, 0xFF, 0x80, 0x00, 0x3F, 0xE1, 0xFE, 0x00, 0x00,
  0xFF, 0x87, 0xF8, 0x00, 0x07, 0xFC, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x7F,
  0xC0, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x07, 0xFE, 0x03, 0xFE, 0x00, 0x3F,
  0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xFC, 0x3F, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xE0, 0xFF, 0xF0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x1F, 0xE0, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x0F,
  0xF0, 0x1F, 0xE0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x7F, 0x80,
  0x07, 0xF8, 0x0F, 0xF0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x7F,
  0x80, 0x07, 0xF8, 0x0F, 0xF0, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x7F, 0xC0,
  0x3F, 0xC0, 0x1F, 0xF8, 0x0F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xF8, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0x7F, 0x81, 0xFF,
  0x00, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x0F,
  0xF0, 0xFF, 0x80, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x00, 0xFF, 0x1F, 0xF0,
  0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x00, 0x3F,
  0xCF, 0xF0, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x03, 0xFD, 0xFF, 0x00,
  0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x00, 0x7F, 0xDF, 0xE0, 0x00, 0x01, 0xFE,
  0x7F, 0x80, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x00, 0x1F, 0xE7, 0xF8, 0x00,
  0x00, 0xFF, 0x9F, 0xE0, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0x0F, 0xF3,
  0xFE, 0x00, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00,
  0x07, 0xF8, 0xFF, 0x80, 0x00, 0x3F, 0xE1, 0xFE, 0x00, 0x00, 0xFF, 0x87,
  0xF8, 0x00, 0x07, 0xFC, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00,
  0xFF, 0x81, 0xFF, 0x00, 0x07, 0xFE, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x0F,
  0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xFE, 0x3F, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xF0, 0x3F, 0xF8,
  0x03, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0xFF, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x7F, 0x80, 0x0F, 0xF0, 0x1F, 0xE0, 0x03, 0xFC, 0x07, 0xF8,
  0x01, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x3F, 0xE0, 0x3F,
  0xC0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xFC, 0x03, 0xFC, 0x07, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x03, 0xFC, 0x1F,
  0xE0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x1F, 0xE0,
  0x3F, 0xC0, 0x07, 0xF8, 0x0F, 0xF0, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xFC, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x0F, 0xF8,
  0x1F, 0xE0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x1F,
  0xF0, 0x7F, 0x00, 0x07, 0xFC, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0xF8, 0x01, 0xFF, 0x00, 0x0C, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x01, 0x80,
  0x01, 0xFF, 0x00, 0xF0, 0x01, 0xFF, 0x80, 0x7F, 0x87, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFF, 0xE8, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x01, 0xFE, 0x07,
  0xF8, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x01, 0xFE, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x7F, 0x80, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x7F, 0x80, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0xFF, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x7F,
  0x80, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x7F,
  0x80, 0xFF, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x3F, 0xC0,
  0x01, 0xFF, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x3F,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x0F, 0xFB,
  0xFC, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x01, 0xFF, 0x3F, 0xC0, 0x00, 0x7F,
  0x8F, 0xF0, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x03,
  0xFC, 0x3F, 0xC0, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x7F, 0x81, 0xFC, 0x00,
  0x3F, 0xC0, 0x7F, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x07, 0xF8, 0x07, 0xF0,
  0x01, 0xFE, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x1F,
  0xC0, 0x1F, 0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x01, 0xFC, 0x03, 0xFC, 0x00,
  0x7F, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x07, 0xF8, 0x1F, 0xE0,
  0x01, 0xFE, 0x07, 0xF0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x1F, 0xE0, 0xFE,
  0x00, 0x03, 0xF8, 0x7F, 0x80, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x3F, 0x8F,
  0xF0, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x00, 0xFE,
  0x7F, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x03,
  0xFB, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xEF, 0xF0,
  0x00, 0x7F, 0xC0, 0x01, 0xFE, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xCF,
  0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFC, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F,
  0x8F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xF8, 0xFF, 0x00, 0x1F, 0xFC, 0x00,
  0x7F, 0x0F, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0x0F, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xE0, 0xFF, 0x00, 0x7F,
  0xFC, 0x01, 0xFE, 0x0F, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xC0, 0xFF, 0x00,
  0xFF, 0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x0F, 0xDF, 0xC0, 0x3F, 0x80, 0xFF,
  0x01, 0xFD, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0x9F, 0xC0, 0x7F, 0x80,
  0xFF, 0x03, 0xF9, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0x3F, 0x9F, 0xC0, 0xFF,
  0x00, 0xFF, 0x03, 0xF1, 0xFC, 0x0F, 0xE0, 0x0F, 0xF0, 0x7F, 0x1F, 0xC1,
  0xFE, 0x00, 0xFF, 0x07, 0xE1, 0xFC, 0x1F, 0xC0, 0x0F, 0xF0, 0xFE, 0x1F,
  0xC3, 0xFC, 0x00, 0xFF, 0x0F, 0xC1, 0xFC, 0x3F, 0xC0, 0x0F, 0xF1, 0xFC,
  0x1F, 0xC3, 0xF8, 0x00, 0xFF, 0x1F, 0xC1, 0xFC, 0x7F, 0x80, 0x0F, 0xE3,
  0xF8, 0x0F, 0xC7, 0xF0, 0x00, 0xFE, 0x3F, 0x80, 0xFC, 0x7F, 0x00, 0x0F,
  0xE3, 0xF0, 0x0F, 0xCF, 0xE0, 0x00, 0xFE, 0x7F, 0x00, 0xFC, 0xFE, 0x00,
  0x0F, 0xE7, 0xE0, 0x0F, 0xDF, 0xE0, 0x00, 0xFE, 0x7E, 0x00, 0xFD, 0xFC,
  0x00, 0x0F, 0xEF, 0xE0, 0x0F, 0xDF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xE0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x07, 0xFC, 0x00, 0x01,
  0xFE, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x03, 0xF8,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x7F,
  0x80, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC7, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x00, 0x07, 0xF9, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x03,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x07, 0xFC,
  0x00, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x07, 0xFC, 0x7F, 0x00,
  0x07, 0xF8, 0x7F, 0x80, 0x0F, 0xF8, 0x7F, 0x80, 0x0F, 0xF0, 0x7F, 0x80,
  0x1F, 0xE0, 0x7F, 0x80, 0x3F, 0xE0, 0x3F, 0x80, 0x3F, 0xC0, 0x3F, 0xC0,
  0x7F, 0xC0, 0x3F, 0xC0, 0x7F, 0x80, 0x3F, 0xC0, 0xFF, 0x00, 0x1F, 0xC0,
  0xFF, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x1F, 0xE3,
  0xFC, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x0F, 0xEF,
  0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0,
  0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x0F,
  0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00,
  0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x03, 0xF0, 0x1F, 0x80, 0xFE,
  0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x03, 0xF0, 0x1F, 0x80, 0xFE, 0x07,
  0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xE0, 0x7F,
  0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x03, 0xF0, 0x1F, 0xC0, 0xFE, 0x07, 0xF0,
  0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0,
  0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x0F,
  0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x03,
  0xF1, 0xF8, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x7E,
  0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xE0, 0x03, 0xF0, 0x0F, 0xC0, 0x0F, 0xE0,
  0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0x3F, 0x00, 0xFC, 0x00,
  0x7E, 0x03, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x01,
  0xF8, 0x7F, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x07,
  0xEF, 0xE0, 0x00, 0x0F, 0xE0, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xE0, 0xFF, 0x87, 0xF8, 0x7F, 0x83, 0xFC,
  0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0x7E, 0x03, 0xF0, 0x3F, 0x01, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x3F, 0x00, 0x7F, 0xFC, 0x7F, 0x00,
  0xFF, 0xFE, 0x7F, 0x01, 0xFF, 0xFE, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFE, 0x07, 0xFE, 0x0F, 0xFE, 0x0F, 0xFC, 0x07, 0xFE, 0x0F,
  0xF8, 0x07, 0xFC, 0x1F, 0xF0, 0x07, 0xFC, 0x1F, 0xE0, 0x03, 0xFC, 0x1F,
  0xE0, 0x03, 0xFC, 0x3F, 0xE0, 0x03, 0xF8, 0x3F, 0xC0, 0x07, 0xF8, 0x3F,
  0xC0, 0x07, 0xF8, 0x7F, 0xC0, 0x07, 0xF8, 0x7F, 0x80, 0x07, 0xF8, 0x7F,
  0x80, 0x07, 0xF0, 0x7F, 0x80, 0x07, 0xF0, 0x7F, 0x80, 0x0F, 0xF0, 0x7F,
  0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x1F, 0xE0, 0xFF,
  0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x7F, 0xE0, 0xFF,
  0x80, 0x7F, 0xC0, 0x7F, 0x80, 0xFF, 0xC0, 0x7F, 0xC3, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xDF, 0xC0, 0x3F, 0xFF, 0x9F, 0x80, 0x1F,
  0xFF, 0x1F, 0x80, 0x1F, 0xFE, 0x1F, 0x80, 0x07, 0xFC, 0x3F, 0x80, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x0F, 0x80, 0x01,
  0xFE, 0x3F, 0xE0, 0x01, 0xFC, 0x7F, 0xF8, 0x01, 0xFD, 0xFF, 0xF8, 0x03,
  0xFD, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0x83, 0xFE, 0x03, 0xFF, 0x01, 0xFE, 0x07, 0xFE, 0x01, 0xFE, 0x07,
  0xFC, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0xFE, 0x07,
  0xF8, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0xFE, 0x0F, 0xF0, 0x01, 0xFE, 0x0F,
  0xE0, 0x01, 0xFE, 0x0F, 0xE0, 0x01, 0xFE, 0x1F, 0xE0, 0x01, 0xFE, 0x1F,
  0xE0, 0x01, 0xFE, 0x1F, 0xE0, 0x03, 0xFC, 0x1F, 0xC0, 0x03, 0xFC, 0x1F,
  0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x07, 0xF8, 0x3F, 0xC0, 0x07, 0xF8, 0x3F,
  0xC0, 0x0F, 0xF8, 0x3F, 0xC0, 0x0F, 0xF0, 0x3F, 0xE0, 0x1F, 0xF0, 0x7F,
  0xE0, 0x3F, 0xE0, 0x7F, 0xF0, 0x7F, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0x80, 0x7E, 0xFF, 0xFF, 0x00, 0xFE, 0x7F, 0xFE, 0x00, 0xFC,
  0x3F, 0xFC, 0x00, 0xFC, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x3F,
  0xF0, 0x1C, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x80, 0xFF, 0xC0, 0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xF0,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xC1, 0xFE, 0x00, 0x07, 0xFE, 0x3F, 0xC0, 0x03, 0xFF,
  0xE7, 0xF8, 0x00, 0xFF, 0xFE, 0xFE, 0x00, 0x3F, 0xFF, 0xDF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0xE0,
  0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x1F,
  0xE0, 0x1F, 0xE0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0xFF, 0x00,
  0x0F, 0xE0, 0x1F, 0xE0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0xFF,
  0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x3F, 0x80,
  0x7F, 0x80, 0x07, 0xF0, 0x0F, 0xF0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x7F, 0x80, 0x07, 0xF0, 0x0F, 0xF0, 0x01, 0xFE, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x3F, 0xC0, 0x0F, 0xF8, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x0F, 0xF0, 0x1F, 0xF8, 0x01, 0xFF, 0x07, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xBF,
  0x00, 0x07, 0xFF, 0xE7, 0xE0, 0x00, 0x7F, 0xF0, 0xFC, 0x00, 0x07, 0xFC,
  0x1F, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0x03, 0xFE, 0x0F, 0xF0, 0x7F, 0xC0, 0x7F, 0x0F,
  0xF8, 0x07, 0xF0, 0xFF, 0x00, 0x7F, 0x1F, 0xE0, 0x07, 0xF1, 0xFE, 0x00,
  0x7F, 0x3F, 0xC0, 0x0F, 0xF3, 0xFC, 0x01, 0xFE, 0x3F, 0xC0, 0x7F, 0xE3,
  0xF8, 0x3F, 0xFC, 0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x02,
  0x07, 0xFC, 0x00, 0xE0, 0x3F, 0xFC, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x02, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x83, 0xF0, 0x01, 0xFF, 0xF1, 0xFC, 0x00, 0xFF, 0xFE, 0x7F, 0x00,
  0x7F, 0xFF, 0xBF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8,
  0x07, 0xFE, 0x0F, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x7F, 0xC0, 0x1F, 0xF0, 0x1F, 0xE0, 0x03, 0xFC, 0x07, 0xF8, 0x00,
  0xFF, 0x03, 0xFE, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x1F, 0xE0, 0x3F, 0xC0,
  0x07, 0xF8, 0x1F, 0xF0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0x81, 0xFE,
  0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x0F, 0xF0, 0x1F, 0xE0, 0x03, 0xFC, 0x07,
  0xF0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x1F, 0xE0,
  0x3F, 0xC0, 0x0F, 0xF8, 0x0F, 0xF0, 0x03, 0xFE, 0x03, 0xFC, 0x01, 0xFF,
  0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xE0, 0x3F, 0xF0, 0x07, 0xFC, 0x3F,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xEF, 0xE0, 0x03, 0xFF, 0xF3, 0xF8, 0x00, 0x7F, 0xF9, 0xFE, 0x00, 0x07,
  0xF8, 0x7F, 0x80, 0x00, 0x70, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x03, 0x00, 0x03, 0xFC,
  0x00, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xA0, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0xC1, 0xF8, 0x00, 0x7F, 0x8F, 0xFC, 0x00, 0xFE, 0x3F,
  0xFC, 0x01, 0xFD, 0xFF, 0xFC, 0x07, 0xFB, 0xFF, 0xF8, 0x0F, 0xEF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xF8, 0x3F, 0xE0, 0x7F, 0xE0, 0x3F,
  0xC1, 0xFF, 0x80, 0x7F, 0x83, 0xFE, 0x00, 0xFF, 0x07, 0xFC, 0x01, 0xFE,
  0x0F, 0xF0, 0x03, 0xFC, 0x1F, 0xE0, 0x07, 0xF8, 0x7F, 0x80, 0x0F, 0xE0,
  0xFF, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0xFF, 0x0F,
  0xF0, 0x01, 0xFE, 0x1F, 0xE0, 0x03, 0xF8, 0x3F, 0xC0, 0x07, 0xF0, 0x7F,
  0x80, 0x1F, 0xE0, 0xFE, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x7F, 0x87, 0xF8,
  0x00, 0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x1F, 0xC0, 0x07, 0xF8, 0x3F, 0x80,
  0x0F, 0xF0, 0xFF, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x3F, 0x83, 0xFC, 0x00,
  0xFF, 0x07, 0xF0, 0x01, 0xFE, 0x0F, 0xE0, 0x03, 0xFC, 0x3F, 0xC0, 0x07,
  0xF8, 0x7F, 0x80, 0x0F, 0xE0, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0x00,
  0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x07,
  0xF8, 0x01, 0xFC, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07,
  0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x10, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF,
  0x80, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x10, 0x1F, 0xE0, 0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x7F,
  0x80, 0x0F, 0xF0, 0x3F, 0xC0, 0x03, 0xF8, 0x1F, 0xF0, 0x00, 0xFE, 0x0F,
  0xF8, 0x00, 0x7F, 0x87, 0xFC, 0x00, 0x1F, 0xE3, 0xFE, 0x00, 0x07, 0xF0,
  0xFF, 0x00, 0x01, 0xFC, 0x7F, 0x80, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x3F,
  0xDF, 0xE0, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xBF, 0xC0, 0x00, 0x7F, 0xCF, 0xF0,
  0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x03, 0xFC, 0x1F,
  0xE0, 0x00, 0xFE, 0x07, 0xFC, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x1F, 0xE0,
  0x3F, 0xC0, 0x07, 0xF8, 0x07, 0xF8, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x7F,
  0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x0F, 0xF0, 0x0F, 0xF0, 0x03, 0xFC, 0x03,
  0xFC, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07,
  0xF8, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07,
  0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xFC, 0x1F, 0xF8, 0x0F, 0xFE,
  0x00, 0x7E, 0x3F, 0xFE, 0x0F, 0xFF, 0x80, 0x3F, 0x3F, 0xFF, 0x0F, 0xFF,
  0xC0, 0x3F, 0xBF, 0xFF, 0xCF, 0xFF, 0xF0, 0x1F, 0xDF, 0xFF, 0xEF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0xC1,
  0xFE, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0x83, 0xFF, 0x00, 0xFF, 0xC0,
  0x3F, 0xC1, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xC0, 0xFF, 0x80, 0x3F, 0xE0,
  0x0F, 0xE0, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x3F, 0xC0, 0x1F, 0xF0,
  0x07, 0xF8, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x1F, 0xE0, 0x07, 0xF8,
  0x01, 0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0xFF, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x7F, 0x80, 0x1F,
  0xE0, 0x07, 0xF8, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x1F, 0xE0, 0x07,
  0xF8, 0x01, 0xFE, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0xFF, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x83, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x7F, 0x80,
  0x1F, 0xE0, 0x07, 0xF8, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x1F, 0xE0,
  0x07, 0xF8, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x7F,
  0xE0, 0x07, 0xE1, 0xFF, 0xE0, 0x0F, 0xCF, 0xFF, 0xE0, 0x3F, 0xBF, 0xFF,
  0xC0, 0x7F, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xC1, 0xFF,
  0x03, 0xFF, 0x01, 0xFE, 0x0F, 0xFC, 0x03, 0xFC, 0x1F, 0xF0, 0x07, 0xF8,
  0x3F, 0xE0, 0x0F, 0xF0, 0x7F, 0x80, 0x1F, 0xE0, 0xFF, 0x00, 0x3F, 0xC3,
  0xFE, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x1F,
  0xE0, 0x07, 0xF8, 0x7F, 0x80, 0x0F, 0xF0, 0xFF, 0x00, 0x1F, 0xE1, 0xFE,
  0x00, 0x3F, 0x83, 0xFC, 0x00, 0xFF, 0x07, 0xF0, 0x01, 0xFE, 0x1F, 0xE0,
  0x03, 0xFC, 0x3F, 0xC0, 0x07, 0xF0, 0x7F, 0x80, 0x1F, 0xE0, 0xFF, 0x00,
  0x3F, 0xC1, 0xFC, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0xFF, 0x0F, 0xF0, 0x01,
  0xFC, 0x1F, 0xE0, 0x07, 0xF8, 0x3F, 0x80, 0x0F, 0xF0, 0xFF, 0x00, 0x1F,
  0xE1, 0xFE, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x7F, 0x07, 0xF8, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x07, 0xF8, 0x3F,
  0xC0, 0x1F, 0xE1, 0xFF, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0xFF, 0x3F, 0xC0,
  0x03, 0xFC, 0xFF, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x3F, 0xDF, 0xE0, 0x00,
  0xFF, 0x7F, 0x80, 0x03, 0xF9, 0xFE, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x7F,
  0x9F, 0xE0, 0x01, 0xFE, 0x7F, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x1F, 0xEF,
  0xF0, 0x00, 0xFF, 0x3F, 0xC0, 0x03, 0xFC, 0xFF, 0x00, 0x0F, 0xF3, 0xFC,
  0x00, 0x7F, 0x87, 0xF0, 0x03, 0xFE, 0x1F, 0xE0, 0x0F, 0xF0, 0x7F, 0x80,
  0x7F, 0xC1, 0xFF, 0x07, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xE0, 0xFF, 0x80, 0x00, 0xFC, 0x7F, 0xFC, 0x00, 0x1F, 0x9F,
  0xFF, 0x80, 0x07, 0xF7, 0xFF, 0xF8, 0x00, 0xFE, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0x83, 0xFE, 0x00, 0x7F, 0xE0, 0x3F, 0xC0,
  0x1F, 0xF8, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x0F, 0xF0, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x7F, 0x80,
  0x07, 0xF0, 0x0F, 0xF0, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x3F,
  0x80, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x1F, 0xE0,
  0x3F, 0xC0, 0x07, 0xF8, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x1F,
  0xE0, 0x3F, 0xC0, 0x07, 0xFC, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0x3F, 0xE0, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF,
  0xC0, 0x7F, 0xC0, 0x1F, 0xFC, 0x1F, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xEF, 0xFF, 0xE0, 0x03, 0xFD, 0xFF, 0xF8,
  0x00, 0x7F, 0x9F, 0xFE, 0x00, 0x0F, 0xE1, 0xFF, 0x80, 0x01, 0xFC, 0x07,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x3F,
  0x00, 0x7F, 0xFC, 0x7F, 0x00, 0xFF, 0xFE, 0x7E, 0x01, 0xFF, 0xFF, 0x7E,
  0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFC, 0x0F, 0xFE,
  0x0F, 0xF8, 0x07, 0xFC, 0x0F, 0xF8, 0x07, 0xFC, 0x1F, 0xF0, 0x03, 0xFC,
  0x1F, 0xE0, 0x03, 0xFC, 0x1F, 0xE0, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xF8,
  0x3F, 0xC0, 0x07, 0xF8, 0x3F, 0xC0, 0x07, 0xF8, 0x7F, 0x80, 0x07, 0xF8,
  0x7F, 0x80, 0x07, 0xF8, 0x7F, 0x80, 0x07, 0xF0, 0x7F, 0x80, 0x07, 0xF0,
  0x7F, 0x80, 0x0F, 0xF0, 0x7F, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x0F, 0xE0,
  0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x3F, 0xE0,
  0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0x80, 0xFF, 0xC0,
  0x7F, 0xC1, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xBF, 0x80, 0x1F, 0xFF, 0x3F, 0x80, 0x1F, 0xFE, 0x7F, 0x80,
  0x07, 0xF8, 0x7F, 0x80, 0x00, 0xE0, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x04, 0x0F, 0xC0,
  0x7E, 0x0F, 0xF0, 0x1F, 0x8F, 0xF8, 0x07, 0xE7, 0xFE, 0x03, 0xF9, 0xFF,
  0x80, 0xFE, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0x01, 0xFF, 0x07, 0xE0, 0x7F, 0xC0, 0x18, 0x0F, 0xF0, 0x01, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x0C, 0x00, 0x3F, 0xE1, 0xE0, 0x0F, 0xF8, 0x3F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xFF, 0xF9, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xF8, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x20, 0x7F,
  0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x01, 0xFF, 0xF0,
  0x07, 0xFF, 0x00, 0x03, 0x00, 0x00, 0x07, 0xF8, 0x01, 0xFE, 0x0F, 0xE0,
  0x03, 0xFC, 0x3F, 0xC0, 0x07, 0xF0, 0x7F, 0x80, 0x0F, 0xE0, 0xFF, 0x00,
  0x3F, 0xC1, 0xFC, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0xFF, 0x0F, 0xF0, 0x01,
  0xFC, 0x1F, 0xE0, 0x03, 0xF8, 0x3F, 0xC0, 0x0F, 0xF0, 0x7F, 0x00, 0x1F,
  0xE1, 0xFE, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0xFE,
  0x0F, 0xF0, 0x03, 0xFC, 0x1F, 0xC0, 0x07, 0xF8, 0x7F, 0x80, 0x0F, 0xF0,
  0xFF, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0xFF, 0x07,
  0xF0, 0x01, 0xFE, 0x1F, 0xE0, 0x07, 0xF8, 0x3F, 0xC0, 0x0F, 0xF0, 0x7F,
  0x80, 0x1F, 0xE0, 0xFF, 0x00, 0x7F, 0xC1, 0xFE, 0x01, 0xFF, 0x83, 0xFC,
  0x03, 0xFE, 0x07, 0xF8, 0x0F, 0xFC, 0x0F, 0xF8, 0x7F, 0xF8, 0x1F, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xEF, 0xE0, 0x3F, 0xFF, 0x9F, 0x80, 0x7F, 0xFE,
  0x3F, 0x00, 0x7F, 0xF8, 0x7E, 0x00, 0x7F, 0xC0, 0xFC, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x07, 0xFD, 0xFC, 0x00, 0x1F, 0xE7, 0xF0, 0x00,
  0xFF, 0x1F, 0xC0, 0x03, 0xFC, 0x7F, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x7F,
  0x87, 0xF0, 0x03, 0xFC, 0x1F, 0xC0, 0x0F, 0xF0, 0x7F, 0x00, 0x3F, 0x81,
  0xFC, 0x01, 0xFE, 0x07, 0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x3F,
  0x80, 0xFE, 0x00, 0xFE, 0x07, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x0F, 0xE0,
  0xFF, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFE, 0x1F, 0xE0, 0x03, 0xF8, 0x7F,
  0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0xFE, 0x7F, 0x80,
  0x03, 0xF9, 0xFC, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x1F, 0xBF, 0x80, 0x00,
  0x7E, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFC, 0x00,
  0xFF, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xEF, 0xE0, 0x0F, 0xFC, 0x01, 0xFE,
  0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xCF, 0xE0, 0x1F, 0xFC, 0x03, 0xFC, 0xFE,
  0x01, 0xFF, 0xC0, 0x3F, 0xCF, 0xE0, 0x3F, 0xFC, 0x07, 0xF8, 0xFE, 0x03,
  0xFF, 0xC0, 0x7F, 0x8F, 0xE0, 0x3F, 0xFC, 0x07, 0xF0, 0xFE, 0x07, 0xEF,
  0xC0, 0xFF, 0x0F, 0xE0, 0x7E, 0xFC, 0x0F, 0xE0, 0xFE, 0x0F, 0xCF, 0xC1,
  0xFE, 0x0F, 0xE0, 0xFC, 0xFC, 0x1F, 0xC0, 0xFE, 0x0F, 0xCF, 0xC1, 0xFC,
  0x0F, 0xE1, 0xF8, 0xFC, 0x3F, 0xC0, 0xFE, 0x1F, 0x8F, 0xC3, 0xF8, 0x0F,
  0xE3, 0xF0, 0xFC, 0x7F, 0x80, 0xFE, 0x3F, 0x0F, 0xC7, 0xF0, 0x0F, 0xE7,
  0xF0, 0xFC, 0x7F, 0x00, 0xFE, 0x7E, 0x0F, 0xCF, 0xE0, 0x0F, 0xE7, 0xE0,
  0xFC, 0xFE, 0x00, 0xFE, 0xFC, 0x0F, 0xDF, 0xC0, 0x0F, 0xEF, 0xC0, 0xFD,
  0xFC, 0x00, 0xFE, 0xFC, 0x0F, 0xDF, 0xC0, 0x0F, 0xFF, 0x80, 0xFF, 0xF8,
  0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x00,
  0x7F, 0xF0, 0x0F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xE0, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0,
  0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x0F, 0xF0, 0x03, 0xFE,
  0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x7F, 0x80,
  0xFF, 0x00, 0x03, 0xFC, 0x1F, 0xF0, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x01,
  0xFC, 0x3F, 0xC0, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x01, 0xFE, 0x7F, 0x80,
  0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0x3F, 0x80, 0x00, 0x1F, 0xE3, 0xFC, 0x00,
  0x03, 0xFE, 0x3F, 0xC0, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x07, 0xF8, 0x1F,
  0xE0, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x00,
  0xFF, 0x80, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xFC, 0x01, 0xFC,
  0x00, 0x1F, 0xE0, 0x07, 0xF0, 0x00, 0xFF, 0x80, 0x1F, 0xC0, 0x03, 0xFC,
  0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x07, 0xF8,
  0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x3F, 0xC0,
  0x00, 0xFE, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x07, 0xF8, 0x00, 0x0F, 0xE0,
  0x3F, 0xC0, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x00, 0xFE, 0x07, 0xF8, 0x00,
  0x03, 0xF8, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x00, 0x3F, 0x83,
  0xFC, 0x00, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00,
  0x07, 0xF3, 0xFC, 0x00, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x00, 0x7F, 0x3F,
  0x80, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x00,
  0x1F, 0xDF, 0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xFC, 0x00,
  0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F,
  0xFE, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x04, 0x7F, 0xF0, 0x00, 0x37, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0xC0, 0x01, 0xFF, 0xE2, 0x00, 0x00,
  0xFE, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_SemiBoldItalic65pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 18, 47, 17, 1, -46 },
  { 107, 22, 16, 27, 6, -46 },
  { 151, 37, 46, 38, 1, -46 },
  { 364, 32, 53, 33, 1, -49 },
  { 576, 44, 48, 50, 4, -47 },
  { 840, 38, 48, 40, 1, -47 },
  { 1068, 10, 16, 15, 7, -46 },
  { 1088, 22, 56, 20, 2, -46 },
  { 1242, 23, 57, 20, -5, -47 },
  { 1406, 27, 29, 32, 6, -50 },
  { 1504, 30, 32, 34, 3, -39 },
  { 1624, 14, 17, 17, -3, -8 },
  { 1654, 17, 7, 20, 1, -21 },
  { 1669, 9, 10, 17, 1, -9 },
  { 1681, 33, 47, 25, -3, -47 },
  { 1875, 30, 48, 33, 2, -47 },
  { 2055, 22, 46, 33, 7, -46 },
  { 2182, 33, 47, 33, -1, -47 },
  { 2376, 32, 48, 33, 0, -47 },
  { 2568, 33, 47, 33, -1, -47 },
  { 2762, 32, 47, 33, 1, -46 },
  { 2950, 31, 48, 33, 3, -47 },
  { 3136, 32, 46, 33, 3, -46 },
  { 3320, 32, 48, 33, 1, -47 },
  { 3512, 30, 48, 33, 2, -47 },
  { 3692, 15, 37, 17, 1, -36 },
  { 3762, 19, 45, 17, -3, -36 },
  { 3869, 30, 33, 34, 3, -40 },
  { 3993, 29, 18, 34, 3, -32 },
  { 4059, 30, 33, 34, 3, -40 },
  { 4183, 24, 48, 26, 4, -47 },
  { 4327, 46, 53, 50, 3, -47 },
  { 4632, 36, 46, 35, -4, -46 },
  { 4839, 35, 46, 36, 1, -46 },
  { 5041, 35, 48, 35, 3, -47 },
  { 5251, 37, 46, 40, 1, -46 },
  { 5464, 33, 46, 31, 1, -46 },
  { 5654, 33, 46, 30, 1, -46 },
  { 5844, 37, 48, 40, 4, -47 },
  { 6066, 41, 46, 41, 1, -46 },
  { 6302, 28, 46, 22, -2, -46 },
  { 6463, 29, 59, 18, -10, -46 },
  { 6677, 40, 46, 35, 1, -46 },
  { 6907, 24, 46, 29, 1, -46 },
  { 7045, 52, 46, 52, 1, -46 },
  { 7344, 43, 46, 43, 1, -46 },
  { 7592, 38, 48, 42, 3, -47 },
  { 7820, 35, 46, 35, 1, -46 },
  { 8022, 38, 58, 42, 3, -47 },
  { 8298, 34, 46, 35, 1, -46 },
  { 8494, 33, 48, 31, 0, -47 },
  { 8692, 30, 46, 30, 5, -46 },
  { 8865, 37, 47, 40, 4, -46 },
  { 9083, 34, 46, 34, 6, -46 },
  { 9279, 52, 46, 52, 6, -46 },
  { 9578, 43, 46, 34, -4, -46 },
  { 9826, 32, 46, 32, 6, -46 },
  { 10010, 36, 46, 31, -2, -46 },
  { 10217, 25, 56, 20, -1, -46 },
  { 10392, 13, 47, 25, 7, -47 },
  { 10469, 25, 56, 20, -4, -46 },
  { 10644, 31, 29, 33, 1, -47 },
  { 10757, 25, 4, 24, -6, 6 },
  { 10770, 12, 11, 19, 9, -50 },
  { 10787, 32, 37, 35, 2, -36 },
  { 10935, 32, 50, 35, 1, -49 },
  { 11135, 27, 37, 28, 2, -36 },
  { 11260, 35, 50, 35, 2, -49 },
  { 11479, 28, 37, 32, 2, -36 },
  { 11609, 35, 66, 21, -7, -50 },
  { 11898, 34, 52, 35, 0, -36 },
  { 12119, 31, 49, 35, 1, -49 },
  { 12309, 18, 49, 17, 1, -49 },
  { 12420, 27, 65, 17, -8, -49 },
  { 12640, 34, 49, 32, 1, -49 },
  { 12849, 18, 49, 17, 1, -49 },
  { 12960, 49, 36, 52, 1, -36 },
  { 13181, 31, 36, 35, 1, -36 },
  { 13321, 30, 37, 34, 2, -36 },
  { 13460, 35, 51, 35, -2, -36 },
  { 13684, 32, 52, 35, 2, -36 },
  { 13892, 26, 36, 24, 1, -36 },
  { 14009, 27, 37, 27, 0, -36 },
  { 14134, 21, 44, 22, 3, -43 },
  { 14250, 31, 36, 35, 3, -35 },
  { 14390, 30, 35, 29, 3, -35 },
  { 14522, 44, 35, 45, 4, -35 },
  { 14715, 36, 35, 30, -3, -35 },
  { 14873, 38, 51, 30, -5, -35 },
  { 15116, 29, 35, 27, -2, -35 },
  { 15243, 26, 56, 22, 1, -46 },
  { 15425, 6, 64, 32, 13, -49 },
  { 15473, 25, 56, 22, -3, -46 },
  { 15648, 30, 10, 34, 3, -28 },
};

const GFXfont NotoSans_SemiCondensed_SemiBoldItalic65pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_SemiBoldItalic65pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_SemiBoldItalic65pt7bGlyphs,
  0x20, 0x7E, 89
};

#endif // _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC65PT7B_H_
