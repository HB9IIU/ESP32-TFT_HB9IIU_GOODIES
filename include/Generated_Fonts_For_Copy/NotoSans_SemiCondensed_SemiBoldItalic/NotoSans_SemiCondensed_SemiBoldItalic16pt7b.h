#ifndef _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC16PT7B_H_
#define _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC16PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-SemiBoldItalic.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_SemiBoldItalic16pt7bBitmaps[] PROGMEM = {
  0x00, 0x39, 0x8C, 0x62, 0x31, 0x80, 0x07, 0x30, 0xDE, 0xA5, 0x60, 0x0D,
  0x84, 0x86, 0xCF, 0xF1, 0x20, 0x93, 0xFF, 0xFE, 0x24, 0x36, 0x12, 0x00,
  0x04, 0x1E, 0x3F, 0x28, 0x38, 0x38, 0x1E, 0x0E, 0x16, 0xD6, 0xFC, 0x10,
  0x20, 0x30, 0x4F, 0x13, 0x66, 0x6D, 0x8D, 0xA1, 0x2F, 0xBF, 0x5A, 0x5B,
  0x1B, 0x66, 0x48, 0x8B, 0x31, 0xC0, 0x04, 0x07, 0xC1, 0x30, 0xCC, 0x16,
  0x07, 0x03, 0xCD, 0xB6, 0xC7, 0xB1, 0xCE, 0xF1, 0xEE, 0xFA, 0x1C, 0x63,
  0x08, 0x61, 0x84, 0x10, 0xC3, 0x04, 0x10, 0x61, 0x80, 0x10, 0xC6, 0x10,
  0x84, 0x63, 0x18, 0xCC, 0x66, 0x23, 0x00, 0x08, 0xB3, 0xE8, 0xF2, 0x8D,
  0x82, 0x00, 0x10, 0x20, 0x40, 0x8F, 0xE2, 0x04, 0x08, 0x36, 0x6C, 0x7F,
  0x80, 0xF8, 0x03, 0x02, 0x06, 0x0C, 0x0C, 0x18, 0x18, 0x30, 0x20, 0x60,
  0xC0, 0x18, 0x79, 0x9B, 0x3C, 0x78, 0xF1, 0xE6, 0x8D, 0x1B, 0x67, 0x80,
  0x3B, 0xF5, 0x63, 0x18, 0xCC, 0x63, 0x18, 0x0C, 0x3E, 0x23, 0x03, 0x03,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xFE, 0xFC, 0x0C, 0x3F, 0x23, 0x03, 0x06,
  0x1E, 0x3C, 0x06, 0x06, 0x06, 0xDC, 0xF8, 0x07, 0x0E, 0x0A, 0x1E, 0x36,
  0x66, 0x44, 0xFF, 0xFE, 0x0C, 0x0C, 0x1F, 0x30, 0x30, 0x30, 0x7C, 0x2E,
  0x06, 0x06, 0x06, 0xDC, 0xF8, 0x06, 0x3C, 0xC3, 0x0C, 0x1F, 0xBB, 0x62,
  0xCD, 0x9B, 0x73, 0xC0, 0x7F, 0x06, 0x04, 0x0C, 0x18, 0x18, 0x30, 0x30,
  0x60, 0x60, 0xC0, 0x0C, 0x1F, 0x33, 0x33, 0x33, 0x1E, 0x3C, 0x66, 0xC6,
  0xC6, 0x6E, 0x7C, 0x0C, 0x3E, 0x33, 0x63, 0x63, 0x67, 0x7E, 0x3E, 0x06,
  0x0C, 0x9C, 0xF8, 0x37, 0x20, 0x00, 0x0E, 0xC0, 0x18, 0xC4, 0x00, 0x00,
  0x06, 0x63, 0x30, 0x02, 0x0C, 0x73, 0x8C, 0x0F, 0x07, 0x81, 0xFF, 0xFC,
  0x07, 0xFF, 0xE0, 0x81, 0x81, 0xC0, 0xE0, 0x67, 0xB8, 0x40, 0x33, 0xF4,
  0xC3, 0x18, 0xE6, 0x18, 0x00, 0x0C, 0x30, 0x1F, 0xC6, 0x0D, 0x81, 0xA7,
  0x9D, 0x93, 0x26, 0x6C, 0x9D, 0x92, 0x9F, 0x90, 0x03, 0x00, 0x3F, 0x80,
  0x07, 0x03, 0x83, 0x41, 0xA1, 0x90, 0xC8, 0xFC, 0x7F, 0x61, 0xB0, 0xF0,
  0x60, 0x1F, 0x18, 0xCC, 0x66, 0x33, 0xF3, 0xF1, 0x8C, 0xC6, 0x63, 0x3F,
  0x3F, 0x00, 0x06, 0x1F, 0x31, 0x60, 0xE0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xFC, 0x7C, 0x1F, 0x19, 0xCC, 0x66, 0x33, 0x1B, 0x0D, 0x86, 0xC7, 0x63,
  0x3F, 0x3F, 0x00, 0x1F, 0x30, 0x30, 0x30, 0x3E, 0x7E, 0x60, 0x60, 0x60,
  0x7C, 0xFC, 0x1F, 0x30, 0x30, 0x30, 0x30, 0x7E, 0x60, 0x60, 0x60, 0x60,
  0xC0, 0x06, 0x0F, 0xCC, 0x4C, 0x0E, 0x06, 0x03, 0x3D, 0x86, 0xC3, 0x61,
  0xBF, 0x8F, 0xC0, 0x18, 0xCC, 0x33, 0x0C, 0xC6, 0x3F, 0x9F, 0xE6, 0x19,
  0x86, 0x63, 0x18, 0xCC, 0x30, 0x1E, 0x18, 0x20, 0xC1, 0x83, 0x06, 0x18,
  0x30, 0x63, 0xE0, 0x06, 0x18, 0x30, 0x60, 0xC1, 0x86, 0x0C, 0x18, 0x30,
  0xC1, 0x8F, 0x1C, 0x00, 0x19, 0xCC, 0xC3, 0x70, 0xD8, 0x3C, 0x1F, 0x07,
  0xC1, 0x98, 0x66, 0x19, 0x8C, 0x70, 0x18, 0xC3, 0x0C, 0x31, 0x86, 0x18,
  0x61, 0xFF, 0xC0, 0x18, 0x39, 0xC3, 0xCF, 0x14, 0x79, 0xE2, 0xCB, 0x36,
  0xD9, 0xB4, 0x8D, 0xEC, 0x6E, 0x62, 0x73, 0x33, 0x18, 0x18, 0x67, 0x08,
  0xF3, 0x1E, 0x62, 0xCC, 0xCD, 0x99, 0xA3, 0x3C, 0x63, 0x88, 0x73, 0x0E,
  0x00, 0x0C, 0x1F, 0x8C, 0xEC, 0x3E, 0x1E, 0x0F, 0x07, 0x83, 0xC3, 0x61,
  0xBF, 0x8F, 0x80, 0x1F, 0x19, 0xCC, 0x66, 0x33, 0x33, 0xF9, 0xF0, 0xC0,
  0x60, 0x30, 0x30, 0x00, 0x0C, 0x1F, 0x8C, 0xEC, 0x3E, 0x1E, 0x0F, 0x07,
  0x83, 0xC3, 0x61, 0xBF, 0x8F, 0x80, 0xC0, 0x60, 0x18, 0x1F, 0x19, 0x8C,
  0x66, 0x63, 0x33, 0xF1, 0xB0, 0xCC, 0x66, 0x33, 0x31, 0xC0, 0x0C, 0x3F,
  0x31, 0x30, 0x30, 0x38, 0x1C, 0x0E, 0x06, 0x06, 0xFC, 0xF8, 0xFF, 0x18,
  0x18, 0x30, 0x30, 0x30, 0x30, 0x30, 0x60, 0x60, 0x60, 0x71, 0xB0, 0xD8,
  0x6C, 0x66, 0x36, 0x1B, 0x0D, 0x8C, 0xC6, 0x7F, 0x1F, 0x00, 0xC3, 0xA1,
  0x91, 0x88, 0xC6, 0x43, 0x61, 0xA0, 0xF0, 0x70, 0x38, 0x1C, 0x00, 0xC3,
  0x1A, 0x38, 0xD1, 0xCC, 0x9E, 0x64, 0xF6, 0x2D, 0xB1, 0x6D, 0x0A, 0x78,
  0x73, 0xC3, 0x1C, 0x18, 0xE0, 0x18, 0xE3, 0x30, 0x2C, 0x07, 0x80, 0xE0,
  0x1C, 0x07, 0x80, 0xF0, 0x33, 0x0C, 0x63, 0x8C, 0x00, 0xE3, 0x66, 0x6C,
  0x6C, 0x78, 0x38, 0x30, 0x30, 0x20, 0x60, 0x60, 0x3F, 0x03, 0x06, 0x0C,
  0x1C, 0x18, 0x30, 0x60, 0x60, 0xFE, 0xFC, 0x3C, 0xC3, 0x08, 0x21, 0x86,
  0x18, 0x41, 0x0C, 0x30, 0xE3, 0x80, 0x9B, 0x6C, 0x92, 0x6D, 0x80, 0x1C,
  0x30, 0xC2, 0x18, 0x61, 0x86, 0x10, 0xC3, 0x0C, 0xE3, 0x80, 0x0C, 0x1C,
  0x14, 0x36, 0x22, 0x62, 0xC3, 0xFC, 0xEC, 0x3A, 0xFF, 0x9E, 0x3C, 0x79,
  0xB3, 0x6E, 0xEC, 0x18, 0x30, 0x30, 0x36, 0x3F, 0x33, 0x63, 0x63, 0x63,
  0x66, 0x6E, 0xDC, 0x3D, 0xFE, 0x30, 0xC3, 0x0C, 0x36, 0x78, 0x03, 0x03,
  0x03, 0x3E, 0x7E, 0xE6, 0xC6, 0xC6, 0xCC, 0xCC, 0xDC, 0xEC, 0x39, 0xFC,
  0x73, 0xFB, 0x0C, 0x32, 0x78, 0x07, 0x83, 0x43, 0x01, 0xE1, 0xF0, 0x60,
  0x30, 0x30, 0x18, 0x0C, 0x06, 0x02, 0x03, 0x01, 0x83, 0xC1, 0xC0, 0x1D,
  0x3F, 0x73, 0x63, 0x63, 0x66, 0x66, 0x6E, 0x76, 0x04, 0x0C, 0xFC, 0x70,
  0x18, 0x30, 0x30, 0x36, 0x3F, 0x33, 0x63, 0x63, 0x66, 0x66, 0x46, 0xC6,
  0x19, 0x80, 0x63, 0x11, 0x8C, 0x63, 0x11, 0x80, 0x06, 0x18, 0x00, 0x60,
  0xC1, 0x86, 0x0C, 0x18, 0x30, 0x41, 0x83, 0x06, 0x38, 0x70, 0x18, 0x18,
  0x0C, 0x06, 0x73, 0x61, 0x71, 0xB0, 0xF0, 0x6C, 0x36, 0x13, 0x18, 0xC0,
  0x19, 0x8C, 0x63, 0x11, 0x8C, 0x63, 0x31, 0x80, 0x36, 0x62, 0xFF, 0x33,
  0x36, 0x33, 0x62, 0x36, 0x63, 0x66, 0x24, 0x66, 0xC6, 0x60, 0x36, 0x2F,
  0x33, 0x63, 0x63, 0x66, 0x66, 0xC6, 0xC6, 0x38, 0xFB, 0x1E, 0x3C, 0x78,
  0xF3, 0x6E, 0x78, 0x1B, 0x0B, 0xC6, 0x66, 0x33, 0x19, 0x8C, 0xCC, 0x6E,
  0x6E, 0x30, 0x18, 0x0C, 0x0C, 0x00, 0x3A, 0xFF, 0x9E, 0x3C, 0x79, 0xB3,
  0x6E, 0xEC, 0x10, 0x60, 0xC1, 0x80, 0x36, 0x58, 0xC3, 0x06, 0x0C, 0x18,
  0x20, 0xC0, 0x3E, 0xF9, 0x83, 0x83, 0x83, 0x83, 0x4C, 0xF8, 0x21, 0x1F,
  0xF6, 0x63, 0x18, 0xC6, 0xB8, 0x66, 0xCD, 0x1E, 0x3C, 0x79, 0xB3, 0x6E,
  0xEC, 0xC7, 0x8B, 0x36, 0x4D, 0x9A, 0x3C, 0x70, 0x60, 0xCC, 0x79, 0x8B,
  0x73, 0x6E, 0x6D, 0x59, 0xEB, 0x39, 0x47, 0x38, 0xC6, 0x00, 0x31, 0x8D,
  0x87, 0x83, 0xC0, 0xC0, 0xE0, 0xD8, 0xCC, 0xE6, 0x00, 0x31, 0x98, 0xCC,
  0xC6, 0x63, 0x61, 0xA0, 0x70, 0x30, 0x18, 0x08, 0x0C, 0x1C, 0x0C, 0x00,
  0x3E, 0xFC, 0x30, 0xC3, 0x06, 0x18, 0x7C, 0xF8, 0x0E, 0x30, 0x60, 0x83,
  0x06, 0x30, 0x30, 0x20, 0xC1, 0x83, 0x07, 0x02, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0x18, 0x30, 0x86, 0x18, 0x60, 0xC6, 0x30, 0xC3, 0x08, 0xE2, 0x00,
  0xE3, 0xFE, 0x30,
};

const GFXglyph NotoSans_SemiCondensed_SemiBoldItalic16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 5, 11, 4, 0, -11 },
  { 8, 5, 4, 7, 2, -11 },
  { 11, 9, 11, 9, 0, -11 },
  { 24, 8, 13, 8, 0, -12 },
  { 37, 11, 12, 12, 1, -12 },
  { 54, 10, 12, 10, 0, -12 },
  { 69, 2, 4, 4, 2, -11 },
  { 70, 6, 14, 5, 0, -11 },
  { 81, 5, 15, 5, -1, -12 },
  { 91, 7, 7, 8, 1, -12 },
  { 98, 7, 8, 8, 1, -10 },
  { 105, 4, 4, 4, -1, -2 },
  { 107, 5, 2, 5, 0, -5 },
  { 109, 3, 2, 4, 0, -2 },
  { 110, 8, 11, 6, -1, -11 },
  { 121, 7, 12, 8, 1, -12 },
  { 132, 5, 11, 8, 2, -11 },
  { 139, 8, 12, 8, 0, -12 },
  { 151, 8, 12, 8, 0, -12 },
  { 163, 8, 11, 8, 0, -11 },
  { 174, 8, 11, 8, 0, -11 },
  { 185, 7, 12, 8, 1, -12 },
  { 196, 8, 11, 8, 1, -11 },
  { 207, 8, 12, 8, 0, -12 },
  { 219, 8, 12, 8, 0, -12 },
  { 231, 4, 9, 4, 0, -9 },
  { 236, 5, 11, 4, -1, -9 },
  { 243, 7, 8, 8, 1, -10 },
  { 250, 7, 5, 8, 1, -8 },
  { 255, 7, 8, 8, 1, -10 },
  { 262, 6, 12, 6, 1, -12 },
  { 271, 11, 12, 12, 1, -11 },
  { 288, 9, 11, 9, -1, -11 },
  { 301, 9, 11, 9, 0, -11 },
  { 314, 8, 12, 9, 1, -12 },
  { 326, 9, 11, 10, 0, -11 },
  { 339, 8, 11, 8, 0, -11 },
  { 350, 8, 11, 7, 0, -11 },
  { 361, 9, 12, 10, 1, -12 },
  { 375, 10, 11, 10, 0, -11 },
  { 389, 7, 11, 5, -1, -11 },
  { 399, 7, 14, 5, -2, -11 },
  { 412, 10, 11, 9, 0, -11 },
  { 426, 6, 11, 7, 0, -11 },
  { 435, 13, 11, 13, 0, -11 },
  { 453, 11, 11, 11, 0, -11 },
  { 469, 9, 12, 10, 1, -12 },
  { 483, 9, 11, 9, 0, -11 },
  { 496, 9, 15, 10, 1, -12 },
  { 513, 9, 11, 9, 0, -11 },
  { 526, 8, 12, 8, 0, -12 },
  { 538, 8, 11, 7, 1, -11 },
  { 549, 9, 11, 10, 1, -11 },
  { 562, 9, 11, 8, 1, -11 },
  { 575, 13, 11, 13, 1, -11 },
  { 593, 11, 11, 8, -1, -11 },
  { 609, 8, 11, 8, 1, -11 },
  { 620, 8, 11, 8, 0, -11 },
  { 631, 6, 14, 5, 0, -11 },
  { 642, 3, 11, 6, 2, -11 },
  { 647, 6, 14, 5, -1, -11 },
  { 658, 8, 7, 8, 0, -11 },
  { 665, 6, 1, 6, -1, 1 },
  { 666, 3, 2, 5, 2, -12 },
  { 667, 7, 9, 9, 1, -9 },
  { 675, 8, 12, 9, 0, -12 },
  { 687, 6, 9, 7, 1, -9 },
  { 694, 8, 12, 9, 1, -12 },
  { 706, 6, 9, 8, 1, -9 },
  { 713, 9, 16, 5, -2, -12 },
  { 731, 8, 13, 9, 0, -9 },
  { 744, 8, 12, 9, 0, -12 },
  { 756, 5, 12, 4, 0, -12 },
  { 764, 7, 16, 4, -2, -12 },
  { 778, 9, 12, 8, 0, -12 },
  { 792, 5, 12, 4, 0, -12 },
  { 800, 12, 9, 13, 0, -9 },
  { 814, 8, 9, 9, 0, -9 },
  { 823, 7, 9, 8, 1, -9 },
  { 831, 9, 13, 9, -1, -9 },
  { 846, 7, 13, 9, 1, -9 },
  { 858, 7, 9, 6, 0, -9 },
  { 866, 7, 9, 7, 0, -9 },
  { 874, 5, 11, 5, 1, -11 },
  { 881, 7, 9, 9, 1, -9 },
  { 889, 7, 9, 7, 1, -9 },
  { 897, 11, 9, 11, 1, -9 },
  { 910, 9, 9, 7, -1, -9 },
  { 921, 9, 13, 7, -1, -9 },
  { 936, 7, 9, 7, 0, -9 },
  { 944, 7, 14, 6, 0, -11 },
  { 957, 2, 16, 8, 3, -12 },
  { 961, 6, 14, 6, -1, -11 },
  { 972, 7, 3, 8, 1, -7 },
};

const GFXfont NotoSans_SemiCondensed_SemiBoldItalic16pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_SemiBoldItalic16pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_SemiBoldItalic16pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC16PT7B_H_
