#ifndef _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC56PT7B_H_
#define _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC56PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-SemiBoldItalic.ttf
// Size: 56pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_SemiBoldItalic56pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0x80, 0x7E, 0x00, 0x30, 0x00, 0x3F, 0x0F, 0xDF, 0xC3, 0xF7, 0xF1,
  0xFD, 0xF8, 0x7E, 0x7E, 0x1F, 0x9F, 0x87, 0xE7, 0xC1, 0xF9, 0xF0, 0x7C,
  0xFC, 0x1F, 0x3F, 0x0F, 0xCF, 0x83, 0xE3, 0xE0, 0xF8, 0xF8, 0x3E, 0x3C,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07,
  0xC0, 0xF8, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x0F,
  0x81, 0xF0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x0F,
  0x03, 0xE0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x1F, 0x03, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x7C,
  0x1F, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0xF8,
  0x1F, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x01, 0xF0,
  0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xC0,
  0xF8, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x0F, 0x81,
  0xF0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x0F, 0x83,
  0xE0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x1F, 0x07,
  0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0xF8, 0xE1, 0xC0, 0x7F,
  0x1C, 0x08, 0x0F, 0xC7, 0x80, 0x01, 0xF8, 0xE0, 0x00, 0x3F, 0x1C, 0x00,
  0x07, 0xE3, 0x80, 0x00, 0xFE, 0x70, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x07, 0x7F, 0x80, 0x01, 0xC7, 0xF0, 0x00, 0x38, 0xFE, 0x00,
  0x07, 0x1F, 0xC0, 0x00, 0xE3, 0xF8, 0x80, 0x3C, 0x7F, 0x1C, 0x07, 0x1F,
  0xC3, 0xF0, 0xE7, 0xF8, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0x80, 0x3F, 0xF0, 0x00, 0x7C, 0x01, 0xFF, 0xE0, 0x03,
  0xF0, 0x0F, 0xFF, 0x80, 0x0F, 0x80, 0x7E, 0x3E, 0x00, 0x7C, 0x01, 0xF0,
  0xFC, 0x03, 0xF0, 0x0F, 0xC3, 0xF0, 0x0F, 0x80, 0x3E, 0x0F, 0xC0, 0x7C,
  0x00, 0xF8, 0x3F, 0x03, 0xF0, 0x07, 0xE0, 0xFC, 0x0F, 0x80, 0x1F, 0x03,
  0xE0, 0x7C, 0x00, 0x7C, 0x0F, 0x83, 0xF0, 0x01, 0xF0, 0x3E, 0x0F, 0x80,
  0x07, 0xC1, 0xF8, 0x7C, 0x00, 0x3F, 0x07, 0xE3, 0xF0, 0x00, 0xFC, 0x1F,
  0x0F, 0x81, 0x03, 0xF0, 0x7C, 0x7C, 0x3F, 0xCF, 0xC3, 0xF3, 0xF3, 0xFF,
  0xBF, 0x1F, 0x8F, 0x9F, 0xFE, 0x7C, 0xFE, 0x7C, 0x7F, 0xFD, 0xFF, 0xF3,
  0xF3, 0xF3, 0xF7, 0xFF, 0x8F, 0x9F, 0x87, 0xCF, 0xFC, 0x7C, 0x7C, 0x1F,
  0x1F, 0xE3, 0xF1, 0xF0, 0x7C, 0x08, 0x0F, 0x8F, 0xC1, 0xF0, 0x00, 0x7C,
  0x3E, 0x07, 0xC0, 0x03, 0xF0, 0xF8, 0x1F, 0x00, 0x0F, 0x87, 0xE0, 0x7C,
  0x00, 0x7C, 0x1F, 0x83, 0xF0, 0x03, 0xF0, 0x7E, 0x0F, 0xC0, 0x0F, 0x81,
  0xF0, 0x3E, 0x00, 0x7C, 0x07, 0xC0, 0xF8, 0x03, 0xF0, 0x1F, 0x07, 0xE0,
  0x0F, 0x80, 0x7C, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0xFC, 0x03, 0xF0, 0x07,
  0xE7, 0xE0, 0x0F, 0x80, 0x0F, 0xFF, 0x80, 0x7C, 0x00, 0x3F, 0xFC, 0x03,
  0xF0, 0x00, 0x7F, 0xE0, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x01, 0xFC, 0x1F, 0xC0, 0x00,
  0xFC, 0x0F, 0xE0, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x3F, 0x03, 0xF0, 0x00,
  0x1F, 0x81, 0xF8, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x07, 0xE1, 0xFC, 0x00,
  0x03, 0xF1, 0xFC, 0x00, 0x01, 0xFD, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x01, 0xF8, 0x3F, 0xFF, 0x80,
  0xFC, 0x3F, 0xFF, 0xC0, 0xFE, 0x1F, 0xC7, 0xF0, 0x7E, 0x1F, 0xC3, 0xFC,
  0x7F, 0x1F, 0xC0, 0xFE, 0x3F, 0x0F, 0xE0, 0x7F, 0xBF, 0x87, 0xE0, 0x1F,
  0xFF, 0x87, 0xF0, 0x07, 0xFF, 0x83, 0xF8, 0x03, 0xFF, 0xC1, 0xFC, 0x00,
  0xFF, 0xC0, 0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0x00, 0x3F, 0xE0, 0x3F, 0xC0,
  0x3F, 0xF0, 0x1F, 0xF0, 0x7F, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x9F, 0xE0, 0x3F, 0xFF, 0x8F, 0xF0, 0x07,
  0xFF, 0x03, 0xFC, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3F, 0x3F, 0x7F, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0xFC, 0xF8, 0xF8, 0xF8, 0xF8, 0x00, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0,
  0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x20, 0x1F, 0x00, 0x38, 0x1E,
  0x00, 0x7C, 0x3E, 0x00, 0x7F, 0x3E, 0x00, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFE,
  0x3F, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xCF, 0x80, 0x3F, 0x8F,
  0x80, 0x7F, 0x8F, 0xC0, 0x3F, 0x0F, 0xC0, 0x1E, 0x07, 0xE0, 0x06, 0x07,
  0xE0, 0x04, 0x07, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x7F, 0x07,
  0xF0, 0x7E, 0x0F, 0xE0, 0xFC, 0x1F, 0xC1, 0xF8, 0x1F, 0x83, 0xF0, 0x3F,
  0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0x7F, 0xFE, 0xFF, 0xF9, 0xFF, 0xF3, 0xFF,
  0xEF, 0xFF, 0xDF, 0xFF, 0x80, 0x1C, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFC, 0x30, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF,
  0xE0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x3F,
  0xC7, 0xF8, 0x1F, 0xE0, 0xFE, 0x07, 0xF0, 0x1F, 0x83, 0xF8, 0x07, 0xF0,
  0xFE, 0x01, 0xFC, 0x7F, 0x00, 0x7F, 0x1F, 0xC0, 0x1F, 0xC7, 0xF0, 0x07,
  0xF3, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0x9F, 0xC0,
  0x07, 0xE7, 0xF0, 0x01, 0xF9, 0xFC, 0x00, 0xFE, 0x7F, 0x00, 0x3F, 0x9F,
  0x80, 0x0F, 0xEF, 0xE0, 0x03, 0xFB, 0xF8, 0x00, 0xFC, 0xFE, 0x00, 0x7F,
  0x3F, 0x80, 0x1F, 0xCF, 0xE0, 0x07, 0xF3, 0xF8, 0x03, 0xF8, 0xFC, 0x00,
  0xFE, 0x3F, 0x00, 0x3F, 0x8F, 0xC0, 0x1F, 0xC3, 0xF8, 0x07, 0xF0, 0xFE,
  0x03, 0xF8, 0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0x7F, 0x01, 0xFE, 0x7F, 0xC0,
  0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x0F, 0xFF, 0x83, 0xFF,
  0xE0, 0xFF, 0xFC, 0x7F, 0xDF, 0x9F, 0xF7, 0xF1, 0xFC, 0xFE, 0x3E, 0x1F,
  0x83, 0x83, 0xF0, 0x20, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFC, 0x7F, 0xC0, 0x1F, 0x00, 0xFE,
  0x00, 0x70, 0x07, 0xF0, 0x02, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x1F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0xFC, 0x3F,
  0xE0, 0x0E, 0x00, 0xFF, 0x00, 0x40, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x08, 0x00, 0x0F, 0xF0, 0xC0,
  0x01, 0xFE, 0x0F, 0xC0, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x1D, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x1F, 0xBF, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x0F, 0xDF, 0x80, 0x00,
  0xFC, 0xFC, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x7C, 0x7F, 0x00, 0x07, 0xE3,
  0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x0F, 0xE0,
  0x03, 0xF0, 0x7F, 0x00, 0x3F, 0x03, 0xF0, 0x03, 0xF0, 0x1F, 0x80, 0x3F,
  0x01, 0xFC, 0x01, 0xF8, 0x0F, 0xE0, 0x1F, 0x80, 0x7F, 0x01, 0xF8, 0x03,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x90, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0x80, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x80, 0x01, 0xFE, 0x18, 0x00, 0xFF, 0x83, 0xE0,
  0x7F, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xF0, 0x10, 0x0F,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFC, 0x1E, 0x00, 0x3F, 0x9F, 0xF0, 0x07, 0xF7, 0xFF, 0x80,
  0xFD, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xC1,
  0xFE, 0x1F, 0xF0, 0x1F, 0xC3, 0xFC, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x1F,
  0xE0, 0x0F, 0xE3, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x8F, 0xE0, 0x07,
  0xF1, 0xFC, 0x00, 0xFC, 0x3F, 0x80, 0x3F, 0x87, 0xF0, 0x07, 0xF0, 0xFE,
  0x00, 0xFE, 0x0F, 0xC0, 0x3F, 0x81, 0xFC, 0x0F, 0xF0, 0x3F, 0xC3, 0xFC,
  0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0x7F,
  0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xC0, 0xFF, 0x07, 0xF8, 0x1F, 0xC0, 0x7F, 0x03, 0xF0, 0x07, 0xE0,
  0x7E, 0x00, 0xFC, 0x1F, 0xC0, 0x1F, 0x83, 0xF8, 0x03, 0xF0, 0x7F, 0x00,
  0xFE, 0x07, 0xE0, 0x1F, 0x80, 0xFE, 0x07, 0xF0, 0x1F, 0xC1, 0xFC, 0x01,
  0xFC, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xF8,
  0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x7F,
  0x9F, 0xE0, 0x1F, 0xE1, 0xFE, 0x07, 0xF0, 0x1F, 0xC1, 0xFC, 0x01, 0xFC,
  0x3F, 0x80, 0x3F, 0x87, 0xE0, 0x03, 0xF1, 0xFC, 0x00, 0x7E, 0x3F, 0x80,
  0x0F, 0xC7, 0xF0, 0x01, 0xF8, 0xFE, 0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xE3,
  0xFC, 0x03, 0xF8, 0x3F, 0xC0, 0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x0A, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFF,
  0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x3F, 0xE3,
  0xFC, 0x1F, 0xC0, 0x7F, 0x1F, 0xC0, 0x3F, 0x8F, 0xE0, 0x1F, 0xC7, 0xE0,
  0x07, 0xE7, 0xF0, 0x03, 0xF3, 0xF8, 0x01, 0xF9, 0xFC, 0x00, 0xFC, 0xFC,
  0x00, 0xFE, 0x7E, 0x00, 0x7F, 0x3F, 0x00, 0x3F, 0x9F, 0x80, 0x3F, 0xCF,
  0xE0, 0x1F, 0xE7, 0xF0, 0x1F, 0xF3, 0xFC, 0x1F, 0xF1, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0x7F, 0x03, 0xFE, 0x3F,
  0x00, 0x1C, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF8, 0x18, 0x1F, 0xF8, 0x0F, 0xFF, 0xF8, 0x07, 0xFF,
  0xF8, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x07, 0xE0, 0x3F, 0xC0, 0xFF, 0x07, 0xFC,
  0x1F, 0xE0, 0x7F, 0x80, 0xFC, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x3F, 0x01, 0xFE,
  0x07, 0xF8, 0x3F, 0xE0, 0xFF, 0x01, 0xFC, 0x07, 0xE0, 0x06, 0x00, 0x00,
  0x1E, 0x00, 0x1F, 0x80, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF8, 0x07, 0xF8,
  0x03, 0xFC, 0x00, 0xFC, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F,
  0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0,
  0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF0,
  0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x03, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x1F, 0xFC, 0x03,
  0xFF, 0xF8, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x7C, 0x1F,
  0xE3, 0x80, 0x7F, 0x10, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x0F,
  0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0x7E, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xF8, 0x0F, 0xF8, 0x00, 0x3F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x07, 0xC0, 0x1F, 0xF8, 0x1F, 0x0F, 0x80, 0x7F,
  0xFE, 0x1F, 0x0F, 0x80, 0xFF, 0xFC, 0x1F, 0x1F, 0x01, 0xFF, 0xFC, 0x1F,
  0x1F, 0x03, 0xF0, 0x7C, 0x0F, 0x3E, 0x07, 0xE0, 0x7C, 0x1F, 0x3E, 0x0F,
  0xC0, 0xF8, 0x1F, 0x3E, 0x0F, 0x80, 0xF8, 0x1F, 0x7C, 0x1F, 0x80, 0xF8,
  0x1F, 0x7C, 0x1F, 0x00, 0xF8, 0x1F, 0x7C, 0x1F, 0x01, 0xF0, 0x1F, 0x7C,
  0x1F, 0x01, 0xF0, 0x3E, 0xF8, 0x3E, 0x01, 0xF0, 0x3E, 0xF8, 0x3E, 0x03,
  0xF0, 0x3E, 0xF8, 0x3E, 0x03, 0xE0, 0x7C, 0xF8, 0x3E, 0x03, 0xE0, 0x7C,
  0xF8, 0x3E, 0x07, 0xE0, 0xF8, 0xF8, 0x3E, 0x0F, 0xE1, 0xF8, 0xF8, 0x3F,
  0x1F, 0xF3, 0xF0, 0xF8, 0x1F, 0xFD, 0xFF, 0xE0, 0xF8, 0x1F, 0xFC, 0xFF,
  0xC0, 0x7C, 0x0F, 0xF8, 0xFF, 0x80, 0x7C, 0x07, 0xE0, 0x3E, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x10, 0x00,
  0x0F, 0xF0, 0x00, 0x70, 0x00, 0x07, 0xFF, 0x9F, 0xF0, 0x00, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3E, 0xFC,
  0x00, 0x01, 0xFB, 0xF0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x3F, 0x3F, 0x00,
  0x00, 0xFC, 0xFC, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x1F, 0x8F, 0xC0, 0x00,
  0xFC, 0x3F, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x7E,
  0x07, 0xE0, 0x03, 0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0x7E, 0x00, 0x7F, 0x01,
  0xF8, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xC0, 0x07, 0xF0, 0xFE,
  0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7F, 0x1F, 0xC0, 0x01, 0xFC, 0x7F, 0x00,
  0x07, 0xF3, 0xF8, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x7F, 0x7F, 0x00, 0x01,
  0xFD, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F,
  0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F,
  0xC0, 0x7F, 0xC0, 0x7F, 0x00, 0xFF, 0x01, 0xF8, 0x01, 0xFC, 0x0F, 0xE0,
  0x07, 0xF0, 0x3F, 0x80, 0x1F, 0xC0, 0xFE, 0x00, 0x7F, 0x03, 0xF8, 0x03,
  0xF8, 0x0F, 0xC0, 0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0x01, 0xFC, 0x03, 0xFC,
  0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFC,
  0x03, 0xFC, 0x03, 0xF0, 0x07, 0xF0, 0x1F, 0xC0, 0x0F, 0xE0, 0x7F, 0x00,
  0x3F, 0x81, 0xFC, 0x00, 0xFE, 0x07, 0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x0F,
  0xE0, 0xFE, 0x00, 0x3F, 0x83, 0xF8, 0x01, 0xFE, 0x0F, 0xE0, 0x07, 0xF0,
  0x3F, 0x00, 0x3F, 0xC1, 0xFC, 0x03, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFE, 0x3F, 0x00, 0xFF, 0xC0, 0x1C,
  0x07, 0xFC, 0x00, 0x20, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0xC0, 0x0F, 0xFE, 0x3F, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFC, 0x0F, 0xFC,
  0x01, 0xFC, 0x03, 0xFE, 0x01, 0xFC, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0xFE,
  0x03, 0xF8, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x7F,
  0x03, 0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x7F,
  0x07, 0xF0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0xFF,
  0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFE,
  0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xC0, 0x01, 0xFE, 0x1F, 0xC0, 0x01, 0xFC,
  0x1F, 0xC0, 0x03, 0xFC, 0x1F, 0xC0, 0x03, 0xFC, 0x1F, 0xC0, 0x07, 0xF8,
  0x3F, 0x80, 0x07, 0xF8, 0x3F, 0x80, 0x0F, 0xF0, 0x3F, 0x80, 0x1F, 0xF0,
  0x3F, 0x80, 0x3F, 0xE0, 0x3F, 0x80, 0x7F, 0xC0, 0x7F, 0x01, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xF3, 0xFC, 0x03, 0xFF, 0x00, 0x1C,
  0x03, 0xFE, 0x00, 0x04, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0xFF, 0xFC,
  0x7F, 0x00, 0xFF, 0xF8, 0xFF, 0x00, 0xFF, 0xF8, 0xFE, 0x00, 0xFF, 0xF8,
  0xFE, 0x00, 0xFF, 0xF8, 0xFE, 0x01, 0xFF, 0xF0, 0xFE, 0x00, 0x07, 0xF0,
  0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x07, 0xF0,
  0xFE, 0x00, 0x07, 0xE0, 0xFF, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x0F, 0xE0,
  0x7F, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x0F, 0xE0, 0x7F, 0xC0, 0x1F, 0xC0,
  0x3F, 0xF8, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x01,
  0xFC, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x0F, 0xC0,
  0x01, 0xFC, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x07, 0xF0, 0x0F,
  0xE0, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x07, 0xF0,
  0x0F, 0xE0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0x07,
  0xF0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x3F, 0x80,
  0x03, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x0F,
  0xE0, 0x1F, 0xC0, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x0F, 0xE0, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x7F,
  0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x3F, 0x80, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x3F, 0x80, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0xFC, 0x00,
  0x1F, 0xC0, 0x3F, 0x80, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0x3F, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x7F,
  0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x3F, 0xC0, 0x3F, 0x80, 0x1F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x03, 0xF0,
  0x03, 0xF8, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x1F,
  0xC0, 0x7F, 0x80, 0x07, 0xF0, 0x3F, 0xC0, 0x01, 0xF8, 0x1F, 0xE0, 0x00,
  0x7E, 0x07, 0xF0, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x0F, 0xE1, 0xFE, 0x00,
  0x03, 0xF8, 0xFF, 0x00, 0x00, 0xFC, 0x7F, 0x80, 0x00, 0x3F, 0x1F, 0xC0,
  0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xCF, 0xE0, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x01,
  0xFC, 0x3F, 0xC0, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x1F, 0x81, 0xFC, 0x00,
  0x0F, 0xE0, 0x7F, 0x80, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0xFE, 0x03, 0xF8,
  0x00, 0x3F, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x07, 0xF0, 0x07,
  0xF0, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x80,
  0x0F, 0xE0, 0x0F, 0xE0, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xF0, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x1F,
  0xFC, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x3F, 0x7C,
  0x00, 0x3F, 0xFC, 0x03, 0xF7, 0xC0, 0x03, 0xEF, 0xC0, 0x3F, 0x7C, 0x00,
  0x7E, 0xFC, 0x03, 0xF7, 0xC0, 0x07, 0xDF, 0xC0, 0x3F, 0x7C, 0x00, 0xFD,
  0xF8, 0x07, 0xF7, 0xE0, 0x0F, 0x9F, 0x80, 0x7E, 0x7E, 0x01, 0xF9, 0xF8,
  0x07, 0xE7, 0xE0, 0x1F, 0x3F, 0x80, 0x7E, 0x7E, 0x03, 0xF3, 0xF8, 0x07,
  0xE7, 0xE0, 0x3E, 0x3F, 0x00, 0xFE, 0x7E, 0x07, 0xE3, 0xF0, 0x0F, 0xC7,
  0xE0, 0x7C, 0x3F, 0x00, 0xFC, 0x7E, 0x0F, 0xC7, 0xF0, 0x0F, 0xC3, 0xE0,
  0xF8, 0x7F, 0x00, 0xFC, 0x3E, 0x1F, 0x87, 0xE0, 0x1F, 0xC3, 0xE1, 0xF0,
  0x7E, 0x01, 0xF8, 0x3E, 0x3F, 0x07, 0xE0, 0x1F, 0x83, 0xE3, 0xE0, 0xFE,
  0x01, 0xF8, 0x3E, 0x7E, 0x0F, 0xE0, 0x3F, 0x83, 0xE7, 0xC0, 0xFC, 0x03,
  0xF8, 0x3E, 0xFC, 0x0F, 0xC0, 0x3F, 0x03, 0xFF, 0x80, 0xFC, 0x03, 0xF0,
  0x3F, 0xF8, 0x1F, 0xC0, 0x3F, 0x03, 0xFF, 0x01, 0xF8, 0x07, 0xF0, 0x3F,
  0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xFE, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0xE0,
  0x3F, 0x80, 0x7E, 0x03, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x3F,
  0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x00, 0xFF, 0x00, 0x01, 0xF8, 0x07, 0xFC, 0x00, 0x1F, 0xC0, 0x3F, 0xE0,
  0x00, 0xFE, 0x01, 0xFF, 0x00, 0x07, 0xE0, 0x0F, 0xF8, 0x00, 0x3F, 0x00,
  0xFF, 0xE0, 0x01, 0xF8, 0x07, 0xFF, 0x00, 0x1F, 0xC0, 0x3F, 0xF8, 0x00,
  0xFE, 0x01, 0xFF, 0xE0, 0x07, 0xE0, 0x1F, 0xBF, 0x00, 0x3F, 0x00, 0xFD,
  0xF8, 0x01, 0xF8, 0x07, 0xEF, 0xC0, 0x1F, 0xC0, 0x3F, 0x7F, 0x00, 0xFC,
  0x01, 0xF9, 0xF8, 0x07, 0xE0, 0x1F, 0xCF, 0xC0, 0x3F, 0x00, 0xFC, 0x7F,
  0x01, 0xF8, 0x07, 0xE3, 0xF8, 0x1F, 0xC0, 0x3F, 0x0F, 0xC0, 0xFC, 0x01,
  0xF8, 0x7E, 0x07, 0xE0, 0x1F, 0xC3, 0xF8, 0x3F, 0x00, 0xFC, 0x0F, 0xC3,
  0xF8, 0x07, 0xE0, 0x7E, 0x1F, 0xC0, 0x3F, 0x03, 0xF8, 0xFC, 0x01, 0xF8,
  0x1F, 0xC7, 0xE0, 0x1F, 0xC0, 0x7E, 0x3F, 0x00, 0xFC, 0x03, 0xF1, 0xF8,
  0x07, 0xE0, 0x1F, 0xDF, 0x80, 0x3F, 0x00, 0x7E, 0xFC, 0x03, 0xF8, 0x03,
  0xF7, 0xE0, 0x1F, 0xC0, 0x1F, 0xBF, 0x00, 0xFC, 0x00, 0xFF, 0xF8, 0x07,
  0xE0, 0x03, 0xFF, 0x80, 0x3F, 0x00, 0x1F, 0xFC, 0x03, 0xF8, 0x00, 0xFF,
  0xE0, 0x1F, 0x80, 0x03, 0xFF, 0x00, 0xFC, 0x00, 0x1F, 0xF8, 0x07, 0xE0,
  0x00, 0xFF, 0x80, 0x3F, 0x00, 0x07, 0xFC, 0x03, 0xF8, 0x00, 0x1F, 0xE0,
  0x1F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xCF, 0xFE, 0x03, 0xFE, 0x01,
  0xFE, 0x07, 0xFC, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0xFF, 0x0F, 0xF0, 0x00,
  0x7F, 0x0F, 0xE0, 0x00, 0x7F, 0x1F, 0xE0, 0x00, 0x7F, 0x1F, 0xC0, 0x00,
  0x7F, 0x3F, 0xC0, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x7F, 0x3F, 0x80, 0x00,
  0x7F, 0x7F, 0x80, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00,
  0x7F, 0x7F, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0xFE, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x01,
  0xFE, 0xFE, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x03,
  0xFC, 0xFE, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x0F,
  0xF0, 0x7F, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x1F, 0xE0, 0x7F, 0xC0, 0x7F,
  0xC0, 0x3F, 0xF9, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xC0, 0x7F, 0x80, 0x7F, 0x00, 0xFF, 0x01,
  0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0x80, 0x1F, 0xC0, 0xFE,
  0x00, 0x7F, 0x03, 0xF8, 0x01, 0xFC, 0x0F, 0xC0, 0x07, 0xF0, 0x7F, 0x00,
  0x3F, 0x81, 0xFC, 0x00, 0xFE, 0x07, 0xF0, 0x07, 0xF8, 0x1F, 0xC0, 0x3F,
  0xC0, 0x7E, 0x01, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xCF, 0xFE, 0x03, 0xFE, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0xFE, 0x07,
  0xF8, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7F, 0x1F,
  0xE0, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x7F, 0x3F,
  0x80, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0x7F, 0x7F,
  0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFE, 0xFE,
  0x00, 0x00, 0xFE, 0xFE, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x01, 0xFC, 0xFE,
  0x00, 0x01, 0xFC, 0xFE, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x03, 0xF8, 0xFE,
  0x00, 0x07, 0xF8, 0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x0F, 0xF0, 0x7F,
  0x80, 0x1F, 0xE0, 0x7F, 0xC0, 0x7F, 0xC0, 0x3F, 0xFB, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xF0, 0x3F,
  0xE0, 0x3F, 0x80, 0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0xC0,
  0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x07, 0xF0, 0x3F, 0x80, 0x3F, 0x81, 0xF8,
  0x01, 0xFC, 0x1F, 0xC0, 0x1F, 0xC0, 0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x0F,
  0xF0, 0x3F, 0x80, 0xFF, 0x01, 0xF8, 0x3F, 0xF0, 0x1F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0xFE, 0x0F, 0xC0, 0x07, 0xF0, 0x7F,
  0x00, 0x3F, 0x83, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0xC0, 0x7F, 0x00,
  0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x00, 0x7F, 0x03, 0xF8,
  0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0xC0, 0xFE, 0x00, 0xFF, 0x07, 0xF0, 0x03,
  0xF8, 0x3F, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0xFF, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xDF,
  0xC0, 0x3F, 0xE0, 0x1C, 0x03, 0xFC, 0x00, 0x40, 0x3F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x04, 0x00, 0x1F, 0xE0, 0x70,
  0x03, 0xFC, 0x0F, 0xFB, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x3F, 0x80, 0xFE, 0x00,
  0x1F, 0xC0, 0xFE, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x07, 0xF0, 0x3F, 0x80,
  0x03, 0xF0, 0x1F, 0xC0, 0x03, 0xF8, 0x0F, 0xC0, 0x01, 0xFC, 0x0F, 0xE0,
  0x00, 0xFE, 0x07, 0xF0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x7F, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0xFC, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F, 0xE0, 0x7F,
  0x00, 0x07, 0xF0, 0x3F, 0x80, 0x07, 0xF0, 0x1F, 0xC0, 0x03, 0xF8, 0x1F,
  0xC0, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x7E, 0x03,
  0xF8, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x1F, 0xC0,
  0xFE, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x07, 0xF0,
  0x1F, 0x80, 0x03, 0xF8, 0x1F, 0xC0, 0x01, 0xFC, 0x0F, 0xE0, 0x01, 0xFC,
  0x07, 0xF0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x7F, 0xC0, 0x1F, 0xFD, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x14,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80,
  0x01, 0xFD, 0xFC, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFE, 0x7F, 0x00, 0x07,
  0xF3, 0xF8, 0x00, 0x7F, 0x0F, 0xC0, 0x03, 0xF8, 0x7E, 0x00, 0x3F, 0x83,
  0xF0, 0x01, 0xFC, 0x1F, 0x80, 0x1F, 0xC0, 0xFC, 0x00, 0xFE, 0x07, 0xE0,
  0x07, 0xE0, 0x3F, 0x00, 0x7F, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x80, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x1F, 0xC0, 0x1F, 0x80, 0xFC, 0x00,
  0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x87, 0xF0, 0x01, 0xFC,
  0x3F, 0x80, 0x07, 0xE3, 0xF8, 0x00, 0x3F, 0x1F, 0xC0, 0x01, 0xF9, 0xFC,
  0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x03, 0xF7, 0xF0, 0x00,
  0x1F, 0xBF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F,
  0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xF0, 0x01, 0xFD, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xEF, 0xE0, 0x03, 0xFC, 0x00, 0xFE, 0x7F, 0x00, 0x3F, 0xE0,
  0x07, 0xF3, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0x1F, 0xC0, 0x1F, 0xF8, 0x03,
  0xF8, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xC7, 0xF0, 0x07, 0xFE, 0x01, 0xFC,
  0x3F, 0x80, 0x7F, 0xF0, 0x0F, 0xE1, 0xFC, 0x03, 0xFF, 0x80, 0x7E, 0x0F,
  0xE0, 0x3F, 0xFC, 0x07, 0xF0, 0x7F, 0x01, 0xF7, 0xE0, 0x3F, 0x03, 0xF8,
  0x1F, 0xBF, 0x03, 0xF8, 0x1F, 0xC0, 0xFD, 0xF8, 0x1F, 0xC0, 0xFE, 0x0F,
  0xCF, 0xC0, 0xFC, 0x07, 0xF0, 0x7E, 0x7E, 0x0F, 0xE0, 0x3F, 0x83, 0xE3,
  0xF0, 0x7E, 0x01, 0xFC, 0x3F, 0x1F, 0x87, 0xF0, 0x07, 0xE1, 0xF8, 0xFC,
  0x3F, 0x00, 0x3F, 0x1F, 0x87, 0xE3, 0xF8, 0x01, 0xF8, 0xFC, 0x3F, 0x1F,
  0xC0, 0x0F, 0xCF, 0xC1, 0xF8, 0xFC, 0x00, 0x7E, 0x7E, 0x0F, 0xCF, 0xE0,
  0x03, 0xF3, 0xE0, 0x7E, 0x7E, 0x00, 0x1F, 0xBF, 0x03, 0xF3, 0xF0, 0x00,
  0xFD, 0xF8, 0x1F, 0xBF, 0x00, 0x07, 0xDF, 0x80, 0xFD, 0xF8, 0x00, 0x3E,
  0xFC, 0x07, 0xFF, 0xC0, 0x01, 0xF7, 0xC0, 0x1F, 0xFC, 0x00, 0x0F, 0xFE,
  0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x1F, 0xE0, 0x03, 0xF8, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x3F, 0x80,
  0x01, 0xF8, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x01, 0xFC, 0x0F,
  0xE0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x0F,
  0xE3, 0xF8, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x07, 0xE7, 0xF0, 0x00,
  0x00, 0x7E, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x00, 0x7F,
  0x3F, 0x80, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00,
  0x1F, 0xC1, 0xFC, 0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x00, 0x3F, 0x81, 0xFC,
  0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFE, 0x7E, 0x00, 0x1F, 0xC7,
  0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x87, 0xF0, 0x07, 0xF0, 0x7F, 0x00,
  0xFE, 0x03, 0xF0, 0x0F, 0xE0, 0x3F, 0x01, 0xFC, 0x03, 0xF8, 0x1F, 0xC0,
  0x3F, 0x83, 0xF8, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0x87, 0xF0, 0x01, 0xF8,
  0xFE, 0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xFD, 0xFC, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xFE,
  0x00, 0x7F, 0xF8, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x7C, 0x07,
  0xC0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x03, 0xE0, 0x3E, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x1F, 0x01, 0xF8, 0x1F, 0x81,
  0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x80, 0xF8, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x07, 0xC0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x3F, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7E, 0xF8,
  0x00, 0x1F, 0x3E, 0x00, 0x0F, 0xCF, 0xC0, 0x03, 0xE1, 0xF0, 0x01, 0xF8,
  0x7C, 0x00, 0xFC, 0x1F, 0x80, 0x3E, 0x03, 0xE0, 0x1F, 0x80, 0xF8, 0x07,
  0xC0, 0x3F, 0x03, 0xF0, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x7E, 0x00, 0x7E,
  0x3F, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xE7, 0xE0, 0x00, 0xFD, 0xF0, 0x00,
  0x1F, 0xFC, 0x00, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x1F, 0xC7, 0xF0, 0xFC, 0x3F, 0x87, 0xE0,
  0xFC, 0x1F, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xF8, 0x7C, 0x07,
  0xFF, 0x9F, 0x81, 0xFF, 0xFB, 0xF0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0x83, 0xFC, 0x1F, 0xF0, 0xFF, 0x01, 0xFE, 0x1F, 0xC0, 0x3F, 0xC7, 0xF8,
  0x07, 0xF8, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xC7, 0xF0, 0x03, 0xF8,
  0xFE, 0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xC3, 0xF8, 0x01, 0xF8, 0xFE, 0x00,
  0x7F, 0x1F, 0xC0, 0x0F, 0xE3, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x0F,
  0xE0, 0x0F, 0xE1, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x87, 0xF0, 0x1F,
  0xF0, 0xFF, 0x07, 0xFC, 0x1F, 0xF1, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0x7E, 0x03, 0xFF, 0xCF, 0x80, 0x7F, 0xF1, 0xF0, 0x03, 0xFC, 0x3E,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x87, 0xC0,
  0x07, 0xE3, 0xFE, 0x00, 0xFC, 0xFF, 0xE0, 0x3F, 0xBF, 0xFE, 0x07, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xF0, 0x7F, 0x83, 0xFC, 0x07, 0xF0,
  0xFF, 0x00, 0xFE, 0x1F, 0xE0, 0x1F, 0xC3, 0xF8, 0x03, 0xF8, 0x7F, 0x00,
  0x7F, 0x0F, 0xC0, 0x0F, 0xE3, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x8F,
  0xC0, 0x07, 0xE1, 0xF8, 0x01, 0xFC, 0x3F, 0x00, 0x3F, 0x8F, 0xE0, 0x07,
  0xF1, 0xFC, 0x00, 0xFC, 0x3F, 0x80, 0x3F, 0x87, 0xF0, 0x07, 0xF1, 0xFE,
  0x01, 0xFC, 0x3F, 0xC0, 0x7F, 0x87, 0xF8, 0x0F, 0xE0, 0xFF, 0x87, 0xFC,
  0x1F, 0xFF, 0xFF, 0x07, 0xEF, 0xFF, 0xC0, 0xFD, 0xFF, 0xF0, 0x1F, 0x1F,
  0xFC, 0x03, 0xE1, 0xFF, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x03, 0xFC, 0x06, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x40, 0xFF, 0x07, 0x81,
  0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x01,
  0xFF, 0xC0, 0x00, 0x50, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x1F, 0x07, 0xE0, 0x01, 0xFF, 0x1F, 0x80, 0x1F, 0xFE,
  0x7E, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0x00, 0xFF, 0x07, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0xC0,
  0xFF, 0x00, 0xFE, 0x03, 0xF8, 0x03, 0xF8, 0x0F, 0xE0, 0x0F, 0xE0, 0x7F,
  0x00, 0x3F, 0x81, 0xFC, 0x00, 0xFE, 0x07, 0xF0, 0x03, 0xF0, 0x1F, 0x80,
  0x0F, 0xC0, 0xFE, 0x00, 0x3F, 0x03, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x07,
  0xF0, 0x3F, 0x80, 0x1F, 0x80, 0xFE, 0x00, 0xFE, 0x03, 0xF8, 0x03, 0xF8,
  0x0F, 0xE0, 0x1F, 0xE0, 0x3F, 0x80, 0xFF, 0x80, 0xFE, 0x03, 0xFC, 0x03,
  0xFC, 0x3F, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xBF, 0x00, 0x3F,
  0xFC, 0xF8, 0x00, 0x7F, 0xE3, 0xE0, 0x00, 0xFF, 0x0F, 0x80, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xFC, 0x01,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x07, 0xF8, 0x7F, 0x0F, 0xF0, 0x3F, 0x1F,
  0xE0, 0x3F, 0x1F, 0xC0, 0x3F, 0x3F, 0x80, 0x3F, 0x3F, 0x80, 0x7F, 0x3F,
  0x00, 0xFE, 0x7F, 0x01, 0xFE, 0x7F, 0x7F, 0xFC, 0x7F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x10, 0x7F, 0x80, 0x70, 0x7F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x08, 0xFF, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xFF, 0x87, 0xC0, 0x1F, 0xFE, 0x7E, 0x01, 0xFF, 0xFB, 0xF0, 0x1F,
  0xFF, 0xDF, 0x80, 0xFF, 0xFF, 0xF8, 0x0F, 0xF0, 0x7F, 0xC0, 0xFF, 0x01,
  0xFE, 0x07, 0xF0, 0x0F, 0xF0, 0x7F, 0x80, 0x7F, 0x83, 0xF8, 0x03, 0xF8,
  0x1F, 0xC0, 0x1F, 0xC1, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0x7F,
  0x00, 0x3F, 0x03, 0xF8, 0x01, 0xF8, 0x3F, 0x80, 0x1F, 0xC1, 0xFC, 0x00,
  0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x03, 0xF8, 0x03, 0xF8,
  0x1F, 0xC0, 0x3F, 0xC0, 0xFE, 0x01, 0xFE, 0x07, 0xF0, 0x1F, 0xF0, 0x3F,
  0xC1, 0xFF, 0x01, 0xFF, 0x1F, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFE, 0x00, 0xFF, 0xF7, 0xE0, 0x07, 0xFF, 0x3F, 0x00, 0x0F, 0xE3, 0xF8,
  0x00, 0x08, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x60, 0x03,
  0xFC, 0x03, 0xE0, 0x3F, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x87, 0xC0, 0x07, 0xE3, 0xFE, 0x00,
  0xFC, 0xFF, 0xE0, 0x3F, 0xBF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFC, 0x1F, 0xF8, 0x7F, 0x83, 0xFC, 0x07, 0xF0, 0xFF, 0x80, 0xFE, 0x1F,
  0xE0, 0x1F, 0xC3, 0xF8, 0x03, 0xF8, 0x7F, 0x00, 0x7E, 0x0F, 0xE0, 0x0F,
  0xC3, 0xF8, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xE1, 0xF8,
  0x01, 0xF8, 0x3F, 0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xE1, 0xFC, 0x01, 0xFC,
  0x3F, 0x80, 0x3F, 0x07, 0xE0, 0x07, 0xE1, 0xFC, 0x01, 0xFC, 0x3F, 0x80,
  0x3F, 0x87, 0xF0, 0x07, 0xF0, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x87,
  0xF0, 0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xC3, 0xF0, 0x03,
  0xF0, 0x00, 0x00, 0x7C, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x1F, 0x80, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x7E, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x01, 0x1F, 0xE0, 0x03, 0xFF, 0xC0, 0x07,
  0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x81,
  0xFC, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x07, 0xF0,
  0x3F, 0x80, 0x3F, 0x83, 0xF8, 0x01, 0xF8, 0x3F, 0xC0, 0x0F, 0xC3, 0xFC,
  0x00, 0xFE, 0x3F, 0xC0, 0x07, 0xF1, 0xFC, 0x00, 0x3F, 0x1F, 0xC0, 0x01,
  0xF9, 0xFC, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0xFF, 0xBF, 0x80, 0x07, 0xF9, 0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x01,
  0xF8, 0x3F, 0x80, 0x1F, 0xC1, 0xFC, 0x00, 0xFE, 0x0F, 0xF0, 0x07, 0xF0,
  0x3F, 0x80, 0x3F, 0x01, 0xFC, 0x01, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F,
  0x80, 0xFE, 0x01, 0xFC, 0x07, 0xF0, 0x07, 0xF0, 0x3F, 0x00, 0x3F, 0x80,
  0x00, 0x7E, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7E, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0xF8, 0x00, 0xF8, 0x7F, 0xC0, 0xFF, 0x80, 0x3E, 0x3F, 0xF8, 0x7F,
  0xF0, 0x1F, 0x9F, 0xFE, 0x3F, 0xFE, 0x07, 0xEF, 0xFF, 0xDF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xC1, 0xFF, 0xC3, 0xFC, 0x1F, 0xE0,
  0x7F, 0xE0, 0x7F, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xC3, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0xFE, 0x01, 0xFE, 0x01, 0xF8, 0x3F, 0x80, 0x7F, 0x00, 0x7E,
  0x0F, 0xC0, 0x1F, 0xC0, 0x3F, 0x87, 0xF0, 0x07, 0xF0, 0x0F, 0xE1, 0xFC,
  0x01, 0xF8, 0x03, 0xF8, 0x7F, 0x00, 0xFE, 0x00, 0xFC, 0x1F, 0x80, 0x3F,
  0x80, 0x3F, 0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0xC3, 0xF8, 0x03, 0xF0, 0x07,
  0xF0, 0xFE, 0x00, 0xFC, 0x01, 0xFC, 0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x0F,
  0xC0, 0x1F, 0xC0, 0x1F, 0x87, 0xF0, 0x07, 0xF0, 0x0F, 0xE1, 0xFC, 0x01,
  0xF8, 0x03, 0xF8, 0x7F, 0x00, 0x7E, 0x00, 0xFE, 0x1F, 0x80, 0x3F, 0x80,
  0x3F, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xC3, 0xF8, 0x03, 0xF0, 0x07, 0xF0,
  0xFE, 0x00, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x00, 0x7E, 0x0F, 0xC0,
  0x1F, 0xC0, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x7C, 0x3F, 0xE0, 0x0F,
  0x8F, 0xFE, 0x03, 0xF3, 0xFF, 0xE0, 0x7E, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xC1, 0xFF, 0x87, 0xF8, 0x3F, 0xE0, 0x7F, 0x0F, 0xF8, 0x0F, 0xE1, 0xFE,
  0x01, 0xFC, 0x3F, 0xC0, 0x3F, 0x87, 0xF0, 0x07, 0xE0, 0xFE, 0x01, 0xFC,
  0x3F, 0x80, 0x3F, 0x87, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x1F, 0x80,
  0x1F, 0x87, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xC3,
  0xF8, 0x03, 0xF0, 0x7E, 0x00, 0x7E, 0x1F, 0xC0, 0x1F, 0xC3, 0xF8, 0x03,
  0xF8, 0x7F, 0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x7F,
  0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xE1, 0xFC, 0x01, 0xFC, 0x3F, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x7F,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F, 0xC1, 0xFE, 0x3F,
  0xC0, 0x7F, 0x1F, 0xC0, 0x3F, 0x9F, 0xC0, 0x1F, 0xCF, 0xE0, 0x07, 0xEF,
  0xE0, 0x03, 0xF7, 0xF0, 0x03, 0xFB, 0xF8, 0x01, 0xFD, 0xF8, 0x00, 0xFF,
  0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F,
  0xDF, 0xC0, 0x0F, 0xEF, 0xE0, 0x07, 0xF7, 0xF0, 0x07, 0xF3, 0xF8, 0x03,
  0xF9, 0xFC, 0x03, 0xFC, 0x7F, 0x03, 0xFC, 0x3F, 0xC3, 0xFC, 0x1F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0xFF,
  0x80, 0x07, 0xC7, 0xFF, 0x00, 0x3F, 0x3F, 0xFE, 0x00, 0xFD, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xF8, 0x3F, 0xC0, 0x3F, 0xC0, 0x7F, 0x01,
  0xFE, 0x01, 0xFC, 0x07, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x1F, 0xC0, 0x7F,
  0x00, 0x7F, 0x01, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0x80,
  0x1F, 0xC0, 0xFC, 0x00, 0x7F, 0x03, 0xF0, 0x03, 0xF8, 0x0F, 0xC0, 0x0F,
  0xE0, 0x7F, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0xFE, 0x07, 0xF0, 0x07, 0xF0,
  0x1F, 0xC0, 0x1F, 0xC0, 0xFF, 0x00, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xC0, 0x3F, 0xE1, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xC0, 0x1F, 0xDF, 0xFE, 0x00, 0x7E, 0x3F, 0xF0, 0x01, 0xF8, 0x7F,
  0x80, 0x07, 0xE0, 0x20, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xF8, 0x7C, 0x07, 0xFF, 0x9F,
  0x81, 0xFF, 0xFB, 0xF0, 0x7F, 0xFF, 0x7E, 0x0F, 0xFF, 0xFF, 0x83, 0xFC,
  0x1F, 0xF0, 0xFF, 0x01, 0xFE, 0x1F, 0xC0, 0x3F, 0xC7, 0xF8, 0x07, 0xF0,
  0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xC7, 0xF0, 0x03, 0xF8, 0xFE, 0x00,
  0x7F, 0x1F, 0xC0, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0xFE, 0x00, 0x3F, 0x1F,
  0xC0, 0x0F, 0xE3, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x0F, 0xE0, 0x0F,
  0xE1, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x87, 0xF0, 0x1F, 0xF0, 0xFE,
  0x03, 0xFC, 0x1F, 0xF1, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE,
  0x03, 0xFF, 0xDF, 0x80, 0x7F, 0xF3, 0xF0, 0x03, 0xF8, 0xFE, 0x00, 0x0C,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x0F, 0x87,
  0xF0, 0x3E, 0x3F, 0xC1, 0xF9, 0xFE, 0x07, 0xEF, 0xF8, 0x1F, 0xFF, 0xE0,
  0x7F, 0xFF, 0x81, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC1,
  0xFF, 0x1F, 0x03, 0xF8, 0x06, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x80, 0x0F, 0xE1, 0xE0, 0x3F, 0xC3,
  0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0x00, 0x40, 0x00, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x04, 0x7F, 0xFE, 0xFF,
  0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF8, 0x40, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x01,
  0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x80, 0x00, 0x07, 0xE0, 0x07, 0xE1, 0xFC,
  0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x87, 0xF0, 0x07, 0xF0, 0xFC, 0x00, 0xFC,
  0x1F, 0x80, 0x1F, 0x87, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x1F, 0xC0,
  0x1F, 0x83, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xC3,
  0xF8, 0x03, 0xF8, 0x7F, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x03,
  0xF8, 0x7F, 0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xE1, 0xF8, 0x03, 0xF8, 0x3F,
  0x00, 0x7F, 0x07, 0xE0, 0x1F, 0xE1, 0xFC, 0x03, 0xFC, 0x3F, 0x80, 0xFF,
  0x87, 0xF0, 0x3F, 0xE0, 0xFF, 0x0F, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFB, 0xF0, 0x3F, 0xFE, 0x7C, 0x03, 0xFF, 0x8F, 0x80, 0x3F, 0xC1, 0xF0,
  0x00, 0x60, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xBF, 0x80,
  0x1F, 0xDF, 0xC0, 0x1F, 0xCF, 0xE0, 0x0F, 0xE7, 0xF0, 0x0F, 0xE1, 0xF8,
  0x07, 0xF0, 0xFC, 0x03, 0xF0, 0x7E, 0x03, 0xF8, 0x3F, 0x01, 0xF8, 0x1F,
  0x81, 0xFC, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0xFE, 0x03, 0xF0, 0x7E, 0x01,
  0xF8, 0x7F, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x3F, 0x80, 0x3F, 0x1F, 0x80,
  0x0F, 0x9F, 0xC0, 0x07, 0xCF, 0xC0, 0x03, 0xE7, 0xE0, 0x01, 0xF7, 0xE0,
  0x00, 0xFB, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0xFC, 0x03, 0xFC, 0x03, 0xFB,
  0xF8, 0x07, 0xF8, 0x07, 0xF7, 0xF0, 0x1F, 0xF0, 0x1F, 0xC7, 0xE0, 0x3F,
  0xE0, 0x3F, 0x8F, 0xC0, 0xFF, 0xC0, 0x7E, 0x1F, 0x81, 0xFF, 0x81, 0xFC,
  0x3F, 0x07, 0xFF, 0x03, 0xF0, 0x7E, 0x0F, 0xBE, 0x0F, 0xE0, 0xFC, 0x1F,
  0x7C, 0x1F, 0x81, 0xF8, 0x7C, 0xF8, 0x3F, 0x03, 0xF0, 0xF9, 0xF0, 0xFE,
  0x07, 0xE3, 0xF3, 0xE1, 0xF8, 0x0F, 0xC7, 0xC7, 0xC7, 0xF0, 0x1F, 0x9F,
  0x8F, 0x8F, 0xC0, 0x3F, 0x3E, 0x1F, 0x3F, 0x80, 0x7E, 0x7C, 0x3E, 0x7E,
  0x00, 0xFD, 0xF8, 0x7C, 0xFC, 0x01, 0xFB, 0xE0, 0xFB, 0xF0, 0x03, 0xF7,
  0xC1, 0xF7, 0xE0, 0x07, 0xDF, 0x03, 0xEF, 0xC0, 0x0F, 0xBE, 0x07, 0xFF,
  0x00, 0x1F, 0xF8, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x01, 0xFE, 0x01, 0xFC, 0x03,
  0xF8, 0x03, 0xF8, 0x0F, 0xE0, 0x03, 0xF0, 0x3F, 0x80, 0x07, 0xF0, 0xFF,
  0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x1F, 0x9F, 0xC0,
  0x00, 0x3F, 0xBF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F,
  0xEF, 0xC0, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0xFE, 0x3F, 0x80, 0x03, 0xF8,
  0x7F, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x7F, 0x01,
  0xFC, 0x01, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x1F, 0xE0, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0xFE, 0x01, 0xFC,
  0x00, 0xFE, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0xFC,
  0x01, 0xF8, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0xFC,
  0x07, 0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0xFC,
  0x0F, 0xC0, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x7E,
  0x3F, 0x80, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x7E,
  0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E,
  0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x87, 0xF8, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xE0,
  0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x78,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x7C, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xE0, 0x02, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0xE0,
  0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x3F, 0xF8,
  0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x9F, 0xFC, 0x00, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x00, 0x7F,
  0xFD, 0x00, 0x0F, 0xFC, 0x80, 0x00, 0x00, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_SemiBoldItalic56pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 15, 41, 15, 1, -40 },
  { 78, 18, 14, 23, 6, -40 },
  { 110, 32, 40, 32, 1, -40 },
  { 270, 27, 46, 28, 1, -43 },
  { 426, 38, 42, 43, 3, -41 },
  { 626, 33, 42, 35, 1, -41 },
  { 800, 8, 14, 13, 6, -40 },
  { 814, 19, 49, 17, 2, -40 },
  { 931, 19, 49, 17, -4, -40 },
  { 1048, 24, 25, 27, 5, -43 },
  { 1123, 25, 27, 30, 3, -33 },
  { 1208, 12, 14, 14, -3, -7 },
  { 1229, 15, 6, 17, 1, -18 },
  { 1241, 8, 9, 14, 1, -8 },
  { 1250, 29, 40, 21, -3, -40 },
  { 1395, 26, 42, 28, 2, -41 },
  { 1532, 19, 40, 28, 6, -40 },
  { 1627, 29, 41, 28, -1, -41 },
  { 1776, 28, 42, 28, 0, -41 },
  { 1923, 29, 40, 28, -1, -40 },
  { 2068, 27, 41, 28, 1, -40 },
  { 2207, 27, 42, 28, 2, -41 },
  { 2349, 28, 40, 28, 2, -40 },
  { 2489, 27, 42, 28, 1, -41 },
  { 2631, 25, 42, 28, 2, -41 },
  { 2763, 14, 32, 14, 0, -31 },
  { 2819, 17, 38, 14, -3, -31 },
  { 2900, 25, 28, 30, 3, -34 },
  { 2988, 25, 16, 30, 3, -28 },
  { 3038, 25, 28, 30, 3, -34 },
  { 3126, 21, 42, 22, 3, -41 },
  { 3237, 40, 45, 43, 2, -40 },
  { 3462, 30, 40, 31, -3, -40 },
  { 3612, 30, 40, 31, 1, -40 },
  { 3762, 30, 42, 30, 3, -41 },
  { 3920, 32, 40, 34, 1, -40 },
  { 4080, 28, 40, 27, 1, -40 },
  { 4220, 28, 40, 26, 1, -40 },
  { 4360, 32, 42, 35, 3, -41 },
  { 4528, 35, 40, 35, 1, -40 },
  { 4703, 24, 40, 19, -2, -40 },
  { 4823, 26, 51, 16, -9, -40 },
  { 4989, 34, 40, 30, 1, -40 },
  { 5159, 21, 40, 25, 1, -40 },
  { 5264, 44, 40, 45, 1, -40 },
  { 5484, 37, 40, 37, 1, -40 },
  { 5669, 32, 42, 37, 3, -41 },
  { 5837, 30, 40, 30, 1, -40 },
  { 5987, 32, 51, 37, 3, -41 },
  { 6191, 29, 40, 31, 1, -40 },
  { 6336, 28, 42, 27, 0, -41 },
  { 6483, 26, 40, 26, 5, -40 },
  { 6613, 33, 41, 35, 3, -40 },
  { 6783, 29, 40, 29, 5, -40 },
  { 6928, 45, 40, 45, 5, -40 },
  { 7153, 36, 40, 29, -3, -40 },
  { 7333, 28, 40, 27, 5, -40 },
  { 7473, 32, 40, 26, -2, -40 },
  { 7633, 22, 49, 17, -1, -40 },
  { 7768, 12, 40, 22, 6, -40 },
  { 7828, 22, 49, 17, -4, -40 },
  { 7963, 26, 25, 28, 1, -40 },
  { 8045, 21, 4, 21, -5, 5 },
  { 8056, 10, 9, 17, 8, -43 },
  { 8068, 27, 32, 30, 2, -31 },
  { 8176, 27, 44, 30, 1, -43 },
  { 8325, 23, 32, 24, 2, -31 },
  { 8417, 30, 44, 30, 2, -43 },
  { 8582, 24, 32, 27, 2, -31 },
  { 8678, 30, 56, 18, -6, -43 },
  { 8888, 29, 44, 30, 0, -31 },
  { 9048, 27, 43, 30, 1, -43 },
  { 9194, 15, 42, 14, 1, -42 },
  { 9273, 23, 55, 15, -7, -42 },
  { 9432, 29, 43, 27, 1, -43 },
  { 9588, 15, 43, 14, 1, -43 },
  { 9669, 42, 31, 45, 1, -31 },
  { 9832, 27, 31, 30, 1, -31 },
  { 9937, 25, 32, 29, 2, -31 },
  { 10037, 30, 44, 30, -2, -31 },
  { 10202, 27, 44, 30, 2, -31 },
  { 10351, 22, 31, 21, 1, -31 },
  { 10437, 23, 32, 23, 0, -31 },
  { 10529, 18, 38, 19, 3, -37 },
  { 10615, 27, 31, 30, 2, -30 },
  { 10720, 25, 30, 25, 3, -30 },
  { 10814, 39, 30, 39, 3, -30 },
  { 10961, 31, 30, 26, -3, -30 },
  { 11078, 32, 43, 25, -4, -30 },
  { 11250, 25, 30, 23, -1, -30 },
  { 11344, 23, 49, 19, 0, -40 },
  { 11485, 5, 56, 27, 11, -43 },
  { 11520, 22, 49, 19, -3, -40 },
  { 11655, 25, 9, 30, 3, -24 },
};

const GFXfont NotoSans_SemiCondensed_SemiBoldItalic56pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_SemiBoldItalic56pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_SemiBoldItalic56pt7bGlyphs,
  0x20, 0x7E, 76
};

#endif // _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC56PT7B_H_
