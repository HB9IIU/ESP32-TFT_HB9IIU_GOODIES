#ifndef _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC42PT7B_H_
#define _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC42PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-SemiBoldItalic.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_SemiBoldItalic42pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x7E, 0x07, 0xE0,
  0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF0, 0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0xFC, 0x07, 0xC0, 0x10, 0x00,
  0x3E, 0x7C, 0xF1, 0xF7, 0xC7, 0xDF, 0x1E, 0x78, 0x79, 0xE1, 0xE7, 0x8F,
  0x1E, 0x3C, 0x70, 0xF3, 0xC3, 0xCF, 0x0E, 0x00, 0x00, 0x3C, 0x3C, 0x00,
  0x3C, 0x3C, 0x00, 0x38, 0x38, 0x00, 0x78, 0x78, 0x00, 0x78, 0x78, 0x00,
  0x70, 0x70, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0xF0, 0x1F, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x01, 0xC1, 0xC0, 0x03,
  0xC3, 0xC0, 0x03, 0xC3, 0xC0, 0x03, 0x83, 0x80, 0x07, 0x87, 0x80, 0x07,
  0x87, 0x80, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x0F,
  0x0F, 0x00, 0x0E, 0x0E, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1C,
  0x1C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x38, 0x00, 0x78,
  0x78, 0x00, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0,
  0x00, 0xFF, 0xE0, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0x98,
  0x41, 0xF1, 0x80, 0x1F, 0x38, 0x01, 0xF3, 0x80, 0x1F, 0x30, 0x01, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0x80, 0x07, 0xF8, 0x00, 0xEF, 0xC0, 0x0E, 0x7C, 0x00, 0xC7, 0xC0,
  0x0C, 0x7C, 0x81, 0xCF, 0x8F, 0x1D, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0,
  0xFF, 0xFC, 0x03, 0xFF, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x70, 0x00, 0x0F, 0xE0, 0x07, 0xC1, 0xFF, 0x00, 0x78, 0x3F, 0xF0,
  0x0F, 0x03, 0xCF, 0x01, 0xE0, 0x78, 0xF0, 0x1E, 0x07, 0x87, 0x83, 0xC0,
  0xF0, 0xF0, 0x78, 0x0F, 0x0F, 0x07, 0x80, 0xF0, 0xF0, 0xF0, 0x0F, 0x0F,
  0x1E, 0x00, 0xF0, 0xF1, 0xE0, 0x0E, 0x1E, 0x3C, 0x00, 0xE1, 0xE7, 0x8F,
  0xCE, 0x1E, 0x79, 0xFE, 0xF3, 0xCF, 0x3F, 0xFF, 0xFD, 0xE7, 0xCF, 0xFF,
  0x9E, 0x78, 0xF7, 0xF3, 0xCF, 0x0F, 0x00, 0x78, 0xF0, 0xF0, 0x07, 0x8F,
  0x0F, 0x00, 0xF1, 0xE0, 0xF0, 0x1E, 0x1E, 0x1F, 0x01, 0xE1, 0xE1, 0xE0,
  0x3C, 0x1E, 0x1E, 0x07, 0x81, 0xE1, 0xE0, 0x78, 0x1E, 0x3C, 0x0F, 0x01,
  0xE7, 0xC1, 0xE0, 0x1F, 0xF8, 0x1E, 0x00, 0xFF, 0x03, 0xC0, 0x07, 0xE0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x03, 0xF3, 0xF0,
  0x03, 0xE1, 0xF0, 0x03, 0xC1, 0xF0, 0x03, 0xC1, 0xF0, 0x07, 0xC1, 0xE0,
  0x07, 0xC3, 0xE0, 0x03, 0xC7, 0xE0, 0x03, 0xEF, 0xC0, 0x03, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFC, 0x1F,
  0x1F, 0xFC, 0x1F, 0x3F, 0x7E, 0x3E, 0x7E, 0x3E, 0x3E, 0x7C, 0x3F, 0x7C,
  0xF8, 0x1F, 0xFC, 0xF8, 0x0F, 0xF8, 0xF8, 0x0F, 0xF0, 0xF8, 0x07, 0xE0,
  0xF8, 0x0F, 0xE0, 0xFC, 0x1F, 0xF0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8,
  0x3F, 0xFC, 0xF8, 0x1F, 0xF0, 0xFC, 0x3E, 0x79, 0xF3, 0xE7, 0xCF, 0x1E,
  0x3C, 0x71, 0xE3, 0xC0, 0x00, 0x3E, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0x80,
  0x1E, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x7C,
  0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0xC0,
  0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00,
  0xF8, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x60, 0xE0, 0x1E, 0x38, 0x0F, 0xFE, 0x03, 0xFF,
  0xFF, 0x3F, 0xFF, 0xC0, 0xFF, 0xF0, 0x7E, 0xFC, 0x3F, 0xC0, 0x1F, 0xF0,
  0x0F, 0x9E, 0x07, 0xC7, 0x80, 0xF1, 0xF0, 0x18, 0x3C, 0x00, 0x0E, 0x00,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x8F, 0xC7, 0xC3, 0xE3, 0xE1, 0xF0, 0xF0, 0xF8, 0x78, 0x78, 0x3C,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xEF, 0xFC, 0x3C, 0xFD, 0xFF, 0xFF,
  0xCF, 0x88, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x1F, 0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xE3, 0xE0, 0xFC,
  0x3F, 0x0F, 0x81, 0xF1, 0xF0, 0x1F, 0x1F, 0x01, 0xF3, 0xF0, 0x1F, 0x3E,
  0x01, 0xF3, 0xE0, 0x1F, 0x7E, 0x03, 0xF7, 0xC0, 0x3E, 0x7C, 0x03, 0xE7,
  0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x7E, 0x7C, 0x07, 0xCF, 0x80, 0x7C,
  0xF8, 0x07, 0xCF, 0x80, 0xF8, 0xF8, 0x0F, 0x87, 0xC1, 0xF8, 0x7C, 0x1F,
  0x07, 0xC3, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0xFE,
  0x00, 0x00, 0x3E, 0x01, 0xF8, 0x07, 0xF0, 0x3F, 0xE0, 0xFF, 0xC3, 0xFF,
  0x1F, 0xFE, 0x7F, 0x7C, 0x78, 0xF8, 0x61, 0xF0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0x81, 0xFF, 0xFE, 0x03, 0xE1, 0xF8,
  0x06, 0x03, 0xF0, 0x10, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x1F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x38, 0x3F, 0x81, 0x00,
  0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF0,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x80, 0x0F, 0xC7, 0x01, 0xFC, 0x3F, 0xFF, 0xE1, 0xFF, 0xFE, 0x0F, 0xFF,
  0xC0, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x07,
  0xBC, 0x00, 0x7B, 0xE0, 0x07, 0xDF, 0x00, 0x7C, 0xF8, 0x03, 0xC7, 0x80,
  0x3C, 0x7C, 0x03, 0xE3, 0xE0, 0x3E, 0x1F, 0x01, 0xE0, 0xF0, 0x1E, 0x0F,
  0x81, 0xE0, 0x7C, 0x1F, 0x03, 0xE0, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFB, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xFF,
  0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x1F, 0x78, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xC0,
  0x7F, 0xFF, 0x01, 0xE7, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF8, 0x80, 0x0F, 0xC7, 0x01, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC,
  0x0F, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x07, 0xFE, 0x01,
  0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xCF, 0xE0,
  0x7D, 0xFF, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0x8F, 0xE0, 0xF8, 0xFC, 0x0F,
  0x8F, 0xC0, 0xF8, 0xF8, 0x0F, 0x8F, 0x80, 0xF8, 0xF8, 0x0F, 0x8F, 0x80,
  0xF8, 0xF8, 0x0F, 0x8F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0xC3, 0xF0, 0x7F,
  0xFE, 0x07, 0xFF, 0xC0, 0x3F, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xFF, 0xF8,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x1F, 0xFC, 0x03, 0xFF, 0xE0,
  0x7F, 0xFF, 0x0F, 0xC1, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F,
  0x0F, 0x81, 0xF0, 0xF8, 0x3E, 0x0F, 0xC7, 0xE0, 0x7C, 0xFC, 0x07, 0xFF,
  0x80, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x03, 0xF1,
  0xF8, 0x7E, 0x0F, 0x87, 0xC0, 0xFC, 0xF8, 0x07, 0xCF, 0x80, 0x7C, 0xF8,
  0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x0F, 0x8F, 0xC1, 0xF8, 0x7F, 0xFF, 0x87,
  0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x7F, 0xF0,
  0x1F, 0xFF, 0x07, 0xFF, 0xF0, 0xF8, 0x7E, 0x3E, 0x07, 0xC7, 0xC0, 0xF9,
  0xF0, 0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0x7C, 0xF8, 0x0F, 0x9F, 0x01, 0xF3,
  0xE0, 0x7E, 0x7C, 0x0F, 0xCF, 0xC3, 0xF9, 0xFF, 0xFF, 0x1F, 0xFB, 0xC3,
  0xFE, 0xF8, 0x1F, 0x9F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x10, 0x1F, 0x83, 0xFF, 0xE0, 0x7F,
  0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xC1, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC1, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x07, 0xC1, 0xF8, 0xFE, 0x3F, 0x07, 0xC0,
  0x80, 0x01, 0xF0, 0x1F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x81, 0xF0, 0x1F, 0x01, 0xF0, 0x3E, 0x03,
  0xE0, 0x7C, 0x07, 0x80, 0x78, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x0C, 0x00, 0x07, 0x80, 0x03, 0xF0, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0x7E,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0xF0, 0x00, 0x06, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x7E,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0x1F, 0xE0, 0x03, 0xF0,
  0x00, 0x78, 0x00, 0x0C, 0x00, 0x00, 0x07, 0xF8, 0x3F, 0xFE, 0x3F, 0xFE,
  0x3F, 0xFF, 0x18, 0x1F, 0x10, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0x78, 0x00, 0x20, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0x81, 0xF8, 0x03,
  0xF0, 0x01, 0xF0, 0x1F, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0x1E, 0x1E, 0x03, 0xF8, 0x38, 0xF8, 0x3F, 0xF8, 0xF3, 0xC1, 0xFF,
  0xC3, 0xDE, 0x0F, 0x8F, 0x0F, 0x78, 0x78, 0x3C, 0x3D, 0xE1, 0xE0, 0xE0,
  0xFF, 0x0F, 0x07, 0x83, 0xFC, 0x3C, 0x1E, 0x0E, 0xF1, 0xE0, 0x78, 0x7B,
  0xC7, 0x81, 0xC1, 0xEE, 0x1E, 0x0F, 0x07, 0xB8, 0x78, 0x3C, 0x3C, 0xE1,
  0xE1, 0xF0, 0xF3, 0x87, 0x87, 0xC7, 0x8E, 0x1F, 0xF7, 0xFC, 0x3C, 0x3F,
  0xDF, 0xE0, 0xF0, 0x7E, 0x3F, 0x03, 0xC0, 0x60, 0x20, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0xC0,
  0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xDF,
  0x00, 0x07, 0xBE, 0x00, 0x1F, 0x7C, 0x00, 0x3C, 0x78, 0x00, 0xF8, 0xF0,
  0x01, 0xE1, 0xE0, 0x07, 0xC3, 0xC0, 0x0F, 0x07, 0x80, 0x3E, 0x0F, 0x00,
  0x7C, 0x1E, 0x01, 0xF0, 0x3C, 0x03, 0xE0, 0x7C, 0x0F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xE0, 0x0F, 0x87, 0xC0,
  0x1F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0xFC, 0x00, 0xF9, 0xF0, 0x01,
  0xF7, 0xE0, 0x03, 0xFF, 0x80, 0x07, 0xC0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0xC0, 0x3F, 0xFF, 0x81, 0xFF, 0xFF, 0x07, 0xC1, 0xFC, 0x1F, 0x03, 0xF0,
  0x7C, 0x07, 0xC1, 0xF0, 0x1F, 0x0F, 0x80, 0x7C, 0x3E, 0x01, 0xF0, 0xF8,
  0x0F, 0x83, 0xE0, 0x7E, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x01, 0xFF, 0xF0,
  0x07, 0xFF, 0xF0, 0x1F, 0x1F, 0xE0, 0xF8, 0x0F, 0xC3, 0xE0, 0x1F, 0x0F,
  0x80, 0x7C, 0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC7, 0xC0, 0x3F, 0x1F, 0x00,
  0xFC, 0x7C, 0x07, 0xE1, 0xF0, 0x7F, 0x87, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xFC,
  0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x7F, 0x83, 0x81, 0xFC, 0x01, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x07, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80,
  0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x07, 0xC7, 0xFC,
  0x07, 0xC0, 0xFE, 0x07, 0xC0, 0x7E, 0x07, 0xC0, 0x3E, 0x0F, 0xC0, 0x3E,
  0x0F, 0x80, 0x3F, 0x0F, 0x80, 0x3F, 0x0F, 0x80, 0x3F, 0x1F, 0x80, 0x3F,
  0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3E,
  0x3F, 0x00, 0x7E, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0xFC, 0x3E, 0x00, 0xFC,
  0x3E, 0x01, 0xF8, 0x7E, 0x03, 0xF8, 0x7C, 0x07, 0xF0, 0x7C, 0x0F, 0xE0,
  0x7C, 0x7F, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x0F,
  0xFF, 0xE0, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xFF,
  0xFC, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x81,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x00, 0x03, 0xFF,
  0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x7F,
  0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x81, 0xFF, 0xF8, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xFF, 0x01,
  0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xF8, 0x1E, 0x0F, 0xE0, 0x04, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x0F, 0xFC, 0x7C, 0x0F, 0xFC, 0xFC, 0x0F, 0xFC, 0xFC, 0x0F, 0xFC, 0xFC,
  0x00, 0xF8, 0xFC, 0x00, 0xF8, 0xFC, 0x00, 0xF8, 0xFC, 0x00, 0xF8, 0xFC,
  0x01, 0xF8, 0x7C, 0x01, 0xF0, 0x7E, 0x01, 0xF0, 0x7F, 0x81, 0xF0, 0x3F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x03,
  0xE0, 0x07, 0xC0, 0xF8, 0x03, 0xF0, 0x3E, 0x00, 0xF8, 0x1F, 0x80, 0x3E,
  0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x03, 0xE0, 0x7C, 0x01, 0xF8, 0x1F, 0x00,
  0x7C, 0x0F, 0xC0, 0x1F, 0x03, 0xE0, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x3E,
  0x00, 0xF8, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xC0, 0x1F, 0x03, 0xE0, 0x07,
  0xC0, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0xFC, 0x0F, 0x80, 0x3E, 0x07, 0xE0,
  0x0F, 0x81, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x1F, 0x00, 0x7C, 0x07,
  0xC0, 0x1F, 0x03, 0xF0, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF8, 0x07, 0xF8, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x03,
  0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x7F, 0xF0,
  0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0x18, 0x00, 0x00, 0x03,
  0xE0, 0x1F, 0x81, 0xF0, 0x1F, 0x80, 0xF8, 0x1F, 0x80, 0xF8, 0x0F, 0x80,
  0x7C, 0x0F, 0xC0, 0x3E, 0x0F, 0xC0, 0x1F, 0x0F, 0xC0, 0x0F, 0x8F, 0xC0,
  0x0F, 0x87, 0xC0, 0x07, 0xC7, 0xE0, 0x03, 0xE7, 0xE0, 0x01, 0xF7, 0xE0,
  0x00, 0xFF, 0xE0, 0x00, 0xFB, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8,
  0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xDF, 0x00, 0x0F, 0xCF, 0x80, 0x07, 0xC7,
  0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0x7E, 0x00, 0xF8,
  0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x3E, 0x07, 0xE0, 0x1F, 0x01, 0xF0, 0x1F,
  0x00, 0xF8, 0x0F, 0x80, 0x7E, 0x07, 0xC0, 0x1F, 0x00, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x81, 0xFC,
  0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x1F, 0xE0, 0x7F,
  0x80, 0x0F, 0xF0, 0x3F, 0xC0, 0x0F, 0xF8, 0x1F, 0xE0, 0x07, 0xFC, 0x0F,
  0xF0, 0x07, 0xBC, 0x0F, 0xF8, 0x03, 0xDE, 0x07, 0xFE, 0x03, 0xDF, 0x03,
  0xEF, 0x01, 0xEF, 0x81, 0xE7, 0x81, 0xE7, 0xC1, 0xF3, 0xC0, 0xF3, 0xC0,
  0xF9, 0xE0, 0xF3, 0xE0, 0x7C, 0xF0, 0x79, 0xF0, 0x3E, 0x78, 0x78, 0xF8,
  0x1E, 0x3C, 0x3C, 0x7C, 0x1F, 0x1E, 0x3C, 0x3C, 0x0F, 0x8F, 0x1E, 0x3E,
  0x07, 0xC7, 0x9F, 0x1F, 0x03, 0xC3, 0xCF, 0x0F, 0x81, 0xE1, 0xEF, 0x87,
  0x81, 0xF0, 0xF7, 0x87, 0xC0, 0xF8, 0x7F, 0xC3, 0xE0, 0x7C, 0x3F, 0xC1,
  0xF0, 0x3C, 0x1F, 0xE0, 0xF8, 0x1E, 0x07, 0xE0, 0x78, 0x1F, 0x03, 0xF0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x00, 0x03, 0xF0,
  0x01, 0xF0, 0x3F, 0x00, 0x1E, 0x03, 0xF8, 0x03, 0xE0, 0x7F, 0x80, 0x3E,
  0x07, 0xF8, 0x03, 0xE0, 0x7F, 0x80, 0x3C, 0x07, 0xFC, 0x07, 0xC0, 0x7F,
  0xC0, 0x7C, 0x0F, 0xBC, 0x07, 0xC0, 0xFB, 0xE0, 0x7C, 0x0F, 0x3E, 0x07,
  0x80, 0xF3, 0xE0, 0xF8, 0x1F, 0x1E, 0x0F, 0x81, 0xF1, 0xF0, 0xF8, 0x1F,
  0x1F, 0x0F, 0x81, 0xF1, 0xF0, 0xF0, 0x1E, 0x0F, 0x9F, 0x03, 0xE0, 0xF9,
  0xF0, 0x3E, 0x0F, 0x9F, 0x03, 0xE0, 0x79, 0xE0, 0x3C, 0x07, 0xDE, 0x03,
  0xC0, 0x7F, 0xE0, 0x7C, 0x07, 0xFE, 0x07, 0xC0, 0x3F, 0xE0, 0x7C, 0x03,
  0xFC, 0x07, 0x80, 0x3F, 0xC0, 0x78, 0x01, 0xFC, 0x0F, 0x80, 0x1F, 0xC0,
  0xF8, 0x01, 0xFC, 0x0F, 0x80, 0x1F, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xF0, 0x7E, 0x0F, 0xE0,
  0x3F, 0x0F, 0xC0, 0x3F, 0x1F, 0x80, 0x1F, 0x1F, 0x00, 0x1F, 0x3F, 0x00,
  0x1F, 0x3E, 0x00, 0x1F, 0x7E, 0x00, 0x1F, 0x7E, 0x00, 0x1F, 0x7C, 0x00,
  0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00,
  0xFC, 0xFC, 0x00, 0xFC, 0x7C, 0x01, 0xF8, 0x7E, 0x03, 0xF8, 0x7F, 0x07,
  0xF0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFE,
  0x07, 0xC3, 0xFC, 0x1F, 0x03, 0xF0, 0x7C, 0x07, 0xC1, 0xF0, 0x1F, 0x0F,
  0x80, 0x7C, 0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x3F, 0x1F, 0x80,
  0xF8, 0x7C, 0x0F, 0xE1, 0xF1, 0xFF, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0,
  0xFF, 0xFE, 0x03, 0xFF, 0xC0, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE,
  0x07, 0xF0, 0x7E, 0x0F, 0xE0, 0x3F, 0x0F, 0xC0, 0x3F, 0x1F, 0x80, 0x1F,
  0x1F, 0x00, 0x1F, 0x3F, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x7E, 0x00, 0x1F,
  0x7E, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x7E,
  0xFC, 0x00, 0x7E, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0x7C, 0x01, 0xF8,
  0x7E, 0x03, 0xF8, 0x7F, 0x0F, 0xF0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0,
  0x0F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x01,
  0xFF, 0xFE, 0x07, 0xC3, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3F, 0x0F, 0x80, 0xFC, 0x3E, 0x03, 0xE0, 0xF8, 0x0F, 0x83, 0xE0, 0x7E,
  0x1F, 0x81, 0xF0, 0x7C, 0x1F, 0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x1F,
  0xFF, 0x00, 0xFF, 0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0x87, 0xC0, 0x3E, 0x1F,
  0x00, 0xF8, 0x7C, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3F, 0x07, 0xC0, 0x7C, 0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xE3, 0xE0,
  0x0F, 0x80, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF,
  0xE0, 0x7F, 0x0F, 0x07, 0xE0, 0x10, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0xC0, 0x1F, 0x87, 0x81, 0xFC, 0x3F, 0xFF,
  0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x7F, 0xFF, 0xF7,
  0xFF, 0xFF, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x81, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x1F, 0x83, 0xE0, 0x0F, 0x83, 0xF0, 0x07, 0xC1, 0xF0, 0x03,
  0xE0, 0xF8, 0x01, 0xF0, 0x7C, 0x01, 0xF8, 0x3E, 0x00, 0xF8, 0x3E, 0x00,
  0x7C, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x1F, 0x07, 0xE0,
  0x0F, 0x83, 0xE0, 0x07, 0xC1, 0xF0, 0x03, 0xE0, 0xF8, 0x03, 0xF0, 0x7C,
  0x01, 0xF0, 0x7E, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x0F,
  0x80, 0x3F, 0x07, 0xC0, 0x1F, 0x07, 0xE0, 0x0F, 0x83, 0xF0, 0x0F, 0xC1,
  0xF8, 0x07, 0xC0, 0x7C, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x1F, 0xFF, 0xF0,
  0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xF8, 0x00,
  0xFF, 0xE0, 0x03, 0xEF, 0x80, 0x1F, 0xBE, 0x00, 0x7C, 0xF8, 0x03, 0xF3,
  0xE0, 0x0F, 0x8F, 0x80, 0x7E, 0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xE0,
  0x3E, 0x0F, 0x80, 0xF8, 0x1E, 0x07, 0xC0, 0x78, 0x1F, 0x01, 0xE0, 0xF8,
  0x07, 0x83, 0xE0, 0x1E, 0x1F, 0x00, 0x78, 0x7C, 0x01, 0xE3, 0xE0, 0x07,
  0xCF, 0x80, 0x1F, 0x7C, 0x00, 0x7D, 0xF0, 0x01, 0xF7, 0x80, 0x07, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0xFE, 0x00, 0xF8, 0x03, 0xEF, 0x80, 0x7E, 0x01, 0xFB, 0xE0, 0x1F,
  0x80, 0x7C, 0xF8, 0x07, 0xE0, 0x1F, 0x3E, 0x03, 0xF8, 0x0F, 0x8F, 0x80,
  0xFE, 0x03, 0xE3, 0xE0, 0x7F, 0x81, 0xF0, 0xF8, 0x1F, 0xE0, 0x7C, 0x3E,
  0x0F, 0xF8, 0x1F, 0x0F, 0x83, 0xDE, 0x0F, 0x83, 0xE1, 0xF7, 0x83, 0xE0,
  0xF8, 0x79, 0xE1, 0xF0, 0x3E, 0x1E, 0x78, 0x7C, 0x0F, 0x8F, 0x9E, 0x1E,
  0x03, 0xE3, 0xC7, 0x8F, 0x80, 0xF9, 0xF1, 0xE3, 0xE0, 0x3E, 0x78, 0x79,
  0xF0, 0x0F, 0xBE, 0x1E, 0x7C, 0x03, 0xEF, 0x07, 0x9E, 0x00, 0xFB, 0xC1,
  0xEF, 0x80, 0x3F, 0xF0, 0x7B, 0xC0, 0x0F, 0xF8, 0x1F, 0xF0, 0x03, 0xDE,
  0x07, 0xFC, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x0F,
  0xE0, 0x1F, 0xC0, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0xFE, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x07, 0xE0, 0x3E, 0x01, 0xF8,
  0x07, 0xC0, 0x3E, 0x00, 0x7C, 0x0F, 0xC0, 0x0F, 0x83, 0xF0, 0x01, 0xF0,
  0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x7C, 0xF8, 0x00,
  0x0F, 0xBE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFB, 0xE0,
  0x00, 0x3F, 0x7C, 0x00, 0x07, 0xC7, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x7E,
  0x1F, 0x00, 0x1F, 0x83, 0xF0, 0x03, 0xE0, 0x3E, 0x00, 0xFC, 0x07, 0xC0,
  0x3F, 0x00, 0xFC, 0x07, 0xC0, 0x1F, 0x81, 0xF8, 0x01, 0xF0, 0x00, 0xF8,
  0x01, 0xFF, 0x80, 0x3E, 0xF8, 0x07, 0xE7, 0xC0, 0x7C, 0x7C, 0x0F, 0xC7,
  0xC0, 0xF8, 0x7C, 0x1F, 0x07, 0xC3, 0xF0, 0x3C, 0x3E, 0x03, 0xE7, 0xC0,
  0x3E, 0x7C, 0x03, 0xEF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xE0,
  0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x7F, 0xC0,
  0x3F, 0xE0, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x78, 0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x00,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xE1, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xE1, 0xF0, 0xF8, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xE1, 0xF0,
  0xF8, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xE1, 0xF0, 0xF8, 0x3C, 0x00, 0xFF,
  0x80, 0x7F, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80,
  0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0,
  0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xEF, 0x00, 0x3C,
  0xF0, 0x03, 0xCF, 0x00, 0x78, 0x78, 0x0F, 0x87, 0x80, 0xF0, 0x78, 0x1E,
  0x03, 0xC1, 0xE0, 0x3C, 0x3C, 0x03, 0xC7, 0xC0, 0x1E, 0x78, 0x01, 0xEF,
  0x80, 0x1F, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x7C, 0x7C, 0x3E,
  0x1E, 0x0F, 0x0F, 0x01, 0xF0, 0xF0, 0x7F, 0xDF, 0x0F, 0xFD, 0xF1, 0xFF,
  0xFE, 0x1F, 0x8F, 0xE3, 0xF0, 0x7E, 0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0x7C,
  0x07, 0xCF, 0xC0, 0x7C, 0xF8, 0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x0F, 0x8F,
  0x80, 0xF8, 0xF8, 0x0F, 0x8F, 0x81, 0xF8, 0xF8, 0x1F, 0x8F, 0x83, 0xF0,
  0xF8, 0x7F, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x07, 0xFD, 0xF0, 0x3F, 0x1E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x3E, 0x01, 0xF7, 0xF8, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x07,
  0xF8, 0xFC, 0x3F, 0x03, 0xE1, 0xF8, 0x1F, 0x0F, 0x80, 0xF8, 0x7C, 0x07,
  0xC7, 0xC0, 0x3E, 0x3E, 0x01, 0xF1, 0xF0, 0x1F, 0x8F, 0x80, 0xF8, 0x78,
  0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0xC1, 0xF8,
  0xFE, 0x1F, 0x87, 0xFF, 0xF8, 0x3D, 0xFF, 0xC1, 0xE7, 0xFC, 0x1F, 0x1F,
  0x80, 0x01, 0xFE, 0x01, 0xFF, 0xC3, 0xFF, 0xC3, 0xFF, 0xE1, 0xF8, 0x21,
  0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3F, 0x06, 0x1F, 0xFF, 0x07, 0xFF, 0x81, 0xFF, 0xC0,
  0x7F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x07, 0xC7, 0xC0, 0x7F, 0xDF, 0x03, 0xFF, 0x7C, 0x1F,
  0xFF, 0xE0, 0x7E, 0x3F, 0x83, 0xF0, 0x7E, 0x1F, 0x81, 0xF8, 0x7C, 0x07,
  0xC1, 0xF0, 0x1F, 0x0F, 0xC0, 0x7C, 0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC3,
  0xE0, 0x1E, 0x0F, 0x80, 0xF8, 0x3E, 0x03, 0xE0, 0xF8, 0x1F, 0x83, 0xE0,
  0x7E, 0x0F, 0x83, 0xF0, 0x3E, 0x1F, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xBC,
  0x07, 0xFD, 0xF0, 0x0F, 0xC7, 0x80, 0x01, 0xFE, 0x00, 0xFF, 0xC0, 0xFF,
  0xF8, 0x7F, 0xFE, 0x1F, 0x07, 0xCF, 0x81, 0xF7, 0xE0, 0x7D, 0xF0, 0x3E,
  0x7C, 0x1F, 0xBE, 0x1F, 0xCF, 0xFF, 0xE3, 0xFF, 0xF0, 0xFF, 0xF0, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0,
  0x43, 0xFD, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFC,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFE, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x11, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x7C, 0x3C, 0x07, 0xFD, 0xF0, 0x3F, 0xF7, 0xC1, 0xFF, 0xFE, 0x07, 0xE3,
  0xF8, 0x3F, 0x07, 0xE1, 0xF8, 0x1F, 0x87, 0xE0, 0x7E, 0x1F, 0x01, 0xF0,
  0xFC, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x3E, 0x03, 0xE0, 0xF8,
  0x0F, 0x83, 0xE0, 0x3E, 0x0F, 0x81, 0xF8, 0x3E, 0x07, 0xE0, 0xF8, 0x3F,
  0x03, 0xE1, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xF7, 0xC0, 0x7F, 0xDF, 0x00,
  0xFC, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x20, 0x0F, 0xC0, 0xE0, 0x7E, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0,
  0x3F, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x3E, 0x01, 0xF7, 0xFC, 0x0F,
  0xFF, 0xE0, 0x7F, 0xFF, 0x87, 0xF8, 0xFC, 0x3F, 0x83, 0xE1, 0xF8, 0x1F,
  0x0F, 0x80, 0xF8, 0x7C, 0x07, 0x87, 0xE0, 0x7C, 0x3E, 0x03, 0xE1, 0xF0,
  0x1F, 0x0F, 0x80, 0xF8, 0x78, 0x0F, 0x87, 0xC0, 0x7C, 0x3E, 0x03, 0xE1,
  0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0xF8, 0x0F, 0x87, 0xC0, 0x7C, 0x3E, 0x03,
  0xE1, 0xF0, 0x1F, 0x1F, 0x81, 0xF8, 0x00, 0x40, 0x1F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x7C,
  0x07, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xE0,
  0x7C, 0x07, 0xC0, 0x7C, 0x0F, 0xC0, 0x00, 0x02, 0x00, 0x07, 0xC0, 0x03,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC,
  0x04, 0xFC, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x01, 0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0x7C, 0x07, 0xC3, 0xE0,
  0x3E, 0x1F, 0x80, 0xF8, 0xFC, 0x03, 0xE7, 0xE0, 0x0F, 0xBF, 0x00, 0x3D,
  0xF8, 0x01, 0xF7, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0,
  0x01, 0xFF, 0xE0, 0x0F, 0xCF, 0x80, 0x3E, 0x3E, 0x00, 0xF8, 0x7C, 0x03,
  0xE1, 0xF0, 0x1F, 0x07, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xFC, 0x3F, 0x01, 0xF0, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x3F, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x07,
  0xC0, 0x7C, 0x0F, 0xC0, 0x07, 0x87, 0xC0, 0xFC, 0x07, 0x9F, 0xE3, 0xFE,
  0x07, 0xBF, 0xF7, 0xFE, 0x07, 0xFF, 0xF7, 0xFF, 0x0F, 0xF1, 0xFE, 0x3F,
  0x0F, 0xE1, 0xFC, 0x1F, 0x0F, 0xC1, 0xF8, 0x1F, 0x0F, 0x81, 0xF8, 0x1F,
  0x0F, 0x81, 0xF0, 0x1F, 0x1F, 0x01, 0xF0, 0x1E, 0x1F, 0x01, 0xF0, 0x3E,
  0x1F, 0x01, 0xE0, 0x3E, 0x1F, 0x03, 0xE0, 0x3E, 0x1E, 0x03, 0xE0, 0x3E,
  0x3E, 0x03, 0xE0, 0x7C, 0x3E, 0x03, 0xE0, 0x7C, 0x3E, 0x07, 0xC0, 0x7C,
  0x3E, 0x07, 0xC0, 0x7C, 0x7C, 0x07, 0xC0, 0x7C, 0x7C, 0x07, 0xC0, 0xF8,
  0x7C, 0x07, 0xC0, 0xF8, 0x7C, 0x0F, 0x80, 0xF8, 0xFC, 0x0F, 0x80, 0xF8,
  0x07, 0x87, 0xC0, 0x3C, 0xFF, 0x81, 0xEF, 0xFC, 0x0F, 0xFF, 0xF0, 0xFF,
  0x1F, 0x87, 0xF0, 0x7C, 0x3F, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x80, 0xF8,
  0xFC, 0x0F, 0x87, 0xC0, 0x7C, 0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x1F, 0x81,
  0xF0, 0xF8, 0x0F, 0x87, 0xC0, 0x7C, 0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x1F,
  0x01, 0xF0, 0xF8, 0x0F, 0x87, 0xC0, 0x7C, 0x3E, 0x03, 0xE3, 0xF0, 0x3F,
  0x00, 0x01, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x7F, 0xFE, 0x3F, 0x8F,
  0xCF, 0xC1, 0xF7, 0xE0, 0x7D, 0xF0, 0x1F, 0x7C, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xE0,
  0x3E, 0xF8, 0x1F, 0xBE, 0x07, 0xCF, 0xC3, 0xF3, 0xFF, 0xF8, 0x7F, 0xFC,
  0x0F, 0xFE, 0x01, 0xFE, 0x00, 0x01, 0xE1, 0xF0, 0x03, 0xCF, 0xF0, 0x07,
  0xBF, 0xF0, 0x0F, 0xFF, 0xE0, 0x3F, 0xC7, 0xE0, 0x7E, 0x07, 0xC0, 0xFC,
  0x0F, 0x81, 0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x0F, 0x80, 0x7C, 0x1F, 0x00,
  0xF8, 0x3E, 0x03, 0xF0, 0x7C, 0x07, 0xC0, 0xF0, 0x0F, 0x83, 0xE0, 0x1F,
  0x07, 0xC0, 0x7E, 0x0F, 0x80, 0xF8, 0x1F, 0x83, 0xF0, 0x7F, 0x0F, 0xC0,
  0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xEF, 0xF8, 0x07, 0xCF, 0xC0, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0xF0, 0x7F, 0xCF, 0x0F, 0xFD, 0xF1,
  0xFF, 0xFE, 0x1F, 0x8F, 0xE3, 0xF0, 0x7E, 0x7E, 0x07, 0xE7, 0xC0, 0x7C,
  0x7C, 0x07, 0xCF, 0xC0, 0x7C, 0xF8, 0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x07,
  0x8F, 0x80, 0xF8, 0xF8, 0x0F, 0x8F, 0x81, 0xF8, 0xF8, 0x1F, 0x8F, 0x83,
  0xF0, 0xF8, 0x7F, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x07, 0xFD, 0xF0, 0x3F,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x07, 0x87, 0x83, 0xCF, 0xC1, 0xEF, 0xE0, 0xFF, 0xF0,
  0xFF, 0xF0, 0x7F, 0x80, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x03, 0xF0, 0x00, 0x01, 0xFE, 0x03, 0xFF, 0xC3, 0xFF, 0xE3, 0xFF,
  0xE1, 0xF0, 0x30, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x3E, 0x00, 0x3F, 0x30, 0x1F, 0x9F, 0xFF, 0x8F, 0xFF,
  0x87, 0xFF, 0xC1, 0xFF, 0x80, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0F, 0x00,
  0xF8, 0x0F, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF8, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xFF, 0x87, 0xFC, 0x1F,
  0xE0, 0x7F, 0x00, 0x1F, 0x01, 0xF1, 0xF0, 0x1F, 0x1F, 0x01, 0xF3, 0xE0,
  0x3E, 0x3E, 0x03, 0xE3, 0xE0, 0x3E, 0x3E, 0x03, 0xE3, 0xE0, 0x3C, 0x7C,
  0x07, 0xC7, 0xC0, 0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0x7C, 0x0F, 0x8F,
  0x80, 0xF8, 0xF8, 0x0F, 0x8F, 0x81, 0xF8, 0xF8, 0x1F, 0x8F, 0x83, 0xF0,
  0xF8, 0x7F, 0x0F, 0xFE, 0xF0, 0xFF, 0xEF, 0x07, 0xFD, 0xF0, 0x3F, 0x1E,
  0x00, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0x7C, 0x07, 0xE7, 0x80,
  0xF8, 0xF0, 0x3F, 0x1E, 0x07, 0xC3, 0xC1, 0xF8, 0x7C, 0x3E, 0x0F, 0x87,
  0xC1, 0xF1, 0xF0, 0x3E, 0x3C, 0x07, 0xCF, 0x80, 0xF9, 0xE0, 0x1F, 0x7C,
  0x01, 0xEF, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xF0, 0x1F, 0x01, 0xFF,
  0x01, 0xF0, 0x1F, 0xF0, 0x3F, 0x03, 0xEF, 0x03, 0xF0, 0x3E, 0xF0, 0x7F,
  0x03, 0xCF, 0x07, 0xF0, 0x7C, 0xF0, 0xF7, 0x07, 0xCF, 0x0F, 0x70, 0xF8,
  0xF0, 0xF7, 0x0F, 0x8F, 0x1E, 0x71, 0xF0, 0xF1, 0xE7, 0x1F, 0x0F, 0x3C,
  0x71, 0xE0, 0xF3, 0xC7, 0x3E, 0x0F, 0x78, 0x73, 0xC0, 0xF7, 0x87, 0x7C,
  0x0F, 0x78, 0x77, 0xC0, 0xFF, 0x07, 0x78, 0x0F, 0xF0, 0x7F, 0x80, 0xFE,
  0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xE0, 0x0F, 0xC0, 0x7E,
  0x00, 0xFC, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x7E, 0x07, 0xC0, 0xF8, 0x0F,
  0x83, 0xF0, 0x1F, 0x0F, 0xC0, 0x1F, 0x1F, 0x00, 0x3E, 0x7C, 0x00, 0x7D,
  0xF8, 0x00, 0x7B, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x07, 0xCF, 0x00, 0x1F, 0x9F, 0x00, 0x7E, 0x3E, 0x00,
  0xF8, 0x7E, 0x03, 0xE0, 0x7C, 0x0F, 0xC0, 0xF8, 0x3F, 0x01, 0xF8, 0x00,
  0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x3F, 0x03, 0xC0, 0x3E, 0x03, 0xC0, 0x7E,
  0x03, 0xC0, 0x7C, 0x03, 0xE0, 0x7C, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0xF8,
  0x03, 0xE1, 0xF0, 0x03, 0xE1, 0xF0, 0x03, 0xE3, 0xE0, 0x01, 0xE3, 0xE0,
  0x01, 0xE7, 0xC0, 0x01, 0xE7, 0xC0, 0x01, 0xEF, 0x80, 0x01, 0xEF, 0x80,
  0x01, 0xEF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF,
  0xE0, 0x80, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00,
  0x3F, 0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x00, 0x00, 0x0F,
  0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x07, 0xC0, 0x03,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x1F, 0x80, 0x7F, 0x80, 0x3F, 0x80,
  0x1F, 0x00, 0x1F, 0xE0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x01, 0xF8, 0x00, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x01, 0xE0, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xFC, 0x00, 0xFC,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF,
  0x00, 0x7F, 0x00, 0x1F, 0x00, 0xFF, 0x01, 0xFE, 0x03, 0xF0, 0x03, 0xE0,
  0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x7F, 0x00, 0xFF, 0x00, 0xFE, 0x00,
  0xFC, 0x00, 0xE0, 0x00, 0x1F, 0x00, 0x2F, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0x00, 0x7F, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_SemiBoldItalic42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 12, 31, 11, 0, -30 },
  { 48, 14, 11, 17, 4, -30 },
  { 68, 24, 30, 24, 1, -30 },
  { 158, 20, 34, 21, 1, -32 },
  { 243, 28, 30, 32, 3, -30 },
  { 348, 24, 30, 26, 1, -30 },
  { 438, 7, 11, 10, 4, -30 },
  { 448, 15, 37, 13, 1, -30 },
  { 518, 14, 37, 13, -3, -30 },
  { 583, 18, 18, 21, 4, -32 },
  { 624, 19, 20, 22, 2, -25 },
  { 672, 9, 11, 11, -2, -5 },
  { 685, 11, 5, 13, 1, -14 },
  { 692, 7, 7, 11, 0, -6 },
  { 699, 21, 30, 16, -2, -30 },
  { 778, 20, 30, 21, 1, -30 },
  { 853, 15, 30, 21, 4, -30 },
  { 910, 22, 30, 21, -1, -30 },
  { 993, 21, 30, 21, 0, -30 },
  { 1072, 21, 30, 21, 0, -30 },
  { 1151, 21, 30, 21, 0, -30 },
  { 1230, 20, 30, 21, 2, -30 },
  { 1305, 21, 30, 21, 2, -30 },
  { 1384, 20, 30, 21, 1, -30 },
  { 1459, 19, 30, 21, 1, -30 },
  { 1531, 10, 24, 11, 0, -23 },
  { 1561, 12, 29, 11, -2, -23 },
  { 1605, 19, 21, 22, 2, -26 },
  { 1655, 19, 12, 22, 2, -21 },
  { 1684, 19, 21, 22, 2, -26 },
  { 1734, 16, 31, 17, 2, -30 },
  { 1796, 30, 34, 32, 2, -30 },
  { 1924, 23, 30, 23, -3, -30 },
  { 2011, 22, 30, 23, 1, -30 },
  { 2094, 23, 30, 22, 2, -30 },
  { 2181, 24, 30, 26, 1, -30 },
  { 2271, 21, 30, 20, 1, -30 },
  { 2350, 21, 30, 19, 1, -30 },
  { 2429, 24, 30, 26, 2, -30 },
  { 2519, 26, 30, 26, 1, -30 },
  { 2617, 18, 30, 14, -1, -30 },
  { 2685, 20, 39, 12, -7, -30 },
  { 2783, 25, 30, 23, 1, -30 },
  { 2877, 15, 30, 19, 1, -30 },
  { 2934, 33, 30, 33, 1, -30 },
  { 3058, 28, 30, 28, 1, -30 },
  { 3163, 24, 30, 27, 2, -30 },
  { 3253, 22, 30, 23, 1, -30 },
  { 3336, 24, 37, 27, 2, -30 },
  { 3447, 22, 30, 23, 1, -30 },
  { 3530, 21, 30, 20, 0, -30 },
  { 3609, 20, 30, 20, 3, -30 },
  { 3684, 25, 30, 26, 2, -30 },
  { 3778, 22, 30, 22, 4, -30 },
  { 3861, 34, 30, 34, 4, -30 },
  { 3989, 27, 30, 22, -2, -30 },
  { 4091, 20, 30, 21, 4, -30 },
  { 4166, 23, 30, 20, -1, -30 },
  { 4253, 17, 37, 13, -1, -30 },
  { 4332, 9, 30, 16, 4, -30 },
  { 4366, 17, 37, 13, -3, -30 },
  { 4445, 20, 18, 21, 1, -30 },
  { 4490, 16, 3, 15, -4, 4 },
  { 4496, 8, 7, 12, 6, -32 },
  { 4503, 20, 23, 22, 2, -23 },
  { 4561, 21, 32, 22, 0, -32 },
  { 4645, 17, 23, 18, 2, -23 },
  { 4694, 22, 32, 23, 2, -32 },
  { 4782, 18, 23, 21, 2, -23 },
  { 4834, 23, 42, 13, -5, -32 },
  { 4955, 22, 33, 23, 0, -23 },
  { 5046, 21, 32, 23, 0, -32 },
  { 5130, 12, 32, 11, 0, -32 },
  { 5178, 17, 42, 11, -5, -32 },
  { 5268, 22, 32, 21, 0, -32 },
  { 5356, 12, 32, 11, 0, -32 },
  { 5404, 32, 23, 34, 0, -23 },
  { 5496, 21, 23, 23, 0, -23 },
  { 5557, 18, 23, 22, 2, -23 },
  { 5609, 23, 33, 22, -2, -23 },
  { 5704, 20, 33, 23, 2, -23 },
  { 5787, 17, 23, 16, 0, -23 },
  { 5836, 17, 23, 17, 0, -23 },
  { 5885, 13, 28, 14, 2, -28 },
  { 5931, 20, 23, 23, 2, -23 },
  { 5989, 19, 23, 19, 2, -23 },
  { 6044, 28, 23, 29, 3, -23 },
  { 6125, 23, 23, 20, -2, -23 },
  { 6192, 24, 33, 19, -3, -23 },
  { 6291, 19, 23, 17, -1, -23 },
  { 6346, 17, 37, 15, 0, -30 },
  { 6425, 4, 42, 20, 8, -32 },
  { 6446, 16, 37, 15, -2, -30 },
  { 6520, 19, 6, 22, 2, -18 },
};

const GFXfont NotoSans_SemiCondensed_SemiBoldItalic42pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_SemiBoldItalic42pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_SemiBoldItalic42pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC42PT7B_H_
