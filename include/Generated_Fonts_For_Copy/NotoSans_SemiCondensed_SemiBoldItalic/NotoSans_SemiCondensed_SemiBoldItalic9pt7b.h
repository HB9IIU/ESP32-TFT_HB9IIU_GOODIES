#ifndef _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC9PT7B_H_
#define _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC9PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-SemiBoldItalic.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_SemiBoldItalic9pt7bBitmaps[] PROGMEM = {
  0x00, 0x69, 0x21, 0x00, 0xB8, 0x2B, 0xD5, 0xF5, 0x30, 0x13, 0xD8, 0xC3,
  0x59, 0x88, 0x43, 0x2D, 0x3A, 0xB5, 0x59, 0x80, 0x11, 0x94, 0x4E, 0xCB,
  0xE0, 0xC0, 0x29, 0x49, 0x30, 0x24, 0x92, 0x4E, 0x2C, 0x7A, 0x27, 0xC8,
  0x40, 0xE0, 0xE0, 0x80, 0x12, 0x24, 0x88, 0x27, 0x5D, 0x99, 0x60, 0x75,
  0x24, 0x80, 0x25, 0x11, 0x24, 0xF0, 0x25, 0x16, 0x11, 0xE0, 0x13, 0x59,
  0xF2, 0x7A, 0x1C, 0x21, 0x70, 0x19, 0x10, 0xED, 0x49, 0x80, 0x78, 0x8C,
  0x44, 0x60, 0x22, 0xD4, 0x4D, 0x4B, 0xC0, 0x25, 0x55, 0x71, 0xE0, 0x40,
  0x80, 0x40, 0xA0, 0x3E, 0x18, 0x30, 0xFF, 0xE0, 0xCD, 0x80, 0x25, 0x12,
  0x40, 0xC0, 0x3C, 0xB6, 0xAD, 0x5B, 0xC8, 0x0E, 0x00, 0x18, 0xCA, 0x74,
  0xE4, 0x7A, 0x5C, 0xBD, 0x78, 0x11, 0x50, 0x8C, 0x21, 0xC0, 0x7A, 0x52,
  0x9D, 0xF8, 0x7A, 0x1C, 0x8C, 0x78, 0x7A, 0x1C, 0x8C, 0x40, 0x14, 0xA4,
  0x16, 0xC9, 0x27, 0x80, 0x6D, 0x27, 0x92, 0x4A, 0x60, 0x74, 0x44, 0x4C,
  0x32, 0x22, 0x24, 0x4C, 0x6D, 0x46, 0x1C, 0x52, 0x40, 0x64, 0x44, 0xCF,
  0x66, 0xCD, 0xAB, 0x6B, 0x56, 0x80, 0x65, 0x95, 0xD6, 0x9A, 0x60, 0x10,
  0xA4, 0x53, 0xC9, 0x27, 0x00, 0x7A, 0x56, 0xCC, 0x40, 0x10, 0xA4, 0x53,
  0xC9, 0x27, 0x04, 0x18, 0x7A, 0x54, 0xED, 0x48, 0x2B, 0x90, 0xC3, 0x0B,
  0x80, 0xF4, 0x44, 0x88, 0xDC, 0xA5, 0x2B, 0x70, 0x9D, 0xA9, 0x4C, 0x60,
  0x93, 0x6A, 0xD6, 0xCD, 0x93, 0x00, 0x24, 0x61, 0x0C, 0x2B, 0x20, 0xBA,
  0xC4, 0xC8, 0x78, 0x88, 0x8C, 0x78, 0x69, 0x29, 0x30, 0xAA, 0x50, 0x31,
  0x22, 0x22, 0xC0, 0x25, 0x59, 0xF0, 0xD0, 0x6A, 0xB5, 0x27, 0x00, 0x62,
  0x1C, 0xB5, 0x6B, 0xC0, 0x74, 0xC8, 0x60, 0x08, 0x5A, 0xAD, 0x49, 0xC0,
  0x75, 0xF8, 0x70, 0x19, 0x9C, 0x42, 0x11, 0x08, 0xC0, 0x6A, 0xB5, 0x27,
  0x0B, 0x80, 0x64, 0x75, 0x59, 0x90, 0x61, 0x25, 0xA0, 0x30, 0x22, 0x26,
  0x44, 0xC0, 0x62, 0x16, 0xE6, 0x52, 0x40, 0x69, 0x25, 0x20, 0x76, 0xB5,
  0x4C, 0xA9, 0x40, 0x75, 0x59, 0x90, 0x75, 0x99, 0x60, 0x72, 0xD5, 0xAF,
  0x42, 0x00, 0x6A, 0xB5, 0x27, 0x08, 0x80, 0x74, 0x4C, 0x80, 0x74, 0x62,
  0xE0, 0x5D, 0x2D, 0x80, 0x4A, 0x95, 0x27, 0x00, 0xDA, 0x98, 0xC4, 0x00,
  0xAF, 0xAE, 0xAC, 0xB0, 0x5B, 0x98, 0xCB, 0x00, 0x6C, 0xA3, 0x0C, 0x20,
  0x8C, 0x00, 0x72, 0x44, 0xE0, 0x32, 0x48, 0x44, 0x40, 0xFF, 0x80, 0x69,
  0x14, 0xA0, 0x6C, 0x80,
};

const GFXglyph NotoSans_SemiCondensed_SemiBoldItalic9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 3, 6, 2, 0, -6 },
  { 4, 3, 2, 4, 1, -6 },
  { 5, 5, 6, 5, 0, -6 },
  { 9, 5, 8, 5, 0, -7 },
  { 14, 6, 7, 7, 1, -7 },
  { 20, 5, 7, 6, 0, -7 },
  { 25, 1, 2, 2, 1, -6 },
  { 26, 3, 7, 3, 0, -6 },
  { 29, 3, 8, 3, -1, -7 },
  { 32, 4, 4, 4, 1, -7 },
  { 34, 5, 4, 5, 0, -5 },
  { 37, 2, 2, 2, 0, -1 },
  { 38, 3, 1, 3, 0, -3 },
  { 39, 1, 1, 2, 0, -1 },
  { 40, 4, 6, 3, 0, -6 },
  { 43, 4, 7, 5, 0, -7 },
  { 47, 3, 6, 5, 1, -6 },
  { 50, 4, 7, 5, 0, -7 },
  { 54, 4, 7, 5, 0, -7 },
  { 58, 4, 6, 5, 0, -6 },
  { 61, 5, 6, 5, 0, -6 },
  { 65, 5, 7, 5, 0, -7 },
  { 70, 5, 6, 5, 0, -6 },
  { 74, 5, 7, 5, 0, -7 },
  { 79, 4, 7, 5, 0, -7 },
  { 83, 2, 5, 2, 0, -5 },
  { 85, 2, 6, 2, 0, -5 },
  { 87, 5, 4, 5, 0, -5 },
  { 90, 4, 2, 5, 0, -4 },
  { 91, 5, 4, 5, 0, -5 },
  { 94, 4, 7, 4, 0, -7 },
  { 98, 7, 7, 7, 0, -6 },
  { 105, 5, 6, 5, -1, -6 },
  { 109, 5, 6, 5, 0, -6 },
  { 113, 5, 7, 5, 0, -7 },
  { 118, 5, 6, 5, 0, -6 },
  { 122, 5, 6, 4, 0, -6 },
  { 126, 5, 6, 4, 0, -6 },
  { 130, 6, 7, 6, 0, -7 },
  { 136, 6, 6, 6, 0, -6 },
  { 141, 4, 6, 3, 0, -6 },
  { 144, 4, 8, 3, -1, -6 },
  { 148, 6, 6, 5, 0, -6 },
  { 153, 4, 6, 4, 0, -6 },
  { 156, 7, 6, 7, 0, -6 },
  { 162, 6, 6, 6, 0, -6 },
  { 167, 6, 7, 6, 0, -7 },
  { 173, 5, 6, 5, 0, -6 },
  { 177, 6, 9, 6, 0, -7 },
  { 184, 5, 6, 5, 0, -6 },
  { 188, 5, 7, 4, 0, -7 },
  { 193, 4, 6, 4, 1, -6 },
  { 196, 5, 6, 6, 1, -6 },
  { 200, 5, 6, 5, 1, -6 },
  { 204, 7, 6, 7, 1, -6 },
  { 210, 6, 6, 5, -1, -6 },
  { 215, 4, 6, 4, 1, -6 },
  { 218, 5, 6, 4, 0, -6 },
  { 222, 3, 7, 3, 0, -6 },
  { 225, 2, 6, 3, 1, -6 },
  { 227, 4, 7, 3, -1, -6 },
  { 231, 4, 4, 5, 0, -6 },
  { 233, 4, 1, 3, -1, 1 },
  { 234, 2, 2, 3, 1, -7 },
  { 235, 5, 5, 5, 0, -5 },
  { 239, 5, 7, 5, 0, -7 },
  { 244, 4, 5, 4, 0, -5 },
  { 247, 5, 7, 5, 0, -7 },
  { 252, 4, 5, 4, 0, -5 },
  { 255, 5, 9, 3, -1, -7 },
  { 261, 5, 7, 5, 0, -5 },
  { 266, 4, 7, 5, 0, -7 },
  { 270, 3, 7, 2, 0, -7 },
  { 273, 4, 9, 2, -1, -7 },
  { 278, 5, 7, 4, 0, -7 },
  { 283, 3, 7, 2, 0, -7 },
  { 286, 7, 5, 7, 0, -5 },
  { 291, 4, 5, 5, 0, -5 },
  { 294, 4, 5, 5, 0, -5 },
  { 297, 5, 7, 5, 0, -5 },
  { 302, 5, 7, 5, 0, -5 },
  { 307, 4, 5, 3, 0, -5 },
  { 310, 4, 5, 4, 0, -5 },
  { 313, 3, 6, 3, 0, -6 },
  { 316, 5, 5, 5, 0, -5 },
  { 320, 5, 5, 4, 0, -5 },
  { 324, 6, 5, 6, 1, -5 },
  { 328, 5, 5, 4, 0, -5 },
  { 332, 6, 7, 4, -1, -5 },
  { 338, 4, 5, 4, 0, -5 },
  { 341, 4, 7, 3, 0, -6 },
  { 345, 1, 9, 4, 2, -7 },
  { 347, 3, 7, 3, 0, -6 },
  { 350, 5, 2, 5, 0, -4 },
};

const GFXfont NotoSans_SemiCondensed_SemiBoldItalic9pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_SemiBoldItalic9pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_SemiBoldItalic9pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC9PT7B_H_
