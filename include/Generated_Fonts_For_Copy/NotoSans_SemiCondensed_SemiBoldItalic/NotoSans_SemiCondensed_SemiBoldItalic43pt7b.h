#ifndef _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC43PT7B_H_
#define _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC43PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-SemiBoldItalic.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_SemiBoldItalic43pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x1F, 0x80, 0xFC, 0x0F, 0xE0,
  0x7E, 0x01, 0xF0, 0x02, 0x00, 0x3E, 0x3E, 0x7C, 0xF8, 0xF1, 0xF3, 0xE3,
  0xE7, 0xC7, 0xCF, 0x0F, 0x1E, 0x1E, 0x3C, 0x3C, 0x78, 0xF0, 0xE1, 0xE3,
  0xC3, 0xC0, 0x00, 0x3C, 0x1C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00,
  0x38, 0x3C, 0x00, 0x78, 0x78, 0x00, 0x78, 0x78, 0x00, 0x78, 0x78, 0x00,
  0xF0, 0x70, 0x00, 0xF0, 0xF0, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x01, 0xC1, 0xE0, 0x03, 0xC1, 0xC0, 0x03,
  0xC3, 0xC0, 0x03, 0xC3, 0xC0, 0x07, 0x83, 0x80, 0x07, 0x87, 0x80, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x0F, 0x0F, 0x00, 0x0E,
  0x0F, 0x00, 0x1E, 0x0E, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1C,
  0x1C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x38, 0x3C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x07, 0xFC,
  0x00, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xDC, 0xE0, 0x7C,
  0xE1, 0x07, 0xC6, 0x00, 0x3E, 0x30, 0x01, 0xF3, 0x80, 0x0F, 0xDC, 0x00,
  0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x80, 0x06, 0xFC, 0x00, 0x33, 0xE0, 0x03, 0x9F, 0x00,
  0x1C, 0xF8, 0x00, 0xC7, 0xC6, 0x06, 0x7E, 0x3E, 0x77, 0xE1, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x07, 0xC0,
  0x03, 0xC0, 0x7F, 0x80, 0x3E, 0x07, 0xFC, 0x01, 0xE0, 0x7D, 0xF0, 0x1E,
  0x07, 0xC7, 0x81, 0xF0, 0x3C, 0x3C, 0x0F, 0x01, 0xE1, 0xE0, 0xF0, 0x1E,
  0x0F, 0x0F, 0x80, 0xF0, 0x78, 0x78, 0x07, 0x87, 0x87, 0x80, 0x3C, 0x3C,
  0x7C, 0x01, 0xE1, 0xE3, 0xC0, 0x0F, 0x0F, 0x3C, 0x3C, 0x78, 0xF3, 0xE7,
  0xF3, 0xC7, 0x9E, 0x7F, 0xDF, 0xF9, 0xE7, 0xFE, 0xFF, 0xDF, 0x7C, 0xFB,
  0xFC, 0xF3, 0xC3, 0xCF, 0x8F, 0x1E, 0x1E, 0x00, 0xF9, 0xE0, 0xF0, 0x07,
  0x8F, 0x0F, 0x80, 0x78, 0x78, 0x78, 0x07, 0xC3, 0xC3, 0xC0, 0x3C, 0x1E,
  0x1E, 0x03, 0xC1, 0xF0, 0xF0, 0x3E, 0x0F, 0x0F, 0x01, 0xE0, 0x7C, 0x78,
  0x1E, 0x01, 0xE7, 0x81, 0xF0, 0x0F, 0xFC, 0x0F, 0x00, 0x7F, 0xC0, 0xF0,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x87,
  0xC0, 0x07, 0x83, 0xE0, 0x03, 0xC1, 0xF0, 0x01, 0xE1, 0xF0, 0x00, 0xF9,
  0xF8, 0x00, 0x7D, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x1F, 0x0F, 0xFC, 0x1F, 0x9F, 0xFF, 0x0F, 0x8F,
  0x8F, 0x87, 0xCF, 0x87, 0xE7, 0xCF, 0xC1, 0xF7, 0xE7, 0xC0, 0xFF, 0xE3,
  0xE0, 0x3F, 0xE1, 0xF0, 0x0F, 0xF0, 0xF8, 0x07, 0xF0, 0x7C, 0x03, 0xF8,
  0x3F, 0x07, 0xFC, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xE7,
  0xE0, 0x7F, 0xC1, 0xF8, 0x3E, 0x7C, 0xF3, 0xE7, 0xCF, 0x9E, 0x3C, 0x78,
  0xE3, 0xC0, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8,
  0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0xC0,
  0x0F, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0,
  0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0x1F,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x40,
  0xF0, 0x1C, 0x3C, 0x0F, 0xCE, 0x03, 0xFF, 0x9F, 0x7F, 0xFF, 0xC3, 0xFF,
  0xF0, 0x3F, 0xFC, 0x1F, 0xC1, 0x0F, 0xF0, 0x0F, 0xDE, 0x07, 0xE7, 0x81,
  0xF1, 0xF0, 0x38, 0x3C, 0x02, 0x0F, 0x80, 0x03, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x8F, 0xC7, 0xC3, 0xE3, 0xE1, 0xF0, 0xF0, 0xF8, 0x78,
  0x7C, 0x3C, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFC, 0x3C, 0xFD,
  0xFF, 0xFF, 0xCF, 0x8C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xFC,
  0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xF3, 0xF0, 0x7C, 0x1F, 0x0F, 0xC1,
  0xF1, 0xF8, 0x1F, 0x1F, 0x01, 0xF1, 0xF0, 0x1F, 0x3F, 0x01, 0xF3, 0xE0,
  0x1F, 0x3E, 0x01, 0xF7, 0xE0, 0x1F, 0x7E, 0x01, 0xF7, 0xC0, 0x3F, 0x7C,
  0x03, 0xF7, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x7E, 0xFC, 0x07, 0xEF,
  0xC0, 0x7C, 0xFC, 0x0F, 0xC7, 0xC0, 0xF8, 0x7C, 0x1F, 0x87, 0xC1, 0xF0,
  0x7E, 0x3F, 0x07, 0xFF, 0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0x80, 0x0F, 0xF0,
  0x00, 0x00, 0x7C, 0x03, 0xF0, 0x1F, 0xC1, 0xFE, 0x0F, 0xF8, 0xFF, 0xE7,
  0xFF, 0xBF, 0xBC, 0xF9, 0xF1, 0xC7, 0xC2, 0x1F, 0x00, 0x7C, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x03,
  0xFF, 0xC0, 0x1F, 0xFF, 0x81, 0xFF, 0xFE, 0x03, 0xFB, 0xFC, 0x07, 0x03,
  0xF0, 0x18, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xFF, 0xFE, 0x1F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x0F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3E, 0x3F, 0x81,
  0x80, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0xFF, 0xE0, 0x07,
  0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xC4, 0x00, 0x7E, 0x38, 0x0F, 0xF1, 0xFF, 0xFF, 0x0F,
  0xFF, 0xF0, 0x7F, 0xFF, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF8,
  0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x3D, 0xF0, 0x03, 0xDF, 0x00, 0x3E,
  0xF8, 0x03, 0xE7, 0xC0, 0x3E, 0x3E, 0x01, 0xE1, 0xE0, 0x1E, 0x1F, 0x01,
  0xF0, 0xF8, 0x1F, 0x07, 0xC0, 0xF0, 0x3E, 0x0F, 0x03, 0xE0, 0xF8, 0x1F,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0x80,
  0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x7F, 0xFE, 0x03, 0xFF, 0xF0,
  0x08, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x84,
  0x00, 0xFC, 0x38, 0x1F, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xF0,
  0x1F, 0xFF, 0x03, 0xF8, 0x20, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE3, 0x80, 0x7C, 0xFF,
  0x07, 0xDF, 0xF8, 0x7F, 0xFF, 0x8F, 0xFF, 0xFC, 0xFE, 0x0F, 0xCF, 0xC0,
  0x7C, 0xFC, 0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x07, 0xCF, 0x80, 0x7C, 0xF8,
  0x0F, 0x8F, 0x80, 0xF8, 0xF8, 0x1F, 0x8F, 0x81, 0xF0, 0xFC, 0x3F, 0x07,
  0xFF, 0xE0, 0x7F, 0xFC, 0x03, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x1F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x0F,
  0xFF, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x7C, 0x1F, 0x07, 0xE0, 0xFC,
  0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x81, 0xF8, 0x7C, 0x0F, 0x83, 0xE0,
  0xFC, 0x0F, 0x8F, 0xC0, 0x7E, 0xFC, 0x01, 0xFF, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0xFC, 0xFC, 0x0F, 0xC3, 0xE0, 0xFC, 0x1F,
  0x8F, 0xC0, 0x7C, 0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8,
  0x07, 0xC7, 0xC0, 0x3E, 0x3F, 0x03, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF0,
  0x1F, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xF8, 0x03,
  0xFF, 0xC0, 0x7F, 0xFE, 0x0F, 0xC7, 0xE1, 0xF8, 0x3F, 0x1F, 0x01, 0xF1,
  0xF0, 0x1F, 0x3E, 0x01, 0xF3, 0xE0, 0x1F, 0x3E, 0x01, 0xF3, 0xE0, 0x3F,
  0x3E, 0x03, 0xF3, 0xE0, 0x3F, 0x3E, 0x07, 0xE3, 0xF9, 0xFE, 0x3F, 0xFF,
  0xE1, 0xFF, 0xBE, 0x0F, 0xF3, 0xE0, 0x7E, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x80,
  0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x00,
  0x01, 0x81, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0x70, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC1,
  0xF8, 0x7E, 0x3F, 0x8F, 0xC1, 0xF0, 0x20, 0x00, 0x00, 0x60, 0x1F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x1F, 0x81, 0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x7C,
  0x07, 0x80, 0xF0, 0x0F, 0x00, 0x00, 0x00, 0x30, 0x00, 0x0F, 0x00, 0x03,
  0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x30, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xE0,
  0x0F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x00,
  0xFC, 0x00, 0x0F, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x0F, 0xFF,
  0x0F, 0xFF, 0xC7, 0xFF, 0xE1, 0xE3, 0xF0, 0x80, 0xFC, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x01,
  0xF0, 0x00, 0x60, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0x80, 0x1F, 0x00,
  0x7C, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x1E, 0x1F,
  0x00, 0x40, 0x3C, 0x3C, 0x0F, 0xFC, 0x78, 0xF0, 0x3F, 0xF8, 0x71, 0xE0,
  0xFF, 0xF0, 0xF7, 0x83, 0xE1, 0xC1, 0xEF, 0x0F, 0x87, 0x83, 0x9E, 0x1E,
  0x0F, 0x07, 0x78, 0x78, 0x1E, 0x1E, 0xF0, 0xF0, 0x78, 0x3D, 0xE1, 0xE0,
  0xF0, 0x7B, 0xC7, 0x81, 0xE0, 0xF7, 0x8F, 0x03, 0xC3, 0xCE, 0x1E, 0x0F,
  0x07, 0x9C, 0x3C, 0x1E, 0x1E, 0x38, 0x7C, 0x7C, 0x7C, 0x78, 0x7F, 0xFF,
  0xF0, 0xF0, 0xFF, 0x3F, 0xC1, 0xE0, 0xFC, 0x7F, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0xC0, 0x06, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xBC, 0x00, 0x0F, 0xBC, 0x00, 0x0F, 0xBC, 0x00, 0x1F, 0x3C, 0x00,
  0x1F, 0x3C, 0x00, 0x3E, 0x3C, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x3E, 0x00,
  0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x3E, 0x01,
  0xF0, 0x3E, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07,
  0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x1F,
  0x80, 0x3F, 0x1F, 0x00, 0x1F, 0x3F, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x7E,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xF8, 0x1F, 0xC1, 0xF0,
  0x1F, 0x83, 0xE0, 0x3F, 0x07, 0xC0, 0x7E, 0x1F, 0x80, 0xF8, 0x3E, 0x01,
  0xF0, 0x7C, 0x07, 0xE0, 0xF8, 0x3F, 0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xF0,
  0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x3E, 0x0F, 0xE0, 0xFC, 0x07, 0xC1,
  0xF0, 0x0F, 0x83, 0xE0, 0x1F, 0x87, 0xC0, 0x3F, 0x0F, 0x80, 0x7E, 0x3F,
  0x00, 0xF8, 0x7C, 0x03, 0xF0, 0xF8, 0x0F, 0xE1, 0xF0, 0x7F, 0x83, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F,
  0xEF, 0xC0, 0xFE, 0x01, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x80, 0xFE, 0x0E, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x01, 0xFF,
  0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x03,
  0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x07, 0xE0, 0xFE, 0x07,
  0xC0, 0x7E, 0x07, 0xC0, 0x3F, 0x07, 0xC0, 0x3F, 0x0F, 0xC0, 0x1F, 0x0F,
  0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x1F,
  0x80, 0x3F, 0x1F, 0x00, 0x3F, 0x1F, 0x00, 0x3F, 0x1F, 0x00, 0x3E, 0x3F,
  0x00, 0x3E, 0x3F, 0x00, 0x7E, 0x3E, 0x00, 0x7E, 0x3E, 0x00, 0xFC, 0x3E,
  0x01, 0xFC, 0x7E, 0x01, 0xF8, 0x7C, 0x03, 0xF0, 0x7C, 0x0F, 0xF0, 0x7F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF,
  0xF0, 0x7F, 0xFF, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xFF,
  0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x7F,
  0xFF, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F,
  0xF7, 0xF0, 0x3F, 0x80, 0x30, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x1F, 0xF8, 0xF8, 0x0F, 0xFC,
  0x7C, 0x07, 0xFE, 0x7E, 0x07, 0xFE, 0x3F, 0x03, 0xFF, 0x1F, 0x80, 0x0F,
  0x8F, 0xC0, 0x0F, 0xC7, 0xE0, 0x07, 0xC3, 0xF0, 0x03, 0xE0, 0xF8, 0x01,
  0xF0, 0x7E, 0x00, 0xF8, 0x3F, 0x80, 0xFC, 0x0F, 0xE0, 0x7C, 0x07, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x03,
  0xF0, 0x07, 0xE0, 0x7C, 0x00, 0xF8, 0x0F, 0x80, 0x1F, 0x01, 0xF0, 0x03,
  0xE0, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x01, 0xF0, 0x03, 0xE0, 0x3E,
  0x00, 0x7C, 0x07, 0xC0, 0x0F, 0x81, 0xF8, 0x03, 0xF0, 0x3E, 0x00, 0x7C,
  0x07, 0xC0, 0x0F, 0x80, 0xF8, 0x01, 0xF0, 0x1F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xE0, 0x07, 0xC0,
  0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x3E, 0x03, 0xE0, 0x07, 0xC0, 0x7C, 0x00,
  0xF8, 0x0F, 0x80, 0x1F, 0x03, 0xF0, 0x07, 0xE0, 0x7C, 0x00, 0xF8, 0x0F,
  0x80, 0x1F, 0x01, 0xF0, 0x03, 0xE0, 0x3E, 0x00, 0x7C, 0x0F, 0xC0, 0x1F,
  0x81, 0xF0, 0x03, 0xE0, 0x3E, 0x00, 0x7C, 0x00, 0x03, 0xFF, 0xC0, 0xFF,
  0xF0, 0x3F, 0xFC, 0x1F, 0xFE, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0xFF, 0x80, 0xFF,
  0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x07, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x07, 0xE0, 0x00, 0x03, 0xE0,
  0x0F, 0xC0, 0xF8, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x0F, 0x81, 0xF8, 0x07,
  0xE0, 0x7E, 0x01, 0xF0, 0x3F, 0x00, 0x7C, 0x1F, 0x80, 0x1F, 0x0F, 0xC0,
  0x07, 0xC7, 0xE0, 0x03, 0xF1, 0xF0, 0x00, 0xF8, 0xFC, 0x00, 0x3E, 0x7E,
  0x00, 0x0F, 0xBF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xF7, 0xC0, 0x00, 0x7F,
  0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFB, 0xF0, 0x00,
  0xFC, 0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x87, 0xE0, 0x03, 0xE1, 0xF8,
  0x01, 0xF8, 0x3E, 0x00, 0x7C, 0x0F, 0xC0, 0x1F, 0x03, 0xF0, 0x07, 0xC0,
  0x7C, 0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3E, 0x00, 0xF8, 0x0F,
  0x80, 0x3F, 0x00, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07,
  0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0xFE, 0x00,
  0x0F, 0xF0, 0x3F, 0x80, 0x07, 0xF8, 0x0F, 0xE0, 0x01, 0xFE, 0x07, 0xFC,
  0x00, 0xFF, 0x81, 0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x1F, 0xF0, 0x1E,
  0xF0, 0x07, 0xBC, 0x07, 0xBC, 0x03, 0xFF, 0x03, 0xEF, 0x00, 0xF7, 0xC0,
  0xFB, 0xC0, 0x7D, 0xF0, 0x3E, 0xF0, 0x1E, 0x78, 0x0F, 0x3C, 0x0F, 0xBE,
  0x03, 0xCF, 0x03, 0xCF, 0x81, 0xF3, 0xC1, 0xF3, 0xE0, 0x7C, 0xF0, 0x78,
  0xF8, 0x1F, 0x3C, 0x3E, 0x7C, 0x07, 0x8F, 0x0F, 0x1F, 0x03, 0xE3, 0xC7,
  0xC7, 0xC0, 0xF8, 0xF9, 0xE1, 0xF0, 0x3E, 0x3E, 0xF8, 0x7C, 0x0F, 0x8F,
  0xBC, 0x3E, 0x03, 0xC3, 0xFF, 0x0F, 0x81, 0xF0, 0x7F, 0x83, 0xE0, 0x7C,
  0x1F, 0xE0, 0xF8, 0x1F, 0x07, 0xF0, 0x3E, 0x07, 0xC1, 0xFC, 0x1F, 0x01,
  0xE0, 0x7E, 0x07, 0xC0, 0xF8, 0x1F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x00, 0x03, 0xF0, 0x01, 0xF0, 0x3F, 0x80, 0x1F,
  0x03, 0xF8, 0x01, 0xF0, 0x3F, 0x80, 0x1F, 0x07, 0xF8, 0x01, 0xE0, 0x7F,
  0xC0, 0x3E, 0x07, 0xFC, 0x03, 0xE0, 0x7F, 0xC0, 0x3E, 0x07, 0xBC, 0x03,
  0xE0, 0xFB, 0xE0, 0x7C, 0x0F, 0xBE, 0x07, 0xC0, 0xFB, 0xE0, 0x7C, 0x0F,
  0x1F, 0x07, 0xC0, 0xF1, 0xF0, 0x78, 0x1F, 0x1F, 0x0F, 0x81, 0xF0, 0xF0,
  0xF8, 0x1F, 0x0F, 0x8F, 0x81, 0xE0, 0xF8, 0xF8, 0x3E, 0x0F, 0x8F, 0x03,
  0xE0, 0x7D, 0xF0, 0x3E, 0x07, 0xDF, 0x03, 0xE0, 0x7D, 0xF0, 0x3C, 0x03,
  0xDF, 0x07, 0xC0, 0x3F, 0xE0, 0x7C, 0x03, 0xFE, 0x07, 0xC0, 0x3F, 0xE0,
  0x7C, 0x01, 0xFE, 0x07, 0x80, 0x1F, 0xE0, 0xF8, 0x01, 0xFC, 0x0F, 0x80,
  0x0F, 0xC0, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xDF, 0xF0, 0x3F, 0x81,
  0xF8, 0x3F, 0x00, 0x7E, 0x3F, 0x80, 0x3F, 0x1F, 0x80, 0x1F, 0x9F, 0x80,
  0x07, 0xCF, 0xC0, 0x03, 0xE7, 0xC0, 0x01, 0xF7, 0xE0, 0x00, 0xFB, 0xF0,
  0x00, 0xFD, 0xF0, 0x00, 0x7E, 0xF8, 0x00, 0x3F, 0x7C, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xBF, 0x00, 0x0F, 0xDF, 0x80, 0x07, 0xEF, 0xC0, 0x03, 0xE7,
  0xE0, 0x03, 0xF3, 0xF0, 0x01, 0xF8, 0xF8, 0x01, 0xF8, 0x7E, 0x01, 0xFC,
  0x3F, 0x01, 0xFC, 0x1F, 0xE1, 0xFC, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF,
  0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0xF8, 0x1F,
  0x81, 0xF0, 0x1F, 0x83, 0xE0, 0x3F, 0x07, 0xC0, 0x7E, 0x1F, 0x80, 0xFC,
  0x3E, 0x01, 0xF8, 0x7C, 0x03, 0xE0, 0xF8, 0x0F, 0xC1, 0xF0, 0x1F, 0x87,
  0xE0, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF,
  0xFC, 0x01, 0xFF, 0xC0, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x7F,
  0xFF, 0xC0, 0x3F, 0xDF, 0xF0, 0x3F, 0x81, 0xF8, 0x3F, 0x00, 0x7E, 0x3F,
  0x00, 0x3F, 0x1F, 0x80, 0x1F, 0x9F, 0x80, 0x07, 0xCF, 0xC0, 0x03, 0xE7,
  0xC0, 0x01, 0xF7, 0xE0, 0x00, 0xFB, 0xF0, 0x00, 0xFD, 0xF0, 0x00, 0x7E,
  0xF8, 0x00, 0x3F, 0x7C, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xBF, 0x00, 0x0F,
  0xDF, 0x80, 0x07, 0xEF, 0xC0, 0x03, 0xE7, 0xE0, 0x03, 0xF3, 0xF0, 0x01,
  0xF8, 0xF8, 0x01, 0xF8, 0x7E, 0x01, 0xFC, 0x3F, 0x01, 0xFC, 0x1F, 0xE3,
  0xFC, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80,
  0x03, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0xFF, 0xFE, 0x07,
  0xFF, 0xF8, 0x1F, 0x03, 0xF0, 0x7C, 0x0F, 0xC1, 0xF0, 0x1F, 0x07, 0xC0,
  0x7C, 0x3F, 0x01, 0xF0, 0xF8, 0x0F, 0xC3, 0xE0, 0x3F, 0x0F, 0x81, 0xF8,
  0x3E, 0x0F, 0xE1, 0xF9, 0xFF, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x7F,
  0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0x87, 0xC0, 0x3E, 0x1F, 0x00, 0xF8, 0x7E,
  0x03, 0xE0, 0xF8, 0x1F, 0x83, 0xE0, 0x7C, 0x0F, 0xC1, 0xF0, 0x1F, 0x07,
  0xC0, 0x7C, 0x1F, 0x01, 0xF8, 0xFC, 0x07, 0xE3, 0xE0, 0x0F, 0x8F, 0x80,
  0x3F, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF,
  0xFE, 0x07, 0xFF, 0xF0, 0x1F, 0x80, 0xC0, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC3, 0x00,
  0x7E, 0x0F, 0x83, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xF0,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x07,
  0xC1, 0xF0, 0x03, 0xE1, 0xF8, 0x03, 0xF0, 0xF8, 0x01, 0xF0, 0x7C, 0x00,
  0xF8, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x0F, 0x80,
  0x1F, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xC3, 0xF0, 0x07, 0xE1, 0xF8,
  0x03, 0xF0, 0xF8, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x3F,
  0x00, 0x7E, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x0F, 0x83,
  0xE0, 0x0F, 0xC1, 0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xE0, 0x7C, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x1F, 0xC3, 0xF8, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xF8,
  0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xF8, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x80, 0x0F, 0xBE, 0x00, 0x7E, 0xF8, 0x01, 0xF3, 0xE0, 0x07, 0xCF,
  0x80, 0x3E, 0x3E, 0x00, 0xF8, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x07, 0x80,
  0xFC, 0x1E, 0x03, 0xE0, 0x78, 0x1F, 0x81, 0xF0, 0x7C, 0x07, 0xC3, 0xF0,
  0x1F, 0x0F, 0x80, 0x7C, 0x7E, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x1F,
  0x3E, 0x00, 0x7C, 0xF8, 0x01, 0xF7, 0xC0, 0x07, 0xDF, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x01, 0xF0,
  0x07, 0xFF, 0x00, 0x7E, 0x00, 0xFB, 0xE0, 0x0F, 0xC0, 0x3F, 0x7C, 0x01,
  0xF8, 0x07, 0xCF, 0x80, 0x7F, 0x01, 0xF9, 0xF0, 0x0F, 0xE0, 0x3E, 0x3E,
  0x03, 0xFC, 0x07, 0xC7, 0xC0, 0x7F, 0x81, 0xF0, 0xF8, 0x1F, 0xF0, 0x3E,
  0x1F, 0x03, 0xFE, 0x0F, 0xC3, 0xE0, 0xFF, 0xC1, 0xF0, 0x7C, 0x1E, 0xF8,
  0x3E, 0x0F, 0x83, 0xDF, 0x0F, 0x81, 0xF0, 0xFB, 0xE1, 0xF0, 0x3E, 0x1E,
  0x7C, 0x7C, 0x07, 0xC7, 0xCF, 0x8F, 0x80, 0xF8, 0xF0, 0xF1, 0xF0, 0x1F,
  0x3E, 0x1E, 0x7C, 0x03, 0xE7, 0x83, 0xCF, 0x80, 0x7C, 0xF0, 0x7B, 0xE0,
  0x0F, 0xBE, 0x0F, 0x7C, 0x01, 0xF7, 0x81, 0xEF, 0x00, 0x3F, 0xF0, 0x3F,
  0xE0, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x1F, 0xE0,
  0x1F, 0xE0, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x0F,
  0xE0, 0x0F, 0xC0, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF0, 0x03, 0xF0, 0x1F, 0x00, 0x7E, 0x01, 0xF8, 0x0F, 0xC0,
  0x0F, 0x80, 0xF8, 0x00, 0xF8, 0x1F, 0x80, 0x0F, 0x83, 0xF0, 0x00, 0xFC,
  0x3E, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x7C, 0xFC, 0x00, 0x07, 0xCF, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xF7, 0xE0, 0x00, 0x3F, 0x3E, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x7C, 0x3F,
  0x00, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x1F, 0x00, 0x1F, 0x01, 0xF0, 0x03,
  0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x0F, 0x80, 0xFC, 0x00,
  0xFC, 0x00, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xBE, 0x00, 0xFC, 0xF8, 0x0F,
  0xC7, 0xC0, 0x7C, 0x3E, 0x07, 0xE1, 0xF0, 0x3E, 0x0F, 0x83, 0xE0, 0x3E,
  0x3F, 0x01, 0xF1, 0xF0, 0x0F, 0x9F, 0x80, 0x7C, 0xF8, 0x03, 0xEF, 0x80,
  0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x20, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0xE0, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0xF0, 0x0F,
  0xF8, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0xF0, 0xF0, 0xF0, 0xF0, 0xF8, 0xF8,
  0xF8, 0x78, 0x78, 0x78, 0x78, 0x7C, 0x7C, 0x7C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3E, 0x3E, 0x3E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1F, 0x1F, 0x1F, 0x0F, 0x0F,
  0x0F, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xE0, 0x3F, 0xE0, 0x00, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03,
  0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x00, 0x1C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x03, 0xCF, 0x00, 0x7C, 0x78, 0x07,
  0x87, 0x80, 0xF0, 0x78, 0x0F, 0x03, 0xC1, 0xE0, 0x3C, 0x3E, 0x03, 0xC3,
  0xC0, 0x1E, 0x7C, 0x01, 0xE7, 0x80, 0x1E, 0xF0, 0x00, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xC0, 0xFC, 0x7C, 0x7E, 0x3E, 0x1E, 0x0F, 0x0F,
  0x00, 0xE0, 0x08, 0x1F, 0xC7, 0x81, 0xFF, 0x3C, 0x1F, 0xFF, 0xE1, 0xFF,
  0xFF, 0x1F, 0xC3, 0xF8, 0xFC, 0x1F, 0x8F, 0xC0, 0x7C, 0x7E, 0x03, 0xE3,
  0xE0, 0x1F, 0x3F, 0x01, 0xF9, 0xF8, 0x0F, 0x8F, 0x80, 0x7C, 0x7C, 0x03,
  0xE3, 0xE0, 0x3F, 0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0x87, 0xC0, 0xFC, 0x3E,
  0x0F, 0xE1, 0xF8, 0xFF, 0x0F, 0xFF, 0xF0, 0x3F, 0xF7, 0x81, 0xFF, 0x3C,
  0x07, 0xF3, 0xE0, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x7E, 0x38, 0x03, 0xE7, 0xF0, 0x1F, 0x7F, 0xC0, 0xFF,
  0xFF, 0x07, 0xFF, 0xF8, 0x7F, 0x07, 0xC3, 0xF0, 0x3E, 0x1F, 0x81, 0xF8,
  0xF8, 0x0F, 0x87, 0xC0, 0x7C, 0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x00,
  0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x7E, 0x7C, 0x03, 0xE3, 0xE0, 0x3F, 0x1F,
  0x01, 0xF0, 0xFC, 0x1F, 0x8F, 0xE1, 0xF8, 0x7F, 0xFF, 0xC3, 0xDF, 0xFC,
  0x1E, 0x7F, 0xC0, 0xF1, 0xFC, 0x00, 0x00, 0x78, 0x01, 0xFF, 0xC1, 0xFF,
  0xE1, 0xFF, 0xE1, 0xFF, 0xF1, 0xFC, 0x08, 0xFC, 0x00, 0xFC, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x83,
  0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x01,
  0xC1, 0xF0, 0x0F, 0xE7, 0xC0, 0x3F, 0xEF, 0x80, 0xFF, 0xFF, 0x03, 0xFF,
  0xFE, 0x0F, 0xC1, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x03, 0xE0, 0xF8, 0x07,
  0xC1, 0xF0, 0x0F, 0x87, 0xE0, 0x3E, 0x0F, 0x80, 0x7C, 0x1F, 0x00, 0xF8,
  0x3E, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0xF8, 0x0F, 0x81, 0xF0, 0x1F, 0x03,
  0xE0, 0x7E, 0x07, 0xC1, 0xFC, 0x0F, 0xC7, 0xF8, 0x1F, 0xFF, 0xE0, 0x1F,
  0xFB, 0xC0, 0x3F, 0xE7, 0x80, 0x3F, 0x8F, 0x00, 0x00, 0x38, 0x00, 0x7F,
  0xC0, 0x7F, 0xF8, 0x3F, 0xFF, 0x1F, 0xCF, 0xCF, 0xC1, 0xF3, 0xE0, 0x7D,
  0xF8, 0x1F, 0x7C, 0x0F, 0xDF, 0x07, 0xEF, 0x9F, 0xFB, 0xFF, 0xFC, 0xFF,
  0xFC, 0x3F, 0xFC, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xF0, 0x18, 0x7F, 0xFE, 0x1F, 0xFF, 0x83, 0xFF, 0xE0,
  0x7F, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xFE, 0x00, 0x07, 0xE4, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x08, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x38, 0x02, 0x01, 0xFE, 0x78, 0x07, 0xFC, 0xF0, 0x1F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xC1, 0xFC, 0x3F, 0x83, 0xF0, 0x7E, 0x0F, 0xC0, 0x7C, 0x1F, 0x80,
  0xF8, 0x3E, 0x01, 0xF0, 0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0x83, 0xE0, 0x1F,
  0x07, 0xC0, 0x3E, 0x0F, 0x80, 0xFC, 0x1F, 0x01, 0xF0, 0x3E, 0x07, 0xE0,
  0x7C, 0x0F, 0xC0, 0xF8, 0x3F, 0x81, 0xF8, 0xFF, 0x03, 0xFF, 0xFC, 0x07,
  0xFF, 0xF8, 0x07, 0xFD, 0xF0, 0x07, 0xE3, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x08, 0x01, 0xF0, 0x1C, 0x07,
  0xE0, 0x3F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0xFC, 0x38, 0x0F, 0x9F, 0xE0, 0xFB, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x1F, 0xE1, 0xF1, 0xFC, 0x1F, 0x1F, 0x81, 0xF1, 0xF0, 0x1F, 0x1F, 0x01,
  0xF3, 0xF0, 0x1F, 0x3E, 0x03, 0xE3, 0xE0, 0x3E, 0x3E, 0x03, 0xE3, 0xE0,
  0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0xFC,
  0x07, 0xCF, 0x80, 0xFC, 0xF8, 0x0F, 0x8F, 0x80, 0xF8, 0xF8, 0x0F, 0x80,
  0x01, 0xE0, 0x7C, 0x1F, 0x83, 0xF0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x41, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x3F, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0xFC, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x83, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0xFC, 0x00, 0xFC, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x3F, 0x00, 0x10, 0xF8, 0x0F, 0x83, 0xE0, 0x7C, 0x0F,
  0x83, 0xE0, 0x3E, 0x1F, 0x01, 0xF0, 0xFC, 0x07, 0xC7, 0xE0, 0x1F, 0x3F,
  0x00, 0x7D, 0xF8, 0x01, 0xEF, 0xC0, 0x0F, 0xBE, 0x00, 0x3F, 0xF8, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x0F, 0xDF, 0x00, 0x7E, 0x7E, 0x01, 0xF1,
  0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0xC0, 0xFC, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF8, 0x3E, 0x03, 0xE0, 0xF8, 0x0F, 0xC0, 0x01, 0xF8, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x3F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xE0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0xFC, 0x00, 0x00, 0x07, 0x80, 0x70, 0x0F, 0x1F, 0xC1, 0xFC, 0x0F,
  0x3F, 0xE7, 0xFE, 0x0F, 0x7F, 0xE7, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x1F,
  0xC1, 0xFC, 0x3F, 0x1F, 0xC1, 0xF8, 0x1F, 0x1F, 0x81, 0xF8, 0x1F, 0x1F,
  0x01, 0xF0, 0x3F, 0x1F, 0x03, 0xF0, 0x3E, 0x3F, 0x03, 0xE0, 0x3E, 0x3E,
  0x03, 0xE0, 0x3E, 0x3E, 0x03, 0xE0, 0x3E, 0x3E, 0x03, 0xE0, 0x7E, 0x3E,
  0x07, 0xC0, 0x7C, 0x7C, 0x07, 0xC0, 0x7C, 0x7C, 0x07, 0xC0, 0x7C, 0x7C,
  0x07, 0xC0, 0x7C, 0x7C, 0x07, 0xC0, 0xF8, 0xFC, 0x0F, 0x80, 0xF8, 0xF8,
  0x0F, 0x80, 0xF8, 0xF8, 0x0F, 0x80, 0xF8, 0xF8, 0x0F, 0x80, 0xF8, 0xF8,
  0x1F, 0x81, 0xF0, 0x00, 0x03, 0xC0, 0x3C, 0x7F, 0x81, 0xE7, 0xFC, 0x0F,
  0x7F, 0xF0, 0x7F, 0xFF, 0x87, 0xF8, 0x7C, 0x3F, 0x83, 0xE1, 0xF8, 0x1F,
  0x0F, 0xC0, 0xF8, 0x7C, 0x07, 0xC7, 0xE0, 0x3E, 0x3E, 0x03, 0xF1, 0xF0,
  0x1F, 0x0F, 0x80, 0xF8, 0xFC, 0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x03, 0xE1,
  0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0xFC, 0x07, 0xC7, 0xC0, 0x7E, 0x3E, 0x03,
  0xE1, 0xF0, 0x1F, 0x1F, 0x80, 0xF8, 0x00, 0x78, 0x00, 0x7F, 0xE0, 0x1F,
  0xFE, 0x07, 0xFF, 0xE1, 0xFF, 0xFC, 0x7E, 0x0F, 0x8F, 0x81, 0xFB, 0xF0,
  0x1F, 0x7C, 0x03, 0xEF, 0x80, 0x7F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x7F, 0xF0, 0x0F, 0xBE, 0x01, 0xF7, 0xC0, 0x3E, 0xF8, 0x0F, 0xDF, 0x01,
  0xF3, 0xE0, 0x7E, 0x7E, 0x1F, 0x87, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFE,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xE0, 0x01, 0xE3, 0xF8, 0x01, 0xE7, 0xFC,
  0x01, 0xEF, 0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xF8, 0x3E, 0x03, 0xF0, 0x3E,
  0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x3F, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x3E,
  0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x7E,
  0x0F, 0x80, 0x7C, 0x0F, 0x80, 0xFC, 0x0F, 0x80, 0xFC, 0x0F, 0xC1, 0xF8,
  0x1F, 0xC3, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x1F, 0x7F, 0xC0,
  0x1F, 0x3F, 0x80, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xE0, 0x08,
  0x1F, 0xE7, 0x81, 0xFF, 0xBC, 0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0x1F, 0x83,
  0xF8, 0xFC, 0x1F, 0x8F, 0xC0, 0x7C, 0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x3F,
  0x01, 0xF1, 0xF0, 0x0F, 0x8F, 0x80, 0x7C, 0x7C, 0x03, 0xE3, 0xE0, 0x3F,
  0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0x87, 0xC0, 0xFC, 0x3E, 0x0F, 0xE1, 0xF8,
  0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x81, 0xFF, 0x7C, 0x07, 0xE3, 0xE0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0x87, 0xCF, 0xC3, 0xCF, 0xC1, 0xEF, 0xE0,
  0xFF, 0xF0, 0xFF, 0x88, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80,
  0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0xE0, 0xFF,
  0xFC, 0x3F, 0xFE, 0x1F, 0xCF, 0x07, 0xC0, 0x41, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x88, 0x03,
  0xE3, 0x01, 0xF8, 0xFF, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0x81, 0xFF, 0x80,
  0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFE, 0xFF, 0xF8, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xFF, 0xC3, 0xFF, 0x07, 0xFC, 0x0F,
  0xF0, 0x1F, 0x01, 0xF8, 0xF8, 0x0F, 0x87, 0xC0, 0x7C, 0x7E, 0x03, 0xE3,
  0xE0, 0x3F, 0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0x87, 0xC0, 0x7C, 0x7C, 0x03,
  0xE3, 0xE0, 0x3E, 0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0x87, 0xC0, 0x7C, 0x7C,
  0x07, 0xE3, 0xE0, 0x3E, 0x1F, 0x01, 0xF0, 0xF8, 0x1F, 0x87, 0xC1, 0xFC,
  0x3E, 0x1F, 0xE1, 0xFF, 0xFE, 0x0F, 0xFE, 0xF0, 0x3F, 0xE7, 0x80, 0xFE,
  0x3C, 0x00, 0xF8, 0x03, 0xFF, 0x80, 0x7E, 0x78, 0x07, 0xC7, 0x80, 0x7C,
  0x7C, 0x0F, 0x87, 0xC0, 0xF8, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x3E,
  0x07, 0xC3, 0xE0, 0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0xF8, 0x07, 0xCF,
  0x80, 0x3D, 0xF0, 0x03, 0xDF, 0x00, 0x3D, 0xE0, 0x03, 0xFE, 0x00, 0x3F,
  0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x00,
  0xF0, 0x1F, 0x80, 0xFF, 0x80, 0xFC, 0x0F, 0xBC, 0x0F, 0xE0, 0x7D, 0xE0,
  0x7F, 0x07, 0xCF, 0x07, 0xF8, 0x3E, 0x78, 0x3F, 0xC1, 0xF3, 0xC1, 0xDE,
  0x1F, 0x1E, 0x1E, 0xF0, 0xF8, 0xF0, 0xF7, 0x8F, 0x87, 0x8F, 0x3C, 0x7C,
  0x3C, 0x79, 0xE7, 0xC1, 0xE7, 0xCF, 0x3E, 0x0F, 0x3C, 0x79, 0xE0, 0x79,
  0xE3, 0xDF, 0x03, 0xDE, 0x1E, 0xF8, 0x1E, 0xF0, 0xF7, 0x80, 0xFF, 0x07,
  0xFC, 0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0xC1, 0xFE, 0x01, 0xFC, 0x0F, 0xE0,
  0x0F, 0xE0, 0x7F, 0x00, 0x7E, 0x03, 0xF0, 0x03, 0xF0, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x7F, 0x03, 0xE0, 0x7C, 0x03, 0xE0, 0xFC, 0x01, 0xF1, 0xF8,
  0x01, 0xF1, 0xF0, 0x01, 0xF3, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xEF, 0x80,
  0x07, 0xCF, 0x80, 0x0F, 0xCF, 0x80, 0x1F, 0x8F, 0xC0, 0x1F, 0x07, 0xC0,
  0x3F, 0x07, 0xC0, 0x7E, 0x07, 0xE0, 0xFC, 0x03, 0xE0, 0x07, 0xC0, 0x1F,
  0x81, 0xE0, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x3E, 0x07,
  0xC0, 0x1F, 0x03, 0xE0, 0x0F, 0x83, 0xE0, 0x07, 0xC1, 0xF0, 0x03, 0xE1,
  0xF0, 0x01, 0xF0, 0xF8, 0x00, 0x78, 0xF8, 0x00, 0x3C, 0x7C, 0x00, 0x1E,
  0x7C, 0x00, 0x0F, 0x3E, 0x00, 0x07, 0x9E, 0x00, 0x03, 0xDF, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF,
  0x83, 0xFF, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF0,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00,
  0xF8, 0x00, 0x3F, 0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x80,
  0x00, 0x03, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80,
  0x1F, 0xC0, 0x1F, 0xE0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFF, 0x00, 0x07,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x00,
  0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x01, 0xC0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F,
  0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x3F, 0x80,
  0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0x00, 0x00, 0x3F, 0xC0, 0x17,
  0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xE8, 0x01, 0xF8,
};

const GFXglyph NotoSans_SemiCondensed_SemiBoldItalic43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 13, 32, 11, 0, -31 },
  { 53, 15, 11, 18, 4, -31 },
  { 74, 24, 31, 25, 1, -31 },
  { 167, 21, 36, 22, 1, -33 },
  { 262, 29, 31, 33, 3, -31 },
  { 375, 25, 31, 27, 1, -31 },
  { 472, 7, 11, 10, 4, -31 },
  { 482, 15, 38, 13, 1, -31 },
  { 554, 15, 38, 13, -3, -31 },
  { 626, 18, 19, 21, 4, -33 },
  { 669, 20, 21, 23, 2, -26 },
  { 722, 9, 11, 11, -2, -5 },
  { 735, 11, 5, 13, 1, -14 },
  { 742, 7, 7, 11, 0, -6 },
  { 749, 22, 31, 16, -2, -31 },
  { 835, 20, 31, 22, 1, -31 },
  { 913, 14, 31, 22, 5, -31 },
  { 968, 22, 31, 22, -1, -31 },
  { 1054, 21, 31, 22, 0, -31 },
  { 1136, 21, 31, 22, 0, -31 },
  { 1218, 21, 31, 22, 1, -31 },
  { 1300, 20, 31, 22, 2, -31 },
  { 1378, 21, 31, 22, 2, -31 },
  { 1460, 21, 31, 22, 1, -31 },
  { 1542, 20, 31, 22, 1, -31 },
  { 1620, 10, 25, 11, 0, -24 },
  { 1652, 12, 30, 11, -2, -24 },
  { 1697, 20, 21, 23, 2, -26 },
  { 1750, 19, 12, 23, 2, -21 },
  { 1779, 20, 21, 23, 2, -26 },
  { 1832, 17, 32, 17, 2, -31 },
  { 1900, 31, 35, 33, 2, -31 },
  { 2036, 24, 31, 23, -3, -31 },
  { 2129, 23, 31, 24, 1, -31 },
  { 2219, 23, 31, 23, 2, -31 },
  { 2309, 24, 31, 26, 1, -31 },
  { 2402, 21, 31, 21, 1, -31 },
  { 2484, 21, 31, 20, 1, -31 },
  { 2566, 25, 31, 27, 2, -31 },
  { 2663, 27, 31, 27, 1, -31 },
  { 2768, 18, 31, 14, -1, -31 },
  { 2838, 20, 40, 12, -7, -31 },
  { 2938, 26, 31, 23, 1, -31 },
  { 3039, 16, 31, 19, 1, -31 },
  { 3101, 34, 31, 34, 1, -31 },
  { 3233, 28, 31, 29, 1, -31 },
  { 3342, 25, 31, 28, 2, -31 },
  { 3439, 23, 31, 23, 1, -31 },
  { 3529, 25, 38, 28, 2, -31 },
  { 3648, 22, 31, 23, 1, -31 },
  { 3734, 22, 31, 20, 0, -31 },
  { 3820, 19, 31, 20, 4, -31 },
  { 3894, 25, 31, 27, 2, -31 },
  { 3991, 22, 31, 23, 4, -31 },
  { 4077, 35, 31, 35, 4, -31 },
  { 4213, 28, 31, 22, -2, -31 },
  { 4322, 21, 31, 21, 4, -31 },
  { 4404, 24, 31, 20, -1, -31 },
  { 4497, 17, 38, 13, -1, -31 },
  { 4578, 8, 31, 17, 5, -31 },
  { 4609, 17, 38, 13, -3, -31 },
  { 4690, 20, 19, 22, 1, -31 },
  { 4738, 17, 3, 16, -4, 4 },
  { 4745, 8, 7, 13, 6, -33 },
  { 4752, 21, 24, 23, 2, -24 },
  { 4815, 21, 33, 23, 1, -33 },
  { 4902, 17, 24, 18, 2, -24 },
  { 4953, 23, 33, 23, 2, -33 },
  { 5048, 18, 24, 21, 2, -24 },
  { 5102, 24, 43, 14, -5, -33 },
  { 5231, 23, 34, 23, 0, -24 },
  { 5329, 20, 33, 23, 1, -33 },
  { 5412, 11, 32, 11, 1, -32 },
  { 5456, 17, 42, 11, -5, -32 },
  { 5546, 22, 33, 21, 1, -33 },
  { 5637, 13, 33, 11, 0, -33 },
  { 5691, 32, 24, 35, 1, -24 },
  { 5787, 21, 24, 23, 0, -24 },
  { 5850, 19, 24, 22, 2, -24 },
  { 5907, 24, 34, 23, -2, -24 },
  { 6009, 21, 34, 23, 2, -24 },
  { 6099, 17, 24, 16, 1, -24 },
  { 6150, 18, 24, 18, 0, -24 },
  { 6204, 14, 28, 15, 2, -28 },
  { 6253, 21, 23, 23, 2, -23 },
  { 6314, 20, 23, 19, 2, -23 },
  { 6372, 29, 23, 30, 3, -23 },
  { 6456, 24, 23, 20, -2, -23 },
  { 6525, 25, 33, 20, -3, -23 },
  { 6629, 19, 23, 18, -1, -23 },
  { 6684, 18, 38, 15, 0, -31 },
  { 6770, 4, 43, 21, 9, -33 },
  { 6792, 17, 38, 15, -2, -31 },
  { 6873, 20, 6, 23, 2, -18 },
};

const GFXfont NotoSans_SemiCondensed_SemiBoldItalic43pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_SemiBoldItalic43pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_SemiBoldItalic43pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC43PT7B_H_
