#ifndef _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC40PT7B_H_
#define _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC40PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-SemiBoldItalic.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_SemiBoldItalic40pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xE0, 0x7C, 0x07, 0xC0,
  0x7C, 0x07, 0xC0, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x01,
  0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x7C, 0x07, 0xC0, 0xFC, 0x0F, 0xC0, 0x78, 0x00, 0x7C, 0x7B, 0xE3,
  0xDF, 0x3E, 0xF1, 0xF7, 0x8F, 0x3C, 0x79, 0xC3, 0xDE, 0x1C, 0xF0, 0xE7,
  0x8F, 0x38, 0x78, 0x00, 0x38, 0x78, 0x00, 0xF0, 0xF0, 0x01, 0xE1, 0xC0,
  0x03, 0x87, 0x80, 0x07, 0x0F, 0x00, 0x1E, 0x1C, 0x00, 0x38, 0x38, 0x00,
  0x70, 0xF0, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xE0, 0x3C, 0x38, 0x00, 0x70, 0xF0, 0x00, 0xE1, 0xE0, 0x03, 0xC3,
  0x80, 0x07, 0x87, 0x01, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0x03, 0xC3, 0xC0, 0x07, 0x87, 0x00, 0x0E, 0x1E, 0x00,
  0x1C, 0x3C, 0x00, 0x78, 0x70, 0x00, 0xF0, 0xE0, 0x01, 0xC3, 0xC0, 0x07,
  0x87, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x7F,
  0xC0, 0x3F, 0xFE, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0xFD, 0xC6, 0x1F, 0x30,
  0x03, 0xE6, 0x00, 0x7C, 0xC0, 0x0F, 0x98, 0x01, 0xFF, 0x00, 0x1F, 0xC0,
  0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0x7E,
  0x00, 0x67, 0xC0, 0x0C, 0xF8, 0x03, 0x9F, 0x20, 0x63, 0xE7, 0x0C, 0xF8,
  0xFF, 0xFF, 0x1F, 0xFF, 0xC3, 0xFF, 0xF0, 0x1F, 0xF8, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x07, 0x80, 0xFF,
  0x00, 0x78, 0x1F, 0xF0, 0x0F, 0x01, 0xEF, 0x81, 0xE0, 0x3C, 0x78, 0x1E,
  0x03, 0xC7, 0x83, 0xC0, 0x78, 0x78, 0x78, 0x07, 0x87, 0x87, 0x80, 0x78,
  0x78, 0xF0, 0x07, 0x0F, 0x1E, 0x00, 0xF0, 0xF1, 0xE0, 0x0F, 0x0F, 0x3C,
  0x20, 0xF0, 0xE7, 0x8F, 0xCF, 0x1E, 0x7B, 0xFE, 0x7B, 0xCF, 0x3F, 0xE7,
  0xFD, 0xE7, 0x9E, 0x3F, 0x9E, 0x70, 0xE1, 0xE3, 0xCF, 0x0F, 0x00, 0x78,
  0xF0, 0xE0, 0x07, 0x8E, 0x1E, 0x00, 0xF1, 0xE1, 0xE0, 0x1E, 0x1E, 0x1E,
  0x01, 0xE1, 0xE1, 0xE0, 0x3C, 0x1E, 0x3C, 0x07, 0x81, 0xE3, 0xC0, 0x78,
  0x1E, 0x78, 0x0F, 0x00, 0xFF, 0x81, 0xE0, 0x0F, 0xF0, 0x3E, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0x3E, 0x3E, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0xF8, 0x03, 0xE1, 0xE0,
  0x07, 0xC3, 0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0x7E, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x0F, 0x8F, 0xFC, 0x1F, 0x3F,
  0xFC, 0x3C, 0xFC, 0xF8, 0xF9, 0xF0, 0xF9, 0xE7, 0xC1, 0xF7, 0xCF, 0x81,
  0xFF, 0x1F, 0x03, 0xFC, 0x3E, 0x03, 0xF8, 0x7C, 0x07, 0xE0, 0xFC, 0x1F,
  0xC1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC1, 0xFF, 0xCF, 0x81, 0xFE, 0x1F,
  0x80, 0x7D, 0xF7, 0xDE, 0x79, 0xE7, 0xBC, 0xF3, 0xCE, 0x00, 0x00, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xE0,
  0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0,
  0x1F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x01,
  0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x0F,
  0x80, 0x00, 0x01, 0x00, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x04, 0x1E,
  0x07, 0x8E, 0x03, 0xF7, 0x01, 0xFF, 0xFF, 0x3F, 0xFF, 0x83, 0xFF, 0xC1,
  0xF7, 0xE3, 0xFC, 0x03, 0xEE, 0x03, 0xE7, 0x81, 0xF3, 0xC0, 0x70, 0xF0,
  0x10, 0x78, 0x00, 0x30, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x0F, 0x8F, 0x87, 0xC3, 0xC3, 0xE1, 0xE0, 0xF0, 0xF0, 0x78, 0x78, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x19, 0xF7, 0xFF, 0xFD, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xF0, 0x0F, 0xFE, 0x03, 0xFF,
  0xE0, 0x7C, 0x7C, 0x1F, 0x07, 0xC7, 0xE0, 0xF8, 0xF8, 0x1F, 0x1F, 0x03,
  0xE7, 0xC0, 0x7C, 0xF8, 0x0F, 0x9F, 0x01, 0xF7, 0xC0, 0x3E, 0xF8, 0x07,
  0x9F, 0x01, 0xF3, 0xE0, 0x3E, 0x78, 0x07, 0xDF, 0x00, 0xFB, 0xE0, 0x3E,
  0x7C, 0x07, 0xCF, 0x80, 0xF9, 0xF0, 0x3E, 0x3E, 0x07, 0xC3, 0xC1, 0xF0,
  0x7C, 0x7E, 0x0F, 0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xF8, 0x01, 0xFE, 0x00,
  0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x81, 0xFE, 0x0F, 0xF8, 0xFF, 0xE7, 0xFF,
  0x3F, 0x3C, 0x79, 0xF0, 0xC7, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x00, 0x3F, 0x80, 0x07, 0xFE, 0x00, 0xFF, 0xF8, 0x0F,
  0xFF, 0xE0, 0x3E, 0x3F, 0x01, 0xC0, 0xFC, 0x04, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xFF, 0xFE, 0x1F,
  0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x3F,
  0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0x87, 0xF0, 0x20, 0x3F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xF0,
  0x00, 0x3F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0xC0, 0x3F, 0x8F, 0xFF,
  0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xBC, 0x00, 0x7B, 0xC0, 0x0F, 0x7C, 0x01, 0xE7,
  0xC0, 0x3C, 0x78, 0x07, 0xC7, 0x80, 0x78, 0xF8, 0x0F, 0x0F, 0x81, 0xE0,
  0xF8, 0x3E, 0x0F, 0x03, 0xC0, 0xF0, 0x78, 0x1F, 0x0F, 0xFF, 0xFE, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xC0, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x01, 0xFF,
  0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F,
  0x80, 0x00, 0xF7, 0x80, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x80,
  0x41, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x88, 0x01, 0xF8, 0xE0, 0x3F,
  0x0F, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x0F, 0xF8, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0x04, 0x1F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0,
  0x00, 0x3E, 0x7E, 0x07, 0xBF, 0xE0, 0xFF, 0xFE, 0x3F, 0xFF, 0xC7, 0xF0,
  0xF8, 0xFC, 0x0F, 0x9F, 0x01, 0xF3, 0xE0, 0x3E, 0x78, 0x07, 0x8F, 0x01,
  0xF1, 0xE0, 0x3E, 0x3C, 0x07, 0xC7, 0xC1, 0xF0, 0xF8, 0x7E, 0x1F, 0xFF,
  0x81, 0xFF, 0xE0, 0x1F, 0xF8, 0x01, 0xFE, 0x00, 0x1F, 0xFF, 0xF3, 0xFF,
  0xFE, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x3F, 0xF0, 0x0F, 0xFF, 0x03, 0xFF, 0xF0, 0xF8, 0x3E, 0x1F, 0x07, 0xC3,
  0xC0, 0x78, 0x78, 0x1F, 0x0F, 0x03, 0xE1, 0xF0, 0x78, 0x3E, 0x1F, 0x03,
  0xEF, 0xC0, 0x7F, 0xF0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xF0, 0x3F,
  0xBF, 0x0F, 0xC3, 0xE1, 0xF0, 0x3E, 0x7C, 0x07, 0xCF, 0x80, 0xF9, 0xF0,
  0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0x7C, 0xF8, 0x1F, 0x1F, 0xCF, 0xE1, 0xFF,
  0xF8, 0x1F, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x7F,
  0xF8, 0x3F, 0xFF, 0x0F, 0x8F, 0xC7, 0xC1, 0xF1, 0xE0, 0x3C, 0xF8, 0x0F,
  0x3E, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x7C, 0xF0, 0x1F, 0x3C, 0x07, 0xCF,
  0x83, 0xF3, 0xF3, 0xFC, 0xFF, 0xFF, 0x1F, 0xF7, 0x83, 0xF9, 0xE0, 0x78,
  0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xFC, 0x3F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0x80, 0x00,
  0x07, 0x83, 0xF0, 0xFC, 0x3F, 0x0F, 0x81, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x1F, 0x07, 0xC3,
  0xF0, 0xFC, 0x1E, 0x00, 0x01, 0xE0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xE0,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x1F, 0x01, 0xF0, 0x1E, 0x03,
  0xE0, 0x3C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0xF0, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00,
  0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xC0,
  0x00, 0xF0, 0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3C, 0x00, 0x0F,
  0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x01, 0xFE, 0x01, 0xFE,
  0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0xFE, 0x00, 0x3C, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0xF0, 0x3F, 0xF8, 0xFF, 0xF1, 0xFF, 0xF3, 0xC3, 0xE2,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x3C, 0x00,
  0x78, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x7C,
  0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0x80, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xF3, 0xF8, 0x03,
  0xF0, 0x07, 0xC0, 0x7C, 0x00, 0x1E, 0x0F, 0x80, 0x01, 0xE0, 0xF0, 0x00,
  0x0F, 0x1E, 0x07, 0xF0, 0xF3, 0xC1, 0xFF, 0x87, 0x3C, 0x3F, 0xF8, 0x77,
  0x87, 0xC7, 0x87, 0x78, 0x78, 0x78, 0x77, 0x0F, 0x07, 0x07, 0xF0, 0xE0,
  0xF0, 0xFF, 0x1E, 0x0F, 0x0F, 0xE1, 0xE0, 0xF0, 0xFE, 0x1C, 0x0E, 0x0E,
  0xE1, 0xC1, 0xE1, 0xEE, 0x1C, 0x1E, 0x1C, 0xE1, 0xC3, 0xE3, 0xCE, 0x1E,
  0x7E, 0x78, 0xE1, 0xFE, 0xFF, 0x0F, 0x0F, 0xC7, 0xE0, 0xF0, 0x38, 0x38,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x60, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0x78, 0x00, 0x7B, 0xC0,
  0x07, 0x9E, 0x00, 0x3C, 0xF0, 0x03, 0xE7, 0x80, 0x1E, 0x3C, 0x01, 0xF1,
  0xE0, 0x0F, 0x0F, 0x00, 0xF8, 0x78, 0x07, 0x83, 0xC0, 0x7C, 0x1E, 0x03,
  0xE0, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x8F, 0x80, 0x7C, 0x7C, 0x03, 0xE7, 0xC0, 0x1F, 0x3E, 0x00, 0xFB, 0xE0,
  0x07, 0xDF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7C, 0x7F, 0x83,
  0xE0, 0xFC, 0x1E, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0x7C, 0x07,
  0xC3, 0xC0, 0x7C, 0x3E, 0x07, 0xE1, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0x7F,
  0xFC, 0x03, 0xFF, 0xF0, 0x3E, 0x0F, 0xC1, 0xF0, 0x1F, 0x0F, 0x80, 0xF8,
  0x7C, 0x07, 0xC3, 0xC0, 0x3E, 0x3E, 0x01, 0xF1, 0xF0, 0x1F, 0x8F, 0x80,
  0xF8, 0x7C, 0x1F, 0xC7, 0xFF, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x07,
  0xFF, 0xF0, 0x7F, 0x8F, 0x07, 0xF0, 0x08, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0x03, 0x01, 0xFF, 0xF8, 0x0F,
  0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xFF, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x1F, 0x07,
  0xE0, 0x78, 0x0F, 0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x3E, 0x01, 0xF0,
  0xF8, 0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xF1, 0xF0,
  0x07, 0xC7, 0xC0, 0x1F, 0x3E, 0x00, 0x7C, 0xF8, 0x03, 0xE3, 0xE0, 0x0F,
  0x8F, 0x80, 0x7E, 0x3C, 0x01, 0xF1, 0xF0, 0x0F, 0xC7, 0xC0, 0x7E, 0x1F,
  0x03, 0xF0, 0x7C, 0x3F, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF,
  0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0xE0,
  0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0xFF,
  0x81, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x02, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F,
  0xFF, 0xC0, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xF8,
  0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xC7, 0xC1, 0xFC, 0x01, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x81, 0xFF, 0x1F, 0x03,
  0xFE, 0x7C, 0x07, 0xFC, 0xF8, 0x1F, 0xF9, 0xF0, 0x01, 0xE3, 0xE0, 0x07,
  0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0x1F, 0x80, 0x3E, 0x3F, 0x00, 0xF8,
  0x3F, 0x01, 0xF0, 0x7F, 0x03, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xE0, 0x0F, 0x81, 0xF0, 0x07,
  0x81, 0xF0, 0x07, 0xC0, 0xF8, 0x03, 0xE0, 0x7C, 0x01, 0xF0, 0x3E, 0x00,
  0xF8, 0x1E, 0x00, 0xF8, 0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x3E, 0x07, 0xC0,
  0x1F, 0x03, 0xE0, 0x0F, 0x83, 0xE0, 0x0F, 0x81, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x3E, 0x00, 0xF8, 0x1F,
  0x00, 0x7C, 0x0F, 0x80, 0x3E, 0x07, 0xC0, 0x1F, 0x03, 0xC0, 0x1F, 0x03,
  0xE0, 0x0F, 0x81, 0xF0, 0x07, 0xC0, 0xF8, 0x03, 0xE0, 0x7C, 0x01, 0xF0,
  0x3C, 0x01, 0xF0, 0x3E, 0x00, 0xF8, 0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x3E,
  0x00, 0x03, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xC0, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x3F, 0xF8, 0x1F, 0xFC,
  0x0F, 0xFE, 0x00, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x87, 0xE0, 0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xFC, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xE0, 0x3F, 0x03, 0xC0, 0x3E, 0x07, 0xC0, 0x7C,
  0x07, 0xC0, 0xFC, 0x07, 0xC1, 0xF8, 0x07, 0xC3, 0xF0, 0x07, 0x83, 0xE0,
  0x0F, 0x87, 0xC0, 0x0F, 0x8F, 0x80, 0x0F, 0x9F, 0x80, 0x0F, 0x3F, 0x00,
  0x1F, 0x3E, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x7C, 0x00, 0x3E, 0x3E, 0x00,
  0x3E, 0x3E, 0x00, 0x3C, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x1F, 0x00,
  0x7C, 0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x07, 0xC0, 0xF8, 0x07, 0xC0, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x03, 0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF,
  0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x07, 0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x07,
  0xF8, 0x3F, 0x80, 0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0xE0, 0xFF, 0x00, 0x7F,
  0x81, 0xFE, 0x00, 0xFF, 0x07, 0xFC, 0x03, 0xFE, 0x0F, 0x78, 0x07, 0xFC,
  0x1E, 0xF0, 0x1E, 0xF0, 0x3D, 0xE0, 0x3D, 0xE0, 0xFB, 0xC0, 0xF7, 0xC1,
  0xF7, 0x81, 0xEF, 0x83, 0xCF, 0x07, 0x9F, 0x07, 0x9E, 0x0F, 0x3C, 0x0F,
  0x3C, 0x3C, 0x78, 0x3E, 0x78, 0x79, 0xF0, 0x7C, 0xF1, 0xE3, 0xE0, 0xF0,
  0xE3, 0xC7, 0xC1, 0xE1, 0xEF, 0x0F, 0x03, 0xC3, 0xDE, 0x1E, 0x0F, 0x87,
  0xF8, 0x7C, 0x1F, 0x0F, 0xF0, 0xF8, 0x3C, 0x1F, 0xC1, 0xF0, 0x78, 0x3F,
  0x83, 0xC1, 0xF0, 0x7E, 0x07, 0x83, 0xE0, 0xFC, 0x1F, 0x07, 0xC1, 0xF0,
  0x3E, 0x0F, 0x03, 0xE0, 0x78, 0x00, 0x03, 0xE0, 0x03, 0xC0, 0xFC, 0x01,
  0xF0, 0x7F, 0x00, 0x7C, 0x1F, 0xC0, 0x1F, 0x07, 0xF0, 0x07, 0x81, 0xFE,
  0x01, 0xE0, 0x7F, 0x80, 0xF8, 0x3D, 0xE0, 0x3E, 0x0F, 0x7C, 0x0F, 0x83,
  0xDF, 0x03, 0xC0, 0xF3, 0xC0, 0xF0, 0x7C, 0xF0, 0x7C, 0x1F, 0x3E, 0x1F,
  0x07, 0x8F, 0x87, 0x81, 0xE1, 0xE1, 0xE0, 0x78, 0x7C, 0x78, 0x3E, 0x1F,
  0x3E, 0x0F, 0x83, 0xCF, 0x83, 0xC0, 0xF3, 0xC0, 0xF0, 0x3E, 0xF0, 0x3C,
  0x0F, 0xBC, 0x1F, 0x01, 0xFF, 0x07, 0xC0, 0x7F, 0xC1, 0xE0, 0x1F, 0xE0,
  0x78, 0x03, 0xF8, 0x3E, 0x00, 0xFE, 0x0F, 0x80, 0x3F, 0x83, 0xE0, 0x0F,
  0xC0, 0xF0, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xE0, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x7F, 0x1F, 0xC1, 0xF8, 0x0F, 0x87, 0xE0,
  0x1F, 0x8F, 0x80, 0x1F, 0x3F, 0x00, 0x3E, 0x7C, 0x00, 0x7C, 0xF8, 0x00,
  0xFB, 0xE0, 0x01, 0xF7, 0xC0, 0x03, 0xEF, 0x80, 0x07, 0xDF, 0x00, 0x0F,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7D, 0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xF7,
  0xC0, 0x07, 0xEF, 0x80, 0x0F, 0x9F, 0x00, 0x3F, 0x3F, 0x00, 0xFC, 0x3E,
  0x01, 0xF8, 0x7E, 0x0F, 0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0xFF,
  0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xFE, 0x01, 0xFF,
  0xF8, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xE0, 0xFC, 0x1E, 0x03, 0xE1,
  0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x3E, 0x3E, 0x03,
  0xE1, 0xF0, 0x1F, 0x0F, 0x83, 0xF8, 0x7F, 0xFF, 0x83, 0xFF, 0xF8, 0x3F,
  0xFF, 0x81, 0xFF, 0xF0, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x7F, 0x1F,
  0xC1, 0xF8, 0x0F, 0x87, 0xE0, 0x1F, 0x8F, 0x80, 0x1F, 0x3F, 0x00, 0x3E,
  0x7C, 0x00, 0x7C, 0xF8, 0x00, 0xFB, 0xE0, 0x01, 0xF7, 0xC0, 0x03, 0xEF,
  0x80, 0x07, 0xDF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7D, 0xF0,
  0x00, 0xFB, 0xE0, 0x01, 0xF7, 0xC0, 0x07, 0xEF, 0x80, 0x0F, 0x9F, 0x00,
  0x3F, 0x3F, 0x00, 0x7C, 0x3E, 0x01, 0xF8, 0x7E, 0x0F, 0xE0, 0x7F, 0xFF,
  0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xF8, 0x07,
  0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xCF, 0xF0, 0x7C, 0x1F, 0x07, 0x81, 0xF0,
  0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF1, 0xF0, 0x1F,
  0x1F, 0x03, 0xE1, 0xF1, 0xFE, 0x1F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFE,
  0x03, 0xFF, 0xE0, 0x3E, 0x3E, 0x03, 0xE3, 0xE0, 0x3C, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF8, 0x7C, 0x0F, 0x8F, 0x80, 0xF8, 0xF8,
  0x0F, 0xCF, 0x80, 0x7C, 0xF8, 0x07, 0xC0, 0x00, 0x3F, 0x80, 0x0F, 0xFE,
  0x03, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xF3, 0xE0, 0xFC, 0x04, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x1F, 0x88, 0x01, 0xF0, 0xE0, 0x3F, 0x0F, 0xFF, 0xE0,
  0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0x7F, 0xFF, 0xEF, 0xFF,
  0xFD, 0xFF, 0xFF, 0x3F, 0xFF, 0xEF, 0xFF, 0xFC, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x3E,
  0x00, 0xF8, 0x7C, 0x01, 0xF0, 0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0x87, 0xC0,
  0x1F, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0xF8, 0x03,
  0xE1, 0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0x00, 0x7C,
  0x3E, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0xF8, 0x03, 0xE1, 0xF0, 0x07, 0xC3,
  0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x3E, 0x01, 0xF0, 0x7E,
  0x03, 0xE0, 0x7E, 0x0F, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x01, 0xFF,
  0xF0, 0x00, 0xFF, 0x80, 0x00, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xBC, 0x00,
  0x7D, 0xE0, 0x07, 0xCF, 0x00, 0x3E, 0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x1F,
  0x01, 0xF0, 0xF8, 0x0F, 0x87, 0xC0, 0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x7C,
  0x0F, 0x83, 0xE0, 0x7C, 0x3E, 0x03, 0xE1, 0xF0, 0x0F, 0x0F, 0x00, 0x78,
  0xF8, 0x03, 0xC7, 0x80, 0x1E, 0x7C, 0x00, 0xF3, 0xC0, 0x07, 0xBE, 0x00,
  0x3D, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF0, 0x03,
  0xC0, 0x1F, 0xF0, 0x07, 0xC0, 0x3E, 0xF0, 0x07, 0xC0, 0x3E, 0xF0, 0x0F,
  0xC0, 0x3E, 0xF0, 0x0F, 0xC0, 0x7C, 0xF0, 0x1F, 0xC0, 0x7C, 0xF0, 0x1F,
  0xC0, 0xF8, 0xF0, 0x1F, 0xC0, 0xF8, 0xF0, 0x3F, 0xC0, 0xF0, 0xF0, 0x3F,
  0xC1, 0xF0, 0xF0, 0x7B, 0xC1, 0xF0, 0xF0, 0x7B, 0xC3, 0xE0, 0xF0, 0xF3,
  0xC3, 0xE0, 0xF0, 0xF3, 0xC3, 0xC0, 0xF1, 0xF3, 0xC7, 0xC0, 0xF1, 0xE3,
  0xC7, 0x80, 0xF1, 0xE3, 0xCF, 0x80, 0xF3, 0xC3, 0xCF, 0x80, 0xF3, 0xC3,
  0xCF, 0x00, 0xF7, 0x83, 0xDF, 0x00, 0xF7, 0x83, 0xDE, 0x00, 0xF7, 0x83,
  0xFE, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFE, 0x03,
  0xFC, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0xFC, 0x03,
  0xF0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x0F, 0xC0, 0x7C, 0x03,
  0xE0, 0x1F, 0x01, 0xF0, 0x07, 0xC0, 0xFC, 0x01, 0xF0, 0x3E, 0x00, 0x3E,
  0x1F, 0x00, 0x0F, 0x8F, 0xC0, 0x03, 0xE3, 0xE0, 0x00, 0x79, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0x78, 0x00, 0x0F, 0x9F, 0x00, 0x03,
  0xE7, 0xC0, 0x01, 0xF1, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x0F, 0x80,
  0x1F, 0x03, 0xE0, 0x0F, 0x80, 0xF8, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x07,
  0xC0, 0xF8, 0x01, 0xF0, 0x00, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x1F,
  0x7C, 0x07, 0xCF, 0x80, 0xF8, 0xF0, 0x3E, 0x1F, 0x0F, 0x83, 0xE1, 0xF0,
  0x7C, 0x7C, 0x0F, 0x8F, 0x80, 0xF3, 0xE0, 0x1E, 0xF8, 0x03, 0xFF, 0x00,
  0x7F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFE, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x80, 0xF0, 0x78, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x7C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x7C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x7C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF8, 0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01,
  0xFE, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x01,
  0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x7F, 0x80, 0x7F,
  0x80, 0xFF, 0x80, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0xF7, 0x80, 0x1E, 0xF0, 0x07, 0x8E,
  0x00, 0xF1, 0xE0, 0x3C, 0x3C, 0x0F, 0x03, 0x81, 0xE0, 0x78, 0x78, 0x0F,
  0x0F, 0x00, 0xE3, 0xC0, 0x1E, 0x78, 0x03, 0xDE, 0x00, 0x3C, 0x7F, 0xFF,
  0xFF, 0xFE, 0xF9, 0xF1, 0xF3, 0xE3, 0xC3, 0xC3, 0x80, 0x01, 0xF8, 0xF0,
  0x3F, 0xCF, 0x07, 0xFD, 0xF0, 0xFF, 0xFE, 0x1F, 0x8F, 0xE1, 0xF0, 0x7E,
  0x3F, 0x07, 0xE3, 0xE0, 0x7C, 0x7E, 0x07, 0xC7, 0xC0, 0x7C, 0x7C, 0x07,
  0xC7, 0xC0, 0x7C, 0x7C, 0x07, 0x8F, 0x80, 0xF8, 0xF8, 0x0F, 0x8F, 0x81,
  0xF8, 0xFC, 0x1F, 0x87, 0xC3, 0xF0, 0x7F, 0xFF, 0x07, 0xFE, 0xF0, 0x3F,
  0xCF, 0x01, 0xF8, 0xF0, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xCF, 0x80, 0x79, 0xFC, 0x07, 0xBF, 0xE0, 0xFF, 0xFE, 0x0F, 0xE3,
  0xF0, 0xFC, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x1F, 0x01, 0xF1, 0xF0,
  0x1F, 0x1F, 0x01, 0xF1, 0xE0, 0x1F, 0x3E, 0x03, 0xE3, 0xE0, 0x3E, 0x3E,
  0x03, 0xE3, 0xE0, 0x7C, 0x3E, 0x07, 0xC7, 0xF0, 0xF8, 0x7F, 0xFF, 0x87,
  0xBF, 0xF0, 0x7B, 0xFE, 0x0F, 0x1F, 0xC0, 0x00, 0xFE, 0x01, 0xFF, 0xC1,
  0xFF, 0xC1, 0xFF, 0xE1, 0xF8, 0x20, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x04, 0x1F, 0xFE, 0x07,
  0xFF, 0x03, 0xFF, 0x80, 0x7F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x7C, 0x01, 0xF9, 0xF0, 0x0F, 0xF7, 0xC0, 0x7F, 0xDF,
  0x03, 0xFF, 0xF8, 0x1F, 0x87, 0xE0, 0x7C, 0x1F, 0x83, 0xE0, 0x3E, 0x0F,
  0x80, 0xF0, 0x7E, 0x07, 0xC1, 0xF0, 0x1F, 0x07, 0xC0, 0x7C, 0x1F, 0x01,
  0xF0, 0x78, 0x07, 0x83, 0xE0, 0x3E, 0x0F, 0x80, 0xF8, 0x3E, 0x07, 0xE0,
  0xF8, 0x1F, 0x81, 0xF0, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFB, 0xC0, 0x3F,
  0xCF, 0x00, 0x7E, 0x38, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xF8,
  0x3F, 0xFE, 0x1F, 0x87, 0xC7, 0xC1, 0xF3, 0xE0, 0x7C, 0xF8, 0x1E, 0x7C,
  0x1F, 0x9F, 0xFF, 0xC7, 0xFF, 0xE1, 0xFF, 0xE0, 0x7F, 0xC0, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x87, 0xF3, 0xE0,
  0xFF, 0xF8, 0x1F, 0xFE, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x40, 0x00, 0x3F,
  0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xF9, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xF0,
  0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x0B, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8,
  0x00, 0x1F, 0x80, 0x00, 0x60, 0x00, 0x00, 0x00, 0xFC, 0x78, 0x0F, 0xF3,
  0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFC, 0x3F, 0x07, 0xC1, 0xF8, 0x7E,
  0x0F, 0xC3, 0xE0, 0x7C, 0x3F, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x80, 0xF8,
  0x7C, 0x07, 0xC3, 0xE0, 0x3C, 0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x81,
  0xF8, 0x7E, 0x0F, 0xC1, 0xF0, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x01,
  0xFE, 0xF8, 0x07, 0xE7, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x20, 0x0F, 0x81, 0xE1, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F,
  0xFC, 0x01, 0xFF, 0x80, 0x01, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xCF, 0x80, 0x79, 0xFE, 0x07, 0xBF, 0xE0, 0xFF,
  0xFF, 0x0F, 0xE3, 0xF0, 0xFC, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x1F,
  0x01, 0xE1, 0xF0, 0x3E, 0x1F, 0x03, 0xE1, 0xE0, 0x3E, 0x3E, 0x03, 0xE3,
  0xE0, 0x3C, 0x3E, 0x07, 0xC3, 0xE0, 0x7C, 0x3C, 0x07, 0xC7, 0xC0, 0x7C,
  0x7C, 0x07, 0x87, 0xC0, 0xF8, 0x7C, 0x0F, 0x8F, 0x80, 0xF8, 0x01, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0xF8,
  0x1E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x78, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x83, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC1, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0,
  0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x0F, 0x80, 0xBF, 0x80, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x70, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0xF8,
  0x3E, 0x0F, 0x81, 0xE0, 0xF8, 0x1F, 0x0F, 0x80, 0xF8, 0xFC, 0x07, 0xCF,
  0xC0, 0x3C, 0x7C, 0x01, 0xE7, 0xC0, 0x1F, 0x7C, 0x00, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xBE, 0x00, 0xF8, 0xF8,
  0x07, 0xC7, 0xC0, 0x3C, 0x3E, 0x03, 0xE0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8,
  0x3E, 0x07, 0x80, 0xF8, 0x7C, 0x07, 0xC0, 0x01, 0xF0, 0x1E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0x7C, 0x07,
  0xC0, 0x7C, 0x0F, 0x80, 0x07, 0x8F, 0x81, 0xF0, 0x1E, 0x7F, 0x1F, 0xE0,
  0x7B, 0xFE, 0xFF, 0xC3, 0xDF, 0xFB, 0xFF, 0x0F, 0xE3, 0xFC, 0x7C, 0x3F,
  0x07, 0xE0, 0xF0, 0xF8, 0x1F, 0x03, 0xC3, 0xE0, 0x7C, 0x0F, 0x1F, 0x03,
  0xE0, 0x7C, 0x7C, 0x0F, 0x81, 0xF1, 0xF0, 0x3E, 0x07, 0xC7, 0x80, 0xF0,
  0x1E, 0x3E, 0x03, 0xC0, 0x78, 0xF8, 0x1F, 0x03, 0xE3, 0xE0, 0x7C, 0x0F,
  0x8F, 0x81, 0xF0, 0x3E, 0x3C, 0x07, 0x80, 0xF1, 0xF0, 0x3E, 0x07, 0xC7,
  0xC0, 0xF8, 0x1F, 0x1F, 0x03, 0xE0, 0x7C, 0x78, 0x0F, 0x81, 0xF3, 0xE0,
  0x3C, 0x07, 0x80, 0x07, 0x8F, 0x80, 0x79, 0xFE, 0x07, 0xBF, 0xE0, 0xF7,
  0xFF, 0x0F, 0xE3, 0xF0, 0xFC, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x1F,
  0x01, 0xE1, 0xF0, 0x3E, 0x1F, 0x03, 0xE1, 0xE0, 0x3E, 0x3E, 0x03, 0xE3,
  0xE0, 0x3C, 0x3E, 0x07, 0xC3, 0xE0, 0x7C, 0x3C, 0x07, 0xC7, 0xC0, 0x7C,
  0x7C, 0x07, 0x87, 0xC0, 0xF8, 0x7C, 0x0F, 0x8F, 0x80, 0xF8, 0x00, 0xFC,
  0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFF, 0x1F, 0x87, 0xC7, 0xC1, 0xF3,
  0xE0, 0x3C, 0xF8, 0x0F, 0x7C, 0x03, 0xDF, 0x00, 0xF7, 0xC0, 0x7D, 0xF0,
  0x1F, 0x78, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0xF9, 0xE0, 0x3E, 0x78, 0x1F,
  0x9F, 0x0F, 0xC7, 0xFF, 0xE0, 0xFF, 0xF8, 0x1F, 0xF8, 0x03, 0xFC, 0x00,
  0x01, 0xE3, 0xE0, 0x07, 0x9F, 0xC0, 0x1E, 0xFF, 0x80, 0xF7, 0xFE, 0x03,
  0xF8, 0xFC, 0x0F, 0xC1, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x07, 0xC0,
  0x7C, 0x1F, 0x01, 0xF0, 0x7C, 0x07, 0xC1, 0xE0, 0x1F, 0x0F, 0x80, 0xF8,
  0x3E, 0x03, 0xE0, 0xF8, 0x0F, 0x83, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x7F,
  0x0F, 0x81, 0xFF, 0xFE, 0x07, 0xBF, 0xF0, 0x1E, 0xFF, 0x80, 0x79, 0xFC,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0xF0, 0x3F, 0xCF, 0x07, 0xFF, 0xE0,
  0xFF, 0xFE, 0x1F, 0x87, 0xE1, 0xF0, 0x7E, 0x3E, 0x03, 0xE3, 0xE0, 0x3C,
  0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0x78, 0x07,
  0x8F, 0x80, 0xF8, 0xF8, 0x0F, 0x8F, 0x81, 0xF8, 0xF8, 0x1F, 0x87, 0xC3,
  0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xDF, 0x01, 0xF9, 0xE0, 0x00,
  0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80,
  0x07, 0x8F, 0x83, 0xCF, 0x81, 0xEF, 0xC1, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F,
  0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0x01,
  0xFC, 0x07, 0xFF, 0x0F, 0xFF, 0x1F, 0xFE, 0x1F, 0x02, 0x1E, 0x00, 0x1E,
  0x00, 0x1F, 0x00, 0x1F, 0x80, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x01,
  0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x80, 0x7C, 0xFB,
  0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0x7F, 0xC0, 0x07, 0x80, 0x3C, 0x03, 0xC0,
  0x1E, 0x01, 0xFF, 0xBF, 0xFB, 0xFF, 0xDF, 0xFE, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xFE, 0x1F, 0xF0, 0xFF, 0x83,
  0xFC, 0x00, 0x1F, 0x03, 0xE3, 0xC0, 0x7C, 0xF8, 0x0F, 0x1F, 0x01, 0xE3,
  0xE0, 0x7C, 0x7C, 0x0F, 0x8F, 0x01, 0xF3, 0xE0, 0x3C, 0x7C, 0x07, 0x8F,
  0x81, 0xF1, 0xE0, 0x3E, 0x3C, 0x07, 0xCF, 0x80, 0xF1, 0xF0, 0x3E, 0x3E,
  0x07, 0xC7, 0xC1, 0xF8, 0xF0, 0x3F, 0x1F, 0x0F, 0xC3, 0xFF, 0xF8, 0x7F,
  0xEF, 0x07, 0xF9, 0xE0, 0x7E, 0x38, 0x00, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0xFB, 0xE0, 0x3E, 0xF8, 0x1F, 0x1E, 0x07, 0xC7, 0x83, 0xE1, 0xE0,
  0xF8, 0x78, 0x7C, 0x1E, 0x1F, 0x07, 0x8F, 0x81, 0xE3, 0xE0, 0x79, 0xF0,
  0x1E, 0x7C, 0x07, 0xBE, 0x01, 0xEF, 0x80, 0x7B, 0xC0, 0x0F, 0xF0, 0x03,
  0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x1F, 0x81,
  0xFF, 0x81, 0xF8, 0x1E, 0xF8, 0x3F, 0x83, 0xEF, 0x83, 0xF8, 0x3C, 0x78,
  0x3F, 0x87, 0xC7, 0x87, 0xF8, 0x7C, 0x78, 0x77, 0x8F, 0x87, 0x8F, 0x78,
  0xF8, 0x78, 0xF7, 0x8F, 0x07, 0x9E, 0x79, 0xF0, 0x79, 0xE7, 0x9E, 0x07,
  0x9C, 0x7B, 0xE0, 0x7B, 0xC7, 0xBC, 0x07, 0xBC, 0x7B, 0xC0, 0x7F, 0x87,
  0xFC, 0x07, 0xF8, 0x77, 0x80, 0x7F, 0x07, 0x78, 0x07, 0xF0, 0x7F, 0x00,
  0x7F, 0x07, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xC0,
  0x7C, 0x00, 0x07, 0xC0, 0x7C, 0x1F, 0x03, 0xE0, 0x3E, 0x1F, 0x80, 0xF8,
  0x7C, 0x03, 0xE3, 0xE0, 0x07, 0x9F, 0x00, 0x1F, 0x7C, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xF7, 0xC0, 0x0F, 0x9F,
  0x00, 0x3E, 0x3C, 0x01, 0xF0, 0xF8, 0x0F, 0x83, 0xE0, 0x7E, 0x0F, 0x83,
  0xF0, 0x1F, 0x00, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x7C, 0x1F, 0x01, 0xF0,
  0x1E, 0x03, 0xE0, 0x3C, 0x0F, 0x80, 0x78, 0x1F, 0x00, 0xF0, 0x7C, 0x01,
  0xE0, 0xF8, 0x03, 0xC3, 0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x9F, 0x00, 0x1F,
  0x3E, 0x00, 0x1E, 0x78, 0x00, 0x3D, 0xF0, 0x00, 0x7B, 0xC0, 0x00, 0xFF,
  0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x04, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07,
  0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFE, 0x00, 0x1F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F,
  0x00, 0x0F, 0x80, 0x07, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0xFF,
  0x00, 0x00, 0x03, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFC, 0x00,
  0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x1F, 0x80, 0x7F, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0xFF, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x3E, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x07, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0x80, 0x03, 0xF0, 0x03,
  0xF8, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF8, 0x00, 0xFF, 0x00, 0x3E, 0x00, 0x7E, 0x01, 0xFE, 0x03,
  0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0xFF, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x7F, 0xF8, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xA0, 0x07, 0xC0,
};

const GFXglyph NotoSans_SemiCondensed_SemiBoldItalic40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 12, 29, 11, 0, -29 },
  { 45, 13, 11, 16, 4, -29 },
  { 63, 23, 29, 23, 1, -29 },
  { 147, 19, 32, 20, 1, -30 },
  { 223, 28, 29, 31, 2, -29 },
  { 325, 23, 29, 25, 1, -29 },
  { 409, 6, 11, 9, 4, -29 },
  { 418, 14, 35, 12, 1, -29 },
  { 480, 14, 35, 12, -3, -29 },
  { 542, 17, 18, 20, 4, -31 },
  { 581, 18, 19, 21, 2, -24 },
  { 624, 9, 10, 10, -2, -5 },
  { 636, 10, 4, 12, 1, -13 },
  { 641, 6, 6, 10, 0, -6 },
  { 646, 21, 29, 15, -2, -29 },
  { 723, 19, 29, 20, 1, -29 },
  { 792, 14, 29, 20, 4, -29 },
  { 843, 21, 29, 20, -1, -29 },
  { 920, 20, 29, 20, 0, -29 },
  { 993, 20, 29, 20, 0, -29 },
  { 1066, 20, 29, 20, 0, -29 },
  { 1139, 19, 29, 20, 2, -29 },
  { 1208, 20, 29, 20, 2, -29 },
  { 1281, 19, 29, 20, 1, -29 },
  { 1350, 18, 29, 20, 1, -29 },
  { 1416, 10, 22, 10, 0, -22 },
  { 1444, 12, 27, 10, -2, -22 },
  { 1485, 18, 19, 21, 2, -24 },
  { 1528, 18, 12, 21, 2, -20 },
  { 1555, 18, 19, 21, 2, -24 },
  { 1598, 15, 29, 16, 2, -29 },
  { 1653, 28, 33, 31, 2, -29 },
  { 1769, 21, 29, 22, -2, -29 },
  { 1846, 21, 29, 22, 1, -29 },
  { 1923, 21, 29, 21, 2, -29 },
  { 2000, 22, 29, 24, 1, -29 },
  { 2080, 20, 29, 19, 1, -29 },
  { 2153, 20, 29, 18, 1, -29 },
  { 2226, 23, 29, 25, 2, -29 },
  { 2310, 25, 29, 25, 1, -29 },
  { 2401, 17, 29, 13, -1, -29 },
  { 2463, 18, 37, 11, -6, -29 },
  { 2547, 24, 29, 21, 1, -29 },
  { 2634, 15, 29, 18, 1, -29 },
  { 2689, 31, 29, 32, 1, -29 },
  { 2802, 26, 29, 27, 1, -29 },
  { 2897, 23, 29, 26, 2, -29 },
  { 2981, 21, 29, 21, 1, -29 },
  { 3058, 23, 36, 26, 2, -29 },
  { 3162, 20, 29, 22, 1, -29 },
  { 3235, 20, 29, 19, 0, -29 },
  { 3308, 19, 29, 19, 3, -29 },
  { 3377, 23, 29, 25, 2, -29 },
  { 3461, 21, 29, 21, 4, -29 },
  { 3538, 32, 29, 32, 4, -29 },
  { 3654, 26, 29, 21, -2, -29 },
  { 3749, 19, 29, 20, 4, -29 },
  { 3818, 22, 29, 19, -1, -29 },
  { 3898, 16, 35, 12, -1, -29 },
  { 3968, 9, 29, 15, 4, -29 },
  { 4001, 16, 35, 12, -3, -29 },
  { 4071, 19, 18, 20, 1, -29 },
  { 4114, 16, 2, 15, -4, 4 },
  { 4118, 7, 7, 12, 6, -31 },
  { 4125, 20, 22, 21, 1, -22 },
  { 4180, 20, 30, 21, 0, -30 },
  { 4255, 17, 22, 17, 1, -22 },
  { 4302, 22, 30, 21, 1, -30 },
  { 4385, 18, 22, 20, 1, -22 },
  { 4435, 21, 41, 13, -4, -31 },
  { 4543, 21, 32, 21, 0, -22 },
  { 4627, 20, 30, 22, 0, -30 },
  { 4702, 11, 30, 10, 0, -30 },
  { 4744, 16, 40, 10, -5, -30 },
  { 4824, 21, 30, 20, 0, -30 },
  { 4903, 12, 30, 10, 0, -30 },
  { 4948, 30, 22, 32, 0, -22 },
  { 5031, 20, 22, 22, 0, -22 },
  { 5086, 18, 22, 21, 1, -22 },
  { 5136, 22, 32, 21, -2, -22 },
  { 5224, 20, 32, 21, 1, -22 },
  { 5304, 17, 22, 15, 0, -22 },
  { 5351, 16, 22, 17, 0, -22 },
  { 5395, 13, 26, 14, 2, -26 },
  { 5438, 19, 22, 21, 2, -22 },
  { 5491, 18, 22, 18, 2, -22 },
  { 5541, 28, 22, 28, 2, -22 },
  { 5618, 22, 22, 19, -2, -22 },
  { 5679, 23, 32, 18, -3, -22 },
  { 5771, 18, 22, 16, -1, -22 },
  { 5821, 16, 35, 14, 0, -29 },
  { 5891, 4, 39, 19, 8, -30 },
  { 5911, 16, 35, 14, -2, -29 },
  { 5981, 18, 6, 21, 2, -17 },
};

const GFXfont NotoSans_SemiCondensed_SemiBoldItalic40pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_SemiBoldItalic40pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_SemiBoldItalic40pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC40PT7B_H_
