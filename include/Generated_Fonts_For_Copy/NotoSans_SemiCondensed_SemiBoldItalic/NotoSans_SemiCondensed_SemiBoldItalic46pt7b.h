#ifndef _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC46PT7B_H_
#define _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC46PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-SemiBoldItalic.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_SemiBoldItalic46pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x07, 0xE0,
  0x3F, 0x03, 0xF8, 0x0F, 0xC0, 0x7C, 0x00, 0x80, 0x00, 0x7E, 0x3E, 0xF8,
  0xFD, 0xF1, 0xF3, 0xE3, 0xE7, 0x87, 0xCF, 0x0F, 0xBE, 0x1E, 0x7C, 0x3C,
  0xF0, 0xF9, 0xE1, 0xE3, 0xC3, 0xC7, 0x87, 0x80, 0x00, 0x1E, 0x0F, 0x00,
  0x07, 0x83, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x1E,
  0x00, 0x0F, 0x07, 0x80, 0x07, 0xC3, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x78,
  0x3C, 0x07, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xC8, 0x7C, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x83, 0xC0,
  0x01, 0xE1, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x0F,
  0x00, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xF8, 0x0F, 0x07, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0xF0, 0x00,
  0x78, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x03, 0xC1, 0xE0,
  0x00, 0xF0, 0x78, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x7F, 0xF0, 0x07, 0xFF,
  0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xEE, 0xF8, 0x3F, 0x38, 0x40,
  0xF8, 0xC0, 0x03, 0xE3, 0x00, 0x0F, 0x9C, 0x00, 0x3E, 0x70, 0x00, 0xFD,
  0xC0, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0x7E, 0x00,
  0x1C, 0xF8, 0x00, 0x63, 0xE0, 0x01, 0x8F, 0x88, 0x0E, 0x3E, 0x38, 0x39,
  0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0x80,
  0x1F, 0xF8, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0xF0, 0x1F, 0xF0, 0x03,
  0xC0, 0x7F, 0xE0, 0x0F, 0x81, 0xFF, 0xE0, 0x1E, 0x03, 0xE7, 0xC0, 0x78,
  0x0F, 0x87, 0x81, 0xF0, 0x1E, 0x0F, 0x03, 0xC0, 0x3C, 0x1E, 0x0F, 0x80,
  0xF8, 0x7C, 0x3E, 0x01, 0xF0, 0xF8, 0x78, 0x03, 0xC1, 0xE1, 0xF0, 0x07,
  0x83, 0xC7, 0xC0, 0x0F, 0x07, 0x8F, 0x00, 0x1E, 0x1F, 0x3E, 0x3E, 0x3C,
  0x3C, 0xF9, 0xFF, 0x78, 0xF9, 0xE7, 0xFE, 0xFF, 0xE7, 0xDF, 0xFF, 0xFF,
  0x9F, 0x3E, 0x7D, 0xFF, 0x3C, 0xF8, 0x79, 0xF8, 0xF9, 0xE0, 0xF0, 0x03,
  0xE3, 0xC1, 0xE0, 0x07, 0x8F, 0x87, 0xC0, 0x1F, 0x1F, 0x0F, 0x80, 0x7C,
  0x3C, 0x1E, 0x00, 0xF0, 0x78, 0x3C, 0x03, 0xE0, 0xF0, 0x78, 0x0F, 0x81,
  0xE1, 0xF0, 0x1E, 0x03, 0xC3, 0xC0, 0x7C, 0x07, 0x8F, 0x81, 0xF0, 0x0F,
  0xBE, 0x03, 0xC0, 0x1F, 0xFC, 0x0F, 0x80, 0x1F, 0xF0, 0x3E, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0xFF, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x1F,
  0x00, 0x1F, 0x03, 0xE0, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x0F,
  0x87, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFE, 0x07, 0xE1, 0xFF,
  0xC0, 0xF8, 0x7F, 0xFC, 0x3F, 0x1F, 0x9F, 0x87, 0xC7, 0xE1, 0xF9, 0xF8,
  0xF8, 0x3F, 0xBE, 0x3F, 0x03, 0xFF, 0xC7, 0xE0, 0x3F, 0xF0, 0xFC, 0x07,
  0xFC, 0x1F, 0x00, 0x7F, 0x83, 0xF0, 0x0F, 0xE0, 0x7E, 0x03, 0xFC, 0x0F,
  0xF1, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xDF, 0x81, 0xFF, 0xF3,
  0xF8, 0x0F, 0xF8, 0x3F, 0x80, 0x7E, 0xF9, 0xF3, 0xE7, 0xCF, 0x3E, 0x7C,
  0xF1, 0xE3, 0xC7, 0x80, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFC,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0,
  0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01,
  0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0x80, 0x20, 0x78, 0x07, 0x87, 0x80, 0x7E, 0x70, 0x0F, 0xFF, 0x07, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0x3F, 0x07, 0xF8, 0x00,
  0xFF, 0x80, 0x1F, 0x3C, 0x07, 0xE3, 0xE0, 0x3E, 0x3E, 0x01, 0xC1, 0xF0,
  0x08, 0x1F, 0x00, 0x01, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x0F, 0xC7, 0xE1, 0xF8, 0x7C, 0x3F, 0x0F, 0x83, 0xE1,
  0xF0, 0x7C, 0x3E, 0x0F, 0x00, 0x7F, 0xF7, 0xFF, 0xFF, 0xEF, 0xFE, 0xFF,
  0xE0, 0x3E, 0xFD, 0xFF, 0xFF, 0xEF, 0x8C, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x07, 0xFE,
  0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0x7F, 0x07, 0xE0, 0xF8, 0x7E,
  0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0x01, 0xF9, 0xF8, 0x0F, 0xCF, 0x80, 0x7E,
  0xFC, 0x03, 0xF7, 0xE0, 0x1F, 0xBE, 0x00, 0xFD, 0xF0, 0x07, 0xDF, 0x80,
  0x3E, 0xFC, 0x01, 0xF7, 0xE0, 0x1F, 0xBE, 0x00, 0xFD, 0xF0, 0x07, 0xEF,
  0x80, 0x3E, 0x7C, 0x03, 0xF3, 0xE0, 0x1F, 0x9F, 0x00, 0xF8, 0xF8, 0x0F,
  0xC7, 0xC0, 0x7C, 0x3E, 0x07, 0xE1, 0xF8, 0x7E, 0x0F, 0xE7, 0xF0, 0x3F,
  0xFF, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0xFC, 0x07, 0xF8, 0x1F, 0xF0, 0x7F, 0xC3, 0xFF, 0x8F, 0xFF, 0x7F,
  0xBE, 0xFE, 0xFC, 0xF1, 0xF0, 0xC3, 0xE1, 0x07, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE,
  0x03, 0xFF, 0xFE, 0x01, 0xE0, 0x7E, 0x01, 0xC0, 0x3F, 0x00, 0x80, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xE0, 0x3F, 0x3F, 0xC0, 0x30, 0x1F, 0xC0, 0x40, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x80, 0x01, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC6, 0x00, 0x7F, 0x0F,
  0x83, 0xFE, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0x3F,
  0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x1E, 0xF8, 0x00, 0x7D, 0xF0, 0x01, 0xF7, 0xE0, 0x07, 0xCF,
  0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0xF8, 0xFC, 0x03, 0xE1, 0xF0,
  0x0F, 0x83, 0xE0, 0x1E, 0x07, 0xC0, 0x7C, 0x0F, 0x81, 0xF0, 0x3F, 0x07,
  0xC0, 0x7C, 0x0F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F,
  0x00, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE,
  0x03, 0xFF, 0xF8, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x90,
  0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0,
  0x30, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0xFE, 0x20, 0x07, 0xF0, 0xF0, 0x7F, 0x83, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x7F, 0xFE, 0x03, 0xFE, 0x18, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x3F, 0x01, 0xFB, 0xFE, 0x07, 0xDF,
  0xFC, 0x1F, 0xFF, 0xF8, 0x7F, 0xDF, 0xE3, 0xFC, 0x1F, 0x8F, 0xE0, 0x3E,
  0x3F, 0x00, 0xF8, 0xFC, 0x03, 0xE3, 0xF0, 0x0F, 0x8F, 0x80, 0x3E, 0x3E,
  0x01, 0xF8, 0xF8, 0x07, 0xE3, 0xE0, 0x1F, 0x0F, 0xC0, 0xFC, 0x3F, 0x07,
  0xF0, 0x7E, 0x3F, 0x81, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0xFF,
  0xFE, 0x07, 0xF1, 0xFC, 0x1F, 0x03, 0xF0, 0xFC, 0x07, 0xC3, 0xF0, 0x1F,
  0x0F, 0xC0, 0x7C, 0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0x81, 0xF0, 0x7E, 0x07,
  0xE3, 0xF0, 0x0F, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFF,
  0x00, 0x3F, 0xFE, 0x01, 0xFD, 0xFC, 0x0F, 0xE3, 0xF8, 0x7E, 0x07, 0xE1,
  0xF0, 0x0F, 0x8F, 0xC0, 0x3F, 0x3F, 0x00, 0xFC, 0xF8, 0x03, 0xF3, 0xE0,
  0x0F, 0xCF, 0xC0, 0x3E, 0x3F, 0x01, 0xF8, 0xFE, 0x0F, 0xE1, 0xFF, 0xFF,
  0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x0F, 0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0x3F, 0x87, 0xE0,
  0xFC, 0x7E, 0x03, 0xE3, 0xF0, 0x1F, 0x1F, 0x00, 0xF9, 0xF8, 0x07, 0xCF,
  0xC0, 0x3E, 0x7C, 0x01, 0xF3, 0xE0, 0x1F, 0x9F, 0x00, 0xFC, 0xFC, 0x0F,
  0xE7, 0xE0, 0x7F, 0x3F, 0x8F, 0xF8, 0xFF, 0xFF, 0x87, 0xFF, 0x7C, 0x1F,
  0xF3, 0xE0, 0x7F, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x0C, 0x0F,
  0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xE0, 0xFC, 0x1F, 0x87, 0xF0, 0xFE, 0x0F, 0x80, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x07, 0xE0, 0xFC, 0x3F, 0x87, 0xF0, 0x7C, 0x02, 0x00,
  0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xF0, 0x3F, 0x80, 0xF8, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0xF8, 0x0F, 0xC0,
  0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x7C,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x08, 0x00, 0x01, 0xC0, 0x00, 0x3E, 0x00,
  0x07, 0xF0, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0,
  0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x01, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x80, 0x00, 0x07, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF0, 0x00,
  0x7F, 0x80, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x01, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0x70, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x1F, 0xFF, 0x1F, 0xFF, 0xCF, 0xFF,
  0xE3, 0xE3, 0xF9, 0x80, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xF8, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xE0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x7C, 0x0F, 0x80,
  0x00, 0x1E, 0x0F, 0x80, 0x00, 0x0F, 0x07, 0x80, 0xFF, 0x07, 0xC7, 0x81,
  0xFF, 0xE1, 0xE7, 0xC1, 0xFF, 0xF0, 0xF3, 0xC1, 0xF8, 0xF0, 0x79, 0xE0,
  0xF0, 0x78, 0x3D, 0xE0, 0xF0, 0x3C, 0x1E, 0xF0, 0xF8, 0x3E, 0x0F, 0x78,
  0x78, 0x1E, 0x0F, 0x78, 0x3C, 0x0F, 0x07, 0xBC, 0x3E, 0x07, 0x83, 0xDE,
  0x1E, 0x07, 0xC1, 0xEF, 0x0F, 0x03, 0xC1, 0xE7, 0x87, 0x81, 0xE0, 0xF3,
  0xC3, 0xC1, 0xF0, 0xF9, 0xE1, 0xE1, 0xF8, 0x78, 0xF0, 0xF9, 0xFE, 0xF8,
  0x78, 0x3F, 0xEF, 0xF8, 0x3C, 0x1F, 0xE7, 0xF8, 0x1F, 0x07, 0xE1, 0xF8,
  0x07, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x0E, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x1F, 0x78,
  0x00, 0x0F, 0xBE, 0x00, 0x0F, 0x9F, 0x00, 0x07, 0xCF, 0x80, 0x07, 0xC7,
  0xC0, 0x03, 0xE3, 0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0xF8, 0x01, 0xF8,
  0x7C, 0x00, 0xF8, 0x3E, 0x00, 0xFC, 0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x7E,
  0x07, 0xC0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0xC7,
  0xE0, 0x03, 0xE3, 0xF0, 0x01, 0xF3, 0xF0, 0x00, 0xF9, 0xF8, 0x00, 0x7D,
  0xF8, 0x00, 0x3E, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xFF,
  0xE0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x03, 0xE0, 0x7F, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x1F, 0x07, 0xE0,
  0x1F, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x3F, 0x0F, 0xC0, 0x3E, 0x0F, 0xC0,
  0x7E, 0x0F, 0xC3, 0xFC, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0x03, 0xF8, 0x1F, 0x00, 0xFC, 0x1F, 0x00,
  0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3E, 0x00, 0xFC, 0x3E, 0x00,
  0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x01, 0xF8, 0x7E, 0x03, 0xF8, 0x7F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFC,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xC0, 0x30, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xF0, 0x0C, 0x03, 0xFF, 0x7E, 0x01, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0x00, 0xF8, 0x1F, 0xE0, 0x7E, 0x03, 0xF8, 0x1F, 0x80, 0x7E, 0x07,
  0xE0, 0x1F, 0xC1, 0xF8, 0x03, 0xF0, 0x7C, 0x00, 0xFC, 0x3F, 0x00, 0x3F,
  0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0xF8, 0x00, 0xFC, 0x3E, 0x00,
  0x3F, 0x1F, 0x80, 0x0F, 0xC7, 0xE0, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x7C,
  0x00, 0x7E, 0x1F, 0x00, 0x1F, 0x8F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xF0,
  0xFC, 0x01, 0xF8, 0x3E, 0x00, 0xFE, 0x1F, 0x80, 0x7F, 0x07, 0xE0, 0x3F,
  0xC1, 0xF8, 0x3F, 0xE0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF8, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFE,
  0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0,
  0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFF,
  0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xC0, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x03,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7C,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80,
  0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x07,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8,
  0x07, 0xF8, 0x07, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x1F,
  0xFC, 0x7E, 0x03, 0xFF, 0x0F, 0xC0, 0x7F, 0xE1, 0xF0, 0x1F, 0xFC, 0x3E,
  0x03, 0xFF, 0x8F, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x7C, 0x3F, 0x00, 0x0F,
  0x83, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xC1, 0xFC,
  0x01, 0xF0, 0x3F, 0xC0, 0x3E, 0x03, 0xFF, 0x7F, 0xC0, 0x3F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x01,
  0xF0, 0x01, 0xF0, 0x1F, 0x00, 0x1F, 0x03, 0xF0, 0x03, 0xF0, 0x3F, 0x00,
  0x3F, 0x03, 0xF0, 0x03, 0xF0, 0x3E, 0x00, 0x3E, 0x03, 0xE0, 0x07, 0xE0,
  0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xC0,
  0x07, 0xC0, 0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0xC0, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xF8, 0x1F, 0x80, 0x1F, 0x81, 0xF0, 0x01, 0xF0, 0x1F, 0x00, 0x3F,
  0x03, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x03, 0xF0, 0x03, 0xF0, 0x3E,
  0x00, 0x3E, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x07,
  0xE0, 0x7C, 0x00, 0x7C, 0x07, 0xC0, 0x07, 0xC0, 0xFC, 0x00, 0xFC, 0x0F,
  0xC0, 0x0F, 0xC0, 0xFC, 0x00, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x1F, 0xFF,
  0x01, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x03, 0xFF, 0x80, 0x7F, 0xFC,
  0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x7F, 0xF8, 0x03, 0xFF, 0xC0,
  0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x07,
  0xF0, 0x1F, 0x00, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x03,
  0xE0, 0x3F, 0x00, 0x3E, 0x07, 0xE0, 0x03, 0xE0, 0xFE, 0x00, 0x7E, 0x1F,
  0xC0, 0x07, 0xE1, 0xF8, 0x00, 0x7C, 0x3F, 0x00, 0x07, 0xC7, 0xE0, 0x00,
  0xFC, 0xFE, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0xF9, 0xF8, 0x00, 0x0F, 0xBF,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x1F, 0x1F, 0x80, 0x03, 0xF0,
  0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xE0, 0xFC, 0x00, 0x3E, 0x07, 0xC0,
  0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7C,
  0x03, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x1F,
  0x80, 0xFC, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFE, 0xFF, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x00,
  0xFF, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x01, 0xFF, 0x03, 0xFE,
  0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xE0,
  0x7F, 0xE0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x0F,
  0xFC, 0x07, 0xFE, 0x01, 0xF7, 0xC0, 0xFB, 0xE0, 0x1F, 0x7C, 0x0F, 0x9E,
  0x03, 0xEF, 0xC0, 0xF9, 0xE0, 0x3E, 0xF8, 0x0F, 0x9E, 0x07, 0xCF, 0x80,
  0xF9, 0xE0, 0x7C, 0xF8, 0x1F, 0x1E, 0x0F, 0x8F, 0x81, 0xF1, 0xE0, 0xF9,
  0xF8, 0x1F, 0x1E, 0x1F, 0x1F, 0x01, 0xF1, 0xF1, 0xF1, 0xF0, 0x1F, 0x1F,
  0x3E, 0x1F, 0x03, 0xE1, 0xF3, 0xE3, 0xF0, 0x3E, 0x1F, 0x7C, 0x3F, 0x03,
  0xE1, 0xF7, 0xC3, 0xE0, 0x3E, 0x1F, 0xF8, 0x3E, 0x07, 0xE1, 0xFF, 0x83,
  0xE0, 0x7C, 0x1F, 0xF0, 0x7E, 0x07, 0xC0, 0xFF, 0x07, 0xC0, 0x7C, 0x0F,
  0xE0, 0x7C, 0x07, 0xC0, 0xFE, 0x07, 0xC0, 0xFC, 0x0F, 0xC0, 0x7C, 0x0F,
  0x80, 0xFC, 0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x7C, 0x07, 0xE0, 0x01, 0xF0, 0x3F, 0xC0, 0x07, 0xC0, 0xFF, 0x00, 0x3F,
  0x03, 0xFC, 0x00, 0xF8, 0x0F, 0xF8, 0x03, 0xE0, 0x7F, 0xE0, 0x0F, 0x81,
  0xFF, 0x80, 0x3E, 0x07, 0xFE, 0x01, 0xF8, 0x1F, 0x7C, 0x07, 0xC0, 0x7D,
  0xF0, 0x1F, 0x03, 0xE7, 0xC0, 0x7C, 0x0F, 0x9F, 0x83, 0xF0, 0x3E, 0x3E,
  0x0F, 0x80, 0xF8, 0xF8, 0x3E, 0x03, 0xE3, 0xE0, 0xF8, 0x1F, 0x87, 0xC3,
  0xE0, 0x7C, 0x1F, 0x1F, 0x81, 0xF0, 0x7C, 0x7C, 0x07, 0xC1, 0xF9, 0xF0,
  0x1F, 0x03, 0xE7, 0xC0, 0xF8, 0x0F, 0x9F, 0x03, 0xE0, 0x3E, 0x7C, 0x0F,
  0x80, 0xFF, 0xE0, 0x3E, 0x01, 0xFF, 0x81, 0xF8, 0x07, 0xFE, 0x07, 0xC0,
  0x1F, 0xF8, 0x1F, 0x00, 0x3F, 0xE0, 0x7C, 0x00, 0xFF, 0x01, 0xF0, 0x03,
  0xFC, 0x0F, 0xC0, 0x0F, 0xF0, 0x3E, 0x00, 0x1F, 0xC0, 0xF8, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x0F, 0xF0, 0x3F, 0x81, 0xF8, 0x03,
  0xF0, 0x7F, 0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xE3, 0xF0, 0x00, 0xFC, 0x7E,
  0x00, 0x1F, 0x9F, 0x80, 0x03, 0xF3, 0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x0F,
  0xDF, 0x80, 0x01, 0xFB, 0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x07, 0xEF, 0xC0,
  0x01, 0xF9, 0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFD,
  0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x07, 0xE3, 0xE0, 0x01, 0xFC, 0x7E, 0x00,
  0x3F, 0x0F, 0xC0, 0x0F, 0xE1, 0xF8, 0x03, 0xF8, 0x3F, 0x80, 0xFE, 0x03,
  0xFE, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x03,
  0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xE0, 0x7F, 0x07,
  0xE0, 0x3F, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x1F, 0x07, 0xC0, 0x1F, 0x07,
  0xC0, 0x1F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x7E, 0x0F,
  0x80, 0xFE, 0x0F, 0x81, 0xFE, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF8, 0x0F, 0xF0, 0x3F, 0x81, 0xF8, 0x03, 0xF0, 0x7F, 0x00, 0x7F, 0x1F,
  0xC0, 0x07, 0xE3, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x9F, 0x80, 0x03,
  0xF3, 0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x0F, 0xDF, 0x80, 0x01, 0xFB, 0xF0,
  0x00, 0x3F, 0x7E, 0x00, 0x07, 0xEF, 0xC0, 0x01, 0xF9, 0xF0, 0x00, 0x3F,
  0x7E, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x3F, 0x3F, 0x00,
  0x07, 0xE3, 0xE0, 0x01, 0xFC, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xE1,
  0xF8, 0x03, 0xF8, 0x3F, 0x80, 0xFE, 0x03, 0xFE, 0xFF, 0xC0, 0x7F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xFC,
  0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x03, 0xE0, 0x7E, 0x07, 0xE0, 0x7F,
  0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x3F, 0x07, 0xC0, 0x3F, 0x07, 0xC0, 0x3F,
  0x0F, 0xC0, 0x3E, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0xFE, 0x0F, 0x81, 0xFC,
  0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80,
  0x1F, 0xFF, 0x80, 0x1F, 0x0F, 0x80, 0x3F, 0x0F, 0x80, 0x3F, 0x0F, 0xC0,
  0x3E, 0x0F, 0xC0, 0x3E, 0x07, 0xC0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x03, 0xE0, 0x7C, 0x03, 0xF0, 0x7C, 0x03, 0xF0, 0xFC, 0x03, 0xF0,
  0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xFC,
  0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFE, 0x03, 0x01,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC2, 0x00, 0x1F, 0x87,
  0x00, 0x7E, 0x0F, 0xEF, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x0F, 0xC3,
  0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0x80, 0x0F,
  0x87, 0xE0, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x1F, 0x00,
  0x1F, 0x07, 0xC0, 0x07, 0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x3F,
  0x00, 0x3F, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x03, 0xE1, 0xF8, 0x01, 0xF8,
  0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x87, 0xC0, 0x07, 0xC3, 0xF0, 0x03,
  0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0x83, 0xE0,
  0x07, 0xE0, 0xF8, 0x01, 0xF8, 0x3E, 0x00, 0x7E, 0x0F, 0xC0, 0x3F, 0x03,
  0xF0, 0x1F, 0xC0, 0xFF, 0xBF, 0xE0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC,
  0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0xFC, 0xFC,
  0x00, 0xFC, 0x7C, 0x01, 0xF8, 0x7C, 0x01, 0xF8, 0x7C, 0x01, 0xF0, 0x7C,
  0x03, 0xF0, 0x7C, 0x03, 0xE0, 0x7C, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0x7C,
  0x0F, 0xC0, 0x7C, 0x0F, 0x80, 0x7C, 0x1F, 0x80, 0x7C, 0x1F, 0x00, 0x7C,
  0x3F, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x7E, 0x00, 0x7C, 0x7C, 0x00, 0x7C,
  0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x3D,
  0xF0, 0x00, 0x3D, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0xFC,
  0x00, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xC0, 0x0F, 0xFF, 0x00, 0x7E, 0x00,
  0x7D, 0xF8, 0x03, 0xF0, 0x07, 0xEF, 0xC0, 0x3F, 0x80, 0x3E, 0x7E, 0x01,
  0xFC, 0x03, 0xF3, 0xF0, 0x1F, 0xE0, 0x1F, 0x9F, 0x80, 0xFF, 0x00, 0xF8,
  0xFC, 0x07, 0xF8, 0x0F, 0xC7, 0xE0, 0x7F, 0xC0, 0x7C, 0x3F, 0x03, 0xDE,
  0x07, 0xE1, 0xF8, 0x3E, 0xF0, 0x3E, 0x0F, 0xC1, 0xF7, 0x81, 0xF0, 0x7E,
  0x1F, 0x3C, 0x1F, 0x83, 0xF0, 0xF9, 0xE0, 0xF8, 0x0F, 0x87, 0x8F, 0x0F,
  0xC0, 0x7C, 0x7C, 0x78, 0x7C, 0x03, 0xE3, 0xC3, 0xC7, 0xE0, 0x1F, 0x3E,
  0x1E, 0x3E, 0x00, 0xF9, 0xF0, 0xF1, 0xF0, 0x07, 0xDF, 0x07, 0x9F, 0x80,
  0x3E, 0xF8, 0x3C, 0xF8, 0x01, 0xE7, 0x81, 0xE7, 0xC0, 0x0F, 0x7C, 0x0F,
  0x7C, 0x00, 0x7B, 0xC0, 0x7B, 0xE0, 0x03, 0xDE, 0x03, 0xFE, 0x00, 0x1F,
  0xF0, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x07, 0xF8,
  0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x0F, 0xC0,
  0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0xFC,
  0x03, 0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0xFC, 0x00,
  0x7E, 0x07, 0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xE0, 0xFC, 0x00, 0x0F,
  0xC7, 0xE0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x7C, 0xFC, 0x00, 0x01, 0xF7,
  0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x7E,
  0x3E, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x7E, 0x0F,
  0xC0, 0x03, 0xF0, 0x1F, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x7E, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x0F, 0xC0, 0xFE, 0x00, 0x3F, 0x00,
  0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xF9, 0xF0, 0x07, 0xE3, 0xE0, 0x0F, 0xC7,
  0xE0, 0x3F, 0x0F, 0xC0, 0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0x07, 0xE0, 0x3E,
  0x0F, 0x80, 0x7C, 0x3F, 0x00, 0xFC, 0x7C, 0x00, 0xF9, 0xF8, 0x01, 0xF7,
  0xE0, 0x03, 0xEF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xF0,
  0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7F, 0xE0, 0x1F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF,
  0x00, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x83, 0xC1, 0xF0, 0xF8, 0x7C, 0x3E,
  0x1F, 0x0F, 0x83, 0xC1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x83, 0xC1,
  0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x83, 0xC1, 0xF0, 0xF8, 0x7C, 0x3E,
  0x1F, 0x0F, 0x80, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFE,
  0x01, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x7F, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7D, 0xE0, 0x01, 0xE7, 0xC0, 0x0F, 0x9F,
  0x00, 0x3C, 0x3C, 0x01, 0xF0, 0xF8, 0x0F, 0x83, 0xE0, 0x3C, 0x07, 0x81,
  0xF0, 0x1F, 0x07, 0x80, 0x7C, 0x3E, 0x00, 0xF1, 0xF0, 0x03, 0xE7, 0x80,
  0x0F, 0xBE, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFC,
  0xFC, 0x7C, 0x3E, 0x3E, 0x1F, 0x0F, 0x01, 0xFC, 0x3C, 0x0F, 0xF9, 0xF0,
  0x7F, 0xF7, 0xC3, 0xFF, 0xFE, 0x1F, 0xC7, 0xF8, 0x7E, 0x0F, 0xE3, 0xF0,
  0x3F, 0x8F, 0xC0, 0x7E, 0x7E, 0x01, 0xF1, 0xF8, 0x07, 0xC7, 0xC0, 0x1F,
  0x3F, 0x00, 0xFC, 0xFC, 0x03, 0xF3, 0xF0, 0x0F, 0x8F, 0x80, 0x3E, 0x3E,
  0x01, 0xF8, 0xF8, 0x07, 0xE3, 0xE0, 0x3F, 0x0F, 0x80, 0xFC, 0x3F, 0x07,
  0xF0, 0xFE, 0x7F, 0xC3, 0xFF, 0xDF, 0x07, 0xFF, 0x78, 0x1F, 0xF9, 0xE0,
  0x1F, 0x8F, 0x80, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x7E, 0x01, 0xF7, 0xFC,
  0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0x1F, 0xC3, 0xF8, 0x3F, 0x1F,
  0xC0, 0xFC, 0x7E, 0x03, 0xF1, 0xF8, 0x0F, 0xC7, 0xC0, 0x3F, 0x1F, 0x00,
  0xFC, 0xFC, 0x03, 0xF3, 0xE0, 0x0F, 0xCF, 0x80, 0x3E, 0x3E, 0x01, 0xF8,
  0xF8, 0x07, 0xE7, 0xE0, 0x1F, 0x1F, 0x80, 0xFC, 0x7E, 0x03, 0xF1, 0xF8,
  0x1F, 0x8F, 0xF0, 0xFE, 0x3F, 0xFF, 0xF0, 0xFB, 0xFF, 0x83, 0xCF, 0xFC,
  0x0F, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xFC, 0x3F,
  0xFE, 0x1F, 0xE3, 0x87, 0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x08, 0xFE, 0x1C, 0x1F, 0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x01, 0xFC, 0x7C, 0x03, 0xFE,
  0x7C, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xC7, 0xF8, 0x1F, 0x83,
  0xF8, 0x3F, 0x01, 0xF8, 0x3F, 0x01, 0xF8, 0x7E, 0x01, 0xF0, 0x7E, 0x01,
  0xF0, 0x7C, 0x01, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xE0, 0xFC, 0x03,
  0xE0, 0xF8, 0x03, 0xE0, 0xF8, 0x07, 0xE0, 0xF8, 0x07, 0xE0, 0xF8, 0x0F,
  0xC0, 0xF8, 0x0F, 0xC0, 0xFC, 0x1F, 0xC0, 0xFE, 0x3F, 0xC0, 0xFF, 0xFF,
  0xC0, 0x7F, 0xF7, 0x80, 0x7F, 0xE7, 0x80, 0x1F, 0x87, 0x80, 0x00, 0xFF,
  0x80, 0x7F, 0xF8, 0x1F, 0xFF, 0x87, 0xFF, 0xF1, 0xFC, 0x3E, 0x3E, 0x07,
  0xCF, 0xC0, 0xF9, 0xF0, 0x1F, 0x7E, 0x07, 0xEF, 0x81, 0xFF, 0xF1, 0xFF,
  0x7F, 0xFF, 0xCF, 0xFF, 0xE1, 0xFF, 0xF0, 0x3F, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x8F, 0xE0, 0x70,
  0xFF, 0xFE, 0x1F, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x7F, 0x30, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x00,
  0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0x0F, 0x00, 0xFF, 0x9F, 0x01, 0xFF, 0xDF, 0x03, 0xFF, 0xFE, 0x07, 0xF1,
  0xFE, 0x07, 0xE0, 0xFE, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x7E, 0x1F, 0x80,
  0x7C, 0x1F, 0x80, 0x7C, 0x1F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00,
  0xFC, 0x3F, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x3E, 0x01, 0xF8, 0x3E, 0x01,
  0xF8, 0x3E, 0x03, 0xF0, 0x3E, 0x07, 0xF0, 0x3F, 0x07, 0xF0, 0x3F, 0x9F,
  0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFB, 0xE0, 0x1F, 0xF3, 0xE0, 0x0F, 0xE3,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0xC0, 0x1F, 0x80, 0xFC, 0xFF, 0x80, 0xFF, 0xFF,
  0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x7E, 0x01, 0xF7, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xE0, 0xFF, 0x1F, 0xC3, 0xF8, 0x3F, 0x1F, 0xC0, 0xFC, 0x7F, 0x03, 0xF1,
  0xF8, 0x0F, 0xC7, 0xE0, 0x3E, 0x1F, 0x00, 0xF8, 0xFC, 0x07, 0xE3, 0xF0,
  0x1F, 0x8F, 0x80, 0x7E, 0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC7, 0xE0, 0x3F,
  0x1F, 0x80, 0xFC, 0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x8F, 0xC0, 0x3E, 0x3F,
  0x01, 0xF8, 0xFC, 0x07, 0xE3, 0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x00, 0x00,
  0x40, 0x1F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x7C, 0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0xF8, 0x1F,
  0x81, 0xF8, 0x1F, 0x81, 0xF0, 0x1F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3E,
  0x03, 0xE0, 0x7E, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0x80, 0xF8, 0x00, 0x00, 0x00, 0x80, 0x00, 0x7C, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xC0,
  0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x7F, 0x07, 0xC0, 0xFC, 0x0F, 0xC1, 0xF8, 0x0F, 0xC3, 0xF0,
  0x0F, 0x87, 0xF0, 0x0F, 0x87, 0xE0, 0x1F, 0x8F, 0xC0, 0x1F, 0x9F, 0x80,
  0x1F, 0x3F, 0x00, 0x1F, 0x7E, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0x3E, 0x00,
  0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7C, 0x1F, 0x80, 0x7C, 0x1F, 0x80,
  0xFC, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0xF8, 0x0F, 0xC0, 0xF8, 0x0F, 0xC0,
  0xF8, 0x07, 0xE0, 0x00, 0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x00,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x3F, 0x00,
  0x07, 0x8F, 0xE0, 0x7F, 0x01, 0xE7, 0xFC, 0x3F, 0xE0, 0xFB, 0xFF, 0x9F,
  0xF8, 0x3F, 0xFF, 0xEF, 0xFF, 0x0F, 0xF1, 0xFF, 0x8F, 0xC3, 0xF8, 0x3F,
  0xC3, 0xF1, 0xFC, 0x0F, 0xE0, 0x7C, 0x7E, 0x03, 0xF0, 0x1F, 0x1F, 0x80,
  0xFC, 0x0F, 0xC7, 0xE0, 0x3E, 0x03, 0xF1, 0xF0, 0x1F, 0x80, 0xF8, 0xFC,
  0x07, 0xE0, 0x3E, 0x3F, 0x01, 0xF0, 0x0F, 0x8F, 0x80, 0x7C, 0x07, 0xE3,
  0xE0, 0x3F, 0x01, 0xF8, 0xF8, 0x0F, 0xC0, 0x7C, 0x7E, 0x03, 0xE0, 0x1F,
  0x1F, 0x80, 0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x03, 0xF1, 0xF0, 0x1F, 0x80,
  0xFC, 0xFC, 0x07, 0xE0, 0x3E, 0x3F, 0x01, 0xF0, 0x0F, 0x8F, 0x80, 0x7C,
  0x07, 0xE3, 0xE0, 0x1F, 0x01, 0xF8, 0xF8, 0x0F, 0xC0, 0x7C, 0x00, 0x03,
  0xC3, 0xF0, 0x07, 0x9F, 0xF8, 0x1F, 0x7F, 0xF0, 0x3F, 0xFF, 0xF0, 0x7F,
  0xCF, 0xE0, 0xFE, 0x0F, 0xC3, 0xF8, 0x1F, 0x87, 0xF0, 0x3F, 0x0F, 0xC0,
  0x7E, 0x1F, 0x80, 0xF8, 0x3E, 0x01, 0xF0, 0xFC, 0x07, 0xE1, 0xF8, 0x0F,
  0xC3, 0xE0, 0x1F, 0x87, 0xC0, 0x3E, 0x0F, 0x80, 0x7C, 0x3F, 0x01, 0xF8,
  0x7E, 0x03, 0xF0, 0xF8, 0x07, 0xC1, 0xF0, 0x0F, 0x87, 0xE0, 0x1F, 0x0F,
  0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x3E, 0x01, 0xF0, 0xFC, 0x03, 0xE0, 0x00,
  0xFF, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x1F, 0xC7, 0xF3,
  0xF8, 0x3F, 0x3F, 0x01, 0xF7, 0xE0, 0x1F, 0x7E, 0x01, 0xF7, 0xC0, 0x1F,
  0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x03,
  0xFF, 0x80, 0x3E, 0xF8, 0x07, 0xEF, 0x80, 0x7E, 0xF8, 0x0F, 0xCF, 0xC1,
  0xFC, 0xFE, 0x3F, 0x87, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xC0, 0x0F,
  0xF8, 0x00, 0x00, 0xF1, 0xFC, 0x00, 0x79, 0xFF, 0x00, 0x7D, 0xFF, 0xC0,
  0x3F, 0xFF, 0xE0, 0x1F, 0xE3, 0xF8, 0x0F, 0xE0, 0xFC, 0x0F, 0xE0, 0x7E,
  0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x81, 0xF0, 0x0F, 0xC0, 0xF8, 0x07,
  0xE0, 0xFC, 0x03, 0xF0, 0x7C, 0x01, 0xF8, 0x3E, 0x00, 0xF8, 0x1F, 0x00,
  0xFC, 0x0F, 0x80, 0x7E, 0x0F, 0xC0, 0x3E, 0x07, 0xE0, 0x3F, 0x03, 0xF0,
  0x1F, 0x81, 0xF8, 0x1F, 0x80, 0xFE, 0x1F, 0xC0, 0xFF, 0xFF, 0xC0, 0x7D,
  0xFF, 0xC0, 0x3E, 0x7F, 0xC0, 0x1F, 0x1F, 0xC0, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x3C, 0x0F, 0xF9,
  0xF0, 0x7F, 0xF7, 0xC3, 0xFF, 0xFE, 0x1F, 0xC7, 0xF8, 0x7E, 0x0F, 0xE3,
  0xF0, 0x1F, 0x8F, 0x80, 0x7E, 0x7E, 0x01, 0xF1, 0xF8, 0x07, 0xC7, 0xC0,
  0x1F, 0x3F, 0x00, 0xFC, 0xFC, 0x03, 0xE3, 0xF0, 0x0F, 0x8F, 0x80, 0x3E,
  0x3E, 0x01, 0xF8, 0xF8, 0x07, 0xE3, 0xE0, 0x3F, 0x0F, 0x80, 0xFC, 0x3F,
  0x07, 0xF0, 0xFE, 0x3F, 0xC3, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x1F, 0xFB,
  0xE0, 0x1F, 0x8F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x07, 0x8F,
  0xC1, 0xE7, 0xF0, 0xFB, 0xF8, 0x3E, 0xFE, 0x0F, 0xFF, 0x83, 0xFC, 0x01,
  0xFE, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0xFF, 0xFC,
  0x3F, 0xFF, 0x07, 0xFF, 0xE1, 0xFC, 0x18, 0x3F, 0x01, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00,
  0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x40, 0x1F, 0x8E, 0x07, 0xF1, 0xFF, 0xFC, 0x3F,
  0xFF, 0x87, 0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x0F,
  0x00, 0x3E, 0x00, 0x7C, 0x03, 0xFF, 0xDF, 0xFF, 0xBF, 0xFE, 0xFF, 0xFC,
  0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x43, 0xFF, 0x87, 0xFF, 0x07,
  0xFE, 0x07, 0xFC, 0x00, 0x0F, 0x80, 0x7C, 0x7E, 0x03, 0xF1, 0xF8, 0x0F,
  0xC7, 0xC0, 0x3E, 0x1F, 0x00, 0xF8, 0xFC, 0x03, 0xE3, 0xF0, 0x1F, 0x8F,
  0x80, 0x7E, 0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC7, 0xE0, 0x3F, 0x1F, 0x80,
  0xFC, 0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x7E, 0x3F, 0x01, 0xF8,
  0xFC, 0x07, 0xE3, 0xE0, 0x3F, 0x0F, 0x80, 0xFC, 0x3F, 0x07, 0xF0, 0xFC,
  0x7F, 0xC3, 0xFF, 0xDF, 0x07, 0xFF, 0x78, 0x1F, 0xF9, 0xE0, 0x3F, 0x87,
  0x80, 0xFC, 0x01, 0xFB, 0xE0, 0x0F, 0xDF, 0x00, 0xFC, 0xF8, 0x07, 0xE7,
  0xC0, 0x7E, 0x3E, 0x03, 0xE1, 0xF0, 0x3F, 0x0F, 0x81, 0xF0, 0x7C, 0x1F,
  0x83, 0xE0, 0xF8, 0x1F, 0x0F, 0xC0, 0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x1E,
  0x3E, 0x00, 0xF9, 0xF0, 0x07, 0xDF, 0x00, 0x3E, 0xF8, 0x01, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xF8, 0x0F, 0xC0, 0x3F, 0xF0,
  0x1F, 0x80, 0xFF, 0xE0, 0x7F, 0x01, 0xF7, 0xC0, 0xFE, 0x07, 0xEF, 0x81,
  0xFC, 0x0F, 0x9F, 0x07, 0xF8, 0x1F, 0x3E, 0x0F, 0xF0, 0x7C, 0x7C, 0x3F,
  0xE0, 0xF8, 0xF8, 0x7B, 0xC3, 0xF1, 0xF1, 0xF7, 0x87, 0xC3, 0xE3, 0xCF,
  0x1F, 0x87, 0xC7, 0x9E, 0x3E, 0x0F, 0x9F, 0x3C, 0x7C, 0x1F, 0x3C, 0x79,
  0xF0, 0x3E, 0xF8, 0xF3, 0xE0, 0x7D, 0xE1, 0xEF, 0x80, 0xFB, 0xC3, 0xDF,
  0x01, 0xFF, 0x07, 0xBE, 0x03, 0xFE, 0x0F, 0xF8, 0x07, 0xFC, 0x1F, 0xF0,
  0x0F, 0xF0, 0x3F, 0xC0, 0x1F, 0xE0, 0x7F, 0x80, 0x3F, 0x80, 0xFE, 0x00,
  0x7F, 0x01, 0xFC, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x1F, 0x81,
  0xF8, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0x3E, 0x0F, 0xC0, 0x1F, 0x0F, 0xC0,
  0x0F, 0xCF, 0xC0, 0x03, 0xE7, 0xC0, 0x01, 0xF7, 0xE0, 0x00, 0xFF, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF,
  0x80, 0x01, 0xF7, 0xE0, 0x01, 0xF9, 0xF0, 0x01, 0xF8, 0xF8, 0x01, 0xF8,
  0x7E, 0x00, 0xFC, 0x1F, 0x00, 0xFC, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0xFC,
  0x03, 0xF0, 0x00, 0x01, 0xF0, 0x07, 0xE0, 0x3E, 0x00, 0xFC, 0x07, 0xC0,
  0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x01, 0xF8, 0x03, 0xE0, 0x3F, 0x00,
  0x7C, 0x0F, 0xC0, 0x0F, 0x81, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x0F,
  0xC0, 0x03, 0xE1, 0xF0, 0x00, 0x7C, 0x7E, 0x00, 0x0F, 0x8F, 0x80, 0x01,
  0xF3, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x07, 0xDF, 0x80, 0x00, 0xFB, 0xE0,
  0x00, 0x1F, 0x7C, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF,
  0xF0, 0x7F, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xFF, 0xF0,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xE0, 0x01,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x00, 0xFC, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0,
  0x01, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x00, 0x7E, 0x00, 0x1F,
  0xC0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07,
  0xFC, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x1F, 0xE0, 0x0F, 0xF8, 0x07, 0xE0,
  0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xE0, 0x00,
  0x0E, 0x00, 0x09, 0xFF, 0x00, 0x5F, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFA, 0x00, 0x3F, 0x80,
};

const GFXglyph NotoSans_SemiCondensed_SemiBoldItalic46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 13, 34, 12, 0, -33 },
  { 57, 15, 12, 19, 5, -33 },
  { 80, 26, 33, 27, 1, -33 },
  { 188, 22, 38, 23, 1, -35 },
  { 293, 31, 33, 36, 3, -33 },
  { 421, 27, 33, 28, 1, -33 },
  { 533, 7, 12, 11, 5, -33 },
  { 544, 16, 40, 14, 1, -33 },
  { 624, 15, 40, 14, -3, -33 },
  { 699, 20, 20, 23, 4, -35 },
  { 749, 21, 22, 24, 2, -27 },
  { 807, 10, 11, 12, -2, -5 },
  { 821, 12, 5, 14, 1, -15 },
  { 829, 7, 7, 12, 0, -6 },
  { 836, 23, 33, 18, -2, -33 },
  { 931, 21, 33, 23, 2, -33 },
  { 1018, 15, 33, 23, 5, -33 },
  { 1080, 24, 33, 23, -1, -33 },
  { 1179, 23, 33, 23, 0, -33 },
  { 1274, 23, 33, 23, 0, -33 },
  { 1369, 22, 33, 23, 1, -33 },
  { 1460, 22, 33, 23, 2, -33 },
  { 1551, 23, 33, 23, 2, -33 },
  { 1646, 22, 33, 23, 1, -33 },
  { 1737, 21, 33, 23, 1, -33 },
  { 1824, 11, 26, 12, 0, -25 },
  { 1860, 13, 31, 12, -2, -25 },
  { 1911, 21, 23, 24, 2, -28 },
  { 1972, 21, 13, 24, 2, -23 },
  { 2007, 21, 23, 24, 2, -28 },
  { 2068, 17, 34, 18, 3, -33 },
  { 2141, 33, 37, 35, 2, -33 },
  { 2294, 25, 33, 25, -3, -33 },
  { 2398, 24, 33, 26, 1, -33 },
  { 2497, 25, 33, 25, 2, -33 },
  { 2601, 26, 33, 28, 1, -33 },
  { 2709, 23, 33, 22, 1, -33 },
  { 2804, 23, 33, 21, 1, -33 },
  { 2899, 27, 33, 29, 2, -33 },
  { 3011, 28, 33, 29, 1, -33 },
  { 3127, 20, 33, 16, -2, -33 },
  { 3210, 21, 42, 13, -7, -33 },
  { 3321, 28, 33, 25, 1, -33 },
  { 3437, 17, 33, 21, 1, -33 },
  { 3508, 36, 33, 37, 1, -33 },
  { 3657, 30, 33, 31, 1, -33 },
  { 3781, 27, 33, 30, 2, -33 },
  { 3893, 24, 33, 25, 1, -33 },
  { 3992, 27, 41, 30, 2, -33 },
  { 4131, 24, 33, 25, 1, -33 },
  { 4230, 23, 33, 22, 0, -33 },
  { 4325, 21, 33, 22, 4, -33 },
  { 4412, 26, 33, 28, 3, -33 },
  { 4520, 24, 33, 24, 4, -33 },
  { 4619, 37, 33, 37, 4, -33 },
  { 4772, 30, 33, 24, -3, -33 },
  { 4896, 23, 33, 23, 4, -33 },
  { 4991, 25, 33, 22, -1, -33 },
  { 5095, 18, 40, 14, -1, -33 },
  { 5185, 9, 33, 18, 5, -33 },
  { 5223, 18, 40, 14, -3, -33 },
  { 5313, 22, 20, 23, 1, -33 },
  { 5368, 17, 3, 17, -4, 4 },
  { 5375, 8, 7, 14, 7, -35 },
  { 5382, 22, 25, 25, 2, -25 },
  { 5451, 22, 35, 25, 1, -35 },
  { 5548, 18, 25, 20, 2, -25 },
  { 5605, 24, 35, 25, 2, -35 },
  { 5710, 19, 25, 22, 2, -25 },
  { 5770, 25, 46, 15, -5, -35 },
  { 5914, 24, 36, 25, 0, -25 },
  { 6022, 22, 35, 25, 1, -35 },
  { 6119, 12, 35, 12, 1, -35 },
  { 6172, 19, 46, 12, -6, -35 },
  { 6282, 24, 35, 23, 1, -35 },
  { 6387, 13, 35, 12, 0, -35 },
  { 6444, 34, 25, 37, 1, -25 },
  { 6551, 23, 25, 25, 0, -25 },
  { 6623, 20, 25, 24, 2, -25 },
  { 6686, 25, 36, 25, -2, -25 },
  { 6799, 22, 36, 25, 2, -25 },
  { 6898, 18, 25, 17, 1, -25 },
  { 6955, 19, 25, 19, 0, -25 },
  { 7015, 15, 30, 16, 2, -30 },
  { 7072, 22, 25, 25, 2, -25 },
  { 7141, 21, 25, 21, 2, -25 },
  { 7207, 31, 25, 32, 3, -25 },
  { 7304, 25, 25, 21, -2, -25 },
  { 7383, 27, 36, 21, -4, -25 },
  { 7505, 20, 25, 19, -1, -25 },
  { 7568, 19, 40, 16, 0, -33 },
  { 7663, 4, 46, 22, 9, -35 },
  { 7686, 18, 40, 16, -2, -33 },
  { 7776, 21, 7, 24, 2, -20 },
};

const GFXfont NotoSans_SemiCondensed_SemiBoldItalic46pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_SemiBoldItalic46pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_SemiBoldItalic46pt7bGlyphs,
  0x20, 0x7E, 63
};

#endif // _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC46PT7B_H_
