#ifndef _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC13PT7B_H_
#define _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC13PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-SemiBoldItalic.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_SemiBoldItalic13pt7bBitmaps[] PROGMEM = {
  0x00, 0x32, 0x66, 0x64, 0x0C, 0xC0, 0x5A, 0xB4, 0x1A, 0x16, 0x7F, 0x34,
  0x24, 0xFE, 0x68, 0x48, 0x50, 0x08, 0x3C, 0xD3, 0x87, 0x07, 0x07, 0x4E,
  0xF8, 0x40, 0x80, 0x73, 0x4B, 0x2D, 0x15, 0x6F, 0xF8, 0xAC, 0x94, 0xCA,
  0xC6, 0x00, 0x3C, 0x34, 0x24, 0x38, 0x33, 0x5A, 0xCE, 0xCC, 0x7E, 0x5C,
  0x19, 0x88, 0xC4, 0x23, 0x18, 0xC2, 0x10, 0x30, 0x84, 0x31, 0x08, 0x46,
  0x23, 0x30, 0x12, 0x4F, 0xCD, 0xD0, 0x60, 0x20, 0x82, 0x3F, 0x20, 0x82,
  0x00, 0x2D, 0x60, 0xF0, 0xF0, 0x06, 0x08, 0x20, 0xC1, 0x06, 0x08, 0x30,
  0xC0, 0x3C, 0x96, 0x51, 0x47, 0x3C, 0xD6, 0x70, 0x3F, 0x94, 0x63, 0x18,
  0x84, 0x60, 0x7C, 0x90, 0x43, 0x18, 0xC6, 0x30, 0xF8, 0x7C, 0x90, 0x43,
  0x38, 0x30, 0xE6, 0xF8, 0x0C, 0x71, 0xCB, 0x4B, 0x2F, 0xC6, 0x18, 0x3E,
  0x40, 0x83, 0xC5, 0xC1, 0x83, 0x4C, 0xF0, 0x3D, 0x8C, 0x2C, 0xDA, 0x69,
  0xA4, 0xF0, 0xFC, 0x21, 0x84, 0x30, 0x86, 0x30, 0xC0, 0x3C, 0x4D, 0x91,
  0xE3, 0x89, 0xB3, 0x66, 0x78, 0x3D, 0x94, 0x51, 0x7C, 0xF0, 0x86, 0xF0,
  0x6C, 0x01, 0xB0, 0x33, 0x00, 0x02, 0x64, 0xC0, 0x04, 0x66, 0x30, 0x70,
  0x70, 0x40, 0xF8, 0x3E, 0x83, 0x03, 0x03, 0x73, 0x08, 0x00, 0xF0, 0xC4,
  0x66, 0x60, 0x10, 0xC0, 0x1F, 0x8C, 0x26, 0x75, 0x29, 0x52, 0x54, 0xAD,
  0x69, 0x2C, 0x60, 0x0F, 0x80, 0x0E, 0x1C, 0x78, 0x93, 0x27, 0xD8, 0xB1,
  0xC2, 0x3E, 0x4C, 0x9B, 0x67, 0xCC, 0x91, 0xA6, 0xF8, 0x3E, 0xC3, 0x06,
  0x08, 0x10, 0x20, 0x64, 0x78, 0x3E, 0x26, 0x23, 0x63, 0x62, 0x62, 0x46,
  0x4C, 0xF8, 0x3E, 0x40, 0x83, 0xE7, 0xCC, 0x10, 0x20, 0xF8, 0x3E, 0x40,
  0x83, 0x07, 0xCC, 0x10, 0x20, 0xC0, 0x3E, 0xC7, 0x06, 0x09, 0xF0, 0xA3,
  0x66, 0x7C, 0x31, 0x23, 0x23, 0x7F, 0x7E, 0x62, 0x46, 0x46, 0xC4, 0x79,
  0x8C, 0x42, 0x31, 0x88, 0xE0, 0x0C, 0x20, 0x86, 0x18, 0x61, 0x04, 0x30,
  0xCE, 0x30, 0x33, 0x26, 0x2C, 0x78, 0x78, 0x78, 0x48, 0x4C, 0xCC, 0x31,
  0x08, 0xC6, 0x31, 0x08, 0xF8, 0x30, 0xE6, 0x38, 0xC7, 0x3D, 0xE7, 0xAC,
  0xBD, 0x17, 0x22, 0x6C, 0xC9, 0x80, 0x31, 0x98, 0x8E, 0x4D, 0x26, 0xB2,
  0x79, 0x38, 0x8C, 0xC6, 0x00, 0x3C, 0xCF, 0x0E, 0x18, 0x70, 0xE1, 0x66,
  0x78, 0x3E, 0x4C, 0x8B, 0x37, 0xCE, 0x10, 0x20, 0xC0, 0x3C, 0xCF, 0x0E,
  0x18, 0x70, 0xE1, 0x66, 0x78, 0x30, 0x70, 0x3C, 0x4C, 0x9B, 0x37, 0xCD,
  0x12, 0x26, 0xCC, 0x3E, 0xC1, 0x83, 0x83, 0x83, 0x02, 0x4C, 0xF0, 0xFC,
  0xC2, 0x08, 0x61, 0x86, 0x10, 0xC0, 0x62, 0x8D, 0x1E, 0x2C, 0x51, 0xA3,
  0x6C, 0xF8, 0xC7, 0x8B, 0x36, 0x4D, 0x8A, 0x1C, 0x30, 0x60, 0xCC, 0x79,
  0x9B, 0x32, 0x6A, 0x4D, 0x59, 0xEA, 0x39, 0xC7, 0x30, 0xC6, 0x00, 0x33,
  0x89, 0x07, 0x83, 0x81, 0xC0, 0xE0, 0xD0, 0xCC, 0xC6, 0x00, 0xCE, 0x91,
  0x62, 0x87, 0x0C, 0x18, 0x20, 0x40, 0x7E, 0x18, 0x20, 0xC3, 0x04, 0x18,
  0x60, 0xF8, 0x39, 0x08, 0xC4, 0x21, 0x18, 0xC4, 0x38, 0xC9, 0x24, 0xDB,
  0x20, 0x38, 0x46, 0x21, 0x08, 0xC6, 0x21, 0x38, 0x18, 0x62, 0x9B, 0xC4,
  0xF8, 0xD0, 0x3E, 0xC9, 0x92, 0x2C, 0xC9, 0x9E, 0x00, 0x30, 0x40, 0x81,
  0xE6, 0x4C, 0xD1, 0x26, 0xCD, 0xF0, 0x3D, 0x84, 0x10, 0xC1, 0x27, 0x80,
  0x02, 0x04, 0x19, 0xF6, 0x48, 0x91, 0x66, 0x4C, 0xF0, 0x3D, 0x94, 0xDE,
  0xC1, 0x27, 0x80, 0x0E, 0x30, 0x61, 0xE1, 0x06, 0x0C, 0x10, 0x20, 0xC1,
  0x83, 0x0C, 0x00, 0x3E, 0xC9, 0x92, 0x2C, 0xC9, 0x9E, 0x04, 0x99, 0xE0,
  0x30, 0x82, 0x0F, 0x65, 0x94, 0x53, 0xCF, 0x20, 0x33, 0x02, 0x66, 0x44,
  0xCC, 0x0C, 0x30, 0x02, 0x18, 0x61, 0x04, 0x30, 0xC3, 0x08, 0xE0, 0x30,
  0x40, 0x81, 0x36, 0xCF, 0x1C, 0x2C, 0xD9, 0x98, 0x33, 0x22, 0x66, 0x44,
  0xCC, 0x3D, 0xD9, 0xB6, 0x4D, 0x33, 0x4C, 0xB3, 0x2C, 0x98, 0x3D, 0x96,
  0x51, 0x4F, 0x3C, 0x80, 0x3D, 0x94, 0x51, 0xCD, 0x37, 0x80, 0x1E, 0x32,
  0x33, 0x22, 0x26, 0x66, 0x7C, 0x60, 0x40, 0xC0, 0x3E, 0xC9, 0x12, 0x2C,
  0xC9, 0x9E, 0x04, 0x18, 0x30, 0x3B, 0x98, 0x84, 0x63, 0x00, 0x7A, 0x58,
  0x61, 0xCF, 0xC0, 0x24, 0xFC, 0xC8, 0x88, 0xE0, 0xCF, 0x2C, 0xA2, 0x9A,
  0x6F, 0x00, 0x8E, 0x69, 0x2C, 0xA3, 0x8C, 0x00, 0x99, 0xCD, 0xAA, 0xD5,
  0x4E, 0xE6, 0x63, 0x30, 0x37, 0x34, 0x1C, 0x18, 0x38, 0x2C, 0xCC, 0x23,
  0x26, 0x24, 0x2C, 0x38, 0x38, 0x30, 0x30, 0x20, 0xC0, 0x78, 0xCC, 0x46,
  0x63, 0xC0, 0x19, 0x8C, 0x46, 0x61, 0x8C, 0x42, 0x18, 0xFF, 0xF8, 0x38,
  0xC6, 0x21, 0x0C, 0xC4, 0x23, 0x30, 0x47, 0xF0,
};

const GFXglyph NotoSans_SemiCondensed_SemiBoldItalic13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 4, 9, 3, 0, -9 },
  { 6, 5, 3, 5, 1, -9 },
  { 8, 8, 9, 8, 0, -9 },
  { 17, 7, 11, 7, 0, -10 },
  { 27, 9, 9, 10, 1, -9 },
  { 38, 8, 9, 8, 0, -9 },
  { 47, 2, 3, 3, 1, -9 },
  { 48, 5, 11, 4, 0, -9 },
  { 55, 5, 11, 4, -1, -9 },
  { 62, 6, 6, 6, 1, -10 },
  { 67, 6, 7, 7, 1, -8 },
  { 73, 3, 4, 3, -1, -2 },
  { 75, 4, 1, 4, 0, -4 },
  { 76, 2, 2, 3, 0, -2 },
  { 77, 7, 9, 5, -1, -9 },
  { 85, 6, 9, 7, 0, -9 },
  { 92, 5, 9, 7, 1, -9 },
  { 98, 6, 9, 7, 0, -9 },
  { 105, 6, 9, 7, 0, -9 },
  { 112, 6, 9, 7, 0, -9 },
  { 119, 7, 9, 7, 0, -9 },
  { 127, 6, 9, 7, 1, -9 },
  { 134, 6, 9, 7, 1, -9 },
  { 141, 7, 9, 7, 0, -9 },
  { 149, 6, 9, 7, 0, -9 },
  { 156, 3, 7, 3, 0, -7 },
  { 159, 4, 9, 3, -1, -7 },
  { 164, 6, 7, 7, 1, -8 },
  { 170, 5, 3, 7, 1, -6 },
  { 172, 6, 7, 7, 1, -8 },
  { 178, 5, 9, 5, 1, -9 },
  { 184, 10, 10, 10, 0, -9 },
  { 197, 7, 9, 7, -1, -9 },
  { 205, 7, 9, 7, 0, -9 },
  { 213, 7, 9, 7, 1, -9 },
  { 221, 8, 9, 8, 0, -9 },
  { 230, 7, 9, 6, 0, -9 },
  { 238, 7, 9, 6, 0, -9 },
  { 246, 7, 9, 8, 1, -9 },
  { 254, 8, 9, 8, 0, -9 },
  { 263, 5, 9, 4, 0, -9 },
  { 269, 6, 12, 4, -2, -9 },
  { 278, 8, 9, 7, 0, -9 },
  { 287, 5, 9, 6, 0, -9 },
  { 293, 11, 9, 10, 0, -9 },
  { 306, 9, 9, 9, 0, -9 },
  { 317, 7, 9, 8, 1, -9 },
  { 325, 7, 9, 7, 0, -9 },
  { 333, 7, 11, 8, 1, -9 },
  { 343, 7, 9, 7, 0, -9 },
  { 351, 7, 9, 6, 0, -9 },
  { 359, 6, 9, 6, 1, -9 },
  { 366, 7, 9, 8, 1, -9 },
  { 374, 7, 9, 7, 1, -9 },
  { 382, 11, 9, 10, 1, -9 },
  { 395, 9, 9, 7, -1, -9 },
  { 406, 7, 9, 6, 1, -9 },
  { 414, 7, 9, 6, 0, -9 },
  { 422, 5, 11, 4, 0, -9 },
  { 429, 3, 9, 5, 1, -9 },
  { 433, 5, 11, 4, -1, -9 },
  { 440, 6, 5, 7, 0, -9 },
  { 444, 5, 1, 5, -1, 1 },
  { 445, 2, 2, 4, 2, -10 },
  { 446, 7, 7, 7, 0, -7 },
  { 453, 7, 10, 7, 0, -10 },
  { 462, 6, 7, 6, 0, -7 },
  { 468, 7, 10, 7, 0, -10 },
  { 477, 6, 7, 6, 0, -7 },
  { 483, 7, 13, 4, -1, -10 },
  { 495, 7, 10, 7, 0, -7 },
  { 504, 6, 10, 7, 0, -10 },
  { 512, 4, 10, 3, 0, -10 },
  { 517, 6, 13, 3, -2, -10 },
  { 527, 7, 10, 6, 0, -10 },
  { 536, 4, 10, 3, 0, -10 },
  { 541, 10, 7, 10, 0, -7 },
  { 550, 6, 7, 7, 0, -7 },
  { 556, 6, 7, 7, 0, -7 },
  { 562, 8, 10, 7, -1, -7 },
  { 572, 7, 10, 7, 0, -7 },
  { 581, 5, 7, 5, 0, -7 },
  { 586, 5, 7, 5, 0, -7 },
  { 591, 4, 9, 4, 1, -9 },
  { 596, 6, 7, 7, 1, -7 },
  { 602, 6, 7, 6, 1, -7 },
  { 608, 9, 7, 9, 1, -7 },
  { 616, 8, 7, 6, -1, -7 },
  { 623, 8, 10, 6, -1, -7 },
  { 633, 5, 7, 5, 0, -7 },
  { 638, 5, 11, 5, 0, -9 },
  { 645, 1, 13, 6, 3, -10 },
  { 647, 5, 11, 5, -1, -9 },
  { 654, 6, 2, 7, 1, -6 },
};

const GFXfont NotoSans_SemiCondensed_SemiBoldItalic13pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_SemiBoldItalic13pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_SemiBoldItalic13pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC13PT7B_H_
