#ifndef _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC49PT7B_H_
#define _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC49PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-SemiBoldItalic.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_SemiBoldItalic49pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x1F,
  0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x3E, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x3E, 0x00, 0x40, 0x00,
  0x3E, 0x3F, 0x7E, 0x3F, 0x7E, 0x3F, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E,
  0x7C, 0x3E, 0x78, 0x7C, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0x78, 0xF0, 0x78,
  0xF0, 0x78, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x1F, 0x07,
  0x80, 0x01, 0xE0, 0xF8, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00,
  0x3E, 0x0F, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0xC1,
  0xE0, 0x1F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x7C, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xF0,
  0x78, 0x00, 0x1E, 0x0F, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x3E, 0x0F, 0x00,
  0x03, 0xC1, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x80, 0x78, 0x3C, 0x00, 0x0F, 0x83, 0xC0,
  0x00, 0xF0, 0x7C, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xF0, 0x78, 0x00, 0x1E,
  0x0F, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xE1, 0xF0,
  0x00, 0x3C, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xFF, 0x01,
  0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xE7, 0x1C, 0x0F,
  0xC7, 0x00, 0x0F, 0xCE, 0x00, 0x0F, 0x8E, 0x00, 0x0F, 0xCE, 0x00, 0x0F,
  0xCE, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x3F, 0xF0, 0x00, 0x3B, 0xF8, 0x00, 0x39, 0xF8, 0x00, 0x71, 0xF8, 0x00,
  0x71, 0xF8, 0x80, 0x71, 0xF8, 0xC0, 0x73, 0xF0, 0xF8, 0x67, 0xF0, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x7C, 0x07, 0xFE, 0x00,
  0x3C, 0x07, 0xFF, 0x00, 0x3E, 0x03, 0xFF, 0xC0, 0x3E, 0x03, 0xE3, 0xE0,
  0x1E, 0x01, 0xF1, 0xF0, 0x1F, 0x01, 0xF0, 0xF8, 0x1F, 0x00, 0xF8, 0x7C,
  0x0F, 0x00, 0x78, 0x3E, 0x0F, 0x80, 0x7C, 0x1F, 0x0F, 0x80, 0x3E, 0x0F,
  0x87, 0x80, 0x1F, 0x07, 0x87, 0xC0, 0x0F, 0x87, 0xC7, 0xC0, 0x07, 0xC3,
  0xE3, 0xC0, 0x83, 0xE1, 0xF3, 0xE3, 0xF9, 0xF1, 0xF3, 0xE3, 0xFE, 0xF8,
  0xF9, 0xE3, 0xFF, 0x7F, 0xF9, 0xF3, 0xFF, 0xDF, 0xF9, 0xF3, 0xE3, 0xEF,
  0xF8, 0xF1, 0xF0, 0xF3, 0xF8, 0xF9, 0xF0, 0x78, 0x00, 0xF8, 0xF8, 0x7C,
  0x00, 0x78, 0x7C, 0x3E, 0x00, 0x7C, 0x3C, 0x1F, 0x00, 0x7C, 0x3E, 0x0F,
  0x80, 0x3E, 0x1F, 0x07, 0xC0, 0x3E, 0x0F, 0x83, 0xC0, 0x3E, 0x07, 0xC3,
  0xE0, 0x1F, 0x03, 0xE1, 0xF0, 0x1F, 0x01, 0xF1, 0xF0, 0x1F, 0x00, 0xF8,
  0xF8, 0x0F, 0x80, 0x7F, 0xF8, 0x0F, 0x80, 0x1F, 0xFC, 0x0F, 0x80, 0x0F,
  0xFC, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xC7, 0xE0,
  0x00, 0xFC, 0x1F, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x3E, 0x07, 0xC0, 0x01,
  0xF0, 0x7E, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x7C, 0x3F, 0x00, 0x03, 0xE3,
  0xF0, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x0F, 0xC3,
  0xFF, 0xC0, 0xFC, 0x3F, 0xFF, 0x07, 0xE3, 0xF9, 0xF8, 0x7E, 0x3F, 0x87,
  0xE3, 0xF1, 0xF8, 0x3F, 0xBF, 0x0F, 0xC0, 0xFD, 0xF8, 0xFC, 0x07, 0xFF,
  0x87, 0xE0, 0x1F, 0xF8, 0x3F, 0x00, 0xFF, 0xC1, 0xF8, 0x03, 0xFC, 0x0F,
  0xC0, 0x1F, 0xC0, 0x7F, 0x03, 0xFF, 0x03, 0xFE, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xBF, 0x81, 0xFF, 0xF8, 0xFC, 0x03, 0xFF, 0x07,
  0xF0, 0x3F, 0x3E, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0x78, 0x78, 0xF8, 0xF8,
  0xF0, 0xF0, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x0F,
  0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01,
  0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x78, 0x02, 0x03, 0xC0, 0x1C, 0x1E, 0x01, 0xF9, 0xE0,
  0x0F, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xC0, 0xFF, 0xFE, 0x03,
  0xFF, 0xF0, 0x3F, 0xC0, 0x83, 0xFE, 0x00, 0x3E, 0xF8, 0x03, 0xF3, 0xC0,
  0x3F, 0x1F, 0x00, 0xF0, 0xF8, 0x03, 0x83, 0xE0, 0x08, 0x1F, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC3, 0xF0, 0xFC, 0x7E, 0x1F,
  0x8F, 0xC3, 0xF0, 0xF8, 0x7C, 0x1F, 0x0F, 0x83, 0xE0, 0x7F, 0xFB, 0xFF,
  0xFF, 0xFD, 0xFF, 0xEF, 0xFF, 0x00, 0x1C, 0x3E, 0x7F, 0x7F, 0xFF, 0x7E,
  0x7C, 0x10, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xFF,
  0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7E, 0x0F, 0xC3,
  0xF0, 0x3F, 0x1F, 0xC0, 0xFC, 0x7E, 0x03, 0xF1, 0xF8, 0x0F, 0xCF, 0xC0,
  0x3F, 0x3F, 0x00, 0xFD, 0xFC, 0x03, 0xF7, 0xE0, 0x0F, 0xDF, 0x80, 0x3F,
  0x7E, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x7E, 0xFC,
  0x01, 0xFB, 0xF0, 0x07, 0xEF, 0xC0, 0x1F, 0xBF, 0x00, 0xFC, 0xF8, 0x03,
  0xF3, 0xE0, 0x0F, 0xCF, 0x80, 0x7E, 0x3E, 0x01, 0xF8, 0xFC, 0x0F, 0xC3,
  0xF0, 0x3F, 0x0F, 0xC1, 0xF8, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x01, 0xFF,
  0xF8, 0x03, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0x80,
  0x3F, 0xC0, 0x3F, 0xE0, 0x7F, 0xF0, 0x7F, 0xF8, 0x7F, 0xF8, 0xFF, 0x7C,
  0xFF, 0x7E, 0x3F, 0x3F, 0x0E, 0x1F, 0x06, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF8, 0x0F, 0x81, 0xFC, 0x03, 0x80, 0x7E, 0x01, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0x01, 0xC0, 0x7F, 0x01, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x80, 0x03, 0xF8, 0xE0, 0x07, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0x7C,
  0x00, 0x1F, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x7C, 0xFC, 0x00, 0xFC, 0xFC,
  0x00, 0xF8, 0xF8, 0x01, 0xF0, 0xF8, 0x03, 0xE1, 0xF8, 0x07, 0xE1, 0xF8,
  0x07, 0xC1, 0xF8, 0x0F, 0x81, 0xF0, 0x1F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3E, 0x03, 0xF0, 0x7C, 0x03, 0xE0, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFE,
  0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xBE, 0x00,
  0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0,
  0x04, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x80, 0x07, 0xF0, 0xC0, 0x1F, 0xE0,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x00, 0x70, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF8,
  0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x3F, 0xF3, 0x80, 0xFF, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xCF, 0xF0, 0x1F, 0x7F,
  0xF0, 0x7E, 0xFF, 0xE0, 0xFF, 0xFF, 0xE1, 0xFF, 0x1F, 0xC3, 0xFC, 0x1F,
  0xCF, 0xE0, 0x1F, 0x9F, 0xC0, 0x3F, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0xFC,
  0xFC, 0x01, 0xF9, 0xF8, 0x03, 0xE3, 0xF0, 0x0F, 0xC7, 0xE0, 0x1F, 0x8F,
  0xC0, 0x7F, 0x1F, 0x80, 0xFC, 0x1F, 0x83, 0xF8, 0x3F, 0xFF, 0xE0, 0x7F,
  0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x03,
  0xF8, 0xFE, 0x07, 0xE0, 0x7F, 0x07, 0xE0, 0x3F, 0x07, 0xC0, 0x3F, 0x07,
  0xC0, 0x3F, 0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0xFC, 0x03, 0xF3, 0xF8, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00,
  0xFF, 0x80, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x1F, 0xEF, 0xE0, 0x3F,
  0x87, 0xF0, 0x3F, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x7C, 0x01, 0xF8, 0xFC,
  0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC,
  0x01, 0xF8, 0xFE, 0x03, 0xF0, 0x7F, 0x0F, 0xF0, 0x7F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x02, 0x00, 0x00,
  0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x83, 0xF8, 0x3F, 0x07, 0xE0, 0x3F, 0x1F, 0x80, 0x7E, 0x3F, 0x00,
  0xFC, 0x7E, 0x01, 0xF9, 0xF8, 0x03, 0xF3, 0xF0, 0x07, 0xE7, 0xE0, 0x0F,
  0xCF, 0xC0, 0x3F, 0x9F, 0x80, 0x7F, 0x3F, 0x01, 0xFC, 0x7F, 0x07, 0xF8,
  0x7F, 0x9F, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF, 0xEF, 0xC1, 0xFF, 0x9F, 0x01,
  0xFE, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x7D, 0xFF, 0x80, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xE0,
  0x07, 0xFF, 0x00, 0x00, 0x01, 0xE0, 0x3F, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x7E, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x07,
  0xE0, 0x7F, 0x07, 0xF0, 0xFF, 0x0F, 0xE0, 0x7C, 0x01, 0x00, 0x00, 0x3C,
  0x00, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E,
  0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x70, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0x00,
  0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE,
  0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x0F,
  0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x07, 0xFE, 0x07, 0xFF, 0xC7, 0xFF, 0xF8, 0xFF, 0xFF, 0x3F, 0xBF,
  0xCE, 0x03, 0xF2, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00,
  0x03, 0xC1, 0xF0, 0x07, 0x80, 0x7C, 0x3C, 0x07, 0xFF, 0x8F, 0x8F, 0x81,
  0xFF, 0xE0, 0xF3, 0xE0, 0x7F, 0xFC, 0x1E, 0x7C, 0x1F, 0x0F, 0x83, 0xCF,
  0x07, 0xC1, 0xF0, 0x7B, 0xE0, 0xF0, 0x3C, 0x0F, 0x78, 0x3E, 0x07, 0x81,
  0xEF, 0x07, 0x81, 0xF0, 0x7F, 0xE1, 0xF0, 0x3E, 0x0F, 0xFC, 0x3C, 0x07,
  0x81, 0xEF, 0x07, 0x80, 0xF0, 0x3D, 0xE0, 0xF0, 0x3E, 0x0F, 0xBC, 0x1E,
  0x07, 0xC1, 0xE7, 0x83, 0xC1, 0xF0, 0x7C, 0xF0, 0x78, 0x3E, 0x0F, 0x1E,
  0x0F, 0x8F, 0xE3, 0xE3, 0xC1, 0xFF, 0xBF, 0xF8, 0x7C, 0x3F, 0xF7, 0xFE,
  0x0F, 0x83, 0xFC, 0x7F, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x1F, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x0C, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFB,
  0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x07, 0xCF, 0x80, 0x00, 0xF9, 0xF0, 0x00,
  0x3E, 0x3E, 0x00, 0x07, 0xC7, 0xC0, 0x01, 0xF8, 0xF8, 0x00, 0x3E, 0x1F,
  0x00, 0x0F, 0xC3, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x7E, 0x0F, 0xC0, 0x0F,
  0x81, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x1F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xE1,
  0xF8, 0x00, 0x7C, 0x3F, 0x00, 0x0F, 0x8F, 0xC0, 0x01, 0xF9, 0xF8, 0x00,
  0x3F, 0x7F, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0xFC, 0x0F, 0xF0, 0x3F, 0x01, 0xFC, 0x0F,
  0xC0, 0x3F, 0x03, 0xE0, 0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0xFC,
  0x1F, 0x80, 0x7E, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x1F, 0xC0, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xC0, 0x7E, 0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x07, 0xE0, 0x1F, 0x81,
  0xF0, 0x07, 0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x7F, 0x0F, 0xC0, 0x1F,
  0x83, 0xF0, 0x07, 0xE0, 0xF8, 0x03, 0xF8, 0x7E, 0x00, 0xFE, 0x1F, 0x80,
  0xFF, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xFF,
  0x01, 0xC0, 0xFF, 0x00, 0x10, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x18, 0x07, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0x07, 0xFC, 0x03, 0xF0, 0x1F,
  0xE0, 0x3F, 0x00, 0xFE, 0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x07,
  0xE0, 0x07, 0xF0, 0x7E, 0x00, 0x7F, 0x07, 0xE0, 0x07, 0xF0, 0xFE, 0x00,
  0x7F, 0x0F, 0xC0, 0x07, 0xF0, 0xFC, 0x00, 0x7F, 0x0F, 0xC0, 0x07, 0xE0,
  0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x07, 0xE1, 0xF8, 0x00, 0x7E, 0x1F, 0x80,
  0x0F, 0xE1, 0xF8, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0xC3, 0xF0, 0x01, 0xFC,
  0x3F, 0x00, 0x3F, 0x83, 0xF0, 0x03, 0xF8, 0x3F, 0x00, 0x7F, 0x03, 0xF0,
  0x0F, 0xE0, 0x7E, 0x03, 0xFE, 0x07, 0xE0, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0x03, 0xFF, 0xFE, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xE0, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xC0, 0x7F, 0xC0, 0x3C, 0x07, 0xF8, 0x00, 0x80, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x04, 0xFE, 0x03, 0xFF, 0x8F, 0xC0, 0x3F, 0xF8,
  0xFC, 0x03, 0xFF, 0x8F, 0xC0, 0x7F, 0xF8, 0xFC, 0x07, 0xFF, 0x8F, 0xC0,
  0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F,
  0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x0F, 0xE0, 0x07, 0xE0, 0xFF,
  0x00, 0x7E, 0x07, 0xF8, 0x07, 0xE0, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0xFC, 0x07, 0xE0, 0x03, 0xF0, 0x1F, 0x80, 0x0F, 0xC0,
  0x7E, 0x00, 0x3F, 0x03, 0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0x07, 0xE0, 0x3F,
  0x00, 0x1F, 0x80, 0xFC, 0x00, 0x7E, 0x03, 0xF0, 0x01, 0xF8, 0x1F, 0x80,
  0x0F, 0xC0, 0x7E, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0xFC, 0x07, 0xE0, 0x03,
  0xF0, 0x1F, 0x80, 0x0F, 0xC0, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x07,
  0xE0, 0x03, 0xF0, 0x1F, 0x80, 0x0F, 0xC0, 0x7E, 0x00, 0x3F, 0x01, 0xF8,
  0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0x3F, 0x00, 0x1F, 0x80, 0xFC, 0x00,
  0x7E, 0x03, 0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0x07, 0xE0, 0x7E, 0x00, 0x3F,
  0x01, 0xF8, 0x00, 0xFC, 0x07, 0xE0, 0x03, 0xF0, 0x1F, 0x80, 0x0F, 0xC0,
  0x7C, 0x00, 0x7F, 0x03, 0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0x07, 0xE0, 0x00,
  0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x3F, 0xFC, 0x00,
  0x3F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7F,
  0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7F, 0x00, 0x21, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xE0, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x01, 0xFC, 0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0x80, 0x7F, 0x00, 0x7C,
  0x03, 0xF8, 0x03, 0xF0, 0x1F, 0xC0, 0x0F, 0xC0, 0xFE, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0xFC, 0x1F, 0xC0, 0x03, 0xE0, 0xFE, 0x00, 0x1F, 0x87, 0xF0,
  0x00, 0x7E, 0x3F, 0x80, 0x01, 0xF8, 0xFC, 0x00, 0x07, 0xE7, 0xF0, 0x00,
  0x1F, 0x3F, 0x80, 0x00, 0xFD, 0xFC, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x1F, 0xEF, 0xC0, 0x00, 0x7E, 0x3F, 0x00, 0x01, 0xF0, 0xFC,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0xFC, 0x1F, 0x80,
  0x03, 0xF0, 0x3F, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x7E, 0x03, 0xF0, 0x01,
  0xF8, 0x0F, 0xE0, 0x07, 0xE0, 0x1F, 0x80, 0x1F, 0x80, 0x7E, 0x00, 0x7C,
  0x01, 0xFC, 0x03, 0xF0, 0x03, 0xF0, 0x0F, 0xC0, 0x0F, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xF8, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x0F, 0xF0, 0x00,
  0x3F, 0xE0, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x01, 0xFF, 0x00,
  0xFF, 0xC0, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x03, 0xFF, 0x00,
  0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0x7C, 0x01, 0xF7, 0xC0,
  0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x7D, 0xF0, 0x0F, 0xBF, 0x01, 0xFB, 0xE0,
  0x1F, 0x7E, 0x03, 0xF7, 0xC0, 0x7C, 0xFC, 0x07, 0xEF, 0x80, 0xF9, 0xF0,
  0x0F, 0x8F, 0x03, 0xE3, 0xE0, 0x1F, 0x1E, 0x07, 0xCF, 0xC0, 0x7E, 0x3C,
  0x1F, 0x1F, 0x80, 0xFC, 0x7C, 0x3E, 0x3F, 0x01, 0xF0, 0xF8, 0xF8, 0x7C,
  0x03, 0xE1, 0xF1, 0xF0, 0xF8, 0x07, 0xC3, 0xE7, 0xC3, 0xF0, 0x1F, 0x87,
  0xCF, 0x87, 0xE0, 0x3F, 0x0F, 0xBE, 0x0F, 0xC0, 0x7C, 0x1F, 0x7C, 0x1F,
  0x00, 0xF8, 0x3F, 0xF0, 0x7E, 0x01, 0xF0, 0x7F, 0xE0, 0xFC, 0x07, 0xE0,
  0xFF, 0x81, 0xF8, 0x0F, 0xC1, 0xFF, 0x03, 0xE0, 0x1F, 0x03, 0xFC, 0x07,
  0xC0, 0x3E, 0x07, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x1F, 0x01, 0xFC, 0x00, 0x1F, 0x01, 0xFE, 0x00, 0x3F, 0x01, 0xFE, 0x00,
  0x3F, 0x03, 0xFE, 0x00, 0x3E, 0x03, 0xFF, 0x00, 0x3E, 0x03, 0xFF, 0x00,
  0x7E, 0x03, 0xFF, 0x00, 0x7E, 0x03, 0xFF, 0x00, 0x7E, 0x07, 0xDF, 0x80,
  0x7C, 0x07, 0xDF, 0x80, 0x7C, 0x07, 0xCF, 0x80, 0xFC, 0x07, 0xCF, 0xC0,
  0xFC, 0x0F, 0xCF, 0xC0, 0xF8, 0x0F, 0xC7, 0xC0, 0xF8, 0x0F, 0xC7, 0xC0,
  0xF8, 0x0F, 0x87, 0xE1, 0xF8, 0x0F, 0x87, 0xE1, 0xF8, 0x1F, 0x83, 0xE1,
  0xF0, 0x1F, 0x83, 0xF1, 0xF0, 0x1F, 0x03, 0xF1, 0xF0, 0x1F, 0x01, 0xF3,
  0xF0, 0x1F, 0x01, 0xF3, 0xF0, 0x3F, 0x01, 0xFB, 0xE0, 0x3F, 0x01, 0xFB,
  0xE0, 0x3E, 0x00, 0xFB, 0xE0, 0x3E, 0x00, 0xFF, 0xE0, 0x3E, 0x00, 0xFF,
  0xE0, 0x7E, 0x00, 0xFF, 0xC0, 0x7E, 0x00, 0x7F, 0xC0, 0x7C, 0x00, 0x7F,
  0xC0, 0x7C, 0x00, 0x7F, 0xC0, 0xFC, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x3F,
  0x80, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x00, 0xFE, 0x0F, 0xE0, 0x07,
  0xE1, 0xFC, 0x00, 0x7F, 0x1F, 0x80, 0x07, 0xF3, 0xF8, 0x00, 0x3F, 0x3F,
  0x00, 0x03, 0xF7, 0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xF7, 0xE0, 0x00,
  0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFE, 0xFC, 0x00,
  0x0F, 0xEF, 0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0xCF, 0xC0, 0x01, 0xF8,
  0xFC, 0x00, 0x3F, 0x8F, 0xC0, 0x03, 0xF8, 0xFE, 0x00, 0x7F, 0x0F, 0xE0,
  0x0F, 0xE0, 0x7F, 0x83, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0x80, 0xFC, 0x0F, 0xE0, 0x3F, 0x01, 0xFC, 0x0F, 0xC0,
  0x3F, 0x03, 0xF0, 0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x1F,
  0x80, 0x3F, 0x07, 0xE0, 0x1F, 0xC3, 0xF0, 0x07, 0xE0, 0xFC, 0x03, 0xF8,
  0x3F, 0x01, 0xFC, 0x0F, 0xC1, 0xFF, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x00, 0xFE, 0x0F, 0xE0, 0x07,
  0xE1, 0xFC, 0x00, 0x7F, 0x1F, 0x80, 0x07, 0xF3, 0xF8, 0x00, 0x3F, 0x3F,
  0x00, 0x03, 0xF7, 0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xF7, 0xE0, 0x00,
  0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFE, 0xFC, 0x00,
  0x0F, 0xEF, 0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0xCF, 0xC0, 0x01, 0xF8,
  0xFC, 0x00, 0x3F, 0x8F, 0xC0, 0x03, 0xF8, 0xFE, 0x00, 0x7F, 0x0F, 0xE0,
  0x0F, 0xE0, 0x7F, 0x83, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0x80, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0x83, 0xFC, 0x0F, 0xC0,
  0x7E, 0x07, 0xE0, 0x3F, 0x03, 0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0xC1, 0xF8,
  0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x3F,
  0x01, 0xFC, 0x1F, 0x81, 0xFE, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07,
  0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0xFC, 0x7E, 0x00,
  0x7E, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x83, 0xF8,
  0x0F, 0xC0, 0xFC, 0x07, 0xC0, 0x7E, 0x07, 0xE0, 0x3F, 0x83, 0xF0, 0x0F,
  0xC1, 0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xF8, 0xFC, 0x01, 0xFC, 0x7E, 0x00,
  0x7E, 0x3F, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFF, 0xC0,
  0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xC0, 0x70,
  0x1F, 0xC0, 0x08, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x04, 0x00, 0x7F, 0x07,
  0x80, 0x7F, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xC0, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0xFC,
  0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x07,
  0xE1, 0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC1, 0xF8, 0x00, 0xFC, 0x1F,
  0x80, 0x0F, 0xC1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x83, 0xF0, 0x01,
  0xF8, 0x3F, 0x00, 0x1F, 0x83, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0x87,
  0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x00,
  0x3F, 0x0F, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE0,
  0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xE0, 0xFC, 0x00, 0xFC, 0x0F, 0xC0,
  0x0F, 0xC0, 0xFE, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xE7, 0xC0, 0x01,
  0xF9, 0xF0, 0x00, 0xFC, 0x7C, 0x00, 0x3F, 0x1F, 0x00, 0x1F, 0x87, 0xC0,
  0x07, 0xE1, 0xF8, 0x03, 0xF8, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x7F, 0x07,
  0xE0, 0x1F, 0x81, 0xF8, 0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x7E, 0x01, 0xF8, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x0F, 0x83,
  0xF0, 0x03, 0xE1, 0xF8, 0x00, 0xF8, 0x7E, 0x00, 0x3E, 0x3F, 0x00, 0x0F,
  0x8F, 0xC0, 0x03, 0xE7, 0xE0, 0x00, 0xF9, 0xF8, 0x00, 0x3E, 0x7C, 0x00,
  0x0F, 0xBF, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0xFC,
  0x00, 0x7F, 0xF0, 0x01, 0xF8, 0x01, 0xFB, 0xE0, 0x07, 0xF0, 0x03, 0xF7,
  0xC0, 0x0F, 0xE0, 0x0F, 0xCF, 0x80, 0x1F, 0xC0, 0x1F, 0x9F, 0x00, 0x7F,
  0x80, 0x3F, 0x3E, 0x00, 0xFF, 0x00, 0xFC, 0x7C, 0x03, 0xFE, 0x01, 0xF8,
  0xF8, 0x07, 0xFC, 0x07, 0xE1, 0xF0, 0x1F, 0xF8, 0x0F, 0xC3, 0xE0, 0x3F,
  0xF0, 0x1F, 0x07, 0xC0, 0x7B, 0xE0, 0x7E, 0x0F, 0x81, 0xF7, 0xC0, 0xFC,
  0x1F, 0x03, 0xEF, 0x83, 0xF0, 0x3E, 0x0F, 0x9F, 0x07, 0xE0, 0x7C, 0x1F,
  0x3E, 0x0F, 0x80, 0xF8, 0x7C, 0x7C, 0x3F, 0x01, 0xF0, 0xF8, 0xF8, 0x7C,
  0x03, 0xE1, 0xF1, 0xF1, 0xF8, 0x07, 0xC7, 0xC3, 0xE3, 0xF0, 0x0F, 0x8F,
  0x87, 0xC7, 0xC0, 0x1F, 0x3E, 0x0F, 0x9F, 0x80, 0x3E, 0x7C, 0x1F, 0x3E,
  0x00, 0x7D, 0xF0, 0x3E, 0xFC, 0x00, 0xFB, 0xE0, 0x7D, 0xF0, 0x01, 0xF7,
  0xC0, 0xFB, 0xE0, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x03, 0xFF,
  0x00, 0x0F, 0xF8, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x3F,
  0xC0, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC,
  0x00, 0x7E, 0x01, 0xFC, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0x3F, 0x07, 0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x1F, 0x8F, 0xC0,
  0x00, 0x1F, 0x9F, 0xC0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x0F, 0xBF, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00,
  0x01, 0xFC, 0xFC, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x03, 0xF0, 0x7E, 0x00,
  0x07, 0xF0, 0x7E, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x0F, 0xC0, 0x3F, 0x00,
  0x1F, 0xC0, 0x3F, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x80,
  0x7F, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x3F, 0x7E,
  0x00, 0x7F, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0xFC, 0x7E, 0x01, 0xFC, 0x3E,
  0x01, 0xF8, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x07, 0xE0, 0x3F,
  0x0F, 0xC0, 0x1F, 0x0F, 0xC0, 0x1F, 0x1F, 0x80, 0x1F, 0x9F, 0x80, 0x1F,
  0xBF, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x80,
  0x7F, 0xF0, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0xF8,
  0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x00, 0xF8,
  0x3E, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x00, 0x7F, 0xE0, 0x1F, 0xFC,
  0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x1F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7E, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7D,
  0xE0, 0x00, 0xF3, 0xE0, 0x03, 0xE7, 0xC0, 0x0F, 0x87, 0x80, 0x1F, 0x0F,
  0x80, 0x7C, 0x1F, 0x00, 0xF0, 0x1E, 0x03, 0xE0, 0x3E, 0x0F, 0x80, 0x7C,
  0x1F, 0x00, 0x78, 0x7C, 0x00, 0xF8, 0xF8, 0x01, 0xF3, 0xE0, 0x01, 0xEF,
  0x80, 0x03, 0xFF, 0x00, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0x1F, 0x87, 0xC3, 0xF0, 0xF8, 0x3E, 0x0F,
  0x00, 0x7C, 0x1F, 0x01, 0xFF, 0x1F, 0x03, 0xFF, 0xBE, 0x07, 0xFF, 0xBE,
  0x0F, 0xFF, 0xFE, 0x1F, 0xE3, 0xFE, 0x1F, 0xC1, 0xFC, 0x3F, 0x80, 0xFC,
  0x3F, 0x00, 0xFC, 0x7F, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xF8,
  0x7E, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8,
  0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x07, 0xF0, 0xFC, 0x07, 0xF0,
  0xFC, 0x0F, 0xE0, 0xFE, 0x1F, 0xE0, 0xFF, 0x7F, 0xE0, 0x7F, 0xFB, 0xE0,
  0x7F, 0xF3, 0xE0, 0x3F, 0xE3, 0xC0, 0x1F, 0xC7, 0xC0, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE3, 0xF0, 0x07, 0xE7, 0xF8, 0x07, 0xDF, 0xFC,
  0x07, 0xDF, 0xFC, 0x0F, 0xFF, 0xFE, 0x0F, 0xF0, 0xFE, 0x0F, 0xE0, 0x7E,
  0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x3F, 0x1F, 0x80, 0x3E, 0x1F, 0x80, 0x7E,
  0x1F, 0x80, 0x7E, 0x1F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7E,
  0x3F, 0x00, 0x7E, 0x3F, 0x00, 0xFC, 0x3E, 0x00, 0xFC, 0x7E, 0x01, 0xFC,
  0x7E, 0x01, 0xF8, 0x7F, 0x03, 0xF8, 0x7F, 0x07, 0xF0, 0x7F, 0xCF, 0xF0,
  0xFF, 0xFF, 0xE0, 0xFB, 0xFF, 0xC0, 0xF9, 0xFF, 0x80, 0xF0, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF,
  0xC1, 0xFE, 0x0C, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x30, 0x7F, 0xBF, 0x07, 0xFF, 0xF0,
  0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x07, 0xC3, 0xF0, 0x07, 0xFC, 0xF8, 0x03,
  0xFF, 0xBE, 0x01, 0xFF, 0xEF, 0x80, 0xFF, 0xFF, 0xE0, 0x7F, 0x07, 0xF8,
  0x1F, 0x81, 0xFC, 0x0F, 0xE0, 0x3F, 0x03, 0xF0, 0x0F, 0xC1, 0xFC, 0x03,
  0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x3E, 0x0F, 0xE0, 0x1F, 0x83, 0xF0,
  0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x7C, 0x0F, 0xC0, 0x3F, 0x03,
  0xF0, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x3F, 0x01, 0xFC, 0x0F, 0xC0, 0xFE,
  0x03, 0xF0, 0x7F, 0x80, 0xFF, 0x3F, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF,
  0xBE, 0x00, 0xFF, 0xCF, 0x00, 0x1F, 0xC3, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x0F, 0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0x3F, 0x8F, 0xE0,
  0xFC, 0x7E, 0x07, 0xE7, 0xE0, 0x3F, 0x3F, 0x01, 0xFB, 0xF0, 0x1F, 0x9F,
  0x81, 0xFC, 0xF8, 0x7F, 0xCF, 0xFF, 0xFC, 0x7F, 0xFF, 0xC3, 0xFF, 0xF8,
  0x1F, 0xFC, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x41, 0xFC, 0x0E, 0x0F, 0xFF, 0xF0,
  0x3F, 0xFF, 0x80, 0xFF, 0xFC, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xF9,
  0x80, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x02, 0x3F, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x07, 0xC0, 0x1F, 0xF1, 0xF0, 0x0F, 0xFE, 0xF8, 0x07, 0xFF,
  0xBE, 0x03, 0xFF, 0xFF, 0x81, 0xFE, 0x1F, 0xE0, 0x7E, 0x07, 0xF0, 0x3F,
  0x80, 0xFC, 0x0F, 0xC0, 0x3F, 0x07, 0xF0, 0x0F, 0xC1, 0xF8, 0x03, 0xF0,
  0x7E, 0x00, 0xF8, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x07,
  0xE0, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0x03, 0xF0,
  0x1F, 0xC0, 0xFC, 0x07, 0xF0, 0x3F, 0x03, 0xF8, 0x0F, 0xE1, 0xFE, 0x03,
  0xFD, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFD, 0xF8, 0x03, 0xFE, 0x7C,
  0x00, 0x7F, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x80, 0x0F, 0xC0, 0x3C,
  0x0F, 0xF0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x8F, 0xC0, 0x3F, 0x3F, 0xC0, 0x7D, 0xFF, 0xC0, 0xFB, 0xFF, 0xC3,
  0xFF, 0xFF, 0x87, 0xFC, 0x3F, 0x0F, 0xF0, 0x7E, 0x1F, 0xC0, 0xFC, 0x3F,
  0x01, 0xF8, 0xFE, 0x03, 0xF1, 0xF8, 0x07, 0xE3, 0xF0, 0x0F, 0xC7, 0xE0,
  0x1F, 0x1F, 0x80, 0x7E, 0x3F, 0x00, 0xFC, 0x7E, 0x01, 0xF8, 0xFC, 0x03,
  0xF1, 0xF0, 0x07, 0xC7, 0xE0, 0x1F, 0x8F, 0xC0, 0x3F, 0x1F, 0x80, 0x7E,
  0x3F, 0x00, 0xFC, 0x7C, 0x03, 0xF1, 0xF8, 0x07, 0xE3, 0xF0, 0x0F, 0xC7,
  0xE0, 0x1F, 0x8F, 0x80, 0x3E, 0x00, 0x00, 0x70, 0x0F, 0xC0, 0x7E, 0x07,
  0xF0, 0x3F, 0x80, 0xF8, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3E, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x09, 0xFE, 0x00, 0xFF, 0xC0, 0x0F,
  0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0xFC, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x3E, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x1F, 0x87, 0xF0,
  0x0F, 0xC7, 0xF0, 0x07, 0xC7, 0xF0, 0x03, 0xE7, 0xF0, 0x03, 0xF3, 0xF0,
  0x01, 0xFB, 0xF0, 0x00, 0xFB, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFC,
  0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xEF, 0xC0, 0x07, 0xE3,
  0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0xF8,
  0x1F, 0x80, 0x7C, 0x0F, 0xE0, 0x7E, 0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x1F,
  0x80, 0xFE, 0x0F, 0x80, 0x3F, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x07, 0xC3, 0xF0, 0x0F, 0x80,
  0x7C, 0xFF, 0x83, 0xFE, 0x07, 0xDF, 0xFC, 0x7F, 0xE0, 0x7B, 0xFF, 0xCF,
  0xFF, 0x0F, 0xBF, 0xFF, 0xFF, 0xF0, 0xFF, 0x8F, 0xFC, 0x3F, 0x0F, 0xE0,
  0x7F, 0x83, 0xF0, 0xFE, 0x07, 0xF0, 0x3F, 0x1F, 0xC0, 0x7F, 0x03, 0xF1,
  0xFC, 0x07, 0xE0, 0x3F, 0x1F, 0x80, 0x7E, 0x03, 0xF1, 0xF8, 0x0F, 0xC0,
  0x3F, 0x1F, 0x80, 0xFC, 0x03, 0xE3, 0xF0, 0x0F, 0xC0, 0x7E, 0x3F, 0x00,
  0xFC, 0x07, 0xE3, 0xF0, 0x0F, 0x80, 0x7E, 0x3F, 0x01, 0xF8, 0x07, 0xE3,
  0xE0, 0x1F, 0x80, 0x7C, 0x7E, 0x01, 0xF8, 0x0F, 0xC7, 0xE0, 0x1F, 0x00,
  0xFC, 0x7E, 0x01, 0xF0, 0x0F, 0xC7, 0xE0, 0x3F, 0x00, 0xFC, 0x7C, 0x03,
  0xF0, 0x0F, 0x8F, 0xC0, 0x3F, 0x01, 0xF8, 0xFC, 0x03, 0xE0, 0x1F, 0x8F,
  0xC0, 0x7E, 0x01, 0xF8, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x07, 0xC3, 0xF0,
  0x0F, 0x8F, 0xF8, 0x1F, 0x7F, 0xF0, 0x3D, 0xFF, 0xF0, 0xFB, 0xFF, 0xE1,
  0xFF, 0x0F, 0xC3, 0xFC, 0x1F, 0x87, 0xF0, 0x3F, 0x1F, 0xC0, 0x7E, 0x3F,
  0x80, 0xFC, 0x7E, 0x01, 0xF8, 0xFC, 0x03, 0xF1, 0xF8, 0x07, 0xC7, 0xE0,
  0x1F, 0x8F, 0xC0, 0x3F, 0x1F, 0x80, 0x7E, 0x3F, 0x00, 0xFC, 0x7C, 0x01,
  0xF1, 0xF8, 0x07, 0xE3, 0xF0, 0x0F, 0xC7, 0xE0, 0x1F, 0x8F, 0xC0, 0x3F,
  0x3F, 0x00, 0xFC, 0x7E, 0x01, 0xF8, 0xFC, 0x03, 0xF1, 0xF8, 0x07, 0xE3,
  0xF0, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFE, 0x01,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x7F, 0x07, 0xE1, 0xF8, 0x1F, 0x8F, 0xC0,
  0x3F, 0x3F, 0x00, 0xFD, 0xF8, 0x03, 0xF7, 0xE0, 0x0F, 0xDF, 0x80, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xBF, 0x00, 0x7E, 0xFC,
  0x01, 0xFB, 0xF0, 0x07, 0xEF, 0xC0, 0x3F, 0x3F, 0x00, 0xFC, 0xFC, 0x07,
  0xE3, 0xF8, 0x3F, 0x87, 0xFB, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xF8, 0x7E, 0x00, 0x1F, 0x3F,
  0xE0, 0x03, 0xEF, 0xFE, 0x00, 0x7B, 0xFF, 0xE0, 0x1F, 0x7F, 0xFC, 0x03,
  0xFC, 0x1F, 0x80, 0x7F, 0x03, 0xF0, 0x0F, 0xE0, 0x7E, 0x03, 0xF8, 0x07,
  0xE0, 0x7E, 0x00, 0xF8, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x3E,
  0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x81, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0x7E,
  0x07, 0xE0, 0x1F, 0x80, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0xFE, 0x07, 0xE0,
  0x1F, 0x80, 0xFE, 0x07, 0xF0, 0x1F, 0xC1, 0xFC, 0x03, 0xFE, 0x7F, 0x80,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x03, 0xF7, 0xFE, 0x00, 0x7C, 0x7F,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x1F, 0x01, 0xFF, 0x1E,
  0x03, 0xFF, 0xBE, 0x07, 0xFF, 0xBE, 0x0F, 0xFF, 0xFE, 0x1F, 0xC1, 0xFE,
  0x1F, 0x81, 0xFC, 0x3F, 0x80, 0xFC, 0x3F, 0x00, 0xFC, 0x7F, 0x00, 0xFC,
  0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8,
  0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF0,
  0xFC, 0x03, 0xF0, 0xFC, 0x07, 0xF0, 0xFC, 0x0F, 0xE0, 0xFC, 0x1F, 0xE0,
  0xFF, 0x3F, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xF7, 0xE0, 0x3F, 0xE7, 0xC0,
  0x1F, 0xCF, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x07, 0xC3, 0xE0, 0xF9, 0xFC, 0x1F, 0x7F, 0x83, 0xEF,
  0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xE0,
  0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x3F,
  0xFE, 0x07, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE1, 0xFC, 0x0C, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x8C, 0x03, 0xF8, 0xF8, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF,
  0xC0, 0x7F, 0xF8, 0x00, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x07, 0xE0, 0x07, 0xFF, 0x3F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFE, 0xFF, 0xFE,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0x20,
  0xFF, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0x3F, 0xE0, 0x0F, 0xC0, 0x3F, 0x0F,
  0xC0, 0x3E, 0x0F, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x1F,
  0x80, 0x7E, 0x1F, 0x80, 0x7C, 0x1F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3F,
  0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3E, 0x00, 0xF8, 0x7E, 0x01, 0xF8, 0x7E,
  0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x7E, 0x01, 0xF0, 0x7C, 0x03, 0xF0, 0xFC,
  0x03, 0xF0, 0xFC, 0x07, 0xF0, 0xFC, 0x07, 0xF0, 0xFC, 0x0F, 0xE0, 0xFC,
  0x1F, 0xE0, 0xFF, 0x7F, 0xE0, 0xFF, 0xFB, 0xE0, 0x7F, 0xF3, 0xE0, 0x7F,
  0xE3, 0xC0, 0x3F, 0xC3, 0xC0, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xEF, 0x80,
  0x1F, 0xBE, 0x00, 0xFC, 0xF8, 0x03, 0xF3, 0xF0, 0x1F, 0x8F, 0xC0, 0x7E,
  0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x1F,
  0x0F, 0xC0, 0x7C, 0x3F, 0x01, 0xF1, 0xF8, 0x07, 0xC7, 0xE0, 0x1F, 0x3F,
  0x00, 0x7C, 0xFC, 0x01, 0xF3, 0xE0, 0x07, 0xDF, 0x80, 0x1F, 0x7C, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xF8, 0x07, 0xF0, 0x0F,
  0xFE, 0x01, 0xFC, 0x07, 0xEF, 0x80, 0x7F, 0x01, 0xFB, 0xE0, 0x3F, 0xC0,
  0xFC, 0xF8, 0x0F, 0xF0, 0x3F, 0x3E, 0x07, 0xFC, 0x0F, 0x8F, 0x81, 0xFF,
  0x07, 0xE3, 0xE0, 0xFF, 0xC1, 0xF0, 0xF8, 0x3F, 0xF0, 0xFC, 0x3E, 0x0F,
  0x7C, 0x3F, 0x0F, 0x87, 0xDF, 0x1F, 0x83, 0xE1, 0xE7, 0xC7, 0xE0, 0xF8,
  0xF9, 0xF1, 0xF0, 0x3E, 0x3E, 0x7C, 0xFC, 0x0F, 0x9F, 0x1F, 0x3E, 0x03,
  0xE7, 0xC7, 0xDF, 0x80, 0xF9, 0xE1, 0xF7, 0xC0, 0x3E, 0xF8, 0x7D, 0xF0,
  0x0F, 0xBC, 0x1F, 0xFC, 0x03, 0xEF, 0x07, 0xFE, 0x00, 0xFF, 0xC1, 0xFF,
  0x80, 0x3F, 0xE0, 0x7F, 0xC0, 0x0F, 0xF8, 0x1F, 0xF0, 0x03, 0xFC, 0x07,
  0xF8, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x07, 0xE0,
  0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x0F, 0xE0, 0x7E, 0x03, 0xF8, 0x0F, 0xC0,
  0x7E, 0x00, 0xFC, 0x1F, 0xC0, 0x1F, 0x87, 0xF0, 0x03, 0xF0, 0xFC, 0x00,
  0x3F, 0x3F, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0xFD, 0xF8, 0x00, 0x0F, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xDF, 0x80, 0x03, 0xFB, 0xF0, 0x00, 0x7E,
  0x3E, 0x00, 0x1F, 0x87, 0xE0, 0x07, 0xE0, 0xFC, 0x01, 0xFC, 0x1F, 0x80,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x01,
  0xF0, 0x01, 0xF8, 0x0F, 0x80, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x07, 0xE0, 0x07, 0xE0, 0x3F,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0xF8, 0x1F, 0x80, 0x07, 0xC1, 0xF8, 0x00,
  0x3E, 0x0F, 0xC0, 0x01, 0xF0, 0xFC, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x7C,
  0x3E, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0xF9, 0xF8,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFC,
  0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xFF, 0xF8,
  0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x3F,
  0xE0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x07,
  0xFE, 0x00, 0x7F, 0x80, 0x07, 0xE0, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x70, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x78, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x3E, 0x00, 0x3F, 0xE0, 0x07, 0xFE,
  0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x7F,
  0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x02, 0x7F, 0xE0, 0x0D, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xB0, 0x03, 0xFE, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_SemiBoldItalic49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 13, 36, 13, 1, -35 },
  { 60, 16, 13, 20, 5, -35 },
  { 86, 28, 35, 28, 1, -35 },
  { 209, 24, 40, 25, 1, -37 },
  { 329, 33, 35, 38, 3, -35 },
  { 474, 29, 35, 30, 1, -35 },
  { 601, 8, 13, 12, 5, -35 },
  { 614, 17, 43, 15, 1, -35 },
  { 706, 17, 43, 15, -4, -35 },
  { 798, 21, 21, 24, 4, -37 },
  { 854, 22, 23, 26, 3, -29 },
  { 918, 10, 12, 13, -2, -6 },
  { 933, 13, 5, 15, 1, -16 },
  { 942, 8, 8, 13, 0, -7 },
  { 950, 25, 35, 19, -2, -35 },
  { 1060, 22, 36, 25, 2, -36 },
  { 1159, 17, 35, 25, 5, -35 },
  { 1234, 25, 35, 25, -1, -35 },
  { 1344, 24, 35, 25, 0, -35 },
  { 1449, 24, 35, 25, 0, -35 },
  { 1554, 24, 35, 25, 1, -35 },
  { 1659, 23, 36, 25, 2, -36 },
  { 1763, 24, 35, 25, 2, -35 },
  { 1868, 24, 36, 25, 1, -36 },
  { 1976, 23, 36, 25, 1, -36 },
  { 2080, 12, 28, 13, 0, -27 },
  { 2122, 15, 33, 13, -3, -27 },
  { 2184, 22, 24, 26, 3, -30 },
  { 2250, 21, 14, 26, 3, -24 },
  { 2287, 22, 24, 26, 3, -30 },
  { 2353, 18, 36, 20, 3, -35 },
  { 2434, 35, 39, 38, 2, -35 },
  { 2605, 27, 35, 27, -3, -35 },
  { 2724, 26, 35, 27, 1, -35 },
  { 2838, 26, 35, 26, 3, -35 },
  { 2952, 28, 35, 30, 1, -35 },
  { 3075, 24, 35, 23, 1, -35 },
  { 3180, 24, 35, 22, 1, -35 },
  { 3285, 28, 35, 30, 3, -35 },
  { 3408, 30, 35, 31, 1, -35 },
  { 3540, 22, 35, 17, -2, -35 },
  { 3637, 23, 45, 14, -8, -35 },
  { 3767, 30, 35, 26, 1, -35 },
  { 3899, 18, 35, 22, 1, -35 },
  { 3978, 39, 35, 39, 1, -35 },
  { 4149, 32, 35, 33, 1, -35 },
  { 4289, 28, 36, 32, 3, -36 },
  { 4415, 26, 35, 26, 1, -35 },
  { 4529, 28, 44, 32, 3, -36 },
  { 4683, 25, 35, 27, 1, -35 },
  { 4793, 25, 35, 23, 0, -35 },
  { 4903, 23, 35, 23, 4, -35 },
  { 5004, 28, 35, 30, 3, -35 },
  { 5127, 26, 35, 26, 4, -35 },
  { 5241, 39, 35, 40, 5, -35 },
  { 5412, 32, 35, 25, -3, -35 },
  { 5552, 24, 35, 24, 4, -35 },
  { 5657, 27, 35, 23, -1, -35 },
  { 5776, 19, 43, 15, -1, -35 },
  { 5879, 10, 35, 19, 5, -35 },
  { 5923, 19, 43, 15, -3, -35 },
  { 6026, 23, 22, 25, 1, -35 },
  { 6090, 18, 4, 18, -4, 4 },
  { 6099, 9, 8, 15, 7, -38 },
  { 6108, 24, 27, 26, 2, -27 },
  { 6189, 24, 37, 26, 1, -37 },
  { 6300, 20, 27, 21, 2, -27 },
  { 6368, 26, 37, 26, 2, -37 },
  { 6489, 21, 27, 24, 2, -27 },
  { 6560, 26, 49, 16, -5, -37 },
  { 6720, 26, 39, 26, 0, -27 },
  { 6847, 23, 37, 26, 1, -37 },
  { 6954, 13, 37, 13, 1, -37 },
  { 7015, 20, 49, 13, -6, -37 },
  { 7138, 25, 37, 24, 1, -37 },
  { 7254, 13, 37, 13, 1, -37 },
  { 7315, 36, 27, 39, 1, -27 },
  { 7437, 23, 27, 26, 1, -27 },
  { 7515, 22, 27, 26, 2, -27 },
  { 7590, 27, 39, 26, -2, -27 },
  { 7722, 24, 39, 26, 2, -27 },
  { 7839, 19, 27, 18, 1, -27 },
  { 7904, 20, 27, 20, 0, -27 },
  { 7972, 16, 32, 17, 2, -32 },
  { 8036, 24, 27, 26, 2, -27 },
  { 8117, 22, 27, 22, 3, -27 },
  { 8192, 34, 27, 34, 3, -27 },
  { 8307, 27, 27, 23, -2, -27 },
  { 8399, 29, 39, 22, -4, -27 },
  { 8541, 22, 27, 20, -1, -27 },
  { 8616, 20, 43, 17, 0, -35 },
  { 8724, 4, 48, 24, 10, -37 },
  { 8748, 20, 43, 17, -3, -35 },
  { 8856, 23, 7, 26, 2, -21 },
};

const GFXfont NotoSans_SemiCondensed_SemiBoldItalic49pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_SemiBoldItalic49pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_SemiBoldItalic49pt7bGlyphs,
  0x20, 0x7E, 67
};

#endif // _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC49PT7B_H_
