#ifndef _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC11PT7B_H_
#define _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC11PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-SemiBoldItalic.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_SemiBoldItalic11pt7bBitmaps[] PROGMEM = {
  0x00, 0x2D, 0xA4, 0x96, 0xFA, 0xA0, 0x14, 0x29, 0xF9, 0x42, 0x9F, 0x94,
  0x28, 0x15, 0xE5, 0x18, 0x18, 0xAF, 0x88, 0x20, 0x67, 0x4A, 0xA5, 0xBD,
  0xA5, 0x52, 0xE6, 0x38, 0x50, 0xA1, 0x87, 0x7B, 0xB2, 0x3E, 0xE8, 0x12,
  0x64, 0x4C, 0xCC, 0x44, 0x21, 0x11, 0x13, 0x22, 0x4C, 0x27, 0xDB, 0xE0,
  0x21, 0x09, 0xF2, 0x10, 0x78, 0xFC, 0x70, 0x04, 0x20, 0x84, 0x30, 0x86,
  0x30, 0x3B, 0x52, 0x9C, 0xE7, 0x6E, 0x37, 0xA2, 0x26, 0x64, 0x3A, 0x42,
  0x31, 0x13, 0x1F, 0x3A, 0x42, 0x73, 0x86, 0x7E, 0x08, 0xCA, 0xF5, 0xFC,
  0x46, 0x3C, 0x86, 0x1C, 0x18, 0x29, 0xBC, 0x1C, 0x84, 0x1E, 0x4B, 0x25,
  0x9C, 0x7C, 0x30, 0x84, 0x30, 0x86, 0x30, 0x39, 0xB6, 0x8E, 0x7B, 0x2C,
  0x9C, 0x3B, 0x52, 0x97, 0x8C, 0x5C, 0x68, 0x05, 0x80, 0x32, 0x00, 0x06,
  0xC0, 0x09, 0xB1, 0x83, 0x04, 0xF0, 0xF0, 0x86, 0x0C, 0x7C, 0x40, 0xEB,
  0x36, 0xC8, 0x88, 0x1E, 0x21, 0x4D, 0x55, 0xA5, 0xA5, 0x5E, 0x40, 0x3C,
  0x0C, 0x31, 0x45, 0x24, 0xF4, 0x71, 0x38, 0x96, 0x5E, 0x49, 0x34, 0xBC,
  0x3B, 0x71, 0x08, 0x42, 0x1E, 0x38, 0xB6, 0x59, 0x45, 0x34, 0xBC, 0x3C,
  0x86, 0x1E, 0x41, 0x04, 0x3C, 0x3C, 0x86, 0x18, 0x79, 0x04, 0x30, 0x3D,
  0x9C, 0x20, 0x9A, 0x29, 0xBE, 0x22, 0x4D, 0x9B, 0xE4, 0x48, 0x93, 0x64,
  0x72, 0x26, 0x64, 0x4E, 0x08, 0x46, 0x31, 0x08, 0x46, 0x27, 0x00, 0x26,
  0x59, 0xE2, 0x87, 0x0A, 0x16, 0x64, 0x22, 0x64, 0x44, 0x4F, 0x31, 0x99,
  0xDC, 0xCA, 0xA5, 0x52, 0xC9, 0x6D, 0xA4, 0x22, 0x65, 0xCA, 0x95, 0xE9,
  0x93, 0x66, 0x39, 0x3C, 0x61, 0x8E, 0x29, 0xBC, 0x38, 0xB6, 0x53, 0x79,
  0x04, 0x30, 0x39, 0x3C, 0x61, 0x8E, 0x29, 0xBC, 0x30, 0x60, 0x38, 0xB6,
  0x53, 0x71, 0x45, 0xB2, 0x3D, 0xA4, 0x18, 0x30, 0x69, 0x3C, 0xF9, 0x18,
  0xC4, 0x21, 0x18, 0x45, 0x3C, 0xA2, 0x8A, 0x69, 0xBC, 0x8E, 0x29, 0xA4,
  0xB3, 0x8A, 0x30, 0x89, 0xCC, 0xA6, 0x57, 0x4A, 0xA5, 0x73, 0x31, 0x98,
  0x33, 0x16, 0x14, 0x18, 0x18, 0x38, 0x6C, 0xCC, 0x8E, 0xF4, 0xC6, 0x21,
  0x18, 0x7C, 0x21, 0x8C, 0x21, 0x0C, 0x3C, 0x32, 0x44, 0x44, 0xC8, 0x8C,
  0xAD, 0x55, 0x38, 0x84, 0x21, 0x10, 0x84, 0x27, 0x00, 0x11, 0x8A, 0x9C,
  0x80, 0xF0, 0xC0, 0x35, 0xA4, 0xB2, 0xD9, 0xE0, 0x20, 0x87, 0x9B, 0x49,
  0x2D, 0xAC, 0x3A, 0x11, 0x8C, 0x38, 0x04, 0x13, 0xD2, 0x4B, 0x2D, 0x9E,
  0x3A, 0x57, 0xCC, 0x38, 0x1C, 0x43, 0x8C, 0x20, 0x82, 0x18, 0x63, 0x08,
  0x00, 0x35, 0x24, 0xB2, 0xD9, 0xE1, 0x2C, 0x60, 0x21, 0x1E, 0xD4, 0xA7,
  0x3B, 0x21, 0xA4, 0xB6, 0x10, 0x32, 0x22, 0x66, 0x4C, 0x80, 0x20, 0x86,
  0xD6, 0x71, 0xCD, 0x36, 0x25, 0xA4, 0xB6, 0x5B, 0x6D, 0x49, 0x49, 0xD9,
  0xDB, 0x5B, 0x52, 0x9C, 0xEC, 0x3A, 0x53, 0x9D, 0xB8, 0x59, 0xB4, 0x92,
  0xDA, 0xC8, 0x20, 0x80, 0x35, 0x24, 0xB2, 0xD9, 0xE1, 0x04, 0x10, 0x5B,
  0x10, 0x8C, 0x60, 0x7A, 0x18, 0x61, 0x70, 0x5E, 0x49, 0x30, 0x6D, 0x24,
  0x92, 0xD9, 0xE0, 0x9D, 0xA9, 0x4C, 0x60, 0xB3, 0x6E, 0xD6, 0xED, 0x93,
  0x00, 0x26, 0x70, 0x61, 0xC2, 0x99, 0x00, 0x26, 0x48, 0xA1, 0x43, 0x06,
  0x08, 0x70, 0xC0, 0x78, 0x88, 0xCC, 0x78, 0x12, 0x22, 0xC4, 0x44, 0x46,
  0xFF, 0xE0, 0x30, 0x84, 0x21, 0x9C, 0x84, 0x66, 0x00, 0xCD, 0x80,
};

const GFXglyph NotoSans_SemiCondensed_SemiBoldItalic11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 3, 8, 3, 0, -8 },
  { 4, 4, 3, 5, 1, -8 },
  { 6, 7, 8, 6, 0, -8 },
  { 13, 6, 9, 6, 0, -8 },
  { 20, 7, 8, 9, 1, -8 },
  { 27, 7, 8, 7, 0, -8 },
  { 34, 2, 3, 3, 1, -8 },
  { 35, 4, 10, 3, 0, -8 },
  { 40, 4, 10, 3, -1, -8 },
  { 45, 5, 4, 5, 1, -8 },
  { 48, 5, 6, 6, 1, -7 },
  { 52, 3, 2, 3, -1, -1 },
  { 53, 3, 2, 3, 0, -4 },
  { 54, 2, 2, 3, 0, -2 },
  { 55, 6, 8, 4, -1, -8 },
  { 61, 5, 8, 6, 0, -8 },
  { 66, 4, 8, 6, 1, -8 },
  { 70, 5, 8, 6, 0, -8 },
  { 75, 5, 8, 6, 0, -8 },
  { 80, 5, 8, 6, 0, -8 },
  { 85, 6, 8, 6, 0, -8 },
  { 91, 6, 8, 6, 0, -8 },
  { 97, 6, 8, 6, 0, -8 },
  { 103, 6, 8, 6, 0, -8 },
  { 109, 5, 8, 6, 0, -8 },
  { 114, 3, 6, 3, 0, -6 },
  { 117, 4, 7, 3, -1, -6 },
  { 121, 5, 6, 6, 1, -7 },
  { 125, 4, 3, 6, 1, -5 },
  { 127, 5, 6, 6, 1, -7 },
  { 131, 4, 8, 4, 1, -8 },
  { 135, 8, 9, 8, 0, -8 },
  { 144, 6, 8, 6, -1, -8 },
  { 150, 6, 8, 6, 0, -8 },
  { 156, 5, 8, 6, 1, -8 },
  { 161, 6, 8, 7, 0, -8 },
  { 167, 6, 8, 5, 0, -8 },
  { 173, 6, 8, 5, 0, -8 },
  { 179, 6, 8, 7, 1, -8 },
  { 185, 7, 8, 7, 0, -8 },
  { 192, 4, 8, 4, 0, -8 },
  { 196, 5, 10, 3, -2, -8 },
  { 203, 7, 8, 6, 0, -8 },
  { 210, 4, 8, 5, 0, -8 },
  { 214, 9, 8, 9, 0, -8 },
  { 223, 7, 8, 7, 0, -8 },
  { 230, 6, 8, 7, 1, -8 },
  { 236, 6, 8, 6, 0, -8 },
  { 242, 6, 10, 7, 1, -8 },
  { 250, 6, 8, 6, 0, -8 },
  { 256, 6, 8, 5, 0, -8 },
  { 262, 5, 8, 5, 1, -8 },
  { 267, 6, 8, 7, 1, -8 },
  { 273, 6, 8, 6, 1, -8 },
  { 279, 9, 8, 9, 1, -8 },
  { 288, 8, 8, 6, -1, -8 },
  { 296, 5, 8, 5, 1, -8 },
  { 301, 6, 8, 5, 0, -8 },
  { 307, 4, 10, 3, 0, -8 },
  { 312, 2, 8, 4, 1, -8 },
  { 314, 5, 10, 3, -1, -8 },
  { 321, 5, 5, 6, 0, -8 },
  { 325, 4, 1, 4, -1, 1 },
  { 326, 2, 1, 3, 2, -8 },
  { 327, 6, 6, 6, 0, -6 },
  { 332, 6, 8, 6, 0, -8 },
  { 338, 5, 6, 5, 0, -6 },
  { 342, 6, 8, 6, 0, -8 },
  { 348, 5, 6, 5, 0, -6 },
  { 352, 6, 11, 4, -1, -8 },
  { 361, 6, 9, 6, 0, -6 },
  { 368, 5, 8, 6, 0, -8 },
  { 373, 3, 8, 3, 0, -8 },
  { 376, 4, 11, 3, -1, -8 },
  { 382, 6, 8, 5, 0, -8 },
  { 388, 3, 8, 3, 0, -8 },
  { 391, 8, 6, 9, 0, -6 },
  { 397, 5, 6, 6, 0, -6 },
  { 401, 5, 6, 6, 0, -6 },
  { 405, 6, 9, 6, 0, -6 },
  { 412, 6, 9, 6, 0, -6 },
  { 419, 5, 6, 4, 0, -6 },
  { 423, 5, 6, 5, 0, -6 },
  { 427, 3, 7, 4, 1, -7 },
  { 430, 6, 6, 6, 0, -6 },
  { 435, 5, 6, 5, 1, -6 },
  { 439, 7, 6, 8, 1, -6 },
  { 445, 7, 6, 5, -1, -6 },
  { 451, 7, 9, 5, -1, -6 },
  { 459, 5, 6, 4, 0, -6 },
  { 463, 4, 10, 4, 0, -8 },
  { 468, 1, 11, 5, 2, -8 },
  { 470, 5, 10, 4, -1, -8 },
  { 477, 5, 2, 6, 1, -5 },
};

const GFXfont NotoSans_SemiCondensed_SemiBoldItalic11pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_SemiBoldItalic11pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_SemiBoldItalic11pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC11PT7B_H_
