#ifndef _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC37PT7B_H_
#define _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC37PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-SemiBoldItalic.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_SemiBoldItalic37pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xE0, 0x3C, 0x07, 0x81, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x70, 0x1F, 0x07, 0xE0, 0xFC, 0x0F,
  0x00, 0x78, 0xF7, 0x9F, 0x79, 0xEF, 0x1E, 0xF1, 0xEF, 0x1C, 0xE1, 0xCE,
  0x1C, 0xE3, 0xC0, 0x00, 0x70, 0xE0, 0x07, 0x8F, 0x00, 0x38, 0x70, 0x01,
  0xC3, 0x80, 0x1E, 0x1C, 0x00, 0xE1, 0xC0, 0x07, 0x0E, 0x07, 0xFF, 0xFF,
  0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xC0, 0xE1, 0xC0, 0x0F, 0x1E, 0x00, 0x70,
  0xE0, 0x03, 0x87, 0x00, 0x1C, 0x38, 0x1F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFE, 0x07, 0x8F, 0x00, 0x38, 0x70, 0x01, 0xC3, 0x80, 0x1E, 0x3C,
  0x00, 0xE1, 0xC0, 0x07, 0x0E, 0x00, 0x38, 0x70, 0x03, 0xC7, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x07, 0xFC, 0x07, 0xFF, 0xC3,
  0xFF, 0xE1, 0xFF, 0xF0, 0x7D, 0xC4, 0x1E, 0x60, 0x07, 0x98, 0x01, 0xE6,
  0x00, 0x7D, 0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x00, 0xFE, 0x00, 0x6F, 0x80, 0x19, 0xE0, 0x06, 0x78, 0x01, 0x9E, 0x20,
  0xE7, 0x8F, 0x37, 0xE3, 0xFF, 0xF0, 0xFF, 0xF8, 0x1F, 0xF8, 0x00, 0x70,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07,
  0xE0, 0x0F, 0x07, 0xF8, 0x0F, 0x07, 0x9C, 0x07, 0x03, 0x8F, 0x07, 0x83,
  0xC7, 0x87, 0x81, 0xC3, 0xC3, 0x80, 0xE1, 0xC3, 0xC0, 0xF0, 0xE3, 0xC0,
  0x78, 0x71, 0xC0, 0x3C, 0x79, 0xE0, 0x1E, 0x39, 0xE7, 0xEF, 0x3C, 0xE7,
  0xF7, 0xBE, 0xF7, 0xFD, 0xFE, 0xF3, 0x8E, 0xFE, 0x73, 0xC7, 0x1C, 0x79,
  0xC3, 0x80, 0x79, 0xE1, 0xC0, 0x38, 0xF0, 0xE0, 0x3C, 0x78, 0xF0, 0x3C,
  0x38, 0x78, 0x1C, 0x1C, 0x38, 0x1E, 0x0E, 0x3C, 0x1E, 0x07, 0x9E, 0x0E,
  0x03, 0xFE, 0x0F, 0x00, 0xFE, 0x0F, 0x00, 0x7E, 0x00, 0x00, 0x3C, 0x00,
  0x0F, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x7C, 0x78, 0x03, 0xC3,
  0xC0, 0x1E, 0x1E, 0x00, 0xF0, 0xF0, 0x07, 0x8F, 0x00, 0x3C, 0xF8, 0x01,
  0xFF, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xC1,
  0xE7, 0xDF, 0x1F, 0x7C, 0xF8, 0xF7, 0xC3, 0xEF, 0xBE, 0x1F, 0xF9, 0xE0,
  0x7F, 0x8F, 0x01, 0xFC, 0x78, 0x0F, 0xC3, 0xE0, 0xFE, 0x1F, 0xDF, 0xF0,
  0xFF, 0xFF, 0xC3, 0xFF, 0x9F, 0x0F, 0xF8, 0xFC, 0x7B, 0xDE, 0xEF, 0x7B,
  0xDC, 0xE0, 0x00, 0xF8, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x78, 0x07, 0xC0,
  0x3C, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x3C,
  0x01, 0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x61, 0xE0, 0x71, 0xC0, 0x7D, 0xC0,
  0xFF, 0xFF, 0x1F, 0xFF, 0x03, 0xFF, 0x0F, 0xC1, 0x1E, 0xE0, 0x3E, 0xE0,
  0x7C, 0xF0, 0x38, 0x78, 0x18, 0x78, 0x00, 0x60, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x1F,
  0x1F, 0x1E, 0x3E, 0x3C, 0x3C, 0x78, 0x70, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x39, 0xFF, 0xFF, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xF0, 0xF8, 0xF8, 0x78, 0x3C, 0x7C,
  0x1E, 0x3C, 0x0F, 0x3E, 0x07, 0x9E, 0x03, 0xDF, 0x01, 0xEF, 0x80, 0xF7,
  0xC0, 0xFB, 0xC0, 0x7D, 0xE0, 0x3F, 0xF0, 0x1E, 0xF8, 0x0F, 0x7C, 0x0F,
  0xBE, 0x07, 0xDF, 0x03, 0xCF, 0x83, 0xE7, 0xC1, 0xE1, 0xE1, 0xF0, 0xFF,
  0xF0, 0x7F, 0xF0, 0x1F, 0xF0, 0x07, 0xF0, 0x00, 0x01, 0xF0, 0x3F, 0x0F,
  0xF1, 0xFF, 0x3F, 0xEF, 0xDE, 0xF9, 0xE7, 0x3E, 0x23, 0xC0, 0x3C, 0x03,
  0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF8, 0x0F,
  0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x1F, 0xF0, 0x0F, 0xFF, 0x03, 0xFF, 0xF0, 0x7C, 0x7E, 0x06,
  0x07, 0xC0, 0x80, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xFF, 0xF8, 0x7F, 0xFF, 0x1F, 0xFF,
  0xE3, 0xFF, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F,
  0xFF, 0x07, 0x07, 0xC0, 0x81, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07,
  0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0xFC, 0x00,
  0x7F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC8, 0x03, 0xE3, 0xE7, 0xF8, 0xFF, 0xFC,
  0x3F, 0xFE, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x01, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x0F, 0x78, 0x03, 0xBE, 0x01,
  0xEF, 0x00, 0xF3, 0xC0, 0x78, 0xF0, 0x3C, 0x3C, 0x0F, 0x1F, 0x07, 0x87,
  0x83, 0xC1, 0xE1, 0xE0, 0x78, 0x78, 0x3E, 0x3F, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFE, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x3E, 0x00, 0x03, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFF, 0x03,
  0xFF, 0xE0, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE4, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x10,
  0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF1, 0x80, 0x7C, 0x3F, 0x7F, 0x87, 0xFF,
  0xE0, 0xFF, 0xF8, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x7F, 0xC0, 0xFF,
  0xE0, 0xFF, 0xE0, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3C,
  0x00, 0x3E, 0x00, 0x1E, 0x3C, 0x0F, 0x7F, 0x8F, 0xFF, 0xC7, 0xFF, 0xF3,
  0xF0, 0xF9, 0xF0, 0x3C, 0xF0, 0x1E, 0x78, 0x0F, 0x3C, 0x07, 0x9E, 0x07,
  0xCF, 0x03, 0xE7, 0x81, 0xE3, 0xC1, 0xF1, 0xFB, 0xF0, 0x7F, 0xF8, 0x3F,
  0xF0, 0x07, 0xF0, 0x00, 0x3F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xF8, 0xFF,
  0xFE, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00,
  0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFE,
  0x0F, 0x07, 0xC7, 0xC1, 0xF1, 0xF0, 0x7C, 0x7C, 0x1F, 0x1F, 0x07, 0x83,
  0xC3, 0xE0, 0xF9, 0xF0, 0x1F, 0xF8, 0x07, 0xF8, 0x01, 0xFC, 0x01, 0xFF,
  0xC0, 0xFD, 0xF0, 0x7C, 0x3E, 0x1E, 0x07, 0x8F, 0x81, 0xF3, 0xC0, 0x7C,
  0xF0, 0x1F, 0x3C, 0x07, 0x8F, 0x83, 0xE3, 0xF1, 0xF8, 0x7F, 0xFC, 0x0F,
  0xFE, 0x01, 0xFE, 0x00, 0x00, 0xF8, 0x01, 0xFF, 0x01, 0xFF, 0xC1, 0xFF,
  0xE1, 0xF0, 0xF8, 0xF0, 0x7C, 0xF8, 0x1E, 0x78, 0x0F, 0x3C, 0x07, 0xBE,
  0x07, 0xDF, 0x03, 0xEF, 0x81, 0xF7, 0xC1, 0xF9, 0xF1, 0xF8, 0xFF, 0xFC,
  0x3F, 0xDE, 0x1F, 0xDF, 0x01, 0x8F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xE1, 0xCF, 0xE0, 0xFF, 0xE0, 0x7F, 0xE0, 0x3F,
  0xC0, 0x00, 0x0F, 0x87, 0xC3, 0xE3, 0xF0, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x7C, 0x7E, 0x3F, 0x0F,
  0x00, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x03, 0xC0, 0x78, 0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x03, 0x80, 0xF0, 0x00,
  0x00, 0x00, 0x80, 0x00, 0xC0, 0x01, 0xE0, 0x03, 0xF0, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F,
  0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x0F,
  0x80, 0x01, 0xC0, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x1F, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x0F,
  0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0xF8,
  0x00, 0x70, 0x00, 0x20, 0x00, 0x00, 0x03, 0xC0, 0x7F, 0xC7, 0xFF, 0x8F,
  0xFF, 0x38, 0x7C, 0x80, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x07, 0x80, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF,
  0xC0, 0x03, 0xF0, 0xFC, 0x01, 0xF0, 0x03, 0xC0, 0x7C, 0x00, 0x3C, 0x0F,
  0x00, 0x03, 0x83, 0xC0, 0x00, 0x78, 0xF0, 0x7F, 0xC7, 0x1C, 0x1F, 0xF0,
  0xE7, 0x87, 0x9E, 0x1C, 0xE1, 0xE1, 0xC3, 0xBC, 0x78, 0x78, 0x77, 0x0E,
  0x0E, 0x0E, 0xE1, 0xC1, 0xC3, 0xDC, 0x78, 0x78, 0x73, 0x8E, 0x0F, 0x0E,
  0xF1, 0xC1, 0xC3, 0xDE, 0x38, 0x78, 0x73, 0xC7, 0x8F, 0x1E, 0x78, 0xFF,
  0x7F, 0x87, 0x0F, 0xCF, 0xE0, 0xE0, 0xF0, 0xF0, 0x1E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x0C, 0x00, 0x3F, 0xFF,
  0x80, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3D, 0xC0, 0x03, 0xDE, 0x00,
  0x79, 0xE0, 0x07, 0x9E, 0x00, 0xF1, 0xE0, 0x0F, 0x1E, 0x01, 0xF1, 0xE0,
  0x1E, 0x1E, 0x03, 0xE1, 0xE0, 0x3C, 0x1E, 0x07, 0xC1, 0xE0, 0x7F, 0xFE,
  0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xF0, 0x1F, 0x3E, 0x01,
  0xF3, 0xE0, 0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x1F, 0x78, 0x01, 0xFF, 0x80,
  0x0F, 0x07, 0xFF, 0x80, 0xFF, 0xF8, 0x1F, 0xFF, 0x87, 0xC3, 0xF0, 0xF8,
  0x3E, 0x1E, 0x03, 0xC3, 0xC0, 0x78, 0x78, 0x0F, 0x1F, 0x03, 0xE3, 0xE0,
  0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xFE, 0x0F, 0x83,
  0xE1, 0xE0, 0x3C, 0x3C, 0x07, 0xCF, 0x80, 0xF9, 0xF0, 0x1F, 0x3E, 0x03,
  0xC7, 0x80, 0xF8, 0xF0, 0x3F, 0x3F, 0xFF, 0xC7, 0xFF, 0xF0, 0xFF, 0xFC,
  0x1F, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0xF0, 0x7F,
  0xFE, 0x0F, 0xE0, 0xC0, 0xF8, 0x04, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x02,
  0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x07,
  0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0x3F, 0xC0, 0xF8, 0x3F,
  0x07, 0xC0, 0xF8, 0x3C, 0x03, 0xC1, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8,
  0x07, 0xC7, 0xC0, 0x3E, 0x3C, 0x01, 0xF1, 0xE0, 0x0F, 0x1F, 0x00, 0xF8,
  0xF8, 0x07, 0xC7, 0x80, 0x3E, 0x3C, 0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x01,
  0xF8, 0xF8, 0x0F, 0x87, 0x81, 0xF8, 0x3C, 0x1F, 0xC3, 0xFF, 0xFC, 0x1F,
  0xFF, 0x80, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC1, 0xFF,
  0xF0, 0x7F, 0xFC, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F,
  0xFE, 0x0F, 0xFF, 0x83, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0xFF, 0x83,
  0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC1, 0xFF, 0xF0,
  0x7F, 0xFC, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7F, 0xF8, 0x1F, 0xFE,
  0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x07, 0xFF, 0x80,
  0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0x0F, 0x07, 0xE0, 0x08, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0x81, 0xFF, 0x7C, 0x0F, 0xF3, 0xE0, 0x7F, 0x9F, 0x07, 0xFC,
  0xF8, 0x03, 0xE7, 0xC0, 0x1E, 0x3E, 0x00, 0xF1, 0xF0, 0x07, 0x8F, 0x80,
  0x7C, 0x7E, 0x03, 0xE1, 0xF8, 0x1E, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80,
  0xFF, 0xFC, 0x01, 0xFF, 0x80, 0x07, 0xC0, 0x3E, 0x0F, 0x00, 0x78, 0x1E,
  0x00, 0xF0, 0x7C, 0x03, 0xE0, 0xF8, 0x07, 0xC1, 0xF0, 0x0F, 0x03, 0xC0,
  0x1E, 0x07, 0x80, 0x7C, 0x1F, 0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x7F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0x80, 0x7C,
  0x1E, 0x00, 0xF0, 0x3C, 0x01, 0xE0, 0x78, 0x07, 0xC1, 0xF0, 0x0F, 0x83,
  0xE0, 0x1E, 0x07, 0x80, 0x3C, 0x0F, 0x00, 0x78, 0x3E, 0x01, 0xF0, 0x7C,
  0x03, 0xE0, 0xF8, 0x07, 0x81, 0xE0, 0x0F, 0x00, 0x07, 0xFF, 0x07, 0xFE,
  0x03, 0xFC, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0xC0,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00,
  0x3E, 0x02, 0x7E, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x08, 0x00,
  0x00, 0x07, 0xC0, 0xFC, 0x1E, 0x03, 0xE0, 0x78, 0x1F, 0x03, 0xE0, 0xF8,
  0x0F, 0x87, 0xC0, 0x3C, 0x3E, 0x00, 0xF1, 0xF8, 0x03, 0xC7, 0xC0, 0x1F,
  0x3E, 0x00, 0x7D, 0xF0, 0x01, 0xEF, 0x80, 0x07, 0xBC, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0x9E, 0x00, 0x3C, 0x7C, 0x00,
  0xF1, 0xF0, 0x07, 0xC3, 0xC0, 0x1F, 0x0F, 0x80, 0x78, 0x3E, 0x01, 0xE0,
  0x78, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x1F, 0x03, 0xC0, 0x3E,
  0x00, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3C,
  0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3C,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xE0, 0x03, 0xF8,
  0x3F, 0x00, 0x1F, 0xC1, 0xF8, 0x01, 0xFC, 0x1F, 0xE0, 0x0F, 0xE0, 0xFF,
  0x00, 0xFF, 0x07, 0xF8, 0x07, 0xF8, 0x3F, 0xC0, 0x7F, 0xC1, 0xFE, 0x03,
  0xFC, 0x1E, 0xF0, 0x3D, 0xE0, 0xF7, 0x81, 0xEF, 0x07, 0xBC, 0x1E, 0xF8,
  0x3D, 0xE0, 0xF7, 0x81, 0xEF, 0x0F, 0x3C, 0x1E, 0x38, 0x79, 0xE0, 0xF1,
  0xC7, 0x8F, 0x07, 0x8E, 0x3C, 0xF8, 0x3C, 0x73, 0xC7, 0x83, 0xE3, 0x9E,
  0x3C, 0x1E, 0x1F, 0xE1, 0xE0, 0xF0, 0xFF, 0x0F, 0x07, 0x87, 0xF0, 0xF8,
  0x3C, 0x3F, 0x87, 0x83, 0xE1, 0xF8, 0x3C, 0x1E, 0x0F, 0xC1, 0xE0, 0xF0,
  0x7C, 0x1F, 0x07, 0x83, 0xE0, 0xF8, 0x00, 0x07, 0xE0, 0x0F, 0x07, 0xE0,
  0x0F, 0x07, 0xE0, 0x1F, 0x0F, 0xE0, 0x1E, 0x0F, 0xF0, 0x1E, 0x0F, 0xF0,
  0x1E, 0x0F, 0xF0, 0x1E, 0x0F, 0xF8, 0x3E, 0x1E, 0x78, 0x3C, 0x1E, 0x78,
  0x3C, 0x1E, 0x78, 0x3C, 0x1E, 0x3C, 0x7C, 0x1E, 0x3C, 0x78, 0x3C, 0x3C,
  0x78, 0x3C, 0x3E, 0x78, 0x3C, 0x1E, 0x78, 0x3C, 0x1E, 0x78, 0x7C, 0x1E,
  0xF0, 0x78, 0x1F, 0xF0, 0x78, 0x0F, 0xF0, 0x78, 0x0F, 0xF0, 0x78, 0x0F,
  0xF0, 0xF8, 0x07, 0xE0, 0xF0, 0x07, 0xE0, 0xF0, 0x07, 0xE0, 0xF0, 0x07,
  0xE0, 0x00, 0x3E, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0,
  0xFE, 0x3F, 0x0F, 0xC0, 0x7C, 0x7C, 0x03, 0xE7, 0xC0, 0x1F, 0x3E, 0x00,
  0x7B, 0xE0, 0x03, 0xDF, 0x00, 0x1E, 0xF8, 0x00, 0xF7, 0x80, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xF7, 0xC0, 0x0F,
  0xBE, 0x00, 0x7D, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x03, 0xE1, 0xF0,
  0x3F, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0xFF, 0xF0, 0x03, 0xFE, 0x00,
  0x07, 0xFF, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0x07, 0xC7, 0xF0, 0xF8, 0x3E,
  0x1F, 0x03, 0xC3, 0xC0, 0x78, 0x78, 0x0F, 0x1F, 0x01, 0xE3, 0xE0, 0x7C,
  0x78, 0x0F, 0x8F, 0x03, 0xE1, 0xFF, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0x81,
  0xFF, 0xC0, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE0, 0xFE, 0x3F, 0x0F, 0xC0, 0x7C, 0x7C, 0x03, 0xE7, 0xC0, 0x1F, 0x3E,
  0x00, 0x7B, 0xE0, 0x03, 0xDF, 0x00, 0x1E, 0xF8, 0x00, 0xF7, 0x80, 0x0F,
  0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xF7, 0xC0,
  0x0F, 0xBE, 0x00, 0x7D, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x03, 0xE1,
  0xF0, 0x3F, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0xFF, 0xF0, 0x03, 0xFE,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFF,
  0x07, 0xC7, 0xE0, 0xF8, 0x3E, 0x1F, 0x07, 0xC3, 0xC0, 0xF8, 0x78, 0x1F,
  0x1F, 0x03, 0xE3, 0xE0, 0x78, 0x78, 0x1F, 0x0F, 0x0F, 0xC1, 0xFF, 0xF8,
  0x7F, 0xFC, 0x0F, 0xFE, 0x01, 0xE3, 0xC0, 0x3C, 0x7C, 0x0F, 0x87, 0x81,
  0xF0, 0xF0, 0x3E, 0x1F, 0x07, 0x83, 0xE0, 0xF0, 0x3C, 0x3E, 0x07, 0xC7,
  0xC0, 0xF8, 0xF8, 0x0F, 0x1E, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x3F, 0xFC,
  0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0xFC, 0x38, 0x1F, 0x01, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00,
  0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x30,
  0x1F, 0x87, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFE, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x7C, 0x3C,
  0x01, 0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x3E, 0x1F, 0x00, 0xF0, 0x78, 0x03,
  0xC1, 0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x3E, 0x01, 0xF0, 0xF8, 0x07, 0x83,
  0xC0, 0x1E, 0x0F, 0x00, 0xF8, 0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0x80,
  0x3C, 0x1E, 0x00, 0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0x78,
  0x3E, 0x03, 0xE0, 0xF8, 0x0F, 0x83, 0xF0, 0x7C, 0x07, 0xFF, 0xF0, 0x1F,
  0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0xF8, 0x01, 0xFF, 0x80,
  0x3E, 0x78, 0x03, 0xC7, 0x80, 0x7C, 0x78, 0x07, 0x87, 0x80, 0xF8, 0x78,
  0x0F, 0x07, 0x81, 0xF0, 0x78, 0x1E, 0x07, 0x83, 0xE0, 0x78, 0x3C, 0x07,
  0x87, 0xC0, 0x78, 0x78, 0x07, 0x87, 0x80, 0x78, 0xF8, 0x07, 0x8F, 0x00,
  0x79, 0xF0, 0x07, 0x9E, 0x00, 0x3B, 0xE0, 0x03, 0xBC, 0x00, 0x3B, 0xC0,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0,
  0x00, 0x78, 0x07, 0x80, 0x7D, 0xE0, 0x3E, 0x01, 0xE7, 0x80, 0xF8, 0x0F,
  0x9E, 0x03, 0xE0, 0x3C, 0x78, 0x1F, 0x80, 0xF1, 0xE0, 0x7E, 0x07, 0xC7,
  0x83, 0xF8, 0x1E, 0x1E, 0x0E, 0xE0, 0xF8, 0x78, 0x7B, 0x83, 0xC1, 0xE1,
  0xEE, 0x0F, 0x07, 0x87, 0x38, 0x7C, 0x1E, 0x3C, 0xE1, 0xE0, 0x78, 0xE3,
  0x8F, 0x81, 0xE7, 0x8E, 0x3C, 0x07, 0x9E, 0x39, 0xF0, 0x1E, 0xF0, 0xE7,
  0x80, 0x7B, 0xC3, 0x9E, 0x01, 0xEE, 0x0E, 0xF8, 0x07, 0xF8, 0x3B, 0xC0,
  0x1F, 0xC0, 0xEF, 0x00, 0x7F, 0x03, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x07,
  0xE0, 0x3F, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x7C, 0x03, 0xF0, 0x01, 0xF0,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x3F, 0x01, 0xE0, 0x3E, 0x01, 0xE0, 0x7C,
  0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x00, 0xF1, 0xF0, 0x00, 0xF3, 0xE0,
  0x00, 0xFB, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x03, 0xEF, 0x00, 0x03, 0xEF, 0x80, 0x07, 0xCF, 0x80,
  0x0F, 0x8F, 0x80, 0x0F, 0x87, 0x80, 0x1F, 0x07, 0xC0, 0x3E, 0x07, 0xC0,
  0x3E, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0xF8, 0x07, 0xEF,
  0x01, 0xF1, 0xE0, 0x3E, 0x3E, 0x0F, 0x87, 0xC1, 0xE0, 0x78, 0x7C, 0x0F,
  0x0F, 0x01, 0xE3, 0xE0, 0x3C, 0xF8, 0x07, 0xDE, 0x00, 0x7F, 0xC0, 0x0F,
  0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xFF, 0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xFF, 0xFC, 0x1F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFE, 0x03, 0xFC,
  0x0F, 0xF0, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x80, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0x70, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x38, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x1C, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x0F, 0x01,
  0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0x80, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x1F, 0xC0,
  0x0E, 0xF0, 0x0F, 0x78, 0x07, 0x1C, 0x07, 0x8F, 0x07, 0x87, 0x83, 0x81,
  0xC3, 0xC0, 0xF1, 0xC0, 0x79, 0xE0, 0x1D, 0xE0, 0x0F, 0xF0, 0x07, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0xF8, 0xF0, 0xE1, 0xE1, 0xC0,
  0x03, 0xF1, 0xC1, 0xFE, 0xF0, 0xFF, 0xFC, 0x7E, 0x7F, 0x1F, 0x0F, 0x8F,
  0x83, 0xE3, 0xC0, 0xF9, 0xF0, 0x3E, 0x7C, 0x0F, 0x9E, 0x03, 0xC7, 0x80,
  0xF3, 0xE0, 0x3C, 0xF8, 0x1F, 0x3E, 0x07, 0xCF, 0x83, 0xE3, 0xE1, 0xF8,
  0x7C, 0xFE, 0x1F, 0xF7, 0x83, 0xF9, 0xE0, 0x7C, 0x70, 0x03, 0xE0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x9F, 0x01, 0xFF, 0xF0, 0x3D, 0xFF, 0x07,
  0xF3, 0xE0, 0xF8, 0x3C, 0x1F, 0x07, 0x87, 0xC0, 0xF8, 0xF8, 0x1E, 0x1E,
  0x03, 0xC3, 0xC0, 0x78, 0xF8, 0x1F, 0x1F, 0x03, 0xE3, 0xC0, 0x78, 0x78,
  0x1F, 0x0F, 0x03, 0xE3, 0xF0, 0xF8, 0x7F, 0x3F, 0x0F, 0xFF, 0xC1, 0xCF,
  0xF0, 0x78, 0xFC, 0x00, 0x01, 0xFE, 0x0F, 0xFC, 0x3F, 0xF8, 0xFC, 0x61,
  0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x04, 0x7E, 0x70,
  0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x03, 0xF3, 0xC0, 0x7F, 0xBC, 0x0F, 0xFF, 0xC1, 0xF9, 0xFC,
  0x1F, 0x0F, 0x83, 0xE0, 0xF8, 0x3C, 0x0F, 0x87, 0xC0, 0xF8, 0x7C, 0x0F,
  0x87, 0x80, 0xF0, 0x78, 0x0F, 0x0F, 0x80, 0xF0, 0xF8, 0x1F, 0x0F, 0x81,
  0xF0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0x7C, 0xFE, 0x07, 0xFF, 0xE0, 0x3F,
  0xDC, 0x01, 0xF1, 0xC0, 0x01, 0xFC, 0x07, 0xFE, 0x0F, 0xFF, 0x1F, 0x0F,
  0x1E, 0x0F, 0x3E, 0x0F, 0x3C, 0x0F, 0x7C, 0x3F, 0x7F, 0xFE, 0x7F, 0xFC,
  0x7F, 0xF0, 0xFE, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00,
  0x7C, 0x18, 0x7F, 0xF8, 0x3F, 0xF8, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xF2, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80,
  0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0xE0, 0x7F, 0xBC, 0x1F, 0xFF,
  0x87, 0xE7, 0xF0, 0xF8, 0x7C, 0x3E, 0x0F, 0x87, 0x81, 0xF1, 0xF0, 0x3E,
  0x3E, 0x07, 0xC7, 0x80, 0xF0, 0xF0, 0x1E, 0x3E, 0x07, 0xC7, 0xC0, 0xF8,
  0xF8, 0x1F, 0x1F, 0x07, 0xC3, 0xE1, 0xF8, 0x3E, 0x7F, 0x07, 0xFF, 0xE0,
  0xFF, 0x7C, 0x0F, 0xCF, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xE0, 0xC0, 0x7C, 0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x03,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x9F, 0x83, 0xFF,
  0xF0, 0xF7, 0xFC, 0x3F, 0x9F, 0x0F, 0xC3, 0xC3, 0xE0, 0xF1, 0xF0, 0x3C,
  0x7C, 0x0F, 0x1E, 0x07, 0xC7, 0x81, 0xF3, 0xE0, 0x78, 0xF8, 0x1E, 0x3C,
  0x07, 0x8F, 0x03, 0xE3, 0xC0, 0xF9, 0xF0, 0x3C, 0x7C, 0x0F, 0x1E, 0x07,
  0xC7, 0x81, 0xF3, 0xE0, 0x78, 0x01, 0xC0, 0x78, 0x0F, 0x81, 0xE0, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x81, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x1E,
  0x07, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x78, 0x0F,
  0x03, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x7C, 0x00, 0x00, 0x0E, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0,
  0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80,
  0x0F, 0x80, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x83, 0xF0, 0xF8, 0x7C, 0x0F,
  0x87, 0x80, 0xF0, 0xF8, 0x0F, 0x1F, 0x00, 0xF3, 0xE0, 0x1F, 0x7C, 0x01,
  0xEF, 0x80, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x80,
  0x3E, 0x78, 0x03, 0xC7, 0xC0, 0x3C, 0x7C, 0x07, 0xC3, 0xC0, 0x7C, 0x3E,
  0x07, 0x83, 0xE0, 0x78, 0x1E, 0x0F, 0x81, 0xF0, 0x03, 0xE0, 0x7C, 0x0F,
  0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x3C, 0x07, 0x81, 0xF0, 0x3E, 0x07,
  0x80, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0xF8, 0x1F, 0x03,
  0xC0, 0x78, 0x0F, 0x03, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x7C, 0x00, 0x07,
  0x3F, 0x07, 0xE0, 0xF7, 0xF9, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0xFE, 0x7F,
  0x9F, 0x0F, 0x83, 0xF0, 0xF0, 0xF8, 0x3E, 0x0F, 0x1F, 0x07, 0xC0, 0xF1,
  0xF0, 0x7C, 0x1F, 0x1E, 0x07, 0xC1, 0xF1, 0xE0, 0x78, 0x1E, 0x3E, 0x07,
  0x81, 0xE3, 0xE0, 0xF8, 0x1E, 0x3C, 0x0F, 0x83, 0xE3, 0xC0, 0xF0, 0x3E,
  0x3C, 0x0F, 0x03, 0xC7, 0xC0, 0xF0, 0x3C, 0x7C, 0x1F, 0x03, 0xC7, 0x81,
  0xF0, 0x7C, 0x78, 0x1E, 0x07, 0xCF, 0x81, 0xE0, 0x78, 0x07, 0x1F, 0x83,
  0xDF, 0xF0, 0xFF, 0xFC, 0x3F, 0x9F, 0x0F, 0xC3, 0xC7, 0xE0, 0xF1, 0xF0,
  0x3C, 0x7C, 0x0F, 0x1E, 0x07, 0xC7, 0x81, 0xF3, 0xE0, 0x78, 0xF8, 0x1E,
  0x3C, 0x07, 0x8F, 0x03, 0xE3, 0xC0, 0xF9, 0xF0, 0x3C, 0x7C, 0x0F, 0x1E,
  0x07, 0xC7, 0x81, 0xF3, 0xE0, 0x78, 0x03, 0xFC, 0x03, 0xFF, 0x03, 0xFF,
  0xC3, 0xF3, 0xE3, 0xE0, 0xF9, 0xF0, 0x7C, 0xF0, 0x1E, 0xF8, 0x0F, 0x78,
  0x0F, 0xBC, 0x07, 0xDE, 0x03, 0xFF, 0x01, 0xEF, 0x80, 0xF7, 0xC0, 0xFB,
  0xE0, 0x78, 0xF0, 0x7C, 0x7E, 0xFC, 0x3F, 0xFE, 0x0F, 0xFE, 0x01, 0xFC,
  0x00, 0x03, 0x8F, 0x80, 0x7B, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0x3E, 0x07,
  0xC1, 0xE0, 0x7C, 0x1E, 0x0F, 0x81, 0xF0, 0xF8, 0x1E, 0x0F, 0x01, 0xE0,
  0xF0, 0x1E, 0x1F, 0x03, 0xE1, 0xF0, 0x3E, 0x1E, 0x03, 0xC1, 0xE0, 0x7C,
  0x1E, 0x07, 0xC3, 0xF0, 0xF8, 0x3F, 0x9F, 0x83, 0xFF, 0xF0, 0x3D, 0xFE,
  0x03, 0xCF, 0xC0, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xF1, 0xC1, 0xFE, 0xF0, 0xFF, 0xFC, 0x7E, 0x7F, 0x1F,
  0x0F, 0x8F, 0x83, 0xE3, 0xC0, 0xF9, 0xF0, 0x3E, 0x7C, 0x0F, 0x9E, 0x03,
  0xC7, 0x80, 0xF3, 0xE0, 0x3C, 0xF8, 0x1F, 0x3E, 0x07, 0xCF, 0x83, 0xE3,
  0xE0, 0xF8, 0x7C, 0xFE, 0x1F, 0xF7, 0x83, 0xFB, 0xC0, 0x7C, 0xF0, 0x00,
  0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x07, 0x1E, 0x1E, 0xFC,
  0x3D, 0xF8, 0x7F, 0xE0, 0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1E,
  0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x00, 0x07, 0xFC,
  0x1F, 0xFC, 0x7F, 0xF0, 0xF8, 0x63, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x0F,
  0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x40, 0x7C, 0xE1, 0xF9, 0xFF, 0xE3, 0xFF, 0x83, 0xFE, 0x00,
  0x07, 0x00, 0xF0, 0x0F, 0x01, 0xE0, 0x3F, 0xFF, 0xFE, 0xFF, 0xE3, 0xE0,
  0x3C, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x80,
  0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF9, 0x0F, 0xF0, 0xFF, 0x07, 0xF0,
  0x3E, 0x07, 0x9F, 0x03, 0xCF, 0x01, 0xE7, 0x81, 0xF3, 0xC0, 0xF3, 0xE0,
  0x79, 0xF0, 0x3C, 0xF0, 0x3E, 0x78, 0x1F, 0x3C, 0x0F, 0x3E, 0x07, 0x9E,
  0x07, 0xCF, 0x03, 0xE7, 0x81, 0xF3, 0xC1, 0xF1, 0xE1, 0xF8, 0xF9, 0xFC,
  0x7F, 0xDE, 0x3F, 0xCE, 0x0F, 0xC7, 0x00, 0xF0, 0x0F, 0xF8, 0x0F, 0xBC,
  0x07, 0x9E, 0x07, 0xCF, 0x03, 0xC7, 0xC3, 0xE1, 0xE1, 0xE0, 0xF1, 0xF0,
  0x78, 0xF0, 0x3C, 0xF8, 0x1E, 0x78, 0x0F, 0x3C, 0x07, 0xBC, 0x03, 0xDE,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0x80, 0x07,
  0xC0, 0x00, 0xF0, 0x3E, 0x07, 0xFC, 0x0F, 0x81, 0xEF, 0x07, 0xE0, 0xF3,
  0xC1, 0xF8, 0x3C, 0xF0, 0xFE, 0x1F, 0x3C, 0x3B, 0x87, 0x8F, 0x0E, 0xE3,
  0xE3, 0xC7, 0xB8, 0xF0, 0xF1, 0xCE, 0x3C, 0x3C, 0xF3, 0x9E, 0x0F, 0x38,
  0xE7, 0x83, 0xCE, 0x3B, 0xC0, 0xF7, 0x8E, 0xF0, 0x1D, 0xC3, 0xBC, 0x07,
  0xF0, 0xFE, 0x01, 0xF8, 0x3F, 0x80, 0x7E, 0x0F, 0xC0, 0x1F, 0x83, 0xF0,
  0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0xC1, 0xF8, 0x3E, 0x0F,
  0x80, 0xF0, 0xF8, 0x07, 0x8F, 0x80, 0x3E, 0x78, 0x00, 0xF7, 0xC0, 0x07,
  0xFC, 0x00, 0x3F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x3E, 0xF8, 0x01, 0xE3,
  0xC0, 0x1F, 0x1F, 0x01, 0xF0, 0xF8, 0x1F, 0x03, 0xC1, 0xF8, 0x1F, 0x00,
  0x07, 0x80, 0x7C, 0x1E, 0x03, 0xE0, 0x7C, 0x0F, 0x01, 0xF0, 0x7C, 0x03,
  0xC1, 0xE0, 0x0F, 0x0F, 0x80, 0x3C, 0x3C, 0x00, 0xF0, 0xF0, 0x03, 0xC7,
  0x80, 0x0F, 0x1E, 0x00, 0x3C, 0xF0, 0x00, 0xF3, 0xC0, 0x03, 0xDE, 0x00,
  0x0F, 0x78, 0x00, 0x1D, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x03, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x87, 0xFF,
  0x83, 0xFF, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xE0, 0x01,
  0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3F, 0xFC, 0x3F, 0xFE,
  0x1F, 0xFF, 0x00, 0x00, 0x3E, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x3E, 0x00, 0x78, 0x03, 0xF0, 0x1F, 0xC0, 0x3E, 0x00, 0xFC, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xF0, 0x03, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xE0,
  0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3E,
  0x00, 0x3F, 0x80, 0x3E, 0x00, 0xFC, 0x07, 0xF8, 0x0F, 0x80, 0x3E, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x78, 0x00, 0x3E, 0x00,
  0xBF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xF4, 0x01, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_SemiBoldItalic37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 11, 26, 10, 0, -26 },
  { 37, 12, 9, 15, 4, -26 },
  { 51, 21, 26, 21, 1, -26 },
  { 120, 18, 30, 19, 1, -28 },
  { 188, 25, 27, 29, 2, -27 },
  { 273, 21, 27, 23, 1, -27 },
  { 344, 5, 9, 9, 4, -26 },
  { 350, 13, 32, 11, 1, -26 },
  { 402, 13, 33, 11, -3, -27 },
  { 456, 16, 16, 18, 3, -28 },
  { 488, 17, 18, 20, 2, -22 },
  { 527, 8, 9, 9, -2, -4 },
  { 536, 9, 4, 11, 1, -12 },
  { 541, 6, 5, 9, 0, -5 },
  { 545, 19, 27, 14, -2, -27 },
  { 610, 17, 27, 19, 1, -27 },
  { 668, 12, 26, 19, 4, -26 },
  { 707, 19, 27, 19, -1, -27 },
  { 772, 18, 27, 19, 0, -27 },
  { 833, 18, 26, 19, 0, -26 },
  { 892, 19, 26, 19, 0, -26 },
  { 954, 17, 27, 19, 2, -27 },
  { 1012, 18, 26, 19, 2, -26 },
  { 1071, 18, 27, 19, 1, -27 },
  { 1132, 17, 27, 19, 1, -27 },
  { 1190, 9, 20, 10, 0, -20 },
  { 1213, 11, 25, 10, -2, -20 },
  { 1248, 17, 19, 20, 2, -23 },
  { 1289, 16, 10, 20, 2, -18 },
  { 1309, 17, 19, 20, 2, -23 },
  { 1350, 14, 27, 15, 2, -27 },
  { 1398, 27, 29, 28, 1, -26 },
  { 1496, 20, 26, 20, -2, -26 },
  { 1561, 19, 26, 21, 1, -26 },
  { 1623, 20, 27, 20, 2, -27 },
  { 1691, 21, 26, 23, 1, -26 },
  { 1760, 18, 26, 18, 1, -26 },
  { 1819, 18, 26, 17, 1, -26 },
  { 1878, 21, 27, 23, 2, -27 },
  { 1949, 23, 26, 23, 1, -26 },
  { 2024, 16, 26, 12, -1, -26 },
  { 2076, 17, 34, 10, -6, -26 },
  { 2149, 22, 26, 20, 1, -26 },
  { 2221, 13, 26, 17, 1, -26 },
  { 2264, 29, 26, 29, 1, -26 },
  { 2359, 24, 26, 25, 1, -26 },
  { 2437, 21, 27, 24, 2, -27 },
  { 2508, 19, 26, 20, 1, -26 },
  { 2570, 21, 33, 24, 2, -27 },
  { 2657, 19, 26, 20, 1, -26 },
  { 2719, 19, 27, 18, 0, -27 },
  { 2784, 17, 26, 17, 3, -26 },
  { 2840, 22, 26, 23, 2, -26 },
  { 2912, 20, 26, 19, 3, -26 },
  { 2977, 30, 26, 30, 3, -26 },
  { 3075, 24, 26, 19, -2, -26 },
  { 3153, 19, 26, 18, 3, -26 },
  { 3215, 21, 26, 18, -1, -26 },
  { 3284, 15, 32, 11, -1, -26 },
  { 3344, 8, 27, 14, 4, -27 },
  { 3371, 15, 32, 11, -3, -26 },
  { 3431, 17, 17, 19, 1, -27 },
  { 3468, 14, 3, 14, -3, 3 },
  { 3474, 7, 6, 11, 5, -28 },
  { 3480, 18, 20, 20, 1, -20 },
  { 3525, 19, 28, 20, 0, -28 },
  { 3592, 15, 20, 16, 1, -20 },
  { 3630, 20, 28, 20, 1, -28 },
  { 3700, 16, 20, 18, 1, -20 },
  { 3740, 20, 37, 12, -4, -28 },
  { 3833, 19, 29, 20, 0, -20 },
  { 3902, 18, 28, 20, 0, -28 },
  { 3965, 11, 28, 10, 0, -28 },
  { 4004, 16, 37, 10, -5, -28 },
  { 4078, 20, 28, 18, 0, -28 },
  { 4148, 11, 28, 10, 0, -28 },
  { 4187, 28, 20, 30, 0, -20 },
  { 4257, 18, 20, 20, 0, -20 },
  { 4302, 17, 20, 19, 1, -20 },
  { 4345, 20, 29, 20, -1, -20 },
  { 4418, 18, 29, 20, 1, -20 },
  { 4484, 15, 20, 14, 0, -20 },
  { 4522, 15, 20, 15, 0, -20 },
  { 4560, 12, 24, 13, 2, -24 },
  { 4596, 17, 20, 20, 2, -20 },
  { 4639, 17, 20, 17, 2, -20 },
  { 4682, 26, 20, 26, 2, -20 },
  { 4747, 21, 20, 17, -2, -20 },
  { 4800, 22, 29, 17, -3, -20 },
  { 4880, 17, 20, 15, -1, -20 },
  { 4923, 15, 32, 13, 0, -26 },
  { 4983, 4, 37, 18, 7, -28 },
  { 5002, 15, 32, 13, -2, -26 },
  { 5062, 17, 6, 20, 2, -16 },
};

const GFXfont NotoSans_SemiCondensed_SemiBoldItalic37pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_SemiBoldItalic37pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_SemiBoldItalic37pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC37PT7B_H_
