#ifndef _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC45PT7B_H_
#define _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC45PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-SemiBoldItalic.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_SemiBoldItalic45pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0x80, 0x7C, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xE0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0xFC, 0x07, 0xE0,
  0x7F, 0x01, 0xF8, 0x0F, 0x80, 0x30, 0x00, 0x3E, 0x3F, 0x3E, 0x3E, 0x3E,
  0x3E, 0x3C, 0x3E, 0x7C, 0x3C, 0x7C, 0x7C, 0x7C, 0x7C, 0x78, 0x78, 0x78,
  0x78, 0x78, 0x78, 0xF0, 0x78, 0x00, 0x1E, 0x1F, 0x00, 0x07, 0x87, 0x80,
  0x03, 0xC1, 0xE0, 0x00, 0xF0, 0x70, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x0F,
  0x00, 0x07, 0x83, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0x78, 0x78, 0x07, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x80,
  0x78, 0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xC1, 0xE0,
  0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x3C, 0x03, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC0, 0x3C, 0x1E, 0x00, 0x0F,
  0x0F, 0x00, 0x03, 0x83, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x78, 0x78, 0x00,
  0x1E, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xC1, 0xC0, 0x00, 0xF0, 0xF0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xE0,
  0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F,
  0xCC, 0x70, 0x3E, 0x30, 0x40, 0xF9, 0xC0, 0x07, 0xE7, 0x00, 0x1F, 0x9C,
  0x00, 0x3E, 0x60, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x01,
  0xDF, 0x80, 0x06, 0x3E, 0x00, 0x18, 0xF8, 0x00, 0xE3, 0xE2, 0x03, 0x9F,
  0x8E, 0x0E, 0x7C, 0x3F, 0x3F, 0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x0F,
  0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x07, 0xC0, 0xFF, 0x80, 0x3E, 0x07, 0xFE, 0x00, 0xF0, 0x3E, 0x78,
  0x07, 0x80, 0xF1, 0xF0, 0x3E, 0x07, 0x87, 0xC0, 0xF0, 0x1E, 0x1F, 0x07,
  0x80, 0xF8, 0x7C, 0x3E, 0x03, 0xE1, 0xE0, 0xF0, 0x0F, 0x07, 0x87, 0x80,
  0x3C, 0x1E, 0x3E, 0x00, 0xF0, 0xF8, 0xF0, 0x03, 0xC3, 0xC7, 0x87, 0x0F,
  0x0F, 0x3E, 0x7F, 0x3C, 0x7C, 0xF3, 0xFE, 0xFB, 0xE7, 0x9F, 0xFF, 0xFF,
  0x3E, 0x79, 0xF7, 0xFC, 0xF3, 0xE3, 0xCF, 0xC7, 0x8F, 0x0F, 0x0C, 0x3E,
  0x7C, 0x3C, 0x00, 0xF1, 0xE0, 0xF0, 0x07, 0x87, 0x83, 0xC0, 0x3E, 0x1E,
  0x1F, 0x00, 0xF0, 0xF8, 0x7C, 0x07, 0x83, 0xE1, 0xE0, 0x3E, 0x0F, 0x87,
  0x80, 0xF0, 0x3E, 0x3E, 0x07, 0x80, 0xF8, 0xF0, 0x3E, 0x01, 0xE7, 0xC0,
  0xF0, 0x07, 0xFE, 0x07, 0x80, 0x1F, 0xF0, 0x3E, 0x00, 0x3F, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xE0,
  0x01, 0xFF, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x83,
  0xE0, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x0F,
  0x8F, 0xC0, 0x03, 0xF7, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFF, 0x81, 0xF1, 0xFF, 0xE0,
  0xF8, 0xFC, 0xFC, 0x3E, 0x7E, 0x1F, 0x1F, 0x1F, 0x07, 0xE7, 0xCF, 0xC0,
  0xFF, 0xE3, 0xF0, 0x3F, 0xF8, 0xF8, 0x07, 0xFC, 0x3E, 0x01, 0xFE, 0x0F,
  0xC0, 0x3F, 0x83, 0xF0, 0x1F, 0xE0, 0xFE, 0x1F, 0xF8, 0x1F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xF9, 0xF8, 0x1F, 0xF8, 0x7F, 0x00, 0x7E,
  0xF9, 0xF3, 0xE7, 0x9F, 0x3E, 0x78, 0xF1, 0xE3, 0xC0, 0x00, 0x3F, 0x00,
  0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3E,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x07,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x06, 0x0F, 0x80, 0xF1, 0xE0, 0x1F, 0xBC, 0x07, 0xFF,
  0xBF, 0x7F, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0x83, 0xF8, 0x10, 0xFF,
  0x80, 0x3E, 0xF0, 0x0F, 0x8F, 0x03, 0xF1, 0xE0, 0x1C, 0x3E, 0x01, 0x03,
  0xE0, 0x00, 0x70, 0x00, 0x08, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x0F, 0xC7, 0xE1, 0xF8, 0x7C, 0x3F, 0x0F, 0x83,
  0xE1, 0xF0, 0x78, 0x3E, 0x0F, 0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xEF, 0xFE,
  0x3E, 0xFD, 0xFF, 0xFF, 0xEF, 0x8C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xC0, 0x3F,
  0xFE, 0x07, 0xFF, 0xE0, 0xFE, 0x3F, 0x0F, 0xC3, 0xF1, 0xF8, 0x1F, 0x1F,
  0x01, 0xF3, 0xF0, 0x1F, 0x3E, 0x01, 0xF7, 0xE0, 0x1F, 0x7E, 0x01, 0xF7,
  0xC0, 0x1F, 0x7C, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x3F,
  0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x07, 0xEF, 0x80, 0x7E, 0xF8, 0x07,
  0xCF, 0x80, 0xFC, 0xF8, 0x0F, 0xCF, 0x81, 0xF8, 0xF8, 0x1F, 0x8F, 0x83,
  0xF0, 0xFC, 0x7E, 0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x03, 0xFF, 0x80, 0x1F,
  0xE0, 0x00, 0x00, 0x7E, 0x01, 0xFC, 0x07, 0xF0, 0x3F, 0xE0, 0xFF, 0xC7,
  0xFF, 0x9F, 0xFF, 0x7F, 0x7C, 0xFC, 0xF8, 0xE1, 0xF0, 0x87, 0xE0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F,
  0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0,
  0x0F, 0x80, 0x00, 0x03, 0x80, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xE0, 0x0F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7E, 0x1F, 0xC0, 0x70, 0x1F, 0x80, 0x40,
  0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF,
  0xE0, 0x00, 0x06, 0x00, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0x01, 0xFF, 0xFE,
  0x03, 0xFF, 0xFC, 0x0F, 0x07, 0xF0, 0x10, 0x0F, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF8, 0x00, 0x1F, 0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xE0, 0x01, 0xFE, 0x00,
  0x07, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7E, 0x20, 0x03, 0xF8, 0xF0, 0x3F, 0xC3, 0xFF, 0xFF, 0x0F,
  0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xE0, 0x01, 0xFF, 0x80, 0x07, 0xBE, 0x00, 0x3F, 0xF0, 0x01, 0xF7, 0xC0,
  0x0F, 0x9F, 0x00, 0x3C, 0x7C, 0x01, 0xF3, 0xF0, 0x0F, 0x8F, 0x80, 0x7C,
  0x3E, 0x01, 0xE0, 0xF8, 0x0F, 0x83, 0xE0, 0x7C, 0x1F, 0x83, 0xE0, 0x7C,
  0x0F, 0x01, 0xF0, 0x7C, 0x07, 0xC7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xF8, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0,
  0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03,
  0xFF, 0xF8, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xFE, 0x00,
  0x7F, 0xFC, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0E, 0x3F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x08,
  0x01, 0xFC, 0x3C, 0x1F, 0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xE0, 0x00, 0xFF, 0xC0, 0x1F, 0xFE,
  0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xE0, 0xC0, 0x1F, 0x3F, 0x81, 0xF7, 0xFE, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xC7, 0xF8, 0x3F, 0x3F, 0x81, 0xF9, 0xF8, 0x0F, 0xCF, 0xC0, 0x3E, 0x7C,
  0x03, 0xF3, 0xE0, 0x1F, 0x9F, 0x00, 0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x7E,
  0x3E, 0x03, 0xF1, 0xF8, 0x3F, 0x07, 0xE3, 0xF8, 0x3F, 0xFF, 0x80, 0xFF,
  0xF8, 0x07, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xF1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xFF,
  0xF8, 0x1F, 0x83, 0xE0, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0x80, 0xFC,
  0x3E, 0x03, 0xE0, 0xFC, 0x0F, 0x83, 0xF0, 0x7E, 0x07, 0xE3, 0xF0, 0x1F,
  0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xFC,
  0x01, 0xFF, 0xF8, 0x0F, 0xE3, 0xF0, 0x7E, 0x07, 0xE1, 0xF0, 0x1F, 0x8F,
  0xC0, 0x3E, 0x3E, 0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0x80,
  0x3E, 0x3F, 0x01, 0xF8, 0xFE, 0x0F, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xF8,
  0x0F, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x00, 0x0C, 0x00, 0x07, 0xFC, 0x00,
  0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0x7F, 0xFF, 0x07, 0xF1, 0xF8, 0x7E, 0x07,
  0xE3, 0xF0, 0x3F, 0x1F, 0x00, 0xF9, 0xF8, 0x07, 0xCF, 0xC0, 0x3E, 0x7C,
  0x03, 0xF3, 0xE0, 0x1F, 0x9F, 0x00, 0xFC, 0xF8, 0x0F, 0xE7, 0xE0, 0x7E,
  0x3F, 0x8F, 0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0x7C, 0x1F, 0xF7, 0xE0, 0x7F,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x0C, 0x0F, 0xE0, 0x7F, 0xFE,
  0x03, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xC0, 0xFC,
  0x1F, 0x87, 0xF0, 0xFE, 0x1F, 0x81, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E,
  0x07, 0xE0, 0xFC, 0x3F, 0x87, 0xF0, 0x7C, 0x02, 0x00, 0x00, 0x70, 0x0F,
  0xC0, 0x7E, 0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0,
  0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x01,
  0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03,
  0xFC, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0,
  0x01, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x04, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x3F, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0xFF,
  0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x3F, 0xC0, 0x01, 0xF8, 0x00, 0x0E,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xE0, 0x07, 0xFE, 0x0F, 0xFF, 0x8F,
  0xFF, 0xE3, 0xFF, 0xF1, 0xC1, 0xF8, 0x80, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xF8, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0x03, 0xF8, 0x01, 0xF8,
  0x00, 0xFC, 0x03, 0xF0, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0x1E, 0x0F, 0x80,
  0x00, 0x1E, 0x0F, 0x00, 0x60, 0x0F, 0x1E, 0x03, 0xFF, 0x0F, 0x1E, 0x0F,
  0xFF, 0x0F, 0x3C, 0x1F, 0xFF, 0x0F, 0x3C, 0x1E, 0x1F, 0x0F, 0x78, 0x3C,
  0x1E, 0x0F, 0x78, 0x7C, 0x1E, 0x0F, 0x78, 0x78, 0x1E, 0x0F, 0xF0, 0xF8,
  0x3E, 0x0F, 0xF0, 0xF0, 0x3C, 0x1E, 0xF0, 0xF0, 0x3C, 0x1E, 0xF0, 0xF0,
  0x3C, 0x1E, 0xF0, 0xF0, 0x7C, 0x3C, 0xF0, 0xF0, 0x78, 0x3C, 0xF0, 0xF0,
  0xF8, 0x78, 0xF0, 0xF9, 0xFC, 0xF8, 0xF0, 0xFF, 0xBF, 0xF0, 0xF0, 0x7F,
  0x9F, 0xE0, 0xF0, 0x3E, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x0C, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0x9E, 0x00, 0x0F,
  0x8F, 0x00, 0x07, 0xC7, 0x80, 0x07, 0xC3, 0xC0, 0x03, 0xE1, 0xE0, 0x03,
  0xF0, 0xF8, 0x01, 0xF0, 0x7C, 0x01, 0xF8, 0x3E, 0x00, 0xF8, 0x1F, 0x00,
  0xFC, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x1F, 0x80, 0x3E, 0x0F, 0xC0, 0x1F,
  0x0F, 0xC0, 0x0F, 0x87, 0xE0, 0x07, 0xE7, 0xE0, 0x03, 0xF3, 0xF0, 0x01,
  0xF9, 0xF0, 0x00, 0xFD, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x03, 0xE1,
  0xFF, 0x07, 0xE0, 0x7F, 0x07, 0xE0, 0x3F, 0x07, 0xC0, 0x3F, 0x07, 0xC0,
  0x3F, 0x07, 0xC0, 0x3F, 0x0F, 0xC0, 0x3E, 0x0F, 0xC0, 0x7E, 0x0F, 0x81,
  0xFC, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xE0, 0x1F, 0x0F, 0xF0, 0x1F, 0x01, 0xF8, 0x3F, 0x00, 0xF8, 0x3F, 0x00,
  0xFC, 0x3E, 0x00, 0xFC, 0x3E, 0x00, 0xFC, 0x3E, 0x00, 0xF8, 0x7E, 0x01,
  0xF8, 0x7E, 0x01, 0xF8, 0x7C, 0x03, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF,
  0xFE, 0x03, 0xFC, 0x1E, 0x07, 0xF0, 0x04, 0x0F, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x40, 0x3F, 0xE7,
  0xC0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x03, 0xFF,
  0x80, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x3F, 0x03, 0xF8, 0x1F, 0x80, 0xFE, 0x0F,
  0xC0, 0x3F, 0x07, 0xC0, 0x1F, 0x83, 0xE0, 0x0F, 0xC3, 0xF0, 0x03, 0xE1,
  0xF8, 0x01, 0xF0, 0xFC, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x7E,
  0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x1F, 0x8F, 0x80, 0x0F, 0xC7, 0xC0, 0x07,
  0xC7, 0xE0, 0x07, 0xE3, 0xF0, 0x03, 0xF1, 0xF8, 0x03, 0xF0, 0xF8, 0x01,
  0xF8, 0x7C, 0x01, 0xF8, 0x7E, 0x01, 0xFC, 0x3F, 0x01, 0xFC, 0x1F, 0x83,
  0xFC, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x03, 0xFF,
  0xF8, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x07, 0xFF,
  0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF,
  0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00,
  0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xFF,
  0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0x83, 0xE0, 0x7F, 0x80, 0x10,
  0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x0F, 0xFC, 0x7E, 0x07, 0xFF, 0x1F, 0x01, 0xFF, 0xC7,
  0xC0, 0x7F, 0xF3, 0xF0, 0x1F, 0xF8, 0xFC, 0x00, 0x3E, 0x3F, 0x00, 0x1F,
  0x8F, 0xC0, 0x07, 0xE3, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x1F, 0x80,
  0x1F, 0x07, 0xE0, 0x0F, 0xC1, 0xFC, 0x03, 0xF0, 0x3F, 0xC3, 0xF8, 0x0F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x00, 0x01, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x03, 0xF0, 0x03, 0xE0,
  0x3E, 0x00, 0x3E, 0x03, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xE0,
  0x07, 0xC0, 0x7E, 0x00, 0x7C, 0x07, 0xC0, 0x0F, 0xC0, 0x7C, 0x00, 0xFC,
  0x0F, 0xC0, 0x0F, 0xC0, 0xFC, 0x00, 0xF8, 0x0F, 0xC0, 0x0F, 0x80, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0x00, 0x3F, 0x01, 0xF0, 0x03, 0xF0, 0x3F,
  0x00, 0x3E, 0x03, 0xF0, 0x03, 0xE0, 0x3E, 0x00, 0x7E, 0x03, 0xE0, 0x07,
  0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xC0, 0x7E, 0x00, 0x7C, 0x07,
  0xC0, 0x0F, 0xC0, 0x7C, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0xC0, 0xFC, 0x00,
  0xF8, 0x0F, 0xC0, 0x0F, 0x80, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF,
  0x00, 0xFF, 0x80, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x03,
  0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x3F, 0x80, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFC,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xF0, 0x0F, 0xE0, 0x7E, 0x01, 0xF8, 0x0F,
  0x80, 0x7E, 0x01, 0xF0, 0x1F, 0x80, 0x3E, 0x07, 0xE0, 0x0F, 0xC1, 0xFC,
  0x01, 0xF8, 0x3F, 0x00, 0x3E, 0x0F, 0xC0, 0x07, 0xC3, 0xF0, 0x00, 0xF8,
  0xFC, 0x00, 0x3F, 0x3F, 0x80, 0x07, 0xEF, 0xE0, 0x00, 0xF9, 0xF8, 0x00,
  0x1F, 0x7E, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0x7C, 0x00, 0x0F, 0xCF, 0xC0, 0x03,
  0xF1, 0xF8, 0x00, 0x7E, 0x1F, 0x00, 0x0F, 0x83, 0xF0, 0x01, 0xF0, 0x7E,
  0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xC0, 0xFC, 0x01, 0xF0, 0x1F, 0x80, 0x3E,
  0x03, 0xF0, 0x07, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xFC,
  0x07, 0xC0, 0x0F, 0xC0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x00, 0x0F, 0xFF, 0xF7, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFD, 0xFF, 0xFE,
  0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x03, 0xFC, 0x0F, 0xF0, 0x00,
  0xFF, 0x81, 0xFE, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x07, 0xFC, 0x0F, 0xF8,
  0x00, 0xFF, 0x81, 0xFF, 0x00, 0x3F, 0xF0, 0x3F, 0xE0, 0x07, 0xFE, 0x07,
  0xFE, 0x01, 0xF7, 0xC0, 0xF7, 0xC0, 0x3F, 0xF0, 0x3E, 0xF8, 0x0F, 0xBE,
  0x07, 0xDF, 0x01, 0xF7, 0xC0, 0xFB, 0xE0, 0x7C, 0xF8, 0x1F, 0x7C, 0x0F,
  0xBF, 0x03, 0xEF, 0x83, 0xE7, 0xC0, 0xF8, 0xF0, 0x7C, 0xF8, 0x1F, 0x1E,
  0x0F, 0x1F, 0x03, 0xE3, 0xC3, 0xE3, 0xE0, 0x7C, 0x78, 0x78, 0xFC, 0x1F,
  0x8F, 0x1F, 0x1F, 0x03, 0xE1, 0xE3, 0xC3, 0xE0, 0x7C, 0x3C, 0xF8, 0x7C,
  0x0F, 0x87, 0x9E, 0x0F, 0x81, 0xF0, 0xF7, 0xC3, 0xE0, 0x7C, 0x1F, 0xF0,
  0x7C, 0x0F, 0x83, 0xFE, 0x0F, 0x81, 0xF0, 0x7F, 0x81, 0xF0, 0x3E, 0x0F,
  0xF0, 0x7E, 0x07, 0xC1, 0xFC, 0x0F, 0x81, 0xF0, 0x3F, 0x81, 0xF0, 0x3E,
  0x07, 0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0xFC,
  0x0F, 0xE0, 0x03, 0xE0, 0x3F, 0xC0, 0x0F, 0x80, 0xFF, 0x00, 0x3E, 0x03,
  0xFC, 0x00, 0xF8, 0x1F, 0xF0, 0x07, 0xC0, 0x7F, 0xE0, 0x1F, 0x01, 0xFF,
  0x80, 0x7C, 0x07, 0xFE, 0x01, 0xF0, 0x1E, 0xF8, 0x07, 0xC0, 0xF9, 0xF0,
  0x3E, 0x03, 0xE7, 0xC0, 0xF8, 0x0F, 0x9F, 0x03, 0xE0, 0x3E, 0x3E, 0x0F,
  0x80, 0xF8, 0xF8, 0x7E, 0x07, 0xC3, 0xE1, 0xF0, 0x1F, 0x0F, 0x87, 0xC0,
  0x7C, 0x1F, 0x1F, 0x01, 0xF0, 0x7C, 0x7C, 0x0F, 0xC1, 0xF3, 0xE0, 0x3E,
  0x03, 0xEF, 0x80, 0xF8, 0x0F, 0xBE, 0x03, 0xE0, 0x3E, 0xF8, 0x0F, 0x80,
  0xFB, 0xE0, 0x7C, 0x01, 0xFF, 0x01, 0xF0, 0x07, 0xFC, 0x07, 0xC0, 0x1F,
  0xF0, 0x1F, 0x00, 0x7F, 0xC0, 0x7C, 0x00, 0xFF, 0x03, 0xE0, 0x03, 0xF8,
  0x0F, 0x80, 0x0F, 0xE0, 0x3E, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x80, 0xFF, 0x1F, 0xE0, 0x7F, 0x01, 0xF8, 0x3F, 0x80, 0x3F, 0x0F, 0xC0,
  0x0F, 0xC7, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0x7C, 0xFC, 0x00, 0x1F, 0x3F,
  0x00, 0x07, 0xCF, 0x80, 0x01, 0xF7, 0xE0, 0x00, 0x7D, 0xF8, 0x00, 0x3F,
  0x7E, 0x00, 0x0F, 0xDF, 0x80, 0x03, 0xF7, 0xC0, 0x00, 0xFF, 0xF0, 0x00,
  0x3E, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x07, 0xEF, 0xC0, 0x03, 0xF3, 0xF0,
  0x00, 0xFC, 0x7C, 0x00, 0x7F, 0x1F, 0x80, 0x1F, 0x87, 0xE0, 0x0F, 0xE1,
  0xFC, 0x07, 0xF0, 0x3F, 0xC7, 0xF8, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x3F, 0x07, 0xC0, 0x3F, 0x07,
  0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3E, 0x0F, 0x80, 0x7E, 0x0F,
  0x80, 0xFE, 0x0F, 0x81, 0xFC, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x80, 0xFF, 0x1F, 0xE0, 0x7F, 0x01, 0xF8, 0x3F, 0x80, 0x3F, 0x0F, 0xC0,
  0x0F, 0xC7, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0x7C, 0xFC, 0x00, 0x1F, 0x3F,
  0x00, 0x07, 0xCF, 0xC0, 0x01, 0xF7, 0xE0, 0x00, 0x7D, 0xF8, 0x00, 0x3F,
  0x7E, 0x00, 0x0F, 0xDF, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0xFF, 0xF0, 0x00,
  0x3E, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x07, 0xEF, 0xC0, 0x03, 0xF3, 0xF0,
  0x00, 0xFC, 0x7C, 0x00, 0x7F, 0x1F, 0x80, 0x1F, 0x87, 0xE0, 0x0F, 0xE1,
  0xFC, 0x07, 0xF0, 0x3F, 0xCF, 0xF8, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF,
  0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x3E, 0x3F,
  0xE0, 0xFC, 0x0F, 0xC1, 0xF8, 0x1F, 0x83, 0xF0, 0x1F, 0x07, 0xC0, 0x3E,
  0x0F, 0x80, 0xFC, 0x3F, 0x01, 0xF8, 0x7E, 0x03, 0xF0, 0xF8, 0x0F, 0xC1,
  0xF0, 0x3F, 0x83, 0xE1, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F,
  0xFF, 0x80, 0x7F, 0xFC, 0x01, 0xF8, 0xFC, 0x03, 0xF0, 0xF8, 0x07, 0xE1,
  0xF0, 0x0F, 0x83, 0xF0, 0x1F, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0xFC, 0x0F,
  0xC1, 0xF0, 0x1F, 0x83, 0xE0, 0x1F, 0x07, 0xC0, 0x3F, 0x1F, 0x80, 0x7E,
  0x3F, 0x00, 0xFC, 0x7C, 0x00, 0xFC, 0x00, 0x03, 0x00, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0x1F, 0x01,
  0xF8, 0x06, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC2, 0x00, 0x3F, 0x07,
  0x00, 0x7E, 0x0F, 0xC7, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xE0,
  0xF8, 0x01, 0xF8, 0x3E, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x87, 0xE0, 0x07,
  0xC1, 0xF8, 0x01, 0xF0, 0x7C, 0x00, 0xFC, 0x1F, 0x00, 0x3F, 0x0F, 0xC0,
  0x0F, 0xC3, 0xF0, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x7E, 0x1F,
  0x80, 0x1F, 0x87, 0xE0, 0x07, 0xC1, 0xF8, 0x01, 0xF0, 0x7C, 0x00, 0xFC,
  0x1F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xE0, 0xFC, 0x00,
  0xF8, 0x3E, 0x00, 0x7E, 0x0F, 0x80, 0x1F, 0x83, 0xE0, 0x07, 0xC0, 0xF8,
  0x03, 0xF0, 0x3E, 0x00, 0xFC, 0x0F, 0xC0, 0x7E, 0x03, 0xFC, 0x7F, 0x80,
  0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xF0,
  0x00, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x7C, 0xFC, 0x00,
  0xFC, 0xFC, 0x00, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF0, 0x7C, 0x03,
  0xF0, 0x7C, 0x03, 0xF0, 0x7C, 0x07, 0xE0, 0x7C, 0x07, 0xE0, 0x7C, 0x07,
  0xC0, 0x7C, 0x0F, 0xC0, 0x7C, 0x0F, 0x80, 0x7C, 0x1F, 0x80, 0x7C, 0x1F,
  0x00, 0x7C, 0x3F, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x7E, 0x00, 0x7C, 0x7C,
  0x00, 0x7C, 0xFC, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x3D, 0xF0,
  0x00, 0x3D, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0xF8, 0x00, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0x80, 0x3F, 0xF8, 0x01,
  0xF8, 0x03, 0xEF, 0x80, 0x3F, 0x80, 0x7E, 0xF8, 0x03, 0xF8, 0x07, 0xCF,
  0x80, 0x7F, 0x80, 0xFC, 0xF8, 0x07, 0xF8, 0x0F, 0xCF, 0x80, 0xFF, 0x80,
  0xF8, 0xF8, 0x0F, 0xF8, 0x1F, 0x8F, 0x80, 0xFF, 0x81, 0xF0, 0xF8, 0x1F,
  0xF8, 0x3F, 0x0F, 0x81, 0xEF, 0x83, 0xE0, 0xF8, 0x3E, 0xF8, 0x3E, 0x0F,
  0x83, 0xCF, 0x87, 0xE0, 0xF8, 0x7C, 0xF8, 0x7C, 0x0F, 0x87, 0xCF, 0x8F,
  0xC0, 0xF8, 0x78, 0xF8, 0xF8, 0x0F, 0x8F, 0x8F, 0x8F, 0x80, 0xF8, 0xF0,
  0xF9, 0xF0, 0x0F, 0x9F, 0x0F, 0x9F, 0x00, 0xF9, 0xF0, 0xFB, 0xF0, 0x0F,
  0xBE, 0x0F, 0xBE, 0x00, 0xFB, 0xE0, 0xFB, 0xE0, 0x07, 0xBC, 0x0F, 0xFC,
  0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x7F, 0x80,
  0x7F, 0x80, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x3F,
  0x00, 0x1F, 0x01, 0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x01, 0xF8, 0x3F, 0x00,
  0x03, 0xE1, 0xF8, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x3F, 0x3F, 0x00, 0x00,
  0x7D, 0xF8, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x03, 0xF7, 0xE0, 0x00,
  0x1F, 0x9F, 0x80, 0x00, 0xFC, 0x3E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1F,
  0x83, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xE0, 0x1F, 0x00, 0x1F, 0x80,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x3F, 0x80, 0x0F,
  0xC0, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xE7, 0xC0, 0x1F, 0x9F, 0x00, 0xFC,
  0x7C, 0x07, 0xE1, 0xF8, 0x1F, 0x87, 0xE0, 0xFC, 0x0F, 0x83, 0xE0, 0x3E,
  0x1F, 0x80, 0xF8, 0xFC, 0x03, 0xE3, 0xE0, 0x0F, 0xDF, 0x80, 0x1F, 0x7C,
  0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC,
  0x00, 0xF0, 0x7C, 0x3E, 0x1F, 0x0F, 0x83, 0xC1, 0xE0, 0xF8, 0x7C, 0x3E,
  0x1F, 0x0F, 0x83, 0xC1, 0xE0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x83, 0xC1,
  0xE0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x83, 0xC1, 0xE0, 0xF8, 0x7C, 0x3E,
  0x1F, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x07, 0xFE, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x01, 0xFF, 0x00, 0xFF, 0xC0,
  0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00,
  0x3C, 0xF0, 0x03, 0xE7, 0x80, 0x1E, 0x3E, 0x01, 0xF0, 0xF0, 0x0F, 0x07,
  0x80, 0xF0, 0x3E, 0x0F, 0x80, 0xF0, 0x78, 0x07, 0x87, 0xC0, 0x3E, 0x3C,
  0x00, 0xF3, 0xE0, 0x07, 0xBE, 0x00, 0x3F, 0xE0, 0x00, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFC, 0xFC, 0x7C, 0x3E, 0x3E, 0x1E, 0x0F,
  0x00, 0xF0, 0x04, 0x0F, 0xF1, 0xE0, 0x7F, 0xE7, 0x83, 0xFF, 0xFE, 0x1F,
  0xFF, 0xF8, 0x7E, 0x1F, 0xE3, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x7E, 0x03,
  0xF1, 0xF8, 0x0F, 0xC7, 0xC0, 0x3F, 0x3F, 0x00, 0xF8, 0xFC, 0x03, 0xE3,
  0xF0, 0x0F, 0x8F, 0x80, 0x7E, 0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xE0,
  0x3F, 0x0F, 0x81, 0xFC, 0x3F, 0x07, 0xF0, 0xFC, 0x7F, 0x83, 0xFF, 0xFE,
  0x07, 0xFE, 0xF8, 0x1F, 0xF3, 0xE0, 0x3F, 0x8F, 0x80, 0x01, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x1E,
  0x00, 0x7C, 0xFE, 0x03, 0xEF, 0xFC, 0x0F, 0xBF, 0xF8, 0x3F, 0xFF, 0xE0,
  0xFE, 0x1F, 0x87, 0xF0, 0x3E, 0x1F, 0x80, 0xF8, 0x7E, 0x03, 0xF1, 0xF0,
  0x0F, 0x87, 0xC0, 0x3E, 0x3F, 0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xE0, 0x1F,
  0x8F, 0x80, 0x7E, 0x3E, 0x01, 0xF1, 0xF8, 0x0F, 0xC7, 0xE0, 0x3F, 0x1F,
  0x81, 0xF8, 0x7E, 0x07, 0xE3, 0xFC, 0x3F, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xE0, 0xF3, 0xFF, 0x03, 0xC7, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0xF0,
  0x7F, 0xFC, 0x3F, 0xFE, 0x1F, 0xFF, 0x87, 0xE0, 0x43, 0xF0, 0x00, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xF0, 0x10, 0xFE, 0x1C, 0x1F, 0xFF, 0x07, 0xFF, 0xC0, 0xFF,
  0xF0, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0xF8, 0xFC, 0x03, 0xFC,
  0xF8, 0x07, 0xFE, 0xF8, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0x87,
  0xF8, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0x7E, 0x03,
  0xF0, 0x7C, 0x03, 0xE0, 0xFC, 0x03, 0xE0, 0xFC, 0x03, 0xE0, 0xF8, 0x03,
  0xE0, 0xF8, 0x07, 0xE0, 0xF8, 0x07, 0xC0, 0xF8, 0x07, 0xC0, 0xF8, 0x0F,
  0xC0, 0xF8, 0x0F, 0xC0, 0xF8, 0x1F, 0xC0, 0xFC, 0x3F, 0x80, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0x80, 0x7F, 0xEF, 0x80, 0x3F, 0x8F, 0x80, 0x00, 0x7E,
  0x00, 0x3F, 0xF0, 0x1F, 0xFF, 0x07, 0xFF, 0xE1, 0xFC, 0x7E, 0x3F, 0x07,
  0xCF, 0xC0, 0xF9, 0xF0, 0x1F, 0x7E, 0x07, 0xEF, 0x81, 0xF9, 0xF0, 0xFF,
  0x7F, 0xFF, 0xCF, 0xFF, 0xF1, 0xFF, 0xF8, 0x3F, 0xE0, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x70,
  0xFF, 0xFE, 0x1F, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00,
  0x7E, 0x20, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0x00,
  0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x01, 0x00, 0xFF,
  0x1E, 0x01, 0xFF, 0x9E, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xE1,
  0xFE, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0x80,
  0xFC, 0x1F, 0x00, 0xFC, 0x3F, 0x00, 0xF8, 0x3F, 0x00, 0xF8, 0x3E, 0x00,
  0xF8, 0x3E, 0x01, 0xF8, 0x3E, 0x01, 0xF0, 0x3E, 0x03, 0xF0, 0x3E, 0x03,
  0xF0, 0x3E, 0x07, 0xF0, 0x3F, 0x0F, 0xF0, 0x3F, 0x1F, 0xE0, 0x3F, 0xFF,
  0xE0, 0x1F, 0xFB, 0xE0, 0x1F, 0xF3, 0xE0, 0x0F, 0xE7, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0xC0, 0x3F, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFC,
  0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x3E, 0x01, 0xF3, 0xFC,
  0x1F, 0x7F, 0xE0, 0xFB, 0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0x87, 0xE3, 0xF8,
  0x1F, 0x1F, 0xC0, 0xF8, 0xFC, 0x07, 0xC7, 0xE0, 0x3E, 0x3E, 0x03, 0xF3,
  0xF0, 0x1F, 0x9F, 0x80, 0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x03,
  0xF3, 0xF0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x7E,
  0x03, 0xF3, 0xF0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x7E,
  0x00, 0x00, 0xE0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0xFC, 0x0F, 0xC0, 0xF8, 0x0F, 0x81,
  0xF8, 0x1F, 0x81, 0xF0, 0x1F, 0x01, 0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0x03,
  0xE0, 0x3E, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0x7C, 0x0F, 0xC0, 0xFC, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0x00, 0x01, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0x80,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x04, 0x1F, 0x03, 0xF0, 0x7E,
  0x0F, 0xC0, 0xF8, 0x3F, 0x01, 0xF0, 0x7C, 0x03, 0xE1, 0xF8, 0x0F, 0xC7,
  0xE0, 0x1F, 0x1F, 0x80, 0x3E, 0x7E, 0x00, 0x7D, 0xF8, 0x00, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x00,
  0x3F, 0x7E, 0x00, 0xFC, 0x7C, 0x01, 0xF0, 0xFC, 0x03, 0xE1, 0xF8, 0x07,
  0xC1, 0xF0, 0x1F, 0x83, 0xF0, 0x3F, 0x07, 0xE0, 0x7C, 0x07, 0xE0, 0xF8,
  0x0F, 0xC1, 0xF0, 0x0F, 0x80, 0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0,
  0x1F, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x3C, 0x03, 0xCF, 0xF0, 0x7F, 0x83, 0xEF, 0xFC,
  0xFF, 0xC1, 0xFF, 0xFE, 0x7F, 0xF0, 0xF7, 0xFF, 0xFF, 0xF8, 0x7F, 0x0F,
  0xF0, 0x7C, 0x7F, 0x07, 0xF8, 0x3E, 0x3F, 0x01, 0xF8, 0x1F, 0x1F, 0x81,
  0xF8, 0x0F, 0x8F, 0x80, 0xFC, 0x07, 0xC7, 0xC0, 0x7C, 0x07, 0xE7, 0xE0,
  0x3E, 0x03, 0xF3, 0xF0, 0x1F, 0x01, 0xF1, 0xF0, 0x1F, 0x80, 0xF8, 0xF8,
  0x0F, 0x80, 0x7C, 0x7C, 0x07, 0xC0, 0x7E, 0x7E, 0x03, 0xE0, 0x3E, 0x3E,
  0x01, 0xF0, 0x1F, 0x1F, 0x01, 0xF8, 0x0F, 0x8F, 0x80, 0xF8, 0x07, 0xCF,
  0xC0, 0x7C, 0x07, 0xE7, 0xE0, 0x3E, 0x03, 0xE3, 0xE0, 0x1F, 0x01, 0xF1,
  0xF0, 0x1F, 0x80, 0xF8, 0xF8, 0x0F, 0x80, 0xFC, 0x00, 0x00, 0x03, 0xE0,
  0x0F, 0x1F, 0xE0, 0x7D, 0xFF, 0x81, 0xFF, 0xFF, 0x07, 0xBF, 0xFC, 0x1F,
  0xC3, 0xF0, 0xFE, 0x07, 0xC3, 0xF8, 0x1F, 0x0F, 0xC0, 0x7C, 0x3F, 0x01,
  0xF0, 0xF8, 0x0F, 0xC7, 0xE0, 0x3F, 0x1F, 0x80, 0xF8, 0x7C, 0x03, 0xE1,
  0xF0, 0x0F, 0x87, 0xC0, 0x7E, 0x3F, 0x01, 0xF8, 0xF8, 0x07, 0xC3, 0xE0,
  0x1F, 0x0F, 0x80, 0xFC, 0x7E, 0x03, 0xF1, 0xF8, 0x0F, 0x87, 0xC0, 0x3E,
  0x1F, 0x00, 0xF8, 0xFC, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0xF0, 0x07,
  0xFF, 0xC0, 0xFF, 0xFC, 0x1F, 0xFF, 0xE1, 0xF8, 0x7E, 0x3F, 0x03, 0xF7,
  0xE0, 0x3F, 0x7E, 0x03, 0xF7, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xEF, 0x80, 0x7E, 0xF8, 0x07,
  0xEF, 0x80, 0x7C, 0xF8, 0x0F, 0xCF, 0xC1, 0xF8, 0xFE, 0x3F, 0x87, 0xFF,
  0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x79, 0xFE, 0x00, 0x7D, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF0, 0x0F, 0xE1, 0xF8, 0x0F, 0xE0, 0x7C, 0x07, 0xE0, 0x3E, 0x03, 0xF0,
  0x1F, 0x81, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0xFC, 0x03, 0xE0, 0x7C,
  0x01, 0xF0, 0x3E, 0x01, 0xF8, 0x1F, 0x00, 0xFC, 0x0F, 0x80, 0x7C, 0x0F,
  0xC0, 0x7E, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0x80,
  0xFE, 0x3F, 0x80, 0xFF, 0xFF, 0xC0, 0x7D, 0xFF, 0xC0, 0x3E, 0xFF, 0xC0,
  0x1F, 0x3F, 0x80, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0xF0, 0x04, 0x0F, 0xF1, 0xE0, 0x7F, 0xE7, 0x83, 0xFF,
  0xFE, 0x1F, 0xFF, 0xF8, 0x7E, 0x1F, 0xE3, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC,
  0x7E, 0x03, 0xF1, 0xF8, 0x0F, 0xC7, 0xC0, 0x3E, 0x3F, 0x00, 0xF8, 0xFC,
  0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x7E, 0x3E, 0x01, 0xF0, 0xF8, 0x07,
  0xC3, 0xE0, 0x3F, 0x0F, 0x80, 0xFC, 0x3E, 0x07, 0xF0, 0xFC, 0x3F, 0x83,
  0xFF, 0xFE, 0x07, 0xFE, 0xF8, 0x1F, 0xF3, 0xE0, 0x3F, 0x9F, 0x80, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC1, 0xE7, 0xE0, 0xFB, 0xF8,
  0x3E, 0xFE, 0x0F, 0xFF, 0x83, 0xFE, 0x41, 0xFE, 0x00, 0x7F, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0xFF, 0x1F,
  0xCF, 0x87, 0xE0, 0x21, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF2, 0x00, 0xFC, 0xE0,
  0x7E, 0x3F, 0xFF, 0x8F, 0xFF, 0xC3, 0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0x01,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x4F, 0xFF,
  0x3F, 0xFE, 0xFF, 0xFD, 0xFF, 0xF8, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07,
  0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF8, 0x43,
  0xFF, 0x07, 0xFE, 0x07, 0xFC, 0x07, 0xF8, 0x00, 0x1F, 0x80, 0xFC, 0x7C,
  0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x7E, 0x3F, 0x01, 0xF8, 0xFC, 0x07,
  0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x3E, 0x03, 0xF1, 0xF8, 0x0F, 0x87,
  0xE0, 0x3E, 0x1F, 0x00, 0xF8, 0x7C, 0x03, 0xE1, 0xF0, 0x1F, 0x8F, 0xC0,
  0x7C, 0x3E, 0x03, 0xF0, 0xF8, 0x0F, 0xC3, 0xE0, 0x7F, 0x0F, 0x81, 0xFC,
  0x3F, 0x1F, 0xE0, 0xFF, 0xF7, 0x83, 0xFF, 0x9E, 0x07, 0xFC, 0xF8, 0x0F,
  0xE3, 0xE0, 0xFC, 0x01, 0xFB, 0xE0, 0x1F, 0x9F, 0x00, 0xF8, 0xF8, 0x0F,
  0xC7, 0xC0, 0x7C, 0x3E, 0x07, 0xE1, 0xF0, 0x3E, 0x0F, 0x83, 0xF0, 0x7C,
  0x1F, 0x03, 0xE1, 0xF8, 0x1F, 0x0F, 0x80, 0xF8, 0xFC, 0x07, 0xC7, 0xC0,
  0x1E, 0x7E, 0x00, 0xF3, 0xE0, 0x07, 0x9F, 0x00, 0x3D, 0xF0, 0x01, 0xEF,
  0x80, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0xF8, 0x0F, 0xC0, 0x7F, 0xF0, 0x3F, 0x81,
  0xFB, 0xE0, 0x7F, 0x03, 0xE7, 0xC1, 0xFE, 0x07, 0xCF, 0x83, 0xFC, 0x1F,
  0x1F, 0x07, 0xF8, 0x3E, 0x3E, 0x1E, 0xF0, 0xFC, 0x7C, 0x3D, 0xE1, 0xF0,
  0xF8, 0xFB, 0xC7, 0xE1, 0xF1, 0xE7, 0x8F, 0x83, 0xE7, 0xCF, 0x1F, 0x07,
  0xCF, 0x1E, 0x7C, 0x0F, 0x9E, 0x3C, 0xF8, 0x1F, 0x78, 0x7B, 0xE0, 0x3E,
  0xF0, 0xF7, 0xC0, 0x7F, 0xE1, 0xEF, 0x80, 0xFF, 0x83, 0xFE, 0x01, 0xFF,
  0x07, 0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x07, 0xF8, 0x1F, 0xE0, 0x0F, 0xF0,
  0x3F, 0x80, 0x1F, 0xC0, 0x7F, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x7E, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x3F, 0x81, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x80,
  0x3E, 0x1F, 0x80, 0x1F, 0x1F, 0x80, 0x0F, 0xCF, 0x80, 0x03, 0xEF, 0xC0,
  0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x07, 0xFF, 0x00, 0x03, 0xEF, 0x80, 0x03, 0xE7, 0xE0, 0x03, 0xF1,
  0xF0, 0x03, 0xF0, 0xF8, 0x01, 0xF0, 0x7E, 0x01, 0xF8, 0x1F, 0x01, 0xF8,
  0x0F, 0x81, 0xF8, 0x07, 0xE0, 0x03, 0xF0, 0x07, 0xE0, 0x3E, 0x01, 0xF8,
  0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x0F, 0xC0, 0x1F, 0x01, 0xF0, 0x03, 0xE0,
  0x7E, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x83, 0xF0, 0x01, 0xF0, 0x7C, 0x00,
  0x1E, 0x1F, 0x80, 0x03, 0xC3, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x9F,
  0x00, 0x01, 0xF3, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xDF, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xE0,
  0x7F, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF0,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x01,
  0xFF, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x1F, 0xF0, 0x07, 0xF8, 0x01, 0xF0,
  0x00, 0x7F, 0x00, 0x3F, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7F,
  0x80, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x7F,
  0x00, 0x7F, 0xC0, 0x0F, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x01,
  0xF0, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x0F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF0, 0x03, 0xE0, 0x00, 0x3F, 0xC0, 0x0B, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0x40, 0x0F, 0xF2, 0x00, 0x04, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_SemiBoldItalic45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 13, 33, 12, 0, -32 },
  { 55, 16, 11, 18, 4, -32 },
  { 77, 26, 32, 26, 1, -32 },
  { 181, 22, 37, 23, 1, -34 },
  { 283, 30, 33, 35, 3, -33 },
  { 407, 26, 33, 28, 1, -33 },
  { 515, 7, 11, 11, 5, -32 },
  { 525, 16, 39, 14, 1, -32 },
  { 603, 15, 40, 14, -3, -33 },
  { 678, 19, 20, 22, 4, -34 },
  { 726, 21, 22, 24, 2, -27 },
  { 784, 10, 11, 12, -2, -5 },
  { 798, 12, 4, 14, 1, -14 },
  { 804, 7, 7, 12, 0, -6 },
  { 811, 23, 32, 17, -2, -32 },
  { 903, 20, 33, 23, 2, -33 },
  { 986, 15, 32, 23, 5, -32 },
  { 1046, 23, 33, 23, -1, -33 },
  { 1141, 22, 33, 23, 0, -33 },
  { 1232, 22, 32, 23, 0, -32 },
  { 1320, 22, 32, 23, 1, -32 },
  { 1408, 21, 33, 23, 2, -33 },
  { 1495, 22, 32, 23, 2, -32 },
  { 1583, 22, 33, 23, 1, -33 },
  { 1674, 21, 33, 23, 1, -33 },
  { 1761, 11, 26, 12, 0, -25 },
  { 1797, 13, 31, 12, -2, -25 },
  { 1848, 21, 22, 24, 2, -27 },
  { 1906, 20, 13, 24, 2, -22 },
  { 1939, 21, 22, 24, 2, -27 },
  { 1997, 17, 34, 18, 3, -33 },
  { 2070, 32, 36, 35, 2, -32 },
  { 2214, 25, 32, 25, -3, -32 },
  { 2314, 24, 32, 25, 1, -32 },
  { 2410, 24, 33, 24, 2, -33 },
  { 2509, 25, 32, 27, 1, -32 },
  { 2609, 22, 32, 22, 1, -32 },
  { 2697, 22, 32, 21, 1, -32 },
  { 2785, 26, 33, 28, 2, -33 },
  { 2893, 28, 32, 28, 1, -32 },
  { 3005, 19, 32, 15, -1, -32 },
  { 3081, 20, 41, 13, -7, -32 },
  { 3184, 27, 32, 24, 1, -32 },
  { 3292, 17, 32, 20, 1, -32 },
  { 3360, 35, 32, 36, 1, -32 },
  { 3500, 30, 32, 30, 1, -32 },
  { 3620, 26, 33, 29, 2, -33 },
  { 3728, 24, 32, 24, 1, -32 },
  { 3824, 26, 41, 29, 2, -33 },
  { 3958, 23, 32, 25, 1, -32 },
  { 4050, 23, 33, 21, 0, -33 },
  { 4145, 21, 32, 21, 4, -32 },
  { 4229, 26, 32, 28, 3, -32 },
  { 4333, 24, 32, 24, 4, -32 },
  { 4429, 36, 32, 36, 4, -32 },
  { 4573, 30, 32, 23, -3, -32 },
  { 4693, 22, 32, 22, 4, -32 },
  { 4781, 25, 32, 21, -1, -32 },
  { 4881, 18, 39, 14, -1, -32 },
  { 4969, 9, 32, 17, 5, -32 },
  { 5005, 18, 39, 14, -3, -32 },
  { 5093, 21, 20, 23, 1, -32 },
  { 5146, 17, 3, 17, -4, 4 },
  { 5153, 8, 7, 13, 7, -34 },
  { 5160, 22, 25, 24, 2, -25 },
  { 5229, 22, 34, 24, 1, -34 },
  { 5323, 18, 25, 19, 2, -25 },
  { 5380, 24, 34, 24, 2, -34 },
  { 5482, 19, 25, 22, 2, -25 },
  { 5542, 25, 45, 14, -5, -34 },
  { 5683, 24, 36, 24, 0, -25 },
  { 5791, 21, 34, 24, 1, -34 },
  { 5881, 12, 34, 12, 1, -34 },
  { 5932, 19, 45, 12, -6, -34 },
  { 6039, 23, 34, 22, 1, -34 },
  { 6137, 13, 34, 12, 0, -34 },
  { 6193, 33, 25, 36, 1, -25 },
  { 6297, 22, 25, 24, 0, -25 },
  { 6366, 20, 25, 24, 2, -25 },
  { 6429, 25, 36, 24, -2, -25 },
  { 6542, 22, 36, 24, 2, -25 },
  { 6641, 18, 25, 17, 1, -25 },
  { 6698, 18, 25, 19, 0, -25 },
  { 6755, 15, 30, 15, 2, -30 },
  { 6812, 22, 24, 24, 2, -24 },
  { 6878, 21, 24, 20, 2, -24 },
  { 6941, 31, 24, 31, 3, -24 },
  { 7034, 25, 24, 21, -2, -24 },
  { 7109, 27, 35, 20, -4, -24 },
  { 7228, 20, 24, 18, -1, -24 },
  { 7288, 18, 39, 16, 0, -32 },
  { 7376, 4, 44, 22, 9, -34 },
  { 7398, 17, 39, 16, -2, -32 },
  { 7481, 21, 7, 24, 2, -19 },
};

const GFXfont NotoSans_SemiCondensed_SemiBoldItalic45pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_SemiBoldItalic45pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_SemiBoldItalic45pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC45PT7B_H_
