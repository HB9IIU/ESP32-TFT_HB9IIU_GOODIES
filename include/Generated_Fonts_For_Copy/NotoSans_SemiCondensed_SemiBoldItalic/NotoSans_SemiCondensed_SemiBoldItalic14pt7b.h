#ifndef _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC14PT7B_H_
#define _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC14PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-SemiBoldItalic.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_SemiBoldItalic14pt7bBitmaps[] PROGMEM = {
  0x00, 0x33, 0x22, 0x66, 0x40, 0xCC, 0x7A, 0xD5, 0xA0, 0x0B, 0x1A, 0x12,
  0x7F, 0x34, 0x24, 0xFE, 0x28, 0x48, 0x58, 0x08, 0x10, 0xFB, 0x46, 0x87,
  0x07, 0x0A, 0x9D, 0xF8, 0x81, 0x00, 0x71, 0xE9, 0xA4, 0x92, 0x8B, 0xFF,
  0x54, 0x5A, 0x69, 0x25, 0xA3, 0x80, 0x1C, 0x36, 0x36, 0x3C, 0x18, 0x79,
  0x4F, 0xCE, 0xCE, 0x7B, 0x69, 0x60, 0x18, 0x88, 0xC6, 0x21, 0x18, 0xC6,
  0x10, 0xC0, 0x10, 0xC6, 0x31, 0x8C, 0x42, 0x31, 0x19, 0x80, 0x18, 0x4F,
  0x0F, 0x71, 0x60, 0x30, 0xCF, 0xFF, 0x30, 0xC0, 0x2D, 0x60, 0x7F, 0xF0,
  0x02, 0x0C, 0x10, 0x61, 0x82, 0x0C, 0x10, 0x61, 0x80, 0x1C, 0x6D, 0x9B,
  0x34, 0x68, 0xF1, 0x66, 0x48, 0xF0, 0x19, 0xFE, 0x21, 0x18, 0xC6, 0x23,
  0x00, 0x3C, 0xCC, 0x18, 0x30, 0xC3, 0x0C, 0x30, 0xC1, 0xF8, 0x3C, 0x4C,
  0x18, 0x33, 0x87, 0x83, 0x06, 0x9D, 0xF0, 0x06, 0x1C, 0x71, 0xA2, 0xC9,
  0xBF, 0xFE, 0x08, 0x30, 0x3E, 0x7C, 0x81, 0x07, 0xC1, 0x81, 0x06, 0x9D,
  0xF0, 0x1D, 0xC4, 0x30, 0xFB, 0x38, 0xA2, 0xDB, 0xC0, 0x7F, 0x18, 0x30,
  0xC1, 0x06, 0x08, 0x30, 0xC1, 0x80, 0x1C, 0x6C, 0x99, 0xB3, 0x8F, 0x91,
  0x62, 0xCC, 0xF0, 0x3C, 0x4D, 0x9B, 0x36, 0x6F, 0x81, 0x06, 0x99, 0xE0,
  0x2C, 0x00, 0x36, 0x13, 0x00, 0x00, 0x26, 0x4C, 0x04, 0x33, 0xB8, 0xE0,
  0xE0, 0xC0, 0xFC, 0x00, 0x3F, 0x83, 0x07, 0x07, 0x1D, 0xCC, 0x00, 0xFC,
  0xC6, 0x33, 0x33, 0x00, 0xC6, 0x00, 0x1F, 0x0C, 0x64, 0x0B, 0x7B, 0x92,
  0xE9, 0xAA, 0x4A, 0xFC, 0x92, 0x30, 0x07, 0xC0, 0x06, 0x0E, 0x0A, 0x1A,
  0x12, 0x32, 0x3F, 0x63, 0x63, 0xC3, 0x3E, 0x37, 0x33, 0x22, 0x7C, 0x6E,
  0x66, 0x46, 0x4E, 0xFC, 0x1E, 0xE5, 0x86, 0x0C, 0x18, 0x30, 0x60, 0xC8,
  0xF0, 0x3E, 0x37, 0x33, 0x23, 0x63, 0x63, 0x63, 0x66, 0x5C, 0xF8, 0x3E,
  0x60, 0xC1, 0x07, 0xCF, 0x98, 0x20, 0x41, 0xF0, 0x3E, 0x60, 0xC1, 0x07,
  0xCF, 0x98, 0x30, 0x41, 0x80, 0x1F, 0x72, 0x60, 0xC0, 0xC0, 0xCE, 0xC6,
  0xC6, 0xE4, 0x7C, 0x31, 0x98, 0xCC, 0x44, 0x27, 0xF3, 0xF9, 0x8C, 0xC4,
  0x46, 0x63, 0x00, 0x7C, 0xC3, 0x0C, 0x20, 0x86, 0x18, 0x63, 0xC0, 0x0C,
  0x30, 0xC2, 0x08, 0x61, 0x86, 0x10, 0xC3, 0x3C, 0xE0, 0x33, 0x99, 0x8D,
  0x85, 0x87, 0x83, 0xC1, 0xB0, 0x98, 0x4C, 0x63, 0x00, 0x31, 0x8C, 0x46,
  0x31, 0x88, 0x47, 0xC0, 0x38, 0x67, 0x1C, 0xE3, 0x94, 0xF6, 0x94, 0xD6,
  0x9A, 0xB2, 0x76, 0x4C, 0xD9, 0x90, 0x30, 0xCE, 0x23, 0x98, 0xA6, 0x6D,
  0x9B, 0x46, 0x51, 0x1C, 0x47, 0x31, 0xC0, 0x3E, 0x76, 0x63, 0xC3, 0xC3,
  0xC3, 0xC6, 0xC6, 0xCC, 0x78, 0x3E, 0x37, 0x33, 0x23, 0x66, 0x7C, 0x60,
  0x40, 0x40, 0xC0, 0x3E, 0x76, 0x63, 0xC3, 0xC3, 0xC3, 0xC6, 0xC6, 0xCC,
  0x78, 0x18, 0x0C, 0x3E, 0x36, 0x33, 0x22, 0x66, 0x7C, 0x6C, 0x4C, 0x4C,
  0xC6, 0x3E, 0x6D, 0x83, 0x03, 0x03, 0x03, 0x06, 0x9D, 0xF0, 0xFE, 0x60,
  0xC1, 0x82, 0x04, 0x18, 0x30, 0x60, 0x80, 0x63, 0x63, 0x42, 0x46, 0xC6,
  0xC6, 0xC6, 0xCC, 0xCC, 0x78, 0xC3, 0xC6, 0xC4, 0xCC, 0x48, 0x58, 0x50,
  0x70, 0x60, 0x60, 0xC6, 0x3C, 0x66, 0xCE, 0x4C, 0xEC, 0xDE, 0xCD, 0x68,
  0xF7, 0x8E, 0x70, 0xE7, 0x0E, 0x60, 0x11, 0x8D, 0x86, 0xC1, 0xC0, 0xC0,
  0xE0, 0x50, 0x6C, 0x66, 0x63, 0x00, 0xC6, 0x99, 0x33, 0xC7, 0x0E, 0x18,
  0x30, 0x60, 0xC0, 0x3E, 0x0C, 0x30, 0x61, 0x86, 0x18, 0x30, 0xC1, 0xF8,
  0x39, 0x08, 0x46, 0x31, 0x08, 0xC6, 0x31, 0xC0, 0xC9, 0x26, 0xD9, 0x24,
  0x3C, 0x20, 0x86, 0x18, 0x41, 0x04, 0x30, 0xC2, 0x38, 0x08, 0x30, 0xF1,
  0x26, 0x58, 0xC0, 0xF8, 0xC8, 0x80, 0x1A, 0x7D, 0x9B, 0x34, 0x59, 0x93,
  0x3E, 0x30, 0x60, 0xC1, 0x63, 0xEC, 0xD9, 0xB3, 0x45, 0xDB, 0xE0, 0x3B,
  0xF1, 0x88, 0x43, 0x5E, 0x03, 0x03, 0x03, 0x1A, 0x3E, 0x66, 0x66, 0x44,
  0xCC, 0x4C, 0x7C, 0x39, 0xEC, 0xE6, 0xF2, 0x0C, 0xBC, 0x03, 0x07, 0x0C,
  0x0E, 0x1E, 0x08, 0x18, 0x18, 0x18, 0x10, 0x30, 0x30, 0x30, 0xE0, 0x1A,
  0x7D, 0x9B, 0x34, 0x59, 0x93, 0x3E, 0x0D, 0x33, 0xE0, 0x30, 0x60, 0xC1,
  0x63, 0xEC, 0xD9, 0xB3, 0x45, 0x9B, 0x30, 0x13, 0x02, 0x26, 0x66, 0x4C,
  0xC0, 0x04, 0x30, 0x02, 0x08, 0x61, 0x86, 0x10, 0x43, 0x0C, 0x33, 0x80,
  0x30, 0x60, 0xC1, 0x12, 0x4D, 0x9E, 0x3C, 0x59, 0x9B, 0x30, 0x33, 0x32,
  0x26, 0x66, 0x4C, 0xC0, 0x2C, 0xC7, 0xFD, 0x99, 0xB3, 0x26, 0x44, 0x89,
  0xB3, 0x36, 0x66, 0x2C, 0x7D, 0x9B, 0x36, 0x68, 0xB3, 0x66, 0x31, 0xEC,
  0xE3, 0x8E, 0x2D, 0xBC, 0x16, 0x1F, 0x33, 0x33, 0x33, 0x23, 0x76, 0x7C,
  0x60, 0x60, 0xC0, 0x1A, 0x7D, 0x9B, 0x34, 0x59, 0x93, 0x3E, 0x0C, 0x10,
  0x60, 0x2C, 0xF6, 0x18, 0x61, 0x0C, 0x30, 0x39, 0xF6, 0x1C, 0x38, 0x69,
  0xBC, 0x67, 0xFC, 0xCC, 0x88, 0xE0, 0x47, 0x3C, 0xF3, 0x8A, 0x69, 0xBE,
  0x8E, 0x39, 0xB4, 0xF3, 0x8E, 0x30, 0x8C, 0xCE, 0xE7, 0x77, 0xEA, 0xB5,
  0x53, 0x39, 0x98, 0x33, 0x36, 0x16, 0x1C, 0x18, 0x3C, 0x6C, 0xE6, 0x23,
  0x23, 0x36, 0x36, 0x3C, 0x3C, 0x38, 0x18, 0x30, 0x20, 0xE0, 0x7D, 0xF1,
  0x8C, 0x21, 0x8C, 0x3E, 0x1C, 0x63, 0x0C, 0x33, 0x8E, 0x18, 0x61, 0x84,
  0x18, 0xFF, 0xFC, 0x18, 0xE1, 0x86, 0x10, 0x71, 0xCC, 0x30, 0x86, 0x38,
  0xE6, 0xF0,
};

const GFXglyph NotoSans_SemiCondensed_SemiBoldItalic14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 4, 10, 4, 0, -10 },
  { 6, 5, 4, 6, 1, -10 },
  { 9, 8, 10, 8, 0, -10 },
  { 19, 7, 12, 7, 0, -11 },
  { 30, 9, 10, 11, 1, -10 },
  { 42, 8, 10, 9, 0, -10 },
  { 52, 3, 4, 3, 1, -10 },
  { 54, 5, 12, 4, 0, -10 },
  { 62, 5, 12, 4, -1, -10 },
  { 70, 6, 6, 7, 1, -11 },
  { 75, 6, 6, 7, 1, -8 },
  { 80, 3, 4, 4, -1, -2 },
  { 82, 4, 2, 4, 0, -5 },
  { 83, 2, 2, 4, 0, -2 },
  { 84, 7, 10, 5, -1, -10 },
  { 93, 7, 10, 7, 0, -10 },
  { 102, 5, 10, 7, 1, -10 },
  { 109, 7, 10, 7, 0, -10 },
  { 118, 7, 10, 7, 0, -10 },
  { 127, 7, 10, 7, 0, -10 },
  { 136, 7, 10, 7, 0, -10 },
  { 145, 6, 10, 7, 1, -10 },
  { 153, 7, 10, 7, 1, -10 },
  { 162, 7, 10, 7, 0, -10 },
  { 171, 7, 10, 7, 0, -10 },
  { 180, 3, 8, 4, 0, -8 },
  { 183, 4, 10, 4, -1, -8 },
  { 188, 6, 7, 7, 1, -9 },
  { 194, 6, 4, 7, 1, -7 },
  { 197, 6, 7, 7, 1, -9 },
  { 203, 5, 10, 6, 1, -10 },
  { 210, 10, 11, 11, 1, -10 },
  { 224, 8, 10, 8, -1, -10 },
  { 234, 8, 10, 8, 0, -10 },
  { 244, 7, 10, 7, 1, -10 },
  { 253, 8, 10, 9, 0, -10 },
  { 263, 7, 10, 7, 0, -10 },
  { 272, 7, 10, 6, 0, -10 },
  { 281, 8, 10, 9, 1, -10 },
  { 291, 9, 10, 9, 0, -10 },
  { 303, 6, 10, 5, 0, -10 },
  { 311, 6, 13, 4, -2, -10 },
  { 321, 9, 10, 8, 0, -10 },
  { 333, 5, 10, 6, 0, -10 },
  { 340, 11, 10, 11, 0, -10 },
  { 354, 10, 10, 9, 0, -10 },
  { 367, 8, 10, 9, 1, -10 },
  { 377, 8, 10, 8, 0, -10 },
  { 387, 8, 12, 9, 1, -10 },
  { 399, 8, 10, 8, 0, -10 },
  { 409, 7, 10, 7, 0, -10 },
  { 418, 7, 10, 7, 1, -10 },
  { 427, 8, 10, 9, 1, -10 },
  { 437, 8, 10, 7, 1, -10 },
  { 447, 12, 10, 11, 1, -10 },
  { 462, 9, 10, 7, -1, -10 },
  { 474, 7, 10, 7, 1, -10 },
  { 483, 7, 10, 7, 0, -10 },
  { 492, 5, 12, 4, 0, -10 },
  { 500, 3, 10, 5, 1, -10 },
  { 504, 6, 12, 4, -1, -10 },
  { 513, 7, 6, 7, 0, -10 },
  { 519, 5, 1, 5, -1, 1 },
  { 520, 3, 3, 4, 2, -11 },
  { 522, 7, 8, 7, 0, -8 },
  { 529, 7, 11, 7, 0, -11 },
  { 539, 5, 8, 6, 1, -8 },
  { 544, 8, 11, 8, 0, -11 },
  { 555, 6, 8, 7, 1, -8 },
  { 561, 8, 14, 4, -2, -11 },
  { 575, 7, 11, 8, 0, -8 },
  { 585, 7, 11, 8, 0, -11 },
  { 595, 4, 11, 4, 0, -11 },
  { 601, 6, 14, 4, -2, -11 },
  { 612, 7, 11, 7, 0, -11 },
  { 622, 4, 11, 4, 0, -11 },
  { 628, 11, 8, 11, 0, -8 },
  { 639, 7, 8, 8, 0, -8 },
  { 646, 6, 8, 7, 1, -8 },
  { 652, 8, 11, 7, -1, -8 },
  { 663, 7, 11, 8, 0, -8 },
  { 673, 6, 8, 5, 0, -8 },
  { 679, 6, 8, 6, 0, -8 },
  { 685, 4, 9, 5, 1, -9 },
  { 690, 6, 8, 8, 1, -8 },
  { 696, 6, 8, 6, 1, -8 },
  { 702, 9, 8, 10, 1, -8 },
  { 711, 8, 8, 7, -1, -8 },
  { 719, 8, 11, 6, -1, -8 },
  { 730, 6, 8, 6, 0, -8 },
  { 736, 6, 12, 5, 0, -10 },
  { 745, 1, 14, 7, 3, -11 },
  { 747, 6, 12, 5, -1, -10 },
  { 756, 6, 2, 7, 1, -6 },
};

const GFXfont NotoSans_SemiCondensed_SemiBoldItalic14pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_SemiBoldItalic14pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_SemiBoldItalic14pt7bGlyphs,
  0x20, 0x7E, 19
};

#endif // _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC14PT7B_H_
