#ifndef _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC47PT7B_H_
#define _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC47PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-SemiBoldItalic.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_SemiBoldItalic47pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x7F, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x07, 0xC0,
  0x7E, 0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x08, 0x00, 0x7E, 0x3E,
  0xFC, 0x7D, 0xF0, 0xFB, 0xE1, 0xF7, 0xC7, 0xCF, 0x8F, 0x9E, 0x1F, 0x7C,
  0x3E, 0xF8, 0x79, 0xE0, 0xF3, 0xC3, 0xE7, 0x87, 0x8F, 0x0F, 0x00, 0x00,
  0x0F, 0x07, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x0F, 0x07,
  0x80, 0x03, 0xE1, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x0F, 0x07, 0x80, 0x01,
  0xE1, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x0F, 0x07, 0x80, 0x7F, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x80, 0x7C,
  0x3E, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x3E, 0x00,
  0x0F, 0x07, 0x80, 0x01, 0xE0, 0xF0, 0x0F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF8, 0x0F, 0x87, 0xC0, 0x01,
  0xE0, 0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xE0, 0xF0,
  0x00, 0x3C, 0x1E, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xF0, 0xF0, 0x00, 0x3C,
  0x1E, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFF, 0xC0,
  0x7F, 0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0x9C, 0x70, 0x3F,
  0x38, 0x00, 0x7C, 0x70, 0x00, 0xF8, 0xC0, 0x01, 0xF1, 0x80, 0x03, 0xF7,
  0x00, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFE,
  0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0D, 0xFC,
  0x00, 0x39, 0xF8, 0x00, 0x73, 0xF0, 0x00, 0xE7, 0xE0, 0x01, 0x8F, 0xC4,
  0x03, 0x1F, 0x8F, 0x0E, 0x7E, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x78, 0x07, 0xF8, 0x00, 0xF0, 0x1F, 0xF8, 0x01, 0xF0, 0x1F,
  0xFC, 0x01, 0xE0, 0x3E, 0x3C, 0x03, 0xC0, 0x3C, 0x3C, 0x07, 0xC0, 0x7C,
  0x3C, 0x07, 0x80, 0x78, 0x3C, 0x0F, 0x00, 0x78, 0x3C, 0x1F, 0x00, 0xF8,
  0x3C, 0x1E, 0x00, 0xF8, 0x7C, 0x3C, 0x00, 0xF0, 0x7C, 0x7C, 0x00, 0xF0,
  0x78, 0x78, 0x00, 0xF0, 0x78, 0xF0, 0x70, 0xF0, 0xF9, 0xF3, 0xFC, 0xF0,
  0xF1, 0xE7, 0xFE, 0xF9, 0xF3, 0xCF, 0xFE, 0xFF, 0xE7, 0xCF, 0xBE, 0x7F,
  0xC7, 0x9F, 0x1F, 0x7F, 0xCF, 0x1E, 0x1F, 0x1F, 0x1F, 0x3E, 0x1F, 0x00,
  0x1E, 0x3E, 0x1F, 0x00, 0x3C, 0x3C, 0x1F, 0x00, 0x7C, 0x3C, 0x1E, 0x00,
  0x78, 0x7C, 0x1E, 0x00, 0xF0, 0x7C, 0x3E, 0x01, 0xF0, 0x7C, 0x3E, 0x01,
  0xE0, 0x7C, 0x3C, 0x03, 0xC0, 0x7C, 0x7C, 0x07, 0xC0, 0x7C, 0x78, 0x07,
  0x80, 0x7F, 0xF8, 0x0F, 0x00, 0x3F, 0xF0, 0x1F, 0x00, 0x3F, 0xE0, 0x3E,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xCF, 0xC0, 0x03, 0xE0, 0xF8, 0x00,
  0x7C, 0x1F, 0x00, 0x1F, 0x83, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x1F,
  0x80, 0x0F, 0xC3, 0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x1F, 0x7F, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x7C, 0x3F, 0xFC, 0x1F, 0x8F, 0xDF, 0x83, 0xE3, 0xF1,
  0xF8, 0xFC, 0xFC, 0x3F, 0x1F, 0x1F, 0x03, 0xF7, 0xE7, 0xE0, 0x7F, 0xF8,
  0xFC, 0x07, 0xFF, 0x1F, 0x80, 0x7F, 0xC3, 0xF0, 0x0F, 0xF0, 0x7E, 0x00,
  0xFC, 0x0F, 0xC0, 0x7F, 0xC1, 0xFE, 0x3F, 0xF8, 0x1F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFE, 0x3F, 0x01, 0xFF, 0x07, 0xF0, 0x7E, 0xFD,
  0xF3, 0xE7, 0xCF, 0x9E, 0x7C, 0xF9, 0xF3, 0xC7, 0x8F, 0x00, 0x00, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07,
  0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8,
  0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x00,
  0x00, 0x72, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x20, 0x78,
  0x07, 0x07, 0x80, 0x7C, 0x78, 0x07, 0xF7, 0x80, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x07, 0xF8, 0x10, 0xFF, 0xC0, 0x1F,
  0xBC, 0x03, 0xF3, 0xE0, 0x7E, 0x3E, 0x01, 0xE1, 0xF0, 0x0C, 0x1F, 0x00,
  0x41, 0xE0, 0x00, 0x08, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0xC3, 0xF1,
  0xF8, 0x7E, 0x1F, 0x0F, 0xC3, 0xE0, 0xF8, 0x7C, 0x1F, 0x0F, 0x83, 0xE0,
  0x7F, 0xF7, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xE0, 0x08, 0x7D, 0xFB, 0xFF,
  0xEF, 0xDF, 0x18, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x07, 0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0xF0,
  0xFC, 0x3F, 0x07, 0xE3, 0xF0, 0x1F, 0x1F, 0x80, 0xF9, 0xF8, 0x07, 0xCF,
  0xC0, 0x3E, 0x7C, 0x01, 0xF7, 0xE0, 0x1F, 0xBF, 0x00, 0xFD, 0xF8, 0x07,
  0xEF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7D, 0xF8,
  0x07, 0xEF, 0x80, 0x3F, 0x7C, 0x01, 0xFB, 0xE0, 0x0F, 0x9F, 0x00, 0xFC,
  0xF8, 0x07, 0xE7, 0xC0, 0x7E, 0x3E, 0x03, 0xF1, 0xF0, 0x3F, 0x0F, 0xC3,
  0xF8, 0x7F, 0xBF, 0x81, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x3F, 0xF8, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x7F, 0x00, 0xFE, 0x01, 0xFE, 0x07,
  0xFE, 0x0F, 0xFE, 0x3F, 0xFE, 0x7F, 0xFC, 0xFF, 0x7C, 0x7C, 0xFC, 0x78,
  0xFC, 0x20, 0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01,
  0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x01, 0xF0, 0x7F, 0x01, 0xC0, 0x3F, 0x00, 0x80, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x38, 0x1F, 0xC0, 0x40,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x0F, 0xFC,
  0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x8C, 0x00, 0x7F, 0x1F, 0x0F, 0xFC, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x07, 0xBE, 0x00, 0x1F, 0xFC, 0x00, 0x7D, 0xF0,
  0x00, 0xF3, 0xE0, 0x03, 0xE7, 0xC0, 0x0F, 0x9F, 0x80, 0x3E, 0x3E, 0x00,
  0x78, 0x7C, 0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xF0, 0x1F, 0x07, 0xE0, 0x7C,
  0x0F, 0x80, 0xF8, 0x1F, 0x03, 0xE0, 0x3E, 0x0F, 0x80, 0xFC, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xF0, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0xFE,
  0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xFF,
  0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x84, 0x00, 0x7F, 0x0C, 0x01, 0xFC, 0x1F, 0x1F, 0xF8, 0x3F,
  0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x01, 0xFF,
  0xF8, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x04, 0x00, 0xF9,
  0xFE, 0x07, 0xEF, 0xFC, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE1, 0xFE, 0x1F,
  0x8F, 0xF0, 0x3F, 0x3F, 0x80, 0xFC, 0xFC, 0x03, 0xF3, 0xF0, 0x0F, 0xCF,
  0xC0, 0x3F, 0x3F, 0x00, 0xFC, 0xF8, 0x03, 0xE3, 0xE0, 0x1F, 0x8F, 0xC0,
  0x7E, 0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0xC1, 0xFC, 0xFE, 0x07, 0xFF, 0xF8,
  0x0F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x3F,
  0x9F, 0xC0, 0xFC, 0x1F, 0xC1, 0xF0, 0x1F, 0x87, 0xE0, 0x3F, 0x0F, 0xC0,
  0x7E, 0x1F, 0x80, 0xF8, 0x3F, 0x01, 0xF0, 0x3E, 0x07, 0xE0, 0x7E, 0x1F,
  0x80, 0x7E, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00,
  0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0xFE, 0x7F, 0x03, 0xF0, 0x7E, 0x0F,
  0xC0, 0x7E, 0x1F, 0x00, 0xFC, 0x7E, 0x00, 0xF8, 0xFC, 0x01, 0xF1, 0xF8,
  0x03, 0xE3, 0xF0, 0x0F, 0xC7, 0xE0, 0x1F, 0x8F, 0xC0, 0x7E, 0x1F, 0xC1,
  0xFC, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFC,
  0x07, 0xFF, 0xF8, 0x3F, 0x87, 0xE0, 0xFC, 0x0F, 0xC7, 0xE0, 0x3F, 0x1F,
  0x80, 0xFC, 0x7C, 0x03, 0xF3, 0xF0, 0x0F, 0xCF, 0xC0, 0x3F, 0x3F, 0x00,
  0xFC, 0xFC, 0x03, 0xF3, 0xF0, 0x1F, 0xCF, 0xC0, 0xFE, 0x3F, 0x87, 0xF8,
  0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x83, 0xFF, 0x7E, 0x0F, 0xF9, 0xF0, 0x0F,
  0xC7, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x03, 0x87, 0xFC, 0x0F,
  0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x00, 0x01,
  0xC0, 0xFC, 0x1F, 0x87, 0xF0, 0xFE, 0x0F, 0xC1, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x04, 0x03, 0xE0, 0xFC, 0x1F, 0x87, 0xF0, 0xFE, 0x0F, 0x80, 0x40,
  0x00, 0x00, 0x70, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x3F, 0x80, 0xFC, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x07,
  0xE0, 0x7E, 0x03, 0xF0, 0x1F, 0x01, 0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xC0,
  0x3C, 0x03, 0xE0, 0x1E, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x70, 0x00,
  0x07, 0xC0, 0x00, 0x7F, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xFE,
  0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x3F,
  0xC0, 0x00, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x07,
  0xFF, 0x00, 0x3F, 0xE0, 0x00, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x03, 0xF8, 0x0F, 0xFF, 0x1F, 0xFF, 0xCF, 0xFF,
  0xF3, 0xFF, 0xF9, 0xC0, 0xFC, 0x80, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7C, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x3F, 0x00, 0x01,
  0xF0, 0x1F, 0x80, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0x0F, 0x83, 0xE0, 0x1E,
  0x01, 0xE1, 0xF0, 0x1F, 0xFC, 0x78, 0x78, 0x1F, 0xFE, 0x1E, 0x3E, 0x0F,
  0xFF, 0x87, 0xCF, 0x07, 0xC1, 0xE1, 0xF7, 0xC1, 0xE0, 0xF8, 0x7D, 0xE0,
  0xF0, 0x3C, 0x1E, 0x78, 0x7C, 0x0F, 0x07, 0x9E, 0x1E, 0x07, 0xC1, 0xEF,
  0x87, 0x81, 0xE0, 0x7B, 0xC3, 0xE0, 0x78, 0x1E, 0xF0, 0xF8, 0x1E, 0x0F,
  0x3C, 0x3C, 0x0F, 0x83, 0xCF, 0x0F, 0x03, 0xE1, 0xF3, 0xC3, 0xC1, 0xF0,
  0x78, 0xF0, 0xF8, 0x7C, 0x3C, 0x3C, 0x3F, 0xFF, 0xFF, 0x0F, 0x07, 0xFD,
  0xFF, 0x83, 0xC0, 0xFE, 0x3F, 0xC0, 0xF8, 0x1F, 0x07, 0xC0, 0x1E, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x01, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0x7C, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0xF9,
  0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0xC7, 0xC0, 0x03,
  0xE1, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x7C, 0x1F, 0x80, 0x3F, 0x03, 0xE0,
  0x0F, 0x80, 0xF8, 0x07, 0xE0, 0x3E, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x83, 0xF0,
  0x03, 0xE0, 0xFC, 0x00, 0xF8, 0x7E, 0x00, 0x3E, 0x1F, 0x80, 0x0F, 0x8F,
  0xC0, 0x03, 0xF3, 0xF0, 0x00, 0xFD, 0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xF0, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0x83, 0xFC, 0x0F,
  0x80, 0xFE, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0xC1,
  0xF8, 0x07, 0xE0, 0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x7E, 0x07, 0xF0,
  0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFE, 0x03, 0xF0, 0x3F, 0x81, 0xF0, 0x0F, 0xC0, 0xF8, 0x03,
  0xE0, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x1F, 0x00,
  0x7E, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x3F, 0x87, 0xE0, 0x3F, 0x83, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x07, 0xFF,
  0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0x01, 0xC0, 0x7F,
  0x80, 0x10, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x20, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x07,
  0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x07,
  0xE3, 0xFF, 0x00, 0xFC, 0x0F, 0xE0, 0x3F, 0x00, 0xFE, 0x07, 0xE0, 0x0F,
  0xC0, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x3F, 0x03, 0xE0, 0x07, 0xE0, 0xFC,
  0x00, 0xFE, 0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x7E,
  0x0F, 0x80, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x0F, 0xC0,
  0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x3E, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xE1,
  0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x7F, 0x07, 0xC0, 0x1F, 0xC1, 0xF8, 0x07,
  0xF8, 0x3F, 0x01, 0xFE, 0x07, 0xE0, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xE0, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x0F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x81,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xFF,
  0xF0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF,
  0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFF, 0xE0,
  0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0x01,
  0xE0, 0xFF, 0x00, 0x10, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x07, 0xFF,
  0x3F, 0x01, 0xFF, 0xCF, 0xC0, 0x7F, 0xF3, 0xF0, 0x1F, 0xFC, 0xFC, 0x08,
  0x3E, 0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xE3, 0xF0, 0x01, 0xF8, 0xFC,
  0x00, 0x7C, 0x3F, 0x00, 0x1F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF8, 0x03, 0xF0,
  0x7F, 0x00, 0xFC, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xF8, 0x01, 0xF8,
  0x0F, 0xC0, 0x0F, 0xC0, 0x7C, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xE0, 0x3F,
  0x00, 0x1F, 0x01, 0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0x7C, 0x00,
  0x7E, 0x07, 0xE0, 0x03, 0xE0, 0x3F, 0x00, 0x3F, 0x01, 0xF8, 0x01, 0xF8,
  0x0F, 0x80, 0x0F, 0xC0, 0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xE0, 0x3F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0x00, 0x3F, 0x01, 0xF8, 0x01, 0xF8,
  0x0F, 0x80, 0x0F, 0xC0, 0xFC, 0x00, 0x7C, 0x07, 0xE0, 0x07, 0xE0, 0x3F,
  0x00, 0x3F, 0x01, 0xF0, 0x01, 0xF8, 0x0F, 0x80, 0x0F, 0xC0, 0xFC, 0x00,
  0x7C, 0x07, 0xE0, 0x07, 0xE0, 0x3F, 0x00, 0x3F, 0x01, 0xF0, 0x01, 0xF8,
  0x1F, 0x80, 0x0F, 0xC0, 0xFC, 0x00, 0x7C, 0x07, 0xE0, 0x07, 0xE0, 0x00,
  0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x07,
  0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x80,
  0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x03, 0x3F, 0xC0,
  0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x1F, 0x00, 0x7F, 0x01, 0xF0, 0x0F,
  0xE0, 0x3F, 0x01, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x3F, 0x03, 0xF0, 0x03,
  0xE0, 0x7F, 0x00, 0x3E, 0x0F, 0xE0, 0x07, 0xE1, 0xFC, 0x00, 0x7E, 0x1F,
  0x80, 0x07, 0xC3, 0xF0, 0x00, 0x7C, 0x7E, 0x00, 0x0F, 0xCF, 0xE0, 0x00,
  0xFD, 0xFC, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0xFB, 0xF0, 0x00, 0x0F, 0xFF,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00,
  0x1F, 0xDF, 0x80, 0x01, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0,
  0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xE0, 0x7E, 0x00, 0x3E, 0x07, 0xE0,
  0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x03, 0xF0, 0x07, 0xE0, 0x3F, 0x00, 0x7C,
  0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0xFC, 0x01, 0xF8, 0x0F, 0xC0, 0x1F,
  0xC0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0xC0,
  0x7F, 0x80, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x01,
  0xFF, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0xFF,
  0xC0, 0x0F, 0xFE, 0x07, 0xDE, 0x00, 0x7F, 0xE0, 0x3E, 0xF0, 0x03, 0xDF,
  0x01, 0xF7, 0x80, 0x3E, 0xF8, 0x0F, 0xBC, 0x01, 0xEF, 0xC0, 0xFD, 0xE0,
  0x1F, 0x7C, 0x07, 0xCF, 0x00, 0xF3, 0xE0, 0x3E, 0x7C, 0x0F, 0x9F, 0x01,
  0xF3, 0xE0, 0x78, 0xF8, 0x0F, 0x9F, 0x07, 0xCF, 0xC0, 0xFC, 0xF8, 0x3C,
  0x7C, 0x07, 0xC7, 0xC3, 0xE3, 0xE0, 0x3E, 0x3E, 0x1E, 0x1F, 0x01, 0xF1,
  0xF1, 0xF1, 0xF8, 0x0F, 0x8F, 0x8F, 0x0F, 0xC0, 0xFC, 0x7C, 0xF8, 0x7C,
  0x07, 0xC3, 0xE7, 0x83, 0xE0, 0x3E, 0x0F, 0x7C, 0x1F, 0x01, 0xF0, 0x7B,
  0xC1, 0xF8, 0x1F, 0x83, 0xFE, 0x0F, 0xC0, 0xF8, 0x1F, 0xE0, 0x7C, 0x07,
  0xC0, 0xFF, 0x03, 0xE0, 0x3E, 0x07, 0xF0, 0x1F, 0x01, 0xF0, 0x3F, 0x81,
  0xF8, 0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xC0,
  0x7C, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x3E, 0x03, 0xF8, 0x00, 0xFC,
  0x07, 0xF0, 0x01, 0xF8, 0x1F, 0xE0, 0x03, 0xE0, 0x3F, 0xE0, 0x07, 0xC0,
  0x7F, 0xC0, 0x0F, 0x80, 0xFF, 0x80, 0x3F, 0x03, 0xFF, 0x00, 0x7C, 0x07,
  0xFF, 0x00, 0xF8, 0x0F, 0xBE, 0x01, 0xF0, 0x1F, 0x7C, 0x03, 0xE0, 0x3E,
  0xFC, 0x0F, 0xC0, 0xFC, 0xF8, 0x1F, 0x01, 0xF1, 0xF0, 0x3E, 0x03, 0xE3,
  0xE0, 0x7C, 0x07, 0xC7, 0xE1, 0xF8, 0x0F, 0x87, 0xC3, 0xF0, 0x3F, 0x0F,
  0x87, 0xC0, 0x7C, 0x1F, 0x0F, 0x80, 0xF8, 0x3F, 0x1F, 0x01, 0xF0, 0x3E,
  0x3E, 0x03, 0xE0, 0x7C, 0xFC, 0x0F, 0xC0, 0xFD, 0xF0, 0x1F, 0x00, 0xFB,
  0xE0, 0x3E, 0x01, 0xF7, 0xC0, 0x7C, 0x03, 0xEF, 0x81, 0xF8, 0x07, 0xFE,
  0x03, 0xF0, 0x07, 0xFC, 0x07, 0xC0, 0x0F, 0xF8, 0x0F, 0x80, 0x1F, 0xF0,
  0x1F, 0x00, 0x1F, 0xE0, 0x7E, 0x00, 0x3F, 0x80, 0xF8, 0x00, 0x7F, 0x01,
  0xF0, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xC1,
  0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0xFE, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE1,
  0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x03, 0xF3, 0xF8, 0x00, 0x3F, 0x3F, 0x00,
  0x03, 0xF3, 0xF0, 0x00, 0x3F, 0x7F, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x7E,
  0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x7E, 0x7E, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x0F,
  0xC7, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF8, 0x7E,
  0x00, 0x7F, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x81, 0xFE, 0x03, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x1F, 0x87, 0xF8, 0x0F, 0x80,
  0xFE, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0xC1, 0xF8,
  0x07, 0xE0, 0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xF0, 0x7E, 0x01, 0xF8, 0x3F,
  0x01, 0xFC, 0x1F, 0x81, 0xFC, 0x0F, 0x83, 0xFE, 0x0F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xC1, 0xFC, 0x07,
  0xF0, 0x0F, 0xE0, 0xFE, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE1, 0xFC, 0x00,
  0x7E, 0x1F, 0x80, 0x03, 0xF3, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x03, 0xF3,
  0xF0, 0x00, 0x3F, 0x7F, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x7E, 0x7E, 0x00,
  0x07, 0xE7, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7E,
  0x7E, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x0F, 0xC7, 0xC0,
  0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF8, 0x7E, 0x00, 0x7F,
  0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x81, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x01,
  0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xF0, 0xFF, 0x03,
  0xE0, 0x3F, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x3F, 0x07,
  0xE0, 0x3F, 0x07, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x7E, 0x0F,
  0xC0, 0xFE, 0x0F, 0xC1, 0xFC, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x1F, 0x0F, 0xC0, 0x3F,
  0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x3E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0x7C,
  0x03, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03,
  0xFF, 0xFC, 0x07, 0xF8, 0x3C, 0x07, 0xF0, 0x04, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x80, 0x07, 0xE0, 0xE0,
  0x0F, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF,
  0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF8, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x07, 0xE0, 0xF8, 0x00, 0xFC, 0x3F, 0x00,
  0x1F, 0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x1F, 0x00, 0x1F, 0x87,
  0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x7C, 0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x03,
  0xF0, 0x7C, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x01, 0xF0, 0x7E,
  0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xC1, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x3E,
  0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x3E, 0x00, 0x3F, 0x0F, 0xC0,
  0x07, 0xE1, 0xF8, 0x00, 0xF8, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xE0,
  0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x01,
  0xFC, 0x0F, 0xE0, 0x7F, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFC, 0x00,
  0x1F, 0xFE, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xDF, 0x80, 0x0F, 0xCF, 0xC0,
  0x07, 0xE3, 0xE0, 0x03, 0xE1, 0xF0, 0x03, 0xF0, 0xF8, 0x01, 0xF0, 0x7C,
  0x01, 0xF8, 0x3E, 0x00, 0xFC, 0x1F, 0x00, 0xFC, 0x0F, 0x80, 0x7E, 0x07,
  0xC0, 0x7E, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x3F, 0x00, 0xF8, 0x1F, 0x80,
  0x7C, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x87, 0xC0, 0x0F, 0xC7, 0xE0,
  0x07, 0xE3, 0xE0, 0x01, 0xF3, 0xF0, 0x00, 0xF9, 0xF0, 0x00, 0x7D, 0xF8,
  0x00, 0x3E, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x7C,
  0x00, 0xFF, 0xF0, 0x03, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xC0, 0x1F, 0xBF,
  0x00, 0x7F, 0x00, 0x7E, 0xFC, 0x01, 0xFC, 0x01, 0xF3, 0xF0, 0x0F, 0xF0,
  0x0F, 0xCF, 0xC0, 0x3F, 0xC0, 0x3F, 0x1F, 0x00, 0xFF, 0x01, 0xF8, 0x7C,
  0x07, 0xFC, 0x07, 0xE1, 0xF0, 0x1F, 0xF0, 0x1F, 0x07, 0xC0, 0xFF, 0xC0,
  0xFC, 0x1F, 0x03, 0xFF, 0x03, 0xE0, 0x7C, 0x1F, 0x7C, 0x1F, 0x81, 0xF0,
  0x7D, 0xF0, 0x7E, 0x07, 0xC1, 0xE7, 0xC1, 0xF0, 0x1F, 0x0F, 0x9F, 0x0F,
  0xC0, 0x7C, 0x3E, 0x7C, 0x3E, 0x01, 0xF1, 0xF1, 0xF1, 0xF8, 0x07, 0xC7,
  0xC7, 0xC7, 0xC0, 0x1F, 0x3E, 0x1F, 0x1F, 0x00, 0x7C, 0xF8, 0x7C, 0xFC,
  0x01, 0xF3, 0xC1, 0xF3, 0xE0, 0x07, 0xDF, 0x07, 0xDF, 0x80, 0x1F, 0x7C,
  0x1F, 0x7C, 0x00, 0x7F, 0xE0, 0x7D, 0xF0, 0x01, 0xFF, 0x81, 0xFF, 0x80,
  0x07, 0xBC, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x1F, 0xF8, 0x00, 0x7F, 0x80,
  0x7F, 0xC0, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00,
  0x1F, 0xC0, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x7E, 0x01, 0xF8, 0x01, 0xF8, 0x01,
  0xF0, 0x07, 0xE0, 0x03, 0xF0, 0x0F, 0xC0, 0x07, 0xE0, 0x3F, 0x00, 0x07,
  0xC0, 0xFC, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x3F,
  0x1F, 0x80, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0x3E, 0x00, 0x00, 0x7E, 0x7E, 0x00,
  0x01, 0xF8, 0xFC, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x0F, 0xC1, 0xF0, 0x00,
  0x3F, 0x03, 0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x03, 0xF8, 0x0F, 0xC0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x7F, 0x00, 0x3F, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xFD, 0xF0, 0x03, 0xF3,
  0xF0, 0x0F, 0xC7, 0xE0, 0x1F, 0x8F, 0xC0, 0x7E, 0x1F, 0x80, 0xF8, 0x1F,
  0x03, 0xF0, 0x3E, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x7E, 0x00, 0xF8,
  0xF8, 0x01, 0xF3, 0xF0, 0x03, 0xEF, 0xC0, 0x07, 0xDF, 0x00, 0x0F, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x1F,
  0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xFF, 0xC0, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0xF8, 0x3E,
  0x0F, 0x83, 0xE0, 0x78, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC0,
  0xF0, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x81, 0xE0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x03, 0xC0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0xF8, 0x3E, 0x07, 0x81, 0xF0, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC,
  0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x1F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3D, 0xE0,
  0x01, 0xF7, 0xC0, 0x07, 0x8F, 0x00, 0x3E, 0x3C, 0x01, 0xF0, 0xF8, 0x07,
  0x81, 0xE0, 0x3E, 0x07, 0x80, 0xF0, 0x1F, 0x07, 0xC0, 0x3C, 0x3E, 0x00,
  0xF0, 0xF8, 0x03, 0xE7, 0xC0, 0x07, 0x9E, 0x00, 0x1E, 0xF8, 0x00, 0x7C,
  0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xF8, 0xFC, 0xFC, 0x7E, 0x3E, 0x3E,
  0x1F, 0x0F, 0x07, 0x00, 0x78, 0x02, 0x03, 0xFC, 0x78, 0x1F, 0xFD, 0xF0,
  0x7F, 0xFB, 0xE0, 0xFF, 0xFF, 0xC3, 0xF8, 0x7F, 0x8F, 0xE0, 0x7E, 0x1F,
  0x80, 0xFC, 0x3F, 0x01, 0xF8, 0xFC, 0x03, 0xF1, 0xF8, 0x07, 0xE3, 0xE0,
  0x0F, 0x8F, 0xC0, 0x1F, 0x1F, 0x80, 0x7E, 0x3F, 0x00, 0xFC, 0x7E, 0x01,
  0xF8, 0xFC, 0x07, 0xE1, 0xF0, 0x0F, 0xC3, 0xE0, 0x3F, 0x87, 0xE0, 0x7F,
  0x0F, 0xC1, 0xFC, 0x1F, 0xCF, 0xF8, 0x3F, 0xFF, 0xF0, 0x3F, 0xFB, 0xE0,
  0x3F, 0xE7, 0xC0, 0x3F, 0x8F, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x0F, 0x00, 0x3E, 0x7F, 0x80, 0x7D, 0xFF, 0x81, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0x07, 0xF8, 0x7E, 0x0F, 0xE0, 0xFC, 0x3F, 0x80, 0xF8, 0x7E, 0x01,
  0xF8, 0xFC, 0x03, 0xE1, 0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0x8F, 0xC0, 0x3F,
  0x1F, 0x80, 0x7E, 0x3E, 0x00, 0xFC, 0x7C, 0x01, 0xF0, 0xF8, 0x07, 0xE3,
  0xF0, 0x0F, 0xC7, 0xE0, 0x3F, 0x0F, 0xC0, 0x7E, 0x1F, 0xC1, 0xFC, 0x3F,
  0xC7, 0xF0, 0xFF, 0xFF, 0xC1, 0xF7, 0xFF, 0x03, 0xCF, 0xFC, 0x07, 0x87,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xE0,
  0xFF, 0xFC, 0x3F, 0x81, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x21, 0xFE, 0x3C, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x3F,
  0xFE, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x3E, 0x1F, 0x80, 0x3F, 0xCF, 0x80, 0x7F, 0xF7, 0xC0, 0x7F, 0xFB, 0xE0,
  0x3F, 0xFF, 0xF0, 0x3F, 0x87, 0xF8, 0x3F, 0x81, 0xF8, 0x1F, 0x80, 0xFC,
  0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x83, 0xE0, 0x0F,
  0x83, 0xF0, 0x07, 0xC1, 0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x7E, 0x01,
  0xF0, 0x3E, 0x00, 0xF8, 0x1F, 0x00, 0xFC, 0x0F, 0x80, 0x7E, 0x07, 0xE0,
  0x7F, 0x03, 0xF0, 0x7F, 0x01, 0xFC, 0x7F, 0x80, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFB, 0xE0, 0x0F, 0xF9, 0xF0, 0x03, 0xF8, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x1F, 0xFC, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xE7, 0xF1, 0xF8, 0x3F,
  0x3F, 0x01, 0xF3, 0xF0, 0x1F, 0x7E, 0x03, 0xF7, 0xE0, 0x7E, 0x7C, 0x0F,
  0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x8F, 0xE0, 0x70, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x07, 0xFF,
  0xE0, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x37, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x80, 0x3F, 0xC7, 0x80,
  0x7F, 0xF7, 0xC0, 0x7F, 0xFB, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0x87, 0xF8,
  0x3F, 0x81, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x3F,
  0x07, 0xE0, 0x1F, 0x83, 0xE0, 0x0F, 0x83, 0xF0, 0x07, 0xC1, 0xF8, 0x07,
  0xE0, 0xFC, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x3F, 0x01, 0xF8, 0x1F, 0x00,
  0xFC, 0x0F, 0x80, 0xFE, 0x07, 0xE0, 0x7F, 0x03, 0xF0, 0x7F, 0x01, 0xFC,
  0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFB, 0xF0, 0x03,
  0xF1, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3F, 0x01, 0x80, 0x3F, 0x80, 0xF8, 0x7F, 0x80,
  0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x3E, 0x01, 0xF3, 0xFE, 0x07, 0xDF,
  0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFC, 0x3F, 0x0F, 0xE0, 0x7C,
  0x7F, 0x01, 0xF1, 0xFC, 0x07, 0xC7, 0xE0, 0x3F, 0x1F, 0x80, 0xFC, 0x7C,
  0x03, 0xF3, 0xF0, 0x0F, 0x8F, 0xC0, 0x3E, 0x3F, 0x01, 0xF8, 0xF8, 0x07,
  0xE3, 0xE0, 0x1F, 0x9F, 0x80, 0x7C, 0x7E, 0x01, 0xF1, 0xF8, 0x0F, 0xC7,
  0xC0, 0x3F, 0x1F, 0x00, 0xF8, 0xFC, 0x03, 0xE3, 0xF0, 0x1F, 0x8F, 0x80,
  0x7E, 0x3E, 0x01, 0xF8, 0x01, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x07, 0xC0, 0x7C, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xC0, 0x7C, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x1B, 0xFC,
  0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x01, 0x07, 0xC0, 0x7E, 0x07,
  0xC0, 0xFC, 0x0F, 0xC1, 0xF8, 0x0F, 0xC3, 0xF0, 0x0F, 0x87, 0xF0, 0x0F,
  0x87, 0xE0, 0x1F, 0x8F, 0xC0, 0x1F, 0x9F, 0x80, 0x1F, 0x3F, 0x00, 0x1F,
  0x7E, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0xFE, 0x00, 0x3F, 0xBF, 0x00, 0x3F, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7E,
  0x1F, 0x80, 0x7C, 0x1F, 0x80, 0x7C, 0x1F, 0x80, 0x7C, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xF8, 0x07, 0xE0, 0xF8, 0x07, 0xE0, 0x01,
  0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0x80, 0x7C,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x1F, 0x00, 0xF1, 0xFE, 0x0F, 0xF0, 0x1E, 0x7F, 0xE3, 0xFF, 0x07,
  0xDF, 0xFC, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xE1, 0xFF, 0x0F,
  0xC3, 0xF8, 0x3F, 0xC1, 0xF8, 0xFE, 0x07, 0xF0, 0x3F, 0x1F, 0x80, 0xFC,
  0x07, 0xE3, 0xF0, 0x1F, 0x80, 0xF8, 0x7E, 0x03, 0xF0, 0x1F, 0x0F, 0x80,
  0x7C, 0x03, 0xE3, 0xF0, 0x1F, 0x80, 0xFC, 0x7E, 0x03, 0xF0, 0x1F, 0x8F,
  0xC0, 0x7E, 0x03, 0xE1, 0xF0, 0x0F, 0x80, 0x7C, 0x3E, 0x01, 0xF0, 0x0F,
  0x8F, 0xC0, 0x7E, 0x03, 0xF1, 0xF8, 0x0F, 0xC0, 0x7E, 0x3E, 0x01, 0xF0,
  0x0F, 0x87, 0xC0, 0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC0, 0x7E, 0x3F, 0x01,
  0xF8, 0x0F, 0xC7, 0xE0, 0x3F, 0x01, 0xF8, 0xF8, 0x07, 0xC0, 0x3E, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x07, 0x83, 0xE0, 0x1E, 0x3F, 0xE0, 0x79, 0xFF,
  0x83, 0xEF, 0xFF, 0x0F, 0xFF, 0xFC, 0x3F, 0xC3, 0xF0, 0xFE, 0x07, 0xC7,
  0xF0, 0x1F, 0x1F, 0xC0, 0x7C, 0x7E, 0x03, 0xF1, 0xF8, 0x0F, 0xC7, 0xC0,
  0x3F, 0x3F, 0x00, 0xF8, 0xFC, 0x03, 0xE3, 0xF0, 0x1F, 0x8F, 0x80, 0x7E,
  0x3E, 0x01, 0xF9, 0xF8, 0x07, 0xC7, 0xE0, 0x3F, 0x1F, 0x80, 0xFC, 0x7C,
  0x03, 0xF3, 0xF0, 0x0F, 0x8F, 0xC0, 0x3E, 0x3F, 0x01, 0xF8, 0xF8, 0x07,
  0xE3, 0xE0, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xF8,
  0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x0F, 0xE1, 0xF8, 0xFE, 0x07, 0xE7, 0xE0,
  0x3F, 0x7E, 0x01, 0xFB, 0xF0, 0x0F, 0xDF, 0x00, 0x7F, 0xF8, 0x03, 0xFF,
  0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xDF, 0x00, 0x7E, 0xF8, 0x03,
  0xF7, 0xC0, 0x1F, 0xBE, 0x01, 0xF9, 0xF8, 0x1F, 0xCF, 0xC0, 0xFC, 0x7F,
  0x1F, 0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x3C, 0x7F, 0x80, 0x0F, 0x3F, 0xF0, 0x07,
  0xDF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0x87, 0xE0, 0x1F, 0xC1, 0xF8,
  0x0F, 0xE0, 0x3E, 0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x03, 0xE0, 0x3E, 0x00,
  0xF8, 0x0F, 0x80, 0x3E, 0x07, 0xE0, 0x1F, 0x81, 0xF8, 0x07, 0xE0, 0x7C,
  0x01, 0xF8, 0x1F, 0x00, 0x7E, 0x07, 0xC0, 0x3F, 0x03, 0xF0, 0x0F, 0xC0,
  0xFC, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0xE0, 0xFE, 0x03, 0xFC, 0x7F,
  0x01, 0xFF, 0xFF, 0x80, 0x7D, 0xFF, 0xC0, 0x1F, 0x3F, 0xE0, 0x07, 0xC7,
  0xF0, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x02, 0x03, 0xFC, 0x78, 0x1F, 0xFD, 0xF0, 0x7F,
  0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xF8, 0x7F, 0x8F, 0xE0, 0x7E, 0x1F, 0x80,
  0xFC, 0x3E, 0x01, 0xF8, 0xFC, 0x03, 0xF1, 0xF8, 0x07, 0xE3, 0xE0, 0x0F,
  0x8F, 0xC0, 0x1F, 0x1F, 0x80, 0x7E, 0x3F, 0x00, 0xFC, 0x7C, 0x01, 0xF0,
  0xF8, 0x03, 0xE1, 0xF0, 0x0F, 0xC3, 0xE0, 0x1F, 0x87, 0xE0, 0x7F, 0x0F,
  0xC1, 0xFC, 0x1F, 0xC7, 0xF8, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F,
  0xEF, 0xC0, 0x3F, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xC1, 0xE3, 0xF0, 0x79, 0xFC, 0x3E, 0xFF, 0x0F, 0xFF,
  0x83, 0xFF, 0xE0, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x7F, 0xF8, 0x1F, 0xFF, 0x87, 0xFF, 0xF0, 0xFE, 0x7C,
  0x3F, 0x01, 0x87, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0,
  0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC8,
  0x03, 0xF1, 0xE0, 0xFE, 0x3F, 0xFF, 0xC7, 0xFF, 0xF0, 0xFF, 0xFC, 0x0F,
  0xFE, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x01,
  0xF8, 0x0F, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x7E, 0x00, 0xFC,
  0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF8, 0x87, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x0F, 0xF8,
  0x00, 0x0F, 0x80, 0x7E, 0x3F, 0x00, 0xF8, 0x7E, 0x03, 0xF0, 0xF8, 0x07,
  0xE1, 0xF0, 0x0F, 0xC7, 0xE0, 0x1F, 0x0F, 0xC0, 0x3E, 0x1F, 0x80, 0xFC,
  0x3E, 0x01, 0xF8, 0x7C, 0x03, 0xF1, 0xF8, 0x07, 0xC3, 0xF0, 0x0F, 0x87,
  0xE0, 0x3F, 0x0F, 0x80, 0x7E, 0x1F, 0x00, 0xF8, 0x7E, 0x03, 0xF0, 0xFC,
  0x07, 0xE1, 0xF8, 0x1F, 0xC3, 0xF0, 0x3F, 0x87, 0xE0, 0xFE, 0x0F, 0xE7,
  0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFD, 0xF0, 0x3F, 0xF3, 0xE0, 0x3F, 0x87,
  0x80, 0xFC, 0x01, 0xFD, 0xF0, 0x07, 0xE7, 0xC0, 0x3F, 0x1F, 0x00, 0xFC,
  0x7C, 0x07, 0xE1, 0xF0, 0x1F, 0x87, 0xC0, 0x7C, 0x1F, 0x03, 0xF0, 0x7C,
  0x0F, 0x81, 0xF0, 0x7E, 0x07, 0xE1, 0xF0, 0x0F, 0x8F, 0xC0, 0x3E, 0x3E,
  0x00, 0xF9, 0xF8, 0x03, 0xE7, 0xC0, 0x0F, 0xBF, 0x00, 0x3E, 0xF8, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0x80, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x0F,
  0xE0, 0x3F, 0xF8, 0x0F, 0xE0, 0x3E, 0xF8, 0x1F, 0xE0, 0x7E, 0xF8, 0x1F,
  0xE0, 0x7C, 0xF8, 0x1F, 0xE0, 0xFC, 0xF8, 0x3D, 0xE0, 0xF8, 0xF8, 0x3D,
  0xE0, 0xF8, 0xF8, 0x7D, 0xE1, 0xF8, 0xF8, 0x79, 0xE1, 0xF0, 0xF8, 0x79,
  0xE3, 0xF0, 0xF8, 0xF9, 0xE3, 0xE0, 0xF8, 0xF1, 0xE7, 0xE0, 0xF9, 0xF1,
  0xE7, 0xC0, 0xF9, 0xE1, 0xE7, 0xC0, 0xFB, 0xE1, 0xEF, 0x80, 0xFB, 0xC1,
  0xEF, 0x80, 0xFB, 0xC3, 0xEF, 0x80, 0xFF, 0xC3, 0xFF, 0x00, 0xFF, 0x83,
  0xFF, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0x03,
  0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x03,
  0xF8, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0xFC, 0x0F, 0xC0, 0x1F, 0x07, 0xF0,
  0x07, 0xE1, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0x3E, 0x7E, 0x00, 0x0F, 0x9F,
  0x80, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xF9, 0xF0,
  0x00, 0x7E, 0x7C, 0x00, 0x3F, 0x1F, 0x80, 0x1F, 0x83, 0xE0, 0x0F, 0xE0,
  0xFC, 0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0xFE, 0x01, 0xF8, 0x00,
  0x01, 0xF0, 0x07, 0xF0, 0x1F, 0x00, 0x7E, 0x01, 0xF0, 0x0F, 0xC0, 0x1F,
  0x00, 0xFC, 0x01, 0xF0, 0x0F, 0x80, 0x1F, 0x01, 0xF8, 0x01, 0xF8, 0x1F,
  0x00, 0x1F, 0x83, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x0F, 0x87, 0xE0, 0x00,
  0xF8, 0x7C, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0x9F,
  0x80, 0x00, 0xF9, 0xF0, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0xFB, 0xE0, 0x00,
  0x07, 0xBE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x0C, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0x81,
  0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x60, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x03, 0xFC,
  0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x07,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x07,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xC0, 0x00, 0x7E,
  0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xE0, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF8,
  0x07, 0xFC, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0xFC, 0x00, 0x3E, 0x00, 0x3F, 0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x03,
  0xF8, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x05, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0x00, 0xFF, 0xE8, 0x00, 0x7E,
  0x00,
};

const GFXglyph NotoSans_SemiCondensed_SemiBoldItalic47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 13, 35, 12, 1, -34 },
  { 58, 15, 13, 19, 5, -34 },
  { 83, 27, 34, 27, 1, -34 },
  { 198, 23, 39, 24, 1, -36 },
  { 311, 32, 34, 36, 3, -34 },
  { 447, 27, 34, 29, 1, -34 },
  { 562, 7, 13, 11, 5, -34 },
  { 574, 17, 41, 14, 1, -34 },
  { 662, 16, 41, 14, -3, -34 },
  { 744, 20, 21, 23, 4, -36 },
  { 797, 22, 23, 25, 2, -28 },
  { 861, 10, 12, 12, -2, -6 },
  { 876, 12, 5, 14, 1, -15 },
  { 884, 7, 8, 12, 0, -7 },
  { 891, 24, 34, 18, -2, -34 },
  { 993, 21, 34, 24, 2, -34 },
  { 1083, 16, 34, 24, 5, -34 },
  { 1151, 24, 34, 24, -1, -34 },
  { 1253, 23, 34, 24, 0, -34 },
  { 1351, 23, 34, 24, 0, -34 },
  { 1449, 23, 34, 24, 1, -34 },
  { 1547, 22, 34, 24, 2, -34 },
  { 1641, 23, 34, 24, 2, -34 },
  { 1739, 23, 34, 24, 1, -34 },
  { 1837, 22, 34, 24, 1, -34 },
  { 1931, 11, 27, 12, 0, -26 },
  { 1969, 13, 32, 12, -2, -26 },
  { 2021, 22, 24, 25, 2, -29 },
  { 2087, 21, 13, 25, 2, -23 },
  { 2122, 22, 24, 25, 2, -29 },
  { 2188, 17, 35, 19, 3, -34 },
  { 2263, 34, 38, 36, 2, -34 },
  { 2425, 26, 34, 26, -3, -34 },
  { 2536, 25, 34, 26, 1, -34 },
  { 2643, 26, 34, 25, 2, -34 },
  { 2754, 27, 34, 29, 1, -34 },
  { 2869, 23, 34, 23, 1, -34 },
  { 2967, 23, 34, 22, 1, -34 },
  { 3065, 26, 34, 29, 3, -34 },
  { 3176, 29, 34, 29, 1, -34 },
  { 3300, 21, 34, 16, -2, -34 },
  { 3390, 21, 44, 13, -7, -34 },
  { 3506, 28, 34, 25, 1, -34 },
  { 3625, 17, 34, 21, 1, -34 },
  { 3698, 37, 34, 37, 1, -34 },
  { 3856, 31, 34, 31, 1, -34 },
  { 3988, 28, 34, 31, 2, -34 },
  { 4107, 25, 34, 25, 1, -34 },
  { 4214, 28, 42, 31, 2, -34 },
  { 4361, 24, 34, 26, 1, -34 },
  { 4463, 24, 34, 22, 0, -34 },
  { 4565, 22, 34, 22, 4, -34 },
  { 4659, 27, 34, 29, 3, -34 },
  { 4774, 25, 34, 25, 4, -34 },
  { 4881, 38, 34, 38, 4, -34 },
  { 5043, 31, 34, 24, -3, -34 },
  { 5175, 23, 34, 23, 4, -34 },
  { 5273, 26, 34, 22, -1, -34 },
  { 5384, 19, 41, 14, -1, -34 },
  { 5482, 10, 34, 18, 5, -34 },
  { 5525, 18, 41, 14, -3, -34 },
  { 5618, 22, 21, 24, 1, -34 },
  { 5676, 18, 3, 17, -4, 4 },
  { 5683, 8, 8, 14, 7, -36 },
  { 5691, 23, 26, 25, 2, -26 },
  { 5766, 23, 36, 25, 1, -36 },
  { 5870, 19, 26, 20, 2, -26 },
  { 5932, 25, 36, 25, 2, -36 },
  { 6045, 20, 26, 23, 2, -26 },
  { 6110, 25, 47, 15, -5, -36 },
  { 6257, 25, 37, 25, 0, -26 },
  { 6373, 22, 36, 25, 1, -36 },
  { 6472, 12, 35, 12, 1, -35 },
  { 6525, 19, 46, 12, -6, -35 },
  { 6635, 24, 36, 23, 1, -36 },
  { 6743, 13, 36, 12, 1, -36 },
  { 6802, 35, 26, 38, 1, -26 },
  { 6916, 22, 26, 25, 1, -26 },
  { 6988, 21, 26, 25, 2, -26 },
  { 7057, 26, 37, 25, -2, -26 },
  { 7178, 23, 37, 25, 2, -26 },
  { 7285, 18, 26, 18, 1, -26 },
  { 7344, 19, 26, 20, 0, -26 },
  { 7406, 15, 31, 16, 2, -31 },
  { 7465, 23, 25, 25, 2, -25 },
  { 7537, 22, 25, 21, 2, -25 },
  { 7606, 32, 25, 33, 3, -25 },
  { 7706, 26, 25, 22, -2, -25 },
  { 7788, 28, 36, 21, -4, -25 },
  { 7914, 21, 25, 19, -1, -25 },
  { 7980, 19, 41, 16, 0, -34 },
  { 8078, 5, 47, 23, 9, -36 },
  { 8108, 18, 41, 16, -2, -34 },
  { 8201, 22, 7, 25, 2, -20 },
};

const GFXfont NotoSans_SemiCondensed_SemiBoldItalic47pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_SemiBoldItalic47pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_SemiBoldItalic47pt7bGlyphs,
  0x20, 0x7E, 64
};

#endif // _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC47PT7B_H_
