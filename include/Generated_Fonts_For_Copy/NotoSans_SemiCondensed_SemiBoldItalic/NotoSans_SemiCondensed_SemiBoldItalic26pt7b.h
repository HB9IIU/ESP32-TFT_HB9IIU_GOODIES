#ifndef _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC26PT7B_H_
#define _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC26PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-SemiBoldItalic.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_SemiBoldItalic26pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x0E, 0x0E, 0x1E, 0x1E, 0x1C, 0x1C, 0x1C, 0x1C, 0x38, 0x38,
  0x38, 0x38, 0x00, 0x00, 0x20, 0x70, 0xF0, 0xF0, 0x77, 0xE7, 0xE7, 0xE6,
  0xC6, 0xC6, 0xCE, 0x01, 0x8C, 0x03, 0x18, 0x0E, 0x70, 0x18, 0xC0, 0x31,
  0x80, 0xE7, 0x0F, 0xFF, 0x9F, 0xFF, 0x06, 0x30, 0x1C, 0xE0, 0x31, 0x83,
  0xFF, 0xE7, 0xFF, 0xDF, 0xFF, 0x86, 0x30, 0x0C, 0xE0, 0x39, 0x80, 0x63,
  0x00, 0xCE, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x78, 0x1F, 0xF1, 0xFF, 0x0E,
  0xC8, 0x76, 0x03, 0xA0, 0x1F, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x2E,
  0x01, 0x78, 0x1B, 0xC8, 0xDC, 0x7F, 0xE7, 0xFE, 0x0F, 0xC0, 0x18, 0x00,
  0xC0, 0x04, 0x00, 0x1C, 0x07, 0x1F, 0x03, 0x1D, 0x83, 0x1C, 0xE3, 0x8E,
  0x71, 0x86, 0x31, 0x83, 0x19, 0xC1, 0x9C, 0xC0, 0xCE, 0xCF, 0x7E, 0xEF,
  0xFE, 0x6E, 0x6E, 0x66, 0x30, 0x73, 0x18, 0x33, 0x9C, 0x31, 0xCE, 0x38,
  0xE6, 0x18, 0x77, 0x18, 0x3F, 0x1C, 0x0F, 0x00, 0x01, 0xE0, 0x07, 0xF0,
  0x07, 0xF8, 0x0E, 0x38, 0x0E, 0x38, 0x0E, 0x38, 0x0E, 0x70, 0x0F, 0xE0,
  0x07, 0xC0, 0x0F, 0x81, 0x3F, 0x8E, 0x3B, 0xCE, 0x71, 0xDC, 0x70, 0xFC,
  0xF0, 0xF8, 0x70, 0xF0, 0x79, 0xF8, 0x7F, 0xFC, 0x3F, 0x1C, 0x7E, 0xEE,
  0xEC, 0xC0, 0x03, 0x83, 0x83, 0x81, 0x81, 0xC1, 0xC0, 0xE0, 0xE0, 0x70,
  0x38, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x03, 0x01, 0xC0, 0x07, 0x03, 0x80, 0xC0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x30, 0x38, 0x1C, 0x0E, 0x0E, 0x07,
  0x07, 0x03, 0x83, 0x83, 0x83, 0x80, 0x07, 0x00, 0xE1, 0x1C, 0x33, 0x0F,
  0xE6, 0x7F, 0xC3, 0xF8, 0xF8, 0x3B, 0x0E, 0x70, 0x8E, 0x01, 0x00, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x0F, 0xFF, 0xFF, 0xF0, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x39, 0xDC, 0xE6, 0x70, 0x7F, 0xFC, 0x27,
  0xFF, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07,
  0x00, 0x70, 0x03, 0x80, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00,
  0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x38, 0x00, 0x03, 0x80, 0xFE, 0x1F,
  0xE3, 0xCF, 0x38, 0x77, 0x87, 0x70, 0x77, 0x07, 0xF0, 0x7E, 0x0F, 0xE0,
  0xEE, 0x0E, 0xE0, 0xEE, 0x1E, 0xE1, 0xCE, 0x3C, 0xF7, 0x87, 0xF0, 0x3E,
  0x00, 0x03, 0x0F, 0x1F, 0x3F, 0xF7, 0xEE, 0x4E, 0x0E, 0x0E, 0x1E, 0x1C,
  0x1C, 0x1C, 0x1C, 0x3C, 0x38, 0x38, 0x38, 0x78, 0x01, 0xE0, 0x1F, 0xE0,
  0xFF, 0x83, 0x8F, 0x04, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x70,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x7F, 0xF1, 0xFF, 0xCF, 0xFE, 0x00, 0x03, 0xC0, 0x7F, 0x87, 0xFE, 0x10,
  0xF0, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x1E, 0x0F, 0xE0, 0x7C, 0x03, 0xF0,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x90, 0x3C, 0xE7, 0xC7, 0xFE, 0x3F,
  0xC0, 0x00, 0x38, 0x03, 0xC0, 0x3C, 0x03, 0xE0, 0x3F, 0x01, 0xB8, 0x1D,
  0xC1, 0xDC, 0x1C, 0xE0, 0xC7, 0x0E, 0x38, 0xE1, 0xCF, 0xFF, 0x7F, 0xFB,
  0xFF, 0xC0, 0x38, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0xF8, 0x7F, 0xC3,
  0xFE, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0xE0, 0x3F, 0xC1, 0xFF,
  0x00, 0x38, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x90, 0x3C, 0xF7, 0xC7,
  0xFE, 0x1F, 0xC0, 0x01, 0xF0, 0x7F, 0x0F, 0xF1, 0xE0, 0x1C, 0x03, 0x80,
  0x78, 0x07, 0x78, 0x7F, 0xC7, 0xFE, 0xF0, 0xEF, 0x0E, 0xE0, 0xEE, 0x0E,
  0xE1, 0xEE, 0x1C, 0xF7, 0xC7, 0xF8, 0x3F, 0x00, 0x3F, 0xF9, 0xFF, 0xCF,
  0xFE, 0x80, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0x80, 0x1C,
  0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x38, 0x03,
  0x80, 0x3C, 0x00, 0x07, 0xC0, 0xFE, 0x1F, 0xF3, 0x87, 0x38, 0x73, 0x87,
  0x38, 0xF1, 0xDE, 0x1F, 0xC1, 0xF0, 0x3F, 0x87, 0x1C, 0xE1, 0xEE, 0x0E,
  0xE0, 0xEE, 0x1C, 0xF3, 0xCF, 0xF8, 0x7F, 0x00, 0x07, 0x81, 0xFC, 0x3F,
  0xE3, 0x8E, 0x70, 0x77, 0x07, 0x70, 0xF7, 0x0F, 0x70, 0xE7, 0x9E, 0x7F,
  0xE3, 0xEE, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x38, 0x9F, 0x0F, 0xE0, 0xFC,
  0x00, 0x1C, 0xF3, 0xC2, 0x00, 0x00, 0x00, 0x00, 0x02, 0x3C, 0xF3, 0xC0,
  0x0E, 0x1C, 0x78, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC3, 0x8E,
  0x1C, 0x70, 0xE0, 0x00, 0x10, 0x07, 0x01, 0xF0, 0x7E, 0x1F, 0x87, 0xC0,
  0xF0, 0x0F, 0x80, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0x00, 0x10, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x0E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x1F, 0x07,
  0xC3, 0xF0, 0xFC, 0x0F, 0x00, 0xC0, 0x00, 0x0F, 0x1F, 0xE3, 0xFC, 0x87,
  0x01, 0xC0, 0x70, 0x3C, 0x1E, 0x0F, 0x07, 0x81, 0xC0, 0xE0, 0x38, 0x00,
  0x00, 0x00, 0x80, 0x70, 0x3C, 0x07, 0x00, 0x00, 0x38, 0x00, 0x3F, 0xE0,
  0x1F, 0x1E, 0x07, 0x00, 0xE1, 0xC0, 0x0C, 0x70, 0xF1, 0x8C, 0x7F, 0x3B,
  0x9E, 0xE7, 0x63, 0x1C, 0xFC, 0xE3, 0x1F, 0x98, 0x63, 0x63, 0x1C, 0x6C,
  0x63, 0x9D, 0x8C, 0xF3, 0x31, 0xF7, 0xC7, 0x3C, 0xF0, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x20, 0x1F, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x38, 0x00,
  0xF0, 0x01, 0xE0, 0x07, 0xE0, 0x0D, 0xC0, 0x3B, 0x80, 0x67, 0x01, 0xCE,
  0x03, 0x9C, 0x0E, 0x38, 0x1C, 0x70, 0x7F, 0xE0, 0xFF, 0xC3, 0xFF, 0x87,
  0x07, 0x1C, 0x0E, 0x38, 0x1C, 0xE0, 0x3F, 0xC0, 0x38, 0x0F, 0xC0, 0x3F,
  0xE0, 0xFF, 0xC3, 0x8F, 0x0E, 0x1C, 0x70, 0x71, 0xC1, 0xC7, 0x0E, 0x1F,
  0xF0, 0xFF, 0x83, 0xFF, 0x0E, 0x1E, 0x38, 0x38, 0xE0, 0xE7, 0x83, 0x9C,
  0x1E, 0x7F, 0xF1, 0xFF, 0x8F, 0xF8, 0x00, 0x01, 0xF0, 0x1F, 0xF0, 0xFF,
  0xC7, 0xC2, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x7F,
  0xE0, 0xFF, 0x81, 0xFC, 0x00, 0x0F, 0x80, 0x1F, 0xF0, 0x3F, 0xF0, 0x71,
  0xE0, 0xE1, 0xE3, 0xC1, 0xC7, 0x03, 0x8E, 0x07, 0x1C, 0x0E, 0x78, 0x1C,
  0xF0, 0x79, 0xC0, 0xF3, 0x81, 0xC7, 0x07, 0x9E, 0x1E, 0x38, 0x7C, 0x7F,
  0xF0, 0xFF, 0x83, 0xFC, 0x00, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1C, 0x00,
  0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1F, 0xE1, 0xFF, 0x0F, 0xF8, 0x70,
  0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0x7F, 0xC3, 0xFE, 0x3F, 0xF0,
  0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x01, 0xFF, 0x0F, 0xF8, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x00, 0x00, 0xF8, 0x07, 0xFC, 0x3F,
  0xF8, 0xF8, 0x21, 0xE0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x00,
  0xE1, 0xFB, 0xC3, 0xF7, 0x81, 0xEF, 0x03, 0x9E, 0x07, 0x1C, 0x0E, 0x3C,
  0x1C, 0x7F, 0xF8, 0x7F, 0xE0, 0x7F, 0x80, 0x1E, 0x0F, 0x1C, 0x0E, 0x1C,
  0x0E, 0x1C, 0x0E, 0x1C, 0x0E, 0x3C, 0x1E, 0x38, 0x1C, 0x38, 0x1C, 0x3F,
  0xFC, 0x3F, 0xFC, 0x7F, 0xFC, 0x70, 0x38, 0x70, 0x38, 0x70, 0x38, 0xF0,
  0x78, 0xE0, 0x70, 0xE0, 0x70, 0xE0, 0x70, 0xE0, 0x70, 0x0F, 0xE1, 0xFC,
  0x3F, 0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x1C, 0x1F, 0xE3, 0xFC, 0x00,
  0x00, 0x70, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x78,
  0x07, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x0E, 0x0B, 0xE0, 0xFC, 0x0F, 0x80,
  0x1E, 0x0E, 0x38, 0x38, 0x70, 0xF0, 0xE3, 0xC1, 0xCF, 0x07, 0x1C, 0x0E,
  0x70, 0x1D, 0xE0, 0x3F, 0x80, 0x7E, 0x01, 0xFE, 0x03, 0xDC, 0x07, 0x38,
  0x0E, 0x78, 0x3C, 0x70, 0x70, 0xE0, 0xE1, 0xE1, 0xC1, 0xC3, 0x83, 0xC0,
  0x0F, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x07, 0x81, 0xC0, 0x70, 0x1C, 0x0F,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x07, 0x81, 0xC0, 0x7F, 0xDF, 0xFF, 0xFC,
  0x0F, 0x80, 0x78, 0x7C, 0x07, 0xC3, 0xE0, 0x3E, 0x1F, 0x03, 0xE0, 0xF8,
  0x1F, 0x0F, 0xC1, 0xF8, 0x7E, 0x0D, 0xC3, 0xB0, 0xEE, 0x1D, 0x86, 0xE1,
  0xCC, 0x77, 0x0E, 0x63, 0x38, 0x73, 0x39, 0xC3, 0x99, 0x8E, 0x1C, 0xDC,
  0xE1, 0xC7, 0xC7, 0x0E, 0x3E, 0x38, 0x71, 0xE1, 0xC3, 0x8F, 0x1C, 0x38,
  0x70, 0xE0, 0x0F, 0x01, 0xC3, 0xC0, 0x60, 0xF8, 0x38, 0x3E, 0x0E, 0x0F,
  0x83, 0x87, 0xE0, 0xE1, 0xDC, 0x70, 0x77, 0x1C, 0x1D, 0xC7, 0x0E, 0x39,
  0xC3, 0x8E, 0x70, 0xE3, 0xB8, 0x38, 0xEE, 0x0E, 0x1F, 0x87, 0x07, 0xE1,
  0xC1, 0xF8, 0x70, 0x3C, 0x1C, 0x0F, 0x0F, 0x03, 0xC0, 0x01, 0xE0, 0x0F,
  0xF0, 0x3F, 0xF0, 0xF0, 0xF3, 0xC0, 0xE7, 0x01, 0xDE, 0x03, 0xBC, 0x07,
  0x70, 0x0E, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0xFF, 0x01, 0xDE, 0x03, 0x9C,
  0x0F, 0x38, 0x3C, 0x7F, 0xF0, 0x7F, 0xC0, 0x7F, 0x00, 0x0F, 0xC0, 0x3F,
  0xE0, 0xFF, 0xC3, 0x8F, 0x0E, 0x1C, 0x78, 0x71, 0xC1, 0xC7, 0x07, 0x1C,
  0x3C, 0xFF, 0xE3, 0xFF, 0x0F, 0xF0, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x0F, 0xF0, 0x3F,
  0xF0, 0xF0, 0xF3, 0xC0, 0xE7, 0x81, 0xDE, 0x03, 0xBC, 0x07, 0x70, 0x0E,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0xFF, 0x01, 0xDE, 0x03, 0x9C, 0x0F, 0x38,
  0x3C, 0x7F, 0xF0, 0x7F, 0xC0, 0x7F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C,
  0x00, 0x3C, 0x00, 0x0F, 0xC0, 0x3F, 0xC0, 0xFF, 0x83, 0x8F, 0x0E, 0x1C,
  0x78, 0x71, 0xC1, 0xC7, 0x0F, 0x1C, 0x78, 0xFF, 0xC3, 0xFE, 0x0F, 0xF0,
  0x39, 0xC0, 0xE3, 0x87, 0x8E, 0x1C, 0x38, 0x70, 0xF1, 0xC1, 0xCF, 0x07,
  0x80, 0x03, 0xE0, 0x7F, 0xC7, 0xFC, 0x3C, 0x21, 0xC0, 0x1E, 0x00, 0x70,
  0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x70,
  0x03, 0x90, 0x3C, 0xFF, 0xC7, 0xFC, 0x1F, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xF0, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x78, 0x07, 0x00, 0x70,
  0x00, 0x38, 0x1E, 0x70, 0x38, 0xE0, 0x71, 0xC0, 0xE7, 0x83, 0xCE, 0x07,
  0x1C, 0x0E, 0x38, 0x1C, 0x70, 0x39, 0xE0, 0xF3, 0x81, 0xC7, 0x03, 0x8E,
  0x07, 0x1C, 0x1E, 0x38, 0x38, 0x70, 0xF0, 0xFF, 0xC1, 0xFF, 0x80, 0xFC,
  0x00, 0xE0, 0x1F, 0x80, 0xEE, 0x03, 0x9C, 0x1E, 0x70, 0x71, 0xC3, 0xC7,
  0x0E, 0x1C, 0x78, 0x71, 0xC1, 0xCF, 0x07, 0x38, 0x1C, 0xE0, 0x77, 0x01,
  0xDC, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x00, 0xE0,
  0x70, 0x3F, 0x03, 0x81, 0xF8, 0x1C, 0x1D, 0xC1, 0xE0, 0xEE, 0x0F, 0x0F,
  0x30, 0xF8, 0x71, 0x86, 0xC3, 0x8C, 0x76, 0x38, 0x63, 0xB1, 0xC3, 0x39,
  0x9C, 0x19, 0xCC, 0xE0, 0xCC, 0x67, 0x06, 0xE3, 0x70, 0x36, 0x1B, 0x81,
  0xF0, 0xF8, 0x0F, 0x87, 0xC0, 0x78, 0x3C, 0x03, 0xC1, 0xE0, 0x1C, 0x0F,
  0x00, 0x0E, 0x07, 0x0E, 0x0F, 0x0F, 0x0E, 0x07, 0x1C, 0x07, 0x3C, 0x07,
  0x38, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07,
  0xE0, 0x0E, 0xE0, 0x1E, 0xE0, 0x1C, 0xF0, 0x38, 0x70, 0x78, 0x70, 0x70,
  0x70, 0xE0, 0x78, 0xF0, 0x3B, 0x83, 0x9C, 0x3C, 0xE1, 0xC7, 0x1E, 0x38,
  0xE0, 0xEE, 0x07, 0xF0, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0x38, 0x01, 0xC0,
  0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0x0F, 0xFE,
  0x1F, 0xFC, 0x3F, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00,
  0xF0, 0x01, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0,
  0x0F, 0x00, 0x1C, 0x00, 0x7F, 0xF0, 0xFF, 0xC3, 0xFF, 0x80, 0x07, 0xE0,
  0xFC, 0x1F, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x06, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xF8, 0x3F, 0x00, 0xC7, 0x39, 0xCE, 0x71, 0x8C, 0x73,
  0x9C, 0xE7, 0x18, 0xC7, 0x39, 0xCE, 0x07, 0xE0, 0xF8, 0x1F, 0x00, 0xE0,
  0x1C, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0xF8,
  0x3F, 0x00, 0x01, 0x80, 0x0C, 0x00, 0xF0, 0x0F, 0x80, 0x6C, 0x07, 0x70,
  0x33, 0x83, 0x8C, 0x38, 0x71, 0x83, 0x9C, 0x0D, 0xC0, 0x70, 0xFF, 0xFF,
  0xE0, 0xE7, 0x9C, 0x70, 0x0F, 0x38, 0xFD, 0x8F, 0x3C, 0xF1, 0xE7, 0x0F,
  0x38, 0x73, 0xC3, 0x9C, 0x1C, 0xE0, 0xE7, 0x0F, 0x38, 0x71, 0xEF, 0x87,
  0xFC, 0x3E, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0E,
  0x00, 0x77, 0xC3, 0xFE, 0x1E, 0x78, 0xE1, 0xCF, 0x0E, 0x70, 0x73, 0x83,
  0x9C, 0x3D, 0xE1, 0xCE, 0x0E, 0x78, 0xF3, 0xCF, 0x1B, 0xF1, 0xDF, 0x00,
  0x0F, 0xE3, 0xF8, 0xF3, 0x3C, 0x07, 0x01, 0xE0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x7D, 0x87, 0xF0, 0x7E, 0x00, 0x00, 0x1C, 0x00, 0xF0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0xF7, 0x07, 0xFC, 0x3C, 0xF1,
  0xE3, 0xC7, 0x0F, 0x1C, 0x38, 0xE0, 0xE3, 0x83, 0x8E, 0x0E, 0x38, 0x78,
  0xE1, 0xC3, 0xDF, 0x07, 0xFC, 0x1F, 0x70, 0x0F, 0xC3, 0xFC, 0xE3, 0xBC,
  0x77, 0x0F, 0xE7, 0xBF, 0xF7, 0xF8, 0xE0, 0x1C, 0x03, 0x80, 0x78, 0x47,
  0xF8, 0x7F, 0x00, 0x00, 0x3C, 0x03, 0xF0, 0x0F, 0xC0, 0x78, 0x01, 0xC0,
  0x07, 0x00, 0x7F, 0x03, 0xFC, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x2F, 0x00, 0xF8, 0x03, 0xC0,
  0x00, 0x07, 0x9C, 0x3F, 0x61, 0xE7, 0x8F, 0x1E, 0x38, 0x78, 0xE1, 0xC7,
  0x87, 0x1C, 0x1C, 0x70, 0x71, 0xC3, 0xC7, 0x1E, 0x1E, 0xF8, 0x7F, 0xE0,
  0xFB, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC3, 0x1E, 0x0F, 0xF8, 0x3F, 0x80,
  0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x77, 0xC3,
  0xFF, 0x1E, 0x78, 0xE1, 0xCF, 0x0E, 0x70, 0xF3, 0x87, 0x1C, 0x39, 0xE1,
  0xCE, 0x0E, 0x70, 0xF3, 0x87, 0x1C, 0x39, 0xE1, 0xC0, 0x04, 0x1C, 0x38,
  0x70, 0x00, 0x07, 0x0E, 0x1C, 0x38, 0xE1, 0xC3, 0x87, 0x1E, 0x38, 0x70,
  0xE1, 0xC7, 0x80, 0x00, 0x80, 0x70, 0x1C, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0xF0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x78, 0x1C, 0x07, 0x01, 0xC3, 0xF0, 0xF8, 0x3C, 0x00,
  0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC3,
  0xC7, 0x1C, 0x1C, 0xF0, 0x77, 0x83, 0xBC, 0x0F, 0xE0, 0x3F, 0x80, 0xFE,
  0x07, 0xB8, 0x1C, 0xF0, 0x71, 0xC1, 0xC7, 0x07, 0x1E, 0x38, 0x38, 0x0F,
  0x0E, 0x0E, 0x0E, 0x0E, 0x1E, 0x1C, 0x1C, 0x1C, 0x1C, 0x38, 0x38, 0x38,
  0x38, 0x78, 0x70, 0x70, 0x70, 0x70, 0xF0, 0x1D, 0xF3, 0xE1, 0xFF, 0x7F,
  0x1E, 0x7E, 0xF1, 0xC3, 0x87, 0x3C, 0x78, 0x73, 0x87, 0x0F, 0x38, 0x70,
  0xE3, 0x87, 0x0E, 0x78, 0x70, 0xE7, 0x0F, 0x0E, 0x70, 0xE1, 0xC7, 0x0E,
  0x1C, 0x70, 0xE1, 0xCE, 0x0E, 0x1C, 0x1D, 0xF0, 0xFF, 0xC7, 0xDE, 0x38,
  0x73, 0xC3, 0x9C, 0x3C, 0xE1, 0xC7, 0x0E, 0x78, 0x73, 0x83, 0x9C, 0x3C,
  0xE1, 0xC7, 0x0E, 0x78, 0x70, 0x0F, 0xC1, 0xFE, 0x3D, 0xE7, 0x8F, 0x70,
  0x7F, 0x07, 0xE0, 0xFE, 0x0E, 0xE0, 0xEE, 0x0E, 0xE1, 0xCF, 0x7C, 0x7F,
  0x83, 0xF0, 0x0E, 0xF8, 0x3F, 0xE0, 0xF3, 0xC3, 0x87, 0x1E, 0x1C, 0x70,
  0x71, 0xC1, 0xC7, 0x0F, 0x3C, 0x38, 0xE0, 0xE3, 0xC7, 0x8F, 0x3C, 0x3F,
  0xE1, 0xCF, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38,
  0x00, 0x0F, 0xB8, 0xFD, 0x8F, 0x3C, 0xF1, 0xE7, 0x0F, 0x38, 0x73, 0x83,
  0x9C, 0x1C, 0xE0, 0xE7, 0x0F, 0x38, 0x71, 0xEF, 0x87, 0xFC, 0x3E, 0xE0,
  0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x1D, 0xE3,
  0xF8, 0x7F, 0x0F, 0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x78, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x01, 0xE0, 0x00, 0x1F, 0xE7, 0xF8, 0xE3, 0x1C, 0x03,
  0x80, 0x78, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0x70, 0x0E, 0x63, 0xCF, 0xF1,
  0xFC, 0x00, 0x0C, 0x0E, 0x07, 0x0F, 0xFF, 0xF1, 0xC0, 0xE0, 0xF0, 0x70,
  0x38, 0x1C, 0x0E, 0x0E, 0x07, 0x03, 0xD1, 0xF8, 0x7C, 0x00, 0x38, 0x79,
  0xC3, 0x8E, 0x1C, 0xE0, 0xE7, 0x07, 0x38, 0x71, 0xC3, 0x8E, 0x1C, 0xE0,
  0xE7, 0x0F, 0x38, 0x71, 0xEF, 0x8F, 0xFC, 0x3E, 0xE0, 0xE0, 0x76, 0x0E,
  0x70, 0xE7, 0x1C, 0x71, 0xC7, 0x38, 0x73, 0x87, 0x70, 0x77, 0x07, 0xE0,
  0x7E, 0x07, 0xC0, 0x7C, 0x03, 0x80, 0xE3, 0xC3, 0xF1, 0xE1, 0xF8, 0xF1,
  0xDC, 0xF8, 0xEC, 0x6C, 0xE6, 0x76, 0x73, 0x33, 0x31, 0xB9, 0xB8, 0xDC,
  0xDC, 0x6C, 0x7C, 0x3E, 0x3E, 0x1E, 0x1E, 0x0F, 0x0F, 0x07, 0x07, 0x00,
  0x1C, 0x3C, 0x38, 0xE0, 0xE7, 0x03, 0xB8, 0x07, 0xE0, 0x1F, 0x00, 0x78,
  0x01, 0xE0, 0x0F, 0x80, 0x77, 0x03, 0xDC, 0x0E, 0x78, 0x70, 0xE3, 0xC3,
  0x80, 0x1E, 0x0E, 0x1C, 0x38, 0x38, 0x70, 0x71, 0xC0, 0xE3, 0x81, 0xCE,
  0x03, 0x9C, 0x07, 0x70, 0x0E, 0xE0, 0x1D, 0x80, 0x1F, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x01, 0x78, 0x03, 0xE0,
  0x07, 0x80, 0x00, 0x0F, 0xF1, 0xFF, 0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x38, 0x07, 0x80, 0x7F, 0xCF, 0xF8,
  0x00, 0x20, 0x78, 0x1F, 0x03, 0x80, 0x70, 0x0C, 0x03, 0x80, 0x70, 0x0E,
  0x03, 0x81, 0xF0, 0x78, 0x0F, 0x80, 0x70, 0x06, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x78, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x08, 0x03, 0xC0, 0xF0, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x06, 0x01, 0xC0, 0x78, 0x0F, 0x07, 0x83, 0xC1,
  0xC0, 0x70, 0x1C, 0x07, 0x03, 0x80, 0xE0, 0x78, 0x3C, 0x0E, 0x00, 0x7C,
  0x1F, 0xFF, 0xCF, 0xF8, 0x1C,
};

const GFXglyph NotoSans_SemiCondensed_SemiBoldItalic26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 8, 19, 7, 0, -19 },
  { 20, 8, 7, 11, 3, -19 },
  { 27, 15, 19, 15, 0, -19 },
  { 63, 13, 22, 13, 0, -20 },
  { 99, 17, 19, 20, 2, -19 },
  { 140, 16, 19, 16, 0, -19 },
  { 178, 4, 7, 6, 3, -19 },
  { 182, 9, 23, 8, 1, -19 },
  { 208, 9, 23, 8, -2, -19 },
  { 234, 11, 12, 13, 2, -20 },
  { 251, 12, 12, 14, 1, -15 },
  { 269, 5, 6, 7, -1, -3 },
  { 273, 7, 2, 8, 0, -8 },
  { 275, 4, 4, 7, 0, -4 },
  { 277, 13, 19, 10, -1, -19 },
  { 308, 12, 19, 13, 1, -19 },
  { 337, 8, 19, 13, 3, -19 },
  { 356, 14, 19, 13, -1, -19 },
  { 390, 13, 19, 13, 0, -19 },
  { 421, 13, 19, 13, 0, -19 },
  { 452, 13, 19, 13, 0, -19 },
  { 483, 12, 19, 13, 1, -19 },
  { 512, 13, 19, 13, 1, -19 },
  { 543, 12, 19, 13, 1, -19 },
  { 572, 12, 19, 13, 1, -19 },
  { 601, 6, 14, 7, 0, -14 },
  { 612, 7, 17, 7, -1, -14 },
  { 627, 12, 13, 14, 1, -16 },
  { 647, 12, 8, 14, 1, -13 },
  { 659, 12, 13, 14, 1, -16 },
  { 679, 10, 19, 10, 1, -19 },
  { 703, 19, 21, 20, 1, -19 },
  { 753, 15, 19, 14, -2, -19 },
  { 789, 14, 19, 14, 0, -19 },
  { 823, 14, 19, 14, 1, -19 },
  { 857, 15, 19, 16, 0, -19 },
  { 893, 13, 19, 12, 0, -19 },
  { 924, 13, 19, 12, 0, -19 },
  { 955, 15, 19, 16, 1, -19 },
  { 991, 16, 19, 16, 1, -19 },
  { 1029, 11, 19, 9, -1, -19 },
  { 1056, 12, 24, 7, -4, -19 },
  { 1092, 15, 19, 14, 1, -19 },
  { 1128, 10, 19, 12, 0, -19 },
  { 1152, 21, 19, 21, 0, -19 },
  { 1202, 18, 19, 17, 0, -19 },
  { 1245, 15, 19, 17, 1, -19 },
  { 1281, 14, 19, 14, 0, -19 },
  { 1315, 15, 23, 17, 1, -19 },
  { 1359, 14, 19, 14, 0, -19 },
  { 1393, 13, 19, 12, 0, -19 },
  { 1424, 12, 19, 12, 2, -19 },
  { 1453, 15, 19, 16, 2, -19 },
  { 1489, 14, 19, 14, 2, -19 },
  { 1523, 21, 19, 21, 2, -19 },
  { 1573, 16, 19, 13, -1, -19 },
  { 1611, 13, 19, 13, 2, -19 },
  { 1642, 15, 19, 12, -1, -19 },
  { 1678, 11, 23, 8, -1, -19 },
  { 1710, 5, 19, 10, 3, -19 },
  { 1722, 11, 23, 8, -2, -19 },
  { 1754, 13, 12, 13, 0, -19 },
  { 1774, 10, 2, 10, -2, 2 },
  { 1777, 5, 4, 8, 4, -20 },
  { 1780, 13, 14, 14, 1, -14 },
  { 1803, 13, 20, 14, 0, -20 },
  { 1836, 11, 14, 11, 1, -14 },
  { 1856, 14, 20, 14, 1, -20 },
  { 1891, 11, 14, 13, 1, -14 },
  { 1911, 14, 26, 8, -3, -20 },
  { 1957, 14, 20, 14, 0, -14 },
  { 1992, 13, 20, 14, 0, -20 },
  { 2025, 7, 20, 7, 0, -20 },
  { 2043, 10, 26, 7, -3, -20 },
  { 2076, 14, 20, 13, 0, -20 },
  { 2111, 8, 20, 7, 0, -20 },
  { 2131, 20, 14, 21, 0, -14 },
  { 2166, 13, 14, 14, 0, -14 },
  { 2189, 12, 14, 14, 1, -14 },
  { 2210, 14, 20, 14, -1, -14 },
  { 2245, 13, 20, 14, 1, -14 },
  { 2278, 11, 14, 10, 0, -14 },
  { 2298, 11, 14, 11, 0, -14 },
  { 2318, 9, 17, 9, 1, -17 },
  { 2338, 13, 14, 14, 1, -14 },
  { 2361, 12, 14, 12, 1, -14 },
  { 2382, 17, 14, 18, 2, -14 },
  { 2412, 14, 14, 12, -1, -14 },
  { 2437, 15, 20, 12, -2, -14 },
  { 2475, 12, 14, 11, -1, -14 },
  { 2496, 11, 23, 9, 0, -19 },
  { 2528, 3, 26, 13, 5, -20 },
  { 2538, 10, 23, 9, -1, -19 },
  { 2567, 12, 4, 14, 1, -11 },
};

const GFXfont NotoSans_SemiCondensed_SemiBoldItalic26pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_SemiBoldItalic26pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_SemiBoldItalic26pt7bGlyphs,
  0x20, 0x7E, 35
};

#endif // _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC26PT7B_H_
