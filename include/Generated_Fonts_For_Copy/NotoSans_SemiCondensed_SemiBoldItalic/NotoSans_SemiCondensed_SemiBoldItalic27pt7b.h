#ifndef _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC27PT7B_H_
#define _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC27PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-SemiBoldItalic.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_SemiBoldItalic27pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x0E, 0x0E, 0x1E, 0x1E, 0x1C, 0x1C, 0x1C, 0x1C, 0x38, 0x38,
  0x38, 0x38, 0x00, 0x00, 0x60, 0x70, 0xF0, 0xF0, 0x77, 0xF3, 0xB9, 0xDC,
  0xEE, 0x66, 0x33, 0x18, 0x01, 0xCE, 0x01, 0x8C, 0x03, 0x8C, 0x03, 0x9C,
  0x03, 0x18, 0x3F, 0xFF, 0x3F, 0xFF, 0x06, 0x30, 0x06, 0x30, 0x0E, 0x70,
  0x0C, 0x70, 0x7F, 0xFC, 0x7F, 0xFC, 0x9C, 0xE0, 0x18, 0xC0, 0x18, 0xC0,
  0x39, 0xC0, 0x31, 0x80, 0x31, 0x80, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x01,
  0xFF, 0x0F, 0xF8, 0x7A, 0xE1, 0xD8, 0x07, 0x60, 0x1D, 0x80, 0x7C, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x27, 0x00, 0x9C, 0x46, 0xF1,
  0xFF, 0x8F, 0xFC, 0x0F, 0xC0, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x08,
  0x00, 0x0F, 0x81, 0xC7, 0xF0, 0x61, 0x9C, 0x38, 0xE7, 0x1C, 0x39, 0xC6,
  0x0C, 0x73, 0x83, 0x19, 0xC0, 0xC6, 0x67, 0x33, 0xBB, 0xEF, 0xDD, 0xDF,
  0xE6, 0x67, 0x23, 0xB9, 0xC1, 0xCE, 0x70, 0x63, 0x1C, 0x38, 0xC6, 0x1C,
  0x33, 0x86, 0x0C, 0xE3, 0x83, 0xF1, 0xC0, 0x78, 0x00, 0x80, 0x0F, 0xC0,
  0x3F, 0xC0, 0x73, 0x81, 0xC7, 0x03, 0x8E, 0x07, 0x1C, 0x0E, 0xF0, 0x0F,
  0xC0, 0x1F, 0x00, 0xFC, 0x3B, 0xFC, 0x7F, 0x39, 0xDC, 0x7F, 0xB8, 0x7E,
  0x70, 0x78, 0xE0, 0xF1, 0xFF, 0xE3, 0xFF, 0xE3, 0xF9, 0xE0, 0x7E, 0xEE,
  0xEC, 0xC0, 0x07, 0x83, 0x83, 0x83, 0x81, 0xC1, 0xC0, 0xE0, 0xE0, 0x70,
  0x38, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x03, 0x01, 0xC0, 0x07, 0x03, 0x80, 0xC0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x1C, 0x0E, 0x07, 0x07,
  0x03, 0x83, 0x81, 0xC1, 0xC1, 0xC1, 0xE0, 0x02, 0x00, 0x38, 0x03, 0x06,
  0x70, 0x7F, 0x0F, 0xFF, 0x0F, 0xF1, 0xF1, 0x3B, 0x07, 0xB8, 0x31, 0x81,
  0x1C, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x00, 0x3C,
  0xE7, 0x1C, 0x63, 0x8C, 0x00, 0x7F, 0x7E, 0xFE, 0x77, 0xFF, 0x00, 0x3C,
  0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0,
  0x03, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x03, 0x80,
  0x0E, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x01, 0x00, 0x7E, 0x0F,
  0xF1, 0xEF, 0x3C, 0x73, 0x87, 0x78, 0x77, 0x07, 0x70, 0x7F, 0x07, 0xF0,
  0x7E, 0x0F, 0xE0, 0xFE, 0x0E, 0xE0, 0xEE, 0x1C, 0xE3, 0xCF, 0xF8, 0x7F,
  0x83, 0xE0, 0x07, 0x87, 0xCF, 0xCF, 0xEF, 0x73, 0x38, 0x3C, 0x1C, 0x0E,
  0x07, 0x07, 0x83, 0x81, 0xC0, 0xE0, 0x70, 0x78, 0x38, 0x1C, 0x0E, 0x00,
  0x00, 0x40, 0x0F, 0xE0, 0xFF, 0xC3, 0xCF, 0x04, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xFF, 0xC7, 0xFF, 0x3F, 0xFC, 0x00,
  0x80, 0x7F, 0x87, 0xFE, 0x18, 0xF0, 0x83, 0x80, 0x1C, 0x00, 0xE0, 0x0F,
  0x01, 0xF0, 0x7E, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xC0,
  0x1E, 0x80, 0xE7, 0xBF, 0x3F, 0xF0, 0xFE, 0x00, 0x00, 0x78, 0x03, 0xC0,
  0x3E, 0x03, 0xF0, 0x3F, 0x03, 0xB8, 0x1D, 0xC1, 0xCE, 0x1C, 0xE1, 0xC7,
  0x0E, 0x38, 0xE1, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x38, 0x01, 0xC0,
  0x1E, 0x00, 0xE0, 0x07, 0xFC, 0x3F, 0xE0, 0xFF, 0x83, 0x80, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0x0F, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x0F, 0x20, 0x78, 0xFF, 0xE3, 0xFF, 0x07, 0xF0,
  0x00, 0x00, 0x20, 0x1F, 0xC1, 0xFE, 0x1E, 0x01, 0xE0, 0x1E, 0x00, 0xE0,
  0x0F, 0x00, 0x77, 0xC3, 0xFF, 0x1F, 0x79, 0xE1, 0xCF, 0x0F, 0x70, 0x73,
  0x83, 0x9C, 0x1C, 0xF1, 0xE3, 0xFE, 0x1F, 0xE0, 0x7E, 0x00, 0x3F, 0xFC,
  0xFF, 0xE3, 0xFF, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x70,
  0x03, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0,
  0x0F, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x01, 0x80, 0x7F, 0x07,
  0xFC, 0x38, 0xF3, 0x87, 0x9C, 0x3C, 0xE1, 0xC7, 0x9E, 0x1F, 0xE0, 0x7C,
  0x07, 0xE0, 0xFF, 0x8F, 0x1E, 0x70, 0x73, 0x83, 0x9C, 0x1C, 0xE1, 0xE7,
  0x9E, 0x3F, 0xF0, 0x7E, 0x00, 0x03, 0x00, 0xFE, 0x1F, 0xE3, 0xCF, 0x38,
  0x77, 0x07, 0x70, 0x77, 0x07, 0x70, 0xF7, 0x0F, 0x7F, 0xF3, 0xFE, 0x1E,
  0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x8D, 0xF8, 0xFF, 0x0F, 0xC0, 0x0C,
  0x3C, 0x70, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x0F, 0x1E, 0x3C,
  0x00, 0x06, 0x0F, 0x0E, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x38, 0x70, 0x70, 0xE0, 0xE0, 0xC0, 0x00, 0x18, 0x03, 0xC0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xF0, 0x00, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x3E, 0x0F, 0xC1, 0xF8, 0x3F, 0x01, 0xE0,
  0x08, 0x00, 0x00, 0x04, 0x1F, 0xEF, 0xF9, 0x8F, 0x01, 0xC0, 0x70, 0x38,
  0x1E, 0x0F, 0x07, 0x83, 0xC0, 0xE0, 0x70, 0x1C, 0x00, 0x00, 0x00, 0x60,
  0x38, 0x0E, 0x03, 0x80, 0x00, 0xFF, 0x00, 0x7F, 0xF0, 0x3C, 0x07, 0x07,
  0x00, 0x71, 0x80, 0x06, 0x70, 0xFC, 0xCC, 0x7F, 0x9B, 0x9C, 0x63, 0x63,
  0x0C, 0x7C, 0xE3, 0x8F, 0x9C, 0x71, 0xF3, 0x0C, 0x7C, 0x63, 0x8D, 0x8C,
  0x73, 0xB9, 0xFF, 0xE7, 0x1E, 0x78, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x10, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x1D, 0xC0, 0x3B, 0x80, 0x77, 0x01, 0xCE, 0x03, 0x9C, 0x0E,
  0x38, 0x1C, 0x38, 0x7F, 0xF0, 0xFF, 0xE3, 0xFF, 0xC7, 0x03, 0x9C, 0x07,
  0x38, 0x0E, 0xF0, 0x1F, 0xC0, 0x38, 0x1F, 0xF0, 0x7F, 0xE1, 0xCF, 0xC7,
  0x0F, 0x1C, 0x1C, 0xF0, 0xF3, 0x83, 0x8E, 0x3E, 0x3F, 0xE0, 0xFF, 0x87,
  0x8F, 0x1C, 0x1C, 0x70, 0x79, 0xC1, 0xEF, 0x07, 0x38, 0x3C, 0xFF, 0xE3,
  0xFF, 0x0F, 0xF8, 0x00, 0x00, 0x20, 0x07, 0xFC, 0x1F, 0xF0, 0x7C, 0xE1,
  0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00,
  0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x00, 0x1F, 0xF0, 0x3F, 0xF0, 0x7F, 0xF0,
  0xE1, 0xE1, 0xC1, 0xE7, 0x83, 0xCE, 0x07, 0x9C, 0x0F, 0x38, 0x1E, 0x70,
  0x3D, 0xE0, 0x73, 0x80, 0xE7, 0x03, 0xCE, 0x0F, 0x3C, 0x1E, 0x78, 0xF8,
  0xFF, 0xE1, 0xFF, 0x83, 0xFC, 0x00, 0x1F, 0xF8, 0xFF, 0xC7, 0xFC, 0x38,
  0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x3F, 0xE1, 0xFF, 0x1E, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xFF, 0xC7, 0xFC, 0x3F,
  0xE0, 0x1F, 0xF8, 0xFF, 0xC7, 0xFC, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x00, 0x3F, 0xE1, 0xFF, 0x1F, 0xF0, 0xE0, 0x07, 0x00, 0x38, 0x03,
  0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0x00, 0x20, 0x03, 0xFF,
  0x07, 0xFE, 0x0F, 0x8E, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x70, 0xFE, 0x70, 0xFE, 0x70, 0xFC, 0xF0, 0x1C, 0xF0, 0x1C,
  0xF0, 0x3C, 0x70, 0x38, 0x78, 0x38, 0x7F, 0xF8, 0x3F, 0xF8, 0x0F, 0xF0,
  0x1E, 0x07, 0x1E, 0x07, 0x1C, 0x0F, 0x1C, 0x0F, 0x1C, 0x0E, 0x3C, 0x0E,
  0x38, 0x0E, 0x38, 0x1E, 0x3F, 0xFC, 0x3F, 0xFC, 0x78, 0x1C, 0x70, 0x3C,
  0x70, 0x3C, 0x70, 0x38, 0xF0, 0x38, 0xF0, 0x38, 0xE0, 0x78, 0xE0, 0x78,
  0xE0, 0x70, 0x0F, 0xF0, 0xFE, 0x03, 0x80, 0x38, 0x07, 0x80, 0x70, 0x07,
  0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1C,
  0x01, 0xC0, 0x1C, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0x70, 0x0F, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0xC0,
  0x3C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x78, 0x07, 0x00, 0x70, 0x07, 0x00,
  0xF0, 0x0F, 0x0B, 0xE0, 0xFE, 0x0F, 0xC0, 0x20, 0x00, 0x1E, 0x0F, 0x1C,
  0x1C, 0x1C, 0x3C, 0x1C, 0x78, 0x1C, 0xF0, 0x3D, 0xE0, 0x39, 0xC0, 0x3B,
  0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x80, 0x7B, 0xC0, 0x73, 0xC0, 0x71,
  0xC0, 0xF1, 0xE0, 0xF1, 0xE0, 0xE0, 0xE0, 0xE0, 0xF0, 0xE0, 0xF0, 0x1E,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x0F, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x07,
  0x81, 0xC0, 0x70, 0x1C, 0x0F, 0x03, 0xC0, 0xFF, 0xFF, 0xEF, 0xF8, 0x1F,
  0x00, 0xF8, 0xF8, 0x0F, 0x87, 0xC0, 0x7C, 0x3E, 0x07, 0xE1, 0xB0, 0x3F,
  0x1D, 0x83, 0xB8, 0xEC, 0x1F, 0x87, 0x61, 0xDC, 0x3B, 0x8E, 0xE1, 0xDC,
  0xE7, 0x1C, 0xE7, 0x78, 0xE7, 0x73, 0x87, 0x3B, 0x9C, 0x39, 0xF8, 0xE3,
  0x8F, 0xC7, 0x1C, 0x7C, 0x78, 0xE3, 0xE3, 0x87, 0x1E, 0x1C, 0x38, 0x70,
  0xE0, 0x1E, 0x03, 0x8F, 0x81, 0xC7, 0xC0, 0xE3, 0xE0, 0x71, 0xB8, 0x71,
  0xDC, 0x38, 0xEE, 0x1C, 0x77, 0x0E, 0x39, 0xCF, 0x1C, 0xE7, 0x1C, 0x73,
  0x8E, 0x1D, 0xC7, 0x0E, 0xE3, 0x87, 0x63, 0x83, 0xF1, 0xC0, 0xF8, 0xE0,
  0x7C, 0x70, 0x3E, 0x38, 0x1E, 0x00, 0x00, 0x40, 0x03, 0xFC, 0x07, 0xFE,
  0x0F, 0x9E, 0x1E, 0x0F, 0x3C, 0x0F, 0x38, 0x07, 0x78, 0x07, 0x78, 0x07,
  0x70, 0x0F, 0x70, 0x0F, 0x70, 0x0F, 0xF0, 0x0E, 0xF0, 0x1E, 0xF0, 0x1E,
  0x70, 0x3C, 0x78, 0x78, 0x7F, 0xF8, 0x3F, 0xF0, 0x1F, 0xC0, 0x1F, 0xF0,
  0x7F, 0xE1, 0xFF, 0x87, 0x0F, 0x1C, 0x3C, 0xF0, 0xF3, 0x83, 0xCE, 0x0E,
  0x38, 0x78, 0xFF, 0xC7, 0xFE, 0x1F, 0xE0, 0x70, 0x01, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x00, 0x40, 0x03, 0xFC,
  0x07, 0xFE, 0x0F, 0x9E, 0x1E, 0x0F, 0x3C, 0x0F, 0x38, 0x07, 0x78, 0x07,
  0x78, 0x07, 0x70, 0x0F, 0x70, 0x0F, 0x70, 0x0F, 0xF0, 0x0E, 0xF0, 0x1E,
  0xF0, 0x1E, 0x70, 0x3C, 0x78, 0x78, 0x7F, 0xF8, 0x3F, 0xF0, 0x1F, 0xC0,
  0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x1F, 0xE0,
  0x7F, 0xE1, 0xCF, 0x87, 0x0E, 0x1C, 0x3C, 0xF0, 0xE3, 0x83, 0x8E, 0x1E,
  0x39, 0xF0, 0xFF, 0x87, 0xFC, 0x1C, 0xF0, 0x71, 0xC1, 0xC7, 0x0F, 0x1E,
  0x3C, 0x78, 0xE0, 0xE3, 0x83, 0xCE, 0x0F, 0x00, 0x00, 0x80, 0x1F, 0xF0,
  0xFF, 0x87, 0xCE, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1E, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x81, 0xE3, 0xFF, 0x0F, 0xFC, 0x1F, 0xC0, 0x7F, 0xFF, 0xFF, 0xBF, 0xFC,
  0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0xC0,
  0x1C, 0x00, 0x3C, 0x0E, 0x70, 0x3C, 0xE0, 0x79, 0xC0, 0xE7, 0x81, 0xCF,
  0x03, 0x9C, 0x0F, 0x38, 0x1E, 0x70, 0x39, 0xE0, 0x73, 0x80, 0xE7, 0x03,
  0xCE, 0x07, 0x1C, 0x0E, 0x38, 0x3C, 0x70, 0x70, 0xFF, 0xE0, 0xFF, 0x80,
  0xFE, 0x00, 0xF0, 0x1E, 0xE0, 0x79, 0xC0, 0xE3, 0x83, 0xC7, 0x07, 0x0E,
  0x1E, 0x1C, 0x38, 0x38, 0x70, 0x71, 0xC0, 0xE3, 0x81, 0xCE, 0x03, 0x9C,
  0x07, 0x70, 0x0E, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0x78, 0x00,
  0xE0, 0x00, 0xE0, 0x70, 0x3F, 0x07, 0x83, 0xB8, 0x3C, 0x1D, 0xC3, 0xE1,
  0xEE, 0x1F, 0x0E, 0x71, 0xF8, 0xF3, 0x8F, 0xC7, 0x1C, 0xEE, 0x38, 0xE7,
  0x73, 0x87, 0x33, 0x9C, 0x3B, 0x9D, 0xE1, 0xDC, 0xEE, 0x0F, 0xC7, 0x70,
  0x7E, 0x3F, 0x03, 0x61, 0xF8, 0x1F, 0x0F, 0x80, 0xF0, 0x7C, 0x07, 0x83,
  0xE0, 0x3C, 0x1E, 0x00, 0x07, 0x83, 0xC1, 0xE1, 0xE0, 0x38, 0x70, 0x0E,
  0x38, 0x03, 0xDE, 0x00, 0x77, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0x70, 0x03, 0xDE, 0x00,
  0xE3, 0x80, 0x70, 0xE0, 0x3C, 0x3C, 0x1E, 0x0F, 0x0F, 0x01, 0xC0, 0xF0,
  0x3D, 0xC1, 0xE7, 0x0F, 0x1C, 0x38, 0x79, 0xE0, 0xE7, 0x03, 0xB8, 0x0E,
  0xE0, 0x3F, 0x00, 0xFC, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03,
  0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x00, 0x0F, 0xFE, 0x1F,
  0xFC, 0x3F, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x0F,
  0x00, 0x1C, 0x00, 0x7F, 0xF1, 0xFF, 0xE3, 0xFF, 0xC0, 0x07, 0xE0, 0xFC,
  0x1C, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xFC, 0x3F, 0x00, 0xE7, 0x39, 0xC6, 0x31, 0xCE, 0x73, 0x9C,
  0x63, 0x1C, 0xE7, 0x39, 0xC6, 0x07, 0xE0, 0xF8, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x30, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0xF8, 0x3F,
  0x00, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0xC0, 0x6E, 0x07, 0x30, 0x71,
  0xC3, 0x8E, 0x38, 0x31, 0x81, 0xDC, 0x0F, 0xC0, 0x30, 0xFF, 0xFF, 0xF0,
  0xE7, 0x9C, 0x71, 0x80, 0x07, 0x38, 0xFD, 0xCF, 0xFE, 0x79, 0xF7, 0x87,
  0x38, 0x3B, 0xC1, 0xDE, 0x1E, 0xE0, 0xE7, 0x07, 0x38, 0x79, 0xC3, 0xCF,
  0xFE, 0x3F, 0x61, 0xF7, 0x00, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x01, 0xEF, 0x07, 0x7E, 0x1F, 0xF8, 0x78, 0xE1, 0xC3,
  0xCF, 0x0E, 0x38, 0x38, 0xE0, 0xE3, 0x83, 0x9E, 0x1E, 0x78, 0x71, 0xE3,
  0xC7, 0xDE, 0x1B, 0xF8, 0xE7, 0x80, 0x07, 0xC3, 0xFC, 0xFF, 0x1E, 0x07,
  0x80, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x78, 0x0F, 0xB8,
  0xFF, 0x0F, 0xC0, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x3C,
  0x00, 0xE0, 0x73, 0x87, 0xEE, 0x3F, 0xF8, 0xE3, 0xE7, 0x87, 0x1C, 0x1C,
  0xF0, 0x73, 0xC1, 0xCE, 0x0E, 0x38, 0x38, 0xE1, 0xE3, 0x87, 0x8F, 0x7E,
  0x1F, 0xB0, 0x7C, 0xC0, 0x07, 0xC1, 0xFE, 0x3F, 0xE3, 0x87, 0x70, 0xF7,
  0x0E, 0xF7, 0xEF, 0xFC, 0xFE, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0xC7,
  0xFC, 0x3F, 0x80, 0x00, 0x18, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0x00, 0x1E,
  0x00, 0x38, 0x00, 0x7E, 0x03, 0xFC, 0x0F, 0xF0, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00,
  0x3C, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0x03, 0x9C, 0x3F, 0x71, 0xFF, 0xC7,
  0x9F, 0x3C, 0x38, 0xE0, 0xE7, 0x83, 0x9E, 0x1E, 0x70, 0x71, 0xC1, 0xC7,
  0x0F, 0x1C, 0x3C, 0x7F, 0xF0, 0xFF, 0x83, 0xEE, 0x00, 0x38, 0x01, 0xE0,
  0x07, 0x0C, 0x3C, 0x3F, 0xE0, 0xFF, 0x00, 0x07, 0x00, 0x78, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x7B, 0xC3, 0xBF, 0x1F, 0xF8, 0xF1, 0xC7,
  0x0E, 0x78, 0x73, 0x83, 0x9C, 0x1C, 0xE1, 0xEF, 0x0E, 0x70, 0x73, 0x83,
  0x9C, 0x1C, 0xE1, 0xEF, 0x0E, 0x00, 0x0F, 0x0F, 0x0E, 0x00, 0x00, 0x1E,
  0x1C, 0x1C, 0x1C, 0x1C, 0x3C, 0x38, 0x38, 0x38, 0x78, 0x78, 0x70, 0x70,
  0x70, 0xF0, 0x01, 0xE0, 0x3C, 0x07, 0x00, 0x00, 0x00, 0x07, 0x80, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x1E, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x78,
  0x0E, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xE0, 0xF8,
  0x1E, 0x00, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x01, 0xE1, 0xC7, 0x0E, 0x1C, 0x70, 0x73, 0xC1, 0xDE, 0x0E, 0xF0, 0x3F,
  0x80, 0xFE, 0x03, 0xF8, 0x1E, 0xF0, 0x71, 0xC1, 0xC7, 0x07, 0x1E, 0x1C,
  0x38, 0xF0, 0xF0, 0x07, 0x0F, 0x0E, 0x0E, 0x0E, 0x0E, 0x1E, 0x1C, 0x1C,
  0x1C, 0x1C, 0x3C, 0x38, 0x38, 0x38, 0x78, 0x78, 0x70, 0x70, 0x70, 0xF0,
  0x1C, 0xF1, 0xE0, 0xEF, 0xDF, 0x87, 0xFF, 0xFC, 0x3C, 0x78, 0xF1, 0xC3,
  0xC7, 0x9E, 0x1C, 0x38, 0xE0, 0xE1, 0xC7, 0x0F, 0x0E, 0x38, 0x70, 0x73,
  0xC3, 0x87, 0x9C, 0x1C, 0x38, 0xE0, 0xE1, 0xC7, 0x0E, 0x0E, 0x38, 0x70,
  0x73, 0xC3, 0x87, 0x80, 0x1C, 0xF0, 0xEF, 0xC7, 0xFE, 0x3C, 0x71, 0xC3,
  0x9E, 0x1C, 0xE0, 0xE7, 0x07, 0x38, 0x7B, 0xC3, 0x9C, 0x1C, 0xE0, 0xE7,
  0x07, 0x38, 0x7B, 0xC3, 0x80, 0x07, 0x81, 0xFE, 0x3F, 0xE3, 0x8F, 0x78,
  0x77, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0xEE, 0x1E, 0xFF,
  0xC7, 0xF8, 0x3F, 0x00, 0x0E, 0x70, 0x1D, 0xF8, 0x3F, 0xF0, 0x78, 0xE0,
  0xE1, 0xE3, 0xC3, 0x87, 0x07, 0x0E, 0x0E, 0x1C, 0x1C, 0x78, 0x78, 0xF0,
  0xE1, 0xE3, 0xC3, 0xEF, 0x07, 0xFE, 0x1E, 0xF0, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x00, 0x07, 0x18, 0xFD, 0xCF,
  0xFE, 0x71, 0xE7, 0x87, 0x38, 0x3B, 0xC1, 0xDE, 0x0E, 0xE0, 0xE7, 0x07,
  0x38, 0x79, 0xC3, 0xCF, 0xFE, 0x3F, 0xE1, 0xF7, 0x00, 0x38, 0x01, 0xC0,
  0x1E, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x00, 0x1C, 0xE3, 0xBC, 0x7F, 0x8F,
  0x81, 0xE0, 0x78, 0x0E, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xE0, 0x38, 0x07,
  0x00, 0xE0, 0x3C, 0x00, 0x0F, 0x83, 0xFC, 0xFF, 0x1C, 0x23, 0x80, 0x78,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x70, 0x0F, 0x01, 0xCE, 0x79, 0xFF, 0x3F,
  0x80, 0x0C, 0x06, 0x07, 0x07, 0xF7, 0xFF, 0xF8, 0xE0, 0x70, 0x38, 0x38,
  0x1C, 0x0E, 0x07, 0x07, 0x83, 0x81, 0xE8, 0xFC, 0x3E, 0x00, 0x38, 0x39,
  0xC1, 0xCE, 0x0E, 0x70, 0xE7, 0x87, 0x38, 0x39, 0xC1, 0xCE, 0x1E, 0x70,
  0xE7, 0x87, 0x38, 0x79, 0xE3, 0xCF, 0x7E, 0x7F, 0x61, 0xF3, 0x00, 0xF0,
  0x7B, 0x83, 0x9C, 0x3C, 0xE1, 0xC7, 0x1E, 0x38, 0xE1, 0xCF, 0x0E, 0x70,
  0x77, 0x83, 0xB8, 0x1D, 0x80, 0xFC, 0x07, 0xC0, 0x1E, 0x00, 0xE0, 0x00,
  0xE1, 0xE1, 0xF8, 0x78, 0xFE, 0x3E, 0x3B, 0x8F, 0x8E, 0xE7, 0xE7, 0x39,
  0xB9, 0xCE, 0xEE, 0xE3, 0xBB, 0xB8, 0xEC, 0xEE, 0x3F, 0x3F, 0x0F, 0x8D,
  0xC3, 0xE3, 0xE0, 0xF8, 0xF8, 0x3C, 0x3C, 0x0F, 0x0F, 0x00, 0x1C, 0x1E,
  0x3C, 0x78, 0x38, 0xE0, 0x73, 0x80, 0xFF, 0x00, 0xFC, 0x01, 0xF0, 0x03,
  0xC0, 0x07, 0xC0, 0x1F, 0x80, 0x7F, 0x01, 0xEF, 0x03, 0x8E, 0x0E, 0x1C,
  0x3C, 0x3C, 0x00, 0x0E, 0x0F, 0x0E, 0x0E, 0x0E, 0x1E, 0x0E, 0x1C, 0x0E,
  0x3C, 0x0E, 0x38, 0x0E, 0x78, 0x0E, 0x70, 0x0E, 0xF0, 0x0E, 0xE0, 0x06,
  0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0F,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x0F, 0xF0, 0xFF,
  0x1F, 0xF0, 0x0E, 0x01, 0xE0, 0x3C, 0x03, 0x80, 0x70, 0x0F, 0x01, 0xE0,
  0x1C, 0x03, 0x80, 0x7F, 0xC7, 0xFC, 0xFF, 0xC0, 0x01, 0xE0, 0x7C, 0x1F,
  0x03, 0x80, 0x70, 0x0E, 0x03, 0x80, 0x70, 0x0E, 0x03, 0xC1, 0xF0, 0x70,
  0x0F, 0x80, 0x78, 0x07, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0xC0, 0x78, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0x03, 0xC0, 0x78, 0x0E, 0x03, 0x81, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x7C, 0x07, 0x07, 0xC3, 0x81, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0xE0, 0x78, 0x3C, 0x0E, 0x00, 0x10, 0x0B, 0xF0, 0xFF,
  0xFF, 0x87, 0xE8, 0x04, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_SemiBoldItalic27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 8, 19, 7, 0, -19 },
  { 20, 9, 7, 11, 3, -19 },
  { 28, 16, 19, 16, 0, -19 },
  { 66, 14, 23, 14, 0, -21 },
  { 107, 18, 20, 21, 2, -20 },
  { 152, 15, 20, 17, 1, -20 },
  { 190, 4, 7, 6, 3, -19 },
  { 194, 9, 23, 8, 1, -19 },
  { 220, 9, 24, 8, -2, -20 },
  { 247, 12, 12, 13, 2, -21 },
  { 265, 13, 13, 14, 1, -16 },
  { 287, 6, 7, 7, -1, -3 },
  { 293, 8, 3, 8, 0, -9 },
  { 296, 4, 4, 7, 0, -4 },
  { 298, 14, 19, 10, -1, -19 },
  { 332, 12, 20, 14, 1, -20 },
  { 362, 9, 19, 14, 3, -19 },
  { 384, 14, 20, 14, -1, -20 },
  { 419, 13, 20, 14, 0, -20 },
  { 452, 13, 19, 14, 0, -19 },
  { 483, 14, 19, 14, 0, -19 },
  { 517, 13, 20, 14, 1, -20 },
  { 550, 14, 19, 14, 1, -19 },
  { 584, 13, 20, 14, 1, -20 },
  { 617, 12, 20, 14, 1, -20 },
  { 647, 7, 15, 7, 0, -15 },
  { 661, 8, 19, 7, -1, -15 },
  { 680, 13, 13, 14, 1, -16 },
  { 702, 12, 7, 14, 1, -13 },
  { 713, 13, 13, 14, 1, -16 },
  { 735, 10, 20, 11, 2, -20 },
  { 760, 19, 21, 21, 1, -19 },
  { 810, 15, 19, 15, -2, -19 },
  { 846, 14, 19, 15, 1, -19 },
  { 880, 15, 20, 14, 1, -20 },
  { 918, 15, 19, 16, 1, -19 },
  { 954, 13, 19, 13, 1, -19 },
  { 985, 13, 19, 12, 1, -19 },
  { 1016, 16, 20, 17, 1, -20 },
  { 1056, 16, 19, 17, 1, -19 },
  { 1094, 12, 19, 9, -1, -19 },
  { 1123, 12, 25, 8, -4, -19 },
  { 1161, 16, 19, 15, 1, -19 },
  { 1199, 10, 19, 12, 1, -19 },
  { 1223, 21, 19, 21, 1, -19 },
  { 1273, 17, 19, 18, 1, -19 },
  { 1314, 16, 20, 18, 1, -20 },
  { 1354, 14, 19, 15, 1, -19 },
  { 1388, 16, 25, 18, 1, -20 },
  { 1438, 14, 19, 15, 1, -19 },
  { 1472, 14, 20, 13, 0, -20 },
  { 1507, 13, 19, 13, 2, -19 },
  { 1538, 15, 19, 17, 2, -19 },
  { 1574, 15, 19, 14, 2, -19 },
  { 1610, 21, 19, 22, 3, -19 },
  { 1660, 18, 19, 14, -2, -19 },
  { 1703, 14, 19, 13, 2, -19 },
  { 1737, 15, 19, 13, -1, -19 },
  { 1773, 11, 23, 8, -1, -19 },
  { 1805, 5, 19, 10, 3, -19 },
  { 1817, 11, 23, 8, -2, -19 },
  { 1849, 13, 12, 14, 0, -19 },
  { 1869, 10, 2, 10, -2, 2 },
  { 1872, 5, 5, 8, 4, -21 },
  { 1876, 13, 15, 14, 1, -15 },
  { 1901, 14, 21, 14, 0, -21 },
  { 1938, 11, 15, 12, 1, -15 },
  { 1959, 14, 21, 14, 1, -21 },
  { 1996, 12, 15, 13, 1, -15 },
  { 2019, 15, 27, 9, -3, -21 },
  { 2070, 14, 21, 15, 0, -15 },
  { 2107, 13, 21, 15, 0, -21 },
  { 2142, 8, 20, 7, 0, -20 },
  { 2162, 11, 26, 7, -3, -20 },
  { 2198, 14, 21, 13, 0, -21 },
  { 2235, 8, 21, 7, 0, -21 },
  { 2256, 21, 15, 22, 0, -15 },
  { 2296, 13, 15, 15, 0, -15 },
  { 2321, 12, 15, 14, 1, -15 },
  { 2344, 15, 21, 14, -1, -15 },
  { 2384, 13, 21, 14, 1, -15 },
  { 2419, 11, 15, 10, 0, -15 },
  { 2440, 11, 15, 11, 0, -15 },
  { 2461, 9, 18, 9, 1, -18 },
  { 2482, 13, 15, 15, 1, -15 },
  { 2507, 13, 15, 12, 1, -15 },
  { 2532, 18, 15, 19, 2, -15 },
  { 2566, 15, 15, 13, -1, -15 },
  { 2595, 16, 21, 12, -2, -15 },
  { 2637, 12, 15, 11, -1, -15 },
  { 2660, 11, 23, 9, 0, -19 },
  { 2692, 3, 27, 13, 5, -21 },
  { 2703, 10, 23, 9, -1, -19 },
  { 2732, 13, 5, 14, 1, -12 },
};

const GFXfont NotoSans_SemiCondensed_SemiBoldItalic27pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_SemiBoldItalic27pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_SemiBoldItalic27pt7bGlyphs,
  0x20, 0x7E, 37
};

#endif // _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC27PT7B_H_
