#ifndef _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC54PT7B_H_
#define _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC54PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-SemiBoldItalic.ttf
// Size: 54pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_SemiBoldItalic54pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F,
  0x80, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3E, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x7E, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x00, 0x18, 0x00, 0x3F, 0x8F, 0xE7, 0xE1, 0xF8, 0xFC, 0x3F, 0x1F,
  0x87, 0xE3, 0xF0, 0xF8, 0x7C, 0x3F, 0x0F, 0x87, 0xE3, 0xF0, 0xFC, 0x7C,
  0x1F, 0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x3E, 0x0F, 0x07, 0x83, 0xE1, 0xF0,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x1F,
  0x07, 0xC0, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0xF8, 0x1E, 0x00, 0x01, 0xF0,
  0x7C, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x1F, 0x07,
  0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x78, 0x1F, 0x00, 0x7F, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xFE, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF0, 0x3C, 0x00,
  0x03, 0xE0, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x0F, 0x03, 0xE0, 0x00,
  0x3E, 0x07, 0x80, 0x00, 0x7C, 0x1F, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xFF, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x01, 0xE0,
  0x7C, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x1F, 0x07,
  0xC0, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x01, 0xF0, 0x7C,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x7F, 0x38, 0x70, 0x1F, 0x8E,
  0x04, 0x07, 0xE3, 0x80, 0x03, 0xF8, 0xE0, 0x00, 0xFE, 0x38, 0x00, 0x3F,
  0x9C, 0x00, 0x07, 0xF7, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00,
  0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0x7F, 0x80, 0x01,
  0xCF, 0xE0, 0x00, 0x71, 0xF8, 0x00, 0x1C, 0x7E, 0x00, 0x0E, 0x1F, 0x88,
  0x03, 0x8F, 0xE3, 0x00, 0xE3, 0xF0, 0xF8, 0x39, 0xFC, 0x3F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x07, 0xC0, 0x1F, 0xF0, 0x00, 0x7C, 0x01, 0xFF, 0xC0, 0x07, 0xC0, 0x1F,
  0xFE, 0x00, 0x3E, 0x01, 0xFD, 0xF8, 0x03, 0xE0, 0x0F, 0x87, 0xC0, 0x3E,
  0x00, 0xFC, 0x3E, 0x01, 0xF0, 0x07, 0xC1, 0xF0, 0x1F, 0x00, 0x7E, 0x0F,
  0x81, 0xF0, 0x03, 0xE0, 0x7C, 0x0F, 0x80, 0x1F, 0x03, 0xE0, 0xF8, 0x00,
  0xF8, 0x3F, 0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x7C, 0x00, 0x7E, 0x0F, 0x87,
  0xC0, 0x03, 0xE0, 0x7C, 0x7E, 0x00, 0x1F, 0x07, 0xE3, 0xE0, 0xE0, 0xF8,
  0x3E, 0x3E, 0x3F, 0xC7, 0xC3, 0xF3, 0xF3, 0xFF, 0x3F, 0x1F, 0x1F, 0x3F,
  0xFC, 0xFF, 0xF9, 0xF3, 0xFF, 0xE7, 0xFF, 0x9F, 0x9F, 0x9F, 0xBF, 0xF8,
  0xF9, 0xF8, 0x7C, 0xFF, 0x8F, 0x8F, 0x83, 0xE1, 0xF0, 0xFC, 0x7C, 0x1F,
  0x00, 0x07, 0xC7, 0xC0, 0xF8, 0x00, 0x7C, 0x3E, 0x07, 0xC0, 0x07, 0xE1,
  0xF0, 0x7E, 0x00, 0x3E, 0x0F, 0x83, 0xE0, 0x03, 0xE0, 0xFC, 0x1F, 0x00,
  0x3F, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x3E, 0x0F, 0xC0, 0x1F, 0x01, 0xF0,
  0x7C, 0x01, 0xF8, 0x0F, 0x83, 0xE0, 0x0F, 0x80, 0x7C, 0x3E, 0x00, 0xF8,
  0x03, 0xF3, 0xF0, 0x0F, 0xC0, 0x0F, 0xFF, 0x00, 0x7C, 0x00, 0x7F, 0xF8,
  0x07, 0xC0, 0x01, 0xFF, 0x80, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0xFC,
  0x0F, 0xC0, 0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xF8, 0x0F, 0xC0, 0x01, 0xF8,
  0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x80, 0x01, 0xFC,
  0x3F, 0x00, 0x00, 0xFC, 0xFF, 0x00, 0x00, 0xFD, 0xFE, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x80, 0x7F, 0x07, 0xFF, 0xC0, 0x7E, 0x0F, 0xFF,
  0xC0, 0xFE, 0x1F, 0xEF, 0xE0, 0xFC, 0x3F, 0x87, 0xF0, 0xFC, 0x3F, 0x07,
  0xF1, 0xF8, 0x7F, 0x03, 0xFB, 0xF8, 0x7E, 0x03, 0xFB, 0xF0, 0xFE, 0x01,
  0xFF, 0xF0, 0xFE, 0x01, 0xFF, 0xE0, 0xFE, 0x00, 0xFF, 0xC0, 0xFE, 0x00,
  0x7F, 0x80, 0xFE, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0x83,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xEF, 0xE0, 0x1F, 0xFF, 0x87, 0xF0, 0x0F, 0xFE, 0x07, 0xF8, 0x00, 0x40,
  0x00, 0x00, 0x3F, 0x9F, 0xCF, 0xC7, 0xE3, 0xF1, 0xF0, 0xF8, 0xFC, 0x7E,
  0x3E, 0x1F, 0x0F, 0x87, 0x87, 0xC0, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01,
  0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0,
  0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x0E, 0x07, 0xC0, 0x1E, 0x0F, 0x80, 0x3F, 0x1E, 0x00, 0xFF,
  0xBC, 0x07, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xE0, 0x7F, 0x8F, 0xC1, 0xFF, 0x80, 0x07, 0xEF, 0x00, 0x1F, 0xDF,
  0x00, 0x7F, 0x3E, 0x01, 0xFC, 0x3E, 0x01, 0xF0, 0x7C, 0x01, 0xE0, 0xFC,
  0x00, 0x80, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0xFE, 0x0F, 0xC1, 0xFC,
  0x1F, 0x81, 0xF8, 0x3F, 0x03, 0xF0, 0x7E, 0x07, 0xC0, 0xFC, 0x00, 0x7F,
  0xFD, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xF8, 0x08, 0x7E, 0xFE, 0xFF,
  0xFF, 0xFE, 0xFE, 0xFC, 0x30, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xF0, 0x1F, 0xF7, 0xF8, 0x1F, 0xE1, 0xFC, 0x0F, 0xE0, 0x7E, 0x0F,
  0xE0, 0x3F, 0x87, 0xE0, 0x1F, 0xC7, 0xF0, 0x0F, 0xE3, 0xF0, 0x07, 0xF3,
  0xF8, 0x03, 0xF9, 0xFC, 0x01, 0xFC, 0xFC, 0x00, 0xFE, 0xFE, 0x00, 0x7E,
  0x7F, 0x00, 0x3F, 0x3F, 0x80, 0x1F, 0x9F, 0x80, 0x0F, 0xCF, 0xC0, 0x0F,
  0xEF, 0xE0, 0x07, 0xF7, 0xF0, 0x03, 0xFB, 0xF8, 0x01, 0xF9, 0xF8, 0x01,
  0xFC, 0xFC, 0x00, 0xFE, 0x7E, 0x00, 0x7F, 0x3F, 0x00, 0x3F, 0x1F, 0x80,
  0x3F, 0x8F, 0xC0, 0x1F, 0xC7, 0xE0, 0x1F, 0xC3, 0xF0, 0x0F, 0xE1, 0xFC,
  0x0F, 0xE0, 0xFE, 0x0F, 0xF0, 0x3F, 0x8F, 0xF0, 0x1F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x07, 0xF8, 0x03, 0xFE,
  0x01, 0xFF, 0x81, 0xFF, 0xE0, 0xFF, 0xF8, 0xFF, 0xFC, 0x7F, 0xFF, 0x3F,
  0xEF, 0xCF, 0xE7, 0xF1, 0xF1, 0xFC, 0x38, 0x7E, 0x08, 0x1F, 0x80, 0x07,
  0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0xF8, 0x0F, 0xE0, 0x0F, 0x00, 0xFE, 0x00,
  0x40, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x03, 0xFD, 0xFF, 0x80, 0x38, 0x07, 0xF8,
  0x04, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0xC0, 0x01, 0xFE, 0x1F, 0x00, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFB,
  0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xDF, 0x80, 0x01, 0xF3, 0xF0, 0x00,
  0x7E, 0x7E, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xE3, 0xF8, 0x00, 0xF8, 0x7E,
  0x00, 0x3E, 0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0x7F, 0x00, 0xFC,
  0x0F, 0xC0, 0x1F, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x07, 0xE0,
  0x7E, 0x01, 0xFC, 0x0F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x07, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC2, 0x00, 0x0F, 0xF0, 0xC0,
  0x07, 0xF8, 0x3C, 0x07, 0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0x0A, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xF8, 0xE0, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x7C, 0x00, 0xFC, 0x7F, 0xC0, 0x3F, 0x7F, 0xF8, 0x0F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x7F, 0xC0, 0xFE, 0x1F, 0xE0, 0x3F,
  0x87, 0xF0, 0x0F, 0xE3, 0xF8, 0x01, 0xF8, 0xFE, 0x00, 0x7E, 0x3F, 0x80,
  0x1F, 0x8F, 0xE0, 0x0F, 0xE3, 0xF8, 0x03, 0xF8, 0xFE, 0x00, 0xFC, 0x3F,
  0x80, 0x3F, 0x0F, 0xE0, 0x1F, 0xC1, 0xF8, 0x07, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0xE3, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x80, 0xFF, 0x0F, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xC0,
  0x3F, 0x07, 0xF0, 0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x1F,
  0xC0, 0x7F, 0x07, 0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0xE0, 0x3F, 0x87, 0xF0,
  0x07, 0xF7, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFE,
  0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x01, 0xFE,
  0x3F, 0xC0, 0xFF, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x1F, 0xC0, 0x3F, 0x87,
  0xE0, 0x07, 0xE3, 0xF8, 0x01, 0xF8, 0xFE, 0x00, 0x7E, 0x3F, 0x80, 0x1F,
  0x8F, 0xE0, 0x07, 0xE3, 0xF8, 0x03, 0xF8, 0xFE, 0x00, 0xFE, 0x1F, 0xC0,
  0x7F, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x07,
  0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF0, 0x3F, 0xE7, 0xF8, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0x7F, 0x0F, 0xE0,
  0x1F, 0x8F, 0xE0, 0x0F, 0xC7, 0xF0, 0x07, 0xE3, 0xF0, 0x03, 0xF1, 0xF8,
  0x01, 0xF8, 0xFC, 0x00, 0xFC, 0xFE, 0x00, 0xFE, 0x7F, 0x00, 0x7F, 0x3F,
  0x80, 0x3F, 0x8F, 0xC0, 0x3F, 0xC7, 0xF0, 0x3F, 0xE3, 0xFC, 0x7F, 0xE1,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFD, 0xF8, 0x3F, 0xFE, 0xFC, 0x0F, 0xFC, 0xFC,
  0x01, 0xFC, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x60, 0x1F, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x04,
  0x00, 0x00, 0x00, 0xE0, 0x1F, 0xC0, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC,
  0x1F, 0xC0, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x07, 0xE0, 0x7F, 0x03, 0xF8, 0x3F, 0xC1, 0xFE, 0x07,
  0xF0, 0x3F, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x3F, 0x00, 0x7F, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3E,
  0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0x00, 0x07,
  0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF,
  0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x80,
  0x00, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0xFF, 0xFC, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x3F,
  0xFF, 0xF1, 0xF8, 0xFF, 0x1C, 0x07, 0xF1, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x3E, 0x00, 0x07,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00,
  0x7C, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xEF, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x7E,
  0x01, 0xFF, 0x81, 0xF0, 0xF8, 0x0F, 0xFF, 0xC3, 0xE3, 0xE0, 0x3F, 0xFF,
  0x07, 0xC7, 0xC0, 0xFF, 0xFE, 0x0F, 0x9F, 0x03, 0xF0, 0x7C, 0x1F, 0x3E,
  0x0F, 0xC0, 0xF0, 0x3E, 0x7C, 0x1F, 0x03, 0xE0, 0x7D, 0xF0, 0x7C, 0x07,
  0xC0, 0xFB, 0xE0, 0xF8, 0x0F, 0x81, 0xF7, 0xC1, 0xF0, 0x1E, 0x03, 0xCF,
  0x07, 0xC0, 0x7C, 0x0F, 0xBE, 0x0F, 0x80, 0xF8, 0x1F, 0x7C, 0x1F, 0x01,
  0xF0, 0x3E, 0xF8, 0x3E, 0x07, 0xC0, 0xF9, 0xF0, 0x7C, 0x0F, 0x81, 0xF3,
  0xE0, 0xF8, 0x3F, 0x07, 0xC7, 0xC1, 0xF0, 0x7E, 0x0F, 0x8F, 0x83, 0xE1,
  0xFC, 0x3E, 0x1F, 0x07, 0xFF, 0xFF, 0xF8, 0x3E, 0x07, 0xFE, 0x7F, 0xE0,
  0x7C, 0x0F, 0xF8, 0xFF, 0x80, 0x7C, 0x0F, 0xE0, 0xFE, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x04, 0x00, 0x03, 0xF8,
  0x00, 0x38, 0x00, 0x03, 0xFF, 0xBF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xF3,
  0xE0, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x0F, 0xC7, 0xC0,
  0x00, 0x7E, 0x3E, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x03,
  0xF0, 0x7E, 0x00, 0x1F, 0x83, 0xF0, 0x01, 0xFC, 0x1F, 0x80, 0x0F, 0xC0,
  0xFC, 0x00, 0xFE, 0x07, 0xE0, 0x07, 0xE0, 0x3F, 0x00, 0x7F, 0x01, 0xF8,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0x87, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xE3, 0xF8, 0x00, 0x7F,
  0x1F, 0xC0, 0x03, 0xF9, 0xFC, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x7E, 0xFE,
  0x00, 0x03, 0xF7, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8,
  0x07, 0xE0, 0x3F, 0xE0, 0x3F, 0x00, 0xFF, 0x03, 0xF8, 0x03, 0xF8, 0x1F,
  0xC0, 0x1F, 0xC0, 0xFE, 0x00, 0xFE, 0x07, 0xE0, 0x07, 0xF0, 0x3F, 0x00,
  0x3F, 0x03, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x3F, 0x80, 0xFC, 0x03, 0xFC,
  0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0x00,
  0xFE, 0x03, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0xC0, 0xFC, 0x00, 0xFE,
  0x07, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x83, 0xF8, 0x01, 0xFC, 0x1F,
  0x80, 0x0F, 0xE0, 0xFC, 0x00, 0xFF, 0x07, 0xE0, 0x07, 0xF0, 0x7F, 0x00,
  0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xF8,
  0x03, 0x80, 0xFF, 0x80, 0x08, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x08, 0x03,
  0xFF, 0x07, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x05, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x7F, 0x07, 0xFE, 0x00, 0xFC, 0x03, 0xFC, 0x03, 0xF8, 0x03, 0xFC,
  0x07, 0xF0, 0x03, 0xF8, 0x0F, 0xE0, 0x07, 0xF0, 0x1F, 0xC0, 0x0F, 0xE0,
  0x3F, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x3F, 0x83,
  0xF8, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0xFE, 0x0F, 0xC0, 0x01, 0xF8, 0x3F,
  0x80, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xC1, 0xF8,
  0x00, 0x3F, 0x83, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0xC0,
  0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xF0, 0x7E, 0x00, 0x1F, 0xC1, 0xFC, 0x00,
  0x7F, 0x83, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x03, 0xFC, 0x0F, 0xC0, 0x0F,
  0xF0, 0x1F, 0x80, 0x7F, 0xC0, 0x7F, 0x01, 0xFF, 0x80, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x40, 0x3F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xC0, 0x1E,
  0x03, 0xFE, 0x00, 0x08, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x03, 0xFF, 0xC7, 0xF0,
  0x07, 0xFF, 0x8F, 0xE0, 0x1F, 0xFF, 0x1F, 0xC0, 0x3F, 0xFE, 0x3F, 0x80,
  0x7F, 0xF8, 0x7F, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x0F, 0xE1, 0xFC, 0x00,
  0x1F, 0xC3, 0xF8, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x7E, 0x0F, 0xE0, 0x00,
  0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0xC0, 0x07, 0xF0, 0x3F, 0x80, 0x0F,
  0xE0, 0x7F, 0x80, 0x1F, 0x80, 0x7F, 0xE0, 0xFF, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x3F, 0x80, 0x07, 0xE0, 0x0F, 0xC0, 0x01, 0xF8, 0x03, 0xF0, 0x00,
  0xFE, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x0F, 0xE0, 0x1F, 0xC0,
  0x03, 0xF0, 0x07, 0xE0, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x07, 0xE0, 0x0F, 0xE0, 0x01, 0xF8, 0x03,
  0xF0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x0F, 0xE0,
  0x1F, 0xC0, 0x03, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x7F, 0x00,
  0x0F, 0xE0, 0x1F, 0xC0, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0xFC, 0x01, 0xF8,
  0x00, 0x7F, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x07, 0xF0, 0x0F,
  0xE0, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x3F, 0x80,
  0x7F, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0xFC,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x07,
  0xF0, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00,
  0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x7F, 0x80, 0x7E, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0x80,
  0x3F, 0x80, 0x1F, 0xC0, 0x3F, 0xC0, 0x0F, 0xE0, 0x3F, 0xC0, 0x07, 0xE0,
  0x3F, 0xC0, 0x03, 0xF0, 0x1F, 0xC0, 0x01, 0xF8, 0x1F, 0xC0, 0x01, 0xFC,
  0x1F, 0xC0, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0x7E, 0x1F, 0xE0, 0x00, 0x3F,
  0x0F, 0xE0, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x0F,
  0xCF, 0xF0, 0x00, 0x07, 0xEF, 0xF0, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xCF, 0xE0, 0x00,
  0x1F, 0xC7, 0xF0, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x07, 0xE0, 0xFE, 0x00,
  0x07, 0xF0, 0x7F, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x01, 0xFC, 0x0F, 0xE0,
  0x00, 0xFC, 0x07, 0xF0, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x7F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x1F, 0xF0,
  0x00, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xE0, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x03, 0xFF,
  0x80, 0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x03,
  0xFF, 0x80, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x0F, 0xFF,
  0x00, 0x3F, 0x7E, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x3E, 0xFC, 0x01,
  0xFB, 0xF0, 0x0F, 0xDF, 0x80, 0x3F, 0x7E, 0x01, 0xF9, 0xF0, 0x07, 0xCF,
  0xC0, 0x3F, 0x3E, 0x01, 0xFB, 0xF8, 0x07, 0xE7, 0xC0, 0x3E, 0x7E, 0x00,
  0xFC, 0xF8, 0x0F, 0xCF, 0xC0, 0x3F, 0x1F, 0x01, 0xF1, 0xF8, 0x07, 0xE3,
  0xE0, 0x7E, 0x3F, 0x00, 0xFC, 0x7C, 0x0F, 0x8F, 0xC0, 0x1F, 0x8F, 0x83,
  0xF1, 0xF8, 0x03, 0xF1, 0xF0, 0x7C, 0x3F, 0x00, 0xFC, 0x3E, 0x1F, 0x87,
  0xE0, 0x1F, 0x87, 0xC3, 0xE1, 0xFC, 0x03, 0xF0, 0xFC, 0xFC, 0x3F, 0x00,
  0x7E, 0x1F, 0x9F, 0x07, 0xE0, 0x1F, 0x83, 0xF7, 0xE0, 0xFC, 0x03, 0xF0,
  0x7E, 0xF8, 0x1F, 0x80, 0x7E, 0x07, 0xFF, 0x07, 0xF0, 0x0F, 0xC0, 0xFF,
  0xC0, 0xFC, 0x01, 0xF8, 0x1F, 0xF8, 0x1F, 0x80, 0x7E, 0x03, 0xFE, 0x03,
  0xF0, 0x0F, 0xC0, 0x7F, 0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0,
  0x3F, 0x01, 0xFE, 0x03, 0xF0, 0x07, 0xE0, 0x3F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x03, 0xF0, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x07, 0xE0,
  0x0F, 0xF0, 0x00, 0x7E, 0x01, 0xFF, 0x80, 0x07, 0xE0, 0x1F, 0xF8, 0x00,
  0x7E, 0x01, 0xFF, 0x80, 0x0F, 0xC0, 0x1F, 0xFC, 0x00, 0xFC, 0x03, 0xFF,
  0xC0, 0x0F, 0xC0, 0x3F, 0xFC, 0x00, 0xFC, 0x03, 0xFF, 0xC0, 0x0F, 0xC0,
  0x3F, 0x7E, 0x01, 0xF8, 0x03, 0xE7, 0xE0, 0x1F, 0x80, 0x7E, 0x7E, 0x01,
  0xF8, 0x07, 0xE7, 0xF0, 0x1F, 0x80, 0x7E, 0x3F, 0x03, 0xF8, 0x07, 0xE3,
  0xF0, 0x3F, 0x00, 0x7E, 0x3F, 0x03, 0xF0, 0x0F, 0xC1, 0xF8, 0x3F, 0x00,
  0xFC, 0x1F, 0x83, 0xF0, 0x0F, 0xC1, 0xF8, 0x7E, 0x00, 0xFC, 0x1F, 0x87,
  0xE0, 0x0F, 0xC0, 0xFC, 0x7E, 0x01, 0xF8, 0x0F, 0xC7, 0xE0, 0x1F, 0x80,
  0xFC, 0x7E, 0x01, 0xF8, 0x0F, 0xE7, 0xC0, 0x1F, 0x80, 0x7E, 0xFC, 0x03,
  0xF0, 0x07, 0xEF, 0xC0, 0x3F, 0x00, 0x7E, 0xFC, 0x03, 0xF0, 0x03, 0xFF,
  0xC0, 0x3F, 0x00, 0x3F, 0xF8, 0x03, 0xF0, 0x03, 0xFF, 0x80, 0x7E, 0x00,
  0x3F, 0xF8, 0x07, 0xE0, 0x01, 0xFF, 0x80, 0x7E, 0x00, 0x1F, 0xF8, 0x07,
  0xE0, 0x01, 0xFF, 0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x0F, 0xC0, 0x00, 0xFF,
  0x00, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0x81, 0xFF, 0x03, 0xFC, 0x01,
  0xFE, 0x0F, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x7F, 0x80, 0x03,
  0xF8, 0xFE, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x1F,
  0xCF, 0xE0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0xFE,
  0xFE, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x7F, 0x7F,
  0x00, 0x00, 0xFE, 0xFE, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x07, 0xF3, 0xF8,
  0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0xFF, 0x1F, 0xC0,
  0x01, 0xFC, 0x3F, 0xC0, 0x07, 0xF8, 0x3F, 0x80, 0x1F, 0xE0, 0x7F, 0x80,
  0x7F, 0xC0, 0xFF, 0xC3, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF8, 0x07, 0xE0, 0x3F, 0xC0, 0x3F, 0x00, 0xFE, 0x03, 0xF8,
  0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0xC0, 0xFE, 0x00, 0xFE, 0x07, 0xE0, 0x07,
  0xF0, 0x3F, 0x00, 0x3F, 0x83, 0xF8, 0x01, 0xF8, 0x1F, 0xC0, 0x1F, 0xC0,
  0xFE, 0x00, 0xFE, 0x07, 0xE0, 0x0F, 0xF0, 0x3F, 0x00, 0xFF, 0x03, 0xF8,
  0x1F, 0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0x00, 0xFF, 0x81, 0xFF, 0x03, 0xFC, 0x00, 0xFE, 0x0F, 0xF0,
  0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x7F, 0x80, 0x03, 0xF8, 0xFE, 0x00,
  0x07, 0xF3, 0xFC, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x1F, 0xCF, 0xE0, 0x00,
  0x3F, 0xBF, 0x80, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x01,
  0xFD, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F,
  0xDF, 0xC0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0xFE,
  0xFE, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x1F, 0xE7,
  0xF0, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0xFF, 0x1F, 0xC0, 0x01, 0xFC, 0x3F,
  0xC0, 0x07, 0xF8, 0x3F, 0x80, 0x1F, 0xE0, 0x7F, 0x80, 0x7F, 0xC0, 0xFF,
  0xC3, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xF8, 0x1F, 0xE0, 0x1F, 0x80,
  0xFF, 0x03, 0xF8, 0x07, 0xF0, 0x3F, 0x80, 0x7F, 0x03, 0xF8, 0x07, 0xF0,
  0x3F, 0x00, 0x7F, 0x03, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x07, 0xF0,
  0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xE0, 0x1F, 0xE0, 0x7E, 0x03, 0xFC,
  0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xC3, 0xF0,
  0x01, 0xF8, 0x3F, 0x80, 0x1F, 0x83, 0xF8, 0x03, 0xF8, 0x1F, 0x80, 0x3F,
  0x81, 0xFC, 0x03, 0xF8, 0x1F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0x07,
  0xE0, 0x07, 0xF0, 0x7E, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF8, 0xFE, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xFF,
  0x00, 0xE0, 0x1F, 0xC0, 0x04, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x04, 0x00,
  0x0F, 0xE0, 0x60, 0x03, 0xFC, 0x1F, 0x83, 0xFF, 0x03, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x7E, 0x07,
  0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x07, 0xF0, 0x7F,
  0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x7F, 0x07, 0xF0,
  0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xF0, 0x3F, 0x00,
  0x07, 0xE0, 0x7E, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x3F, 0x83, 0xF8, 0x00,
  0x7F, 0x07, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x07,
  0xF0, 0x7F, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x3F,
  0x03, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xF8,
  0x3F, 0x80, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x3F, 0x83,
  0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xF8, 0x1F,
  0xC0, 0x07, 0xF0, 0x3F, 0x80, 0x0F, 0xE0, 0x7F, 0x00, 0x3F, 0x80, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x87, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x2C, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x7F, 0xFC, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0xFE, 0xFC, 0x00, 0x1F, 0xCF,
  0xC0, 0x01, 0xFC, 0xFC, 0x00, 0x1F, 0x8F, 0xE0, 0x03, 0xF8, 0xFE, 0x00,
  0x3F, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xE0,
  0x7E, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x3F, 0x80, 0x7E, 0x03, 0xF0, 0x07, 0xE0, 0x7F, 0x00, 0x7E, 0x07, 0xE0,
  0x07, 0xE0, 0xFE, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x7E,
  0x1F, 0x80, 0x07, 0xE1, 0xF8, 0x00, 0x7E, 0x3F, 0x80, 0x07, 0xE3, 0xF0,
  0x00, 0x3E, 0x7F, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x3E, 0xFE, 0x00, 0x03,
  0xEF, 0xC0, 0x00, 0x3E, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x07, 0xFF, 0x80, 0x07, 0xF0, 0x01, 0xFF, 0xF0, 0x00,
  0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xEF, 0xC0, 0x07, 0xF8,
  0x01, 0xFD, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0xE0, 0x0F,
  0xE7, 0xE0, 0x07, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0x1F,
  0x80, 0x3F, 0xF0, 0x0F, 0xE3, 0xF0, 0x0F, 0xFE, 0x01, 0xF8, 0x7E, 0x01,
  0xFF, 0xC0, 0x7F, 0x0F, 0xC0, 0x3F, 0xF8, 0x0F, 0xC1, 0xF8, 0x0F, 0xFF,
  0x03, 0xF8, 0x3F, 0x01, 0xF7, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0x9F, 0x83, 0xF8, 0x1F, 0x83, 0xF3, 0xF0, 0x7E, 0x03,
  0xF0, 0x7C, 0x7E, 0x1F, 0xC0, 0x7E, 0x1F, 0x8F, 0xC3, 0xF0, 0x0F, 0xC3,
  0xF1, 0xF8, 0x7E, 0x01, 0xF8, 0x7C, 0x1F, 0x1F, 0x80, 0x3F, 0x1F, 0x83,
  0xE3, 0xF0, 0x07, 0xE3, 0xE0, 0x7C, 0xFE, 0x00, 0xFC, 0xFC, 0x0F, 0x9F,
  0x80, 0x1F, 0x9F, 0x01, 0xF3, 0xF0, 0x03, 0xF3, 0xE0, 0x3E, 0xFC, 0x00,
  0x7E, 0xFC, 0x07, 0xDF, 0x80, 0x0F, 0xDF, 0x00, 0xFF, 0xE0, 0x01, 0xFF,
  0xE0, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x01, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x0F, 0xE0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x03,
  0xF8, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x3F, 0x80,
  0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x03, 0xF8, 0x7F,
  0x00, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00, 0xFE,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x01,
  0xFC, 0xFC, 0x00, 0x00, 0x7F, 0x1F, 0x80, 0x00, 0x1F, 0xC3, 0xF8, 0x00,
  0x03, 0xF8, 0x7F, 0x00, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0xFE,
  0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x1F, 0xFF,
  0x80, 0x07, 0xFF, 0xE0, 0x03, 0xFB, 0xF8, 0x01, 0xFC, 0x7E, 0x00, 0x7F,
  0x1F, 0x80, 0x3F, 0x87, 0xF0, 0x0F, 0xE1, 0xFC, 0x07, 0xF0, 0x3F, 0x03,
  0xF8, 0x0F, 0xC0, 0xFE, 0x03, 0xF0, 0x7F, 0x00, 0xFC, 0x1F, 0x80, 0x3F,
  0x8F, 0xE0, 0x07, 0xE7, 0xF0, 0x01, 0xF9, 0xFC, 0x00, 0x7E, 0xFE, 0x00,
  0x1F, 0xBF, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0,
  0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00,
  0xF8, 0x1F, 0x03, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x1F,
  0x03, 0xE0, 0x7E, 0x0F, 0xC1, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x3E,
  0xFC, 0x00, 0x3E, 0x3E, 0x00, 0x3F, 0x1F, 0x00, 0x1F, 0x0F, 0xC0, 0x1F,
  0x03, 0xE0, 0x0F, 0x81, 0xF0, 0x0F, 0x80, 0xFC, 0x0F, 0xC0, 0x3E, 0x07,
  0xC0, 0x1F, 0x07, 0xE0, 0x0F, 0xC3, 0xE0, 0x03, 0xE3, 0xE0, 0x01, 0xF3,
  0xF0, 0x00, 0xFD, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFC, 0xFE, 0x1F, 0x87, 0xF0, 0xFC, 0x1F, 0x07,
  0xE0, 0xF8, 0x1F, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0xE1, 0xF0, 0x1F, 0xFC,
  0xFC, 0x0F, 0xFF, 0xBF, 0x07, 0xFF, 0xEF, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF,
  0x0F, 0xF8, 0x7F, 0x81, 0xFE, 0x1F, 0xC0, 0x7F, 0x8F, 0xE0, 0x0F, 0xE3,
  0xF8, 0x03, 0xF1, 0xFC, 0x00, 0xFC, 0x7F, 0x00, 0x7F, 0x1F, 0xC0, 0x1F,
  0xC7, 0xE0, 0x07, 0xE3, 0xF8, 0x01, 0xF8, 0xFE, 0x00, 0x7E, 0x3F, 0x80,
  0x3F, 0x8F, 0xE0, 0x0F, 0xE3, 0xF8, 0x03, 0xF0, 0xFE, 0x01, 0xFC, 0x3F,
  0x80, 0x7F, 0x0F, 0xE0, 0x3F, 0xC3, 0xF8, 0x1F, 0xF0, 0xFF, 0x0F, 0xF8,
  0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xDF, 0x80, 0xFF, 0xF7, 0xE0, 0x3F, 0xF1,
  0xF0, 0x07, 0xF8, 0x7C, 0x00, 0x10, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC1, 0xE0, 0x03,
  0xF3, 0xFE, 0x01, 0xFD, 0xFF, 0xC0, 0x7E, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0x81, 0xFF, 0x0F, 0xF0, 0xFF, 0x01, 0xFC, 0x3F, 0xC0,
  0x7F, 0x0F, 0xE0, 0x1F, 0xC3, 0xF8, 0x07, 0xF0, 0xFC, 0x01, 0xFC, 0x7F,
  0x00, 0x7F, 0x1F, 0x80, 0x1F, 0xC7, 0xE0, 0x07, 0xF1, 0xF8, 0x01, 0xF8,
  0xFE, 0x00, 0x7E, 0x3F, 0x80, 0x3F, 0x8F, 0xC0, 0x0F, 0xE3, 0xF0, 0x03,
  0xF0, 0xFC, 0x01, 0xFC, 0x7F, 0x00, 0x7F, 0x1F, 0xE0, 0x3F, 0x87, 0xF8,
  0x1F, 0xE1, 0xFF, 0x0F, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x0F,
  0xDF, 0xFF, 0x03, 0xE3, 0xFF, 0x80, 0xF8, 0x7F, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE,
  0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0x01, 0x07, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x10, 0x7F, 0x83, 0x81, 0xFF, 0xFE,
  0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x1F, 0xF8, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x3C, 0x1F, 0x80, 0x0F,
  0xF8, 0xFC, 0x00, 0xFF, 0xE7, 0xE0, 0x0F, 0xFF, 0xBF, 0x00, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0x07, 0xFC, 0x07, 0xF0, 0x1F, 0xE0,
  0x3F, 0x80, 0xFF, 0x03, 0xF8, 0x03, 0xF0, 0x1F, 0xC0, 0x1F, 0x81, 0xFC,
  0x00, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0x03, 0xF0, 0x03,
  0xF0, 0x3F, 0x80, 0x1F, 0x81, 0xFC, 0x00, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0,
  0x7F, 0x00, 0x7F, 0x03, 0xF8, 0x03, 0xF0, 0x1F, 0x80, 0x3F, 0x80, 0xFE,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0x81, 0xFE, 0x01, 0xFE, 0x1F,
  0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xF7, 0xE0,
  0x07, 0xFF, 0x3E, 0x00, 0x0F, 0xE1, 0xF0, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xE1, 0xFE, 0x1F, 0xC3, 0xF8, 0x1F, 0x8F, 0xE0, 0x3F, 0x1F,
  0x80, 0x7E, 0x7F, 0x00, 0xFC, 0xFC, 0x03, 0xFB, 0xF8, 0x0F, 0xE7, 0xE0,
  0x7F, 0xCF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x01, 0xFF, 0xC0, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x10, 0x7F, 0x00, 0x60,
  0xFF, 0xDF, 0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x00,
  0xFF, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0xFF, 0x08, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xDF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xFE, 0x1F, 0x00, 0x7F, 0xF3, 0xF0, 0x0F, 0xFF, 0xBF,
  0x01, 0xFF, 0xFB, 0xF0, 0x3F, 0xFF, 0xFE, 0x03, 0xFC, 0x3F, 0xE0, 0x7F,
  0x81, 0xFE, 0x07, 0xF0, 0x1F, 0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x0F,
  0xC1, 0xFC, 0x00, 0xFC, 0x1F, 0xC0, 0x1F, 0xC1, 0xFC, 0x01, 0xFC, 0x1F,
  0x80, 0x1F, 0x83, 0xF8, 0x01, 0xF8, 0x3F, 0x80, 0x1F, 0x83, 0xF8, 0x03,
  0xF8, 0x3F, 0x80, 0x3F, 0x83, 0xF8, 0x07, 0xF0, 0x3F, 0x80, 0x7F, 0x03,
  0xF8, 0x0F, 0xF0, 0x3F, 0x80, 0xFF, 0x03, 0xF8, 0x1F, 0xF0, 0x3F, 0xC3,
  0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0x7E, 0x01, 0xFF, 0xEF, 0xE0,
  0x0F, 0xFC, 0xFC, 0x00, 0x7F, 0x8F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0xC0, 0x07, 0xF0, 0x0F, 0xC3, 0xFF, 0x00, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC1, 0xE0, 0x03, 0xF3, 0xFE, 0x01,
  0xFD, 0xFF, 0xC0, 0x7E, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xC1, 0xFF, 0x07, 0xF0, 0xFF, 0x81, 0xFC, 0x3F, 0xC0, 0x7F, 0x0F, 0xE0,
  0x1F, 0xC3, 0xF8, 0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x7F, 0x00, 0x7E, 0x1F,
  0xC0, 0x3F, 0x87, 0xE0, 0x0F, 0xE1, 0xF8, 0x03, 0xF0, 0xFE, 0x00, 0xFC,
  0x3F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0xC3, 0xF0, 0x07, 0xF0, 0xFC, 0x01,
  0xF8, 0x7F, 0x00, 0x7E, 0x1F, 0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0xE1, 0xF8,
  0x03, 0xF8, 0x7E, 0x00, 0xFC, 0x3F, 0x80, 0x3F, 0x0F, 0xE0, 0x0F, 0xC3,
  0xF0, 0x07, 0xF0, 0xFC, 0x01, 0xFC, 0x00, 0x00, 0x30, 0x03, 0xF0, 0x0F,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0x80, 0x18, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0xE0, 0x1F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03,
  0xF0, 0x0F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x30, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x01, 0x03, 0xF0, 0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x3F, 0x80,
  0x7E, 0x07, 0xF0, 0x07, 0xE0, 0xFE, 0x00, 0x7E, 0x0F, 0xE0, 0x0F, 0xE1,
  0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xC7, 0xF0, 0x00, 0xFC, 0xFE, 0x00,
  0x0F, 0xDF, 0xC0, 0x01, 0xFB, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0,
  0x03, 0xFD, 0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF0, 0xFE, 0x00, 0x7F,
  0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x7E, 0x07, 0xF0, 0x07, 0xE0, 0x3F,
  0x00, 0x7E, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x01, 0xF8, 0x0F,
  0xC0, 0x1F, 0xC0, 0xFC, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0x03,
  0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0xFE, 0x01, 0xFC, 0x03,
  0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xFC, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE3, 0xFE, 0x07, 0xFC, 0x07, 0xE7,
  0xFF, 0x0F, 0xFE, 0x07, 0xEF, 0xFF, 0x1F, 0xFE, 0x07, 0xDF, 0xFF, 0xBF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFC, 0x3F, 0xF8, 0x7F, 0x0F,
  0xF8, 0x1F, 0xE0, 0x3F, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x80, 0x7F,
  0x1F, 0xC0, 0x3F, 0x80, 0x7E, 0x1F, 0xC0, 0x3F, 0x00, 0x7E, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x3F, 0x80, 0x7F, 0x00,
  0xFE, 0x3F, 0x80, 0x7F, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x01, 0xFC, 0x7F, 0x00, 0xFE,
  0x01, 0xFC, 0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x03, 0xF8, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x00, 0x00, 0x78, 0x00, 0xF8, 0xFF,
  0x80, 0x7E, 0x7F, 0xF0, 0x1F, 0xBF, 0xFE, 0x07, 0xDF, 0xFF, 0x81, 0xF7,
  0xFF, 0xF0, 0x7F, 0xC1, 0xFC, 0x3F, 0xE0, 0x7F, 0x0F, 0xF0, 0x1F, 0xC3,
  0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x7E, 0x1F, 0xC0, 0x1F,
  0x87, 0xF0, 0x0F, 0xE1, 0xF8, 0x03, 0xF8, 0x7E, 0x00, 0xFE, 0x3F, 0x80,
  0x3F, 0x0F, 0xE0, 0x0F, 0xC3, 0xF8, 0x07, 0xF0, 0xFC, 0x01, 0xFC, 0x3F,
  0x00, 0x7E, 0x1F, 0xC0, 0x1F, 0x87, 0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xF8,
  0x7E, 0x00, 0xFE, 0x1F, 0x80, 0x3F, 0x0F, 0xE0, 0x0F, 0xC3, 0xF8, 0x03,
  0xF0, 0xFC, 0x01, 0xFC, 0x3F, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFE, 0x0F, 0xE0, 0xFF, 0x1F, 0xC0, 0x7F, 0x3F, 0x80, 0x3F, 0x3F,
  0x80, 0x3F, 0x3F, 0x00, 0x3F, 0x7F, 0x00, 0x3F, 0x7F, 0x00, 0x3F, 0x7E,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0xFE, 0xFE,
  0x01, 0xFC, 0xFE, 0x01, 0xFC, 0xFE, 0x03, 0xF8, 0x7F, 0x07, 0xF8, 0x7F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x03, 0xE3, 0xFE,
  0x00, 0x3F, 0x3F, 0xF8, 0x01, 0xFB, 0xFF, 0xE0, 0x0F, 0xBF, 0xFF, 0x00,
  0x7F, 0xFF, 0xF8, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x01, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0xFE, 0x03, 0xF0, 0x07,
  0xF0, 0x3F, 0x80, 0x3F, 0x81, 0xF8, 0x01, 0xFC, 0x0F, 0xC0, 0x0F, 0xE0,
  0x7E, 0x00, 0x7E, 0x03, 0xF0, 0x03, 0xF0, 0x3F, 0x80, 0x3F, 0x81, 0xF8,
  0x01, 0xFC, 0x0F, 0xC0, 0x0F, 0xC0, 0x7E, 0x00, 0xFE, 0x07, 0xF0, 0x07,
  0xF0, 0x3F, 0xC0, 0x7F, 0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xF8, 0x7F, 0x80,
  0x7F, 0xFF, 0xF8, 0x07, 0xEF, 0xFF, 0xC0, 0x3F, 0x7F, 0xFC, 0x01, 0xF9,
  0xFF, 0xC0, 0x0F, 0xC7, 0xF8, 0x00, 0x7E, 0x04, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0xE1, 0xF0,
  0x1F, 0xFC, 0x7C, 0x0F, 0xFF, 0xBF, 0x07, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xE0, 0xFE, 0x0F, 0xF8, 0x7F, 0x01, 0xFE, 0x1F, 0xC0, 0x7F, 0x8F, 0xE0,
  0x0F, 0xC3, 0xF8, 0x03, 0xF1, 0xFC, 0x00, 0xFC, 0x7F, 0x00, 0x7F, 0x1F,
  0xC0, 0x1F, 0xC7, 0xE0, 0x07, 0xE3, 0xF8, 0x01, 0xF8, 0xFE, 0x00, 0x7E,
  0x3F, 0x80, 0x3F, 0x8F, 0xE0, 0x0F, 0xE3, 0xF8, 0x03, 0xF0, 0xFC, 0x01,
  0xFC, 0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x3F, 0xC3, 0xF8, 0x1F, 0xE0, 0xFF,
  0x0F, 0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xDF, 0x81, 0xFF, 0xEF, 0xE0,
  0x3F, 0xF3, 0xF0, 0x07, 0xF8, 0xFC, 0x00, 0x10, 0x3F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xF8, 0x1F, 0x1F, 0xC1, 0xF9, 0xFE, 0x0F, 0xDF, 0xF0,
  0x7E, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC1, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x03,
  0xFF, 0xC0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xC3,
  0xE0, 0xFE, 0x01, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x20,
  0x03, 0xF8, 0xE0, 0x1F, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xE0, 0xFF, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xE1,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x41, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x1F, 0xFC,
  0x07, 0xFE, 0x00, 0x20, 0x00, 0x0F, 0xE0, 0x0F, 0xC3, 0xF8, 0x03, 0xF0,
  0xFC, 0x01, 0xFC, 0x3F, 0x00, 0x7F, 0x0F, 0xC0, 0x1F, 0x87, 0xF0, 0x07,
  0xE1, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0xFE, 0x1F, 0x80, 0x3F, 0x07, 0xE0,
  0x0F, 0xC3, 0xF8, 0x03, 0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x00, 0x7F, 0x0F,
  0xC0, 0x1F, 0x87, 0xF0, 0x07, 0xE1, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0xFE,
  0x1F, 0x80, 0x3F, 0x87, 0xE0, 0x1F, 0xC1, 0xF8, 0x07, 0xF0, 0xFE, 0x03,
  0xFC, 0x3F, 0x80, 0xFF, 0x0F, 0xE0, 0x7F, 0x83, 0xFC, 0x3F, 0xE0, 0x7F,
  0xFE, 0xF8, 0x1F, 0xFF, 0x7E, 0x07, 0xFF, 0xDF, 0x80, 0xFF, 0xC7, 0xC0,
  0x1F, 0xE1, 0xF0, 0x00, 0x40, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x7E, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0xFC, 0xFC, 0x01, 0xFC, 0xFC, 0x01,
  0xF8, 0xFC, 0x03, 0xF8, 0x7E, 0x03, 0xF0, 0x7E, 0x07, 0xF0, 0x7E, 0x07,
  0xE0, 0x7E, 0x0F, 0xE0, 0x7E, 0x0F, 0xC0, 0x7E, 0x1F, 0xC0, 0x7E, 0x1F,
  0x80, 0x7E, 0x3F, 0x80, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x7E,
  0x00, 0x7E, 0x7E, 0x00, 0x3E, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0xFC, 0x01,
  0xFC, 0x01, 0xFF, 0xE0, 0x1F, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0x00, 0xFD,
  0xF8, 0x0F, 0xF8, 0x0F, 0xEF, 0xC0, 0x7F, 0xC0, 0x7E, 0x7E, 0x03, 0xFE,
  0x07, 0xF3, 0xF0, 0x3F, 0xF0, 0x3F, 0x1F, 0x81, 0xFF, 0x81, 0xF8, 0xFC,
  0x1F, 0x7C, 0x1F, 0x87, 0xE0, 0xFB, 0xE0, 0xFC, 0x1F, 0x07, 0xDF, 0x0F,
  0xE0, 0xF8, 0x7C, 0xF8, 0x7E, 0x07, 0xC3, 0xE7, 0xC7, 0xF0, 0x3E, 0x3E,
  0x3E, 0x3F, 0x01, 0xF1, 0xF1, 0xF1, 0xF8, 0x0F, 0x9F, 0x8F, 0x9F, 0x80,
  0x7C, 0xF8, 0x7C, 0xFC, 0x03, 0xE7, 0xC3, 0xEF, 0xC0, 0x1F, 0x7C, 0x1F,
  0x7E, 0x00, 0xFB, 0xE0, 0xFB, 0xF0, 0x07, 0xDE, 0x07, 0xFF, 0x00, 0x3F,
  0xF0, 0x3F, 0xF8, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x0F, 0xF8, 0x0F, 0xFC,
  0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0x1F, 0xE0,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x07, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x07, 0xF8, 0x0F, 0xC0, 0x3F, 0x80, 0x7F, 0x03, 0xF8,
  0x03, 0xF8, 0x3F, 0xC0, 0x0F, 0xC1, 0xFC, 0x00, 0x7E, 0x1F, 0xC0, 0x03,
  0xF9, 0xFC, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x7E, 0xFE, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xF7,
  0xE0, 0x00, 0x3F, 0xBF, 0x80, 0x03, 0xF8, 0xFC, 0x00, 0x3F, 0x87, 0xE0,
  0x01, 0xFC, 0x3F, 0x80, 0x1F, 0xC1, 0xFC, 0x01, 0xFC, 0x07, 0xE0, 0x1F,
  0xE0, 0x3F, 0x80, 0xFE, 0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0xFE, 0x03, 0xF0, 0x01, 0xF8, 0x07, 0xE0, 0x07, 0xF0, 0x0F,
  0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x1F, 0x80, 0x7E, 0x00, 0x3F,
  0x01, 0xFC, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0xFC, 0x0F, 0xE0, 0x01, 0xF8,
  0x1F, 0x80, 0x03, 0xF0, 0x7F, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0xC1,
  0xF8, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x3E, 0x3F,
  0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x01, 0xF3, 0xF0,
  0x00, 0x03, 0xF7, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xBE, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x08, 0xFF, 0x80, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFE,
  0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0x00, 0x0B, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x0A, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x70, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x00, 0x07,
  0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x3F, 0xF8, 0x01,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xF8, 0x00, 0x14, 0x00,
  0x00, 0x1F, 0xC0, 0x01, 0x7F, 0xF8, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x1F, 0xFE, 0x80, 0x03,
  0xF8,
};

const GFXglyph NotoSans_SemiCondensed_SemiBoldItalic54pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 15, 40, 14, 1, -39 },
  { 76, 19, 14, 22, 5, -39 },
  { 110, 31, 39, 31, 1, -39 },
  { 262, 26, 44, 27, 1, -41 },
  { 405, 37, 39, 42, 3, -39 },
  { 586, 32, 40, 33, 1, -39 },
  { 746, 9, 14, 13, 5, -39 },
  { 762, 18, 48, 16, 2, -39 },
  { 870, 19, 48, 16, -4, -39 },
  { 984, 23, 24, 26, 5, -41 },
  { 1053, 24, 26, 29, 3, -32 },
  { 1131, 12, 13, 14, -3, -6 },
  { 1151, 14, 5, 16, 1, -17 },
  { 1160, 8, 9, 14, 1, -8 },
  { 1169, 28, 39, 21, -3, -39 },
  { 1306, 25, 40, 27, 2, -39 },
  { 1431, 18, 39, 27, 6, -39 },
  { 1519, 28, 39, 27, -1, -39 },
  { 1656, 27, 40, 27, 0, -39 },
  { 1791, 27, 39, 27, 0, -39 },
  { 1923, 26, 40, 27, 1, -39 },
  { 2053, 26, 40, 27, 2, -39 },
  { 2183, 27, 39, 27, 2, -39 },
  { 2315, 26, 40, 27, 1, -39 },
  { 2445, 25, 40, 27, 1, -39 },
  { 2570, 13, 31, 14, 0, -30 },
  { 2621, 16, 37, 14, -3, -30 },
  { 2695, 24, 27, 29, 3, -33 },
  { 2776, 24, 16, 29, 3, -27 },
  { 2824, 24, 27, 29, 3, -33 },
  { 2905, 20, 40, 22, 3, -39 },
  { 3005, 39, 44, 42, 2, -39 },
  { 3220, 29, 39, 29, -3, -39 },
  { 3362, 29, 39, 30, 1, -39 },
  { 3504, 29, 40, 29, 3, -39 },
  { 3649, 31, 39, 33, 1, -39 },
  { 3801, 27, 39, 26, 1, -39 },
  { 3933, 27, 39, 25, 1, -39 },
  { 4065, 31, 40, 34, 3, -39 },
  { 4220, 34, 39, 34, 1, -39 },
  { 4386, 24, 39, 18, -2, -39 },
  { 4503, 24, 50, 15, -8, -39 },
  { 4653, 33, 39, 29, 1, -39 },
  { 4814, 20, 39, 24, 1, -39 },
  { 4912, 43, 39, 43, 1, -39 },
  { 5122, 36, 39, 36, 1, -39 },
  { 5298, 31, 40, 35, 3, -39 },
  { 5453, 29, 39, 29, 1, -39 },
  { 5595, 31, 48, 35, 3, -39 },
  { 5781, 28, 39, 29, 1, -39 },
  { 5918, 27, 40, 26, 0, -39 },
  { 6053, 25, 39, 25, 4, -39 },
  { 6175, 31, 40, 33, 3, -39 },
  { 6330, 28, 39, 28, 5, -39 },
  { 6467, 43, 39, 44, 5, -39 },
  { 6677, 35, 39, 28, -3, -39 },
  { 6848, 26, 39, 26, 5, -39 },
  { 6975, 30, 39, 26, -2, -39 },
  { 7122, 21, 48, 16, -1, -39 },
  { 7248, 11, 39, 21, 6, -39 },
  { 7302, 22, 48, 16, -4, -39 },
  { 7434, 25, 24, 27, 1, -39 },
  { 7509, 21, 3, 20, -5, 5 },
  { 7517, 10, 8, 16, 8, -41 },
  { 7527, 26, 31, 29, 2, -30 },
  { 7628, 26, 42, 29, 1, -41 },
  { 7765, 22, 31, 23, 2, -30 },
  { 7851, 29, 42, 29, 2, -41 },
  { 8004, 23, 31, 26, 2, -30 },
  { 8094, 29, 54, 17, -6, -41 },
  { 8290, 28, 43, 29, 0, -30 },
  { 8441, 26, 41, 29, 1, -41 },
  { 8575, 14, 41, 14, 1, -41 },
  { 8647, 23, 54, 14, -7, -41 },
  { 8803, 28, 41, 26, 1, -41 },
  { 8947, 15, 41, 14, 1, -41 },
  { 9024, 40, 30, 43, 1, -30 },
  { 9174, 26, 30, 29, 1, -30 },
  { 9272, 24, 31, 28, 2, -30 },
  { 9365, 29, 43, 29, -2, -30 },
  { 9521, 26, 43, 29, 2, -30 },
  { 9661, 21, 30, 20, 1, -30 },
  { 9740, 22, 31, 22, 0, -30 },
  { 9826, 17, 37, 18, 3, -36 },
  { 9905, 26, 30, 29, 2, -29 },
  { 10003, 24, 29, 24, 3, -29 },
  { 10090, 37, 29, 38, 3, -29 },
  { 10225, 29, 29, 25, -2, -29 },
  { 10331, 31, 42, 25, -4, -29 },
  { 10494, 24, 29, 22, -1, -29 },
  { 10581, 22, 48, 19, 0, -39 },
  { 10713, 5, 54, 26, 11, -41 },
  { 10747, 21, 48, 19, -3, -39 },
  { 10873, 24, 8, 29, 3, -23 },
};

const GFXfont NotoSans_SemiCondensed_SemiBoldItalic54pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_SemiBoldItalic54pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_SemiBoldItalic54pt7bGlyphs,
  0x20, 0x7E, 74
};

#endif // _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC54PT7B_H_
