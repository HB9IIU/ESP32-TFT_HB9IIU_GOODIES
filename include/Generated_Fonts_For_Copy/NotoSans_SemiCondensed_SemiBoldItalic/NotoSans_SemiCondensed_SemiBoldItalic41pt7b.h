#ifndef _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC41PT7B_H_
#define _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC41PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-SemiBoldItalic.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_SemiBoldItalic41pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x3E, 0x07, 0xE0, 0x7E, 0x07, 0xC0,
  0x7C, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x01,
  0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x7C, 0x07, 0xE0, 0xFC, 0x0F, 0xC0, 0x7C, 0x00, 0x7C, 0x7D, 0xF1,
  0xE7, 0xC7, 0x9E, 0x3E, 0x78, 0xF9, 0xE3, 0xC7, 0x8F, 0x3C, 0x3C, 0xF0,
  0xE3, 0xC3, 0x80, 0x00, 0x3C, 0x38, 0x00, 0xF0, 0xF0, 0x01, 0xE1, 0xE0,
  0x03, 0xC3, 0x80, 0x07, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x38, 0x00,
  0x70, 0xF0, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0x0E,
  0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x70, 0x00, 0xE1, 0xE0, 0x03, 0xC3,
  0xC0, 0x07, 0x87, 0x01, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0x01, 0xC3, 0xC0, 0x07, 0x87, 0x80, 0x0F, 0x0E, 0x00,
  0x1C, 0x3C, 0x00, 0x78, 0x78, 0x00, 0xF0, 0xE0, 0x01, 0xC1, 0xC0, 0x07,
  0x87, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x07,
  0xF0, 0x01, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0xFD, 0x9C, 0x1F,
  0x38, 0x41, 0xF3, 0x80, 0x1F, 0x30, 0x01, 0xF3, 0x00, 0x1F, 0xB0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xCF, 0x80, 0x0C, 0xF8, 0x00, 0xCF,
  0x88, 0x1C, 0xF8, 0xE1, 0x9F, 0x8F, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF,
  0xC0, 0x3F, 0xF0, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x3C, 0x0F, 0xF0, 0x07,
  0x81, 0xFF, 0x80, 0xF0, 0x3E, 0x78, 0x0E, 0x03, 0xC7, 0x81, 0xE0, 0x78,
  0x78, 0x3C, 0x07, 0x87, 0x83, 0x80, 0x78, 0x78, 0x78, 0x07, 0x87, 0x8F,
  0x00, 0x70, 0x78, 0xE0, 0x0F, 0x0F, 0x1E, 0x00, 0xF0, 0xF3, 0xC7, 0xCF,
  0x0F, 0x3C, 0xFE, 0x79, 0xE7, 0x9F, 0xF7, 0xFE, 0xF3, 0xFF, 0x7F, 0xCF,
  0x78, 0xF3, 0xF9, 0xE7, 0x8F, 0x0E, 0x3C, 0x70, 0xF0, 0x03, 0xCF, 0x0F,
  0x00, 0x78, 0xF0, 0xF0, 0x0F, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0xF0, 0x1E,
  0x0E, 0x1E, 0x03, 0xC0, 0xE1, 0xE0, 0x3C, 0x0E, 0x1E, 0x07, 0x80, 0xF3,
  0xC0, 0xF0, 0x0F, 0xF8, 0x0F, 0x00, 0xFF, 0x81, 0xE0, 0x07, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x03,
  0xE3, 0xE0, 0x03, 0xC1, 0xE0, 0x07, 0xC1, 0xE0, 0x07, 0xC1, 0xE0, 0x07,
  0xC3, 0xE0, 0x07, 0xC7, 0xC0, 0x03, 0xCF, 0xC0, 0x03, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF8, 0x1F, 0x1F,
  0xFC, 0x3E, 0x3F, 0x7C, 0x3E, 0x7E, 0x7E, 0x7C, 0x7C, 0x3E, 0x7C, 0xF8,
  0x1F, 0xF8, 0xF8, 0x1F, 0xF8, 0xF8, 0x0F, 0xF0, 0xF8, 0x0F, 0xE0, 0xF8,
  0x0F, 0xC0, 0xFC, 0x1F, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F,
  0xF9, 0xF8, 0x1F, 0xF0, 0xFC, 0x3E, 0xF9, 0xF3, 0xC7, 0x8F, 0x1E, 0x38,
  0xF1, 0xE0, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xE0, 0x0F,
  0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x3E,
  0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x7C, 0x00,
  0xF0, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xF0,
  0x07, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xC0,
  0x1F, 0x00, 0xF8, 0x03, 0xC0, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x7C, 0x08, 0x3C, 0x06, 0x1E, 0x07, 0xCF, 0x03, 0xFF, 0x0F, 0xFF, 0xFF,
  0x0F, 0xFF, 0x83, 0xFF, 0xC3, 0xF8, 0x23, 0xFC, 0x03, 0xEF, 0x03, 0xE7,
  0x81, 0xF1, 0xE0, 0x70, 0xF8, 0x10, 0x78, 0x00, 0x10, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x8F, 0xC7, 0xC3,
  0xE3, 0xE1, 0xF0, 0xF0, 0xF8, 0x78, 0x78, 0x00, 0xFF, 0xFF, 0xFB, 0xFF,
  0x7F, 0xE0, 0x18, 0xF9, 0xFF, 0xEF, 0xCF, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x7F,
  0xFE, 0x1F, 0x87, 0xC3, 0xE0, 0xF8, 0xF8, 0x1F, 0x1F, 0x03, 0xE7, 0xE0,
  0x7C, 0xF8, 0x0F, 0x9F, 0x01, 0xF3, 0xE0, 0x3E, 0xF8, 0x07, 0xDF, 0x00,
  0xFB, 0xE0, 0x1F, 0x7C, 0x07, 0xCF, 0x80, 0xFB, 0xE0, 0x1F, 0x7C, 0x03,
  0xEF, 0x80, 0xF9, 0xF0, 0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0xF8, 0x7C, 0x3F,
  0x0F, 0x8F, 0xC1, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0x1F, 0xC0,
  0x00, 0x00, 0x7C, 0x07, 0xF0, 0x3F, 0xC1, 0xFE, 0x1F, 0xF8, 0xFF, 0xEF,
  0xEF, 0x9F, 0x3C, 0x39, 0xF0, 0x87, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xFC,
  0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x81, 0xE0, 0xFC, 0x06, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC0, 0x00,
  0x1E, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0,
  0x30, 0x1F, 0x02, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x1F, 0xF8, 0x03, 0xFC,
  0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x80,
  0x0F, 0x8C, 0x03, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x07,
  0xFF, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xBE, 0x00, 0xFB,
  0xC0, 0x0F, 0x3C, 0x01, 0xE7, 0xC0, 0x3C, 0x7C, 0x07, 0xC7, 0xC0, 0x78,
  0x78, 0x0F, 0x0F, 0x81, 0xE0, 0xF8, 0x3E, 0x0F, 0x87, 0xC0, 0xF8, 0x78,
  0x0F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0,
  0x00, 0x7C, 0x00, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x07,
  0xFF, 0xE0, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0xFF,
  0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x3F, 0x10, 0x03, 0xF0, 0xE0, 0x3F, 0x87, 0xFF, 0xF8, 0x3F,
  0xFF, 0x81, 0xFF, 0xF8, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x07,
  0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xCC, 0x0F, 0xC0, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x3C,
  0x07, 0xDF, 0xE0, 0xFF, 0xFE, 0x1F, 0xFF, 0xC7, 0xF8, 0xFC, 0xFC, 0x0F,
  0x9F, 0x81, 0xF3, 0xE0, 0x3E, 0x7C, 0x07, 0xCF, 0x80, 0xF9, 0xE0, 0x1F,
  0x3C, 0x07, 0xC7, 0xC0, 0xF8, 0xF8, 0x3F, 0x1F, 0x8F, 0xC1, 0xFF, 0xF8,
  0x3F, 0xFE, 0x03, 0xFF, 0x80, 0x3F, 0xC0, 0x00, 0x1F, 0xFF, 0xF3, 0xFF,
  0xFF, 0x3F, 0xFF, 0xF3, 0xFF, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xC7, 0xE0, 0xF8, 0x3F,
  0x0F, 0x81, 0xF0, 0xF0, 0x1F, 0x0F, 0x01, 0xF0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xFC, 0xFC, 0x07, 0xFF, 0x80, 0x3F, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0xC0, 0x1F, 0xFE, 0x03, 0xF3, 0xF0, 0x7E, 0x1F, 0x87, 0xC0, 0xF8, 0xF8,
  0x0F, 0x8F, 0x80, 0x78, 0xF8, 0x07, 0x8F, 0x80, 0xF8, 0xF8, 0x0F, 0x8F,
  0xC1, 0xF8, 0xFF, 0x7F, 0x07, 0xFF, 0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0x80,
  0x00, 0x3C, 0x00, 0x3F, 0xE0, 0x0F, 0xFE, 0x03, 0xFF, 0xE0, 0xFE, 0xFC,
  0x3F, 0x0F, 0xC7, 0xC0, 0xF9, 0xF0, 0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0x7C,
  0xF8, 0x0F, 0x9F, 0x01, 0xF3, 0xE0, 0x7E, 0x7C, 0x0F, 0xCF, 0x83, 0xF1,
  0xFF, 0xFE, 0x3F, 0xFF, 0xC3, 0xFE, 0xF8, 0x3F, 0x9F, 0x00, 0x87, 0xC0,
  0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x10,
  0x1F, 0x83, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0x00, 0x00,
  0x01, 0x01, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xE0, 0x70, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x07, 0xC1,
  0xF0, 0xFC, 0x3F, 0x07, 0x80, 0x00, 0x40, 0x1F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3E, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x81, 0xF0, 0x1F,
  0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x0F, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x1C, 0x00, 0x0F, 0x80, 0x07, 0xF0, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x03, 0xE0,
  0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x07,
  0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x30, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x80, 0x00, 0x1C, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0x80, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0xFF, 0x00, 0x1F, 0x80, 0x03, 0xC0, 0x00, 0x60, 0x00, 0x00,
  0x01, 0xC0, 0x0F, 0xFC, 0x3F, 0xFE, 0x3F, 0xFE, 0x3E, 0x7F, 0x10, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x03,
  0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x78, 0x3C, 0x00,
  0x03, 0xC3, 0xC0, 0x10, 0x0F, 0x1E, 0x07, 0xFC, 0x79, 0xE0, 0xFF, 0xE3,
  0xCE, 0x0F, 0xFF, 0x1E, 0xF0, 0xF8, 0x70, 0xF7, 0x87, 0x87, 0x87, 0xB8,
  0x78, 0x3C, 0x3F, 0xC3, 0x81, 0xC1, 0xFE, 0x3C, 0x1E, 0x0F, 0xE1, 0xE0,
  0xF0, 0x77, 0x0F, 0x07, 0x87, 0xB8, 0x78, 0x78, 0x3D, 0xC3, 0xC3, 0xC3,
  0xCE, 0x1E, 0x3E, 0x1C, 0x70, 0xFB, 0xFB, 0xE3, 0x87, 0xF9, 0xFE, 0x1E,
  0x1F, 0xCF, 0xE0, 0xF0, 0x18, 0x18, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x03, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x7B, 0xC0, 0x01, 0xEF, 0x00, 0x0F, 0xBC, 0x00, 0x3C,
  0xF0, 0x01, 0xF3, 0xE0, 0x07, 0x8F, 0x80, 0x3E, 0x3E, 0x00, 0xF0, 0xF8,
  0x07, 0xC3, 0xE0, 0x1E, 0x0F, 0x80, 0xF8, 0x3E, 0x03, 0xE0, 0xF8, 0x1F,
  0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x7C, 0x01,
  0xE1, 0xF0, 0x07, 0x8F, 0x80, 0x1F, 0x3E, 0x00, 0x7D, 0xF0, 0x01, 0xF7,
  0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x7C, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0xC0, 0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x07, 0xC1, 0xFC, 0x1F, 0x03,
  0xF0, 0x78, 0x07, 0xC3, 0xE0, 0x3F, 0x0F, 0x80, 0xF8, 0x3E, 0x03, 0xE0,
  0xF8, 0x1F, 0x07, 0xC1, 0xFC, 0x1F, 0xFF, 0xC0, 0x7F, 0xFC, 0x01, 0xFF,
  0xF8, 0x07, 0xFF, 0xF0, 0x3E, 0x07, 0xE0, 0xF8, 0x0F, 0x83, 0xE0, 0x3F,
  0x0F, 0x80, 0x7C, 0x3C, 0x03, 0xF1, 0xF0, 0x0F, 0x87, 0xC0, 0x3E, 0x1F,
  0x01, 0xF8, 0x7C, 0x1F, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF,
  0x80, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0x00, 0x00, 0xFF, 0xE0, 0x0F, 0xFF,
  0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x1F, 0xC0, 0x40, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00,
  0x01, 0xFC, 0x0C, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00,
  0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0,
  0x3F, 0xFF, 0xC0, 0x7C, 0x1F, 0xC0, 0xF8, 0x1F, 0x81, 0xF0, 0x1F, 0x87,
  0xC0, 0x3F, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0xFC,
  0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x07, 0xC7, 0xC0, 0x1F, 0x8F, 0x80,
  0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x03, 0xF1, 0xF0, 0x07,
  0xC3, 0xE0, 0x1F, 0x8F, 0x80, 0x7E, 0x1F, 0x01, 0xFC, 0x3E, 0x07, 0xF0,
  0x7C, 0x3F, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x0F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F,
  0xFE, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xFF, 0x81,
  0xFF, 0xF8, 0x1F, 0xFF, 0x81, 0xFF, 0xF0, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF,
  0xC0, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0xF0,
  0x7F, 0xFE, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00,
  0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xF0, 0x0C, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x0F, 0xFC, 0x7C, 0x0F, 0xFC, 0xFC, 0x0F, 0xF8, 0xFC, 0x0F, 0xF8, 0xF8,
  0x10, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x01, 0xF0, 0xFC, 0x01, 0xF0, 0xFC,
  0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x7E, 0x01, 0xF0, 0x7F, 0x03, 0xE0, 0x3F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x03,
  0xE0, 0x0F, 0x81, 0xF0, 0x07, 0xC1, 0xF0, 0x03, 0xE0, 0xF8, 0x03, 0xE0,
  0x7C, 0x01, 0xF0, 0x3E, 0x00, 0xF8, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x3E,
  0x0F, 0x80, 0x3E, 0x07, 0xC0, 0x1F, 0x03, 0xE0, 0x0F, 0x81, 0xF0, 0x07,
  0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF8, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x7E, 0x0F, 0x80, 0x3E, 0x07, 0xC0,
  0x1F, 0x03, 0xE0, 0x0F, 0x83, 0xE0, 0x07, 0xC1, 0xF0, 0x07, 0xC0, 0xF8,
  0x03, 0xE0, 0x7C, 0x01, 0xF0, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x1F,
  0x00, 0x7C, 0x0F, 0x80, 0x3E, 0x00, 0x03, 0xFF, 0x83, 0xFF, 0xC1, 0xFF,
  0xE0, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x1F,
  0xE0, 0x3F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x3F, 0xF0,
  0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xE0, 0x3F, 0x81,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x1F, 0x80, 0x7C, 0x1F, 0x80,
  0x3E, 0x1F, 0x80, 0x1E, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x0F, 0x8F, 0xC0,
  0x07, 0xCF, 0xC0, 0x03, 0xEF, 0xC0, 0x01, 0xE7, 0xC0, 0x01, 0xF7, 0xC0,
  0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xBE,
  0x00, 0x1F, 0x9F, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0xC7, 0xE0, 0x03, 0xE1,
  0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x7E, 0x00, 0xF8, 0x1F, 0x00, 0x7C,
  0x0F, 0x80, 0x3C, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x0F,
  0x80, 0x7E, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x03, 0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x07, 0xF8,
  0x01, 0xFE, 0x07, 0xF8, 0x01, 0xFE, 0x07, 0xF8, 0x03, 0xFE, 0x07, 0xF8,
  0x03, 0xFE, 0x0F, 0xF8, 0x07, 0xFE, 0x0F, 0xF8, 0x07, 0xBC, 0x0F, 0x78,
  0x0F, 0xFC, 0x0F, 0x78, 0x0F, 0x7C, 0x1F, 0x78, 0x1F, 0x7C, 0x1F, 0x78,
  0x1E, 0x78, 0x1F, 0x78, 0x3E, 0x78, 0x1E, 0x3C, 0x3C, 0xF8, 0x1E, 0x3C,
  0x7C, 0xF8, 0x3E, 0x3C, 0x78, 0xF8, 0x3E, 0x3C, 0xF8, 0xF0, 0x3E, 0x3C,
  0xF0, 0xF0, 0x3C, 0x3D, 0xF1, 0xF0, 0x3C, 0x3D, 0xE1, 0xF0, 0x7C, 0x3F,
  0xE1, 0xF0, 0x7C, 0x3F, 0xC1, 0xE0, 0x7C, 0x3F, 0xC3, 0xE0, 0x78, 0x3F,
  0x83, 0xE0, 0x78, 0x3F, 0x83, 0xE0, 0xF8, 0x3F, 0x03, 0xE0, 0xF8, 0x3F,
  0x03, 0xC0, 0xF0, 0x3E, 0x07, 0xC0, 0x03, 0xF0, 0x03, 0xE0, 0x7E, 0x00,
  0x7C, 0x1F, 0xC0, 0x0F, 0x03, 0xFC, 0x03, 0xE0, 0x7F, 0x80, 0x7C, 0x0F,
  0xF0, 0x0F, 0x81, 0xFE, 0x01, 0xE0, 0x7F, 0xE0, 0x3C, 0x0F, 0x7C, 0x0F,
  0x81, 0xE7, 0x81, 0xF0, 0x3C, 0xF8, 0x3E, 0x0F, 0x9F, 0x07, 0x81, 0xF1,
  0xE0, 0xF0, 0x3E, 0x3C, 0x3E, 0x07, 0x87, 0xC7, 0xC0, 0xF0, 0xF8, 0xF8,
  0x3E, 0x0F, 0x1E, 0x07, 0xC1, 0xF3, 0xC0, 0xF8, 0x3E, 0xF8, 0x1E, 0x07,
  0xDF, 0x03, 0xC0, 0x7B, 0xC0, 0xF8, 0x0F, 0xF8, 0x1F, 0x01, 0xFF, 0x03,
  0xE0, 0x1F, 0xE0, 0x78, 0x03, 0xFC, 0x0F, 0x00, 0x7F, 0x03, 0xE0, 0x0F,
  0xE0, 0x7C, 0x00, 0xFC, 0x0F, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x07,
  0xE0, 0x7E, 0x0F, 0xC0, 0x3E, 0x1F, 0x80, 0x3F, 0x1F, 0x00, 0x3F, 0x3F,
  0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x7E, 0x00, 0x1F, 0x7E, 0x00, 0x1F, 0x7C,
  0x00, 0x3F, 0x7C, 0x00, 0x3F, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3E, 0xFC,
  0x00, 0x3E, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF8,
  0x00, 0xFC, 0xFC, 0x01, 0xF8, 0x7C, 0x01, 0xF8, 0x7E, 0x03, 0xF0, 0x7F,
  0x0F, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0x01, 0xFF,
  0xFE, 0x07, 0xC1, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x83, 0xE0, 0x3F,
  0x0F, 0x80, 0xFC, 0x3E, 0x03, 0xE0, 0xF8, 0x0F, 0x87, 0xC0, 0x7E, 0x1F,
  0x01, 0xF0, 0x7C, 0x1F, 0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF,
  0x80, 0xFF, 0xF8, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF,
  0xFC, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0x3E, 0x1F, 0x80, 0x3F, 0x1F, 0x00,
  0x3F, 0x3F, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x7E, 0x00, 0x1F, 0x7E, 0x00,
  0x1F, 0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0xFC, 0x00, 0x3E, 0xFC, 0x00,
  0x3E, 0xFC, 0x00, 0x3E, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x7C, 0xF8, 0x00,
  0x7C, 0xF8, 0x00, 0xFC, 0xFC, 0x00, 0xF8, 0x7C, 0x01, 0xF8, 0x7E, 0x03,
  0xF0, 0x7F, 0x0F, 0xE0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x0F, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0,
  0x7C, 0x1F, 0x83, 0xE0, 0x7C, 0x1F, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x80,
  0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x7E, 0x3E, 0x03, 0xE1, 0xF0, 0x7F, 0x0F,
  0xFF, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xFE, 0x01, 0xF1, 0xF0,
  0x0F, 0x8F, 0x80, 0x7C, 0x3E, 0x03, 0xE1, 0xF0, 0x3E, 0x0F, 0x81, 0xF0,
  0x3E, 0x0F, 0x81, 0xF0, 0x7C, 0x0F, 0x83, 0xC0, 0x7E, 0x3E, 0x01, 0xF1,
  0xF0, 0x0F, 0x8F, 0x80, 0x7E, 0x00, 0x00, 0x1E, 0x00, 0x07, 0xFF, 0x00,
  0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x03, 0xF0, 0x30, 0x3F, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x80, 0x1F, 0x87,
  0x81, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x1F, 0xF8,
  0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x80,
  0x3E, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x7C, 0x1F, 0x00,
  0x7C, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0xFC, 0x3E, 0x00,
  0xF8, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x01,
  0xF0, 0x7C, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0xF8, 0x03,
  0xF0, 0xF8, 0x03, 0xE0, 0xFC, 0x03, 0xE0, 0x7C, 0x07, 0xE0, 0x7E, 0x0F,
  0xC0, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xBE, 0x00, 0x7D, 0xF0, 0x07, 0xCF,
  0x80, 0x3E, 0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x01, 0xF0, 0xF8, 0x0F,
  0x87, 0xC0, 0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x0F, 0x83, 0xE0, 0x3C,
  0x1F, 0x01, 0xE1, 0xF0, 0x0F, 0x0F, 0x80, 0x78, 0xF8, 0x03, 0xC7, 0xC0,
  0x1E, 0x7C, 0x00, 0xF3, 0xE0, 0x07, 0xBE, 0x00, 0x3D, 0xF0, 0x01, 0xEF,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0xFC, 0x03,
  0xE0, 0x0F, 0xBE, 0x01, 0xF0, 0x07, 0xDF, 0x01, 0xF8, 0x07, 0xCF, 0x80,
  0xFE, 0x03, 0xE7, 0xC0, 0x7F, 0x03, 0xE3, 0xE0, 0x7F, 0x81, 0xF1, 0xF0,
  0x3F, 0xC0, 0xF0, 0xF8, 0x3D, 0xE0, 0xF8, 0x7C, 0x1E, 0xF0, 0x7C, 0x3E,
  0x1F, 0x78, 0x7C, 0x1F, 0x0F, 0x3C, 0x3E, 0x0F, 0x8F, 0x9E, 0x3E, 0x07,
  0xC7, 0x8F, 0x1F, 0x03, 0xE3, 0xC7, 0x8F, 0x01, 0xF3, 0xC3, 0xCF, 0x80,
  0xF9, 0xE1, 0xE7, 0xC0, 0x7D, 0xF0, 0xF7, 0xC0, 0x3C, 0xF0, 0x7B, 0xE0,
  0x1E, 0x78, 0x3D, 0xE0, 0x0F, 0x78, 0x1F, 0xF0, 0x07, 0xBC, 0x0F, 0xF0,
  0x03, 0xFC, 0x07, 0x78, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0xFF, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x1F, 0x80, 0x3F,
  0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x7C, 0x03,
  0xE0, 0x1F, 0x01, 0xF0, 0x07, 0xE0, 0xFC, 0x00, 0xF8, 0x3E, 0x00, 0x3E,
  0x1F, 0x00, 0x0F, 0x8F, 0xC0, 0x01, 0xF3, 0xE0, 0x00, 0x7D, 0xF0, 0x00,
  0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xDF, 0x00, 0x03,
  0xE7, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0xFC, 0x3E, 0x00, 0x7E, 0x0F, 0x80,
  0x1F, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x1F, 0x01, 0xF0, 0x07,
  0xC0, 0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x03, 0xFF, 0x80, 0x7E, 0xF8, 0x07,
  0xCF, 0x80, 0xF8, 0x7C, 0x0F, 0x87, 0xC1, 0xF0, 0x7C, 0x3F, 0x07, 0xC3,
  0xE0, 0x3C, 0x7C, 0x03, 0xC7, 0xC0, 0x3E, 0xF8, 0x03, 0xFF, 0x00, 0x3F,
  0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x07,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x40, 0x7F, 0x80,
  0x7F, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xF8, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xF0, 0xF8, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xF0, 0xF8, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xF0, 0xF8, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xF0, 0xF8, 0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x1F, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x01,
  0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0xFF,
  0x80, 0xFF, 0x80, 0x00, 0x38, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0xF7, 0x80, 0x1E, 0x78, 0x07, 0x8F,
  0x00, 0xF1, 0xE0, 0x3C, 0x1E, 0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x78, 0x07,
  0x8F, 0x00, 0xF3, 0xC0, 0x1E, 0xF8, 0x01, 0xFE, 0x00, 0x3C, 0x7F, 0xFF,
  0xFF, 0xFF, 0xF8, 0xF9, 0xF1, 0xF1, 0xE1, 0xC0, 0x00, 0x60, 0x08, 0x0F,
  0xE7, 0x81, 0xFF, 0xBC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xC3, 0xF8,
  0x7C, 0x0F, 0x87, 0xE0, 0x7C, 0x3E, 0x03, 0xE3, 0xF0, 0x1F, 0x1F, 0x00,
  0xF0, 0xF8, 0x0F, 0x87, 0xC0, 0x7C, 0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x1F,
  0x81, 0xF0, 0xFC, 0x0F, 0x83, 0xE0, 0xFC, 0x1F, 0x0F, 0xE0, 0xFF, 0xFF,
  0x07, 0xFE, 0xF0, 0x1F, 0xE7, 0x80, 0x7E, 0x3C, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC3, 0x00, 0x3E, 0x7E, 0x01,
  0xFF, 0xF8, 0x0F, 0x7F, 0xE0, 0xFF, 0xFF, 0x07, 0xF0, 0xF8, 0x3F, 0x07,
  0xC1, 0xF0, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x0F, 0x87, 0xC0, 0x7C, 0x3E,
  0x03, 0xE1, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x0F, 0x87, 0xC0, 0x7C,
  0x3E, 0x07, 0xE1, 0xF0, 0x3E, 0x1F, 0xC3, 0xF0, 0xFF, 0xFF, 0x07, 0xBF,
  0xF0, 0x3D, 0xFF, 0x03, 0xC7, 0xF0, 0x00, 0x00, 0x78, 0x03, 0xFF, 0x07,
  0xFF, 0x0F, 0xFE, 0x1F, 0xDE, 0x3F, 0x02, 0x3E, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x18, 0xFF, 0xF8, 0x7F,
  0xF8, 0x3F, 0xF8, 0x1F, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x60, 0xF8, 0x07, 0xF3, 0xC0, 0x7F, 0xFF, 0x03,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x7E, 0x1F, 0x81, 0xF0, 0x3E, 0x0F, 0x80,
  0xF8, 0x3E, 0x03, 0xE1, 0xF8, 0x0F, 0x87, 0xC0, 0x3C, 0x1F, 0x01, 0xF0,
  0x7C, 0x07, 0xC1, 0xF0, 0x1F, 0x0F, 0xC0, 0x7C, 0x3E, 0x03, 0xE0, 0xF8,
  0x0F, 0x81, 0xF0, 0x7E, 0x07, 0xC3, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF,
  0x00, 0xFF, 0xBC, 0x01, 0xF8, 0xF0, 0x00, 0x00, 0x30, 0x01, 0xFF, 0x01,
  0xFF, 0xC1, 0xFF, 0xF1, 0xF8, 0xF9, 0xF0, 0x7C, 0xF8, 0x1E, 0xF8, 0x1F,
  0x7C, 0x0F, 0xFC, 0x1F, 0xBF, 0xFF, 0x9F, 0xFF, 0x8F, 0xFF, 0x07, 0xF8,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x01, 0x1F,
  0xEF, 0x87, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x08, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x30, 0x04, 0x03, 0xF9, 0xE0,
  0x3F, 0xF7, 0x81, 0xFF, 0xDE, 0x07, 0xFF, 0xF8, 0x3F, 0x0F, 0xE0, 0xF8,
  0x1F, 0x07, 0xE0, 0x7C, 0x1F, 0x01, 0xF0, 0xFC, 0x07, 0xC3, 0xE0, 0x1E,
  0x0F, 0x80, 0xF8, 0x3E, 0x03, 0xE0, 0xF8, 0x0F, 0x83, 0xE0, 0x7E, 0x1F,
  0x81, 0xF0, 0x7E, 0x0F, 0xC0, 0xF8, 0x3F, 0x03, 0xE1, 0xFC, 0x0F, 0xFF,
  0xF0, 0x3F, 0xF7, 0x80, 0x7F, 0xBE, 0x00, 0xFC, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x20, 0x0F, 0x80, 0xF0,
  0xFE, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC1, 0x80,
  0x7C, 0xFE, 0x07, 0xFF, 0xE0, 0x7B, 0xFF, 0x0F, 0xFF, 0xF0, 0xFE, 0x1F,
  0x0F, 0xC1, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF1, 0xF0, 0x1F, 0x1F, 0x01,
  0xF1, 0xF0, 0x1E, 0x1F, 0x03, 0xE3, 0xE0, 0x3E, 0x3E, 0x03, 0xE3, 0xE0,
  0x3E, 0x3E, 0x03, 0xC3, 0xE0, 0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0x7C,
  0x07, 0xC7, 0xC0, 0xF8, 0xF8, 0x0F, 0x80, 0x00, 0xE0, 0x1F, 0x03, 0xF0,
  0x3F, 0x03, 0xE0, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x07, 0xC0,
  0x7C, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7C, 0x07,
  0xC0, 0x7C, 0x07, 0xC0, 0xFC, 0x00, 0x00, 0x07, 0x00, 0x07, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x09, 0xF8,
  0x07, 0xFC, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x04, 0x1F,
  0x03, 0xE0, 0x7C, 0x1F, 0x01, 0xE0, 0xF8, 0x0F, 0x87, 0xC0, 0x3E, 0x3F,
  0x00, 0xF9, 0xF8, 0x03, 0xEF, 0xC0, 0x0F, 0x3E, 0x00, 0x7D, 0xF0, 0x01,
  0xFF, 0x80, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xF3,
  0xE0, 0x0F, 0x8F, 0x80, 0x3E, 0x3E, 0x00, 0xF0, 0x7C, 0x07, 0xC1, 0xF0,
  0x1F, 0x07, 0xC0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x0F, 0x80, 0xFC, 0x00,
  0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7C,
  0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0xF8, 0x00, 0x00,
  0x03, 0x00, 0x60, 0x0F, 0x3F, 0x83, 0xF8, 0x1E, 0xFF, 0x9F, 0xF0, 0x3F,
  0xFF, 0x3F, 0xF0, 0xFF, 0xBF, 0xF7, 0xE1, 0xFC, 0x3F, 0x87, 0xC3, 0xF0,
  0x7E, 0x0F, 0x87, 0xC0, 0xFC, 0x1F, 0x0F, 0x81, 0xF0, 0x3E, 0x3E, 0x03,
  0xE0, 0x7C, 0x7C, 0x0F, 0x80, 0xF8, 0xF8, 0x1F, 0x01, 0xE1, 0xF0, 0x3E,
  0x07, 0xC7, 0xC0, 0x7C, 0x0F, 0x8F, 0x80, 0xF0, 0x1F, 0x1F, 0x03, 0xE0,
  0x3E, 0x3E, 0x07, 0xC0, 0xF8, 0x78, 0x0F, 0x81, 0xF1, 0xF0, 0x1F, 0x03,
  0xE3, 0xE0, 0x3C, 0x07, 0xC7, 0xC0, 0xF8, 0x0F, 0x0F, 0x81, 0xF0, 0x3E,
  0x3E, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0x03, 0x80, 0x78, 0xFE, 0x07, 0xBF,
  0xE0, 0x7F, 0xFF, 0x0F, 0xFF, 0xF0, 0xFE, 0x1F, 0x0F, 0xC1, 0xF0, 0xF8,
  0x1F, 0x0F, 0x81, 0xF1, 0xF8, 0x1F, 0x1F, 0x01, 0xF1, 0xF0, 0x1E, 0x1F,
  0x03, 0xE3, 0xE0, 0x3E, 0x3E, 0x03, 0xE3, 0xE0, 0x3E, 0x3E, 0x03, 0xC3,
  0xE0, 0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0xF8,
  0xFC, 0x0F, 0x80, 0x00, 0x70, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x7F, 0xFE,
  0x1F, 0xFF, 0x8F, 0xC3, 0xF7, 0xE0, 0x7D, 0xF0, 0x1F, 0x7C, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x03, 0xEF, 0x00,
  0xFB, 0xC0, 0x3E, 0xF0, 0x1F, 0x3E, 0x07, 0xCF, 0x83, 0xE3, 0xFF, 0xF8,
  0x7F, 0xFC, 0x0F, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xC0, 0x03, 0xCF,
  0xE0, 0x07, 0xBF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0xCF, 0xC0, 0x7F, 0x0F,
  0x80, 0xFC, 0x1F, 0x01, 0xF0, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x80, 0xF8,
  0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x78, 0x07, 0xC0, 0xF0, 0x0F, 0x83,
  0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x0F, 0x81, 0xF8, 0x1F, 0x03, 0xE0, 0x7F,
  0x0F, 0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x03, 0xEF, 0xF0, 0x07, 0x8F,
  0xC0, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x20, 0x00, 0x1F, 0xCF, 0x07,
  0xFE, 0xF0, 0x7F, 0xEF, 0x0F, 0xFF, 0xF1, 0xF8, 0x7E, 0x1F, 0x03, 0xE3,
  0xE0, 0x3E, 0x3E, 0x03, 0xE7, 0xE0, 0x3E, 0x7C, 0x03, 0xC7, 0xC0, 0x7C,
  0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0x78, 0x07, 0xCF, 0x80, 0xF8, 0xF8, 0x0F,
  0x87, 0xC1, 0xF8, 0x7C, 0x3F, 0x87, 0xFF, 0xF8, 0x7F, 0xEF, 0x03, 0xFD,
  0xF0, 0x1F, 0x9F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0x03, 0x03, 0xCF, 0xC1, 0xEF, 0xC0,
  0xF7, 0xE0, 0xFF, 0xF0, 0x7F, 0x88, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0x80,
  0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x00, 0x00, 0xE0, 0x01, 0xFF, 0x83, 0xFF,
  0xE3, 0xFF, 0xE1, 0xF8, 0xF0, 0xF8, 0x10, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3E, 0x30, 0x1F, 0x1F, 0xFF,
  0x8F, 0xFF, 0x87, 0xFF, 0x81, 0xFF, 0x80, 0x03, 0x80, 0x3C, 0x01, 0xE0,
  0x1F, 0x00, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xF1, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0xF0, 0xFF, 0x83,
  0xFC, 0x1F, 0xE0, 0x1F, 0x01, 0xE3, 0xC0, 0x7C, 0xF8, 0x0F, 0x9F, 0x01,
  0xF3, 0xE0, 0x3C, 0x7C, 0x0F, 0x8F, 0x01, 0xF3, 0xE0, 0x3E, 0x7C, 0x07,
  0xCF, 0x80, 0xF1, 0xF0, 0x3E, 0x3C, 0x07, 0xCF, 0x80, 0xF9, 0xF0, 0x3F,
  0x3E, 0x07, 0xC7, 0xC0, 0xF8, 0xF8, 0x3F, 0x1F, 0x0F, 0xE3, 0xFF, 0xFC,
  0x7F, 0xEF, 0x07, 0xF9, 0xE0, 0x7E, 0x3C, 0x00, 0xF8, 0x07, 0xFF, 0x00,
  0xFB, 0xE0, 0x3E, 0x7C, 0x07, 0xC7, 0x81, 0xF0, 0xF0, 0x3E, 0x1E, 0x0F,
  0x83, 0xC1, 0xF0, 0x78, 0x7C, 0x0F, 0x0F, 0x81, 0xE3, 0xE0, 0x3E, 0x7C,
  0x07, 0xDF, 0x00, 0xFB, 0xE0, 0x1F, 0x78, 0x01, 0xFF, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x00, 0xF8, 0x1F, 0x81, 0xFB, 0xC0, 0xFC, 0x0F, 0x9E, 0x07, 0xE0, 0x78,
  0xF0, 0x7F, 0x07, 0xC7, 0x83, 0xF8, 0x3E, 0x3C, 0x3F, 0xC3, 0xE1, 0xE1,
  0xFE, 0x1F, 0x0F, 0x1E, 0xF1, 0xF0, 0x78, 0xF7, 0x8F, 0x83, 0xC7, 0xBC,
  0x78, 0x1E, 0x79, 0xE7, 0xC0, 0xF3, 0xCF, 0x3C, 0x07, 0xBC, 0x7B, 0xE0,
  0x3D, 0xE3, 0xDF, 0x01, 0xEE, 0x1E, 0xF0, 0x0F, 0xF0, 0xFF, 0x80, 0x7F,
  0x87, 0xF8, 0x03, 0xF8, 0x3F, 0xC0, 0x1F, 0xC1, 0xFC, 0x00, 0xFC, 0x0F,
  0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x7E,
  0x07, 0xC1, 0xF0, 0x0F, 0x87, 0xE0, 0x1F, 0x0F, 0x80, 0x1F, 0x3E, 0x00,
  0x3E, 0xF8, 0x00, 0x7D, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0xC0, 0x03, 0xEF, 0x80, 0x0F, 0x8F, 0x00, 0x3F, 0x1F,
  0x00, 0x7C, 0x3E, 0x01, 0xF0, 0x7E, 0x07, 0xE0, 0x7C, 0x1F, 0x80, 0xF8,
  0x00, 0x07, 0xC0, 0x3F, 0x07, 0xC0, 0x3E, 0x03, 0xC0, 0x7C, 0x03, 0xC0,
  0x7C, 0x03, 0xC0, 0xF8, 0x03, 0xC0, 0xF8, 0x03, 0xC1, 0xF0, 0x03, 0xE1,
  0xF0, 0x03, 0xE1, 0xE0, 0x03, 0xE3, 0xE0, 0x03, 0xE3, 0xC0, 0x01, 0xE7,
  0xC0, 0x01, 0xE7, 0x80, 0x01, 0xEF, 0x80, 0x01, 0xEF, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x8F, 0xC0,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x3F, 0xFE, 0x00, 0x1F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xFF, 0xE3, 0xFF, 0xF8, 0xFF, 0xFC,
  0x3F, 0xFF, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0,
  0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0xFF,
  0x00, 0x7F, 0x00, 0x3C, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x01, 0xE0, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xFC, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0x00, 0xFE, 0x01, 0xFE, 0x03, 0xF0, 0x03, 0xE0, 0x03,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x1F, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xF8,
  0x00, 0x08, 0x00, 0x2F, 0xF0, 0x0F, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0x00, 0xFF, 0x20, 0x01, 0x80,
};

const GFXglyph NotoSans_SemiCondensed_SemiBoldItalic41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 12, 29, 11, 0, -29 },
  { 45, 14, 10, 17, 4, -29 },
  { 63, 23, 29, 24, 1, -29 },
  { 147, 20, 33, 21, 1, -31 },
  { 230, 28, 30, 32, 2, -30 },
  { 335, 24, 30, 25, 1, -30 },
  { 425, 7, 10, 10, 4, -29 },
  { 434, 14, 35, 12, 1, -29 },
  { 496, 14, 36, 12, -3, -30 },
  { 559, 17, 18, 20, 4, -31 },
  { 598, 19, 19, 22, 2, -24 },
  { 644, 9, 10, 11, -2, -5 },
  { 656, 11, 4, 12, 1, -13 },
  { 662, 7, 6, 11, 0, -6 },
  { 668, 21, 29, 16, -2, -29 },
  { 745, 19, 30, 21, 1, -30 },
  { 817, 14, 29, 21, 4, -29 },
  { 868, 21, 30, 21, -1, -30 },
  { 947, 20, 30, 21, 0, -30 },
  { 1022, 20, 29, 21, 0, -29 },
  { 1095, 21, 29, 21, 0, -29 },
  { 1172, 19, 30, 21, 2, -30 },
  { 1244, 20, 29, 21, 2, -29 },
  { 1317, 20, 30, 21, 1, -30 },
  { 1392, 19, 30, 21, 1, -30 },
  { 1464, 10, 23, 11, 0, -23 },
  { 1493, 12, 28, 11, -2, -23 },
  { 1535, 19, 20, 22, 2, -25 },
  { 1583, 18, 11, 22, 2, -20 },
  { 1608, 19, 20, 22, 2, -25 },
  { 1656, 16, 30, 16, 2, -30 },
  { 1716, 29, 33, 32, 2, -29 },
  { 1836, 22, 29, 22, -2, -29 },
  { 1916, 22, 29, 23, 1, -29 },
  { 1996, 22, 30, 22, 2, -30 },
  { 2079, 23, 29, 25, 1, -29 },
  { 2163, 20, 29, 20, 1, -29 },
  { 2236, 20, 29, 19, 1, -29 },
  { 2309, 24, 30, 26, 2, -30 },
  { 2399, 25, 29, 26, 1, -29 },
  { 2490, 17, 29, 14, -1, -29 },
  { 2552, 18, 37, 12, -6, -29 },
  { 2636, 25, 29, 22, 1, -29 },
  { 2727, 15, 29, 19, 1, -29 },
  { 2782, 32, 29, 33, 1, -29 },
  { 2898, 27, 29, 27, 1, -29 },
  { 2996, 24, 30, 27, 2, -30 },
  { 3086, 22, 29, 22, 1, -29 },
  { 3166, 24, 37, 27, 2, -30 },
  { 3277, 21, 29, 22, 1, -29 },
  { 3354, 21, 30, 20, 0, -30 },
  { 3433, 19, 29, 19, 3, -29 },
  { 3502, 24, 29, 25, 2, -29 },
  { 3589, 21, 29, 22, 4, -29 },
  { 3666, 33, 29, 33, 4, -29 },
  { 3786, 26, 29, 21, -2, -29 },
  { 3881, 20, 29, 20, 4, -29 },
  { 3954, 23, 29, 19, -1, -29 },
  { 4038, 16, 36, 12, -1, -29 },
  { 4110, 9, 29, 16, 4, -29 },
  { 4143, 16, 36, 12, -3, -29 },
  { 4215, 19, 18, 21, 1, -29 },
  { 4258, 16, 2, 15, -4, 4 },
  { 4262, 7, 6, 12, 6, -31 },
  { 4268, 21, 23, 22, 1, -23 },
  { 4329, 21, 31, 22, 0, -31 },
  { 4411, 16, 23, 18, 2, -23 },
  { 4457, 22, 31, 22, 1, -31 },
  { 4543, 17, 23, 20, 2, -23 },
  { 4592, 23, 41, 13, -5, -31 },
  { 4710, 22, 33, 22, 0, -23 },
  { 4801, 20, 31, 22, 0, -31 },
  { 4879, 12, 31, 11, 0, -31 },
  { 4926, 17, 41, 11, -5, -31 },
  { 5014, 22, 31, 20, 0, -31 },
  { 5100, 12, 31, 11, 0, -31 },
  { 5147, 31, 23, 33, 0, -23 },
  { 5237, 20, 23, 22, 0, -23 },
  { 5295, 18, 23, 21, 2, -23 },
  { 5347, 23, 33, 22, -2, -23 },
  { 5442, 20, 33, 22, 1, -23 },
  { 5525, 17, 23, 15, 0, -23 },
  { 5574, 17, 23, 17, 0, -23 },
  { 5623, 13, 27, 14, 2, -27 },
  { 5667, 19, 22, 22, 2, -22 },
  { 5720, 19, 22, 18, 2, -22 },
  { 5773, 29, 22, 29, 2, -22 },
  { 5853, 23, 22, 19, -2, -22 },
  { 5917, 24, 32, 19, -3, -22 },
  { 6013, 18, 22, 17, -1, -22 },
  { 6063, 17, 35, 14, 0, -29 },
  { 6138, 4, 41, 20, 8, -31 },
  { 6159, 16, 35, 14, -2, -29 },
  { 6229, 19, 7, 22, 2, -18 },
};

const GFXfont NotoSans_SemiCondensed_SemiBoldItalic41pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_SemiBoldItalic41pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_SemiBoldItalic41pt7bGlyphs,
  0x20, 0x7E, 56
};

#endif // _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC41PT7B_H_
