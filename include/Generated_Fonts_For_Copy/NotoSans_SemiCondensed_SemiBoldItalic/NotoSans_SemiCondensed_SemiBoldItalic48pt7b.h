#ifndef _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC48PT7B_H_
#define _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC48PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-SemiBoldItalic.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_SemiBoldItalic48pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF8, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3E, 0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x07, 0xC0,
  0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFC, 0x07, 0xC0, 0x08, 0x00, 0x7E, 0x3F,
  0x7E, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x7C, 0x78, 0x7C,
  0xF8, 0x7C, 0xF8, 0x78, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0xF8, 0x00, 0x0F,
  0x07, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x0F, 0x07, 0x80,
  0x03, 0xE0, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xE0,
  0xF0, 0x00, 0x7C, 0x3E, 0x03, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x1E,
  0x00, 0x0F, 0x87, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x0F,
  0x87, 0xC0, 0x01, 0xE0, 0xF0, 0x0F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF8, 0x07, 0x83, 0xC0, 0x01, 0xF0,
  0xF8, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xF0, 0xF8, 0x00,
  0x3C, 0x1E, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x1E,
  0x00, 0x07, 0x83, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x3E, 0x00, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xF6, 0x78, 0x1F, 0x9C, 0x10, 0x3E, 0x38,
  0x00, 0x7C, 0x70, 0x00, 0xF8, 0xE0, 0x01, 0xF9, 0x80, 0x03, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0C, 0xFC, 0x00,
  0x19, 0xF8, 0x00, 0x71, 0xF0, 0x00, 0xE3, 0xE0, 0x01, 0xC7, 0xC6, 0x03,
  0x1F, 0x8F, 0x0E, 0x7F, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x04, 0x07, 0xF8, 0x00, 0x78, 0x0F, 0xFC, 0x00, 0xF8, 0x1F, 0xFC,
  0x01, 0xF0, 0x3F, 0x7C, 0x01, 0xE0, 0x3E, 0x3E, 0x03, 0xE0, 0x7C, 0x3E,
  0x07, 0xC0, 0x7C, 0x3E, 0x07, 0x80, 0x78, 0x3E, 0x0F, 0x80, 0x78, 0x3E,
  0x1F, 0x00, 0xF8, 0x3C, 0x1E, 0x00, 0xF8, 0x3C, 0x3E, 0x00, 0xF8, 0x7C,
  0x7C, 0x00, 0xF0, 0x7C, 0x78, 0x00, 0xF0, 0x78, 0xF8, 0xF8, 0xF0, 0xF9,
  0xF3, 0xFE, 0xF8, 0xF9, 0xE7, 0xFF, 0xF9, 0xF3, 0xE7, 0xFF, 0xFF, 0xE7,
  0xCF, 0x9F, 0x7F, 0xE7, 0x9F, 0x0F, 0x3F, 0x8F, 0x9F, 0x0F, 0x0E, 0x1F,
  0x1E, 0x0F, 0x00, 0x1E, 0x3E, 0x0F, 0x00, 0x3E, 0x3E, 0x0F, 0x00, 0x7C,
  0x3E, 0x1F, 0x00, 0x78, 0x3C, 0x1F, 0x00, 0xF8, 0x3C, 0x1F, 0x01, 0xF0,
  0x3C, 0x1E, 0x01, 0xE0, 0x3C, 0x3E, 0x03, 0xE0, 0x3C, 0x3E, 0x07, 0xC0,
  0x3C, 0x7C, 0x07, 0x80, 0x3F, 0xFC, 0x0F, 0x80, 0x3F, 0xF8, 0x1F, 0x00,
  0x1F, 0xF0, 0x3E, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00,
  0x1F, 0x87, 0xE0, 0x01, 0xF0, 0x7E, 0x00, 0x1F, 0x07, 0xE0, 0x03, 0xF0,
  0x7E, 0x00, 0x3F, 0x07, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x1F, 0x80,
  0x01, 0xF3, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFF, 0x03,
  0xF1, 0xFF, 0xF0, 0x3E, 0x3F, 0x9F, 0x87, 0xE3, 0xF1, 0xF8, 0x7C, 0x7E,
  0x0F, 0xCF, 0xC7, 0xC0, 0xFF, 0xF8, 0xFC, 0x07, 0xFF, 0x8F, 0xC0, 0x7F,
  0xF0, 0xFC, 0x03, 0xFE, 0x0F, 0xC0, 0x1F, 0xC0, 0xFC, 0x01, 0xFC, 0x0F,
  0xE0, 0x7F, 0xC0, 0xFF, 0x3F, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xBF, 0x03, 0xFF, 0xF3, 0xF8, 0x0F, 0xFC, 0x1F, 0xC0, 0x3E, 0xFD, 0xFB,
  0xE7, 0xCF, 0x9E, 0x7C, 0xF9, 0xF3, 0xC7, 0x80, 0x00, 0x1F, 0x80, 0x1F,
  0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x18,
  0x3E, 0x01, 0xF1, 0xE0, 0x0F, 0xEF, 0x00, 0x7F, 0xF8, 0xFF, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x3F, 0x9F, 0x83, 0xFE, 0x00, 0x3E,
  0xF0, 0x03, 0xF7, 0xC0, 0x7F, 0x1E, 0x01, 0xF0, 0xF8, 0x07, 0x87, 0xC0,
  0x18, 0x1F, 0x00, 0x00, 0xE0, 0x00, 0x04, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x0F, 0xC3, 0xF1, 0xF8, 0x7E, 0x1F, 0x0F, 0xC3, 0xE0, 0xF8,
  0x7C, 0x1F, 0x0F, 0x83, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0C, 0x3E, 0x7F, 0x7F, 0xFE, 0x7E, 0x7C, 0x10, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x00,
  0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x1F, 0xC7, 0xE0, 0xFE, 0x1F, 0x83, 0xF0,
  0x3F, 0x1F, 0x80, 0xFC, 0x7E, 0x03, 0xF3, 0xF0, 0x0F, 0xCF, 0xC0, 0x3F,
  0x3F, 0x00, 0xFD, 0xF8, 0x03, 0xF7, 0xE0, 0x0F, 0xDF, 0x80, 0x3E, 0xFC,
  0x01, 0xFB, 0xF0, 0x07, 0xEF, 0xC0, 0x1F, 0xBF, 0x00, 0x7E, 0xFC, 0x01,
  0xFB, 0xF0, 0x0F, 0xCF, 0x80, 0x3F, 0x3E, 0x00, 0xFC, 0xF8, 0x07, 0xE3,
  0xE0, 0x1F, 0x8F, 0x80, 0x7E, 0x3E, 0x03, 0xF0, 0xFC, 0x1F, 0xC3, 0xF0,
  0xFE, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x7F, 0x01, 0xFF, 0x03, 0xFE,
  0x07, 0xFE, 0x1F, 0xFE, 0x3F, 0xFE, 0xFF, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C,
  0x30, 0xFC, 0x20, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8,
  0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0,
  0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF0, 0x1F, 0xE3, 0xF8, 0x07, 0x80, 0xFC, 0x01, 0x80,
  0x7F, 0x00, 0x80, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xFC, 0x07,
  0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x01, 0xF0, 0xFE, 0x01, 0x80, 0x7F, 0x01,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x01,
  0xFF, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x80, 0x03, 0xF0, 0xC0, 0x07, 0xF0, 0xFC, 0x7F, 0xE0, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0x7C, 0x00,
  0x1F, 0x7C, 0x00, 0x3E, 0xFC, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF8, 0x00,
  0xF8, 0xF8, 0x01, 0xF1, 0xF8, 0x03, 0xE1, 0xF8, 0x03, 0xE1, 0xF0, 0x07,
  0xC1, 0xF0, 0x0F, 0x83, 0xF0, 0x1F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3E,
  0x03, 0xE0, 0x7C, 0x03, 0xE0, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07,
  0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x1E, 0x3F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC4, 0x00,
  0x7F, 0x0C, 0x01, 0xFE, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF,
  0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x3F, 0xC0,
  0x80, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE3, 0xE0, 0x0F,
  0x9F, 0xF0, 0x3F, 0x7F, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xE1, 0xFE,
  0x0F, 0xC7, 0xF8, 0x1F, 0x8F, 0xE0, 0x3F, 0x1F, 0x80, 0x3E, 0x3F, 0x00,
  0x7C, 0x7E, 0x01, 0xF8, 0xFC, 0x03, 0xF1, 0xF8, 0x07, 0xE3, 0xF0, 0x0F,
  0x87, 0xE0, 0x3F, 0x0F, 0xC0, 0x7E, 0x1F, 0xC1, 0xF8, 0x1F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xE0,
  0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0xFE, 0x1F, 0xC1,
  0xF8, 0x1F, 0x83, 0xE0, 0x1F, 0x07, 0xC0, 0x3E, 0x1F, 0x80, 0xFC, 0x3F,
  0x01, 0xF8, 0x3E, 0x03, 0xE0, 0x7E, 0x0F, 0xC0, 0xFE, 0x7F, 0x00, 0xFF,
  0xFC, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xFF,
  0x00, 0x7F, 0xFF, 0x03, 0xFC, 0x7E, 0x07, 0xE0, 0xFE, 0x1F, 0x80, 0xFC,
  0x3E, 0x00, 0xF8, 0xFC, 0x01, 0xF9, 0xF8, 0x03, 0xF3, 0xF0, 0x07, 0xE7,
  0xE0, 0x0F, 0x8F, 0xC0, 0x3F, 0x1F, 0xC0, 0x7E, 0x1F, 0xC3, 0xF8, 0x3F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xFF,
  0xF8, 0x3F, 0xC7, 0xF0, 0xFC, 0x0F, 0xC7, 0xE0, 0x3F, 0x1F, 0x80, 0x7C,
  0x7E, 0x01, 0xF3, 0xF0, 0x07, 0xCF, 0xC0, 0x1F, 0x3F, 0x00, 0xFC, 0xFC,
  0x03, 0xF3, 0xF0, 0x0F, 0xCF, 0xC0, 0x7F, 0x3F, 0x03, 0xFC, 0xFE, 0x1F,
  0xF1, 0xFF, 0xFF, 0x87, 0xFF, 0xBE, 0x0F, 0xFD, 0xF8, 0x1F, 0xE7, 0xE0,
  0x1C, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x0F, 0x1F, 0xF0,
  0x3F, 0xFF, 0x80, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x80, 0x3E, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x03, 0xE0, 0x7E, 0x07, 0xF0,
  0xFE, 0x0F, 0xE0, 0x7C, 0x01, 0x00, 0x00, 0x10, 0x00, 0xF8, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x01,
  0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xF0,
  0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x70, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0x00, 0x07, 0xFC, 0x00, 0x7F,
  0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07,
  0xFC, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0xC0, 0x01, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03,
  0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0xFE, 0x00,
  0x03, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0xF8, 0x03,
  0xFF, 0x83, 0xFF, 0xF1, 0xFF, 0xFE, 0x3F, 0xFF, 0x8F, 0x07, 0xF1, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x1F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x00, 0x0F, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0x07, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x00, 0xF8,
  0x1F, 0x00, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x07, 0xC3, 0xC0, 0x3F, 0xE0,
  0xF1, 0xF0, 0x3F, 0xFC, 0x3C, 0x78, 0x1F, 0xFF, 0x0F, 0x3E, 0x0F, 0xEF,
  0x83, 0xCF, 0x07, 0xC1, 0xE0, 0xF7, 0xC1, 0xE0, 0x78, 0x3D, 0xE0, 0xF8,
  0x3E, 0x0F, 0x78, 0x3C, 0x0F, 0x03, 0xDE, 0x1F, 0x03, 0xC0, 0xFF, 0x87,
  0x80, 0xF0, 0x7F, 0xC1, 0xE0, 0x7C, 0x1E, 0xF0, 0xF8, 0x1E, 0x07, 0xBC,
  0x3E, 0x07, 0x83, 0xEF, 0x0F, 0x83, 0xE0, 0xF3, 0xC3, 0xE0, 0xF8, 0x7C,
  0xF0, 0xF8, 0x7E, 0x3E, 0x3C, 0x1F, 0xFB, 0xFF, 0x0F, 0x07, 0xFC, 0xFF,
  0x83, 0xE0, 0xFE, 0x3F, 0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0x1E, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x01, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0x7C, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xE3, 0xE0, 0x00, 0xF8, 0xF8,
  0x00, 0x7E, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0xC3, 0xE0, 0x03, 0xE0,
  0xF8, 0x01, 0xF8, 0x3E, 0x00, 0x7C, 0x0F, 0x80, 0x3F, 0x03, 0xE0, 0x0F,
  0x80, 0xF8, 0x07, 0xE0, 0x3E, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC3, 0xF0, 0x03,
  0xF0, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xCF, 0xC0,
  0x03, 0xF3, 0xF0, 0x00, 0xFD, 0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x07, 0xFF,
  0x80, 0x01, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFC, 0x0F, 0xE0, 0x3F,
  0x01, 0xFC, 0x0F, 0x80, 0x7F, 0x07, 0xE0, 0x0F, 0x81, 0xF8, 0x07, 0xE0,
  0x7E, 0x01, 0xF8, 0x1F, 0x00, 0x7E, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x3F,
  0x80, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x07,
  0xC0, 0x1F, 0x83, 0xF0, 0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x7E,
  0x0F, 0x80, 0x1F, 0x87, 0xE0, 0x0F, 0xE1, 0xF8, 0x07, 0xF0, 0x7E, 0x03,
  0xFC, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xFF,
  0x00, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xF9,
  0xF8, 0x1F, 0xE0, 0x18, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x03, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xE0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF8, 0x07, 0xE0, 0x7F, 0x80, 0xFC, 0x07, 0xF0, 0x1F, 0x00, 0x7F, 0x07,
  0xE0, 0x0F, 0xE0, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x03,
  0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x7E,
  0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE3, 0xF0, 0x01, 0xFC, 0x7E, 0x00, 0x3F,
  0x0F, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x3E, 0x00, 0x3F, 0x8F, 0xC0,
  0x07, 0xE1, 0xF8, 0x01, 0xFC, 0x3F, 0x00, 0x7F, 0x07, 0xE0, 0x0F, 0xE1,
  0xF8, 0x03, 0xF8, 0x3F, 0x01, 0xFE, 0x07, 0xE0, 0xFF, 0x80, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFE,
  0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xFE, 0x3F, 0x01,
  0xFE, 0x00, 0x60, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x03, 0xFF,
  0x9F, 0x80, 0x7F, 0xF3, 0xF0, 0x1F, 0xFC, 0x7E, 0x03, 0xFF, 0x8F, 0xC0,
  0x7F, 0xF1, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xC7, 0xE0, 0x01, 0xF0,
  0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x7F, 0x00,
  0x3F, 0x0F, 0xE0, 0x0F, 0xC0, 0xFE, 0x01, 0xF8, 0x1F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0xFC, 0x07, 0xE0, 0x03, 0xE0, 0x1F, 0x80,
  0x1F, 0x80, 0xFC, 0x00, 0x7E, 0x03, 0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0x07,
  0xE0, 0x3F, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0xFC, 0x07, 0xE0, 0x03, 0xF0,
  0x1F, 0x80, 0x0F, 0xC0, 0x7E, 0x00, 0x3E, 0x01, 0xF8, 0x01, 0xF8, 0x0F,
  0xC0, 0x07, 0xE0, 0x3F, 0x00, 0x1F, 0x80, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFC, 0x07, 0xE0, 0x03, 0xF0, 0x1F, 0x80, 0x1F, 0x80, 0x7C, 0x00, 0x7E,
  0x03, 0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0x07, 0xE0, 0x3F, 0x00, 0x1F, 0x80,
  0xFC, 0x00, 0xFC, 0x03, 0xE0, 0x03, 0xF0, 0x1F, 0x80, 0x0F, 0xC0, 0x7E,
  0x00, 0x3F, 0x01, 0xF8, 0x00, 0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x3F, 0x00,
  0x1F, 0x80, 0xFC, 0x00, 0x7E, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x01, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x01, 0xFF, 0xC0, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xFC,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x02, 0x1F, 0xE0, 0x1F, 0xFE,
  0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x80, 0x7C, 0x03, 0xF8, 0x07,
  0xE0, 0x3F, 0x80, 0x3F, 0x01, 0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0x81,
  0xFC, 0x00, 0x7C, 0x1F, 0xC0, 0x07, 0xE1, 0xFC, 0x00, 0x3F, 0x1F, 0xC0,
  0x01, 0xF8, 0xFC, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0xFC, 0xFE, 0x00, 0x07,
  0xEF, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00,
  0x01, 0xFC, 0xFC, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x07,
  0xE0, 0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF0, 0x3F, 0x00, 0x0F, 0x81,
  0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x07, 0xE0, 0x3F, 0x00, 0x3F, 0x01, 0xFC,
  0x01, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xFC, 0x07,
  0xE0, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xFF, 0xF7,
  0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xE0, 0x01, 0xFE, 0x00,
  0x07, 0xFC, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0xFF, 0x80,
  0xFF, 0x80, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x0F, 0xF8, 0x00,
  0x7F, 0xE0, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x07,
  0xDE, 0x00, 0x7D, 0xF0, 0x1F, 0x7C, 0x01, 0xFF, 0xC0, 0x7D, 0xF0, 0x0F,
  0xBF, 0x01, 0xF7, 0xC0, 0x3E, 0xF8, 0x0F, 0xDF, 0x01, 0xF3, 0xE0, 0x3F,
  0x7C, 0x07, 0xDF, 0x80, 0xF9, 0xF0, 0x3E, 0x7E, 0x03, 0xE7, 0xC0, 0xF9,
  0xF8, 0x0F, 0x9F, 0x07, 0xC7, 0xC0, 0x7E, 0x7C, 0x1F, 0x1F, 0x01, 0xF9,
  0xF0, 0xF8, 0xFC, 0x07, 0xC3, 0xC3, 0xE3, 0xF0, 0x1F, 0x0F, 0x1F, 0x0F,
  0x80, 0x7C, 0x3C, 0x7C, 0x3E, 0x03, 0xF0, 0xF3, 0xE0, 0xF8, 0x0F, 0x83,
  0xCF, 0x87, 0xE0, 0x3E, 0x0F, 0xFC, 0x1F, 0x80, 0xF8, 0x3F, 0xF0, 0x7C,
  0x07, 0xE0, 0xFF, 0x81, 0xF0, 0x1F, 0x83, 0xFE, 0x07, 0xC0, 0x7C, 0x0F,
  0xF0, 0x3F, 0x01, 0xF0, 0x3F, 0xC0, 0xFC, 0x07, 0xC0, 0xFE, 0x03, 0xE0,
  0x3F, 0x03, 0xF8, 0x0F, 0x80, 0xFC, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x3F,
  0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x3E, 0x01,
  0xFC, 0x00, 0x3E, 0x03, 0xFE, 0x00, 0x7E, 0x03, 0xFE, 0x00, 0x7E, 0x03,
  0xFE, 0x00, 0x7C, 0x03, 0xFF, 0x00, 0x7C, 0x03, 0xFF, 0x00, 0x7C, 0x07,
  0xDF, 0x00, 0xFC, 0x07, 0xDF, 0x00, 0xFC, 0x07, 0xDF, 0x80, 0xF8, 0x07,
  0xCF, 0x80, 0xF8, 0x0F, 0xCF, 0x80, 0xF8, 0x0F, 0xCF, 0xC1, 0xF8, 0x0F,
  0x8F, 0xC1, 0xF8, 0x0F, 0x87, 0xC1, 0xF0, 0x0F, 0x87, 0xC1, 0xF0, 0x1F,
  0x87, 0xE3, 0xF0, 0x1F, 0x83, 0xE3, 0xF0, 0x1F, 0x03, 0xE3, 0xE0, 0x1F,
  0x03, 0xF3, 0xE0, 0x1F, 0x03, 0xF3, 0xE0, 0x3F, 0x01, 0xF3, 0xE0, 0x3E,
  0x01, 0xF7, 0xE0, 0x3E, 0x01, 0xFF, 0xC0, 0x3E, 0x00, 0xFF, 0xC0, 0x7E,
  0x00, 0xFF, 0xC0, 0x7E, 0x00, 0xFF, 0xC0, 0x7C, 0x00, 0xFF, 0xC0, 0x7C,
  0x00, 0x7F, 0x80, 0x7C, 0x00, 0x7F, 0x80, 0xFC, 0x00, 0x7F, 0x80, 0xFC,
  0x00, 0x7F, 0x80, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8,
  0x0F, 0xF8, 0xFF, 0x81, 0xFC, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x1F, 0xC0,
  0x0F, 0xE3, 0xF0, 0x00, 0xFC, 0xFE, 0x00, 0x1F, 0x9F, 0x80, 0x03, 0xF7,
  0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xDF, 0x80, 0x01, 0xFF, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x1F, 0xBF, 0x00, 0x07,
  0xF7, 0xE0, 0x00, 0xFC, 0xFC, 0x00, 0x3F, 0x9F, 0x80, 0x07, 0xF3, 0xF0,
  0x01, 0xFC, 0x7E, 0x00, 0x3F, 0x8F, 0xE0, 0x0F, 0xE0, 0xFE, 0x07, 0xF8,
  0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x01, 0xFF,
  0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x1F, 0x81,
  0xFC, 0x0F, 0xC0, 0x7E, 0x07, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x83, 0xF0,
  0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x7E,
  0x01, 0xFC, 0x3F, 0x01, 0xFC, 0x1F, 0x81, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x00,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xFF, 0x80,
  0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x0F, 0xF8,
  0xFF, 0x81, 0xFC, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xE3,
  0xF0, 0x00, 0xFC, 0xFE, 0x00, 0x1F, 0x9F, 0x80, 0x03, 0xF7, 0xF0, 0x00,
  0x7E, 0xFC, 0x00, 0x0F, 0xDF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x07,
  0xEF, 0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x1F, 0xBF, 0x00, 0x07, 0xF7, 0xE0,
  0x00, 0xFC, 0xFC, 0x00, 0x3F, 0x9F, 0x80, 0x07, 0xF3, 0xF0, 0x01, 0xFC,
  0x7E, 0x00, 0x3F, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x07, 0xF8, 0x1F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F,
  0x81, 0xF8, 0x0F, 0xC0, 0xFE, 0x07, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x83,
  0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0xFC, 0x07, 0xE0, 0xFC, 0x03, 0xF0,
  0x7E, 0x03, 0xF8, 0x3F, 0x03, 0xF8, 0x1F, 0x87, 0xFC, 0x0F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x01, 0xF8, 0xFC,
  0x00, 0xF8, 0x7E, 0x00, 0xFC, 0x1F, 0x00, 0x7E, 0x0F, 0xC0, 0x3F, 0x07,
  0xE0, 0x1F, 0x83, 0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0x7E, 0x07, 0xE0,
  0x3F, 0x03, 0xF0, 0x0F, 0xC1, 0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0xFC,
  0x01, 0xFC, 0x7E, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFE, 0xFE,
  0x07, 0xF0, 0x0C, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x80, 0x07, 0xE0, 0xF0, 0x0F, 0xE0,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xF8, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x07, 0xF0, 0x7C, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE0,
  0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x1F, 0x80,
  0x0F, 0xC1, 0xF8, 0x00, 0xFC, 0x1F, 0x80, 0x0F, 0xC1, 0xF8, 0x00, 0xF8,
  0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0x83, 0xF0,
  0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x03, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x3F,
  0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xE0, 0xFC,
  0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x0F,
  0xC0, 0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0xC0, 0xFC, 0x01, 0xF8, 0x0F,
  0xC0, 0x1F, 0x80, 0xFE, 0x07, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xEF, 0xC0, 0x03, 0xF1, 0xF0, 0x00,
  0xFC, 0x7C, 0x00, 0x7E, 0x1F, 0x00, 0x1F, 0x87, 0xC0, 0x0F, 0xC1, 0xF0,
  0x03, 0xF0, 0x7C, 0x01, 0xF8, 0x1F, 0x00, 0x7E, 0x07, 0xC0, 0x3F, 0x01,
  0xF0, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x1F, 0x81, 0xF8, 0x07, 0xE0, 0x7C,
  0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x0F, 0x80, 0x1F, 0x87, 0xE0, 0x03, 0xE1,
  0xF0, 0x00, 0xF8, 0xFC, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x9F, 0x80, 0x03,
  0xE7, 0xC0, 0x00, 0xFB, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xBE, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xE0, 0x07,
  0xEF, 0x80, 0x1F, 0x80, 0x1F, 0xBE, 0x00, 0xFE, 0x00, 0x7C, 0xF8, 0x03,
  0xF8, 0x03, 0xF3, 0xE0, 0x0F, 0xE0, 0x0F, 0xCF, 0x80, 0x7F, 0x80, 0x7E,
  0x3E, 0x01, 0xFE, 0x01, 0xF8, 0xF8, 0x0F, 0xF8, 0x07, 0xC3, 0xE0, 0x3F,
  0xE0, 0x3F, 0x0F, 0x81, 0xF7, 0x80, 0xF8, 0x3E, 0x07, 0xDE, 0x07, 0xE0,
  0xF8, 0x1E, 0x78, 0x1F, 0x83, 0xE0, 0xF9, 0xE0, 0xFC, 0x0F, 0x83, 0xE7,
  0x83, 0xF0, 0x3E, 0x1F, 0x1E, 0x0F, 0x80, 0xF8, 0x7C, 0x78, 0x7E, 0x03,
  0xE3, 0xE1, 0xE1, 0xF0, 0x0F, 0x8F, 0x87, 0xCF, 0xC0, 0x3E, 0x3C, 0x1E,
  0x3F, 0x00, 0xF9, 0xF0, 0x78, 0xF8, 0x03, 0xE7, 0xC1, 0xE7, 0xE0, 0x0F,
  0xBE, 0x07, 0x9F, 0x00, 0x3E, 0xF8, 0x1E, 0x7C, 0x00, 0xFB, 0xC0, 0x7B,
  0xE0, 0x03, 0xFF, 0x01, 0xEF, 0x80, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x3F,
  0xE0, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x7F, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x7E, 0x01,
  0xF8, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x3F, 0x07,
  0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0x1F, 0x9F,
  0x80, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7E, 0xF8,
  0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x01, 0xF8, 0xFC,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x07, 0xE0, 0x7E,
  0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x1F, 0x80, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x1F,
  0x80, 0xFC, 0x00, 0x7F, 0x7C, 0x00, 0xFE, 0x7E, 0x00, 0xFC, 0x7E, 0x01,
  0xFC, 0x7E, 0x01, 0xF8, 0x3E, 0x03, 0xF0, 0x3E, 0x03, 0xF0, 0x3F, 0x07,
  0xE0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x1F, 0x1F, 0x80, 0x1F, 0x1F,
  0x00, 0x1F, 0x3F, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x1F,
  0xF8, 0x00, 0xF8, 0x3E, 0x0F, 0x81, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x03, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x0F, 0x83, 0xE0, 0xF8,
  0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x1F, 0x07, 0xC1, 0xF0, 0x00, 0xFF, 0xE0,
  0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3D, 0xF0, 0x01,
  0xF3, 0xC0, 0x0F, 0x8F, 0x80, 0x3E, 0x3E, 0x01, 0xF0, 0x78, 0x07, 0x81,
  0xF0, 0x3E, 0x07, 0xC1, 0xF0, 0x0F, 0x07, 0xC0, 0x3E, 0x3E, 0x00, 0xF8,
  0xF8, 0x01, 0xE7, 0xC0, 0x07, 0xDE, 0x00, 0x1F, 0xF8, 0x00, 0x3C, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0x7F, 0x1F, 0x87, 0xC3, 0xF0,
  0xF8, 0x3C, 0x0F, 0x00, 0x10, 0x00, 0x01, 0xFC, 0x7C, 0x0F, 0xFC, 0xF8,
  0x3F, 0xFD, 0xF0, 0xFF, 0xFF, 0xC3, 0xFC, 0xFF, 0x87, 0xF0, 0x7F, 0x1F,
  0xC0, 0xFE, 0x3F, 0x01, 0xFC, 0xFE, 0x03, 0xF1, 0xF8, 0x07, 0xE3, 0xF0,
  0x0F, 0xC7, 0xE0, 0x1F, 0x9F, 0x80, 0x3F, 0x3F, 0x00, 0x7C, 0x7E, 0x01,
  0xF8, 0xFC, 0x03, 0xF1, 0xF8, 0x07, 0xE3, 0xF0, 0x1F, 0xC7, 0xE0, 0x3F,
  0x0F, 0xC0, 0xFE, 0x1F, 0x83, 0xFC, 0x3F, 0xDF, 0xF8, 0x7F, 0xFF, 0xE0,
  0x7F, 0xF7, 0xC0, 0x7F, 0xCF, 0x80, 0x7F, 0x1F, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC1, 0x00, 0x1F, 0x9F, 0xC0, 0x3E, 0x7F, 0xC0, 0x7D, 0xFF, 0xC1, 0xFF,
  0xFF, 0x83, 0xFE, 0x7F, 0x87, 0xF0, 0x3F, 0x0F, 0xE0, 0x7E, 0x3F, 0x80,
  0xFC, 0x7E, 0x01, 0xF8, 0xFC, 0x03, 0xF1, 0xF8, 0x07, 0xE3, 0xE0, 0x0F,
  0xCF, 0xC0, 0x1F, 0x9F, 0x80, 0x3E, 0x3F, 0x00, 0xFC, 0x7C, 0x01, 0xF8,
  0xF8, 0x03, 0xF3, 0xF0, 0x0F, 0xC7, 0xE0, 0x1F, 0x8F, 0xE0, 0x7E, 0x1F,
  0xC1, 0xFC, 0x3F, 0xC7, 0xF0, 0xFF, 0xFF, 0xE1, 0xF7, 0xFF, 0x83, 0xE7,
  0xFE, 0x07, 0x87, 0xF0, 0x00, 0x00, 0x08, 0x00, 0x1F, 0xF8, 0x0F, 0xFF,
  0x83, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0xE7, 0x87, 0xF0, 0x11, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x04, 0x3F, 0xC7, 0x83,
  0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3E, 0x00, 0x08, 0x1F, 0x00, 0x3F, 0x9F, 0x80, 0x7F, 0xEF, 0xC0,
  0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0x9F, 0xF0, 0x3F, 0x83, 0xF8,
  0x3F, 0x81, 0xFC, 0x1F, 0x80, 0xFE, 0x1F, 0xC0, 0x7E, 0x0F, 0xC0, 0x3F,
  0x07, 0xE0, 0x1F, 0x87, 0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xE1, 0xF8, 0x03,
  0xE0, 0xFC, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x80,
  0xFC, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x7F, 0x03, 0xF0, 0x7F, 0x81, 0xFC,
  0x7F, 0xC0, 0xFF, 0xFB, 0xC0, 0x3F, 0xFB, 0xE0, 0x0F, 0xF9, 0xF0, 0x03,
  0xF8, 0xF8, 0x00, 0x00, 0x08, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xE0, 0x7F,
  0xFF, 0x0F, 0xFF, 0xF0, 0xFC, 0x3F, 0x1F, 0x81, 0xF3, 0xF0, 0x1F, 0x3F,
  0x01, 0xF7, 0xE0, 0x3F, 0x7E, 0x07, 0xF7, 0xC1, 0xFE, 0xFF, 0xFF, 0xCF,
  0xFF, 0xF8, 0xFF, 0xFE, 0x0F, 0xFF, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x08, 0x7F, 0x07,
  0x87, 0xFF, 0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFE,
  0x00, 0x03, 0xFF, 0x80, 0x01, 0xFC, 0x20, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0,
  0x07, 0xFF, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x02, 0x7F, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x3F, 0xC7, 0xC0, 0x3F, 0xF3,
  0xE0, 0x3F, 0xFD, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xCF, 0xF8, 0x1F, 0xC1,
  0xFC, 0x1F, 0xC0, 0xFE, 0x0F, 0xC0, 0x7F, 0x0F, 0xE0, 0x3F, 0x07, 0xE0,
  0x1F, 0x83, 0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0xFC,
  0x01, 0xF0, 0x7E, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x0F,
  0xC0, 0x7E, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x3F, 0x81, 0xF8, 0x3F, 0xC0,
  0xFF, 0x7F, 0xE0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFD, 0xF0, 0x07, 0xFD, 0xF8,
  0x01, 0xFC, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0xC0, 0x0F, 0xC0, 0x7C, 0x1F,
  0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0x00, 0x04, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC1, 0x00, 0x1F, 0x9F,
  0xC0, 0x3E, 0x7F, 0xC0, 0x7D, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0x3F,
  0x87, 0xF8, 0x3F, 0x0F, 0xE0, 0x7E, 0x3F, 0x80, 0xFC, 0x7F, 0x01, 0xF8,
  0xFC, 0x03, 0xE1, 0xF8, 0x0F, 0xC3, 0xE0, 0x1F, 0x8F, 0xC0, 0x3F, 0x1F,
  0x80, 0x7E, 0x3F, 0x00, 0xF8, 0x7C, 0x03, 0xF0, 0xF8, 0x07, 0xE3, 0xF0,
  0x0F, 0xC7, 0xE0, 0x1F, 0x8F, 0xC0, 0x3E, 0x1F, 0x00, 0xFC, 0x3E, 0x01,
  0xF8, 0xFC, 0x03, 0xF1, 0xF8, 0x07, 0xC3, 0xF0, 0x0F, 0x87, 0xC0, 0x3F,
  0x00, 0x00, 0xF0, 0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xE0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x9F, 0xE0, 0x0F,
  0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x03, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x0F, 0xE0, 0xF8,
  0x0F, 0xC0, 0x7C, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x1F,
  0x8F, 0xE0, 0x0F, 0x8F, 0xE0, 0x0F, 0xC7, 0xE0, 0x07, 0xE7, 0xE0, 0x03,
  0xF7, 0xE0, 0x01, 0xF7, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00,
  0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xDF, 0x80, 0x0F, 0xCF, 0xC0,
  0x0F, 0xC3, 0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xF0, 0x3F,
  0x00, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0xE0, 0x7E, 0x03, 0xF0, 0x3F, 0x01,
  0xF8, 0x1F, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7C, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x80, 0x04, 0x00, 0x7C, 0x7F, 0x03,
  0xF8, 0x07, 0x8F, 0xF8, 0x7F, 0xC0, 0x79, 0xFF, 0xCF, 0xFE, 0x0F, 0xBF,
  0xFD, 0xFF, 0xE0, 0xFF, 0x9F, 0xFC, 0x7E, 0x0F, 0xF0, 0xFF, 0x83, 0xF0,
  0xFE, 0x07, 0xF0, 0x3F, 0x1F, 0xC0, 0x7E, 0x03, 0xE1, 0xFC, 0x07, 0xE0,
  0x3E, 0x1F, 0x80, 0xFC, 0x03, 0xE1, 0xF8, 0x0F, 0xC0, 0x7E, 0x1F, 0x00,
  0xFC, 0x07, 0xE3, 0xF0, 0x0F, 0x80, 0x7E, 0x3F, 0x01, 0xF8, 0x07, 0xC3,
  0xF0, 0x1F, 0x80, 0xFC, 0x3E, 0x01, 0xF8, 0x0F, 0xC3, 0xE0, 0x1F, 0x00,
  0xFC, 0x7E, 0x01, 0xF0, 0x0F, 0xC7, 0xE0, 0x3F, 0x00, 0xF8, 0x7E, 0x03,
  0xF0, 0x1F, 0x87, 0xC0, 0x3F, 0x01, 0xF8, 0x7C, 0x03, 0xE0, 0x1F, 0x8F,
  0xC0, 0x3E, 0x01, 0xF0, 0xFC, 0x07, 0xE0, 0x1F, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x00, 0x80, 0x0F, 0x8F, 0xE0,
  0x1E, 0x3F, 0xE0, 0x3C, 0xFF, 0xE0, 0xFB, 0xFF, 0xC1, 0xFF, 0xBF, 0xC3,
  0xFC, 0x1F, 0x87, 0xF0, 0x3F, 0x1F, 0xC0, 0x7E, 0x3F, 0x80, 0xFC, 0x7E,
  0x01, 0xF0, 0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0xC7, 0xE0, 0x1F, 0x8F, 0xC0,
  0x3F, 0x1F, 0x80, 0x7C, 0x3F, 0x01, 0xF8, 0x7C, 0x03, 0xF1, 0xF8, 0x07,
  0xE3, 0xF0, 0x0F, 0xC7, 0xE0, 0x1F, 0x0F, 0x80, 0x7E, 0x3F, 0x00, 0xFC,
  0x7E, 0x01, 0xF8, 0xFC, 0x03, 0xE1, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x80,
  0x00, 0x08, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x0F, 0xF3, 0xFC, 0x7E, 0x07, 0xE7, 0xE0, 0x3F, 0x3F, 0x01, 0xFB,
  0xF0, 0x07, 0xDF, 0x80, 0x3E, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x1F, 0xBE,
  0x00, 0xFD, 0xF8, 0x0F, 0xEF, 0xC0, 0x7E, 0x7E, 0x07, 0xF1, 0xFC, 0xFF,
  0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x3E, 0x3F, 0x80, 0x0F, 0x1F, 0xF0, 0x03, 0xCF, 0xFE,
  0x01, 0xF7, 0xFF, 0x80, 0x7F, 0xC7, 0xF0, 0x1F, 0xC0, 0xFC, 0x07, 0xF0,
  0x3F, 0x03, 0xF8, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x0F,
  0xC0, 0x3F, 0x03, 0xE0, 0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0xF8,
  0x1F, 0x80, 0x7E, 0x07, 0xC0, 0x1F, 0x81, 0xF0, 0x07, 0xE0, 0xFC, 0x03,
  0xF0, 0x3F, 0x00, 0xFC, 0x0F, 0xE0, 0x7E, 0x03, 0xF8, 0x3F, 0x80, 0xFF,
  0x1F, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x07, 0xCF, 0xFC, 0x01,
  0xF1, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x01, 0xFC, 0x7C, 0x0F, 0xFC, 0xF8,
  0x3F, 0xFD, 0xF0, 0xFF, 0xFF, 0xC3, 0xFC, 0xFF, 0x87, 0xF0, 0x7F, 0x1F,
  0xC0, 0xFE, 0x3F, 0x01, 0xFC, 0xFE, 0x03, 0xF1, 0xF8, 0x07, 0xE3, 0xF0,
  0x0F, 0xC7, 0xC0, 0x1F, 0x9F, 0x80, 0x3F, 0x3F, 0x00, 0x7C, 0x7E, 0x01,
  0xF8, 0xFC, 0x03, 0xF1, 0xF8, 0x07, 0xE3, 0xF0, 0x1F, 0x87, 0xE0, 0x3F,
  0x0F, 0xC0, 0xFE, 0x1F, 0x83, 0xFC, 0x3F, 0x8F, 0xF8, 0x7F, 0xFF, 0xE0,
  0x7F, 0xF7, 0xC0, 0x7F, 0xDF, 0x80, 0x7F, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x80, 0xF8,
  0xFC, 0x1F, 0x3F, 0x03, 0xCF, 0xE0, 0xFB, 0xFC, 0x1F, 0xFF, 0x83, 0xFE,
  0x10, 0x7F, 0x80, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F,
  0xFF, 0xE1, 0xFC, 0x1C, 0x1F, 0x80, 0x41, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x88, 0x03, 0xF8, 0xF0, 0x7F, 0x0F, 0xFF,
  0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0x01, 0xE0, 0x01,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x1F, 0xFF, 0x7F,
  0xFE, 0x7F, 0xFE, 0xFF, 0xFE, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFE, 0x20, 0xFF, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0x3F,
  0xE0, 0x0F, 0xC0, 0x7E, 0x1F, 0x00, 0xFC, 0x7E, 0x01, 0xF8, 0xFC, 0x03,
  0xE1, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x8F, 0xC0, 0x3F, 0x1F, 0x80, 0x7E,
  0x3F, 0x00, 0xF8, 0x7E, 0x03, 0xF0, 0xF8, 0x07, 0xE3, 0xF0, 0x0F, 0xC7,
  0xE0, 0x1F, 0x8F, 0xC0, 0x3E, 0x1F, 0x00, 0xFC, 0x3E, 0x01, 0xF8, 0xFC,
  0x03, 0xF1, 0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0x87, 0xE0, 0x7F, 0x0F, 0xC1,
  0xFE, 0x1F, 0xCF, 0xFC, 0x3F, 0xFE, 0xF0, 0x3F, 0xFB, 0xE0, 0x7F, 0xE7,
  0xC0, 0x7F, 0x8F, 0x80, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xBE, 0x00, 0xFD,
  0xF0, 0x07, 0xCF, 0x80, 0x7E, 0x7C, 0x03, 0xE3, 0xE0, 0x3F, 0x1F, 0x81,
  0xF0, 0xFC, 0x1F, 0x87, 0xE0, 0xF8, 0x3F, 0x0F, 0xC0, 0xF8, 0x7C, 0x07,
  0xC7, 0xE0, 0x3E, 0x3E, 0x01, 0xF3, 0xF0, 0x0F, 0x9F, 0x00, 0x7D, 0xF8,
  0x03, 0xEF, 0x80, 0x1F, 0x7C, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F,
  0xE0, 0x01, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00,
  0x00, 0xF8, 0x07, 0xE0, 0x1F, 0xFC, 0x07, 0xF0, 0x1F, 0xBE, 0x03, 0xF8,
  0x0F, 0xDF, 0x01, 0xFC, 0x07, 0xCF, 0x81, 0xFE, 0x07, 0xE7, 0xC0, 0xFF,
  0x03, 0xE3, 0xE0, 0xFF, 0x83, 0xF1, 0xF0, 0x7B, 0xC1, 0xF0, 0xF8, 0x7D,
  0xE1, 0xF8, 0x7C, 0x3E, 0xF0, 0xFC, 0x3E, 0x1E, 0x78, 0x7C, 0x1F, 0x1F,
  0x3C, 0x7E, 0x0F, 0x8F, 0x1E, 0x3E, 0x07, 0xCF, 0x8F, 0x3F, 0x03, 0xE7,
  0xC7, 0x9F, 0x01, 0xF3, 0xC3, 0xCF, 0x80, 0xFB, 0xE1, 0xEF, 0x80, 0x7D,
  0xE0, 0xF7, 0xC0, 0x3F, 0xF0, 0x7B, 0xE0, 0x1F, 0xF0, 0x3F, 0xE0, 0x0F,
  0xF8, 0x1F, 0xF0, 0x07, 0xFC, 0x0F, 0xF0, 0x03, 0xFC, 0x07, 0xF8, 0x01,
  0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x07,
  0xE1, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0x9F, 0x80,
  0x03, 0xF7, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFD, 0xF0, 0x00,
  0x7E, 0x7E, 0x00, 0x1F, 0x9F, 0x80, 0x0F, 0xC3, 0xE0, 0x07, 0xE0, 0xFC,
  0x03, 0xF8, 0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x3F, 0x80,
  0x7E, 0x00, 0x01, 0xF0, 0x03, 0xF0, 0x1F, 0x00, 0x3F, 0x01, 0xF0, 0x07,
  0xE0, 0x1F, 0x00, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x1F, 0x80, 0xFC, 0x01,
  0xF8, 0x1F, 0x80, 0x1F, 0x81, 0xF8, 0x00, 0xF8, 0x3F, 0x00, 0x0F, 0x83,
  0xF0, 0x00, 0xF8, 0x7E, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0xF8, 0xFC, 0x00,
  0x0F, 0x8F, 0xC0, 0x00, 0xF9, 0xF8, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0xF9,
  0xF0, 0x00, 0x07, 0xBE, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x07, 0xBC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x87, 0xF0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xFF,
  0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x3F,
  0x80, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x7F, 0xE0, 0x07,
  0xF8, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x02, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07, 0xFC, 0x00, 0xFF,
  0x00, 0x0F, 0xC0, 0x0F, 0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00,
  0x1F, 0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x20,
  0x00, 0x00, 0x04, 0x00, 0x04, 0xFF, 0x80, 0x17, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFC, 0x01, 0xFF, 0xA0, 0x00, 0x70,
};

const GFXglyph NotoSans_SemiCondensed_SemiBoldItalic48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 13, 35, 13, 1, -34 },
  { 58, 16, 12, 20, 5, -34 },
  { 82, 27, 34, 28, 1, -34 },
  { 197, 23, 39, 24, 1, -36 },
  { 310, 32, 35, 37, 3, -35 },
  { 450, 28, 35, 30, 1, -35 },
  { 573, 7, 12, 11, 5, -34 },
  { 584, 17, 42, 14, 1, -34 },
  { 674, 17, 43, 15, -4, -35 },
  { 766, 21, 22, 24, 4, -37 },
  { 824, 22, 24, 25, 2, -29 },
  { 890, 10, 12, 12, -2, -6 },
  { 905, 12, 5, 15, 1, -15 },
  { 913, 8, 8, 12, 0, -7 },
  { 921, 24, 34, 18, -2, -34 },
  { 1023, 22, 35, 24, 2, -35 },
  { 1120, 16, 34, 24, 5, -34 },
  { 1188, 25, 35, 24, -1, -35 },
  { 1298, 24, 35, 24, 0, -35 },
  { 1403, 24, 34, 24, 0, -34 },
  { 1505, 23, 34, 24, 1, -34 },
  { 1603, 23, 35, 24, 2, -35 },
  { 1704, 24, 34, 24, 2, -34 },
  { 1806, 23, 35, 24, 1, -35 },
  { 1907, 22, 35, 24, 1, -35 },
  { 2004, 12, 28, 12, 0, -27 },
  { 2046, 15, 33, 12, -3, -27 },
  { 2108, 22, 24, 25, 2, -29 },
  { 2174, 21, 14, 25, 3, -24 },
  { 2211, 22, 24, 25, 2, -29 },
  { 2277, 18, 36, 19, 3, -35 },
  { 2358, 34, 38, 37, 2, -34 },
  { 2520, 26, 34, 26, -3, -34 },
  { 2631, 26, 34, 27, 1, -34 },
  { 2742, 25, 35, 26, 3, -35 },
  { 2852, 27, 34, 29, 1, -34 },
  { 2967, 24, 34, 23, 1, -34 },
  { 3069, 24, 34, 22, 1, -34 },
  { 3171, 27, 35, 30, 3, -35 },
  { 3290, 30, 34, 30, 1, -34 },
  { 3418, 21, 34, 16, -2, -34 },
  { 3508, 21, 44, 13, -7, -34 },
  { 3624, 29, 34, 26, 1, -34 },
  { 3748, 18, 34, 22, 1, -34 },
  { 3825, 38, 34, 38, 1, -34 },
  { 3987, 32, 34, 32, 1, -34 },
  { 4123, 27, 35, 31, 3, -35 },
  { 4242, 25, 34, 26, 1, -34 },
  { 4349, 27, 43, 31, 3, -35 },
  { 4495, 25, 34, 26, 1, -34 },
  { 4602, 24, 35, 23, 0, -35 },
  { 4707, 22, 34, 22, 4, -34 },
  { 4801, 28, 34, 30, 3, -34 },
  { 4920, 26, 34, 25, 4, -34 },
  { 5031, 38, 34, 39, 5, -34 },
  { 5193, 32, 34, 25, -3, -34 },
  { 5329, 24, 34, 24, 4, -34 },
  { 5431, 26, 34, 23, -1, -34 },
  { 5542, 19, 42, 15, -1, -34 },
  { 5642, 10, 34, 18, 5, -34 },
  { 5685, 19, 42, 15, -3, -34 },
  { 5785, 22, 21, 24, 1, -34 },
  { 5843, 18, 3, 18, -4, 4 },
  { 5850, 9, 8, 14, 7, -37 },
  { 5859, 23, 27, 26, 2, -27 },
  { 5937, 23, 36, 26, 1, -36 },
  { 6041, 19, 27, 21, 2, -27 },
  { 6106, 25, 36, 26, 2, -36 },
  { 6219, 20, 27, 23, 2, -27 },
  { 6287, 26, 49, 15, -5, -37 },
  { 6447, 25, 39, 26, 0, -27 },
  { 6569, 23, 36, 26, 1, -36 },
  { 6673, 13, 36, 12, 1, -36 },
  { 6732, 20, 48, 12, -6, -36 },
  { 6852, 25, 36, 23, 1, -36 },
  { 6965, 13, 36, 12, 1, -36 },
  { 7024, 36, 27, 39, 1, -27 },
  { 7146, 23, 27, 26, 1, -27 },
  { 7224, 21, 27, 25, 2, -27 },
  { 7295, 26, 38, 26, -2, -27 },
  { 7419, 23, 39, 26, 2, -27 },
  { 7532, 19, 27, 18, 1, -27 },
  { 7597, 20, 27, 20, 0, -27 },
  { 7665, 16, 32, 16, 2, -32 },
  { 7729, 23, 26, 26, 2, -26 },
  { 7804, 21, 26, 22, 3, -26 },
  { 7873, 33, 26, 34, 3, -26 },
  { 7981, 26, 26, 22, -2, -26 },
  { 8066, 28, 38, 22, -4, -26 },
  { 8199, 21, 26, 20, -1, -26 },
  { 8268, 20, 42, 17, 0, -34 },
  { 8373, 5, 48, 23, 9, -37 },
  { 8403, 18, 42, 17, -2, -34 },
  { 8498, 22, 8, 25, 2, -21 },
};

const GFXfont NotoSans_SemiCondensed_SemiBoldItalic48pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_SemiBoldItalic48pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_SemiBoldItalic48pt7bGlyphs,
  0x20, 0x7E, 65
};

#endif // _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC48PT7B_H_
