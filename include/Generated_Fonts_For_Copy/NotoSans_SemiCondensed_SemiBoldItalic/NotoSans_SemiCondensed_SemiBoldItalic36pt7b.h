#ifndef _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC36PT7B_H_
#define _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC36PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-SemiBoldItalic.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_SemiBoldItalic36pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0x78, 0x0F, 0x03, 0xE0, 0x7C,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1C,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x70, 0x1F, 0x07, 0xE0, 0xFC, 0x0F,
  0x00, 0x79, 0xF7, 0x9E, 0x79, 0xEF, 0x1E, 0xF1, 0xEF, 0x1C, 0xE1, 0xCE,
  0x3C, 0xE3, 0x8E, 0x38, 0x00, 0x71, 0xE0, 0x0F, 0x1C, 0x00, 0xE1, 0xC0,
  0x0E, 0x1C, 0x01, 0xE3, 0x80, 0x1C, 0x38, 0x01, 0xC3, 0x80, 0x1C, 0x78,
  0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x3F, 0xFF, 0xF0, 0x78, 0xE0, 0x07, 0x0E,
  0x00, 0x70, 0xE0, 0x0F, 0x1C, 0x00, 0xE1, 0xC0, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xC1, 0xC3, 0x80, 0x1C, 0x38, 0x03, 0xC7, 0x00, 0x38,
  0x70, 0x03, 0x87, 0x00, 0x38, 0xE0, 0x07, 0x0E, 0x00, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x0E, 0x00, 0x7F, 0xE0, 0x7F, 0xF8, 0x7F, 0xF8, 0x7D, 0x9C,
  0x3C, 0xC0, 0x1E, 0x60, 0x0F, 0x30, 0x07, 0xB8, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0xDF, 0x00,
  0x67, 0x80, 0x33, 0xC8, 0x33, 0xE7, 0x1B, 0xE3, 0xFF, 0xF1, 0xFF, 0xF0,
  0x7F, 0xE0, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x07,
  0x80, 0x1E, 0x0F, 0xE0, 0x1E, 0x0F, 0xF8, 0x0E, 0x07, 0x9C, 0x0E, 0x07,
  0x8E, 0x0F, 0x03, 0x87, 0x07, 0x01, 0xC3, 0x87, 0x01, 0xE1, 0xC7, 0x80,
  0xF1, 0xE3, 0x80, 0x78, 0xF3, 0x80, 0x3C, 0x73, 0xC7, 0x1E, 0x79, 0xCF,
  0xCF, 0x39, 0xCF, 0xF3, 0xFD, 0xEF, 0x39, 0xFC, 0xE7, 0x1E, 0x7C, 0xE7,
  0x8F, 0x00, 0xF3, 0xC7, 0x80, 0x71, 0xC3, 0x80, 0x70, 0xE1, 0xC0, 0x78,
  0x70, 0xE0, 0x38, 0x78, 0xF0, 0x38, 0x3C, 0x70, 0x3C, 0x1E, 0x78, 0x1C,
  0x07, 0xF8, 0x1C, 0x03, 0xFC, 0x1E, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0x9F, 0x00, 0x78, 0x78, 0x03, 0xC3,
  0xC0, 0x1E, 0x1E, 0x00, 0xF1, 0xE0, 0x07, 0x9F, 0x00, 0x3D, 0xF0, 0x01,
  0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x7C, 0xFF, 0xC3,
  0xCF, 0x9F, 0x3E, 0x78, 0x79, 0xE7, 0xC3, 0xFF, 0x3C, 0x0F, 0xF1, 0xE0,
  0x7F, 0x0F, 0x01, 0xF0, 0x78, 0x1F, 0x83, 0xF3, 0xFE, 0x1F, 0xFF, 0xF0,
  0x7F, 0xF7, 0xC1, 0xFE, 0x1F, 0x00, 0x7B, 0xDF, 0xEF, 0x7B, 0x9C, 0xE7,
  0x00, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0x78, 0x0F, 0x00,
  0xF0, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x07,
  0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x07, 0x80, 0x38, 0x03,
  0xC0, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x01,
  0xC0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x3C, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x00, 0x01, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x0E,
  0x06, 0x1C, 0x0F, 0x38, 0x3F, 0xF1, 0xBF, 0xFF, 0x07, 0xFE, 0x0F, 0xFC,
  0x3F, 0x00, 0xF7, 0x07, 0xCE, 0x07, 0x1E, 0x06, 0x1E, 0x08, 0x30, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x1F, 0x1E, 0x1E,
  0x3E, 0x3C, 0x38, 0x78, 0x70, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x39,
  0xFF, 0xFE, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0xC1,
  0xFF, 0xE0, 0xF8, 0xF0, 0xF8, 0x7C, 0x78, 0x3E, 0x7C, 0x0F, 0x3C, 0x0F,
  0x9E, 0x07, 0xDF, 0x03, 0xEF, 0x01, 0xF7, 0x80, 0xF3, 0xC0, 0x7B, 0xE0,
  0x3D, 0xF0, 0x3E, 0xF8, 0x1F, 0x78, 0x0F, 0x3C, 0x0F, 0x9E, 0x07, 0xCF,
  0x87, 0xC7, 0xC3, 0xE1, 0xF7, 0xE0, 0xFF, 0xE0, 0x3F, 0xE0, 0x0F, 0xE0,
  0x00, 0x00, 0xF0, 0x1F, 0x07, 0xE0, 0xFE, 0x3F, 0xE7, 0xFE, 0xFF, 0xE7,
  0x3C, 0x63, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x07, 0x80,
  0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x3E, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x3F, 0xF0, 0x1F, 0xFF, 0x03,
  0xFF, 0xE0, 0x38, 0x3E, 0x04, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0xFF, 0xC3, 0xFF,
  0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0xC0, 0x00, 0xFE, 0x01, 0xFF, 0xC0, 0xFF,
  0xF8, 0x1F, 0xFE, 0x06, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0x80, 0x03, 0xE0, 0x03, 0xF0, 0x0F, 0xF8, 0x03, 0xF0, 0x01,
  0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x20, 0x0F, 0x8F, 0x0F, 0xE3, 0xFF, 0xF0,
  0xFF, 0xF8, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8,
  0x00, 0x7E, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x0F, 0x70, 0x03, 0xBC, 0x01,
  0xEF, 0x00, 0xF3, 0xC0, 0x78, 0xF0, 0x1C, 0x78, 0x0F, 0x1E, 0x07, 0x87,
  0x83, 0xC1, 0xE0, 0xE0, 0xF8, 0x78, 0x3C, 0x3F, 0xFF, 0xEF, 0xFF, 0xFB,
  0xFF, 0xFE, 0xFF, 0xFF, 0x80, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0xF8, 0x00, 0x3C, 0x00, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F,
  0xFE, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1E, 0x20, 0x0F, 0x8F, 0x9F, 0xC3, 0xFF, 0xF0, 0xFF, 0xF8,
  0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFE,
  0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F,
  0x08, 0x03, 0xDF, 0xC1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0x87, 0x87, 0xC1,
  0xF1, 0xE0, 0x7C, 0x78, 0x1F, 0x3E, 0x07, 0xCF, 0x81, 0xE3, 0xE0, 0x78,
  0x78, 0x3E, 0x1E, 0x0F, 0x07, 0xCF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF0, 0x07,
  0xF8, 0x00, 0x3F, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xE7, 0xFF, 0xF4, 0x00,
  0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3C, 0x00,
  0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80,
  0x07, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0,
  0x00, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xFC,
  0x01, 0xFF, 0x81, 0xFF, 0xC1, 0xFB, 0xF1, 0xF0, 0x78, 0xF0, 0x3C, 0x78,
  0x1E, 0x3C, 0x0F, 0x1F, 0x0F, 0x87, 0x8F, 0x83, 0xEF, 0x80, 0xFF, 0x80,
  0x7F, 0x00, 0x7F, 0xC0, 0xFF, 0xF0, 0xF8, 0x78, 0x78, 0x3E, 0x7C, 0x0F,
  0x3C, 0x07, 0x9E, 0x03, 0xCF, 0x01, 0xE7, 0x81, 0xF3, 0xE1, 0xF0, 0xFF,
  0xF8, 0x7F, 0xF8, 0x0F, 0xF0, 0x00, 0x01, 0xF8, 0x03, 0xFF, 0x03, 0xFF,
  0x83, 0xFF, 0xE1, 0xF0, 0xF1, 0xF0, 0x78, 0xF0, 0x3C, 0x78, 0x1F, 0x7C,
  0x0F, 0xBE, 0x07, 0x9F, 0x03, 0xCF, 0x83, 0xE7, 0xC3, 0xF1, 0xFF, 0xF8,
  0xFF, 0xFC, 0x3F, 0xBC, 0x07, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F,
  0x80, 0x07, 0x80, 0x07, 0xC3, 0x0F, 0xC1, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F,
  0x80, 0x00, 0x07, 0x07, 0xC3, 0xE3, 0xF0, 0xF0, 0x20, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x7C, 0x7E, 0x3E, 0x0F,
  0x00, 0x01, 0xC0, 0x7C, 0x0F, 0x83, 0xF0, 0x3C, 0x02, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x03, 0xC0, 0x78, 0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x03, 0x80, 0xF0, 0x00,
  0x00, 0x01, 0x00, 0x07, 0x00, 0x1F, 0x00, 0x7F, 0x01, 0xFE, 0x07, 0xF0,
  0x1F, 0xC0, 0x7F, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x00, 0x07, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0xE0, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x7F, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0x80, 0xFE, 0x00, 0xF8, 0x00, 0xE0, 0x00, 0x80, 0x00, 0x0F, 0xE0,
  0xFF, 0xC7, 0xFF, 0x8F, 0xFE, 0x30, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1E,
  0x00, 0x78, 0x03, 0xC0, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x01, 0xE0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xC0, 0x7C, 0x03, 0xC0, 0x07,
  0x81, 0xE0, 0x00, 0xE0, 0xF0, 0x00, 0x3C, 0x78, 0x1F, 0x07, 0x1C, 0x1F,
  0xF1, 0xCF, 0x0F, 0xFC, 0x73, 0x87, 0x8E, 0x1D, 0xE3, 0xC3, 0x87, 0x70,
  0xE0, 0xE1, 0xDC, 0x78, 0x78, 0x77, 0x1C, 0x1C, 0x3D, 0xC7, 0x07, 0x0E,
  0xF1, 0xC3, 0xC3, 0xBC, 0x70, 0xF1, 0xEF, 0x1C, 0x7C, 0x73, 0xC7, 0xFF,
  0xF8, 0x71, 0xFD, 0xFC, 0x1C, 0x3E, 0x3E, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x10, 0x00, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7B,
  0xC0, 0x07, 0xBC, 0x00, 0xF3, 0xC0, 0x0F, 0x3C, 0x01, 0xF1, 0xC0, 0x1E,
  0x1C, 0x03, 0xE1, 0xE0, 0x3C, 0x1E, 0x07, 0xC1, 0xE0, 0x7F, 0xFE, 0x0F,
  0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE1, 0xE0, 0x1E, 0x1E, 0x01, 0xE3,
  0xE0, 0x1E, 0x3C, 0x01, 0xE7, 0xC0, 0x1E, 0x78, 0x01, 0xEF, 0x80, 0x1F,
  0x07, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x07, 0xFF, 0xE0, 0xF8, 0x7E,
  0x1E, 0x07, 0xC3, 0xC0, 0xF8, 0x78, 0x1F, 0x1F, 0x03, 0xC3, 0xE0, 0xF8,
  0x78, 0x3E, 0x0F, 0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0x0F, 0xC1,
  0xE0, 0x7C, 0x3C, 0x07, 0x8F, 0x80, 0xF1, 0xF0, 0x1E, 0x3C, 0x07, 0xC7,
  0x80, 0xF8, 0xF0, 0x3E, 0x3F, 0xFF, 0xC7, 0xFF, 0xF0, 0xFF, 0xF8, 0x1F,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0xFC, 0x0F, 0xFF, 0x83, 0xFF, 0xE0,
  0xFC, 0x0C, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x08, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x1F,
  0xFC, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0xC0,
  0xFF, 0xFC, 0x0F, 0x87, 0xE0, 0xF0, 0x3E, 0x0F, 0x01, 0xF0, 0xF0, 0x1F,
  0x1F, 0x01, 0xF1, 0xF0, 0x1F, 0x1E, 0x01, 0xF1, 0xE0, 0x1F, 0x1E, 0x01,
  0xF3, 0xE0, 0x1F, 0x3E, 0x01, 0xF3, 0xC0, 0x1E, 0x3C, 0x03, 0xE7, 0xC0,
  0x3E, 0x7C, 0x07, 0xC7, 0x80, 0xFC, 0x78, 0x1F, 0x87, 0x83, 0xF0, 0xFF,
  0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0xC1,
  0xFF, 0xE0, 0x7F, 0xF8, 0x3F, 0xFE, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x7F, 0xF8,
  0x1F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xF0, 0x00, 0x3C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0xFF,
  0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xC1, 0xFF,
  0xE0, 0x7F, 0xF8, 0x3F, 0xFE, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1F,
  0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x1F, 0xFF,
  0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xC0, 0x61, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80,
  0x00, 0xF8, 0x3F, 0xEF, 0x83, 0xFE, 0xF8, 0x3F, 0xCF, 0x83, 0xFC, 0xF8,
  0x03, 0xCF, 0x80, 0x7C, 0xF8, 0x07, 0xCF, 0x80, 0x78, 0xF8, 0x07, 0x87,
  0xC0, 0x78, 0x7F, 0xBF, 0x83, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xE0,
  0x07, 0xC0, 0x3C, 0x1E, 0x01, 0xF0, 0x78, 0x07, 0xC3, 0xE0, 0x1E, 0x0F,
  0x80, 0x78, 0x3C, 0x01, 0xE0, 0xF0, 0x0F, 0x83, 0xC0, 0x3E, 0x1F, 0x00,
  0xF0, 0x7C, 0x03, 0xC1, 0xE0, 0x1F, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0x00, 0xF8, 0x3C, 0x03, 0xE0, 0xF0,
  0x0F, 0x07, 0xC0, 0x3C, 0x1F, 0x00, 0xF0, 0x78, 0x07, 0xC1, 0xE0, 0x1F,
  0x0F, 0x80, 0x78, 0x3E, 0x01, 0xE0, 0xF0, 0x07, 0x83, 0xC0, 0x3E, 0x00,
  0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x3F, 0xE0, 0xFF, 0xC1, 0xFF,
  0x80, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C,
  0x00, 0x3E, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0x80, 0xFC, 0x1E, 0x03, 0xE0, 0x78, 0x1F, 0x03, 0xE0, 0xF8, 0x0F,
  0x87, 0xC0, 0x3C, 0x3E, 0x00, 0xF0, 0xF8, 0x03, 0xC7, 0xC0, 0x1F, 0x3E,
  0x00, 0x79, 0xF0, 0x01, 0xEF, 0x80, 0x07, 0xBC, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x0F, 0xBE, 0x00, 0x3C, 0x78, 0x00, 0xF1,
  0xF0, 0x07, 0xC7, 0xC0, 0x1E, 0x0F, 0x00, 0x78, 0x3E, 0x01, 0xE0, 0xF8,
  0x0F, 0x81, 0xE0, 0x3E, 0x07, 0x80, 0xF0, 0x1F, 0x03, 0xC0, 0x7C, 0x00,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x7E,
  0x00, 0x7F, 0x07, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x0F,
  0xE0, 0xFE, 0x01, 0xFE, 0x0F, 0xE0, 0x1F, 0xE0, 0xEE, 0x03, 0xDE, 0x1E,
  0xE0, 0x3F, 0xC1, 0xEF, 0x07, 0xBC, 0x1E, 0xF0, 0x7B, 0xC1, 0xEF, 0x0F,
  0x3C, 0x1E, 0xF0, 0xF7, 0xC3, 0xCF, 0x1E, 0x78, 0x3C, 0xF1, 0xE7, 0x83,
  0xCF, 0x3C, 0x78, 0x3C, 0xF3, 0xC7, 0x87, 0x87, 0x78, 0xF8, 0x78, 0x77,
  0x8F, 0x07, 0x87, 0xF0, 0xF0, 0x78, 0x7F, 0x0F, 0x07, 0x87, 0xE0, 0xF0,
  0xF0, 0x7E, 0x1E, 0x0F, 0x07, 0xC1, 0xE0, 0xF0, 0x7C, 0x1E, 0x0F, 0x07,
  0x81, 0xE0, 0x07, 0xC0, 0x1E, 0x0F, 0x80, 0x3C, 0x1F, 0x80, 0x78, 0x7F,
  0x00, 0xF0, 0xFE, 0x01, 0xE1, 0xFC, 0x07, 0x83, 0xFC, 0x0F, 0x07, 0x78,
  0x1E, 0x1E, 0xF0, 0x3C, 0x3C, 0xF0, 0xF8, 0x79, 0xE1, 0xE0, 0xF3, 0xC3,
  0xC1, 0xE7, 0x87, 0x87, 0x87, 0x8F, 0x0F, 0x0F, 0x3C, 0x1E, 0x1E, 0x78,
  0x3C, 0x1E, 0xF0, 0xF8, 0x3D, 0xE1, 0xE0, 0x7B, 0xC3, 0xC0, 0xF7, 0x07,
  0x80, 0xFE, 0x0F, 0x01, 0xFC, 0x3C, 0x03, 0xF8, 0x78, 0x07, 0xF0, 0xF0,
  0x07, 0xC1, 0xE0, 0x0F, 0x80, 0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x00, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC0, 0xFC, 0x3F, 0x0F, 0x80, 0xF8, 0xFC, 0x03, 0xC7,
  0xC0, 0x1F, 0x3C, 0x00, 0xFB, 0xE0, 0x07, 0xDF, 0x00, 0x3E, 0xF0, 0x01,
  0xFF, 0x80, 0x0F, 0x7C, 0x00, 0x7B, 0xE0, 0x07, 0xDF, 0x00, 0x3E, 0xF0,
  0x01, 0xF7, 0x80, 0x1F, 0x3E, 0x00, 0xF9, 0xF0, 0x0F, 0x8F, 0x80, 0x7C,
  0x3E, 0x07, 0xC1, 0xFD, 0xFC, 0x07, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xE0,
  0xF8, 0x7C, 0x1E, 0x07, 0xC3, 0xC0, 0xF8, 0x78, 0x1F, 0x1F, 0x03, 0xE3,
  0xE0, 0x7C, 0x78, 0x0F, 0x0F, 0x03, 0xE1, 0xE1, 0xF8, 0x7F, 0xFE, 0x0F,
  0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xC0, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xF8,
  0x0F, 0xFF, 0xC0, 0xFC, 0x3F, 0x0F, 0x80, 0xF8, 0xFC, 0x03, 0xC7, 0xC0,
  0x1F, 0x3C, 0x00, 0xFB, 0xE0, 0x07, 0xDF, 0x00, 0x3E, 0xF0, 0x01, 0xFF,
  0x80, 0x0F, 0x7C, 0x00, 0x7B, 0xE0, 0x07, 0xDF, 0x00, 0x3E, 0xF0, 0x01,
  0xF7, 0x80, 0x1F, 0x3E, 0x00, 0xF9, 0xF0, 0x0F, 0x8F, 0x80, 0x7C, 0x3E,
  0x0F, 0xC1, 0xFD, 0xFC, 0x07, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x7F, 0xC0,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x07, 0xF0, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F,
  0xFF, 0x0F, 0x87, 0xC3, 0xC0, 0xF0, 0xF0, 0x3C, 0x3C, 0x0F, 0x1F, 0x03,
  0xC7, 0xC1, 0xF1, 0xE0, 0x7C, 0x78, 0x3E, 0x1F, 0xFF, 0x0F, 0xFF, 0x83,
  0xFF, 0xC0, 0xFF, 0xE0, 0x3C, 0x78, 0x1F, 0x1F, 0x07, 0xC7, 0xC1, 0xE0,
  0xF0, 0x78, 0x3E, 0x1E, 0x0F, 0x8F, 0x81, 0xE3, 0xE0, 0x7C, 0xF0, 0x1F,
  0x3C, 0x07, 0xC0, 0x00, 0xFF, 0x00, 0xFF, 0xF0, 0x7F, 0xFC, 0x3F, 0xFE,
  0x0F, 0x81, 0x83, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F,
  0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x30, 0x1F, 0x0F, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xF0, 0x1F,
  0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xE0, 0x3C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00,
  0xF8, 0x78, 0x07, 0xC7, 0xC0, 0x3C, 0x3E, 0x01, 0xE1, 0xE0, 0x0F, 0x0F,
  0x00, 0xF8, 0x78, 0x07, 0xC7, 0xC0, 0x3C, 0x3E, 0x01, 0xE1, 0xE0, 0x1F,
  0x0F, 0x00, 0xF8, 0x78, 0x07, 0x87, 0xC0, 0x3C, 0x3E, 0x01, 0xE1, 0xE0,
  0x1F, 0x0F, 0x00, 0xF8, 0xF8, 0x07, 0x87, 0xC0, 0x3C, 0x3E, 0x03, 0xE1,
  0xF0, 0x1F, 0x0F, 0x80, 0xF0, 0x7C, 0x0F, 0x81, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0x3F, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0xF8, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0x0F, 0x7C, 0x03, 0xEF, 0x80, 0x78, 0xF0, 0x1F, 0x1E, 0x03, 0xC3,
  0xC0, 0xF8, 0x78, 0x1E, 0x0F, 0x07, 0xC1, 0xE0, 0xF0, 0x3C, 0x3E, 0x07,
  0x87, 0x80, 0xF1, 0xF0, 0x1E, 0x3C, 0x03, 0xC7, 0x80, 0x79, 0xE0, 0x0F,
  0x3C, 0x01, 0xEF, 0x00, 0x3D, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x07, 0x80,
  0x7F, 0x80, 0x7C, 0x07, 0xFC, 0x03, 0xE0, 0x3D, 0xE0, 0x3F, 0x01, 0xEF,
  0x01, 0xF8, 0x1E, 0x78, 0x0F, 0xC0, 0xF3, 0xC0, 0xFE, 0x0F, 0x9E, 0x07,
  0xF0, 0x78, 0xF0, 0x7F, 0x87, 0xC7, 0x83, 0xBC, 0x3C, 0x1C, 0x3D, 0xE1,
  0xE0, 0xE1, 0xEF, 0x1E, 0x07, 0x0E, 0x78, 0xF0, 0x38, 0xF3, 0xCF, 0x81,
  0xC7, 0x1E, 0x78, 0x0E, 0x78, 0xF3, 0xC0, 0x73, 0xC7, 0xBC, 0x03, 0xBC,
  0x3D, 0xE0, 0x1D, 0xE1, 0xEE, 0x00, 0xEE, 0x0F, 0xF0, 0x07, 0xF0, 0x7F,
  0x80, 0x3F, 0x03, 0xF8, 0x01, 0xF8, 0x1F, 0xC0, 0x0F, 0xC0, 0xFC, 0x00,
  0x7C, 0x07, 0xE0, 0x03, 0xE0, 0x3F, 0x00, 0x00, 0x03, 0xC0, 0x3E, 0x07,
  0xC0, 0x7C, 0x07, 0x81, 0xF0, 0x0F, 0x07, 0xC0, 0x1E, 0x0F, 0x00, 0x3E,
  0x3E, 0x00, 0x3C, 0xF8, 0x00, 0x79, 0xE0, 0x00, 0xF7, 0xC0, 0x01, 0xFF,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x07, 0x9E, 0x00,
  0x1F, 0x3C, 0x00, 0x7C, 0x7C, 0x00, 0xF0, 0xF8, 0x03, 0xE0, 0xF0, 0x0F,
  0x81, 0xE0, 0x1E, 0x03, 0xE0, 0x7C, 0x07, 0xC1, 0xF0, 0x07, 0x80, 0xF8,
  0x07, 0xFE, 0x03, 0xE7, 0x80, 0xF9, 0xE0, 0x7C, 0x78, 0x1E, 0x1F, 0x0F,
  0x83, 0xC7, 0xC0, 0xF1, 0xE0, 0x3C, 0xF8, 0x0F, 0x3C, 0x03, 0xDE, 0x00,
  0x7F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFE, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7F, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE,
  0x0F, 0xFF, 0xE0, 0x01, 0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0xF8, 0x0F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x80, 0xF1, 0xE3, 0xC7, 0x8F, 0x0E, 0x1C, 0x3C, 0x78, 0xF1,
  0xE3, 0xC3, 0x87, 0x0F, 0x1E, 0x3C, 0x78, 0xF0, 0xE1, 0xC3, 0xC7, 0x8F,
  0x1E, 0x3C, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0x81, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00,
  0xF0, 0x03, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x60,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3F, 0x80, 0x1D, 0xC0, 0x1E,
  0xE0, 0x0E, 0x78, 0x0F, 0x1C, 0x0F, 0x0E, 0x07, 0x07, 0x87, 0x81, 0xC3,
  0x80, 0xE3, 0xC0, 0x79, 0xC0, 0x1D, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0x80, 0xF8, 0xF1, 0xE1, 0xE1, 0xC3, 0xC0, 0x01, 0xE3, 0xC1, 0xFC,
  0xF0, 0xFF, 0xB8, 0x7F, 0xFE, 0x1F, 0x1F, 0x8F, 0x83, 0xE3, 0xC0, 0xF9,
  0xF0, 0x3C, 0x7C, 0x0F, 0x1E, 0x03, 0xC7, 0x80, 0xF3, 0xE0, 0x7C, 0xF8,
  0x1E, 0x3E, 0x07, 0x8F, 0x83, 0xE3, 0xE1, 0xF8, 0x7C, 0xFE, 0x1F, 0xF7,
  0x07, 0xFB, 0xC0, 0xFC, 0xF0, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x78, 0x0F,
  0x3F, 0x03, 0xDF, 0xE0, 0xFF, 0xFC, 0x3E, 0x1F, 0x1F, 0x83, 0xC7, 0xC0,
  0xF1, 0xE0, 0x3C, 0x78, 0x0F, 0x1E, 0x07, 0xCF, 0x81, 0xF3, 0xC0, 0x78,
  0xF0, 0x1E, 0x3C, 0x0F, 0x8F, 0x03, 0xC7, 0xE1, 0xF1, 0xF8, 0xF8, 0x7F,
  0xFE, 0x1D, 0xFF, 0x0F, 0x3F, 0x00, 0x00, 0xF8, 0x07, 0xFC, 0x3F, 0xF0,
  0xFF, 0xE1, 0xF0, 0x47, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x3C, 0x08,
  0x7E, 0x70, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x1E, 0x3C, 0x07, 0xF7, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x81,
  0xF1, 0xF8, 0x3E, 0x0F, 0x83, 0xC0, 0xF8, 0x7C, 0x0F, 0x07, 0xC0, 0xF0,
  0x78, 0x0F, 0x07, 0x80, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xE0, 0xF8, 0x1E,
  0x0F, 0x83, 0xE0, 0xF8, 0x7E, 0x07, 0xCF, 0xC0, 0x7F, 0xDC, 0x07, 0xF9,
  0xC0, 0x3F, 0x3C, 0x00, 0x00, 0xF8, 0x03, 0xFC, 0x0F, 0xFE, 0x1F, 0xBF,
  0x1E, 0x0F, 0x3E, 0x0F, 0x3C, 0x1F, 0x7C, 0x1E, 0x78, 0xFE, 0x7F, 0xFC,
  0x7F, 0xF0, 0xFF, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00,
  0x7C, 0x18, 0x7F, 0xF8, 0x3F, 0xF8, 0x1F, 0xF0, 0x00, 0x00, 0x80, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x80,
  0x3F, 0xF0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F,
  0xC0, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF1, 0xE0, 0x7F, 0x3C, 0x1F, 0xF7,
  0x07, 0xFF, 0xE0, 0xF8, 0xFC, 0x3E, 0x0F, 0x87, 0x81, 0xF1, 0xF0, 0x3C,
  0x3E, 0x07, 0x87, 0x80, 0xF0, 0xF0, 0x1E, 0x3E, 0x07, 0xC7, 0xC0, 0xF0,
  0xF8, 0x3E, 0x1F, 0x07, 0xC3, 0xE1, 0xF8, 0x3E, 0x7F, 0x07, 0xFF, 0xC0,
  0xFF, 0x78, 0x0F, 0xCF, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x03, 0xE0, 0xC0, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xE0, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x78, 0x0F, 0x3F, 0x83, 0xDF,
  0xE0, 0xFF, 0xFC, 0x3F, 0x1F, 0x1F, 0x87, 0xC7, 0xC1, 0xF1, 0xF0, 0x7C,
  0x78, 0x1E, 0x1E, 0x07, 0x8F, 0x81, 0xE3, 0xE0, 0xF8, 0xF0, 0x3E, 0x3C,
  0x0F, 0x0F, 0x03, 0xC7, 0xC0, 0xF1, 0xE0, 0x7C, 0x78, 0x1E, 0x1E, 0x07,
  0x8F, 0x81, 0xE0, 0x03, 0xC0, 0xF0, 0x7C, 0x1F, 0x01, 0x80, 0x00, 0x00,
  0x1E, 0x0F, 0x83, 0xC0, 0xF0, 0x3C, 0x0F, 0x07, 0xC1, 0xE0, 0x78, 0x1E,
  0x0F, 0x83, 0xE0, 0xF0, 0x3C, 0x0F, 0x07, 0xC1, 0xF0, 0x78, 0x1E, 0x0F,
  0x80, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07,
  0xC0, 0xFF, 0x01, 0xFE, 0x03, 0xF8, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x1F, 0x0F, 0x83, 0xC1, 0xE0, 0xF0, 0x3C, 0x3C, 0x07,
  0x8F, 0x81, 0xF3, 0xE0, 0x3C, 0xF8, 0x07, 0xBE, 0x00, 0xFF, 0x80, 0x1F,
  0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0x7C, 0x03, 0xC7, 0x80, 0x78,
  0xF8, 0x1F, 0x1F, 0x03, 0xC1, 0xE0, 0x78, 0x3E, 0x0F, 0x07, 0xC3, 0xE0,
  0x7C, 0x00, 0x03, 0xE0, 0x78, 0x0F, 0x03, 0xE0, 0x7C, 0x0F, 0x01, 0xE0,
  0x3C, 0x0F, 0x81, 0xE0, 0x3C, 0x07, 0x81, 0xF0, 0x3E, 0x07, 0x80, 0xF0,
  0x1E, 0x07, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0x78, 0x1F, 0x03, 0xC0, 0x78,
  0x0F, 0x03, 0xE0, 0x00, 0x07, 0x1E, 0x07, 0x81, 0xE7, 0xE3, 0xF8, 0x3D,
  0xFE, 0xFF, 0x87, 0xFF, 0xDF, 0xF0, 0xFC, 0x7E, 0x1E, 0x1F, 0x0F, 0xC3,
  0xC7, 0xC1, 0xF0, 0x78, 0xF8, 0x3E, 0x0F, 0x1E, 0x07, 0x81, 0xE3, 0xC0,
  0xF0, 0x3C, 0xF8, 0x3E, 0x0F, 0x9E, 0x07, 0x81, 0xE3, 0xC0, 0xF0, 0x3C,
  0x78, 0x1E, 0x07, 0x8F, 0x03, 0xC1, 0xF3, 0xE0, 0xF8, 0x3C, 0x78, 0x1E,
  0x07, 0x8F, 0x03, 0xC0, 0xF1, 0xE0, 0x78, 0x1E, 0x7C, 0x1F, 0x07, 0xC0,
  0x07, 0x1E, 0x03, 0xCF, 0xE0, 0xF7, 0xF8, 0x3F, 0xFF, 0x0F, 0xC7, 0xC7,
  0xE1, 0xF1, 0xF0, 0x7C, 0x7C, 0x1F, 0x1E, 0x07, 0x87, 0x81, 0xE3, 0xE0,
  0x78, 0xF8, 0x3E, 0x3C, 0x0F, 0x8F, 0x03, 0xC3, 0xC0, 0xF1, 0xF0, 0x3C,
  0x78, 0x1F, 0x1E, 0x07, 0x87, 0x81, 0xE3, 0xE0, 0x78, 0x01, 0xF0, 0x03,
  0xFE, 0x03, 0xFF, 0x83, 0xFF, 0xE1, 0xF1, 0xF1, 0xF0, 0x78, 0xF0, 0x3C,
  0xF8, 0x1F, 0x78, 0x0F, 0x3C, 0x07, 0x9E, 0x03, 0xDF, 0x01, 0xEF, 0x81,
  0xF7, 0xC0, 0xFB, 0xE0, 0xF8, 0xF0, 0x7C, 0x7C, 0xFC, 0x3F, 0xFC, 0x0F,
  0xFC, 0x03, 0xFC, 0x00, 0x03, 0x8F, 0x00, 0xF3, 0xF0, 0x1E, 0xFF, 0x03,
  0xFF, 0xF0, 0x7C, 0x3E, 0x0F, 0x83, 0xC3, 0xE0, 0x78, 0x78, 0x0F, 0x0F,
  0x01, 0xE1, 0xE0, 0x7C, 0x7C, 0x0F, 0x8F, 0x01, 0xE1, 0xE0, 0x3C, 0x3C,
  0x0F, 0x87, 0x81, 0xE1, 0xF8, 0x7C, 0x3F, 0x1F, 0x07, 0xFF, 0xE0, 0xF7,
  0xF8, 0x1E, 0x7C, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE3, 0xC1, 0xFC, 0xF0, 0xFF, 0xB8, 0x7F, 0xFE, 0x1F, 0x1F,
  0x8F, 0x83, 0xE3, 0xC0, 0xF9, 0xF0, 0x3C, 0x78, 0x0F, 0x1E, 0x03, 0xC7,
  0x80, 0xF3, 0xE0, 0x7C, 0xF8, 0x1E, 0x3E, 0x07, 0x8F, 0x83, 0xE3, 0xE1,
  0xF8, 0x7C, 0xFC, 0x1F, 0xFF, 0x07, 0xFB, 0xC0, 0xFC, 0xF0, 0x00, 0x7C,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x07, 0x1E, 0x1E, 0x7C, 0x3D,
  0xF0, 0x7F, 0xE0, 0xFE, 0x41, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00,
  0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x1F,
  0xFC, 0x7F, 0xF0, 0xFF, 0xE3, 0xE0, 0x47, 0xC0, 0x0F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00,
  0x3E, 0x40, 0x7C, 0xE1, 0xF1, 0xFF, 0xE3, 0xFF, 0x83, 0xFC, 0x00, 0x07,
  0x00, 0xE0, 0x38, 0x07, 0x01, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x3C, 0x07,
  0x80, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0xC0, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x11, 0xFE, 0x3F, 0xC3, 0xF8, 0x3E, 0x07, 0x9E, 0x07,
  0xCF, 0x03, 0xC7, 0x81, 0xE3, 0xC0, 0xF3, 0xE0, 0x79, 0xE0, 0x7C, 0xF0,
  0x3C, 0x78, 0x1E, 0x7C, 0x0F, 0x3E, 0x0F, 0x9E, 0x07, 0xCF, 0x03, 0xC7,
  0x83, 0xE3, 0xC1, 0xF1, 0xE1, 0xF8, 0xF9, 0xF8, 0x7F, 0xDC, 0x3F, 0xCE,
  0x0F, 0xCF, 0x00, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x1E, 0xF0, 0x3E, 0xF0,
  0x3C, 0xF0, 0x7C, 0xF0, 0x78, 0xF0, 0xF8, 0x78, 0xF0, 0x79, 0xF0, 0x79,
  0xE0, 0x7B, 0xE0, 0x7B, 0xC0, 0x7B, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0x7F,
  0x00, 0x7F, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0xF0, 0x3E, 0x07, 0xF8, 0x1F,
  0x07, 0xBC, 0x1F, 0x83, 0xDE, 0x0F, 0xC3, 0xEF, 0x0F, 0xE1, 0xE7, 0x87,
  0x71, 0xF3, 0xC7, 0xF8, 0xF1, 0xE3, 0xBC, 0x78, 0xF1, 0xDE, 0x78, 0x79,
  0xEF, 0x3C, 0x3C, 0xE7, 0xBC, 0x1E, 0xF3, 0xDE, 0x0F, 0x71, 0xEF, 0x07,
  0xB8, 0xFF, 0x03, 0xFC, 0x7F, 0x81, 0xFC, 0x3F, 0x80, 0x7E, 0x1F, 0xC0,
  0x3E, 0x0F, 0xC0, 0x1F, 0x07, 0xE0, 0x0F, 0x03, 0xE0, 0x00, 0x07, 0x81,
  0xF0, 0x78, 0x1E, 0x07, 0xC3, 0xE0, 0x3C, 0x7C, 0x03, 0xC7, 0x80, 0x3E,
  0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x1F, 0x80, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xBC, 0x00,
  0xF1, 0xE0, 0x1F, 0x1E, 0x03, 0xE1, 0xF0, 0x7C, 0x1F, 0x0F, 0xC0, 0xF0,
  0x07, 0x80, 0x78, 0x3C, 0x07, 0xC1, 0xE0, 0x3C, 0x0F, 0x03, 0xE0, 0x78,
  0x1E, 0x01, 0xE1, 0xF0, 0x0F, 0x0F, 0x00, 0x78, 0xF8, 0x03, 0xC7, 0x80,
  0x1E, 0x7C, 0x00, 0xF3, 0xC0, 0x07, 0x9E, 0x00, 0x3D, 0xE0, 0x01, 0xEF,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xF8,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F,
  0xFF, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x1E, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0x7F, 0xF8, 0xFF, 0xF8, 0xFF, 0xF0, 0x00, 0x1E, 0x00,
  0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x1F,
  0xC0, 0x3E, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xF0, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x01, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x03, 0x80, 0x0F, 0x80, 0x3F, 0x00, 0xFC, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x0F, 0xC0, 0x1F, 0x00, 0xFC, 0x07, 0xF0, 0x3E,
  0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x07, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xC0, 0x30, 0x00, 0x7F,
  0x01, 0xFF, 0xE7, 0xFF, 0xFF, 0xC3, 0xFF, 0x80, 0x7C,
};

const GFXglyph NotoSans_SemiCondensed_SemiBoldItalic36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 11, 26, 10, 0, -26 },
  { 37, 12, 10, 15, 4, -26 },
  { 52, 20, 26, 21, 1, -26 },
  { 117, 17, 29, 18, 1, -27 },
  { 179, 25, 26, 28, 2, -26 },
  { 261, 21, 26, 22, 1, -26 },
  { 330, 5, 10, 8, 4, -26 },
  { 337, 12, 32, 11, 1, -26 },
  { 385, 13, 32, 11, -3, -26 },
  { 437, 15, 16, 18, 3, -28 },
  { 467, 16, 17, 19, 2, -21 },
  { 501, 8, 9, 9, -2, -4 },
  { 510, 9, 4, 11, 1, -12 },
  { 515, 6, 5, 9, 0, -5 },
  { 519, 19, 26, 14, -2, -26 },
  { 581, 17, 26, 18, 1, -26 },
  { 637, 12, 26, 18, 4, -26 },
  { 676, 19, 26, 18, -1, -26 },
  { 738, 18, 26, 18, 0, -26 },
  { 797, 18, 26, 18, 0, -26 },
  { 856, 18, 26, 18, 0, -26 },
  { 915, 18, 26, 18, 1, -26 },
  { 974, 17, 26, 18, 2, -26 },
  { 1030, 17, 26, 18, 1, -26 },
  { 1086, 17, 26, 18, 1, -26 },
  { 1142, 9, 20, 9, 0, -20 },
  { 1165, 11, 25, 9, -2, -20 },
  { 1200, 16, 18, 19, 2, -22 },
  { 1236, 16, 11, 19, 2, -18 },
  { 1258, 16, 18, 19, 2, -22 },
  { 1294, 14, 26, 14, 2, -26 },
  { 1340, 26, 29, 28, 1, -26 },
  { 1435, 20, 26, 20, -2, -26 },
  { 1500, 19, 26, 20, 1, -26 },
  { 1562, 19, 26, 19, 2, -26 },
  { 1624, 20, 26, 22, 1, -26 },
  { 1689, 18, 26, 17, 1, -26 },
  { 1748, 18, 26, 17, 1, -26 },
  { 1807, 20, 26, 22, 2, -26 },
  { 1872, 22, 26, 23, 1, -26 },
  { 1944, 15, 26, 12, -1, -26 },
  { 1993, 17, 33, 10, -6, -26 },
  { 2064, 22, 26, 19, 1, -26 },
  { 2136, 13, 26, 16, 1, -26 },
  { 2179, 28, 26, 29, 1, -26 },
  { 2270, 23, 26, 24, 1, -26 },
  { 2345, 21, 26, 24, 2, -26 },
  { 2414, 19, 26, 19, 1, -26 },
  { 2476, 21, 32, 24, 2, -26 },
  { 2560, 18, 26, 20, 1, -26 },
  { 2619, 18, 26, 17, 0, -26 },
  { 2678, 17, 26, 17, 3, -26 },
  { 2734, 21, 26, 22, 2, -26 },
  { 2803, 19, 26, 19, 3, -26 },
  { 2865, 29, 26, 29, 3, -26 },
  { 2960, 23, 26, 19, -2, -26 },
  { 3035, 18, 26, 18, 3, -26 },
  { 3094, 20, 26, 17, -1, -26 },
  { 3159, 15, 32, 11, -1, -26 },
  { 3219, 7, 26, 14, 4, -26 },
  { 3242, 14, 32, 11, -2, -26 },
  { 3298, 17, 16, 18, 1, -26 },
  { 3332, 14, 3, 13, -3, 3 },
  { 3338, 7, 6, 11, 5, -28 },
  { 3344, 18, 20, 19, 1, -20 },
  { 3389, 18, 27, 19, 0, -27 },
  { 3450, 15, 20, 15, 1, -20 },
  { 3488, 20, 27, 19, 1, -27 },
  { 3556, 16, 20, 18, 1, -20 },
  { 3596, 20, 37, 11, -4, -28 },
  { 3689, 19, 29, 19, 0, -20 },
  { 3758, 18, 27, 19, 0, -27 },
  { 3819, 10, 27, 9, 0, -27 },
  { 3853, 15, 36, 9, -5, -27 },
  { 3921, 19, 27, 18, 0, -27 },
  { 3986, 11, 27, 9, 0, -27 },
  { 4024, 27, 20, 29, 0, -20 },
  { 4092, 18, 20, 19, 0, -20 },
  { 4137, 17, 20, 19, 1, -20 },
  { 4180, 19, 29, 19, -1, -20 },
  { 4249, 18, 29, 19, 1, -20 },
  { 4315, 15, 20, 13, 0, -20 },
  { 4353, 15, 20, 15, 0, -20 },
  { 4391, 11, 24, 12, 2, -24 },
  { 4424, 17, 20, 19, 2, -20 },
  { 4467, 16, 20, 16, 2, -20 },
  { 4507, 25, 20, 25, 2, -20 },
  { 4570, 20, 20, 17, -2, -20 },
  { 4620, 21, 29, 16, -3, -20 },
  { 4697, 16, 20, 15, -1, -20 },
  { 4737, 15, 32, 12, 0, -26 },
  { 4797, 4, 35, 17, 7, -27 },
  { 4815, 14, 32, 12, -2, -26 },
  { 4871, 16, 5, 19, 2, -15 },
};

const GFXfont NotoSans_SemiCondensed_SemiBoldItalic36pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_SemiBoldItalic36pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_SemiBoldItalic36pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC36PT7B_H_
