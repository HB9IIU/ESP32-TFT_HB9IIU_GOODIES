#ifndef _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC71PT7B_H_
#define _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC71PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-SemiBoldItalic.ttf
// Size: 71pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_SemiBoldItalic71pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00,
  0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0xC0,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFE,
  0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0xC0,
  0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC,
  0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x7F, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0xE0, 0xFF, 0x1F, 0xE1, 0xFF, 0x3F, 0xC1, 0xFE, 0x3F, 0xC1, 0xFE, 0x3F,
  0xC1, 0xFE, 0x3F, 0xC1, 0xFE, 0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x3F,
  0x83, 0xFC, 0x7F, 0x03, 0xF8, 0x7F, 0x03, 0xF8, 0x7F, 0x03, 0xF8, 0x7F,
  0x03, 0xF8, 0x7E, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0x7E, 0x07, 0xF0, 0xFE,
  0x07, 0xE0, 0xFC, 0x07, 0xE0, 0xFC, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x00, 0x03,
  0xF0, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x0F,
  0xE0, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x7F,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7E, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x0F, 0xE0,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x1F, 0x80,
  0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00,
  0x00, 0xFE, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00,
  0x07, 0xF0, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0x3C, 0x3E, 0x00, 0x7F, 0xC7, 0x81, 0xC0,
  0x0F, 0xF0, 0xF0, 0x00, 0x03, 0xFC, 0x1E, 0x00, 0x00, 0x7F, 0x87, 0xC0,
  0x00, 0x0F, 0xF0, 0xF0, 0x00, 0x01, 0xFE, 0x1E, 0x00, 0x00, 0x3F, 0xE3,
  0xC0, 0x00, 0x07, 0xFC, 0x78, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3D, 0xFF, 0x80, 0x00,
  0x07, 0x9F, 0xF0, 0x00, 0x00, 0xF1, 0xFF, 0x00, 0x00, 0x3C, 0x3F, 0xE0,
  0x00, 0x07, 0x87, 0xFC, 0x00, 0x00, 0xF0, 0xFF, 0x80, 0x00, 0x1E, 0x1F,
  0xE0, 0x40, 0x03, 0xC3, 0xFC, 0x0C, 0x00, 0xF0, 0xFF, 0x81, 0xF0, 0x1E,
  0x3F, 0xF0, 0x3F, 0xC3, 0xDF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xF0, 0x01, 0xFF, 0xF0, 0x00,
  0x0F, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xC0, 0x07, 0xFF, 0xF8, 0x00,
  0x1F, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xE1, 0xFC, 0x00,
  0x3F, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC1, 0xFC, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0xFC, 0x00, 0x3F, 0x81, 0xFC, 0x01,
  0xFC, 0x00, 0x3F, 0x81, 0xFC, 0x03, 0xF8, 0x00, 0x7F, 0x01, 0xFC, 0x03,
  0xF0, 0x00, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x7F, 0x01, 0xFC, 0x0F,
  0xE0, 0x00, 0x7F, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x7E, 0x01, 0xF8, 0x1F,
  0xC0, 0x00, 0xFE, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0xFE, 0x03, 0xF8, 0x3F,
  0x00, 0x00, 0xFE, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0xFE,
  0x0F, 0xF0, 0xFE, 0x07, 0xF0, 0xFC, 0x3F, 0xF8, 0xFE, 0x07, 0xE1, 0xFC,
  0x7F, 0xFC, 0xFE, 0x0F, 0xE3, 0xF8, 0xFF, 0xFE, 0x7E, 0x1F, 0xE3, 0xF1,
  0xFF, 0xFF, 0x7F, 0xFF, 0xC7, 0xF1, 0xFF, 0xFF, 0x7F, 0xFF, 0x8F, 0xE3,
  0xFC, 0x7F, 0x3F, 0xFF, 0x0F, 0xC3, 0xF8, 0x7F, 0x3F, 0xFF, 0x1F, 0xC7,
  0xF0, 0x3F, 0x1F, 0xFC, 0x3F, 0x87, 0xF0, 0x3F, 0x0F, 0xF8, 0x3F, 0x0F,
  0xE0, 0x3F, 0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x3F, 0x00, 0x00, 0xFE, 0x0F,
  0xC0, 0x7F, 0x00, 0x00, 0xFC, 0x1F, 0xC0, 0x7F, 0x00, 0x01, 0xFC, 0x1F,
  0xC0, 0x7F, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x7F, 0x00, 0x03, 0xF0, 0x1F,
  0xC0, 0x7F, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x00, 0x0F, 0xE0, 0x1F,
  0x80, 0xFE, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0xFE, 0x00, 0x1F, 0xC0, 0x3F,
  0x80, 0xFE, 0x00, 0x3F, 0x80, 0x3F, 0x81, 0xFC, 0x00, 0x3F, 0x00, 0x3F,
  0x81, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0xFE, 0x00, 0x1F,
  0xC3, 0xF8, 0x00, 0xFC, 0x00, 0x1F, 0xCF, 0xF0, 0x01, 0xFC, 0x00, 0x1F,
  0xFF, 0xF0, 0x03, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xF0, 0x00, 0x0F,
  0xFF, 0xC0, 0x07, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x87, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC1, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x7F, 0xC0, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x1F,
  0xF0, 0x1F, 0xFF, 0xF0, 0x07, 0xF8, 0x0F, 0xFF, 0xFC, 0x01, 0xFE, 0x07,
  0xFE, 0xFF, 0x80, 0xFF, 0x83, 0xFF, 0x3F, 0xE0, 0x3F, 0xC1, 0xFF, 0x87,
  0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x87, 0xF8, 0x3F, 0xE0, 0x3F, 0xE3,
  0xFE, 0x0F, 0xF0, 0x0F, 0xFC, 0xFF, 0x07, 0xFC, 0x01, 0xFF, 0x7F, 0x81,
  0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x7F, 0x80, 0x0F, 0xFF, 0xF0, 0x3F, 0xE0,
  0x01, 0xFF, 0xF8, 0x0F, 0xF8, 0x00, 0x7F, 0xFE, 0x03, 0xFE, 0x00, 0x0F,
  0xFF, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0xFF, 0xE0,
  0x07, 0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x7F,
  0xFD, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x7F, 0xC0, 0x0F, 0xFF, 0xFF, 0x1F,
  0xF8, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xC0,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE3, 0xFC, 0xFF, 0x9F, 0xE3, 0xFC,
  0x7F, 0x8F, 0xE1, 0xFC, 0x3F, 0x8F, 0xF1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE,
  0x1F, 0x83, 0xF0, 0xFE, 0x1F, 0x83, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x01, 0x00, 0x3F, 0x00, 0x0F, 0x00,
  0xFC, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0xFE, 0x0F, 0x80, 0x07, 0xFE, 0x7E,
  0x00, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x40, 0x7F, 0xFC, 0x00, 0x03,
  0xFD, 0xF8, 0x00, 0x1F, 0xE7, 0xE0, 0x00, 0xFF, 0x9F, 0xC0, 0x07, 0xFC,
  0x3F, 0x00, 0x3F, 0xE0, 0xFE, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0xFC, 0x0F,
  0xF0, 0x00, 0xE0, 0x1F, 0xC0, 0x01, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFE, 0x07,
  0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0x81, 0xFF, 0x03, 0xFC, 0x07, 0xF8,
  0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x01, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x1F,
  0xC0, 0x7F, 0x00, 0xFE, 0x00, 0x3F, 0xFF, 0xE7, 0xFF, 0xFD, 0xFF, 0xFF,
  0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xFF, 0xF7, 0xFF, 0xFC,
  0x0F, 0x0F, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F,
  0xC3, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0x83,
  0xFE, 0x01, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0xFF, 0x80,
  0x3F, 0xE0, 0x7F, 0xC0, 0x0F, 0xF0, 0x7F, 0xC0, 0x07, 0xF8, 0x3F, 0xE0,
  0x03, 0xFC, 0x3F, 0xE0, 0x01, 0xFE, 0x1F, 0xF0, 0x00, 0xFF, 0x0F, 0xF0,
  0x00, 0x7F, 0x8F, 0xF8, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x3F, 0xE3, 0xFE,
  0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x07, 0xFC, 0xFF,
  0x80, 0x03, 0xFE, 0x7F, 0x80, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0xFF, 0x3F,
  0xE0, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x3F, 0xE7,
  0xF8, 0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x0F, 0xF8,
  0xFF, 0x00, 0x07, 0xFC, 0x7F, 0x80, 0x03, 0xFE, 0x7F, 0xC0, 0x03, 0xFE,
  0x3F, 0xE0, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0xFF,
  0x87, 0xFC, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x3F,
  0xE0, 0x7F, 0x80, 0x3F, 0xF0, 0x3F, 0xC0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x0F, 0xFC, 0x1F, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0x01,
  0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE7, 0xFF,
  0xBF, 0xCF, 0xFE, 0x7F, 0x9F, 0xF9, 0xFF, 0x1F, 0xC3, 0xFC, 0x1F, 0x07,
  0xF8, 0x38, 0x0F, 0xF0, 0x20, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x07, 0xFE, 0x0F, 0xFE, 0x00, 0x1F, 0xC0, 0x1F, 0xF8,
  0x00, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0x80, 0x03, 0xFE, 0x00, 0x08, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFC, 0x07,
  0xFF, 0x00, 0x3C, 0x00, 0x7F, 0xE0, 0x03, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07,
  0xFC, 0x10, 0x00, 0x01, 0xFF, 0x83, 0x80, 0x00, 0x7F, 0xF0, 0x7C, 0x00,
  0x3F, 0xFC, 0x0F, 0xFE, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xBF,
  0x80, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x1F,
  0xE7, 0xF8, 0x00, 0x01, 0xFC, 0x7F, 0x80, 0x00, 0x3F, 0x8F, 0xF0, 0x00,
  0x07, 0xF8, 0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0xFF,
  0x00, 0x01, 0xFC, 0x1F, 0xF0, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x07, 0xF8,
  0x1F, 0xE0, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x1F, 0xE0, 0x01,
  0xFE, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x03, 0xF8, 0x03, 0xFC,
  0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x07, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x01, 0xFE, 0x78, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xC1,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x0F, 0xF8, 0x10, 0x00, 0x03, 0xFF, 0x03, 0x00, 0x00, 0xFF, 0xC0,
  0x7C, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xE0, 0x04, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x03, 0xC0,
  0x00, 0x7F, 0x87, 0xFE, 0x00, 0x3F, 0xE7, 0xFF, 0xC0, 0x0F, 0xF3, 0xFF,
  0xF8, 0x03, 0xFD, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xDF, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xC1, 0xFF,
  0xC0, 0x1F, 0xF0, 0x7F, 0xE0, 0x07, 0xFC, 0x3F, 0xF0, 0x01, 0xFF, 0x0F,
  0xFC, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x07, 0xFC,
  0x3F, 0xE0, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x1F,
  0xE0, 0xFF, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x03, 0xFE, 0x0F, 0xF0, 0x00,
  0xFF, 0x83, 0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x1F, 0xF0, 0x3F, 0xE0,
  0x0F, 0xFC, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x03, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xF8, 0x7F, 0xF0,
  0x07, 0xFE, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xE0, 0x07,
  0xFC, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x0F, 0xF0, 0x1F, 0xE0,
  0x03, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x0F, 0xF0, 0x0F,
  0xF8, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x1F, 0xF0,
  0x03, 0xFE, 0x07, 0xFC, 0x00, 0x3F, 0xE3, 0xFF, 0x00, 0x07, 0xFE, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFB, 0xFF, 0x00,
  0x1F, 0xFC, 0x3F, 0xF0, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x3F, 0xE0, 0x07, 0xFC, 0x07, 0xF8, 0x00, 0x7F, 0xC1, 0xFF, 0x00,
  0x0F, 0xF8, 0x3F, 0xC0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0xFF,
  0x00, 0x03, 0xFC, 0x3F, 0xE0, 0x00, 0x7F, 0x87, 0xFC, 0x00, 0x1F, 0xF0,
  0xFF, 0x80, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x1F,
  0xF0, 0x3F, 0xF0, 0x07, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFE,
  0x07, 0xFE, 0x07, 0xFE, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0x83, 0xFE,
  0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x0F, 0xF0, 0xFF,
  0x80, 0x07, 0xFC, 0x7F, 0xC0, 0x03, 0xFE, 0x3F, 0xC0, 0x01, 0xFF, 0x1F,
  0xE0, 0x00, 0xFF, 0x8F, 0xF0, 0x00, 0x7F, 0xC7, 0xF8, 0x00, 0x3F, 0xC3,
  0xFC, 0x00, 0x3F, 0xE1, 0xFE, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x1F, 0xF8,
  0x7F, 0x80, 0x0F, 0xFC, 0x3F, 0xE0, 0x0F, 0xFE, 0x1F, 0xF8, 0x0F, 0xFF,
  0x0F, 0xFE, 0x1F, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xDF, 0xE0, 0x3F, 0xFF, 0xDF, 0xF0, 0x0F, 0xFF, 0xCF,
  0xF0, 0x03, 0xFF, 0x87, 0xF8, 0x00, 0x3F, 0x07, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x7F, 0xC0, 0x10, 0x00, 0xFF, 0xE0, 0x0F, 0xEF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0xFF, 0x01, 0xFF, 0x03, 0xFF,
  0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x01, 0xFC,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x3F, 0x80, 0x7F, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0,
  0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xF0, 0x7E, 0x03, 0xFF, 0x0E, 0x00, 0x3F, 0xE1, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x3F, 0xF8, 0x03, 0xF0,
  0x3F, 0x80, 0x1F, 0xFF, 0xF0, 0x7E, 0x0F, 0xE0, 0x07, 0xFF, 0xFC, 0x0F,
  0xE1, 0xFC, 0x03, 0xFF, 0xFF, 0x81, 0xFC, 0x7F, 0x00, 0xFF, 0xFF, 0xF0,
  0x3F, 0x8F, 0xE0, 0x3F, 0xE0, 0xFE, 0x03, 0xF1, 0xF8, 0x07, 0xF0, 0x1F,
  0x80, 0x7E, 0x7F, 0x01, 0xFC, 0x03, 0xF0, 0x1F, 0xCF, 0xC0, 0x7F, 0x00,
  0xFE, 0x03, 0xF9, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x7F, 0x03, 0xF8,
  0x03, 0xF0, 0x0F, 0xCF, 0xC0, 0x7E, 0x00, 0x7E, 0x01, 0xF9, 0xF8, 0x0F,
  0xC0, 0x1F, 0xC0, 0x3F, 0x3F, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xEF, 0xE0,
  0x7E, 0x00, 0x7E, 0x01, 0xFD, 0xF8, 0x0F, 0xC0, 0x1F, 0xC0, 0x3F, 0x3F,
  0x01, 0xF8, 0x03, 0xF8, 0x07, 0xE7, 0xE0, 0x7F, 0x00, 0x7F, 0x01, 0xFC,
  0xFC, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x1F, 0x81, 0xFC, 0x03, 0xF8, 0x0F,
  0xE3, 0xF0, 0x3F, 0x80, 0x7F, 0x01, 0xF8, 0x7E, 0x07, 0xF0, 0x1F, 0xE0,
  0x7F, 0x0F, 0xC0, 0xFE, 0x07, 0xFC, 0x1F, 0xC1, 0xF8, 0x0F, 0xE1, 0xFF,
  0x87, 0xF8, 0x3F, 0x01, 0xFF, 0xFD, 0xFF, 0xFE, 0x07, 0xE0, 0x3F, 0xFF,
  0x3F, 0xFF, 0x80, 0xFE, 0x03, 0xFF, 0xE3, 0xFF, 0xE0, 0x1F, 0xC0, 0x3F,
  0xF8, 0x7F, 0xF8, 0x01, 0xF8, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xFF, 0xE0, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0x00,
  0xFF, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0xFF, 0x00, 0x00, 0x07, 0xF9, 0xFE,
  0x00, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x00,
  0x7F, 0x87, 0xF0, 0x00, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x1F,
  0xC0, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x00,
  0x7F, 0x80, 0xFE, 0x00, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0xFF, 0x80,
  0x01, 0xFF, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x07, 0xFC,
  0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0xFF, 0x80,
  0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x00, 0x7F,
  0x8F, 0xF8, 0x00, 0x00, 0xFF, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x7F, 0xC0,
  0x00, 0x03, 0xFD, 0xFF, 0x80, 0x00, 0x07, 0xFB, 0xFE, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0xF0, 0x7F, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0x00, 0x3F,
  0xF0, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x7F,
  0xC0, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x07, 0xFC, 0x03, 0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xFF, 0x00,
  0x7F, 0x80, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00,
  0x3F, 0xC0, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x03, 0xFE, 0x03,
  0xFC, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x01,
  0xFF, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x1F,
  0xE0, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x07, 0xFE, 0x03, 0xFE, 0x00, 0x3F,
  0xF8, 0x0F, 0xF0, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0x01, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xE0, 0x07,
  0xFF, 0x00, 0x01, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x03, 0x00, 0x0F, 0xFF, 0x00, 0x7C, 0x00, 0x3F, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xC0, 0x3F, 0xFC, 0x00, 0x3F, 0xE0,
  0x07, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x7F,
  0xE0, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x03,
  0xFE, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x00, 0x7F,
  0xE0, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x0F,
  0xF0, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x07, 0xFC, 0x00,
  0x03, 0xFE, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x7F,
  0xC0, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0x00,
  0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x0F, 0xF8, 0x00, 0x07, 0xFC,
  0x07, 0xFC, 0x00, 0x07, 0xFE, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x01, 0xFE,
  0x00, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x01, 0xFF, 0xC0,
  0x1F, 0xE0, 0x01, 0xFF, 0xC0, 0x1F, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xF8,
  0x07, 0xFF, 0xE0, 0x07, 0xFC, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFE, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x7C, 0x01, 0xFF,
  0xE0, 0x00, 0x08, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x07, 0xFF,
  0xF8, 0x7F, 0xC0, 0x07, 0xFF, 0xF8, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0xFF,
  0x80, 0x0F, 0xFF, 0xF8, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0xFF, 0x80, 0x0F,
  0xFF, 0xF0, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0xFF,
  0xC0, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x00,
  0x7F, 0xC0, 0x7F, 0xE0, 0x00, 0x7F, 0x80, 0x7F, 0xF0, 0x00, 0x7F, 0x80,
  0x3F, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0,
  0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x40, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x01, 0xFE,
  0x00, 0x07, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x7F, 0xE0, 0x00, 0x07, 0xF8, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x83,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x0F, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x1F, 0xF8, 0x00,
  0x00, 0x1F, 0xE3, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x7F, 0xE0, 0x00, 0x00,
  0x1F, 0xE7, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x00, 0x07, 0xFE, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x00,
  0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x0F,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x07, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x13, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFE,
  0x00, 0x03, 0xFB, 0xFC, 0x00, 0xFF, 0x7E, 0x00, 0x07, 0xFB, 0xF8, 0x00,
  0xFE, 0x7F, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xF7,
  0xF8, 0x01, 0xFE, 0x7F, 0x00, 0x0F, 0xE7, 0xF8, 0x01, 0xFE, 0x7F, 0x00,
  0x1F, 0xE7, 0xF8, 0x01, 0xFE, 0x7F, 0x00, 0x1F, 0xCF, 0xF0, 0x01, 0xFE,
  0x7F, 0x00, 0x3F, 0xCF, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x8F, 0xF0,
  0x03, 0xFC, 0x7F, 0x00, 0x7F, 0x8F, 0xF0, 0x03, 0xFC, 0x7F, 0x00, 0x7F,
  0x1F, 0xF0, 0x03, 0xFC, 0x7F, 0x00, 0xFF, 0x1F, 0xE0, 0x03, 0xFC, 0x7F,
  0x00, 0xFE, 0x1F, 0xE0, 0x03, 0xF8, 0x7F, 0x01, 0xFE, 0x1F, 0xE0, 0x07,
  0xF8, 0x7F, 0x01, 0xFC, 0x1F, 0xE0, 0x07, 0xF8, 0x7F, 0x03, 0xFC, 0x3F,
  0xE0, 0x07, 0xF8, 0x7F, 0x03, 0xF8, 0x3F, 0xC0, 0x07, 0xF8, 0x3F, 0x87,
  0xF8, 0x3F, 0xC0, 0x0F, 0xF0, 0x3F, 0x87, 0xF0, 0x3F, 0xC0, 0x0F, 0xF0,
  0x3F, 0x8F, 0xF0, 0x3F, 0xC0, 0x0F, 0xF0, 0x3F, 0x8F, 0xE0, 0x7F, 0x80,
  0x0F, 0xF0, 0x3F, 0x9F, 0xE0, 0x7F, 0x80, 0x0F, 0xF0, 0x3F, 0x9F, 0xC0,
  0x7F, 0x80, 0x1F, 0xE0, 0x3F, 0xBF, 0xC0, 0x7F, 0x80, 0x1F, 0xE0, 0x3F,
  0xBF, 0x80, 0x7F, 0x80, 0x1F, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0x00, 0x1F,
  0xE0, 0x3F, 0xFF, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x3F, 0xFF, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x3F, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x3F, 0xFE,
  0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x3F, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x3F, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xF8, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x1F, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x03,
  0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xF8, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xF0, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xC0, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x0F,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xF0, 0x01, 0xFF,
  0xFC, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xC0, 0x0F, 0xFF,
  0xF0, 0x00, 0x7F, 0x80, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x3F, 0xDF,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x7F,
  0x80, 0x0F, 0xF0, 0x03, 0xFC, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0xFF,
  0x00, 0x7F, 0x80, 0x0F, 0xF1, 0xFE, 0x00, 0xFF, 0x00, 0x1F, 0xE3, 0xFC,
  0x01, 0xFE, 0x00, 0x3F, 0x83, 0xFC, 0x03, 0xFC, 0x00, 0xFF, 0x07, 0xF8,
  0x07, 0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x1F, 0xE0, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x80, 0x0F, 0xE0, 0x3F, 0xC0,
  0xFF, 0x00, 0x3F, 0xC0, 0x7F, 0x81, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0x87,
  0xF8, 0x00, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x01, 0xFE, 0x01, 0xFE, 0x1F,
  0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x7F,
  0x00, 0x1F, 0xE0, 0x07, 0xF8, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF3, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xF7, 0xF8, 0x01, 0xFE, 0x00, 0x1F, 0xEF, 0xF0,
  0x03, 0xFC, 0x00, 0x3F, 0xDF, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0xFF, 0x80,
  0x0F, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xFE, 0x00,
  0x7F, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x01,
  0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x03, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x0F,
  0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x1F, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xF0, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xF0, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0,
  0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0x3F,
  0xE0, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x3F,
  0xE0, 0x00, 0x03, 0xFE, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x00, 0x7F, 0xCF, 0xFC, 0x00, 0x00, 0x3F,
  0xE7, 0xFC, 0x00, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x00, 0x0F, 0xFB, 0xFF,
  0x00, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00,
  0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x7F, 0xE0, 0x00, 0x00, 0xFF,
  0xBF, 0xE0, 0x00, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x00, 0x3F, 0xEF, 0xF8,
  0x00, 0x00, 0x3F, 0xF7, 0xFC, 0x00, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x00,
  0x0F, 0xF9, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0xFF, 0x80, 0x00, 0x07, 0xFC,
  0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x87, 0xFC, 0x00, 0x00,
  0xFF, 0x83, 0xFE, 0x00, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x7F, 0xC0, 0x00, 0xFF, 0xE0, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x1F, 0xFC,
  0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x81, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x00,
  0x3F, 0xF0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00,
  0x7F, 0xC0, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x07,
  0xFC, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x03,
  0xFE, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x07, 0xF8, 0x00, 0x7F, 0xE0, 0x3F,
  0xE0, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xFE, 0x03, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x3F, 0xFC, 0x01, 0xFF,
  0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x00, 0x1F, 0xF0,
  0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x3F, 0xF0,
  0x00, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x00,
  0x7F, 0xCF, 0xFC, 0x00, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x00, 0x1F, 0xF3,
  0xFE, 0x00, 0x00, 0x0F, 0xFB, 0xFF, 0x00, 0x00, 0x07, 0xFD, 0xFF, 0x00,
  0x00, 0x07, 0xFE, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x01,
  0xFF, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x00, 0x7F, 0xDF,
  0xF0, 0x00, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x00, 0x3F, 0xF7, 0xFC, 0x00,
  0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x00, 0x0F,
  0xFC, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x3F,
  0xE0, 0x00, 0x03, 0xFF, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x0F, 0xF8, 0x00,
  0x01, 0xFF, 0x87, 0xFC, 0x00, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x00, 0xFF,
  0xC1, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x00, 0xFF, 0xE0, 0x3F,
  0xF0, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x81,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x07, 0xF8, 0x7F, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xF8, 0x03, 0xFE,
  0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x1F, 0xF0,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x07, 0xFC, 0x03, 0xFE, 0x00,
  0x3F, 0xE0, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x0F,
  0xF8, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x3F,
  0xE0, 0x1F, 0xE0, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xF8,
  0x03, 0xFF, 0x80, 0x7F, 0xC0, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x1F, 0xE0,
  0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0x1F, 0xE0,
  0x3F, 0xE0, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x07, 0xFC, 0x00,
  0x7F, 0xC0, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x7F,
  0xC0, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x01, 0xFF,
  0x81, 0xFF, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x7F, 0x80,
  0x01, 0xFF, 0x83, 0xFC, 0x00, 0x0F, 0xFC, 0x3F, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0x83, 0xF8,
  0x00, 0xFF, 0xE0, 0x07, 0x80, 0x0F, 0xF8, 0x00, 0x10, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xF8, 0x04, 0x00, 0x01, 0xFF, 0x80, 0x70, 0x00, 0x3F,
  0xF0, 0x07, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x07,
  0xFC, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x01,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0x1F,
  0xE0, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x0F,
  0xF8, 0x00, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x03, 0xFE, 0x00,
  0x01, 0xFE, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x3F,
  0xC0, 0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00,
  0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x03, 0xFC,
  0x03, 0xFC, 0x00, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x00,
  0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0x1F, 0xF0,
  0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x07, 0xFC,
  0x00, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xE7, 0xF8, 0x00, 0x00, 0xFF, 0x9F, 0xE0, 0x00, 0x07, 0xFC, 0x7F,
  0x80, 0x00, 0x1F, 0xF1, 0xFE, 0x00, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0x03,
  0xFE, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x00, 0x7F, 0xC1, 0xFE,
  0x00, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x1F, 0xE0, 0x00, 0x7F,
  0xC0, 0x7F, 0x80, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x07, 0xF8,
  0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x07, 0xFC,
  0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x7F, 0xC0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x0F, 0xF8, 0x00,
  0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x00, 0xFF, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x00,
  0x3F, 0xC3, 0xFC, 0x00, 0x00, 0xFF, 0x1F, 0xF0, 0x00, 0x01, 0xFC, 0x7F,
  0x80, 0x00, 0x07, 0xF3, 0xFE, 0x00, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x00,
  0x7F, 0x3F, 0xC0, 0x00, 0x01, 0xFD, 0xFE, 0x00, 0x00, 0x07, 0xF7, 0xF8,
  0x00, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xBF, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xDF, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xCF,
  0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE7, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xE3, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF1, 0xFE, 0x00, 0x0F,
  0xFE, 0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xF8, 0x7F,
  0x80, 0x07, 0xFF, 0x80, 0x07, 0xFC, 0x3F, 0xC0, 0x03, 0xFF, 0xC0, 0x03,
  0xFC, 0x1F, 0xE0, 0x03, 0xFF, 0xE0, 0x03, 0xFE, 0x0F, 0xF0, 0x01, 0xFF,
  0xF0, 0x01, 0xFE, 0x07, 0xF8, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0x03, 0xFC,
  0x00, 0xFF, 0xFC, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0x80, 0xFF, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x3F, 0xBF,
  0x80, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xDF, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0,
  0x1F, 0xCF, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x1F, 0xE7, 0xF0, 0x0F, 0xF0,
  0x07, 0xF8, 0x0F, 0xE3, 0xF8, 0x0F, 0xF8, 0x03, 0xFC, 0x07, 0xF1, 0xFC,
  0x07, 0xF8, 0x01, 0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xFC, 0x00, 0xFF, 0x03,
  0xF8, 0x7F, 0x03, 0xFC, 0x00, 0x7F, 0x83, 0xFC, 0x3F, 0x81, 0xFE, 0x00,
  0x3F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFE, 0x00, 0x1F, 0xE1, 0xFE, 0x0F, 0xE0,
  0xFF, 0x00, 0x0F, 0xF0, 0xFE, 0x07, 0xF0, 0xFF, 0x80, 0x07, 0xF8, 0x7F,
  0x03, 0xF8, 0x7F, 0x80, 0x03, 0xFC, 0x7F, 0x01, 0xFC, 0x3F, 0xC0, 0x01,
  0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0xC0, 0x00, 0xFF, 0x3F, 0xC0, 0x7F, 0x1F,
  0xE0, 0x00, 0x7F, 0x9F, 0xC0, 0x3F, 0x9F, 0xE0, 0x00, 0x3F, 0xCF, 0xE0,
  0x1F, 0xCF, 0xF0, 0x00, 0x1F, 0xEF, 0xE0, 0x0F, 0xE7, 0xF8, 0x00, 0x0F,
  0xF7, 0xF0, 0x07, 0xF7, 0xF8, 0x00, 0x07, 0xF7, 0xF0, 0x03, 0xFB, 0xFC,
  0x00, 0x03, 0xFB, 0xF8, 0x01, 0xFD, 0xFC, 0x00, 0x01, 0xFD, 0xFC, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xC0, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x07,
  0xFC, 0x00, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF1, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xBF, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFD, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE7,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x9F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x7F,
  0xC0, 0x00, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x83, 0xFE,
  0x00, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x3F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x0F, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xEF, 0xF0, 0x00,
  0x0F, 0xFD, 0xFE, 0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x7F, 0xC7, 0xFC,
  0x00, 0x1F, 0xF8, 0xFF, 0x80, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0x81,
  0xFE, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x07, 0xFC, 0x07, 0xFC, 0x01, 0xFF,
  0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF8, 0x01, 0xFE, 0x01,
  0xFF, 0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x7F,
  0x83, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x01, 0xFE, 0x1F, 0xE0, 0x00,
  0x3F, 0xC7, 0xFC, 0x00, 0x07, 0xF9, 0xFF, 0x00, 0x00, 0x7F, 0xBF, 0xE0,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0xFE, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFF, 0x01, 0xFE, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0xC0, 0x7F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0x1F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x80,
  0xFF, 0x01, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00,
  0x1F, 0xC7, 0xE0, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x03, 0xF8, 0x7F, 0x00,
  0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0xFE,
  0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x07, 0xF0, 0x07, 0xF0, 0x01, 0xFC, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x1F, 0xC0,
  0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x1F, 0xC1, 0xFC,
  0x00, 0x07, 0xF0, 0xFF, 0x00, 0x00, 0xFC, 0x3F, 0x80, 0x00, 0x3F, 0x9F,
  0xE0, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x01, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xC3, 0xFE, 0x1F, 0xF0, 0x7F, 0xC1, 0xFE, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0xC0, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0x07, 0xF0, 0x07, 0xFF, 0xE1, 0xFC, 0x03, 0xFF, 0xFC, 0xFF,
  0x01, 0xFF, 0xFF, 0xBF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFC, 0x3F, 0xFE, 0x0F, 0xFE, 0x03, 0xFF, 0x83, 0xFF, 0x00,
  0xFF, 0xC1, 0xFF, 0x80, 0x3F, 0xF0, 0x7F, 0xC0, 0x07, 0xFC, 0x3F, 0xF0,
  0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x1F, 0xE1, 0xFF,
  0x00, 0x07, 0xF8, 0x7F, 0xC0, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0xFF, 0x87,
  0xF8, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x03, 0xFC,
  0x3F, 0xE0, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x1F,
  0xE0, 0xFF, 0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x03, 0xFE, 0x0F, 0xF0, 0x00,
  0xFF, 0x83, 0xFC, 0x00, 0x7F, 0xE0, 0xFF, 0x00, 0x3F, 0xF0, 0x3F, 0xE0,
  0x0F, 0xFC, 0x0F, 0xF8, 0x07, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0xC0, 0xFF,
  0xF7, 0xFF, 0xF0, 0x1F, 0xFF, 0xFB, 0xF8, 0x07, 0xFF, 0xFE, 0xFE, 0x00,
  0xFF, 0xFF, 0x3F, 0x80, 0x3F, 0xFF, 0x8F, 0xE0, 0x07, 0xFF, 0xC7, 0xF0,
  0x00, 0xFF, 0xC1, 0xFC, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x00, 0xFF, 0x1F, 0xFC, 0x00,
  0x1F, 0xE7, 0xFF, 0xC0, 0x07, 0xF9, 0xFF, 0xFC, 0x00, 0xFF, 0x7F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xF8,
  0x3F, 0xF0, 0x1F, 0xFE, 0x03, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xC0, 0x7F,
  0xE0, 0x07, 0xF8, 0x0F, 0xF8, 0x00, 0xFF, 0x03, 0xFF, 0x00, 0x1F, 0xF0,
  0x7F, 0xC0, 0x03, 0xFC, 0x0F, 0xF8, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x0F,
  0xF0, 0x3F, 0xC0, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x3F, 0xC1, 0xFE, 0x00,
  0x0F, 0xF8, 0x3F, 0xC0, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0xFF,
  0x00, 0x07, 0xF8, 0x3F, 0xE0, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x3F, 0xE0,
  0xFF, 0x00, 0x07, 0xFC, 0x1F, 0xE0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x3F,
  0xE0, 0xFF, 0x80, 0x0F, 0xF8, 0x1F, 0xF0, 0x01, 0xFF, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x7F, 0xE0, 0x1F, 0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0x03, 0xFF,
  0xF3, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xEF, 0xFF, 0xFC, 0x01,
  0xFD, 0xFF, 0xFF, 0x00, 0x7F, 0x1F, 0xFF, 0xC0, 0x0F, 0xE1, 0xFF, 0xF0,
  0x01, 0xFC, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80,
  0xFF, 0xE0, 0x38, 0x0F, 0xFE, 0x00, 0x40, 0x7F, 0xC0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x10, 0x1F, 0xFC, 0x03, 0x80, 0x7F, 0xF9, 0xFC, 0x03, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x07,
  0xF8, 0x00, 0x1F, 0xFC, 0x3F, 0xC0, 0x03, 0xFF, 0xF1, 0xFE, 0x00, 0x3F,
  0xFF, 0xDF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFC, 0x1F, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xF0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x07,
  0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x1F,
  0xE0, 0x1F, 0xF0, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x0F, 0xF8,
  0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x1F, 0xE0,
  0x3F, 0xE0, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x0F, 0xF8, 0x00,
  0x3F, 0xC0, 0x7F, 0x80, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x07, 0xF8, 0x00, 0x7F,
  0xC0, 0x3F, 0xC0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x0F, 0xF0,
  0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0xC0,
  0x1F, 0xFC, 0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0x7F, 0x00, 0x0F, 0xFF, 0xF3, 0xF8, 0x00, 0x7F, 0xFF, 0x1F, 0xC0, 0x01,
  0xFF, 0xF0, 0xFC, 0x00, 0x03, 0xFE, 0x07, 0xE0, 0x00, 0x03, 0x80, 0x40,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xE0, 0x3F, 0xF8, 0xFF, 0xC1, 0xFF, 0x80, 0xFF, 0x0F, 0xFC, 0x03, 0xFC,
  0x3F, 0xE0, 0x0F, 0xF1, 0xFF, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0xFF, 0x3F,
  0xE0, 0x07, 0xFC, 0xFF, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0xFF, 0x9F, 0xF0,
  0x0F, 0xFC, 0x7F, 0x81, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x08, 0x3F, 0xF0,
  0x00, 0xE0, 0x7F, 0xF0, 0x1F, 0x81, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x04, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x20, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x41, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x1F, 0xC0, 0x03, 0xFF, 0xF0, 0xFE, 0x00, 0x3F, 0xFF,
  0xCF, 0xF0, 0x03, 0xFF, 0xFF, 0x7F, 0x00, 0x3F, 0xFF, 0xFB, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFC, 0x1F, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x07, 0xFC,
  0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x1F, 0xF0,
  0x1F, 0xF0, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x0F, 0xF8, 0x00,
  0x7F, 0xC0, 0x7F, 0xC0, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x3F,
  0xE0, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x0F, 0xF8, 0x00, 0x7F,
  0xC0, 0x7F, 0xC0, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x1F, 0xE0,
  0x01, 0xFF, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x07, 0xF8, 0x00, 0xFF, 0xC0,
  0x3F, 0xC0, 0x07, 0xFE, 0x01, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x07,
  0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x07, 0xFF, 0xC0, 0x1F,
  0xFE, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0xFF,
  0x00, 0x1F, 0xFF, 0xE7, 0xF8, 0x00, 0x7F, 0xFE, 0x7F, 0xC0, 0x01, 0xFF,
  0xE3, 0xFC, 0x00, 0x07, 0xFE, 0x1F, 0xE0, 0x00, 0x03, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x02, 0x00, 0x00, 0xFF, 0x80, 0x1C, 0x00, 0x0F, 0xF8,
  0x00, 0xFC, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0xFF,
  0x1F, 0xFE, 0x00, 0x3F, 0xCF, 0xFF, 0xC0, 0x1F, 0xE7, 0xFF, 0xF8, 0x07,
  0xFB, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFE, 0x0F, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x80, 0x7F,
  0xC0, 0xFF, 0xC0, 0x0F, 0xF0, 0x3F, 0xF0, 0x03, 0xFC, 0x1F, 0xF8, 0x00,
  0xFF, 0x07, 0xFE, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x1F, 0xF0, 0x7F, 0xC0,
  0x07, 0xF8, 0x1F, 0xE0, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x7F, 0x83, 0xFE,
  0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x03, 0xFC, 0x0F,
  0xF0, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x1F, 0xF0,
  0x7F, 0x80, 0x07, 0xFC, 0x1F, 0xE0, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x7F,
  0x83, 0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x0F, 0xF8, 0x3F, 0xC0, 0x03,
  0xFC, 0x0F, 0xF0, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x3F, 0xC1, 0xFF, 0x00,
  0x1F, 0xF0, 0x7F, 0x80, 0x07, 0xFC, 0x1F, 0xE0, 0x01, 0xFE, 0x07, 0xF8,
  0x00, 0x7F, 0x83, 0xFE, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x0F, 0xF8, 0x3F,
  0xC0, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x03, 0xFC, 0x00, 0xFF, 0x80,
  0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFE, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x20, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x07,
  0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x1F,
  0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F,
  0xC0, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x02, 0x0F, 0xFC, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x07, 0xF8, 0x01, 0xFF, 0x00,
  0x7F, 0xC0, 0x1F, 0xF0, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x1F,
  0xF0, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x1F, 0xF8, 0x00, 0x7F,
  0xC1, 0xFF, 0x80, 0x03, 0xFC, 0x1F, 0xF8, 0x00, 0x1F, 0xE0, 0xFF, 0x80,
  0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x00, 0x7F, 0x8F,
  0xF8, 0x00, 0x03, 0xFC, 0xFF, 0x80, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xF7, 0xFC, 0x00,
  0x03, 0xFF, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x01, 0xFF, 0x07,
  0xFC, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x03,
  0xFC, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x03,
  0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00,
  0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE,
  0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F,
  0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01,
  0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00,
  0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0x80,
  0x07, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0xFF, 0xE0,
  0x0F, 0xFE, 0x00, 0x3F, 0x0F, 0xFF, 0x81, 0xFF, 0xF8, 0x03, 0xF8, 0xFF,
  0xFE, 0x1F, 0xFF, 0xE0, 0x1F, 0xCF, 0xFF, 0xF9, 0xFF, 0xFF, 0x00, 0xFE,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFC, 0x1F, 0xFF, 0xC3, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F,
  0xF8, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xC0, 0xFF, 0xC0, 0x1F, 0xFC,
  0x01, 0xFE, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xF0, 0x7F, 0xE0, 0x07,
  0xFC, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x1F, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFE, 0x07,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x7F,
  0x83, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x1F, 0xE0, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x83, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xFC, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0xFF,
  0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x7F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x3F, 0xC0, 0x07,
  0xFC, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x1F, 0xF0,
  0x01, 0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x1F, 0xE0,
  0x03, 0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x0F,
  0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0xFF,
  0x83, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x07, 0xF8,
  0x00, 0x3F, 0x07, 0xFF, 0x80, 0x0F, 0xC3, 0xFF, 0xF0, 0x07, 0xF1, 0xFF,
  0xFE, 0x01, 0xFC, 0xFF, 0xFF, 0x80, 0x7F, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xC3, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xC0, 0xFF,
  0xE0, 0x1F, 0xF0, 0x3F, 0xF0, 0x03, 0xFC, 0x0F, 0xFC, 0x00, 0xFF, 0x07,
  0xFE, 0x00, 0x3F, 0xC1, 0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0xC0, 0x07, 0xFC,
  0x1F, 0xF0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x1F,
  0xE0, 0xFF, 0x80, 0x0F, 0xF8, 0x3F, 0xC0, 0x03, 0xFE, 0x0F, 0xF0, 0x00,
  0xFF, 0x03, 0xFC, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0xC0,
  0x07, 0xFC, 0x1F, 0xE0, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x7F, 0x83, 0xFE,
  0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x0F, 0xF8, 0x3F, 0xE0, 0x03, 0xFE, 0x0F,
  0xF0, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x0F, 0xF0,
  0x7F, 0xC0, 0x07, 0xFC, 0x1F, 0xE0, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x7F,
  0x81, 0xFE, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x07, 0xF8, 0x3F, 0xE0, 0x03,
  0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0x0F, 0xFC, 0x0F, 0xFC, 0x03, 0xFE, 0x1F, 0xF8, 0x03, 0xFE, 0x1F, 0xF0,
  0x01, 0xFE, 0x3F, 0xF0, 0x01, 0xFE, 0x3F, 0xE0, 0x01, 0xFF, 0x3F, 0xE0,
  0x01, 0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0x7F, 0x80,
  0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFE, 0xFF, 0x80, 0x01, 0xFE, 0xFF, 0x80,
  0x01, 0xFE, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x00, 0x03, 0xFE, 0xFF, 0x00,
  0x03, 0xFE, 0xFF, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x07, 0xFC, 0xFF, 0x00,
  0x07, 0xFC, 0xFF, 0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x0F, 0xF8, 0xFF, 0x00,
  0x1F, 0xF8, 0xFF, 0x80, 0x1F, 0xF0, 0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0xC0,
  0x7F, 0xE0, 0x7F, 0xFB, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC3, 0xFF, 0x80, 0x00, 0x3F, 0x0F, 0xFF,
  0x80, 0x00, 0xFE, 0x3F, 0xFF, 0x80, 0x01, 0xFC, 0xFF, 0xFF, 0x80, 0x03,
  0xFB, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0x07,
  0xFE, 0x00, 0x3F, 0xFC, 0x07, 0xFC, 0x00, 0x7F, 0xF0, 0x0F, 0xF8, 0x00,
  0xFF, 0xC0, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xFE, 0x00,
  0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x01, 0xFF, 0x00,
  0x07, 0xF8, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x07, 0xF8, 0x00, 0x3F, 0xE0,
  0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x7F, 0xC0,
  0x03, 0xFE, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x0F, 0xF8,
  0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x1F, 0xF0,
  0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x07, 0xFF,
  0xE7, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF8,
  0x00, 0x3F, 0xDF, 0xFF, 0xE0, 0x00, 0xFF, 0x9F, 0xFF, 0x80, 0x01, 0xFE,
  0x3F, 0xFE, 0x00, 0x03, 0xFC, 0x1F, 0xF8, 0x00, 0x07, 0xF8, 0x0F, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0x07, 0xF0, 0x07, 0xFF, 0xE1, 0xFC, 0x03, 0xFF, 0xFC, 0xFF,
  0x01, 0xFF, 0xFF, 0xBF, 0x80, 0xFF, 0xFF, 0xEF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFC, 0x3F, 0xFE, 0x0F, 0xFC, 0x03, 0xFF, 0x83, 0xFE, 0x00,
  0xFF, 0xC1, 0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0xC0, 0x07, 0xFC, 0x3F, 0xE0,
  0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x1F, 0xE1, 0xFF,
  0x00, 0x07, 0xF8, 0x7F, 0xC0, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0xFF, 0x87,
  0xF8, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x03, 0xFC,
  0x3F, 0xE0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x1F,
  0xE0, 0xFF, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x03, 0xFE, 0x0F, 0xF0, 0x00,
  0xFF, 0x83, 0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x1F, 0xF0, 0x3F, 0xC0,
  0x0F, 0xFC, 0x0F, 0xF8, 0x07, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0xC0, 0xFF,
  0xF3, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFD, 0xFE, 0x01,
  0xFF, 0xFE, 0x7F, 0x80, 0x3F, 0xFF, 0xBF, 0xE0, 0x07, 0xFF, 0x8F, 0xF0,
  0x00, 0xFF, 0xC3, 0xFC, 0x00, 0x07, 0x80, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x0F, 0xE1, 0xFF,
  0x00, 0xFE, 0x3F, 0xF0, 0x1F, 0xE7, 0xFF, 0x01, 0xFC, 0xFF, 0xE0, 0x1F,
  0xDF, 0xFE, 0x01, 0xFD, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xF0,
  0x40, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xFE, 0x7F, 0x80,
  0xFF, 0x80, 0x3C, 0x07, 0xFC, 0x00, 0x40, 0x3F, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC2, 0x00,
  0x03, 0xFE, 0x1C, 0x00, 0x3F, 0xE0, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x1F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC3, 0x01, 0xFF, 0xFE, 0x01,
  0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x00, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xC1, 0xFF, 0x00,
  0x1F, 0xF0, 0x7F, 0x80, 0x07, 0xFC, 0x1F, 0xE0, 0x01, 0xFE, 0x07, 0xF8,
  0x00, 0x7F, 0x83, 0xFE, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x0F, 0xF8, 0x3F,
  0xC0, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x3F, 0xC1,
  0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x07, 0xFC, 0x1F, 0xE0, 0x01, 0xFE,
  0x07, 0xF8, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x0F,
  0xF8, 0x3F, 0xC0, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0x03, 0xFC, 0x00,
  0x3F, 0xC1, 0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x07, 0xFC, 0x1F, 0xE0,
  0x01, 0xFF, 0x07, 0xF8, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x3F, 0xE0, 0xFF,
  0x80, 0x0F, 0xF8, 0x3F, 0xE0, 0x07, 0xFE, 0x0F, 0xF8, 0x01, 0xFF, 0x03,
  0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x3F, 0xF0, 0x3F, 0xE0, 0x1F, 0xFC,
  0x0F, 0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0x9F, 0xFF, 0x80, 0xFF, 0xFF, 0xEF,
  0xE0, 0x1F, 0xFF, 0xF3, 0xF8, 0x07, 0xFF, 0xFC, 0xFE, 0x00, 0xFF, 0xFE,
  0x3F, 0x80, 0x1F, 0xFE, 0x0F, 0xC0, 0x03, 0xFF, 0x03, 0xF0, 0x00, 0x1E,
  0x01, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFE, 0xFF,
  0x00, 0x03, 0xFC, 0xFF, 0x00, 0x07, 0xFC, 0xFF, 0x00, 0x07, 0xF8, 0xFF,
  0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x1F, 0xF0, 0x7F,
  0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x3F, 0xE0, 0x7F, 0x80, 0x3F, 0xC0, 0x7F,
  0x80, 0x7F, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x80, 0x7F,
  0x80, 0xFF, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x7F,
  0x83, 0xFE, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x7F, 0x87, 0xFC, 0x00, 0x3F,
  0x87, 0xF8, 0x00, 0x3F, 0x8F, 0xF8, 0x00, 0x3F, 0x8F, 0xF0, 0x00, 0x3F,
  0x8F, 0xF0, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0x3F,
  0xBF, 0xC0, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xBF,
  0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xDF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xCF,
  0xF0, 0x03, 0xFF, 0x80, 0x3F, 0xE7, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xE3,
  0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xF1, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xF0,
  0x7F, 0x00, 0xFD, 0xF8, 0x07, 0xF8, 0x3F, 0x80, 0x7E, 0xFC, 0x07, 0xFC,
  0x1F, 0xC0, 0x7F, 0x7E, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x3F, 0x03, 0xFE,
  0x07, 0xF0, 0x3F, 0x9F, 0x81, 0xFE, 0x03, 0xF8, 0x1F, 0xCF, 0xC0, 0xFF,
  0x01, 0xFC, 0x1F, 0xC7, 0xE0, 0xFF, 0x00, 0xFE, 0x0F, 0xE7, 0xF0, 0x7F,
  0x80, 0x7F, 0x07, 0xE3, 0xF8, 0x7F, 0x80, 0x3F, 0x87, 0xF1, 0xFC, 0x3F,
  0xC0, 0x1F, 0xC3, 0xF8, 0xFE, 0x3F, 0xE0, 0x0F, 0xE3, 0xF8, 0x7F, 0x1F,
  0xE0, 0x07, 0xF1, 0xFC, 0x3F, 0x8F, 0xF0, 0x03, 0xF9, 0xFC, 0x1F, 0xCF,
  0xF0, 0x01, 0xFC, 0xFE, 0x0F, 0xE7, 0xF8, 0x00, 0xFE, 0x7E, 0x07, 0xF3,
  0xF8, 0x00, 0x7F, 0x7F, 0x03, 0xFB, 0xFC, 0x00, 0x3F, 0xBF, 0x81, 0xFD,
  0xFC, 0x00, 0x1F, 0xDF, 0x80, 0xFE, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x07,
  0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x01,
  0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x01, 0xFE, 0x00, 0xFF, 0x80,
  0x03, 0xFE, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x07, 0xF8,
  0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x00, 0x1F, 0xF1, 0xFF, 0x00,
  0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x00, 0x3F, 0xCF, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xBF, 0xC0, 0x00, 0x03,
  0xFE, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0xFF,
  0x00, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x03,
  0xFE, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x0F,
  0xF8, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x07,
  0xFC, 0x00, 0x3F, 0xE0, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0x07, 0xF8,
  0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x7F,
  0xC0, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x0F, 0xF8, 0x00,
  0x00, 0xFE, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x00, 0x0F,
  0xE0, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x00, 0x0F, 0xF1, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0xCF, 0xF0, 0x00, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x00, 0x01, 0xFD,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x02, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0xC0, 0x01, 0xFF, 0xFC, 0x80,
  0x00, 0x3F, 0xF0,
};

const GFXglyph NotoSans_SemiCondensed_SemiBoldItalic71pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 20, 52, 19, 1, -51 },
  { 131, 24, 19, 29, 7, -51 },
  { 188, 41, 51, 41, 1, -51 },
  { 450, 35, 58, 36, 1, -54 },
  { 704, 48, 52, 55, 4, -51 },
  { 1016, 42, 52, 44, 1, -51 },
  { 1289, 11, 19, 17, 7, -51 },
  { 1316, 24, 62, 21, 2, -51 },
  { 1502, 24, 62, 21, -5, -51 },
  { 1688, 30, 31, 35, 6, -54 },
  { 1805, 32, 34, 37, 4, -42 },
  { 1941, 15, 17, 18, -3, -8 },
  { 1973, 19, 8, 22, 1, -23 },
  { 1992, 10, 11, 18, 1, -10 },
  { 2006, 36, 51, 27, -3, -51 },
  { 2236, 33, 52, 36, 2, -51 },
  { 2451, 23, 51, 36, 8, -51 },
  { 2598, 37, 51, 36, -2, -51 },
  { 2834, 35, 52, 36, 0, -51 },
  { 3062, 36, 51, 36, -1, -51 },
  { 3292, 35, 52, 36, 1, -51 },
  { 3520, 34, 52, 36, 3, -51 },
  { 3741, 35, 51, 36, 3, -51 },
  { 3965, 35, 52, 36, 1, -51 },
  { 4193, 33, 52, 36, 2, -51 },
  { 4408, 16, 40, 18, 1, -39 },
  { 4488, 21, 48, 18, -4, -39 },
  { 4614, 32, 35, 37, 4, -43 },
  { 4754, 31, 20, 37, 4, -35 },
  { 4832, 32, 35, 37, 4, -43 },
  { 4972, 27, 52, 28, 4, -51 },
  { 5148, 51, 57, 55, 3, -51 },
  { 5512, 39, 51, 39, -4, -51 },
  { 5761, 38, 51, 39, 1, -51 },
  { 6004, 38, 52, 38, 4, -51 },
  { 6251, 41, 51, 43, 1, -51 },
  { 6513, 36, 51, 34, 1, -51 },
  { 6743, 36, 51, 33, 1, -51 },
  { 6973, 40, 52, 44, 4, -51 },
  { 7233, 45, 51, 45, 1, -51 },
  { 7520, 30, 51, 24, -2, -51 },
  { 7712, 32, 65, 20, -11, -51 },
  { 7972, 44, 51, 38, 1, -51 },
  { 8253, 27, 51, 32, 1, -51 },
  { 8426, 56, 51, 57, 1, -51 },
  { 8783, 47, 51, 47, 1, -51 },
  { 9083, 41, 52, 46, 4, -51 },
  { 9350, 38, 51, 38, 1, -51 },
  { 9593, 41, 63, 46, 4, -51 },
  { 9916, 37, 51, 39, 1, -51 },
  { 10152, 36, 52, 34, 0, -51 },
  { 10386, 33, 51, 33, 6, -51 },
  { 10597, 41, 52, 44, 4, -51 },
  { 10864, 38, 51, 37, 6, -51 },
  { 11107, 57, 51, 57, 7, -51 },
  { 11471, 46, 51, 37, -4, -51 },
  { 11765, 35, 51, 35, 6, -51 },
  { 11989, 39, 51, 34, -2, -51 },
  { 12238, 29, 62, 22, -2, -51 },
  { 12463, 15, 51, 27, 7, -51 },
  { 12559, 28, 62, 22, -5, -51 },
  { 12776, 34, 31, 36, 1, -51 },
  { 12908, 27, 5, 26, -6, 6 },
  { 12925, 13, 11, 21, 10, -54 },
  { 12943, 34, 40, 38, 3, -39 },
  { 13113, 35, 55, 38, 1, -54 },
  { 13354, 29, 40, 30, 3, -39 },
  { 13499, 37, 55, 38, 3, -54 },
  { 13754, 30, 40, 35, 3, -39 },
  { 13904, 39, 71, 23, -8, -54 },
  { 14251, 37, 56, 38, 0, -39 },
  { 14510, 34, 54, 38, 1, -54 },
  { 14740, 19, 53, 18, 1, -53 },
  { 14866, 29, 70, 18, -9, -53 },
  { 15120, 37, 54, 35, 1, -54 },
  { 15370, 20, 54, 18, 1, -54 },
  { 15505, 53, 39, 57, 1, -39 },
  { 15764, 34, 39, 38, 1, -39 },
  { 15930, 32, 40, 37, 3, -39 },
  { 16090, 39, 56, 38, -3, -39 },
  { 16363, 34, 56, 38, 3, -39 },
  { 16601, 28, 39, 26, 1, -39 },
  { 16738, 29, 40, 30, 0, -39 },
  { 16883, 23, 48, 24, 3, -47 },
  { 17021, 34, 39, 38, 3, -38 },
  { 17187, 32, 38, 32, 4, -38 },
  { 17339, 49, 38, 50, 4, -38 },
  { 17572, 39, 38, 33, -3, -38 },
  { 17758, 42, 55, 32, -6, -38 },
  { 18047, 32, 38, 29, -2, -38 },
  { 18199, 28, 62, 25, 1, -51 },
  { 18416, 7, 70, 34, 14, -54 },
  { 18478, 28, 62, 25, -4, -51 },
  { 18695, 32, 10, 37, 4, -30 },
};

const GFXfont NotoSans_SemiCondensed_SemiBoldItalic71pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_SemiBoldItalic71pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_SemiBoldItalic71pt7bGlyphs,
  0x20, 0x7E, 97
};

#endif // _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC71PT7B_H_
