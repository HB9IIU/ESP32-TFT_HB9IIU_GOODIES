#ifndef _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC23PT7B_H_
#define _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC23PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-SemiBoldItalic.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_SemiBoldItalic23pt7bBitmaps[] PROGMEM = {
  0x00, 0x1E, 0x38, 0x70, 0xE1, 0x87, 0x0E, 0x1C, 0x30, 0x60, 0xC0, 0x00,
  0x0E, 0x3C, 0x70, 0x77, 0x66, 0x66, 0x66, 0xC6, 0xCC, 0x03, 0x38, 0x0C,
  0xC0, 0x63, 0x01, 0x98, 0x3F, 0xFC, 0xFF, 0xE0, 0xC6, 0x03, 0x30, 0x0C,
  0xC1, 0xFF, 0xCF, 0xFF, 0x06, 0x60, 0x31, 0x80, 0xCC, 0x03, 0x30, 0x1C,
  0xC0, 0x01, 0x80, 0x3C, 0x0F, 0xF1, 0xFE, 0x3B, 0x23, 0xB0, 0x3A, 0x01,
  0xE0, 0x0F, 0x80, 0x7C, 0x05, 0xC0, 0x4C, 0x85, 0xC6, 0x7C, 0xFF, 0x87,
  0xF0, 0x08, 0x01, 0x80, 0x0C, 0x02, 0x3E, 0x0C, 0x36, 0x18, 0x66, 0x18,
  0x66, 0x30, 0x66, 0x60, 0xE6, 0x60, 0xEE, 0xDE, 0xED, 0xBF, 0x7D, 0xB3,
  0x33, 0x73, 0x06, 0x63, 0x06, 0x67, 0x0C, 0x66, 0x18, 0x66, 0x18, 0x7C,
  0x30, 0x3C, 0x01, 0x80, 0x1F, 0x80, 0xEE, 0x03, 0x18, 0x0C, 0x60, 0x33,
  0x80, 0xDC, 0x03, 0xE0, 0x1F, 0x00, 0xFC, 0x77, 0x3B, 0x9C, 0xEE, 0xE1,
  0xF3, 0x83, 0x87, 0x1E, 0x1F, 0xFC, 0x3F, 0x78, 0x76, 0x66, 0xEC, 0x0F,
  0x0C, 0x18, 0x38, 0x30, 0x70, 0x60, 0x60, 0xE0, 0xE0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xE0, 0x60, 0x60, 0x06, 0x06, 0x07, 0x07, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x07, 0x07, 0x06, 0x06, 0x0E, 0x0C, 0x1C,
  0x18, 0x30, 0x70, 0xE0, 0x08, 0x03, 0x88, 0xE1, 0xB0, 0xFF, 0xC7, 0xF1,
  0xC4, 0xD8, 0x76, 0x09, 0xC0, 0x40, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC1, 0xFF, 0xFF, 0xF8, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x00, 0x39, 0x9C,
  0xC6, 0x60, 0x7F, 0xF0, 0x7F, 0xE0, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x1C,
  0x01, 0x80, 0x38, 0x03, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0C, 0x01, 0xC0,
  0x38, 0x03, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x00, 0x07, 0x03, 0xE1, 0xFC,
  0xE7, 0x70, 0xDC, 0x36, 0x0F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x06, 0xC3,
  0xB8, 0xEE, 0x73, 0xF8, 0x7C, 0x00, 0x07, 0x1F, 0x3F, 0xF6, 0x6E, 0x0E,
  0x0E, 0x0C, 0x0C, 0x1C, 0x1C, 0x1C, 0x18, 0x38, 0x38, 0x38, 0x01, 0xC0,
  0x7E, 0x1F, 0xF0, 0xC7, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0E, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x27, 0xFC, 0xFF, 0xC0,
  0x03, 0x83, 0xFC, 0x7F, 0x88, 0x70, 0x06, 0x01, 0xC0, 0x38, 0x7E, 0x0E,
  0x03, 0xF0, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0xA0, 0xE7, 0xFC, 0xFE, 0x00,
  0x00, 0xE0, 0x3C, 0x0F, 0x83, 0xF0, 0x6C, 0x1B, 0x87, 0x71, 0xCE, 0x31,
  0x8C, 0x33, 0xFF, 0xFF, 0xFF, 0xFE, 0x06, 0x00, 0xC0, 0x38, 0x0F, 0xF0,
  0xFE, 0x1C, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x3F, 0x83, 0xFC, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xCC, 0x38, 0xFF, 0x8F, 0xE0, 0x01, 0xC0,
  0xFC, 0x7F, 0x0E, 0x03, 0x80, 0xE0, 0x1C, 0x83, 0x7C, 0xFF, 0x9E, 0x3B,
  0x87, 0x70, 0xEE, 0x19, 0xC7, 0x39, 0xE3, 0xF8, 0x3E, 0x00, 0x3F, 0xEF,
  0xFC, 0x03, 0x00, 0xE0, 0x18, 0x07, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0,
  0x70, 0x0E, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0x00, 0x03, 0x80, 0xFE, 0x1F,
  0xE1, 0xC7, 0x18, 0x71, 0x86, 0x1C, 0xE0, 0xFC, 0x0F, 0x03, 0xF8, 0x71,
  0xC7, 0x0C, 0x60, 0xCE, 0x0C, 0x71, 0xC7, 0xF8, 0x3F, 0x00, 0x07, 0x07,
  0xE3, 0xFD, 0xC7, 0x71, 0xD8, 0x7E, 0x1F, 0x87, 0x73, 0xDF, 0xF3, 0xD8,
  0x0E, 0x03, 0x81, 0xC8, 0xE3, 0xF0, 0xF8, 0x00, 0x18, 0xF3, 0x86, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x3C, 0xE0, 0x0C, 0x3C, 0x70, 0x60, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xE1, 0x87, 0x0C, 0x38, 0x60, 0x00, 0x20, 0x1C, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x01, 0x80,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x80, 0x1C, 0x03, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0xF8, 0x7C, 0x7C, 0x1E, 0x03, 0x00, 0x00,
  0x0E, 0x3F, 0x9F, 0xE8, 0x70, 0x38, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x0C,
  0x0E, 0x00, 0x00, 0x01, 0xC1, 0xE0, 0xE0, 0x00, 0x03, 0xFC, 0x0F, 0x0E,
  0x1C, 0x07, 0x38, 0x03, 0x31, 0xF3, 0x63, 0xF3, 0x66, 0x33, 0xC6, 0x33,
  0xCC, 0x63, 0xCC, 0x63, 0xCC, 0x66, 0xCC, 0xE6, 0xCF, 0xBC, 0xC2, 0x10,
  0x60, 0x00, 0x70, 0x10, 0x3F, 0xE0, 0x0F, 0xC0, 0x01, 0xE0, 0x1E, 0x03,
  0xE0, 0x36, 0x07, 0x60, 0x66, 0x0E, 0x70, 0xC7, 0x1C, 0x71, 0xFF, 0x3F,
  0xF3, 0xFF, 0x70, 0x77, 0x07, 0xE0, 0x7E, 0x07, 0x0F, 0xF0, 0x7F, 0x87,
  0x0E, 0x38, 0x71, 0xC3, 0x8C, 0x38, 0xFF, 0x87, 0xF0, 0x3F, 0xE1, 0xC7,
  0x0C, 0x1C, 0xE0, 0xC7, 0x0E, 0x38, 0xF1, 0xFF, 0x1F, 0xE0, 0x01, 0xC0,
  0x3F, 0xC7, 0xFC, 0x38, 0x23, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xE2, 0x0F, 0xF0,
  0x1F, 0x80, 0x0F, 0xE0, 0x7F, 0x87, 0x1E, 0x38, 0x71, 0xC3, 0x8C, 0x0C,
  0xE0, 0xE7, 0x07, 0x38, 0x39, 0xC1, 0xCC, 0x1E, 0xE0, 0xE7, 0x0E, 0x39,
  0xF1, 0xFE, 0x1F, 0xE0, 0x0F, 0xF0, 0xFF, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x3F, 0xC3, 0xFC, 0x3F, 0xC3, 0x80, 0x30, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x7F, 0x8F, 0xF8, 0x0F, 0xF0, 0xFF, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0x80, 0x38, 0x03, 0xFC, 0x3F, 0xC3, 0x80, 0x30, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x0E, 0x00, 0x01, 0xE0, 0x3F, 0xC3, 0xFE, 0x38, 0x13, 0x80,
  0x3C, 0x01, 0xC0, 0x0E, 0x00, 0xE1, 0xF7, 0x0F, 0xB8, 0x1D, 0xC0, 0xEE,
  0x06, 0x38, 0x71, 0xE3, 0x87, 0xFC, 0x1F, 0xC0, 0x0E, 0x0E, 0x18, 0x18,
  0x70, 0x70, 0xE0, 0xE1, 0xC1, 0xC3, 0x03, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F,
  0xF8, 0x70, 0x70, 0xC0, 0xC3, 0x83, 0x87, 0x07, 0x0E, 0x0E, 0x1C, 0x1C,
  0x70, 0x70, 0x1F, 0xC3, 0xE0, 0x70, 0x18, 0x06, 0x03, 0x80, 0xE0, 0x38,
  0x0C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x06, 0x07, 0xE3, 0xF8, 0x00, 0xE0,
  0x18, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0xC1, 0xF0,
  0x3E, 0x0F, 0x00, 0x0E, 0x3C, 0x30, 0xE1, 0xC7, 0x07, 0x38, 0x1D, 0xC0,
  0x6F, 0x03, 0xB8, 0x0F, 0xC0, 0x3F, 0x80, 0xEE, 0x03, 0x38, 0x1C, 0x70,
  0x71, 0xC1, 0xC7, 0x07, 0x0E, 0x38, 0x38, 0x0E, 0x06, 0x07, 0x03, 0x81,
  0xC0, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0C, 0x0E, 0x07, 0x03, 0x81, 0xFF,
  0xFF, 0x0F, 0x03, 0xE1, 0xE0, 0x78, 0x7C, 0x1F, 0x0D, 0x83, 0xE1, 0xB0,
  0xFC, 0x36, 0x1B, 0x0E, 0xC7, 0x61, 0xD8, 0xDC, 0x3B, 0x3B, 0x86, 0x66,
  0x70, 0xCD, 0xCC, 0x39, 0xB3, 0x87, 0x3E, 0x70, 0xE7, 0x8E, 0x18, 0xF1,
  0x87, 0x1C, 0x30, 0x0E, 0x07, 0x0F, 0x06, 0x1F, 0x0E, 0x1B, 0x0E, 0x1B,
  0x0E, 0x1B, 0x8C, 0x3B, 0x8C, 0x39, 0x9C, 0x39, 0xDC, 0x31, 0xDC, 0x30,
  0xD8, 0x70, 0xD8, 0x70, 0xF8, 0x70, 0xF8, 0x60, 0x70, 0xE0, 0x70, 0x01,
  0xC0, 0x7F, 0x87, 0xFE, 0x38, 0x73, 0x83, 0xB8, 0x0D, 0xC0, 0x6E, 0x03,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0x78, 0x79, 0xE7, 0x8F,
  0xF8, 0x1F, 0x80, 0x0F, 0xE0, 0x7F, 0x87, 0x1E, 0x38, 0x71, 0xC3, 0x8C,
  0x18, 0xE1, 0xC7, 0x3E, 0x3F, 0xE1, 0xFC, 0x0C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x1C, 0x00, 0x01, 0xC0, 0x7F, 0x87, 0xFE, 0x38, 0x73,
  0x83, 0xB8, 0x0D, 0xC0, 0x6E, 0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x07, 0x78, 0x79, 0xE7, 0x8F, 0xF8, 0x1F, 0x80, 0x1C, 0x00, 0xE0,
  0x03, 0x80, 0x1E, 0x00, 0x0F, 0xE0, 0xFF, 0x1C, 0x71, 0xC7, 0x1C, 0x71,
  0x87, 0x38, 0xF3, 0xFE, 0x3F, 0xC3, 0xB8, 0x33, 0x87, 0x1C, 0x71, 0xC7,
  0x1C, 0x70, 0xEE, 0x0E, 0x03, 0x80, 0xFF, 0x1F, 0xE3, 0xC2, 0x38, 0x03,
  0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x01, 0xC0,
  0x38, 0xC7, 0x8F, 0xF0, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x06, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x18, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x1C, 0x1C, 0xE0, 0xE3, 0x83, 0x8E, 0x0E, 0x38,
  0x38, 0xC0, 0xC7, 0x07, 0x1C, 0x1C, 0x70, 0x71, 0x81, 0x8E, 0x0E, 0x38,
  0x38, 0xE0, 0xE1, 0xC7, 0x07, 0xF8, 0x0F, 0xC0, 0xE0, 0x7E, 0x0E, 0xE0,
  0xEE, 0x1C, 0xE1, 0xCE, 0x38, 0x63, 0x86, 0x30, 0x67, 0x06, 0x60, 0x6E,
  0x06, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x07, 0x00, 0xE0, 0xE1, 0xFC, 0x3C,
  0x3B, 0x87, 0x86, 0x71, 0xF1, 0xCE, 0x3E, 0x39, 0xC7, 0xCE, 0x39, 0xB9,
  0xC7, 0x37, 0x30, 0xEE, 0xEE, 0x1D, 0x9D, 0x83, 0xF3, 0xF0, 0x7C, 0x7E,
  0x0F, 0x8F, 0x81, 0xE1, 0xF0, 0x3C, 0x3C, 0x07, 0x83, 0x80, 0x1E, 0x1E,
  0x1C, 0x70, 0x38, 0xE0, 0x33, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x01,
  0xC0, 0x07, 0x80, 0x1F, 0x80, 0x37, 0x00, 0xEE, 0x03, 0x8E, 0x0E, 0x1C,
  0x1C, 0x38, 0x70, 0x78, 0xE0, 0xFC, 0x39, 0x87, 0x39, 0xC7, 0x70, 0xEE,
  0x0F, 0x81, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x0F, 0xF8, 0xFF, 0xC0, 0x1C, 0x01, 0xC0, 0x1E, 0x00, 0xE0,
  0x0E, 0x00, 0xF0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0x80, 0x38,
  0x01, 0xFF, 0x1F, 0xF8, 0x07, 0xC3, 0xE0, 0xE0, 0x30, 0x0C, 0x03, 0x01,
  0xC0, 0x70, 0x18, 0x06, 0x03, 0x80, 0xE0, 0x30, 0x0C, 0x03, 0x01, 0xC0,
  0x70, 0x18, 0x07, 0xC3, 0xE0, 0xE3, 0x18, 0xC6, 0x39, 0xCE, 0x31, 0x8C,
  0x63, 0x9C, 0xE3, 0x18, 0x0F, 0xC3, 0xE0, 0x38, 0x0E, 0x03, 0x00, 0xC0,
  0x30, 0x1C, 0x07, 0x01, 0x80, 0x60, 0x18, 0x0E, 0x03, 0x80, 0xC0, 0x30,
  0x1C, 0x07, 0x07, 0x83, 0xE0, 0x03, 0x00, 0xF0, 0x1E, 0x06, 0xC1, 0xDC,
  0x31, 0x8E, 0x31, 0x87, 0x60, 0x7C, 0x0C, 0xFF, 0xFF, 0x80, 0xE3, 0x8C,
  0x70, 0x0E, 0x03, 0xFC, 0xFF, 0xB8, 0xE7, 0x1D, 0xC3, 0xB8, 0x77, 0x0E,
  0xE1, 0x9C, 0x73, 0x9E, 0x7F, 0xC7, 0xB8, 0x0E, 0x00, 0xC0, 0x1C, 0x01,
  0xC0, 0x1D, 0xC1, 0xBE, 0x1F, 0xE3, 0xC6, 0x38, 0x73, 0x86, 0x30, 0x67,
  0x0E, 0x70, 0xE7, 0x1C, 0x71, 0xC7, 0xF8, 0xEF, 0x00, 0x07, 0x0F, 0xCF,
  0xEE, 0x07, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x8F, 0xC7, 0xE0,
  0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x0C, 0xE1, 0xFE, 0x3F, 0xE7, 0x1C,
  0x71, 0xCE, 0x1C, 0xE1, 0xCE, 0x1C, 0xE1, 0x8E, 0x38, 0xE7, 0x8F, 0xF8,
  0x7B, 0x80, 0x07, 0x07, 0xE3, 0x9D, 0xC7, 0x61, 0xF8, 0xEF, 0xF3, 0xF0,
  0xE0, 0x38, 0x0E, 0x11, 0xFC, 0x3F, 0x00, 0x00, 0x30, 0x07, 0xC0, 0x7C,
  0x03, 0x80, 0x18, 0x01, 0xC0, 0x3F, 0x81, 0xFC, 0x03, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x00, 0x38, 0x01, 0xC0, 0x7C, 0x03, 0xE0, 0x04, 0x00, 0x07, 0x00,
  0xFF, 0x1F, 0xF3, 0x8E, 0x38, 0xE7, 0x0E, 0x70, 0xE7, 0x0E, 0x71, 0xC7,
  0x1C, 0x73, 0xC7, 0xFC, 0x3D, 0xC0, 0x18, 0x03, 0x88, 0x38, 0xFF, 0x0F,
  0xE0, 0x10, 0x00, 0x0E, 0x01, 0x80, 0x70, 0x0E, 0x01, 0xDC, 0x37, 0xC7,
  0xF9, 0xE3, 0x38, 0x67, 0x1C, 0xC3, 0xB8, 0x77, 0x0C, 0xE1, 0x9C, 0x73,
  0x0E, 0xE1, 0xC0, 0x0E, 0x3C, 0x30, 0x00, 0x43, 0x06, 0x1C, 0x38, 0x70,
  0xC3, 0x87, 0x0E, 0x1C, 0x30, 0xE0, 0x01, 0xC0, 0xF0, 0x18, 0x00, 0x00,
  0x00, 0xE0, 0x30, 0x1C, 0x07, 0x01, 0xC0, 0x60, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x30, 0x1C, 0x07, 0x01, 0xC0, 0x60, 0xF8, 0x3C, 0x04, 0x00, 0x0E,
  0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x11, 0x8E, 0x19, 0xC3, 0x9C, 0x3B,
  0x83, 0x70, 0x3F, 0x07, 0xF0, 0x77, 0x07, 0x38, 0x63, 0x86, 0x38, 0xE1,
  0xC0, 0x0E, 0x18, 0x70, 0xE1, 0xC3, 0x0E, 0x1C, 0x38, 0x70, 0xC3, 0x87,
  0x0E, 0x1C, 0x30, 0xE0, 0x01, 0xC3, 0x06, 0xFB, 0xE1, 0xFF, 0xF8, 0xF3,
  0xC7, 0x38, 0xE1, 0x8E, 0x38, 0x63, 0x0E, 0x39, 0xC3, 0x0E, 0x70, 0xC3,
  0x9C, 0x70, 0xC7, 0x1C, 0x71, 0x87, 0x1C, 0xE1, 0x87, 0x00, 0x01, 0xC3,
  0x7C, 0xFF, 0x9E, 0x33, 0x86, 0x71, 0xCC, 0x3B, 0x87, 0x70, 0xEE, 0x19,
  0xC7, 0x30, 0xEE, 0x1C, 0x06, 0x07, 0xE3, 0xFD, 0xC7, 0x61, 0xF8, 0x7E,
  0x1F, 0x87, 0xE1, 0xF8, 0xEE, 0x79, 0xFC, 0x3E, 0x00, 0x00, 0xE0, 0x6F,
  0x83, 0xFC, 0x3C, 0x61, 0xC3, 0x8E, 0x18, 0x60, 0xC7, 0x0E, 0x38, 0x71,
  0xC7, 0x0E, 0x38, 0x7F, 0x87, 0x78, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0x60,
  0x07, 0x00, 0x00, 0x0E, 0x03, 0xEC, 0xFF, 0xB8, 0xE7, 0x1D, 0xC3, 0xB8,
  0x77, 0x0E, 0xE1, 0x9C, 0x73, 0x9E, 0x7F, 0xC7, 0xB8, 0x06, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xC0, 0x18, 0x00, 0x01, 0xC6, 0xE1, 0xF8, 0xF0, 0x38,
  0x0E, 0x03, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0x80, 0xE0, 0x00, 0x0F,
  0x1F, 0xCE, 0x6E, 0x07, 0x01, 0xE0, 0xF8, 0x1E, 0x07, 0x03, 0xA1, 0xDF,
  0xCF, 0xC0, 0x18, 0x30, 0xE7, 0xFF, 0xEE, 0x1C, 0x38, 0x60, 0xC3, 0x87,
  0x0E, 0x1F, 0x1E, 0x00, 0x38, 0xEE, 0x1D, 0xC3, 0x38, 0x66, 0x1C, 0xC3,
  0xB8, 0x77, 0x1C, 0xE3, 0x9C, 0xF3, 0xFE, 0x3D, 0xC0, 0xE1, 0xFC, 0x3B,
  0x8E, 0x31, 0xC6, 0x70, 0xCE, 0x1B, 0x83, 0x70, 0x6C, 0x0F, 0x81, 0xE0,
  0x3C, 0x00, 0xE3, 0xC7, 0xE3, 0xC6, 0xE7, 0xCE, 0xE6, 0xCC, 0x66, 0xDC,
  0x6C, 0xDC, 0x6C, 0xD8, 0x7C, 0xF8, 0x78, 0xF0, 0x78, 0xF0, 0x70, 0xE0,
  0x70, 0xE0, 0x1C, 0x78, 0xE7, 0x03, 0x30, 0x1F, 0x80, 0xF8, 0x03, 0x80,
  0x3C, 0x03, 0xF0, 0x1B, 0x81, 0xCC, 0x1C, 0x71, 0xC3, 0x80, 0x1C, 0x3C,
  0x70, 0xE0, 0xC7, 0x03, 0x1C, 0x0C, 0xE0, 0x33, 0x80, 0xDC, 0x03, 0x70,
  0x0D, 0x80, 0x3E, 0x00, 0xF0, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0,
  0x3E, 0x00, 0xF8, 0x01, 0x00, 0x00, 0x1F, 0xE3, 0xF8, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x01, 0xFE, 0x7F, 0x80, 0x07,
  0x83, 0xC3, 0x81, 0xC0, 0xC0, 0x60, 0x70, 0x38, 0x78, 0x70, 0x3C, 0x07,
  0x03, 0x81, 0xC0, 0xC0, 0x60, 0x70, 0x3E, 0x0E, 0x01, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x0F, 0x01, 0xC0, 0xC0, 0x60, 0x70, 0x38,
  0x1C, 0x0F, 0x01, 0xC3, 0xC3, 0x81, 0xC0, 0xC0, 0x60, 0x70, 0x38, 0x78,
  0x3C, 0x18, 0x00, 0x78, 0x3F, 0xFF, 0x3F, 0x40, 0xC0,
};

const GFXglyph NotoSans_SemiCondensed_SemiBoldItalic23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 7, 16, 6, 0, -16 },
  { 15, 8, 6, 9, 2, -16 },
  { 21, 14, 16, 13, 0, -16 },
  { 49, 12, 18, 12, 0, -17 },
  { 76, 16, 17, 18, 1, -17 },
  { 110, 14, 17, 14, 0, -17 },
  { 140, 4, 6, 5, 2, -16 },
  { 143, 8, 20, 7, 1, -16 },
  { 163, 8, 21, 7, -2, -17 },
  { 184, 10, 11, 11, 2, -18 },
  { 198, 11, 11, 12, 1, -14 },
  { 214, 5, 6, 6, -1, -3 },
  { 218, 6, 2, 7, 0, -7 },
  { 220, 4, 3, 6, 0, -3 },
  { 222, 12, 17, 9, -1, -17 },
  { 248, 10, 17, 12, 1, -17 },
  { 270, 8, 16, 12, 2, -16 },
  { 286, 12, 17, 12, -1, -17 },
  { 312, 11, 17, 12, 0, -17 },
  { 336, 11, 16, 12, 0, -16 },
  { 358, 12, 16, 12, 0, -16 },
  { 382, 11, 17, 12, 1, -17 },
  { 406, 11, 16, 12, 1, -16 },
  { 428, 12, 17, 12, 0, -17 },
  { 454, 10, 17, 12, 1, -17 },
  { 476, 6, 13, 6, 0, -13 },
  { 486, 7, 16, 6, -1, -13 },
  { 500, 11, 11, 12, 1, -14 },
  { 516, 10, 6, 12, 1, -11 },
  { 524, 11, 11, 12, 1, -14 },
  { 540, 9, 17, 9, 1, -17 },
  { 560, 16, 18, 18, 1, -16 },
  { 596, 12, 16, 13, -1, -16 },
  { 620, 13, 16, 13, 0, -16 },
  { 646, 13, 17, 12, 1, -17 },
  { 674, 13, 16, 14, 0, -16 },
  { 700, 12, 16, 11, 0, -16 },
  { 724, 12, 16, 11, 0, -16 },
  { 748, 13, 17, 14, 1, -17 },
  { 776, 15, 16, 14, 0, -16 },
  { 806, 10, 16, 8, -1, -16 },
  { 826, 11, 21, 6, -4, -16 },
  { 855, 14, 16, 12, 0, -16 },
  { 883, 9, 16, 10, 0, -16 },
  { 901, 19, 16, 18, 0, -16 },
  { 939, 16, 16, 15, 0, -16 },
  { 971, 13, 17, 15, 1, -17 },
  { 999, 13, 16, 12, 0, -16 },
  { 1025, 13, 21, 15, 1, -17 },
  { 1060, 12, 16, 13, 0, -16 },
  { 1084, 12, 17, 11, 0, -17 },
  { 1110, 11, 16, 11, 2, -16 },
  { 1132, 14, 16, 14, 1, -16 },
  { 1160, 12, 16, 12, 2, -16 },
  { 1184, 19, 16, 19, 2, -16 },
  { 1222, 15, 16, 12, -1, -16 },
  { 1252, 11, 16, 11, 2, -16 },
  { 1274, 13, 16, 11, -1, -16 },
  { 1300, 10, 20, 7, -1, -16 },
  { 1325, 5, 17, 9, 2, -17 },
  { 1336, 10, 20, 7, -2, -16 },
  { 1361, 11, 10, 12, 0, -16 },
  { 1375, 9, 2, 8, -2, 2 },
  { 1378, 5, 4, 7, 3, -18 },
  { 1381, 11, 13, 12, 1, -13 },
  { 1399, 12, 17, 12, 0, -17 },
  { 1425, 9, 13, 10, 1, -13 },
  { 1440, 12, 17, 12, 1, -17 },
  { 1466, 10, 13, 11, 1, -13 },
  { 1483, 13, 24, 7, -3, -18 },
  { 1522, 12, 19, 12, 0, -13 },
  { 1551, 11, 17, 12, 0, -17 },
  { 1575, 7, 17, 6, 0, -17 },
  { 1590, 10, 23, 6, -3, -17 },
  { 1619, 12, 17, 11, 0, -17 },
  { 1645, 7, 17, 6, 0, -17 },
  { 1660, 18, 13, 18, 0, -13 },
  { 1690, 11, 13, 12, 0, -13 },
  { 1708, 10, 13, 12, 1, -13 },
  { 1725, 13, 18, 12, -1, -13 },
  { 1755, 11, 19, 12, 1, -13 },
  { 1782, 10, 13, 9, 0, -13 },
  { 1799, 9, 13, 10, 0, -13 },
  { 1814, 7, 15, 8, 1, -15 },
  { 1828, 11, 12, 12, 1, -12 },
  { 1845, 11, 12, 10, 1, -12 },
  { 1862, 16, 12, 16, 1, -12 },
  { 1886, 13, 12, 11, -1, -12 },
  { 1906, 14, 18, 10, -2, -12 },
  { 1938, 11, 12, 9, -1, -12 },
  { 1955, 9, 20, 8, 0, -16 },
  { 1978, 2, 23, 11, 5, -18 },
  { 1984, 9, 20, 8, -1, -16 },
  { 2007, 11, 4, 12, 1, -10 },
};

const GFXfont NotoSans_SemiCondensed_SemiBoldItalic23pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_SemiBoldItalic23pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_SemiBoldItalic23pt7bGlyphs,
  0x20, 0x7E, 31
};

#endif // _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC23PT7B_H_
