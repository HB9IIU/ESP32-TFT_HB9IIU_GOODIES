#ifndef _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC12PT7B_H_
#define _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC12PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-SemiBoldItalic.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_SemiBoldItalic12pt7bBitmaps[] PROGMEM = {
  0x00, 0x32, 0x66, 0x44, 0x04, 0xC0, 0x5D, 0x9A, 0x16, 0x28, 0x53, 0xF2,
  0x85, 0x3F, 0x28, 0x50, 0x08, 0xF7, 0x1C, 0x30, 0x62, 0xBE, 0x20, 0x80,
  0x62, 0xE4, 0xA4, 0xA8, 0xB7, 0xDD, 0x29, 0x4A, 0xCE, 0x18, 0x78, 0x91,
  0x43, 0x0B, 0xF3, 0x66, 0x76, 0x5A, 0x13, 0x26, 0x44, 0xCC, 0xC4, 0x40,
  0x31, 0x11, 0x11, 0x13, 0x24, 0xC0, 0x37, 0x0F, 0xA5, 0x00, 0x21, 0x3E,
  0x42, 0x10, 0x6B, 0x00, 0xE0, 0x70, 0x06, 0x08, 0x20, 0xC1, 0x06, 0x08,
  0x30, 0xC0, 0x18, 0xF6, 0x53, 0x4F, 0x3C, 0xB6, 0x70, 0x13, 0xF3, 0x22,
  0x26, 0x60, 0x19, 0xF0, 0xC3, 0x18, 0xC6, 0x30, 0xF8, 0x19, 0xF0, 0xC3,
  0x30, 0x20, 0xA6, 0xF0, 0x0C, 0x31, 0x8A, 0x69, 0x6F, 0xC4, 0x10, 0x3C,
  0xF2, 0x18, 0x78, 0x20, 0xA6, 0xF0, 0x0C, 0xF2, 0x14, 0x79, 0x3C, 0x92,
  0x70, 0xFF, 0xC6, 0x23, 0x11, 0x18, 0x80, 0x18, 0xB6, 0x4B, 0x31, 0x2C,
  0xB2, 0x78, 0x19, 0xF4, 0xD3, 0x4D, 0xE0, 0x86, 0xF0, 0x2C, 0x00, 0xB0,
  0x13, 0x00, 0x00, 0x64, 0xC0, 0x1B, 0xB1, 0xC1, 0x84, 0xF8, 0x3F, 0xF0,
  0x83, 0x06, 0x6C, 0x40, 0x6F, 0x13, 0x6C, 0x08, 0x80, 0x06, 0x0C, 0x88,
  0x29, 0xD5, 0x2A, 0xA7, 0x54, 0xB4, 0x40, 0x1E, 0x00, 0x0C, 0x18, 0x70,
  0xA3, 0x67, 0xCF, 0xB3, 0xC6, 0x38, 0x78, 0x9B, 0x27, 0x89, 0x91, 0x26,
  0xF8, 0x19, 0xF4, 0x30, 0x82, 0x08, 0x32, 0x70, 0x38, 0x78, 0x9B, 0x36,
  0x68, 0xD1, 0x26, 0xF0, 0x3C, 0xF2, 0x18, 0x79, 0x04, 0x10, 0xF8, 0x3C,
  0xF2, 0x18, 0x79, 0xE4, 0x10, 0xC0, 0x1D, 0xF4, 0x30, 0x9E, 0x78, 0xF2,
  0x78, 0x33, 0x22, 0x22, 0x62, 0x7E, 0x46, 0x44, 0x44, 0xCC, 0x79, 0x88,
  0x42, 0x31, 0x88, 0xE0, 0x0C, 0x20, 0x86, 0x18, 0x61, 0x04, 0x30, 0xCE,
  0x00, 0x23, 0x26, 0x2C, 0x78, 0x70, 0x78, 0x58, 0x48, 0xCC, 0x21, 0x08,
  0xC6, 0x21, 0x08, 0xF8, 0x30, 0xCC, 0x63, 0x19, 0xCA, 0x73, 0x95, 0x65,
  0x51, 0x64, 0xD9, 0x00, 0x31, 0x31, 0x33, 0x7B, 0x7A, 0x4A, 0x4A, 0x4E,
  0xC4, 0x18, 0xFB, 0x16, 0x38, 0x50, 0xA3, 0x64, 0x70, 0x38, 0x78, 0x9B,
  0x36, 0xCF, 0x10, 0x20, 0xC0, 0x18, 0xFB, 0x16, 0x38, 0x50, 0xA3, 0x6C,
  0x70, 0x20, 0x60, 0x38, 0xF2, 0x59, 0x7D, 0xE5, 0x92, 0xCC, 0x18, 0xF6,
  0x18, 0x30, 0x61, 0xA6, 0xF0, 0xFF, 0xE2, 0x08, 0x61, 0x84, 0x10, 0xC0,
  0x46, 0x89, 0x16, 0x6C, 0xD1, 0xA2, 0x4C, 0xF0, 0xC7, 0x3C, 0xB6, 0xD3,
  0x4E, 0x18, 0x40, 0xCC, 0xF3, 0x2D, 0xDB, 0x74, 0xDD, 0x2B, 0xCA, 0xE3,
  0x38, 0xCC, 0x00, 0x33, 0x12, 0x16, 0x1C, 0x18, 0x18, 0x3C, 0x64, 0xC6,
  0xCF, 0x25, 0x94, 0x61, 0x84, 0x10, 0xC0, 0x3D, 0xF0, 0x86, 0x30, 0x86,
  0x30, 0xF8, 0x39, 0x08, 0xC4, 0x21, 0x18, 0xC5, 0x30, 0xD9, 0x24, 0x93,
  0x60, 0x38, 0xC4, 0x21, 0x08, 0xC4, 0x21, 0x38, 0x10, 0x42, 0x9A, 0x4B,
  0x10, 0xF8, 0x90, 0x15, 0xF4, 0xD3, 0xCB, 0x66, 0x80, 0x20, 0x82, 0x9F,
  0x65, 0x34, 0xF2, 0xB8, 0x1B, 0xD0, 0x8C, 0x25, 0xC0, 0x06, 0x08, 0x53,
  0xE4, 0xC9, 0xB2, 0x6C, 0x68, 0x19, 0xB4, 0xDE, 0xC1, 0x07, 0x80, 0x1C,
  0x41, 0x8E, 0x30, 0xC2, 0x08, 0x61, 0x84, 0x30, 0x15, 0xF4, 0xD3, 0xCB,
  0x66, 0x86, 0x93, 0xC0, 0x20, 0x82, 0x9F, 0x6D, 0x34, 0xF2, 0xC8, 0x24,
  0xB6, 0x96, 0xC0, 0x08, 0x42, 0x31, 0x88, 0x46, 0x31, 0x09, 0xC0, 0x20,
  0x82, 0x5A, 0x59, 0xC5, 0x36, 0xD8, 0x32, 0x26, 0x64, 0x4C, 0xC0, 0x29,
  0x3F, 0xDB, 0x29, 0x94, 0x9E, 0x4B, 0x64, 0x29, 0xF6, 0xD3, 0x4F, 0x2C,
  0x80, 0x11, 0xF4, 0xD3, 0xCD, 0x27, 0x00, 0x29, 0xF6, 0x53, 0x4F, 0x2F,
  0xA0, 0x82, 0x00, 0x15, 0xF4, 0xD3, 0xCB, 0x66, 0x86, 0x18, 0x40, 0x2B,
  0xD8, 0x84, 0x63, 0x00, 0x33, 0xD0, 0xE3, 0x4B, 0xC0, 0x4F, 0xE9, 0x26,
  0xCE, 0x67, 0x39, 0x5B, 0x40, 0x8C, 0xE5, 0x6A, 0x73, 0x00, 0x99, 0x9B,
  0xAA, 0xBE, 0xDC, 0xDC, 0xD8, 0x26, 0x68, 0x70, 0xC3, 0x85, 0x33, 0x00,
  0x22, 0x4C, 0x91, 0x62, 0x87, 0x0C, 0x18, 0x61, 0x80, 0x7B, 0xC4, 0x46,
  0x63, 0xC0, 0x09, 0xC8, 0x42, 0x61, 0x08, 0x42, 0x18, 0xFF, 0xFF, 0xFF,
  0x21, 0x84, 0x21, 0x0C, 0xC4, 0x23, 0x30, 0xEC, 0x80,
};

const GFXglyph NotoSans_SemiCondensed_SemiBoldItalic12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 4, 9, 3, 0, -9 },
  { 6, 4, 4, 5, 1, -9 },
  { 8, 7, 9, 7, 0, -9 },
  { 16, 6, 10, 6, 0, -9 },
  { 24, 8, 9, 9, 1, -9 },
  { 33, 7, 9, 7, 0, -9 },
  { 41, 2, 4, 3, 1, -9 },
  { 42, 4, 11, 4, 0, -9 },
  { 48, 4, 11, 4, -1, -9 },
  { 54, 5, 5, 6, 1, -9 },
  { 58, 5, 6, 6, 1, -7 },
  { 62, 3, 3, 3, -1, -1 },
  { 64, 3, 1, 4, 0, -4 },
  { 65, 2, 2, 3, 0, -2 },
  { 66, 7, 9, 5, -1, -9 },
  { 74, 6, 9, 6, 0, -9 },
  { 81, 4, 9, 6, 1, -9 },
  { 86, 6, 9, 6, 0, -9 },
  { 93, 6, 9, 6, 0, -9 },
  { 100, 6, 9, 6, 0, -9 },
  { 107, 6, 9, 6, 0, -9 },
  { 114, 6, 9, 6, 0, -9 },
  { 121, 5, 9, 6, 1, -9 },
  { 127, 6, 9, 6, 0, -9 },
  { 134, 6, 9, 6, 0, -9 },
  { 141, 3, 7, 3, 0, -7 },
  { 144, 4, 9, 3, -1, -7 },
  { 149, 5, 6, 6, 1, -7 },
  { 153, 5, 4, 6, 1, -6 },
  { 156, 5, 6, 6, 1, -7 },
  { 160, 4, 9, 5, 1, -9 },
  { 165, 9, 10, 9, 0, -9 },
  { 177, 7, 9, 7, -1, -9 },
  { 185, 7, 9, 7, 0, -9 },
  { 193, 6, 9, 6, 1, -9 },
  { 200, 7, 9, 7, 0, -9 },
  { 208, 6, 9, 6, 0, -9 },
  { 215, 6, 9, 6, 0, -9 },
  { 222, 6, 9, 7, 1, -9 },
  { 229, 8, 9, 8, 0, -9 },
  { 238, 5, 9, 4, 0, -9 },
  { 244, 6, 11, 3, -2, -9 },
  { 253, 8, 9, 6, 0, -9 },
  { 262, 5, 9, 5, 0, -9 },
  { 268, 10, 9, 10, 0, -9 },
  { 280, 8, 9, 8, 0, -9 },
  { 289, 7, 9, 8, 1, -9 },
  { 297, 7, 9, 6, 0, -9 },
  { 305, 7, 11, 8, 1, -9 },
  { 315, 6, 9, 7, 0, -9 },
  { 322, 6, 9, 6, 0, -9 },
  { 329, 6, 9, 6, 1, -9 },
  { 336, 7, 9, 7, 1, -9 },
  { 344, 6, 9, 6, 1, -9 },
  { 351, 10, 9, 10, 1, -9 },
  { 363, 8, 9, 6, -1, -9 },
  { 372, 6, 9, 6, 1, -9 },
  { 379, 6, 9, 6, 0, -9 },
  { 386, 5, 11, 4, 0, -9 },
  { 393, 3, 9, 5, 1, -9 },
  { 397, 5, 11, 4, -1, -9 },
  { 404, 6, 6, 6, 0, -9 },
  { 409, 5, 1, 4, -1, 1 },
  { 410, 2, 2, 4, 2, -9 },
  { 411, 6, 7, 6, 0, -7 },
  { 417, 6, 9, 6, 0, -9 },
  { 424, 5, 7, 5, 0, -7 },
  { 429, 7, 9, 6, 0, -9 },
  { 437, 6, 7, 6, 0, -7 },
  { 443, 6, 12, 4, -1, -9 },
  { 452, 6, 10, 6, 0, -7 },
  { 460, 6, 9, 6, 0, -9 },
  { 467, 3, 9, 3, 0, -9 },
  { 471, 5, 12, 3, -2, -9 },
  { 479, 6, 9, 6, 0, -9 },
  { 486, 4, 9, 3, 0, -9 },
  { 491, 9, 7, 10, 0, -7 },
  { 499, 6, 7, 6, 0, -7 },
  { 505, 6, 7, 6, 0, -7 },
  { 511, 6, 10, 6, 0, -7 },
  { 519, 6, 10, 6, 0, -7 },
  { 527, 5, 7, 4, 0, -7 },
  { 532, 5, 7, 5, 0, -7 },
  { 537, 3, 8, 4, 1, -8 },
  { 540, 5, 7, 6, 1, -7 },
  { 545, 5, 7, 5, 1, -7 },
  { 550, 8, 7, 8, 1, -7 },
  { 557, 7, 7, 6, -1, -7 },
  { 564, 7, 10, 5, -1, -7 },
  { 573, 5, 7, 5, 0, -7 },
  { 578, 5, 11, 4, 0, -9 },
  { 585, 2, 12, 6, 2, -9 },
  { 588, 5, 11, 4, -1, -9 },
  { 595, 5, 2, 6, 1, -5 },
};

const GFXfont NotoSans_SemiCondensed_SemiBoldItalic12pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_SemiBoldItalic12pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_SemiBoldItalic12pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC12PT7B_H_
