#ifndef _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC7PT7B_H_
#define _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC7PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-SemiBoldItalic.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_SemiBoldItalic7pt7bBitmaps[] PROGMEM = {
  0x00, 0x56, 0x80, 0xF0, 0x37, 0x6F, 0xA0, 0x74, 0x66, 0xC0, 0x6D, 0xBE,
  0x75, 0x80, 0x66, 0x5B, 0xF0, 0xC0, 0x6A, 0x49, 0x00, 0x24, 0x95, 0x80,
  0xDF, 0x00, 0x4F, 0x40, 0xC0, 0xC0, 0x80, 0x29, 0x48, 0x6E, 0xDE, 0x76,
  0x80, 0x64, 0xAE, 0x65, 0x1E, 0x2D, 0xF2, 0x74, 0x62, 0xE0, 0x74, 0xEA,
  0xE0, 0x72, 0x24, 0xC0, 0x65, 0x6A, 0xE0, 0x75, 0x9C, 0x42, 0x42, 0x80,
  0x3C, 0x30, 0xFF, 0xC3, 0xC0, 0x65, 0x08, 0x3B, 0xF7, 0xF8, 0x38, 0x2D,
  0xFA, 0x75, 0x69, 0xE0, 0x74, 0x88, 0x60, 0x75, 0x59, 0xE0, 0x74, 0x68,
  0xE0, 0x74, 0x68, 0x80, 0x74, 0xB9, 0x70, 0x55, 0x79, 0x90, 0x69, 0x2C,
  0x24, 0xA5, 0x80, 0x56, 0x6A, 0xA0, 0x49, 0x4E, 0x4D, 0x25, 0xAA, 0xA8,
  0x4B, 0x5D, 0x69, 0x00, 0x75, 0x99, 0x60, 0x75, 0x68, 0x80, 0x75, 0x99,
  0x63, 0x75, 0x6A, 0xA0, 0x74, 0x62, 0xE0, 0xF2, 0x48, 0x55, 0x59, 0x60,
  0xB7, 0x68, 0xAF, 0x7D, 0x6A, 0x00, 0x56, 0x46, 0xA0, 0xBA, 0x48, 0x72,
  0x44, 0xE0, 0x6A, 0x49, 0x00, 0xF8, 0x55, 0xA0, 0x2E, 0x80, 0xE0, 0x80,
  0x7A, 0xAE, 0x46, 0x5A, 0xE0, 0x72, 0x70, 0x17, 0xAA, 0xE0, 0x77, 0x70,
  0x37, 0x24, 0x44, 0x80, 0x7A, 0xAE, 0x2C, 0x4D, 0xDA, 0x56, 0x80, 0x24,
  0xA4, 0xA0, 0x47, 0x6A, 0xA0, 0x56, 0x80, 0x6B, 0xEB, 0x50, 0x6E, 0xD0,
  0x76, 0xF0, 0x65, 0xAE, 0x88, 0x7A, 0xAE, 0x22, 0x6A, 0x40, 0x71, 0x60,
  0x5D, 0x4C, 0x5A, 0xAE, 0xBA, 0xC4, 0xAD, 0x75, 0xA0, 0x76, 0x4A, 0x5A,
  0x98, 0x44, 0x60, 0x69, 0x60, 0x69, 0x49, 0x80, 0xFE, 0x55, 0xA0, 0xF0,
};

const GFXglyph NotoSans_SemiCondensed_SemiBoldItalic7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 5, 2, 0, -5 },
  { 3, 2, 2, 3, 1, -5 },
  { 4, 4, 5, 4, 0, -5 },
  { 7, 4, 5, 4, 0, -5 },
  { 10, 5, 5, 5, 0, -5 },
  { 14, 4, 5, 4, 0, -5 },
  { 17, 1, 2, 2, 1, -5 },
  { 18, 3, 6, 2, 0, -5 },
  { 21, 3, 6, 2, -1, -5 },
  { 24, 3, 3, 3, 1, -5 },
  { 26, 4, 3, 4, 0, -4 },
  { 28, 1, 2, 2, 0, -1 },
  { 29, 2, 1, 2, 0, -2 },
  { 30, 1, 1, 2, 0, -1 },
  { 31, 3, 5, 3, 0, -5 },
  { 33, 3, 5, 4, 0, -5 },
  { 35, 2, 5, 4, 1, -5 },
  { 37, 3, 5, 4, 0, -5 },
  { 39, 3, 5, 4, 0, -5 },
  { 41, 3, 5, 4, 0, -5 },
  { 43, 4, 5, 4, 0, -5 },
  { 46, 4, 5, 4, 0, -5 },
  { 49, 4, 5, 4, 0, -5 },
  { 52, 4, 5, 4, 0, -5 },
  { 55, 3, 5, 4, 0, -5 },
  { 57, 2, 4, 2, 0, -4 },
  { 58, 2, 5, 2, 0, -4 },
  { 60, 4, 3, 4, 0, -4 },
  { 62, 4, 2, 4, 0, -3 },
  { 63, 4, 3, 4, 0, -4 },
  { 65, 3, 5, 3, 0, -5 },
  { 67, 5, 6, 5, 0, -5 },
  { 71, 3, 5, 4, 0, -5 },
  { 73, 4, 5, 4, 0, -5 },
  { 76, 4, 5, 4, 0, -5 },
  { 79, 4, 5, 4, 0, -5 },
  { 82, 4, 5, 3, 0, -5 },
  { 85, 4, 5, 3, 0, -5 },
  { 88, 4, 5, 4, 0, -5 },
  { 91, 4, 5, 4, 0, -5 },
  { 94, 3, 5, 2, 0, -5 },
  { 96, 3, 6, 2, -1, -5 },
  { 99, 4, 5, 4, 0, -5 },
  { 102, 3, 5, 3, 0, -5 },
  { 104, 6, 5, 6, 0, -5 },
  { 108, 5, 5, 5, 0, -5 },
  { 112, 4, 5, 5, 0, -5 },
  { 115, 4, 5, 4, 0, -5 },
  { 118, 4, 6, 5, 0, -5 },
  { 121, 4, 5, 4, 0, -5 },
  { 124, 4, 5, 3, 0, -5 },
  { 127, 3, 5, 3, 1, -5 },
  { 129, 4, 5, 4, 0, -5 },
  { 132, 3, 5, 4, 1, -5 },
  { 134, 5, 5, 6, 1, -5 },
  { 138, 4, 5, 4, 0, -5 },
  { 141, 3, 5, 3, 1, -5 },
  { 143, 4, 5, 3, 0, -5 },
  { 146, 3, 6, 2, 0, -5 },
  { 149, 1, 5, 3, 1, -5 },
  { 150, 2, 6, 2, 0, -5 },
  { 152, 3, 3, 4, 0, -5 },
  { 154, 3, 1, 3, -1, 0 },
  { 155, 1, 1, 2, 1, -5 },
  { 156, 4, 4, 4, 0, -4 },
  { 158, 4, 5, 4, 0, -5 },
  { 161, 3, 4, 3, 0, -4 },
  { 163, 4, 5, 4, 0, -5 },
  { 166, 3, 4, 3, 0, -4 },
  { 168, 4, 7, 2, -1, -5 },
  { 172, 4, 6, 4, 0, -4 },
  { 175, 3, 5, 4, 0, -5 },
  { 177, 2, 5, 2, 0, -5 },
  { 179, 3, 7, 2, -1, -5 },
  { 182, 4, 5, 3, 0, -5 },
  { 185, 2, 5, 2, 0, -5 },
  { 187, 5, 4, 6, 0, -4 },
  { 190, 3, 4, 4, 0, -4 },
  { 192, 3, 4, 4, 0, -4 },
  { 194, 4, 6, 4, 0, -4 },
  { 197, 4, 6, 4, 0, -4 },
  { 200, 3, 4, 3, 0, -4 },
  { 202, 3, 4, 3, 0, -4 },
  { 204, 3, 5, 2, 0, -5 },
  { 206, 4, 4, 4, 0, -4 },
  { 208, 4, 4, 3, 0, -4 },
  { 210, 5, 4, 5, 0, -4 },
  { 213, 4, 4, 3, 0, -4 },
  { 215, 5, 6, 3, -1, -4 },
  { 219, 3, 4, 3, 0, -4 },
  { 221, 3, 6, 2, 0, -5 },
  { 224, 1, 7, 3, 1, -5 },
  { 225, 2, 6, 2, 0, -5 },
  { 227, 4, 1, 4, 0, -3 },
};

const GFXfont NotoSans_SemiCondensed_SemiBoldItalic7pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_SemiBoldItalic7pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_SemiBoldItalic7pt7bGlyphs,
  0x20, 0x7E, 10
};

#endif // _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC7PT7B_H_
