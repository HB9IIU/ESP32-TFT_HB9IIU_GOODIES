#ifndef _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC52PT7B_H_
#define _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC52PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-SemiBoldItalic.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_SemiBoldItalic52pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x3F, 0x80, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0x80, 0xFC, 0x00, 0xC0, 0x00, 0x3F, 0x1F, 0xCF, 0xC7,
  0xE3, 0xE1, 0xF8, 0xF8, 0x7E, 0x7E, 0x1F, 0x1F, 0x87, 0xC7, 0xC1, 0xF1,
  0xF0, 0xFC, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0x83, 0xE3, 0xE0, 0xF0, 0xF8,
  0x3C, 0x00, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0xF8,
  0x3E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x7C, 0x1F,
  0x00, 0x01, 0xF0, 0x78, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x3E, 0x0F, 0x80,
  0x00, 0xF8, 0x3E, 0x01, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x80, 0x3E,
  0x0F, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1F, 0x07,
  0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x07, 0x83, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x0F,
  0x83, 0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0xF8, 0x3C, 0x00, 0x03, 0xC1,
  0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x1E, 0x00, 0x01, 0xE0, 0x78,
  0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x81, 0xFC, 0xE3, 0x80, 0xFC, 0x70, 0x40, 0xFC,
  0x70, 0x00, 0x7E, 0x38, 0x00, 0x3F, 0x1C, 0x00, 0x1F, 0x8E, 0x00, 0x0F,
  0xE7, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00,
  0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xFC, 0x00, 0x0E, 0xFE, 0x00, 0x0E, 0x3F, 0x00, 0x07, 0x1F,
  0x80, 0x03, 0x8F, 0xC0, 0x01, 0xC7, 0xE3, 0x00, 0xE7, 0xF1, 0xE0, 0xE3,
  0xF0, 0xFF, 0x7F, 0xF8, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF8, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x03, 0xE0, 0x1F, 0xF8, 0x00,
  0xF8, 0x07, 0xFF, 0x00, 0x1F, 0x01, 0xFF, 0xF0, 0x07, 0xC0, 0x3E, 0x3E,
  0x01, 0xF0, 0x0F, 0x87, 0xC0, 0x3E, 0x01, 0xF0, 0xF8, 0x0F, 0x80, 0x7C,
  0x1F, 0x03, 0xE0, 0x0F, 0x83, 0xE0, 0x7C, 0x01, 0xF0, 0x7C, 0x1F, 0x00,
  0x3E, 0x0F, 0x87, 0xC0, 0x0F, 0x81, 0xF0, 0xF8, 0x01, 0xF0, 0x7C, 0x3E,
  0x00, 0x3E, 0x0F, 0x8F, 0x80, 0x07, 0xC1, 0xF1, 0xF0, 0xF0, 0xF8, 0x7C,
  0x7C, 0x7F, 0x9F, 0x0F, 0x9F, 0x1F, 0xFB, 0xE3, 0xF3, 0xE7, 0xFF, 0xBF,
  0xFC, 0xF9, 0xFF, 0xF7, 0xFF, 0x3E, 0x3E, 0x3E, 0xFF, 0xC7, 0xCF, 0x87,
  0xCF, 0xF1, 0xF1, 0xF0, 0xF8, 0x30, 0x7C, 0x7E, 0x1F, 0x00, 0x0F, 0x8F,
  0x83, 0xE0, 0x03, 0xE1, 0xF0, 0x7C, 0x00, 0xF8, 0x3E, 0x0F, 0x80, 0x1F,
  0x07, 0xC1, 0xF0, 0x07, 0xC1, 0xF0, 0x3E, 0x01, 0xF0, 0x3E, 0x0F, 0x80,
  0x3E, 0x07, 0xC1, 0xF0, 0x0F, 0x80, 0xF8, 0x3E, 0x03, 0xE0, 0x1F, 0x0F,
  0x80, 0x7C, 0x03, 0xF3, 0xF0, 0x1F, 0x00, 0x3F, 0xFC, 0x07, 0xC0, 0x07,
  0xFF, 0x00, 0xF8, 0x00, 0x7F, 0xC0, 0x3E, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x0F, 0xC1,
  0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x07, 0xE0, 0x7C,
  0x00, 0x1F, 0x83, 0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xF8, 0x7E, 0x00,
  0x07, 0xE3, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0xE0, 0x3F, 0x0F, 0xFF, 0x80, 0xFC, 0x7F, 0xFF, 0x07, 0xE3, 0xFC, 0xFC,
  0x1F, 0x8F, 0xE3, 0xF8, 0xFC, 0x7F, 0x07, 0xF3, 0xF1, 0xF8, 0x1F, 0xDF,
  0x8F, 0xE0, 0x3F, 0xFE, 0x3F, 0x00, 0x7F, 0xF0, 0xFC, 0x01, 0xFF, 0x83,
  0xF0, 0x03, 0xFE, 0x0F, 0xE0, 0x0F, 0xF0, 0x3F, 0x80, 0x7F, 0xC0, 0xFF,
  0x03, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF7, 0xF0, 0x1F, 0xFF, 0x8F, 0xE0, 0x3F, 0xF8, 0x3F, 0xC0, 0x04, 0x00,
  0x00, 0x00, 0x3F, 0x3F, 0x3F, 0x3E, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0x7C,
  0x78, 0xF8, 0xF8, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0,
  0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x03,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0,
  0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03,
  0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C,
  0x01, 0x81, 0xF0, 0x07, 0x87, 0xC0, 0x1F, 0x9F, 0x00, 0xFF, 0x78, 0x03,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x0F,
  0xF3, 0xF0, 0x7F, 0xC0, 0x03, 0xFF, 0x80, 0x1F, 0xBE, 0x00, 0xFC, 0x7C,
  0x07, 0xF1, 0xF0, 0x0F, 0x87, 0xE0, 0x1C, 0x0F, 0x80, 0x20, 0x3F, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0xFC, 0x0F, 0xC1, 0xF8,
  0x1F, 0x81, 0xF0, 0x3F, 0x03, 0xE0, 0x7E, 0x07, 0xC0, 0xFC, 0x00, 0x7F,
  0xFD, 0xFF, 0xE7, 0xFF, 0xBF, 0xFE, 0xFF, 0xFB, 0xFF, 0xE0, 0x7D, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x10, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFC, 0x01, 0xFF,
  0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xE0, 0x7E, 0x0F, 0xE0,
  0x7F, 0x1F, 0xC0, 0x7F, 0x1F, 0xC0, 0x3F, 0x1F, 0x80, 0x3F, 0x3F, 0x80,
  0x7F, 0x3F, 0x00, 0x7F, 0x3F, 0x00, 0x7F, 0x7F, 0x00, 0x7E, 0x7E, 0x00,
  0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFE, 0x00,
  0xFE, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x01,
  0xFC, 0xFC, 0x01, 0xFC, 0xFC, 0x01, 0xF8, 0xFC, 0x03, 0xF8, 0xFC, 0x03,
  0xF0, 0xFC, 0x07, 0xF0, 0xFC, 0x07, 0xF0, 0xFE, 0x0F, 0xE0, 0xFE, 0x1F,
  0xC0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0xC0,
  0x3F, 0xC0, 0x3F, 0xE0, 0x7F, 0xF0, 0x7F, 0xF8, 0xFF, 0xFC, 0xFF, 0xFC,
  0xFF, 0x7E, 0x7F, 0x3F, 0x1F, 0x1F, 0x8E, 0x1F, 0xC2, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F,
  0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0x7E,
  0x07, 0xF0, 0x07, 0x00, 0x7E, 0x00, 0x40, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x02, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1E, 0x03, 0xFC, 0x02, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x43, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0xC2, 0x00, 0x0F, 0xF0, 0xF0, 0x07, 0xF8, 0x3F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0x7C, 0x00, 0x07, 0xFF, 0x00,
  0x03, 0xEF, 0xC0, 0x01, 0xF3, 0xE0, 0x00, 0xFD, 0xF8, 0x00, 0x7E, 0x7E,
  0x00, 0x1F, 0x1F, 0x80, 0x0F, 0x87, 0xE0, 0x07, 0xE3, 0xF0, 0x03, 0xF0,
  0xFC, 0x00, 0xF8, 0x3F, 0x00, 0x7C, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x1F,
  0x81, 0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x81, 0xF8, 0x07, 0xE0,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0x80, 0xFF, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xC2, 0x00, 0x1F, 0xE1, 0xC0, 0x3F, 0xE0, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x07,
  0xFF, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x07, 0xFF,
  0xF8, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x3E, 0x00, 0x7E, 0x7F, 0xC0, 0x3F, 0x7F, 0xF0, 0x3F,
  0x7F, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xFC, 0x7F, 0x87, 0xF8, 0x1F, 0xC3,
  0xF8, 0x07, 0xE3, 0xF8, 0x03, 0xF1, 0xFC, 0x01, 0xF8, 0xFE, 0x00, 0xFC,
  0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x3F, 0x8F, 0xC0, 0x1F,
  0x87, 0xE0, 0x0F, 0xC3, 0xF8, 0x0F, 0xE0, 0xFC, 0x0F, 0xE0, 0x7F, 0x0F,
  0xF0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x01, 0xFF,
  0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF0, 0x1F, 0xE3, 0xFC, 0x0F, 0xC0, 0xFE, 0x0F, 0xE0, 0x3F, 0x07, 0xE0,
  0x1F, 0x83, 0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x7E,
  0x03, 0xF0, 0x3F, 0x83, 0xF8, 0x0F, 0xE3, 0xF8, 0x07, 0xFF, 0xF8, 0x01,
  0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF8, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xBF, 0x80, 0x7F, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x7F, 0x01, 0xFC, 0x3F, 0x00, 0x7E, 0x3F, 0x80, 0x3F, 0x1F, 0x80, 0x1F,
  0x8F, 0xC0, 0x0F, 0xC7, 0xE0, 0x07, 0xE3, 0xF0, 0x03, 0xF1, 0xFC, 0x03,
  0xF8, 0xFF, 0x03, 0xF8, 0x3F, 0xE7, 0xFC, 0x1F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x03,
  0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xF0, 0x7F, 0x0F, 0xE0, 0x3F, 0x0F,
  0xC0, 0x3F, 0x1F, 0xC0, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x1F,
  0x80, 0x3F, 0x3F, 0x80, 0x3F, 0x3F, 0x80, 0x3F, 0x3F, 0x80, 0x7F, 0x3F,
  0x80, 0x7F, 0x3F, 0x80, 0xFF, 0x1F, 0xC1, 0xFF, 0x1F, 0xF7, 0xFE, 0x1F,
  0xFF, 0xFE, 0x0F, 0xFF, 0x7E, 0x0F, 0xFF, 0x7E, 0x03, 0xFC, 0xFC, 0x00,
  0xE0, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x80,
  0x3F, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF,
  0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x02, 0x00, 0x00, 0x00, 0xE0, 0x1F, 0x80,
  0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xF8, 0x1F, 0xC0, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x0F, 0xE0, 0x7F,
  0x07, 0xF8, 0x3F, 0xC0, 0xFE, 0x07, 0xE0, 0x08, 0x00, 0x00, 0x1C, 0x00,
  0x7E, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x07, 0xE0, 0x0F,
  0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x78, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC,
  0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x04,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80,
  0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xC0, 0x00, 0x7C, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xE3,
  0xFF, 0xFE, 0x1C, 0x07, 0xE1, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xF8, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x7E, 0x00,
  0x00, 0x3E, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x3E, 0x00, 0x00, 0x07, 0xC3,
  0xE0, 0x1F, 0xF8, 0x3E, 0x1F, 0x01, 0xFF, 0xE0, 0xF1, 0xF0, 0x3F, 0xFF,
  0x07, 0x8F, 0x03, 0xFF, 0xF8, 0x3C, 0xF8, 0x3F, 0x07, 0xC1, 0xE7, 0xC1,
  0xF0, 0x3C, 0x0F, 0x7C, 0x1F, 0x03, 0xE0, 0x7B, 0xE0, 0xF8, 0x1F, 0x03,
  0xDF, 0x0F, 0x80, 0xF8, 0x3E, 0xF0, 0x7C, 0x07, 0x81, 0xFF, 0x83, 0xC0,
  0x7C, 0x0F, 0xFC, 0x3E, 0x03, 0xE0, 0x7B, 0xE1, 0xF0, 0x1F, 0x07, 0xDF,
  0x0F, 0x81, 0xF0, 0x3E, 0xF8, 0x7C, 0x0F, 0x83, 0xE7, 0xC3, 0xE0, 0xFC,
  0x1F, 0x3E, 0x1F, 0x07, 0xE1, 0xF1, 0xF0, 0x7F, 0xFF, 0xBF, 0x0F, 0x83,
  0xFF, 0x3F, 0xF0, 0x7C, 0x0F, 0xF9, 0xFF, 0x01, 0xE0, 0x3F, 0x07, 0xF0,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x80, 0x01,
  0xFC, 0x00, 0x1C, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F,
  0xFC, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3F, 0x7C, 0x00, 0x03, 0xE7, 0xC0,
  0x00, 0x7E, 0x7C, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0xFC, 0x7C, 0x00, 0x0F,
  0xC7, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF0, 0x7E,
  0x00, 0x3F, 0x07, 0xE0, 0x07, 0xF0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x0F,
  0xE0, 0x7E, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0xC0, 0x7E, 0x01, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xF0, 0x7E, 0x00, 0x3F, 0x0F, 0xE0, 0x03, 0xF0, 0xFC, 0x00,
  0x3F, 0x1F, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x3F, 0x80, 0x03, 0xF3,
  0xF0, 0x00, 0x3F, 0x7F, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F, 0xFE, 0x00,
  0x03, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0x81, 0xFE, 0x03,
  0xF8, 0x0F, 0xF0, 0x3F, 0x00, 0x7F, 0x03, 0xF0, 0x07, 0xF0, 0x3F, 0x00,
  0x7F, 0x03, 0xF0, 0x07, 0xE0, 0x7F, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xE0,
  0x7E, 0x01, 0xFC, 0x07, 0xE0, 0x3F, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0,
  0x1F, 0xC0, 0xFF, 0x01, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x3F, 0x81, 0xF8,
  0x01, 0xF8, 0x1F, 0x80, 0x1F, 0x83, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x1F,
  0x83, 0xF0, 0x03, 0xF8, 0x3F, 0x00, 0x3F, 0x83, 0xF0, 0x07, 0xF0, 0x7F,
  0x00, 0xFF, 0x07, 0xE0, 0x3F, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFE, 0x03,
  0xC0, 0x7F, 0x80, 0x08, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x80, 0x7F, 0xC0, 0x70, 0x03, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00,
  0xFC, 0x1F, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x00, 0xFF, 0x03, 0xF0,
  0x03, 0xF8, 0x1F, 0x80, 0x1F, 0xC0, 0xFC, 0x00, 0x7E, 0x0F, 0xE0, 0x03,
  0xF0, 0x7F, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xE0,
  0xFC, 0x00, 0x3F, 0x0F, 0xE0, 0x01, 0xF8, 0x7F, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0xFE, 0x1F, 0x80, 0x07, 0xF1, 0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x01,
  0xF8, 0x7E, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0xFE, 0x1F, 0x80, 0x0F, 0xE1,
  0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0x7E, 0x00, 0x7F, 0x83, 0xF0,
  0x07, 0xF8, 0x1F, 0x80, 0x7F, 0xC1, 0xFC, 0x07, 0xFC, 0x0F, 0xE7, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0x80, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xE0, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x80, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x0F, 0xFC, 0x07, 0xC0,
  0xFF, 0x80, 0x04, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x7F, 0xF9, 0xFC, 0x03, 0xFF, 0xCF, 0xE0,
  0x1F, 0xFE, 0x7F, 0x01, 0xFF, 0xE3, 0xF0, 0x0F, 0xFF, 0x1F, 0x80, 0x01,
  0xF8, 0xFC, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0xFE, 0x3F, 0x00, 0x07, 0xE1,
  0xFC, 0x00, 0x3F, 0x0F, 0xE0, 0x01, 0xF8, 0x7F, 0x00, 0x1F, 0xC1, 0xFC,
  0x00, 0xFE, 0x0F, 0xF0, 0x07, 0xE0, 0x7F, 0xC0, 0x7F, 0x01, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0xFC, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x7F,
  0x01, 0xF8, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x7E,
  0x03, 0xF8, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0xFC,
  0x03, 0xF0, 0x00, 0xFC, 0x07, 0xF0, 0x01, 0xFC, 0x07, 0xF0, 0x01, 0xFC,
  0x07, 0xE0, 0x01, 0xF8, 0x07, 0xE0, 0x01, 0xF8, 0x07, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x1F, 0xC0, 0x07, 0xF0,
  0x1F, 0x80, 0x07, 0xF0, 0x1F, 0x80, 0x07, 0xE0, 0x1F, 0x80, 0x07, 0xE0,
  0x3F, 0x80, 0x0F, 0xE0, 0x3F, 0x80, 0x0F, 0xE0, 0x3F, 0x00, 0x0F, 0xC0,
  0x3F, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x1F, 0xC0,
  0x7F, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x1F, 0x80,
  0x7E, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x3F, 0x80,
  0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0,
  0x03, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0xFF,
  0xFE, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF,
  0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0xFF, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x01,
  0xF8, 0x07, 0xF8, 0x01, 0xF8, 0x07, 0xF0, 0x01, 0xF8, 0x0F, 0xE0, 0x03,
  0xF8, 0x1F, 0xC0, 0x03, 0xF0, 0x3F, 0x80, 0x03, 0xF0, 0x7F, 0x80, 0x03,
  0xF0, 0x7F, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x07,
  0xE3, 0xF8, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x07,
  0xEF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x1F,
  0x87, 0xF0, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x3F,
  0x03, 0xF8, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x7F,
  0x01, 0xFC, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x7E,
  0x00, 0xFE, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0xFC,
  0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x3F,
  0xF0, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00,
  0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0x1F, 0xFC,
  0x03, 0xEF, 0x80, 0x0F, 0xBE, 0x01, 0xF7, 0xC0, 0x0F, 0xFF, 0x00, 0xFB,
  0xE0, 0x07, 0xDF, 0x80, 0xFD, 0xF0, 0x07, 0xEF, 0xC0, 0x7E, 0xF8, 0x03,
  0xE7, 0xC0, 0x3F, 0x7C, 0x03, 0xF7, 0xE0, 0x1F, 0xBE, 0x01, 0xF3, 0xF0,
  0x0F, 0x9F, 0x01, 0xF9, 0xF8, 0x0F, 0xCF, 0x80, 0xF8, 0xFC, 0x07, 0xE7,
  0xC0, 0xFC, 0xFC, 0x03, 0xF3, 0xE0, 0x7C, 0x7E, 0x01, 0xF1, 0xF8, 0x7E,
  0x3F, 0x01, 0xF8, 0xFC, 0x3E, 0x1F, 0x80, 0xFC, 0x3E, 0x1F, 0x0F, 0xC0,
  0x7E, 0x1F, 0x1F, 0x0F, 0xC0, 0x3F, 0x0F, 0x8F, 0x87, 0xE0, 0x1F, 0x07,
  0xCF, 0x83, 0xF0, 0x1F, 0x83, 0xE7, 0xC1, 0xF8, 0x0F, 0xC1, 0xF7, 0xC0,
  0xF8, 0x07, 0xE0, 0xFB, 0xE0, 0xFC, 0x03, 0xF0, 0x7F, 0xE0, 0x7E, 0x01,
  0xF0, 0x3F, 0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0xF0, 0x1F, 0x80, 0xFC, 0x0F,
  0xF8, 0x1F, 0x80, 0x7E, 0x07, 0xF8, 0x0F, 0xC0, 0x3F, 0x03, 0xFC, 0x07,
  0xE0, 0x1F, 0x01, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0xFE, 0x01, 0xF8, 0x0F,
  0xC0, 0x3E, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x7F, 0x80,
  0x03, 0xF0, 0x1F, 0xF0, 0x00, 0xFC, 0x07, 0xFC, 0x00, 0x3F, 0x01, 0xFF,
  0x00, 0x0F, 0x80, 0x7F, 0xE0, 0x07, 0xE0, 0x3F, 0xF8, 0x01, 0xF8, 0x0F,
  0xFE, 0x00, 0x7E, 0x03, 0xFF, 0x80, 0x1F, 0x80, 0xFB, 0xF0, 0x0F, 0xC0,
  0x3E, 0xFC, 0x03, 0xF0, 0x1F, 0xBF, 0x00, 0xFC, 0x07, 0xE7, 0xC0, 0x3F,
  0x01, 0xF9, 0xF8, 0x0F, 0xC0, 0x7C, 0x7E, 0x07, 0xE0, 0x1F, 0x1F, 0x81,
  0xF8, 0x0F, 0xC3, 0xF0, 0x7E, 0x03, 0xF0, 0xFC, 0x1F, 0x80, 0xFC, 0x3F,
  0x07, 0xC0, 0x3E, 0x07, 0xC3, 0xF0, 0x1F, 0x81, 0xF8, 0xFC, 0x07, 0xE0,
  0x7E, 0x3F, 0x01, 0xF8, 0x1F, 0x8F, 0xC0, 0x7E, 0x03, 0xF3, 0xE0, 0x1F,
  0x00, 0xFD, 0xF8, 0x0F, 0xC0, 0x3F, 0x7E, 0x03, 0xF0, 0x07, 0xDF, 0x80,
  0xFC, 0x01, 0xFF, 0xE0, 0x3F, 0x00, 0x7F, 0xF0, 0x0F, 0x80, 0x1F, 0xFC,
  0x07, 0xE0, 0x03, 0xFF, 0x01, 0xF8, 0x00, 0xFF, 0xC0, 0x7E, 0x00, 0x3F,
  0xE0, 0x1F, 0x80, 0x07, 0xF8, 0x07, 0xC0, 0x01, 0xFE, 0x03, 0xF0, 0x00,
  0x7F, 0x80, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xC0, 0xFF, 0x01, 0xFE, 0x01,
  0xFE, 0x0F, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x07, 0xE1, 0xFC, 0x00, 0x1F,
  0xC7, 0xF0, 0x00, 0x7F, 0x3F, 0x80, 0x01, 0xFC, 0xFE, 0x00, 0x07, 0xF7,
  0xF0, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x7F, 0x7F, 0x00, 0x01, 0xFD, 0xF8,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x7E, 0xFE, 0x00,
  0x03, 0xFB, 0xF8, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x3F, 0xBF, 0x00, 0x00,
  0xFC, 0xFC, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0xFE,
  0x3F, 0x80, 0x03, 0xF8, 0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0xFF, 0x0F,
  0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0xE0, 0x7F, 0xC1, 0xFF, 0x00, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0x83, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0x7E, 0x03, 0xF0, 0x07, 0xF0, 0x3F, 0x00, 0x7F, 0x03, 0xF0, 0x07,
  0xF0, 0x7F, 0x00, 0x7E, 0x07, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x07,
  0xE0, 0x0F, 0xE0, 0x7E, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0xC0, 0xFC, 0x0F,
  0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xC0, 0xFF, 0x01, 0xFE,
  0x01, 0xFE, 0x0F, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x07, 0xE1, 0xFC, 0x00,
  0x1F, 0xC7, 0xF0, 0x00, 0x7F, 0x3F, 0x80, 0x01, 0xFC, 0xFE, 0x00, 0x07,
  0xF7, 0xF0, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x7F, 0x7F, 0x00, 0x01, 0xFD,
  0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x7E, 0xFE,
  0x00, 0x03, 0xFB, 0xF8, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x3F, 0xBF, 0x00,
  0x00, 0xFC, 0xFC, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x1F, 0xCF, 0xC0, 0x00,
  0xFE, 0x3F, 0x80, 0x03, 0xF8, 0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0xFF,
  0x0F, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x3F, 0xE0, 0x7F, 0xC1, 0xFF, 0x00,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0,
  0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x03, 0xF0,
  0x7F, 0x80, 0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0x7F, 0x03, 0xF0, 0x0F, 0xE0,
  0x7E, 0x01, 0xFC, 0x0F, 0xC0, 0x3F, 0x83, 0xF8, 0x07, 0xF0, 0x7E, 0x00,
  0xFE, 0x0F, 0xC0, 0x1F, 0x81, 0xF8, 0x07, 0xF0, 0x3F, 0x01, 0xFC, 0x0F,
  0xE0, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0xFC,
  0x3F, 0x80, 0x1F, 0x83, 0xF0, 0x07, 0xF0, 0x7E, 0x00, 0xFE, 0x0F, 0xE0,
  0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xF8, 0x1F, 0xC0,
  0x7F, 0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0xFE, 0x0F, 0xC0, 0x1F, 0xC1,
  0xF8, 0x01, 0xF8, 0x7F, 0x00, 0x3F, 0x8F, 0xC0, 0x07, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xC0, 0xF0, 0x0F, 0xE0, 0x04,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x08,
  0x00, 0x3F, 0x81, 0x80, 0x0F, 0xE0, 0xF8, 0x0F, 0xF0, 0x3F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0xFC,
  0x1F, 0xC0, 0x07, 0xF0, 0x7E, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x7E, 0x07,
  0xE0, 0x01, 0xF8, 0x3F, 0x80, 0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0x83, 0xF0,
  0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x7F, 0x00, 0x0F, 0xC1, 0xFC, 0x00,
  0x7F, 0x07, 0xE0, 0x01, 0xFC, 0x1F, 0x80, 0x07, 0xE0, 0x7E, 0x00, 0x1F,
  0x83, 0xF8, 0x00, 0x7E, 0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0x00, 0x0F, 0xE0,
  0xFC, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0x7F,
  0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x01, 0xF8, 0x1F, 0x80,
  0x07, 0xE0, 0xFE, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFE, 0x0F, 0xC0, 0x03,
  0xF0, 0x3F, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x7F, 0x03, 0xF8, 0x03, 0xF8,
  0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0x80,
  0x01, 0xFB, 0xF0, 0x00, 0x7F, 0x7E, 0x00, 0x0F, 0xCF, 0xC0, 0x03, 0xF9,
  0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0xC7, 0xE0, 0x03, 0xF0, 0xFC, 0x00,
  0xFE, 0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x07, 0xF0, 0x7E, 0x00, 0xFC, 0x0F,
  0xC0, 0x3F, 0x80, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x3F,
  0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x3F,
  0x0F, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x8F, 0xC0,
  0x03, 0xF3, 0xF8, 0x00, 0x7E, 0x7E, 0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xFB,
  0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xEF, 0xC0,
  0x07, 0xF0, 0x03, 0xF3, 0xF0, 0x03, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFF,
  0x00, 0x7F, 0x3F, 0x00, 0x7F, 0xC0, 0x1F, 0x8F, 0xC0, 0x1F, 0xF0, 0x0F,
  0xE3, 0xF0, 0x07, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xFF, 0x00, 0xFC, 0x3F,
  0x00, 0xFF, 0xC0, 0x7E, 0x0F, 0xC0, 0x7D, 0xF0, 0x1F, 0x83, 0xF0, 0x1F,
  0x7C, 0x0F, 0xE0, 0xFC, 0x0F, 0xDF, 0x03, 0xF0, 0x3F, 0x03, 0xE7, 0xC0,
  0xFC, 0x0F, 0xC0, 0xF9, 0xF0, 0x7E, 0x03, 0xF0, 0x7C, 0x7C, 0x1F, 0x80,
  0xFC, 0x1F, 0x1F, 0x0F, 0xE0, 0x3F, 0x0F, 0xC7, 0xC3, 0xF0, 0x0F, 0xC3,
  0xE1, 0xF0, 0xFC, 0x03, 0xF1, 0xF8, 0x7C, 0x7E, 0x00, 0xFC, 0x7C, 0x1F,
  0x1F, 0x80, 0x3F, 0x3F, 0x07, 0xCF, 0xC0, 0x0F, 0xCF, 0x81, 0xF3, 0xF0,
  0x03, 0xF3, 0xE0, 0x7C, 0xFC, 0x00, 0xFD, 0xF8, 0x1F, 0x7E, 0x00, 0x3F,
  0x7C, 0x07, 0xDF, 0x80, 0x0F, 0xDF, 0x01, 0xF7, 0xC0, 0x03, 0xFF, 0x80,
  0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x07, 0xFE,
  0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF0, 0x07, 0xF0, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x00, 0x7E, 0x0F,
  0xE0, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x00, 0xFC,
  0xFC, 0x00, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x00, 0x7E, 0x7E,
  0x00, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x7E,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x3F, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xBF,
  0x00, 0x1F, 0xDF, 0xC0, 0x1F, 0xC7, 0xE0, 0x0F, 0xC3, 0xF0, 0x0F, 0xE1,
  0xF8, 0x0F, 0xE0, 0xFC, 0x07, 0xE0, 0x7F, 0x07, 0xF0, 0x1F, 0x83, 0xF0,
  0x0F, 0xC3, 0xF8, 0x07, 0xE3, 0xF8, 0x03, 0xF1, 0xF8, 0x00, 0xF9, 0xFC,
  0x00, 0x7E, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xFC,
  0x00, 0xFF, 0xE0, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7C, 0x00, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0x00, 0xFC, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xE0, 0xFC, 0x1F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x83, 0xF0, 0x7E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7E, 0x0F, 0xC1, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF8, 0x3F, 0x07, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xE0, 0xFC, 0x1F, 0x81, 0xF0, 0x3E, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0,
  0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0xF9, 0xF0, 0x00, 0xF9, 0xF0, 0x01,
  0xF1, 0xF0, 0x03, 0xF0, 0xF8, 0x03, 0xE0, 0xF8, 0x07, 0xC0, 0xF8, 0x07,
  0xC0, 0x7C, 0x0F, 0x80, 0x7C, 0x0F, 0x80, 0x7C, 0x1F, 0x00, 0x3E, 0x3F,
  0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x7F,
  0x1F, 0x8F, 0xC3, 0xF0, 0xF8, 0x7C, 0x1F, 0x00, 0x1C, 0x00, 0x00, 0x7F,
  0x87, 0xC0, 0x7F, 0xE3, 0xE0, 0x7F, 0xFB, 0xF0, 0x7F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xF8, 0x7F, 0x83, 0xFC, 0x3F, 0x81, 0xFE, 0x3F, 0x80, 0x7F, 0x1F,
  0xC0, 0x3F, 0x0F, 0xC0, 0x1F, 0x8F, 0xE0, 0x0F, 0xC7, 0xE0, 0x07, 0xE3,
  0xF0, 0x03, 0xF3, 0xF8, 0x03, 0xF1, 0xFC, 0x01, 0xF8, 0xFE, 0x00, 0xFC,
  0x7E, 0x00, 0xFE, 0x3F, 0x00, 0x7F, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x3F,
  0x87, 0xE0, 0x3F, 0xC3, 0xF8, 0x1F, 0xE1, 0xFC, 0x1F, 0xF0, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFE, 0xF8, 0x1F, 0xFE, 0x7C, 0x07, 0xFE, 0x7E, 0x01, 0xFE,
  0x3E, 0x00, 0x18, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x1E, 0x00, 0x7E, 0x3F, 0xC0, 0x3F, 0x3F,
  0xF0, 0x1F, 0xBF, 0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xFE, 0xFF, 0x07, 0xFC,
  0x1F, 0xC3, 0xFC, 0x0F, 0xE1, 0xFC, 0x03, 0xF0, 0xFE, 0x01, 0xF8, 0x7E,
  0x00, 0xFC, 0x7F, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x3F, 0x8F,
  0xC0, 0x1F, 0xCF, 0xC0, 0x0F, 0xC7, 0xE0, 0x07, 0xE3, 0xF0, 0x07, 0xF1,
  0xF8, 0x03, 0xF8, 0xFC, 0x01, 0xF8, 0xFE, 0x01, 0xFC, 0x7F, 0x00, 0xFC,
  0x3F, 0x80, 0xFE, 0x1F, 0xE0, 0xFE, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0x07, 0xCF, 0xFF, 0x03, 0xE7, 0xFF, 0x01, 0xF0, 0xFE, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x03, 0xFF, 0x80, 0x7F, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0xFF, 0x07, 0xFE, 0xF8, 0x7F, 0x80, 0x83, 0xF8, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x02, 0x1F, 0xE0, 0x70, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x0F, 0xFF,
  0xE0, 0x3F, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x60, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x01, 0xC1, 0xF8, 0x00, 0xFF, 0x1F, 0x80, 0x1F, 0xF9, 0xF8, 0x03, 0xFF,
  0xDF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFB, 0xFF, 0x01, 0xFE, 0x0F, 0xF0,
  0x1F, 0xC0, 0x7F, 0x03, 0xF8, 0x07, 0xF0, 0x3F, 0x80, 0x7E, 0x03, 0xF0,
  0x07, 0xE0, 0x7F, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7E,
  0x0F, 0xE0, 0x0F, 0xC0, 0xFE, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0xC0, 0xFC,
  0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0xC0, 0xFC, 0x01, 0xF8, 0x0F, 0xC0, 0x3F,
  0x80, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x80, 0xFE, 0x0F, 0xF0, 0x0F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFD, 0xF0, 0x07, 0xFF, 0x9F, 0x00, 0x3F, 0xF1,
  0xF0, 0x01, 0xFE, 0x3E, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x01, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F,
  0xC3, 0xF1, 0xFC, 0x0F, 0xC7, 0xE0, 0x3F, 0x3F, 0x80, 0xFC, 0xFC, 0x03,
  0xF7, 0xF0, 0x1F, 0xDF, 0x80, 0xFE, 0x7E, 0x1F, 0xF9, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xC0, 0xFF, 0xF8, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0xC0, 0x30, 0x7F, 0xCF, 0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x07,
  0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0xFF, 0x10, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x01,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0xF8, 0x7C,
  0x01, 0xFF, 0x8F, 0x80, 0x7F, 0xFB, 0xF0, 0x1F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0x81, 0xFE, 0x0F, 0xF0, 0x3F, 0x81, 0xFE, 0x0F, 0xE0, 0x1F, 0xC1,
  0xFC, 0x03, 0xF0, 0x3F, 0x00, 0x7E, 0x0F, 0xE0, 0x0F, 0xC1, 0xF8, 0x01,
  0xF8, 0x3F, 0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xC1, 0xFC, 0x01, 0xF8, 0x3F,
  0x80, 0x3F, 0x07, 0xE0, 0x0F, 0xE0, 0xFC, 0x01, 0xFC, 0x1F, 0x80, 0x3F,
  0x03, 0xF0, 0x0F, 0xE0, 0x7E, 0x03, 0xFC, 0x0F, 0xE0, 0x7F, 0x81, 0xFC,
  0x1F, 0xF0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFB, 0xF0,
  0x07, 0xFE, 0x7E, 0x00, 0x7F, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x02,
  0x00, 0x1F, 0xC0, 0x70, 0x07, 0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x1E, 0x00, 0x7E, 0x3F, 0xC0, 0x3F, 0x3F, 0xF0, 0x1F, 0xBF, 0xFC, 0x0F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x87, 0xFC, 0x1F, 0xC3, 0xFC, 0x0F, 0xE1,
  0xFC, 0x07, 0xF0, 0xFE, 0x03, 0xF8, 0x7E, 0x01, 0xF8, 0x7F, 0x00, 0xFC,
  0x3F, 0x80, 0x7E, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x3F, 0x8F, 0xE0, 0x1F,
  0x87, 0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0xFC, 0x03,
  0xF8, 0xFE, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x1F, 0x80,
  0x3F, 0x0F, 0xC0, 0x3F, 0x8F, 0xE0, 0x1F, 0x87, 0xE0, 0x0F, 0xC3, 0xF0,
  0x07, 0xE1, 0xF8, 0x07, 0xF0, 0x00, 0x78, 0x03, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xE0, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xE0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xF0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x0F, 0xFF, 0x00, 0x3F,
  0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x10, 0x7F, 0x01, 0xFC, 0x0F, 0xC0, 0x7F, 0x01, 0xF8,
  0x1F, 0xC0, 0x3F, 0x03, 0xF0, 0x07, 0xE0, 0xFC, 0x01, 0xFC, 0x3F, 0x80,
  0x3F, 0x0F, 0xE0, 0x07, 0xE3, 0xF8, 0x00, 0xFC, 0xFE, 0x00, 0x1F, 0xBF,
  0x80, 0x07, 0xEF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFD, 0xF8,
  0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x7E,
  0x0F, 0xE0, 0x0F, 0xC0, 0xFC, 0x01, 0xF8, 0x1F, 0xC0, 0x3F, 0x03, 0xF8,
  0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xF0, 0x3F, 0x00, 0xFE, 0x07, 0xE0,
  0x0F, 0xE0, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x07,
  0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x80, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x03,
  0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0x00, 0x00, 0xF0, 0x01, 0xC0, 0x0F, 0x87, 0xF8, 0x1F, 0xE0, 0x1F, 0x1F,
  0xF8, 0x7F, 0xE0, 0x3E, 0x7F, 0xF1, 0xFF, 0xE0, 0x7D, 0xFF, 0xF7, 0xFF,
  0xC0, 0xFF, 0xDF, 0xFF, 0x7F, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0x87, 0xF8,
  0x1F, 0xE0, 0x7F, 0x0F, 0xE0, 0x3F, 0xC0, 0xFE, 0x1F, 0xC0, 0x7F, 0x01,
  0xF8, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0xFE, 0x01, 0xF8, 0x07, 0xE1, 0xF8,
  0x07, 0xF0, 0x0F, 0xC3, 0xF0, 0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x1F, 0x80,
  0x7E, 0x1F, 0xC0, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x7E,
  0x01, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0x07, 0xE1, 0xF8, 0x07, 0xE0,
  0x1F, 0x87, 0xF0, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x1F,
  0x80, 0x7E, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x03, 0xF8, 0x7E, 0x01, 0xF8,
  0x07, 0xE1, 0xF8, 0x03, 0xF0, 0x0F, 0xC3, 0xF0, 0x07, 0xE0, 0x1F, 0x87,
  0xE0, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x3F, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xF0, 0x03, 0xE1, 0xFE, 0x01, 0xF1, 0xFF, 0x80, 0xF9, 0xFF, 0xE0, 0x7D,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x3F, 0xE0, 0xFE, 0x1F, 0xE0, 0x7F, 0x0F,
  0xE0, 0x3F, 0x87, 0xF0, 0x1F, 0xC3, 0xF0, 0x0F, 0xC3, 0xF8, 0x07, 0xE1,
  0xFC, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x7E, 0x01, 0xFC, 0x7F, 0x00, 0xFC,
  0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x1F,
  0xC7, 0xF0, 0x0F, 0xC3, 0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0xFC, 0x01,
  0xF8, 0x7E, 0x01, 0xFC, 0x7F, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x1F, 0x80,
  0x3F, 0x0F, 0xC0, 0x3F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xC0, 0x07,
  0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x87, 0xF8,
  0x3F, 0x8F, 0xE0, 0x3F, 0x3F, 0x80, 0x7E, 0x7E, 0x00, 0xFD, 0xFC, 0x01,
  0xFB, 0xF0, 0x03, 0xF7, 0xE0, 0x07, 0xEF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xF7,
  0xE0, 0x0F, 0xEF, 0xC0, 0x1F, 0x9F, 0x80, 0x7F, 0x3F, 0x81, 0xFE, 0x3F,
  0x87, 0xF8, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF,
  0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x0F, 0x87, 0xF8, 0x00, 0xF8, 0xFF, 0xC0, 0x0F, 0x9F, 0xFE, 0x00, 0xFB,
  0xFF, 0xE0, 0x0F, 0xFD, 0xFE, 0x01, 0xFF, 0x07, 0xF0, 0x1F, 0xE0, 0x7F,
  0x01, 0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0x3F, 0x01, 0xF8, 0x03, 0xF0, 0x3F,
  0x80, 0x3F, 0x03, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x7F, 0x03, 0xF0, 0x07,
  0xF0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0xFE, 0x07,
  0xE0, 0x0F, 0xE0, 0x7E, 0x00, 0xFC, 0x0F, 0xE0, 0x1F, 0xC0, 0xFE, 0x01,
  0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFF, 0x07, 0xF0, 0x0F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xE0, 0x1F, 0xBF, 0xFC, 0x01, 0xF9, 0xFF, 0x80, 0x1F, 0x8F,
  0xE0, 0x01, 0xF8, 0x10, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x7F, 0xC7, 0xC0, 0x7F, 0xF3, 0xE0, 0x7F, 0xFB, 0xF0, 0x7F, 0xFF, 0xF0,
  0x7F, 0xDF, 0xF8, 0x7F, 0x83, 0xFC, 0x3F, 0x81, 0xFE, 0x3F, 0x80, 0x7F,
  0x1F, 0xC0, 0x3F, 0x0F, 0xC0, 0x1F, 0x8F, 0xE0, 0x0F, 0xC7, 0xE0, 0x07,
  0xE3, 0xF0, 0x03, 0xF3, 0xF8, 0x03, 0xF1, 0xFC, 0x01, 0xF8, 0xFC, 0x00,
  0xFC, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x7F, 0x1F, 0x80, 0x3F, 0x0F, 0xC0,
  0x3F, 0x87, 0xE0, 0x1F, 0xC3, 0xF8, 0x1F, 0xE1, 0xFC, 0x1F, 0xE0, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFE, 0xFC, 0x07, 0xFE, 0x7E, 0x01,
  0xFE, 0x7E, 0x00, 0x10, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x7E, 0x3F, 0x07, 0xC7,
  0xF0, 0x7C, 0xFF, 0x07, 0xDF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFE, 0x20, 0xFF,
  0x80, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0xFF, 0x00,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x07, 0xF0, 0x78, 0x7F, 0x00,
  0x83, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE2, 0x00, 0x3F, 0x18, 0x03, 0xF8, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x07, 0xFF, 0x80, 0x01, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00,
  0x3F, 0x00, 0x3F, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xBF, 0xFF,
  0xC1, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01,
  0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF0, 0x0F,
  0xF8, 0x00, 0x80, 0x00, 0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0xC3, 0xF0,
  0x07, 0xE1, 0xF8, 0x07, 0xE1, 0xFC, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x7E,
  0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x3F, 0x0F,
  0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0xC3, 0xF0, 0x0F, 0xE3, 0xF8, 0x07, 0xE1,
  0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x7E, 0x01, 0xFC, 0x3F, 0x00, 0xFE,
  0x3F, 0x80, 0x7E, 0x1F, 0x80, 0x7F, 0x0F, 0xC0, 0x7F, 0x87, 0xF0, 0x3F,
  0xC3, 0xF8, 0x3F, 0xC1, 0xFF, 0xFF, 0xE0, 0x7F, 0xFD, 0xF0, 0x3F, 0xFC,
  0xF8, 0x0F, 0xFC, 0x7C, 0x03, 0xFC, 0x7C, 0x00, 0x20, 0x00, 0x00, 0xFC,
  0x00, 0xFF, 0xF8, 0x01, 0xFB, 0xF0, 0x07, 0xF7, 0xE0, 0x0F, 0xCF, 0xC0,
  0x1F, 0x9F, 0x80, 0x7E, 0x3F, 0x00, 0xFC, 0x7E, 0x03, 0xF0, 0xFC, 0x07,
  0xE0, 0xF8, 0x1F, 0x81, 0xF0, 0x3F, 0x03, 0xE0, 0xFC, 0x07, 0xC1, 0xF8,
  0x0F, 0xC7, 0xE0, 0x1F, 0x8F, 0xC0, 0x3F, 0x3F, 0x00, 0x7E, 0x7E, 0x00,
  0xFD, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xF7, 0xC0, 0x03, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x03, 0xF8, 0x07,
  0xFF, 0xC0, 0x3F, 0x80, 0x7E, 0xFC, 0x07, 0xF8, 0x0F, 0xEF, 0xC0, 0x7F,
  0x80, 0xFC, 0xFC, 0x0F, 0xF8, 0x0F, 0xCF, 0xC0, 0xFF, 0x81, 0xF8, 0xFC,
  0x0F, 0x78, 0x1F, 0x8F, 0xC1, 0xF7, 0x83, 0xF0, 0xFC, 0x1F, 0xF8, 0x3F,
  0x0F, 0xC3, 0xEF, 0x83, 0xE0, 0xFC, 0x3E, 0xF8, 0x7E, 0x0F, 0xC7, 0xCF,
  0x87, 0xE0, 0xFC, 0x7C, 0xF8, 0xFC, 0x0F, 0xC7, 0xCF, 0x8F, 0xC0, 0xFC,
  0xF8, 0xF9, 0xF8, 0x0F, 0xCF, 0x8F, 0x9F, 0x80, 0x7D, 0xF0, 0xF9, 0xF0,
  0x07, 0xDF, 0x0F, 0xBF, 0x00, 0x7D, 0xE0, 0xFB, 0xE0, 0x07, 0xFE, 0x0F,
  0xBE, 0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x07, 0xFC, 0x0F, 0xFC, 0x00, 0x7F,
  0xC0, 0xFF, 0xC0, 0x07, 0xF8, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0xFF, 0x80,
  0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x01, 0xF8, 0x1F,
  0xC0, 0x1F, 0x81, 0xFC, 0x00, 0xFC, 0x3F, 0x80, 0x0F, 0xC7, 0xF0, 0x00,
  0xFC, 0x7E, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0x3F, 0x00,
  0x07, 0xF3, 0xF0, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x01, 0xFC,
  0x1F, 0x80, 0x3F, 0x81, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x00, 0xFC,
  0x0F, 0xE0, 0x0F, 0xE0, 0x01, 0xF8, 0x01, 0xFC, 0x07, 0xE0, 0x07, 0xF0,
  0x1F, 0x80, 0x1F, 0x80, 0x7E, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x1F, 0xC0, 0x0F, 0x80, 0x7E, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0xFC,
  0x0F, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3F, 0x0F,
  0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x0F, 0xC7, 0xE0,
  0x00, 0x1F, 0x3F, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x01, 0xF3, 0xE0, 0x00,
  0x07, 0xDF, 0x80, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFF,
  0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x3F,
  0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xC0, 0x00,
  0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x07,
  0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xC0,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x7C, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x01,
  0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0x80, 0x07,
  0xF8, 0x00, 0x0F, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00,
  0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x02, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xA0, 0x03, 0xFE, 0x40, 0x00,
  0x60,
};

const GFXglyph NotoSans_SemiCondensed_SemiBoldItalic52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 14, 38, 14, 1, -37 },
  { 68, 18, 13, 21, 5, -37 },
  { 98, 30, 37, 30, 1, -37 },
  { 237, 25, 43, 26, 1, -40 },
  { 372, 35, 38, 40, 3, -38 },
  { 539, 30, 39, 32, 1, -38 },
  { 686, 8, 13, 12, 5, -37 },
  { 699, 17, 45, 16, 2, -37 },
  { 795, 18, 46, 16, -4, -38 },
  { 899, 22, 23, 25, 5, -40 },
  { 963, 23, 25, 27, 3, -31 },
  { 1035, 12, 13, 13, -3, -6 },
  { 1055, 14, 6, 16, 1, -17 },
  { 1066, 7, 8, 13, 1, -7 },
  { 1073, 27, 37, 20, -3, -37 },
  { 1198, 24, 39, 26, 2, -38 },
  { 1315, 17, 37, 26, 6, -37 },
  { 1394, 27, 38, 26, -1, -38 },
  { 1523, 26, 39, 26, 0, -38 },
  { 1650, 26, 37, 26, 0, -37 },
  { 1771, 25, 38, 26, 1, -37 },
  { 1890, 25, 39, 26, 2, -38 },
  { 2012, 26, 37, 26, 2, -37 },
  { 2133, 25, 39, 26, 1, -38 },
  { 2255, 24, 39, 26, 1, -38 },
  { 2372, 13, 30, 13, 0, -29 },
  { 2421, 16, 36, 13, -3, -29 },
  { 2493, 23, 26, 27, 3, -32 },
  { 2568, 23, 15, 27, 3, -26 },
  { 2612, 23, 26, 27, 3, -32 },
  { 2687, 20, 39, 21, 3, -38 },
  { 2785, 37, 42, 40, 2, -37 },
  { 2980, 28, 37, 28, -3, -37 },
  { 3110, 28, 37, 29, 1, -37 },
  { 3240, 28, 39, 28, 3, -38 },
  { 3377, 29, 37, 32, 1, -37 },
  { 3512, 26, 37, 25, 1, -37 },
  { 3633, 26, 37, 24, 1, -37 },
  { 3754, 29, 39, 32, 3, -38 },
  { 3896, 32, 37, 33, 1, -37 },
  { 4044, 23, 37, 18, -2, -37 },
  { 4151, 24, 48, 15, -8, -37 },
  { 4295, 32, 37, 28, 1, -37 },
  { 4443, 19, 37, 24, 1, -37 },
  { 4531, 41, 37, 41, 1, -37 },
  { 4721, 34, 37, 35, 1, -37 },
  { 4879, 30, 39, 34, 3, -38 },
  { 5026, 28, 37, 28, 1, -37 },
  { 5156, 30, 47, 34, 3, -38 },
  { 5333, 27, 37, 28, 1, -37 },
  { 5458, 26, 39, 25, 0, -38 },
  { 5585, 24, 37, 24, 4, -37 },
  { 5696, 30, 38, 32, 3, -37 },
  { 5839, 27, 37, 27, 5, -37 },
  { 5964, 42, 37, 42, 5, -37 },
  { 6159, 34, 37, 27, -3, -37 },
  { 6317, 25, 37, 25, 5, -37 },
  { 6433, 29, 37, 25, -2, -37 },
  { 6568, 21, 45, 16, -1, -37 },
  { 6687, 11, 37, 20, 5, -37 },
  { 6738, 21, 45, 16, -4, -37 },
  { 6857, 24, 23, 26, 1, -37 },
  { 6926, 20, 3, 19, -5, 5 },
  { 6934, 9, 8, 15, 8, -40 },
  { 6943, 25, 30, 28, 2, -29 },
  { 7037, 25, 41, 28, 1, -40 },
  { 7166, 21, 30, 22, 2, -29 },
  { 7245, 28, 41, 28, 2, -40 },
  { 7389, 22, 30, 25, 2, -29 },
  { 7472, 29, 52, 17, -6, -40 },
  { 7661, 27, 41, 28, 0, -29 },
  { 7800, 25, 40, 28, 1, -40 },
  { 7925, 14, 39, 13, 1, -39 },
  { 7994, 22, 51, 13, -7, -39 },
  { 8135, 27, 40, 25, 1, -40 },
  { 8270, 14, 40, 13, 1, -40 },
  { 8340, 39, 29, 42, 1, -29 },
  { 8482, 25, 29, 28, 1, -29 },
  { 8573, 23, 30, 27, 2, -29 },
  { 8660, 28, 41, 28, -2, -29 },
  { 8804, 25, 41, 28, 2, -29 },
  { 8933, 20, 29, 19, 1, -29 },
  { 9006, 21, 30, 22, 0, -29 },
  { 9085, 17, 35, 18, 2, -34 },
  { 9160, 25, 29, 28, 2, -28 },
  { 9251, 23, 28, 23, 3, -28 },
  { 9332, 36, 28, 36, 3, -28 },
  { 9458, 28, 28, 24, -2, -28 },
  { 9556, 30, 40, 24, -4, -28 },
  { 9706, 23, 28, 21, -1, -28 },
  { 9787, 21, 45, 18, 0, -37 },
  { 9906, 5, 52, 25, 10, -40 },
  { 9939, 21, 45, 18, -3, -37 },
  { 10058, 23, 8, 27, 3, -22 },
};

const GFXfont NotoSans_SemiCondensed_SemiBoldItalic52pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_SemiBoldItalic52pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_SemiBoldItalic52pt7bGlyphs,
  0x20, 0x7E, 71
};

#endif // _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC52PT7B_H_
