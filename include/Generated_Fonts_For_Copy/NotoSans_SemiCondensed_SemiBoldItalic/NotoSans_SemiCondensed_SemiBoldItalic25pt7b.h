#ifndef _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC25PT7B_H_
#define _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC25PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-SemiBoldItalic.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_SemiBoldItalic25pt7bBitmaps[] PROGMEM = {
  0x00, 0x0E, 0x1C, 0x78, 0xE1, 0xC3, 0x87, 0x0C, 0x38, 0x70, 0xE1, 0x83,
  0x00, 0x08, 0x38, 0xF1, 0xE0, 0x73, 0xB9, 0xDC, 0xCC, 0xE6, 0x73, 0x33,
  0x98, 0x01, 0x9C, 0x07, 0x30, 0x0C, 0x60, 0x19, 0xC0, 0x73, 0x07, 0xFF,
  0xCF, 0xFF, 0x83, 0x30, 0x0C, 0x60, 0x18, 0xC0, 0x33, 0x83, 0xFF, 0xCF,
  0xFF, 0x83, 0x18, 0x0E, 0x60, 0x18, 0xC0, 0x31, 0x80, 0xE7, 0x00, 0x00,
  0xC0, 0x04, 0x01, 0xF8, 0x1F, 0xF1, 0xFF, 0x0E, 0x80, 0xE4, 0x03, 0xA0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x6E, 0x03, 0x72, 0x1B, 0x8F,
  0xF8, 0xFF, 0xC1, 0xF8, 0x03, 0x00, 0x10, 0x00, 0x1E, 0x07, 0x1F, 0x83,
  0x0C, 0xC3, 0x8E, 0x63, 0x86, 0x31, 0x83, 0x19, 0xC1, 0x9D, 0xC1, 0xCC,
  0xCE, 0x6E, 0xEF, 0xBE, 0xEE, 0xCE, 0x6E, 0x60, 0x77, 0x30, 0x73, 0x18,
  0x31, 0x8C, 0x38, 0xCE, 0x38, 0x66, 0x18, 0x3F, 0x1C, 0x0F, 0x00, 0x03,
  0xE0, 0x0F, 0xE0, 0x39, 0xC0, 0x71, 0x80, 0xE7, 0x01, 0xCE, 0x03, 0xB8,
  0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x1C, 0xEE, 0x73, 0x8E, 0xE7, 0x1F, 0x9E,
  0x1F, 0x3C, 0x3C, 0x3C, 0xF8, 0x7F, 0xF8, 0x7E, 0x78, 0xFF, 0xED, 0xB0,
  0x07, 0x06, 0x0E, 0x1C, 0x38, 0x38, 0x70, 0x70, 0x70, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xC0, 0xC0, 0xC0, 0xE0, 0xE0, 0xE0, 0x60, 0x70, 0x06, 0x03,
  0x80, 0xC0, 0x60, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xC0, 0xE0,
  0x70, 0x38, 0x18, 0x1C, 0x0E, 0x0E, 0x06, 0x07, 0x07, 0x07, 0x00, 0x07,
  0x00, 0xE1, 0x18, 0x3B, 0x0F, 0xFE, 0x3F, 0xC7, 0x89, 0xF8, 0x73, 0x04,
  0x70, 0x0C, 0x00, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x0F, 0xFF,
  0xFF, 0xF0, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x39, 0xDC, 0xE6,
  0x70, 0x7E, 0xFF, 0xF0, 0x27, 0xFF, 0x00, 0x78, 0x03, 0x80, 0x38, 0x01,
  0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x30, 0x03, 0x80,
  0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x00,
  0x07, 0xC3, 0xFC, 0x7F, 0x9C, 0x73, 0x8E, 0xE1, 0xDC, 0x3F, 0x87, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0xEE, 0x1D, 0xC3, 0xB8, 0xE7, 0xBC, 0x7F, 0x0F,
  0xC0, 0x07, 0x0F, 0x3F, 0x7E, 0xFE, 0xCE, 0x0E, 0x0E, 0x1C, 0x1C, 0x1C,
  0x1C, 0x38, 0x38, 0x38, 0x38, 0x38, 0x70, 0x03, 0xE0, 0x7F, 0xC3, 0xFE,
  0x18, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0xFC, 0x7F, 0xE7, 0xFF,
  0x00, 0x07, 0xE1, 0xFF, 0x1E, 0xF0, 0x87, 0x00, 0x70, 0x07, 0x00, 0xF0,
  0x3E, 0x0F, 0x80, 0xFC, 0x01, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xEE,
  0x3C, 0xFF, 0x8F, 0xF0, 0x00, 0x70, 0x0F, 0x01, 0xF0, 0x1F, 0x03, 0x60,
  0x7E, 0x0E, 0xE0, 0xCE, 0x18, 0xE3, 0x9C, 0x71, 0xCE, 0x1C, 0xFF, 0xFF,
  0xFF, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x0F, 0xF8, 0x7F, 0x83, 0xFC,
  0x18, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0xF0, 0x3F, 0xC0, 0x8F, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x9C, 0xF8, 0xFF, 0x83, 0xF8,
  0x00, 0x03, 0xF0, 0x7F, 0x0F, 0xA1, 0xC0, 0x38, 0x03, 0x80, 0x70, 0x07,
  0xFC, 0x7F, 0xCF, 0x1C, 0xF0, 0xEE, 0x0E, 0xE1, 0xCE, 0x1C, 0xE1, 0xCF,
  0x78, 0x7F, 0x83, 0xE0, 0x3F, 0xF3, 0xFF, 0x7F, 0xF0, 0x0E, 0x00, 0xE0,
  0x1C, 0x01, 0xC0, 0x38, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xE0, 0x1C, 0x01,
  0xC0, 0x38, 0x07, 0x80, 0x70, 0x0F, 0x00, 0x07, 0xE0, 0x7F, 0x87, 0x9C,
  0x38, 0x71, 0xC3, 0x8E, 0x38, 0x73, 0xC1, 0xFC, 0x07, 0x80, 0xFE, 0x0E,
  0x78, 0xE1, 0xC7, 0x0E, 0x70, 0x71, 0xC3, 0x8E, 0x3C, 0x7F, 0xC1, 0xFC,
  0x00, 0x0F, 0x83, 0xF8, 0xF7, 0xBC, 0x77, 0x0E, 0xE1, 0xDC, 0x3B, 0x87,
  0x71, 0xEF, 0xFC, 0xFB, 0x0C, 0xE0, 0x1C, 0x07, 0x01, 0xE4, 0xF8, 0xFE,
  0x1F, 0x80, 0x18, 0x73, 0xC6, 0x00, 0x00, 0x00, 0x00, 0x02, 0x1C, 0xF3,
  0x80, 0x0C, 0x1C, 0x78, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC3,
  0x8E, 0x1C, 0x70, 0xC0, 0x00, 0x30, 0x0F, 0x03, 0xE0, 0xF8, 0x3E, 0x0F,
  0x80, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0xC0, 0x0F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x01, 0xF0, 0x7C, 0x1F, 0x07, 0xC0, 0xF0,
  0x0C, 0x00, 0x1F, 0x1F, 0xE3, 0xBD, 0x07, 0x01, 0xC0, 0x60, 0x38, 0x1C,
  0x1E, 0x07, 0x03, 0x80, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0xF0, 0x1C,
  0x00, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0xF0, 0x78, 0x70, 0x06, 0x38, 0x01,
  0xCC, 0x3F, 0x37, 0x1F, 0x8D, 0x8C, 0x63, 0x67, 0x18, 0xF9, 0x8E, 0x7C,
  0x63, 0x1B, 0x38, 0xC6, 0xCE, 0x73, 0xB1, 0xFF, 0xCC, 0x79, 0xE3, 0x80,
  0x00, 0x60, 0x00, 0x1E, 0x02, 0x03, 0xFF, 0x00, 0x3F, 0x80, 0x00, 0x78,
  0x01, 0xE0, 0x0F, 0x80, 0x36, 0x01, 0xD8, 0x06, 0x60, 0x39, 0x80, 0xE6,
  0x07, 0x18, 0x1C, 0x70, 0xE1, 0xC3, 0xFF, 0x1F, 0xFC, 0x70, 0x73, 0x81,
  0xCE, 0x07, 0x70, 0x1F, 0xC0, 0x70, 0x0F, 0xE0, 0x3F, 0xE0, 0xFF, 0xC3,
  0x8F, 0x1C, 0x1C, 0x70, 0x71, 0xC3, 0x87, 0xFC, 0x3F, 0xE0, 0xFF, 0x83,
  0x87, 0x0E, 0x1C, 0x38, 0x79, 0xC1, 0xC7, 0x07, 0x1F, 0xFC, 0x7F, 0xE3,
  0xFE, 0x00, 0x03, 0xF8, 0x1F, 0xF0, 0xFF, 0x87, 0x82, 0x3C, 0x00, 0xE0,
  0x07, 0x80, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x07, 0x00, 0x1F, 0x70, 0x3F, 0xC0, 0x7F, 0x00, 0x0F, 0xE0,
  0x1F, 0xF0, 0x3F, 0xF0, 0x71, 0xE1, 0xC1, 0xC3, 0x83, 0xC7, 0x07, 0x8E,
  0x0F, 0x3C, 0x1E, 0x70, 0x38, 0xE0, 0x71, 0xC1, 0xE3, 0x83, 0x8F, 0x0F,
  0x1C, 0x3C, 0x3F, 0xF0, 0x7F, 0xC1, 0xFE, 0x00, 0x0F, 0xF8, 0x7F, 0xC3,
  0xFE, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0xFC, 0x3F, 0xE1, 0xFF,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x0F, 0xF8, 0x7F, 0xC7,
  0xFC, 0x00, 0x0F, 0xF8, 0x7F, 0xC3, 0xFC, 0x1C, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x3F, 0xE1, 0xFF, 0x0F, 0xF0, 0x70, 0x03, 0x80, 0x3C,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x00, 0x01, 0xF8, 0x0F, 0xFC,
  0x3F, 0xF0, 0xF0, 0x23, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70,
  0xFD, 0xE3, 0xF3, 0xC7, 0xE7, 0x81, 0xCF, 0x03, 0x9E, 0x0E, 0x1C, 0x1C,
  0x3E, 0x78, 0x3F, 0xF0, 0x3F, 0xC0, 0x0E, 0x07, 0x0E, 0x07, 0x0E, 0x0F,
  0x0E, 0x0E, 0x1C, 0x0E, 0x1C, 0x0E, 0x1C, 0x0E, 0x1F, 0xFC, 0x1F, 0xFC,
  0x3F, 0xFC, 0x38, 0x1C, 0x38, 0x1C, 0x38, 0x38, 0x78, 0x38, 0x70, 0x38,
  0x70, 0x38, 0x70, 0x78, 0xF0, 0x70, 0x0F, 0xE1, 0xFC, 0x1E, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0xFF, 0x1F, 0xC0, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x1E, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x0F, 0xE1,
  0xF8, 0x3E, 0x00, 0x0E, 0x0F, 0x0E, 0x1E, 0x0E, 0x3C, 0x0E, 0x78, 0x1C,
  0x70, 0x1C, 0xE0, 0x1D, 0xC0, 0x1F, 0xC0, 0x1B, 0x80, 0x3F, 0x80, 0x3F,
  0xC0, 0x39, 0xC0, 0x39, 0xC0, 0x71, 0xE0, 0x70, 0xE0, 0x70, 0xE0, 0x70,
  0xF0, 0xF0, 0x70, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x3C, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x1C, 0x07, 0x01, 0xFF, 0x7F,
  0xFF, 0xE0, 0x0F, 0x00, 0xF0, 0xF0, 0x1F, 0x0F, 0x01, 0xF0, 0xF8, 0x3F,
  0x1F, 0x83, 0x61, 0xF8, 0x7E, 0x1F, 0x86, 0xE1, 0xB8, 0xEE, 0x3B, 0x8C,
  0xC3, 0xB9, 0xDC, 0x39, 0x99, 0xC3, 0x9B, 0x9C, 0x31, 0xB1, 0xC7, 0x1F,
  0x18, 0x71, 0xE3, 0x87, 0x1E, 0x38, 0x71, 0xC3, 0x8E, 0x1C, 0x38, 0x0F,
  0x03, 0x87, 0x81, 0xC3, 0xC0, 0xE1, 0xF0, 0xE1, 0xF8, 0x70, 0xFC, 0x38,
  0x76, 0x1C, 0x33, 0x8C, 0x39, 0xCE, 0x1C, 0xE7, 0x0E, 0x3B, 0x87, 0x1D,
  0xC3, 0x0E, 0xC3, 0x83, 0x61, 0xC1, 0xF0, 0xE0, 0xF8, 0x70, 0x7C, 0x70,
  0x1C, 0x00, 0x03, 0xF0, 0x1F, 0xF0, 0x7F, 0xF0, 0xE0, 0xE3, 0xC1, 0xE7,
  0x01, 0xDE, 0x03, 0xB8, 0x07, 0x70, 0x1F, 0xE0, 0x3B, 0xC0, 0x77, 0x80,
  0xEF, 0x03, 0xDE, 0x07, 0x1C, 0x1E, 0x3E, 0xF8, 0x3F, 0xE0, 0x3F, 0x00,
  0x0F, 0xE0, 0x3F, 0xE0, 0xFF, 0x83, 0x8F, 0x1C, 0x1C, 0x70, 0x71, 0xC3,
  0xC7, 0x0E, 0x3C, 0xF8, 0xFF, 0xC3, 0xFE, 0x0E, 0x00, 0x38, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x00, 0x03, 0xF0, 0x1F, 0xF0,
  0x7F, 0xF0, 0xE0, 0xE3, 0xC1, 0xE7, 0x01, 0xDE, 0x03, 0xB8, 0x07, 0x70,
  0x1F, 0xE0, 0x3B, 0xC0, 0x77, 0x80, 0xEF, 0x03, 0xDE, 0x07, 0x1C, 0x1E,
  0x3E, 0xF8, 0x3F, 0xE0, 0x3F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x0F, 0xE0, 0x7F, 0x83, 0xFE, 0x1C, 0x71, 0xC3, 0x8E, 0x1C,
  0x70, 0xE3, 0x8F, 0x3F, 0xF1, 0xFF, 0x0F, 0xF0, 0x73, 0x83, 0x9C, 0x38,
  0xF1, 0xC3, 0x8E, 0x1C, 0x70, 0xF7, 0x83, 0x80, 0x07, 0xE0, 0x7F, 0xC7,
  0xFC, 0x38, 0x23, 0xC0, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0xE2, 0x07, 0x1E, 0xF8, 0xFF, 0x83,
  0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xE0, 0xE0, 0x0E, 0x01, 0xE0, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x1C, 0x0E, 0x38, 0x1C, 0x70, 0x71, 0xC0,
  0xE3, 0x81, 0xC7, 0x03, 0x8E, 0x0F, 0x1C, 0x1C, 0x70, 0x38, 0xE0, 0x71,
  0xC0, 0xE3, 0x83, 0x87, 0x07, 0x1E, 0x0E, 0x1C, 0x3C, 0x3D, 0xF0, 0x7F,
  0xC0, 0x7F, 0x00, 0xE0, 0x3F, 0x01, 0xF8, 0x1D, 0xC0, 0xE6, 0x0E, 0x30,
  0x71, 0x87, 0x0E, 0x38, 0x73, 0x83, 0x9C, 0x1D, 0xC0, 0xEE, 0x07, 0xE0,
  0x3F, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x00, 0xE0, 0x70, 0x7E,
  0x0F, 0x07, 0xE0, 0xF0, 0xEE, 0x0F, 0x0E, 0xE1, 0xF0, 0xEE, 0x1F, 0x1C,
  0xE3, 0xF1, 0xCE, 0x37, 0x38, 0xE7, 0x73, 0x8E, 0x77, 0x70, 0xEE, 0x77,
  0x0E, 0xE7, 0x70, 0xEC, 0x7E, 0x07, 0xC7, 0xE0, 0x78, 0x7C, 0x07, 0x87,
  0xC0, 0x78, 0x78, 0x07, 0x07, 0x80, 0x0E, 0x0F, 0x0E, 0x0E, 0x0E, 0x1C,
  0x07, 0x3C, 0x07, 0x38, 0x07, 0x70, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x0E, 0xE0, 0x1E, 0xE0, 0x1C, 0xE0, 0x38, 0xE0,
  0x78, 0x70, 0x70, 0x70, 0xE0, 0x70, 0xE0, 0x7B, 0x87, 0x9C, 0x38, 0xE3,
  0x87, 0x1C, 0x39, 0xC0, 0xDE, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x00,
  0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC0, 0x1E, 0x00, 0x70, 0x03, 0x80, 0x1E,
  0x00, 0x70, 0x03, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0xF0,
  0x03, 0x80, 0x1F, 0xF8, 0x7F, 0xE3, 0xFF, 0x80, 0x07, 0xC1, 0xF0, 0x60,
  0x38, 0x0E, 0x03, 0x80, 0xC0, 0x30, 0x1C, 0x07, 0x01, 0xC0, 0x60, 0x38,
  0x0E, 0x03, 0x80, 0xC0, 0x30, 0x1C, 0x07, 0x01, 0xC0, 0x7C, 0x3F, 0x00,
  0xC6, 0x39, 0xCE, 0x71, 0x8C, 0x63, 0x9C, 0xE7, 0x18, 0xC6, 0x39, 0xC0,
  0x07, 0xC1, 0xF0, 0x9C, 0x06, 0x01, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x00,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xC0,
  0x70, 0x7C, 0x3F, 0x00, 0x01, 0x80, 0x38, 0x03, 0x80, 0x7C, 0x0E, 0xC0,
  0xCC, 0x1C, 0xE1, 0x86, 0x30, 0x67, 0x07, 0xE0, 0x30, 0xFF, 0xFF, 0xC0,
  0xEE, 0x73, 0x06, 0x31, 0xF7, 0x3F, 0xF7, 0x8E, 0x70, 0xE7, 0x0E, 0xE0,
  0xEE, 0x0E, 0xE1, 0xCE, 0x1C, 0xE3, 0xCF, 0x7C, 0xFF, 0xC7, 0x98, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x60, 0x7F, 0xC3, 0xFE,
  0x1C, 0x71, 0xE3, 0xCE, 0x1C, 0x70, 0xE3, 0x87, 0x38, 0x39, 0xC3, 0xCE,
  0x1C, 0x79, 0xE3, 0xFE, 0x3B, 0xE0, 0x07, 0x87, 0xF3, 0xF9, 0xE0, 0x70,
  0x1C, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0xCC, 0x7F, 0x0F, 0xC0,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x03, 0x38, 0x7D, 0xC7,
  0xFE, 0x78, 0xE3, 0x87, 0x1C, 0x39, 0xC1, 0xCE, 0x0E, 0x70, 0xE3, 0x87,
  0x1C, 0x78, 0xF7, 0xC7, 0xFE, 0x1F, 0x60, 0x07, 0x83, 0xF8, 0xF7, 0xBC,
  0x77, 0x0E, 0xE3, 0xBF, 0xE7, 0xF8, 0xE0, 0x1C, 0x03, 0x80, 0x78, 0xC7,
  0xF8, 0x7E, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x1E, 0x80, 0x70, 0x01, 0xC0,
  0x0F, 0xC0, 0xFF, 0x03, 0xFC, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x1C, 0x00, 0x70, 0x0F, 0xC0, 0x3E, 0x00, 0xF0, 0x00, 0x07,
  0x18, 0x7F, 0xC7, 0xFE, 0x78, 0xE3, 0x87, 0x1C, 0x39, 0xC1, 0xCE, 0x0E,
  0x70, 0xE3, 0x87, 0x1C, 0x78, 0xF7, 0xC7, 0xEE, 0x1E, 0xE0, 0x07, 0x00,
  0x38, 0x03, 0xC7, 0x7C, 0x3F, 0xC0, 0xFC, 0x00, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x1C, 0x01, 0xCC, 0x1F, 0xF1, 0xFF, 0x1C, 0x73, 0xC7, 0x38,
  0x73, 0x87, 0x38, 0x77, 0x07, 0x70, 0xE7, 0x0E, 0x70, 0xE7, 0x0E, 0xE1,
  0xE0, 0x06, 0x1C, 0x38, 0x20, 0x03, 0x87, 0x0E, 0x1C, 0x70, 0xE1, 0xC3,
  0x8E, 0x1C, 0x38, 0x70, 0xE3, 0x80, 0x00, 0xC0, 0x70, 0x1C, 0x02, 0x00,
  0x00, 0xE0, 0x38, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0x1C, 0x07, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0x1C, 0x07, 0x0F, 0x83, 0xE0,
  0xF0, 0x00, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x1C,
  0x71, 0xC3, 0x9C, 0x19, 0xE1, 0xDE, 0x0E, 0xE0, 0x7E, 0x03, 0xF0, 0x3D,
  0xC1, 0xCE, 0x0E, 0x78, 0x71, 0xC3, 0x8E, 0x38, 0x78, 0x0E, 0x1C, 0x38,
  0x71, 0xC3, 0x87, 0x0E, 0x1C, 0x70, 0xE1, 0xC3, 0x8E, 0x1C, 0x38, 0x70,
  0xE3, 0x80, 0x1C, 0xE1, 0xC3, 0x7E, 0xFC, 0x7F, 0xFF, 0x8E, 0x3C, 0x73,
  0xC7, 0x8E, 0x70, 0xE1, 0xCE, 0x1C, 0x39, 0xC3, 0x8E, 0x70, 0xE1, 0xCE,
  0x1C, 0x39, 0xC3, 0x87, 0x38, 0x70, 0xE7, 0x0C, 0x39, 0xC3, 0x87, 0x00,
  0x18, 0xE1, 0xBF, 0x1F, 0xF1, 0xE7, 0x3C, 0x73, 0x87, 0x38, 0x73, 0x87,
  0x70, 0x77, 0x0E, 0x70, 0xE7, 0x0E, 0x70, 0xEE, 0x1C, 0x07, 0x03, 0xF8,
  0xFF, 0xBC, 0x77, 0x0F, 0xE1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x3B, 0x87,
  0x7B, 0xC7, 0xF8, 0x7C, 0x00, 0x0E, 0x70, 0x37, 0xE0, 0xFF, 0x83, 0x8E,
  0x1E, 0x3C, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x38, 0x38, 0xE1, 0xE3, 0x87,
  0x0F, 0x3C, 0x37, 0xE1, 0xDF, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x0E, 0x00, 0x38, 0x00, 0x0E, 0x31, 0xFF, 0x3F, 0xF7, 0x8E, 0x70, 0xE7,
  0x0E, 0xE0, 0xEE, 0x0E, 0xE1, 0xCE, 0x1C, 0xE3, 0xCF, 0x7C, 0xFD, 0xC7,
  0xB8, 0x03, 0x80, 0x38, 0x03, 0x80, 0x30, 0x07, 0x00, 0x70, 0x1C, 0xC6,
  0xF1, 0xBC, 0x78, 0x3C, 0x0E, 0x03, 0x80, 0xE0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x38, 0x00, 0x0F, 0x07, 0xF3, 0xFC, 0xE0, 0x38, 0x0F, 0x03,
  0xE0, 0x7C, 0x07, 0x80, 0xE0, 0x3B, 0x1E, 0xFF, 0x3F, 0x80, 0x0C, 0x1C,
  0x18, 0x3F, 0xFF, 0xFF, 0x38, 0x70, 0x70, 0x70, 0x70, 0x70, 0xE0, 0xE0,
  0xE4, 0xFC, 0x7C, 0x38, 0x73, 0x87, 0x38, 0x77, 0x06, 0x70, 0xE7, 0x0E,
  0x70, 0xE7, 0x0E, 0xE1, 0xCE, 0x1C, 0xE3, 0xCF, 0x7C, 0xFF, 0xC7, 0x98,
  0xE0, 0xFE, 0x0E, 0xE1, 0xE6, 0x1C, 0x61, 0xC6, 0x38, 0x73, 0x87, 0x70,
  0x77, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0xC3, 0xC3, 0xE1,
  0xE3, 0xB1, 0xF1, 0xD8, 0xF9, 0xCC, 0x7C, 0xE6, 0x7E, 0x63, 0x37, 0x71,
  0xBB, 0xB8, 0xD9, 0xF8, 0x6C, 0xFC, 0x3E, 0x7C, 0x1E, 0x3E, 0x0F, 0x1E,
  0x07, 0x0F, 0x00, 0x1C, 0x3C, 0x70, 0xE0, 0xE7, 0x03, 0xB8, 0x0E, 0xE0,
  0x1F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x76, 0x03, 0xDC, 0x0E, 0x70,
  0x71, 0xC3, 0xC3, 0x80, 0x1C, 0x1E, 0x38, 0x38, 0x30, 0x70, 0x61, 0xC0,
  0xE3, 0x81, 0xCE, 0x03, 0x9C, 0x07, 0x70, 0x0E, 0xE0, 0x1F, 0x80, 0x3F,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x1E, 0x01,
  0x78, 0x03, 0xE0, 0x07, 0x80, 0x00, 0x0F, 0xF1, 0xFE, 0x1F, 0xE0, 0x1C,
  0x03, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0x7F, 0x8F, 0xF8, 0x01, 0xC0, 0xF0, 0x7C, 0x1C, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x1C, 0x0F, 0x07, 0x83, 0xC0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0C, 0x03, 0x00, 0xF0, 0x3C, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0C, 0x07, 0x87, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0C, 0x0E,
  0x03, 0x81, 0xE0, 0xF0, 0xF0, 0xE0, 0x70, 0x38, 0x18, 0x1C, 0x0E, 0x1F,
  0x0F, 0x07, 0x00, 0x38, 0x1F, 0xE3, 0xFF, 0xF8, 0x3E,
};

const GFXglyph NotoSans_SemiCondensed_SemiBoldItalic25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 7, 18, 7, 0, -18 },
  { 17, 9, 7, 10, 2, -18 },
  { 25, 15, 18, 14, 0, -18 },
  { 59, 13, 20, 13, 0, -19 },
  { 92, 17, 18, 19, 1, -18 },
  { 131, 15, 18, 15, 0, -18 },
  { 165, 3, 7, 6, 3, -18 },
  { 168, 8, 22, 8, 1, -18 },
  { 190, 9, 22, 8, -2, -18 },
  { 215, 11, 11, 12, 2, -19 },
  { 231, 12, 12, 13, 1, -15 },
  { 249, 5, 6, 6, -1, -3 },
  { 253, 7, 3, 8, 0, -8 },
  { 256, 4, 4, 6, 0, -4 },
  { 258, 13, 18, 10, -1, -18 },
  { 288, 11, 18, 13, 1, -18 },
  { 313, 8, 18, 13, 3, -18 },
  { 331, 13, 18, 13, -1, -18 },
  { 361, 12, 18, 13, 0, -18 },
  { 388, 12, 18, 13, 0, -18 },
  { 415, 13, 18, 13, 0, -18 },
  { 445, 12, 18, 13, 1, -18 },
  { 472, 12, 18, 13, 1, -18 },
  { 499, 13, 18, 13, 0, -18 },
  { 529, 11, 18, 13, 1, -18 },
  { 554, 6, 14, 6, 0, -14 },
  { 565, 7, 17, 6, -1, -14 },
  { 580, 12, 12, 13, 1, -15 },
  { 598, 11, 7, 13, 1, -12 },
  { 608, 12, 12, 13, 1, -15 },
  { 626, 10, 18, 10, 1, -18 },
  { 649, 18, 20, 19, 1, -18 },
  { 694, 14, 18, 14, -2, -18 },
  { 726, 14, 18, 14, 0, -18 },
  { 758, 14, 18, 13, 1, -18 },
  { 790, 15, 18, 15, 0, -18 },
  { 824, 13, 18, 12, 0, -18 },
  { 854, 13, 18, 11, 0, -18 },
  { 884, 15, 18, 16, 1, -18 },
  { 918, 16, 18, 16, 0, -18 },
  { 954, 11, 18, 8, -1, -18 },
  { 979, 11, 23, 7, -4, -18 },
  { 1011, 16, 18, 13, 0, -18 },
  { 1047, 10, 18, 11, 0, -18 },
  { 1070, 20, 18, 20, 0, -18 },
  { 1115, 17, 18, 17, 0, -18 },
  { 1154, 15, 18, 16, 1, -18 },
  { 1188, 14, 18, 13, 0, -18 },
  { 1220, 15, 22, 16, 1, -18 },
  { 1262, 13, 18, 14, 0, -18 },
  { 1292, 13, 18, 12, 0, -18 },
  { 1322, 12, 18, 12, 2, -18 },
  { 1349, 15, 18, 15, 1, -18 },
  { 1383, 13, 18, 13, 2, -18 },
  { 1413, 20, 18, 20, 2, -18 },
  { 1458, 16, 18, 13, -1, -18 },
  { 1494, 13, 18, 12, 2, -18 },
  { 1524, 14, 18, 12, -1, -18 },
  { 1556, 10, 22, 8, -1, -18 },
  { 1584, 5, 18, 10, 3, -18 },
  { 1596, 10, 22, 8, -2, -18 },
  { 1624, 12, 11, 13, 0, -18 },
  { 1641, 9, 2, 9, -2, 2 },
  { 1644, 4, 4, 7, 4, -19 },
  { 1646, 12, 14, 13, 1, -14 },
  { 1667, 13, 19, 13, 0, -19 },
  { 1698, 10, 14, 11, 1, -14 },
  { 1716, 13, 19, 13, 1, -19 },
  { 1747, 11, 14, 12, 1, -14 },
  { 1767, 14, 25, 8, -3, -19 },
  { 1811, 13, 20, 13, 0, -14 },
  { 1844, 12, 19, 13, 0, -19 },
  { 1873, 7, 19, 6, 0, -19 },
  { 1890, 10, 25, 6, -3, -19 },
  { 1922, 13, 19, 12, 0, -19 },
  { 1953, 7, 19, 6, 0, -19 },
  { 1970, 19, 14, 20, 0, -14 },
  { 2004, 12, 14, 13, 0, -14 },
  { 2025, 11, 14, 13, 1, -14 },
  { 2045, 14, 20, 13, -1, -14 },
  { 2080, 12, 20, 13, 1, -14 },
  { 2110, 10, 14, 9, 0, -14 },
  { 2128, 10, 14, 10, 0, -14 },
  { 2146, 8, 17, 9, 1, -17 },
  { 2163, 12, 14, 13, 1, -14 },
  { 2184, 12, 14, 11, 1, -14 },
  { 2205, 17, 14, 17, 2, -14 },
  { 2235, 14, 14, 12, -1, -14 },
  { 2260, 15, 20, 11, -2, -14 },
  { 2298, 12, 14, 10, -1, -14 },
  { 2319, 10, 22, 9, 0, -18 },
  { 2347, 2, 25, 12, 5, -19 },
  { 2354, 9, 22, 9, -1, -18 },
  { 2379, 12, 4, 13, 1, -11 },
};

const GFXfont NotoSans_SemiCondensed_SemiBoldItalic25pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_SemiBoldItalic25pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_SemiBoldItalic25pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC25PT7B_H_
