#ifndef _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC32PT7B_H_
#define _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC32PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-SemiBoldItalic.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_SemiBoldItalic32pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x83, 0xC3, 0xE1, 0xF0, 0xF0, 0x78, 0x3C, 0x1C, 0x1E, 0x0F,
  0x07, 0x83, 0x81, 0xC0, 0xE0, 0xF0, 0x70, 0x00, 0x00, 0x00, 0x0F, 0x0F,
  0x87, 0xC1, 0xC0, 0x79, 0xEF, 0x3D, 0xC7, 0x38, 0xE7, 0x1C, 0xE7, 0x38,
  0xE7, 0x1C, 0x01, 0xC3, 0x00, 0x71, 0xC0, 0x1C, 0x70, 0x06, 0x18, 0x03,
  0x8E, 0x00, 0xE3, 0x80, 0x38, 0xE0, 0xFF, 0xFF, 0x3F, 0xFF, 0xD1, 0xC7,
  0x00, 0x61, 0x80, 0x38, 0xE0, 0x0E, 0x38, 0x03, 0x0E, 0x0F, 0xFF, 0xF3,
  0xFF, 0xFC, 0x1C, 0x70, 0x0E, 0x18, 0x03, 0x8E, 0x00, 0xE3, 0x80, 0x30,
  0xC0, 0x1C, 0x70, 0x07, 0x1C, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x07, 0xC0,
  0x3F, 0xF0, 0xFF, 0xE3, 0xFF, 0x8F, 0x31, 0x1E, 0x60, 0x3C, 0x80, 0x7F,
  0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7E, 0x00, 0xFE, 0x01, 0xBC,
  0x03, 0x38, 0x04, 0xF2, 0x19, 0xE7, 0xFF, 0x8F, 0xFF, 0x1F, 0xF8, 0x03,
  0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x0F, 0x00, 0x70, 0xFE, 0x03,
  0x83, 0xFC, 0x1C, 0x1C, 0x70, 0x70, 0x71, 0xC3, 0x83, 0xC7, 0x1C, 0x0E,
  0x1C, 0x70, 0x38, 0xE3, 0x80, 0xE3, 0x9C, 0x03, 0x8E, 0x73, 0xCE, 0x73,
  0xBF, 0xBF, 0xDC, 0xFE, 0x7E, 0x77, 0x3D, 0xF3, 0x9C, 0x70, 0x1C, 0xE1,
  0xC0, 0x73, 0x8E, 0x03, 0x8E, 0x38, 0x1C, 0x38, 0xE0, 0x70, 0xE3, 0x83,
  0x83, 0x9C, 0x1C, 0x0F, 0xF0, 0x70, 0x3F, 0x83, 0x80, 0x7C, 0x00, 0x01,
  0xF8, 0x00, 0xFF, 0x00, 0x7F, 0xE0, 0x3C, 0x78, 0x0F, 0x1E, 0x03, 0x87,
  0x80, 0xE1, 0xC0, 0x3C, 0xF0, 0x0F, 0x78, 0x01, 0xFC, 0x00, 0x7E, 0x00,
  0x7F, 0x07, 0x3F, 0xC3, 0xDF, 0x78, 0xEF, 0x9F, 0x7B, 0xC3, 0xFC, 0xF0,
  0x7F, 0x3C, 0x1F, 0x8F, 0x03, 0xC3, 0xC3, 0xF8, 0xFF, 0xFE, 0x1F, 0xFF,
  0xC3, 0xF8, 0xF8, 0x7B, 0xDE, 0xE7, 0x3B, 0x9C, 0x01, 0xE0, 0x78, 0x0E,
  0x03, 0x80, 0xF0, 0x1C, 0x07, 0x80, 0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x3C,
  0x07, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x3C, 0x07, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x1C, 0x00, 0x03,
  0x80, 0x70, 0x0F, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x1E, 0x03, 0xC0, 0x70,
  0x1E, 0x03, 0xC0, 0x70, 0x1E, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x01, 0xC0,
  0x78, 0x00, 0x03, 0xC0, 0x1C, 0x10, 0xE0, 0xC7, 0x0F, 0xB0, 0x7F, 0xFC,
  0x7F, 0xE1, 0xFF, 0x1F, 0x81, 0xEC, 0x1E, 0x70, 0x63, 0x81, 0x1E, 0x00,
  0x80, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x00, 0x1E, 0x3C, 0x79, 0xE3, 0xC7, 0x1C, 0x78, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFE, 0xE0, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0x80,
  0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E,
  0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x0F, 0xF8, 0x3F, 0xF0,
  0xF9, 0xE1, 0xE1, 0xE7, 0x83, 0xCF, 0x07, 0x9C, 0x0F, 0x78, 0x1E, 0xF0,
  0x3D, 0xE0, 0x7F, 0x81, 0xEF, 0x03, 0xDE, 0x07, 0xBC, 0x0F, 0x78, 0x3C,
  0xF0, 0x79, 0xE0, 0xF3, 0xC3, 0xC7, 0xCF, 0x87, 0xFE, 0x0F, 0xF8, 0x0F,
  0xE0, 0x00, 0x01, 0xE0, 0x7C, 0x1F, 0x8F, 0xE3, 0xFD, 0xFF, 0x9C, 0xF1,
  0x1E, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x00, 0x00, 0xFC,
  0x01, 0xFF, 0x03, 0xFF, 0xC0, 0xF1, 0xF0, 0x60, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0xFF, 0xC3, 0xFF, 0xE3, 0xFF, 0xF0, 0x03,
  0xF8, 0x0F, 0xFE, 0x0F, 0xFE, 0x0E, 0x1F, 0x04, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x07, 0xF0, 0x07, 0xE0, 0x07,
  0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x7C, 0xC0, 0xF8, 0xFF, 0xF0, 0xFF, 0xF0, 0x7F, 0xC0, 0x00, 0x0F, 0x00,
  0x1F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xDC, 0x03,
  0x9C, 0x07, 0xBC, 0x07, 0x3C, 0x0E, 0x3C, 0x1C, 0x38, 0x3C, 0x38, 0x38,
  0x78, 0x70, 0x78, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x03, 0xFF, 0x07, 0xFF, 0x07,
  0xFF, 0x07, 0xFE, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E,
  0x00, 0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0xFC, 0x00, 0x7C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0xC0, 0xF8, 0xFF,
  0xF0, 0xFF, 0xE0, 0x7F, 0xC0, 0x00, 0x7F, 0x01, 0xFE, 0x03, 0xFE, 0x07,
  0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0xC0, 0x7B,
  0xF0, 0x7F, 0xF8, 0x7F, 0xFC, 0x7C, 0x3C, 0xF8, 0x3C, 0xF0, 0x3C, 0xF0,
  0x3C, 0xF0, 0x3C, 0xF0, 0x78, 0xF0, 0x78, 0x78, 0xF0, 0x7F, 0xF0, 0x3F,
  0xE0, 0x1F, 0xC0, 0x1F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFE, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F,
  0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF8,
  0x00, 0x03, 0xF8, 0x0F, 0xF8, 0x3F, 0xF8, 0xF0, 0xF1, 0xE1, 0xE3, 0x83,
  0xC7, 0x07, 0x8F, 0x0F, 0x1E, 0x3C, 0x1F, 0xF0, 0x1F, 0x80, 0x7F, 0x03,
  0xFF, 0x0F, 0x9F, 0x3E, 0x1E, 0x78, 0x3C, 0xF0, 0x39, 0xC0, 0x73, 0xC1,
  0xE7, 0x83, 0xCF, 0xFF, 0x0F, 0xFC, 0x0F, 0xF0, 0x00, 0x03, 0xF0, 0x1F,
  0xF0, 0x7F, 0xF0, 0xF1, 0xE3, 0xC1, 0xC7, 0x83, 0xDE, 0x07, 0xBC, 0x0F,
  0x78, 0x3E, 0xF0, 0x79, 0xE1, 0xF3, 0xE7, 0xE3, 0xFF, 0xC7, 0xF7, 0x83,
  0xCE, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x07, 0x84, 0x1F, 0x0F, 0xFC,
  0x1F, 0xF0, 0x3F, 0x80, 0x00, 0x04, 0x0F, 0x1F, 0x1F, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0xF8, 0xF8, 0xF0, 0x01,
  0x00, 0xF0, 0x7C, 0x1F, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x78, 0x1C, 0x0F, 0x03, 0x81, 0xE0,
  0x70, 0x3C, 0x00, 0x00, 0x0C, 0x00, 0xF0, 0x0F, 0xC0, 0xFE, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0x3C, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0xFC, 0x00, 0xF0, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0x03,
  0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F,
  0x00, 0xFC, 0x0F, 0xC1, 0xFC, 0x1F, 0xC0, 0xFC, 0x03, 0xC0, 0x0C, 0x00,
  0x00, 0x1F, 0xC7, 0xFE, 0x7F, 0xF7, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x1E, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x3C, 0x03, 0x80, 0x38, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x3E, 0x01, 0xE0,
  0xF0, 0x01, 0xC1, 0xC0, 0x01, 0xC7, 0x07, 0xC3, 0x9C, 0x1F, 0xE7, 0x38,
  0xFF, 0x8E, 0xE1, 0xC7, 0x1D, 0xC7, 0x0E, 0x3B, 0x8E, 0x1C, 0x76, 0x38,
  0x70, 0xFC, 0x70, 0xE1, 0xF8, 0xE1, 0xC7, 0x71, 0xC7, 0x8E, 0xE3, 0x8F,
  0x39, 0xC7, 0xFF, 0xE3, 0x87, 0xCF, 0x83, 0x82, 0x04, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x0F, 0x00, 0x40, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x7F, 0x00, 0x1D, 0xC0, 0x0F, 0x70, 0x03, 0x9C, 0x01, 0xE7, 0x80,
  0x71, 0xE0, 0x3C, 0x78, 0x0E, 0x1E, 0x07, 0x87, 0x81, 0xFF, 0xE0, 0xFF,
  0xF8, 0x3F, 0xFE, 0x1F, 0xFF, 0x87, 0x81, 0xE3, 0xC0, 0x78, 0xF0, 0x0E,
  0x78, 0x03, 0x9E, 0x00, 0xEF, 0x00, 0x3C, 0x0F, 0xF8, 0x07, 0xFF, 0x03,
  0xFF, 0xC1, 0xE3, 0xE0, 0xE0, 0xF8, 0xF0, 0x3C, 0x78, 0x1E, 0x3C, 0x1E,
  0x1E, 0x0F, 0x1E, 0x3F, 0x0F, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0xC1, 0xC1,
  0xF1, 0xE0, 0x78, 0xF0, 0x3C, 0x78, 0x1E, 0x3C, 0x0F, 0x1C, 0x0F, 0x9E,
  0x1F, 0x8F, 0xFF, 0x87, 0xFF, 0x83, 0xFF, 0x00, 0x00, 0xFE, 0x01, 0xFF,
  0xC3, 0xFF, 0xC1, 0xF8, 0xE1, 0xF0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00,
  0x0F, 0x86, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x0F, 0xF8, 0x03,
  0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFE, 0x0E, 0x0F, 0x87, 0x81, 0xE1, 0xE0,
  0x7C, 0x78, 0x0F, 0x1E, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x3C, 0xF0, 0x1E,
  0x3C, 0x07, 0x8F, 0x01, 0xE7, 0x80, 0xF9, 0xE0, 0x3C, 0x78, 0x1F, 0x1E,
  0x07, 0x87, 0x87, 0xE3, 0xC7, 0xF0, 0xFF, 0xF8, 0x3F, 0xF8, 0x0F, 0xF8,
  0x00, 0x0F, 0xFF, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0xFE, 0x0E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F,
  0xF8, 0x3F, 0xF8, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x70, 0x00, 0xF0, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0x0F,
  0xFF, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0xFE, 0x0E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F,
  0xF8, 0x3F, 0xF0, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0x0E, 0x1F, 0x00, 0x8F, 0x80, 0x03, 0xC0,
  0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x07, 0xFB, 0xC1, 0xFC,
  0xF0, 0x7F, 0x3C, 0x3F, 0xCF, 0x00, 0xF3, 0xC0, 0x3C, 0xF0, 0x1E, 0x3C,
  0x07, 0x8F, 0x81, 0xE1, 0xF0, 0x78, 0x7F, 0xFC, 0x0F, 0xFF, 0x00, 0xFF,
  0x80, 0x0F, 0x00, 0xF0, 0xF0, 0x1E, 0x0F, 0x01, 0xE0, 0xF0, 0x1E, 0x0E,
  0x01, 0xE1, 0xE0, 0x3C, 0x1E, 0x03, 0xC1, 0xE0, 0x3C, 0x1E, 0x03, 0xC3,
  0xFF, 0xFC, 0x3F, 0xFF, 0x83, 0xFF, 0xF8, 0x3F, 0xFF, 0x83, 0xC0, 0x78,
  0x78, 0x07, 0x07, 0x80, 0xF0, 0x78, 0x0F, 0x07, 0x80, 0xF0, 0x78, 0x0F,
  0x0F, 0x01, 0xE0, 0xF0, 0x1E, 0x0F, 0x01, 0xE0, 0xF0, 0x1E, 0x00, 0x07,
  0xFC, 0x3F, 0xE0, 0x7F, 0x80, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x7F, 0x83,
  0xFE, 0x0F, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x07, 0x80, 0x1F, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x06, 0x00,
  0x00, 0x0F, 0x03, 0xE1, 0xE0, 0x78, 0x3C, 0x1E, 0x07, 0x87, 0x80, 0xE1,
  0xF0, 0x3C, 0x7C, 0x07, 0x9F, 0x00, 0xF3, 0xC0, 0x1C, 0xF0, 0x07, 0xBC,
  0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x1E, 0x3C,
  0x03, 0xC7, 0x80, 0x78, 0xF0, 0x0F, 0x0F, 0x01, 0xC1, 0xE0, 0x78, 0x3C,
  0x0F, 0x07, 0xC1, 0xE0, 0x78, 0x3C, 0x0F, 0x00, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x70, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x78, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0xC3, 0xF0,
  0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0xFC, 0x07, 0xF0, 0xFE, 0x03, 0xF8, 0x7F,
  0x03, 0xFC, 0x3B, 0x81, 0xDC, 0x1D, 0xC1, 0xFE, 0x1E, 0xE0, 0xEF, 0x0F,
  0x70, 0xF7, 0x87, 0xB8, 0x73, 0xC3, 0x9C, 0x79, 0xC1, 0xCE, 0x39, 0xE1,
  0xE7, 0xBC, 0xF0, 0xF3, 0xDC, 0x78, 0x78, 0xFE, 0x38, 0x38, 0x7E, 0x1C,
  0x1C, 0x3F, 0x1E, 0x1E, 0x1F, 0x0F, 0x0F, 0x0F, 0x87, 0x87, 0x07, 0x83,
  0x83, 0x83, 0xC3, 0xC0, 0x0F, 0x80, 0x78, 0x7C, 0x03, 0x83, 0xE0, 0x1C,
  0x1F, 0x81, 0xE0, 0xFC, 0x0F, 0x0F, 0xE0, 0x78, 0x77, 0x83, 0x83, 0xBC,
  0x1C, 0x1C, 0xE1, 0xE1, 0xE7, 0x0F, 0x0F, 0x3C, 0x78, 0x79, 0xE3, 0x83,
  0x87, 0x1C, 0x1C, 0x3D, 0xE1, 0xE1, 0xEF, 0x0F, 0x07, 0x78, 0x78, 0x3B,
  0x83, 0x81, 0xFC, 0x1C, 0x0F, 0xE1, 0xE0, 0x3F, 0x0F, 0x01, 0xF0, 0x70,
  0x0F, 0x83, 0x80, 0x7C, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0xF8,
  0x7E, 0x3E, 0x1E, 0x07, 0xCF, 0x80, 0xF3, 0xC0, 0x3D, 0xE0, 0x0F, 0x78,
  0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x01,
  0xEF, 0x00, 0x7B, 0xC0, 0x1E, 0xF0, 0x0F, 0x3C, 0x07, 0xCF, 0x81, 0xE1,
  0xF1, 0xF8, 0x7F, 0xFC, 0x0F, 0xFE, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x07,
  0xFF, 0x03, 0xFF, 0xC1, 0xE7, 0xE0, 0xE0, 0xF0, 0xF0, 0x3C, 0x78, 0x1E,
  0x3C, 0x0F, 0x1E, 0x0F, 0x1E, 0x07, 0x8F, 0x07, 0xC7, 0xFF, 0xC3, 0xFF,
  0xC1, 0xFF, 0x81, 0xFC, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0xFF, 0xC0, 0xFF, 0xF8, 0x7E, 0x3E, 0x1E, 0x07, 0xCF, 0x80, 0xF3,
  0xC0, 0x3D, 0xE0, 0x0F, 0x78, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xEF, 0x00, 0x7B, 0xC0, 0x1E, 0xF0, 0x0F,
  0x3C, 0x07, 0xCF, 0x81, 0xE1, 0xF1, 0xF8, 0x7F, 0xFC, 0x0F, 0xFE, 0x01,
  0xFE, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01,
  0xF0, 0x0F, 0xF0, 0x0F, 0xFC, 0x0F, 0xFE, 0x0F, 0x3F, 0x0E, 0x0F, 0x1E,
  0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x3C, 0x1E, 0x3C, 0x7E, 0x3F,
  0xFC, 0x3F, 0xF8, 0x3F, 0xE0, 0x78, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0x78,
  0x78, 0x70, 0x78, 0xF0, 0x78, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0x01,
  0xFC, 0x07, 0xFF, 0x0F, 0xFE, 0x0F, 0x8E, 0x1F, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x80,
  0x78, 0xE0, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0x7F, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x00, 0x1E, 0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x3C, 0x70, 0x0F, 0x3C,
  0x07, 0x8F, 0x01, 0xE3, 0xC0, 0x78, 0xF0, 0x1E, 0x78, 0x07, 0x9E, 0x03,
  0xC7, 0x80, 0xF1, 0xE0, 0x3C, 0x78, 0x0F, 0x3C, 0x03, 0xCF, 0x01, 0xE3,
  0xC0, 0x78, 0xF0, 0x1E, 0x3C, 0x0F, 0x8F, 0x03, 0xC3, 0xE1, 0xF0, 0x7F,
  0xF8, 0x1F, 0xFC, 0x01, 0xFC, 0x00, 0xF0, 0x0F, 0xF8, 0x07, 0xBC, 0x03,
  0xDE, 0x03, 0xCF, 0x01, 0xE7, 0x81, 0xE3, 0xC0, 0xF1, 0xE0, 0xF0, 0xF0,
  0x78, 0x78, 0x78, 0x1C, 0x3C, 0x0E, 0x3C, 0x07, 0x1E, 0x03, 0x9E, 0x01,
  0xCF, 0x00, 0xE7, 0x00, 0x77, 0x80, 0x3B, 0x80, 0x1F, 0xC0, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x1E, 0x03, 0xFC, 0x0F,
  0x81, 0xEF, 0x03, 0xE0, 0x7B, 0xC0, 0xF8, 0x3C, 0xF0, 0x7E, 0x0F, 0x3C,
  0x1F, 0x83, 0x8F, 0x0E, 0xE1, 0xE3, 0xC3, 0xB8, 0x78, 0xF1, 0xFE, 0x3C,
  0x3C, 0x77, 0x8F, 0x0F, 0x1D, 0xE7, 0x83, 0xCE, 0x39, 0xE0, 0xF3, 0x8E,
  0x70, 0x3D, 0xE3, 0xBC, 0x0F, 0x70, 0xEF, 0x03, 0xFC, 0x3B, 0x80, 0xFE,
  0x0F, 0xE0, 0x3B, 0x83, 0xF0, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x3E, 0x00,
  0xFC, 0x0F, 0x80, 0x3E, 0x03, 0xE0, 0x0F, 0x80, 0xF0, 0x00, 0x07, 0xC0,
  0x78, 0x1E, 0x07, 0x80, 0xF0, 0x78, 0x07, 0x83, 0xC0, 0x1E, 0x3C, 0x00,
  0xF3, 0xC0, 0x07, 0x9E, 0x00, 0x1D, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0xF3, 0x80, 0x07, 0x9E, 0x00, 0x78, 0xF0, 0x07, 0x87, 0x80,
  0x3C, 0x1E, 0x03, 0xC0, 0xF0, 0x3C, 0x07, 0x83, 0xE0, 0x3E, 0x00, 0xF0,
  0x1F, 0xF0, 0x1E, 0xF0, 0x3C, 0x70, 0x78, 0x78, 0x78, 0x78, 0xF0, 0x78,
  0xF0, 0x79, 0xE0, 0x3B, 0xC0, 0x3B, 0xC0, 0x3F, 0x80, 0x3F, 0x00, 0x3F,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x07, 0xFF, 0xC1,
  0xFF, 0xF0, 0x7F, 0xF8, 0x20, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0x80,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7F, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF,
  0x80, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1C,
  0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C,
  0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0xF8, 0x1F, 0x81, 0xFC, 0x00, 0xF0,
  0xE1, 0xC3, 0x87, 0x0E, 0x1E, 0x3C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x8F,
  0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xE3, 0xC3, 0x80, 0x03, 0xF8, 0x3F, 0x81,
  0xFC, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F,
  0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0E,
  0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x00, 0x00, 0xC0, 0x03, 0x80, 0x0F, 0x80,
  0x1F, 0x00, 0x7E, 0x00, 0xEE, 0x03, 0x9C, 0x0F, 0x38, 0x1C, 0x38, 0x70,
  0x70, 0xE0, 0xE3, 0x80, 0xE7, 0x01, 0xDC, 0x03, 0xC0, 0xFF, 0xFF, 0xFF,
  0xF3, 0xC7, 0x1E, 0x38, 0x70, 0x01, 0x80, 0x07, 0xEF, 0x1F, 0xEE, 0x1F,
  0xFE, 0x3E, 0x3E, 0x3C, 0x1E, 0x78, 0x1E, 0x78, 0x1C, 0x78, 0x3C, 0xF0,
  0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x78, 0xF0, 0xF8, 0xF8, 0xF8, 0x7F,
  0xF8, 0x7F, 0x70, 0x3E, 0x70, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x18, 0x0F, 0x7E, 0x0E, 0xFE, 0x1F,
  0xFF, 0x1F, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x1C, 0x0F, 0x3C, 0x0F, 0x3C,
  0x0F, 0x3C, 0x1E, 0x3C, 0x1E, 0x3C, 0x1E, 0x7C, 0x3C, 0x7C, 0x7C, 0x7F,
  0xF8, 0x77, 0xF0, 0xF3, 0xE0, 0x01, 0xC0, 0x3F, 0xC3, 0xFE, 0x3F, 0xE3,
  0xE0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xE1, 0x0F, 0xF8, 0x3F, 0xC0, 0xFE, 0x00, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x06, 0x3C, 0x0F, 0xDE, 0x0F, 0xEE, 0x0F, 0xFF, 0x0F, 0x8F, 0x87, 0x83,
  0xC7, 0x81, 0xE3, 0xC0, 0xE1, 0xE0, 0xF1, 0xE0, 0x78, 0xF0, 0x3C, 0x78,
  0x1C, 0x3C, 0x1E, 0x1E, 0x0F, 0x0F, 0x8F, 0x83, 0xFF, 0xC1, 0xFD, 0xC0,
  0x7C, 0xE0, 0x00, 0xC0, 0x1F, 0xE0, 0xFF, 0x87, 0xDF, 0x3C, 0x3C, 0xF0,
  0xF7, 0x83, 0xDE, 0x3E, 0x7F, 0xF3, 0xFF, 0x8F, 0xE0, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x81, 0x1F, 0xF8, 0x3F, 0xE0, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x10, 0x07, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x0F, 0x00, 0x03,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x01, 0xC0, 0x00, 0x00, 0xC0,
  0x01, 0xFB, 0xC3, 0xFD, 0xC1, 0xFF, 0xE1, 0xF1, 0xF0, 0xF0, 0x78, 0xF0,
  0x3C, 0x78, 0x1C, 0x3C, 0x1E, 0x3C, 0x0F, 0x1E, 0x07, 0x8F, 0x07, 0xC7,
  0x83, 0xC3, 0xC3, 0xE1, 0xF3, 0xF0, 0x7F, 0xF8, 0x3F, 0xB8, 0x0F, 0xBC,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x04, 0x07, 0x83, 0xCF, 0xC1, 0xFF,
  0xC0, 0xFF, 0xC0, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x18, 0x0F, 0x7E, 0x0E, 0xFE,
  0x1F, 0xFF, 0x1F, 0x0F, 0x1F, 0x0F, 0x1E, 0x0F, 0x1E, 0x0E, 0x3C, 0x1E,
  0x3C, 0x1E, 0x3C, 0x1E, 0x3C, 0x1E, 0x38, 0x1C, 0x78, 0x3C, 0x78, 0x3C,
  0x78, 0x3C, 0x70, 0x3C, 0xF0, 0x78, 0x03, 0x83, 0xC1, 0xE0, 0xE0, 0x00,
  0x00, 0x00, 0x1E, 0x0F, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0E, 0x0F, 0x07, 0x83, 0xC1, 0xE1, 0xE0, 0x00, 0x38, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0xF0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3C, 0x0F, 0xE0, 0x7E, 0x03, 0xF0, 0x0E,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00,
  0x78, 0x00, 0x3C, 0x02, 0x1E, 0x1E, 0x0E, 0x1E, 0x0F, 0x1E, 0x07, 0x9F,
  0x03, 0xCF, 0x01, 0xCF, 0x00, 0xEF, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x3F,
  0xE0, 0x1E, 0xF0, 0x0E, 0x3C, 0x0F, 0x1E, 0x07, 0x87, 0x83, 0xC3, 0xC1,
  0xC1, 0xE1, 0xE0, 0x78, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0E, 0x0F, 0x07, 0x83, 0xC1, 0xE1, 0xE0, 0x00, 0x18, 0x08, 0x0E, 0x7E,
  0x7E, 0x0E, 0xFE, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0x0F, 0x8F, 0x1E, 0x0F,
  0x07, 0x1E, 0x0F, 0x0F, 0x1E, 0x1E, 0x0F, 0x3C, 0x1E, 0x0F, 0x3C, 0x1E,
  0x0F, 0x3C, 0x1E, 0x0E, 0x3C, 0x1C, 0x1E, 0x38, 0x3C, 0x1E, 0x78, 0x3C,
  0x1E, 0x78, 0x3C, 0x1E, 0x78, 0x3C, 0x1C, 0x70, 0x38, 0x3C, 0xF0, 0x78,
  0x3C, 0x00, 0x38, 0x0E, 0x7E, 0x0E, 0xFE, 0x1F, 0xFF, 0x1F, 0x0F, 0x1F,
  0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x3C, 0x1E, 0x3C, 0x1E, 0x3C, 0x1E, 0x3C,
  0x1E, 0x38, 0x1C, 0x78, 0x3C, 0x78, 0x3C, 0x78, 0x3C, 0x78, 0x3C, 0xF0,
  0x78, 0x01, 0xC0, 0x0F, 0xE0, 0x3F, 0xE0, 0xFF, 0xE3, 0xC3, 0xC7, 0x83,
  0x9E, 0x07, 0xBC, 0x0F, 0x70, 0x1D, 0xE0, 0x7B, 0xC0, 0xF7, 0x81, 0xEF,
  0x03, 0xDE, 0x0F, 0x1E, 0x3E, 0x3F, 0xF8, 0x3F, 0xE0, 0x3F, 0x00, 0x00,
  0x0C, 0x03, 0x9F, 0x81, 0xDF, 0xC1, 0xFF, 0xF0, 0xF8, 0x78, 0x78, 0x3C,
  0x3C, 0x1E, 0x1C, 0x0F, 0x1E, 0x07, 0x8F, 0x03, 0xC7, 0x83, 0xC3, 0xC1,
  0xE1, 0xE0, 0xF1, 0xF0, 0xF0, 0xF8, 0xF8, 0x7F, 0xF8, 0x3B, 0xF8, 0x3C,
  0xF8, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x01, 0x80, 0x07, 0xEF, 0x0F,
  0xFE, 0x1F, 0xFE, 0x3E, 0x3E, 0x3C, 0x1E, 0x78, 0x1E, 0x78, 0x1C, 0x78,
  0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x38, 0xF0, 0x78, 0xF0, 0x78, 0xF8,
  0xF8, 0x7F, 0xF8, 0x7F, 0x70, 0x3E, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x00,
  0x18, 0x73, 0xC3, 0xBE, 0x3F, 0xF1, 0xF8, 0x0F, 0x80, 0x78, 0x03, 0xC0,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x07, 0x80, 0x00, 0x03, 0x80, 0x7F, 0xC7, 0xFE, 0x7C, 0xE3,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x03,
  0xC0, 0x1E, 0x00, 0xF2, 0x07, 0x9F, 0xFC, 0xFF, 0xC7, 0xFC, 0x00, 0x07,
  0x00, 0xE0, 0x38, 0x07, 0x07, 0xFE, 0xFF, 0xBF, 0xF1, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x1F, 0x01,
  0xFC, 0x3F, 0x83, 0xF0, 0x1E, 0x0F, 0x1C, 0x0E, 0x3C, 0x1E, 0x3C, 0x1E,
  0x3C, 0x1E, 0x38, 0x1E, 0x78, 0x1C, 0x78, 0x3C, 0x78, 0x3C, 0x78, 0x3C,
  0x70, 0x78, 0xF0, 0x78, 0xF0, 0xF8, 0xF1, 0xF8, 0x7F, 0xF8, 0x7F, 0x70,
  0x3E, 0x70, 0xE0, 0x3F, 0xC1, 0xEF, 0x07, 0xBC, 0x3C, 0xF0, 0xF3, 0xC7,
  0x8F, 0x1E, 0x3C, 0xF0, 0xF3, 0xC1, 0xDE, 0x07, 0x78, 0x1D, 0xC0, 0x7F,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x00, 0xF0, 0xF8, 0x3F, 0xC3,
  0xE1, 0xEF, 0x1F, 0x87, 0xBC, 0x7E, 0x3C, 0xF1, 0xF8, 0xF3, 0xCE, 0xE3,
  0x8F, 0x3B, 0x9E, 0x3D, 0xCE, 0x70, 0xE7, 0x3B, 0xC3, 0x9C, 0xEF, 0x0E,
  0xE3, 0xB8, 0x3B, 0x8F, 0xE0, 0xFC, 0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0xC3,
  0xE0, 0x3E, 0x0F, 0x80, 0xF8, 0x3C, 0x00, 0x1F, 0x0F, 0x87, 0x87, 0x83,
  0xC7, 0x80, 0xE7, 0x80, 0x7B, 0xC0, 0x3F, 0xC0, 0x0F, 0xC0, 0x07, 0xC0,
  0x03, 0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xFE, 0x01, 0xEF, 0x01, 0xE3,
  0xC1, 0xF1, 0xE0, 0xF0, 0xF0, 0xF0, 0x3C, 0x00, 0x07, 0x81, 0xE0, 0xF0,
  0x78, 0x1E, 0x0F, 0x03, 0xC3, 0xC0, 0x78, 0x78, 0x0F, 0x1E, 0x01, 0xE3,
  0xC0, 0x1C, 0xF0, 0x03, 0x9E, 0x00, 0x73, 0x80, 0x0E, 0xF0, 0x01, 0xDC,
  0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0xFE, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x00, 0x70, 0x00, 0x00, 0x0F, 0xFE, 0x1F, 0xF8,
  0x3F, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0xFC,
  0x3F, 0xF0, 0xFF, 0xE0, 0x00, 0x78, 0x07, 0xC0, 0x7E, 0x07, 0xC0, 0x3C,
  0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x1E, 0x07,
  0xE0, 0x3E, 0x03, 0xE0, 0x1F, 0x80, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x38,
  0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xF8, 0x07, 0xC0,
  0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x03, 0x00, 0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00,
  0x7C, 0x03, 0xC0, 0x7E, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x38, 0x03, 0xC0, 0x1E, 0x07, 0xE0, 0x3F, 0x01, 0xE0, 0x00,
  0x38, 0x07, 0xFC, 0x1F, 0xFF, 0xF1, 0xFF, 0x81, 0xF8,
};

const GFXglyph NotoSans_SemiCondensed_SemiBoldItalic32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 9, 23, 8, 0, -23 },
  { 27, 11, 8, 13, 3, -23 },
  { 38, 18, 23, 18, 1, -23 },
  { 90, 15, 26, 16, 1, -24 },
  { 139, 22, 23, 25, 2, -23 },
  { 203, 18, 23, 20, 1, -23 },
  { 255, 5, 8, 8, 3, -23 },
  { 260, 11, 28, 10, 1, -23 },
  { 299, 11, 28, 10, -2, -23 },
  { 338, 13, 14, 16, 3, -24 },
  { 361, 14, 15, 17, 2, -19 },
  { 388, 7, 8, 8, -2, -4 },
  { 395, 8, 3, 10, 1, -10 },
  { 398, 5, 4, 8, 0, -4 },
  { 401, 17, 23, 12, -2, -23 },
  { 450, 15, 23, 16, 1, -23 },
  { 494, 11, 23, 16, 3, -23 },
  { 526, 17, 23, 16, -1, -23 },
  { 575, 16, 23, 16, 0, -23 },
  { 621, 16, 23, 16, 0, -23 },
  { 667, 16, 23, 16, 0, -23 },
  { 713, 16, 23, 16, 1, -23 },
  { 759, 16, 23, 16, 1, -23 },
  { 805, 15, 23, 16, 1, -23 },
  { 849, 15, 23, 16, 1, -23 },
  { 893, 8, 18, 8, 0, -18 },
  { 911, 10, 22, 8, -2, -18 },
  { 939, 14, 15, 17, 2, -19 },
  { 966, 14, 9, 17, 2, -16 },
  { 982, 14, 15, 17, 2, -19 },
  { 1009, 12, 23, 13, 2, -23 },
  { 1044, 23, 26, 25, 1, -23 },
  { 1119, 18, 23, 17, -2, -23 },
  { 1171, 17, 23, 18, 1, -23 },
  { 1220, 17, 23, 17, 2, -23 },
  { 1269, 18, 23, 19, 1, -23 },
  { 1321, 16, 23, 15, 1, -23 },
  { 1367, 16, 23, 15, 1, -23 },
  { 1413, 18, 23, 20, 2, -23 },
  { 1465, 20, 23, 20, 1, -23 },
  { 1523, 14, 23, 11, -1, -23 },
  { 1564, 15, 30, 9, -5, -23 },
  { 1621, 19, 23, 17, 1, -23 },
  { 1676, 11, 23, 15, 1, -23 },
  { 1708, 25, 23, 25, 1, -23 },
  { 1780, 21, 23, 21, 1, -23 },
  { 1841, 18, 23, 21, 2, -23 },
  { 1893, 17, 23, 17, 1, -23 },
  { 1942, 18, 28, 21, 2, -23 },
  { 2005, 16, 23, 17, 1, -23 },
  { 2051, 16, 23, 15, 0, -23 },
  { 2097, 14, 23, 15, 3, -23 },
  { 2138, 18, 23, 20, 2, -23 },
  { 2190, 17, 23, 17, 3, -23 },
  { 2239, 26, 23, 26, 3, -23 },
  { 2314, 21, 23, 17, -2, -23 },
  { 2375, 16, 23, 16, 3, -23 },
  { 2421, 18, 23, 15, -1, -23 },
  { 2473, 13, 28, 10, -1, -23 },
  { 2519, 7, 23, 12, 3, -23 },
  { 2540, 13, 28, 10, -2, -23 },
  { 2586, 15, 14, 16, 1, -23 },
  { 2613, 12, 2, 12, -3, 3 },
  { 2616, 6, 6, 10, 5, -25 },
  { 2621, 16, 18, 17, 1, -18 },
  { 2657, 16, 24, 17, 0, -24 },
  { 2705, 13, 18, 14, 1, -18 },
  { 2735, 17, 24, 17, 1, -24 },
  { 2786, 14, 18, 16, 1, -18 },
  { 2818, 18, 32, 10, -4, -24 },
  { 2890, 17, 26, 17, 0, -18 },
  { 2946, 16, 24, 17, 0, -24 },
  { 2994, 9, 24, 8, 0, -24 },
  { 3021, 13, 32, 8, -4, -24 },
  { 3073, 17, 24, 16, 0, -24 },
  { 3124, 9, 24, 8, 0, -24 },
  { 3151, 24, 18, 26, 0, -18 },
  { 3205, 16, 18, 17, 0, -18 },
  { 3241, 15, 18, 17, 1, -18 },
  { 3275, 17, 26, 17, -1, -18 },
  { 3331, 16, 26, 17, 1, -18 },
  { 3383, 13, 18, 12, 0, -18 },
  { 3413, 13, 18, 13, 0, -18 },
  { 3443, 11, 21, 11, 1, -21 },
  { 3472, 16, 17, 17, 1, -17 },
  { 3506, 14, 17, 14, 2, -17 },
  { 3536, 22, 17, 22, 2, -17 },
  { 3583, 17, 17, 15, -1, -17 },
  { 3620, 19, 25, 15, -3, -17 },
  { 3680, 15, 17, 13, -1, -17 },
  { 3712, 13, 28, 11, 0, -23 },
  { 3758, 3, 31, 16, 6, -24 },
  { 3770, 13, 28, 11, -2, -23 },
  { 3816, 14, 5, 17, 2, -14 },
};

const GFXfont NotoSans_SemiCondensed_SemiBoldItalic32pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_SemiBoldItalic32pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_SemiBoldItalic32pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC32PT7B_H_
