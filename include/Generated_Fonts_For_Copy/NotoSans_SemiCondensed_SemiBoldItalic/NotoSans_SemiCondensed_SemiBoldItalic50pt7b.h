#ifndef _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC50PT7B_H_
#define _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC50PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-SemiBoldItalic.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_SemiBoldItalic50pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xC0,
  0x3F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xE0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x07, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8,
  0x0F, 0xC0, 0x3F, 0x00, 0x20, 0x00, 0x3F, 0x1F, 0x9F, 0x0F, 0x8F, 0x87,
  0xCF, 0xC7, 0xE7, 0xE3, 0xF3, 0xE1, 0xF1, 0xF0, 0xF8, 0xF8, 0x7C, 0x78,
  0x3C, 0x3C, 0x1E, 0x3E, 0x1F, 0x1F, 0x0F, 0x8F, 0x07, 0x80, 0x00, 0x0F,
  0x83, 0xC0, 0x00, 0x78, 0x1E, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x3E, 0x0F,
  0x00, 0x01, 0xF0, 0x78, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x78, 0x3C, 0x00,
  0x07, 0xC1, 0xE0, 0x00, 0x3C, 0x1F, 0x00, 0x01, 0xE0, 0xF8, 0x07, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0xC0, 0x1E, 0x0F, 0x80, 0x00, 0xF0, 0x7C, 0x00,
  0x0F, 0x83, 0xC0, 0x00, 0x78, 0x1E, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x3E,
  0x0F, 0x00, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x01, 0xE0, 0xF8, 0x00,
  0x1F, 0x07, 0x80, 0x00, 0xF8, 0x3C, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x3C,
  0x1E, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0xF0, 0x78,
  0x00, 0x0F, 0x83, 0xC0, 0x00, 0x78, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE,
  0x07, 0xF7, 0x1C, 0x0F, 0xC7, 0x04, 0x0F, 0xC7, 0x00, 0x0F, 0xC7, 0x00,
  0x0F, 0xCE, 0x00, 0x0F, 0xCE, 0x00, 0x0F, 0xEE, 0x00, 0x07, 0xFE, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x3B, 0xF8, 0x00, 0x39, 0xF8,
  0x00, 0x39, 0xF8, 0x00, 0x39, 0xF8, 0x00, 0x71, 0xF8, 0x80, 0x71, 0xF8,
  0xE0, 0x73, 0xF8, 0xFC, 0x77, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x3E, 0x01, 0xFF, 0x00, 0x0F, 0x00, 0xFF, 0xE0, 0x07,
  0xC0, 0x7F, 0xF8, 0x03, 0xE0, 0x1F, 0x3E, 0x00, 0xF0, 0x0F, 0x87, 0x80,
  0x7C, 0x03, 0xC1, 0xE0, 0x3E, 0x01, 0xF0, 0x78, 0x0F, 0x00, 0x7C, 0x1E,
  0x07, 0xC0, 0x1E, 0x0F, 0x83, 0xE0, 0x0F, 0x83, 0xE0, 0xF0, 0x03, 0xE0,
  0xF8, 0x7C, 0x00, 0xF8, 0x3E, 0x3E, 0x00, 0x3E, 0x0F, 0x0F, 0x00, 0x0F,
  0x87, 0xC7, 0xC7, 0xE3, 0xE1, 0xF3, 0xE3, 0xFC, 0xF8, 0xF8, 0xF1, 0xFF,
  0xBE, 0x3E, 0x7C, 0xFF, 0xEF, 0xFF, 0x3E, 0x7E, 0xFD, 0xFF, 0x8F, 0x1F,
  0x1F, 0x3F, 0xC7, 0xCF, 0x87, 0xC7, 0xE3, 0xE3, 0xE1, 0xF0, 0x00, 0xF1,
  0xF0, 0x7C, 0x00, 0x7C, 0x7C, 0x1F, 0x00, 0x3E, 0x1F, 0x07, 0xC0, 0x0F,
  0x07, 0xC1, 0xE0, 0x07, 0xC1, 0xE0, 0xF8, 0x03, 0xE0, 0x78, 0x3E, 0x00,
  0xF0, 0x3E, 0x0F, 0x80, 0x7C, 0x0F, 0x87, 0xC0, 0x3E, 0x03, 0xE1, 0xF0,
  0x0F, 0x00, 0x78, 0xF8, 0x07, 0xC0, 0x1F, 0xFE, 0x03, 0xE0, 0x07, 0xFF,
  0x00, 0xF0, 0x00, 0xFF, 0x80, 0x7C, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00,
  0x0F, 0xE7, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x3E,
  0x07, 0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x7C, 0x1F,
  0x80, 0x03, 0xE1, 0xF8, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0xFD, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x7E, 0x1F, 0xFF, 0x03, 0xF1, 0xFD, 0xF8,
  0x3F, 0x1F, 0xCF, 0xE1, 0xF9, 0xFC, 0x3F, 0x9F, 0x8F, 0xC0, 0xFC, 0xFC,
  0xFE, 0x07, 0xFF, 0xC7, 0xE0, 0x1F, 0xFC, 0x3F, 0x00, 0xFF, 0xE1, 0xF8,
  0x03, 0xFE, 0x0F, 0xC0, 0x1F, 0xE0, 0x7F, 0x00, 0xFF, 0x03, 0xF8, 0x1F,
  0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xC7, 0xF0, 0x1F, 0xF8, 0x1F, 0xC0, 0x0C, 0x00, 0x00, 0x00,
  0x3F, 0x3E, 0x3E, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0x7C, 0x78, 0xF8, 0xF8,
  0xF0, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xF0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F,
  0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x20, 0x3E, 0x00, 0xE0, 0xF0, 0x07,
  0xE3, 0xC0, 0x1F, 0xEF, 0x00, 0x7F, 0xF9, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xC0, 0x3F, 0xFF, 0x01, 0xFC, 0xFC, 0x0F, 0xF0, 0x00, 0xFD, 0xE0,
  0x07, 0xE7, 0x80, 0x3F, 0x9F, 0x00, 0xFC, 0x7C, 0x01, 0xE0, 0xF8, 0x03,
  0x83, 0xF0, 0x04, 0x0F, 0x00, 0x00, 0x10, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x0F, 0xC3, 0xF0, 0xFC, 0x7E, 0x1F, 0x8F, 0xC3, 0xF0, 0xF8,
  0x7E, 0x1F, 0x0F, 0xC3, 0xE0, 0xF0, 0x00, 0x7F, 0xFB, 0xFF, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0x00, 0x1E, 0x3F, 0x7F, 0x7F, 0xFF, 0x7E, 0x7E, 0x30,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xE0, 0x03,
  0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFE, 0x1F, 0x83, 0xF8,
  0x3F, 0x07, 0xE0, 0x3F, 0x1F, 0xC0, 0x7E, 0x3F, 0x00, 0xFC, 0xFE, 0x01,
  0xF9, 0xF8, 0x03, 0xF3, 0xF0, 0x07, 0xEF, 0xE0, 0x0F, 0xDF, 0x80, 0x3F,
  0xBF, 0x00, 0x7E, 0x7E, 0x00, 0xFD, 0xFC, 0x01, 0xFB, 0xF0, 0x03, 0xF7,
  0xE0, 0x07, 0xEF, 0xC0, 0x1F, 0xDF, 0x80, 0x3F, 0x3F, 0x00, 0x7E, 0x7E,
  0x00, 0xFC, 0xFC, 0x03, 0xF1, 0xF8, 0x07, 0xE3, 0xF0, 0x1F, 0xC7, 0xE0,
  0x3F, 0x0F, 0xC0, 0xFE, 0x1F, 0x81, 0xF8, 0x3F, 0x87, 0xF0, 0x3F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0x80,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x1F,
  0xE0, 0x3F, 0xF0, 0x3F, 0xF8, 0x7F, 0xFC, 0x7F, 0xFE, 0xFF, 0xBE, 0x3F,
  0xBF, 0x1F, 0x1F, 0x87, 0x0F, 0xC1, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0x80, 0x7E, 0x0F, 0xE0, 0x1E, 0x01, 0xF8, 0x03, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0x03,
  0xFC, 0x06, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0x84, 0x00, 0x1F, 0xC3, 0x80, 0x1F, 0xE1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xBE, 0x00, 0x0F, 0xBF, 0x00, 0x07, 0xDF,
  0x80, 0x07, 0xCF, 0x80, 0x07, 0xCF, 0xC0, 0x07, 0xE7, 0xE0, 0x03, 0xE3,
  0xF0, 0x03, 0xE1, 0xF0, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0xFC, 0x03, 0xF0,
  0x7E, 0x01, 0xF0, 0x3F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x81, 0xF8,
  0x0F, 0xC0, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xFF,
  0xFE, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x80, 0x07,
  0xF0, 0xE0, 0x1F, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF,
  0xFE, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3F, 0x1F, 0x80, 0x3F, 0x7F, 0xE0, 0x3E, 0xFF, 0xF0, 0x7F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF8, 0x7F, 0xC3, 0xF8, 0x7F, 0x01, 0xF8, 0xFE, 0x01,
  0xF8, 0xFE, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01,
  0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x03, 0xF0, 0xFC, 0x03,
  0xF0, 0xFE, 0x07, 0xF0, 0x7E, 0x0F, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF,
  0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xC0,
  0x00, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xFD, 0xFF, 0x03, 0xF0, 0x7F,
  0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x3F,
  0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x03, 0xF1, 0xFC,
  0x03, 0xFB, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xE7, 0xF0, 0x3F, 0x83, 0xF0,
  0x7F, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x00, 0xFC,
  0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8,
  0xFE, 0x03, 0xF8, 0x7F, 0x8F, 0xF0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0,
  0x1F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x40, 0x00, 0x00, 0x3F, 0xC0,
  0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0,
  0xFE, 0x1F, 0xC3, 0xF8, 0x1F, 0x87, 0xE0, 0x3F, 0x1F, 0x80, 0x7E, 0x3F,
  0x00, 0xFC, 0x7E, 0x01, 0xF9, 0xF8, 0x03, 0xF3, 0xF0, 0x07, 0xE7, 0xE0,
  0x0F, 0xCF, 0xC0, 0x3F, 0x9F, 0x80, 0x7F, 0x3F, 0x81, 0xFE, 0x3F, 0x07,
  0xFC, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0x9F,
  0x80, 0xFE, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x20,
  0x0F, 0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xF8, 0x03, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xC0, 0x3F, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x7F, 0x07, 0xF0, 0x7F, 0x0F, 0xF0, 0xFE,
  0x07, 0xE0, 0x18, 0x00, 0x00, 0x18, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x03,
  0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xE0,
  0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF,
  0xC0, 0x0F, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x07,
  0xFF, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x03, 0xFE, 0x03, 0xFF, 0xE1, 0xFF, 0xFE, 0x1F,
  0xFF, 0xE3, 0xFF, 0xFC, 0x78, 0x1F, 0xC4, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xF8, 0x01,
  0xF8, 0x00, 0x07, 0xC0, 0x3F, 0x00, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x03,
  0xE0, 0x7C, 0x00, 0x00, 0x1E, 0x0F, 0x80, 0x7F, 0xC1, 0xE1, 0xF0, 0x1F,
  0xFE, 0x1F, 0x1F, 0x03, 0xFF, 0xE1, 0xF3, 0xE0, 0x7F, 0xFE, 0x1F, 0x3E,
  0x0F, 0x83, 0xC1, 0xF3, 0xC1, 0xF0, 0x3C, 0x1F, 0x7C, 0x1E, 0x07, 0xC1,
  0xF7, 0x83, 0xE0, 0x7C, 0x1F, 0x78, 0x3C, 0x07, 0x81, 0xEF, 0x87, 0xC0,
  0x78, 0x1E, 0xF8, 0x7C, 0x0F, 0x81, 0xEF, 0x87, 0x80, 0xF8, 0x3E, 0xF0,
  0x78, 0x0F, 0x03, 0xCF, 0x07, 0x81, 0xF0, 0x7C, 0xF0, 0x78, 0x1F, 0x07,
  0x8F, 0x07, 0xC3, 0xF0, 0xF8, 0xF0, 0x7C, 0x7F, 0x1F, 0x0F, 0x87, 0xFF,
  0xFF, 0xE0, 0xF8, 0x3F, 0xE7, 0xFC, 0x0F, 0x81, 0xFC, 0x3F, 0x80, 0x78,
  0x07, 0x01, 0xC0, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x80, 0x01, 0xFC, 0x00,
  0x38, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0x7C, 0x00,
  0x07, 0xEF, 0x80, 0x00, 0xF9, 0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xE7,
  0xE0, 0x00, 0xF8, 0xFC, 0x00, 0x3F, 0x1F, 0x80, 0x07, 0xC3, 0xF0, 0x01,
  0xF8, 0x7E, 0x00, 0x3E, 0x0F, 0xC0, 0x0F, 0xC0, 0xF8, 0x01, 0xF0, 0x1F,
  0x00, 0x7E, 0x03, 0xE0, 0x0F, 0xC0, 0x7C, 0x03, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC,
  0x1F, 0x80, 0x1F, 0x87, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x3F, 0x00,
  0x0F, 0xC7, 0xE0, 0x01, 0xF9, 0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x07, 0xEF,
  0xE0, 0x00, 0xFD, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xF0, 0x01, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFC, 0x07, 0xE0, 0xFF, 0x80, 0xFC, 0x07, 0xF8, 0x1F, 0x80,
  0x7F, 0x03, 0xF0, 0x0F, 0xE0, 0x7E, 0x01, 0xFC, 0x1F, 0x80, 0x3F, 0x03,
  0xF0, 0x07, 0xE0, 0x7E, 0x01, 0xFC, 0x0F, 0xC0, 0x3F, 0x03, 0xF8, 0x1F,
  0xC0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0xFE,
  0x07, 0xE0, 0x0F, 0xC0, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x07, 0xE0,
  0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x83, 0xF0, 0x07, 0xE0,
  0xFC, 0x01, 0xFC, 0x1F, 0x80, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0x83, 0xE0, 0x7F, 0x80, 0x10, 0x3F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF8, 0x06, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x07,
  0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xF0,
  0x1F, 0xE0, 0x3F, 0x00, 0xFE, 0x03, 0xF0, 0x07, 0xF0, 0x3F, 0x00, 0x7F,
  0x07, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x7E,
  0x00, 0x3F, 0x0F, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x03,
  0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xF1, 0xFC, 0x00, 0x7F, 0x1F,
  0x80, 0x07, 0xE1, 0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xE1, 0xF8, 0x00,
  0xFC, 0x3F, 0x80, 0x1F, 0xC3, 0xF0, 0x01, 0xFC, 0x3F, 0x00, 0x3F, 0x83,
  0xF0, 0x07, 0xF0, 0x3F, 0x00, 0xFF, 0x07, 0xE0, 0x3F, 0xE0, 0x7E, 0x0F,
  0xFC, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF8, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x80, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x03,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F,
  0xF0, 0x7E, 0x07, 0xF8, 0x00, 0xC0, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFE, 0x03, 0xFF, 0xCF, 0xE0, 0x3F, 0xFC, 0xFE, 0x03, 0xFF, 0xCF,
  0xC0, 0x3F, 0xF8, 0xFC, 0x03, 0xFF, 0x8F, 0xC0, 0x7F, 0xF8, 0xFC, 0x00,
  0x1F, 0x8F, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0,
  0xFC, 0x00, 0x3F, 0x0F, 0xE0, 0x03, 0xF0, 0xFE, 0x00, 0x7F, 0x07, 0xF0,
  0x07, 0xE0, 0x7F, 0x80, 0x7E, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0xFC, 0x07,
  0xE0, 0x03, 0xF8, 0x0F, 0xC0, 0x07, 0xE0, 0x1F, 0x80, 0x0F, 0xC0, 0x7F,
  0x00, 0x1F, 0x80, 0xFC, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0xFE, 0x03, 0xF0,
  0x01, 0xF8, 0x07, 0xE0, 0x03, 0xF0, 0x1F, 0xC0, 0x07, 0xE0, 0x3F, 0x00,
  0x0F, 0xC0, 0x7E, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x7E, 0x01, 0xF8, 0x00,
  0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x01, 0xF8, 0x00, 0x7E,
  0x03, 0xF0, 0x01, 0xFC, 0x07, 0xE0, 0x03, 0xF0, 0x0F, 0xC0, 0x07, 0xE0,
  0x3F, 0x80, 0x0F, 0xC0, 0x7E, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x7E, 0x01,
  0xF8, 0x00, 0xFC, 0x03, 0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0x03, 0xF0, 0x1F,
  0x80, 0x0F, 0xE0, 0x3F, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x3F, 0x00, 0xFC,
  0x00, 0x7E, 0x03, 0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0x00,
  0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0x7F,
  0xE0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00,
  0x03, 0xFC, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x3F,
  0xFF, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x83, 0xFC, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x01, 0xFC, 0x01, 0xFC, 0x07, 0xE0, 0x0F, 0xE0, 0x1F,
  0x80, 0x3F, 0x80, 0x7E, 0x01, 0xFC, 0x01, 0xF8, 0x0F, 0xE0, 0x0F, 0xC0,
  0x7F, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x7F,
  0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x7E, 0x1F, 0xC0, 0x01, 0xF8, 0xFE, 0x00,
  0x07, 0xE7, 0xF0, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0x7C, 0xFE, 0x00, 0x03,
  0xF7, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xBF,
  0x00, 0x01, 0xF8, 0xFE, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0xFC, 0x1F, 0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xC0, 0xFC, 0x00,
  0x3F, 0x03, 0xF8, 0x01, 0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x1F, 0x80, 0x1F,
  0x80, 0x7F, 0x00, 0x7E, 0x01, 0xFC, 0x01, 0xF0, 0x03, 0xF0, 0x0F, 0xC0,
  0x0F, 0xE0, 0x3F, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x07,
  0xFC, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x1F,
  0xF0, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x03,
  0xFF, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x07,
  0xFE, 0x00, 0x7F, 0xF8, 0x1F, 0xFC, 0x00, 0xFB, 0xE0, 0x3F, 0xF8, 0x03,
  0xFF, 0xC0, 0x7D, 0xF0, 0x07, 0xDF, 0x80, 0xF9, 0xE0, 0x1F, 0xBF, 0x03,
  0xF3, 0xE0, 0x3E, 0x7C, 0x07, 0xE7, 0xC0, 0xFC, 0xF8, 0x0F, 0xCF, 0x81,
  0xF3, 0xF0, 0x1F, 0x1F, 0x07, 0xE7, 0xE0, 0x3E, 0x3E, 0x0F, 0x8F, 0xC0,
  0xFC, 0x7C, 0x3F, 0x1F, 0x01, 0xF8, 0xF8, 0x7C, 0x3E, 0x03, 0xF1, 0xF1,
  0xF8, 0xFC, 0x07, 0xC3, 0xE3, 0xE1, 0xF8, 0x0F, 0x87, 0xCF, 0xC3, 0xF0,
  0x3F, 0x0F, 0x9F, 0x07, 0xC0, 0x7E, 0x1F, 0x7E, 0x1F, 0x80, 0xFC, 0x3E,
  0xF8, 0x3F, 0x01, 0xF0, 0x7F, 0xF0, 0x7E, 0x03, 0xE0, 0x7F, 0xC0, 0xFC,
  0x0F, 0xC0, 0xFF, 0x81, 0xF0, 0x1F, 0x81, 0xFE, 0x07, 0xE0, 0x3E, 0x03,
  0xFC, 0x0F, 0xC0, 0x7C, 0x07, 0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0xE0, 0x3E,
  0x03, 0xF0, 0x1F, 0x80, 0x7C, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x1F, 0x80, 0xFF, 0x00, 0x0F, 0xC0, 0x7F, 0x80, 0x07, 0xE0,
  0x3F, 0xC0, 0x03, 0xE0, 0x1F, 0xE0, 0x01, 0xF0, 0x1F, 0xF8, 0x01, 0xF8,
  0x0F, 0xFC, 0x00, 0xFC, 0x07, 0xFE, 0x00, 0x7C, 0x03, 0xFF, 0x80, 0x3E,
  0x01, 0xFF, 0xC0, 0x3F, 0x01, 0xFB, 0xE0, 0x1F, 0x80, 0xF9, 0xF0, 0x0F,
  0xC0, 0x7C, 0xFC, 0x07, 0xC0, 0x3E, 0x7E, 0x03, 0xE0, 0x3F, 0x1F, 0x03,
  0xF0, 0x1F, 0x8F, 0xC1, 0xF8, 0x0F, 0xC7, 0xE0, 0xFC, 0x07, 0xC1, 0xF0,
  0x7C, 0x03, 0xE0, 0xF8, 0x3E, 0x03, 0xF0, 0x7E, 0x3F, 0x01, 0xF8, 0x3F,
  0x1F, 0x80, 0xFC, 0x0F, 0x8F, 0xC0, 0x7C, 0x07, 0xE7, 0xC0, 0x3E, 0x03,
  0xF3, 0xE0, 0x3F, 0x01, 0xFB, 0xF0, 0x1F, 0x80, 0x7D, 0xF8, 0x0F, 0xC0,
  0x3F, 0xF8, 0x07, 0xC0, 0x1F, 0xFC, 0x03, 0xE0, 0x07, 0xFE, 0x03, 0xF0,
  0x03, 0xFF, 0x01, 0xF8, 0x01, 0xFF, 0x80, 0xF8, 0x00, 0xFF, 0x80, 0x7C,
  0x00, 0x3F, 0xC0, 0x7E, 0x00, 0x1F, 0xE0, 0x3F, 0x00, 0x0F, 0xF0, 0x1F,
  0x80, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x03, 0xFE,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC1, 0xFC, 0x00, 0xFE, 0x1F, 0xC0, 0x03,
  0xF0, 0xFE, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0xFC, 0x7F, 0x00, 0x07, 0xE3,
  0xF0, 0x00, 0x3F, 0xBF, 0x80, 0x01, 0xF9, 0xF8, 0x00, 0x0F, 0xCF, 0xC0,
  0x00, 0x7E, 0xFE, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x1F, 0xBF, 0x80, 0x00,
  0xFD, 0xF8, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x7F, 0x7E, 0x00, 0x03, 0xF3,
  0xF0, 0x00, 0x3F, 0x9F, 0x80, 0x01, 0xFC, 0xFC, 0x00, 0x0F, 0xC7, 0xE0,
  0x00, 0xFE, 0x3F, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x07,
  0xF0, 0x3F, 0x80, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x0F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8,
  0x07, 0xE1, 0xFF, 0x80, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xF0,
  0x0F, 0xC0, 0x7E, 0x01, 0xFC, 0x1F, 0x80, 0x3F, 0x03, 0xF0, 0x07, 0xE0,
  0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x83, 0xF8, 0x07, 0xF0, 0x7E, 0x01,
  0xFC, 0x0F, 0xC0, 0x7F, 0x81, 0xF8, 0x7F, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFE, 0x03, 0xFE, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0xC1, 0xFC,
  0x00, 0xFE, 0x1F, 0xE0, 0x03, 0xF0, 0xFE, 0x00, 0x1F, 0x8F, 0xE0, 0x00,
  0xFC, 0x7F, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x3F, 0xBF, 0x80, 0x01, 0xF9,
  0xF8, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x7E, 0xFE, 0x00, 0x03, 0xF7, 0xF0,
  0x00, 0x1F, 0xBF, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x0F, 0xEF, 0xC0, 0x00,
  0x7F, 0x7E, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x3F, 0x9F, 0x80, 0x01, 0xFC,
  0xFC, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0xFE, 0x3F, 0x00, 0x07, 0xE1, 0xFC,
  0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0x80, 0x7F, 0x81, 0xFE, 0x0F,
  0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00,
  0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0xFC, 0x3F,
  0xE0, 0x3F, 0x01, 0xFC, 0x0F, 0xC0, 0x7F, 0x03, 0xF0, 0x0F, 0xC0, 0xFC,
  0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x7F, 0x07, 0xE0, 0x1F, 0x81,
  0xF8, 0x07, 0xE0, 0xFE, 0x03, 0xF8, 0x3F, 0x01, 0xFC, 0x0F, 0xC1, 0xFF,
  0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x3F,
  0x07, 0xE0, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x0F, 0xC0,
  0x3F, 0x03, 0xF8, 0x1F, 0x80, 0x7E, 0x07, 0xE0, 0x1F, 0x81, 0xF8, 0x07,
  0xF0, 0x7E, 0x00, 0xFC, 0x3F, 0x80, 0x3F, 0x0F, 0xC0, 0x0F, 0xE3, 0xF0,
  0x03, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xE0, 0xF0, 0x1F, 0xE0, 0x18,
  0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x02, 0x00, 0x3F, 0x83,
  0xC0, 0x3F, 0xC1, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0,
  0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x00, 0x18, 0x00, 0x00, 0x7F, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0x80, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x3F, 0x00,
  0x1F, 0xC1, 0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x3F,
  0x07, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0xFC, 0x1F,
  0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF8, 0x3F, 0x00,
  0x1F, 0x81, 0xF8, 0x00, 0xFC, 0x1F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x3F,
  0x07, 0xE0, 0x03, 0xF8, 0x3F, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0xFC, 0x1F,
  0x80, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x3F, 0x00,
  0x1F, 0x81, 0xF8, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x7F,
  0x07, 0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x1F, 0x81, 0xF8, 0x01, 0xFC, 0x0F,
  0xC0, 0x0F, 0xC0, 0x7F, 0x00, 0xFE, 0x03, 0xFC, 0x0F, 0xE0, 0x0F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x0F,
  0xEF, 0x80, 0x01, 0xF9, 0xF8, 0x00, 0x7F, 0x3F, 0x00, 0x0F, 0xC7, 0xE0,
  0x03, 0xF8, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x03, 0xF0,
  0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0x81, 0xF8, 0x03, 0xF0, 0x3F, 0x00,
  0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x03,
  0xF0, 0x3F, 0x00, 0x3E, 0x07, 0xE0, 0x07, 0xC1, 0xF8, 0x00, 0xF8, 0x3F,
  0x00, 0x1F, 0x0F, 0xC0, 0x03, 0xE1, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x0F,
  0x8F, 0xC0, 0x01, 0xF1, 0xF0, 0x00, 0x3E, 0x7E, 0x00, 0x07, 0xCF, 0xC0,
  0x00, 0xFB, 0xF0, 0x00, 0x1F, 0x7E, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7F,
  0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3F, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0xF8, 0x01, 0xFC, 0x00, 0xFC,
  0xF8, 0x01, 0xFC, 0x00, 0xFC, 0xF8, 0x03, 0xFC, 0x01, 0xF8, 0xF8, 0x03,
  0xFC, 0x01, 0xF8, 0xF8, 0x07, 0xFC, 0x03, 0xF0, 0xF8, 0x07, 0xFC, 0x03,
  0xF0, 0xF8, 0x07, 0xBC, 0x07, 0xE0, 0xF8, 0x0F, 0xBE, 0x07, 0xE0, 0xF8,
  0x0F, 0xBE, 0x07, 0xE0, 0xF8, 0x1F, 0x3E, 0x0F, 0xC0, 0xF8, 0x1F, 0x3E,
  0x0F, 0xC0, 0xF8, 0x3F, 0x3E, 0x1F, 0x80, 0xF8, 0x3E, 0x3E, 0x1F, 0x80,
  0xF8, 0x3E, 0x3E, 0x1F, 0x00, 0xF8, 0x7C, 0x3E, 0x3F, 0x00, 0xF8, 0x7C,
  0x3E, 0x3F, 0x00, 0xF8, 0xF8, 0x3E, 0x7E, 0x00, 0xF8, 0xF8, 0x3E, 0x7E,
  0x00, 0xF9, 0xF8, 0x3E, 0x7C, 0x00, 0xF9, 0xF0, 0x3E, 0xFC, 0x00, 0xF9,
  0xF0, 0x3E, 0xF8, 0x00, 0xFB, 0xE0, 0x3E, 0xF8, 0x00, 0xFB, 0xE0, 0x3D,
  0xF8, 0x00, 0xFF, 0xC0, 0x3D, 0xF0, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x00,
  0xFF, 0xC0, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x0F, 0xC0, 0x1F, 0x80, 0x03, 0xF0, 0x1F, 0xC0, 0x01, 0xF8, 0x0F, 0xC0,
  0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x1F, 0x87, 0xE0,
  0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x01, 0xF3, 0xF0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFD,
  0xF8, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0x7E,
  0x1F, 0x80, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x3F,
  0x01, 0xF8, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x1F,
  0x80, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x1F, 0xC0, 0x07, 0xE0, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xBF, 0x00, 0x1F, 0x9F, 0x80,
  0x1F, 0xCF, 0xC0, 0x0F, 0xC7, 0xE0, 0x0F, 0xC1, 0xF0, 0x0F, 0xE0, 0xFC,
  0x07, 0xE0, 0x7E, 0x07, 0xF0, 0x3F, 0x03, 0xF0, 0x1F, 0x83, 0xF0, 0x07,
  0xC3, 0xF8, 0x03, 0xF1, 0xF8, 0x01, 0xF9, 0xF8, 0x00, 0xFC, 0xFC, 0x00,
  0x7E, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFE, 0x04, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00,
  0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE,
  0x00, 0xF8, 0x1F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0xC1, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3F, 0x07, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xFC, 0x1F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xF0, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x7F,
  0xF0, 0x0F, 0xFE, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F,
  0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x07,
  0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3D, 0xF0, 0x00,
  0xFB, 0xE0, 0x03, 0xE7, 0xC0, 0x07, 0xC7, 0xC0, 0x1F, 0x0F, 0x80, 0x3C,
  0x1F, 0x00, 0xF8, 0x1F, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x1F, 0x00,
  0x7C, 0x3E, 0x00, 0xF8, 0xF8, 0x01, 0xF3, 0xE0, 0x01, 0xF7, 0xC0, 0x03,
  0xFF, 0x00, 0x07, 0xC0, 0x7F, 0xFF, 0xF7, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF,
  0xFF, 0xFE, 0xFE, 0x3F, 0x0F, 0xC7, 0xE1, 0xF0, 0x7C, 0x1E, 0x0F, 0x00,
  0x18, 0x00, 0x00, 0xFF, 0x1F, 0x03, 0xFF, 0x9F, 0x07, 0xFF, 0xBF, 0x0F,
  0xFF, 0xFF, 0x0F, 0xF7, 0xFE, 0x1F, 0xC1, 0xFE, 0x1F, 0x80, 0xFE, 0x3F,
  0x80, 0xFE, 0x3F, 0x00, 0xFC, 0x7F, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E,
  0x00, 0xFC, 0xFE, 0x00, 0xFC, 0xFE, 0x00, 0xF8, 0xFC, 0x01, 0xF8, 0xFC,
  0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x03, 0xF8, 0xFC, 0x03, 0xF0, 0xFC,
  0x07, 0xF0, 0xFC, 0x0F, 0xF0, 0xFE, 0x1F, 0xF0, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFB, 0xE0, 0x7F, 0xFB, 0xE0, 0x3F, 0xF3, 0xE0, 0x1F, 0xC3, 0xE0, 0x02,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0xC0, 0x07,
  0xE7, 0xF8, 0x07, 0xEF, 0xFC, 0x07, 0xDF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F,
  0xFC, 0xFF, 0x0F, 0xF0, 0x7F, 0x0F, 0xE0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F,
  0xC0, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x1F,
  0x00, 0x3F, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3F,
  0x00, 0x7E, 0x3F, 0x00, 0xFC, 0x7F, 0x00, 0xFC, 0x7F, 0x01, 0xFC, 0x7F,
  0x03, 0xF8, 0x7F, 0x83, 0xF8, 0x7F, 0xEF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFB,
  0xFF, 0xC0, 0xF9, 0xFF, 0x80, 0xF0, 0xFF, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x04, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0xE0,
  0xFF, 0xBE, 0x1F, 0xC0, 0x21, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x03, 0x07, 0xFF, 0xF0, 0x7F,
  0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x60,
  0xFC, 0x00, 0x7F, 0x1F, 0x80, 0x3F, 0xFB, 0xF0, 0x0F, 0xFF, 0x7E, 0x03,
  0xFF, 0xFF, 0x80, 0x7F, 0x9F, 0xF0, 0x1F, 0xC1, 0xFE, 0x03, 0xF0, 0x1F,
  0xC0, 0xFE, 0x03, 0xF8, 0x1F, 0x80, 0x7E, 0x07, 0xF0, 0x0F, 0xC0, 0xFC,
  0x01, 0xF8, 0x1F, 0x80, 0x3F, 0x07, 0xF0, 0x07, 0xE0, 0xFC, 0x00, 0xF8,
  0x1F, 0x80, 0x3F, 0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x0F, 0xC0,
  0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x01, 0xFC, 0x07, 0xE0, 0x3F, 0x80,
  0xFE, 0x0F, 0xF0, 0x1F, 0xF7, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFD,
  0xF0, 0x03, 0xFF, 0x3E, 0x00, 0x3F, 0x87, 0xC0, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x7F,
  0xFF, 0x87, 0xF0, 0xFC, 0x7F, 0x03, 0xE3, 0xF0, 0x1F, 0x3F, 0x00, 0xF9,
  0xF8, 0x0F, 0xDF, 0x80, 0xFE, 0xFC, 0x0F, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF,
  0xE3, 0xFF, 0xFE, 0x1F, 0xFF, 0xC0, 0xFF, 0xC0, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x02,
  0x0F, 0xE0, 0xF0, 0x7F, 0xFF, 0x81, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x1F,
  0xFC, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x87, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0F, 0xF1, 0xF0, 0x0F, 0xFE, 0x7C, 0x07, 0xFF,
  0xBF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0x7F, 0xE0, 0x7F, 0x07, 0xF8, 0x1F,
  0x80, 0xFE, 0x0F, 0xE0, 0x3F, 0x83, 0xF0, 0x0F, 0xC1, 0xFC, 0x03, 0xF0,
  0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x0F, 0xE0, 0x0F, 0xC3, 0xF8, 0x07,
  0xE0, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0x83, 0xF0,
  0x0F, 0xE0, 0xFC, 0x03, 0xF0, 0x3F, 0x01, 0xFC, 0x0F, 0xC0, 0xFF, 0x03,
  0xF8, 0x7F, 0xC0, 0xFF, 0xFF, 0xE0, 0x1F, 0xFE, 0xF8, 0x07, 0xFF, 0x7E,
  0x00, 0xFF, 0x9F, 0x80, 0x1F, 0xC7, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x20,
  0x03, 0xF8, 0x0F, 0x01, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0xC0, 0x07, 0xE3, 0xF8, 0x07, 0xEF,
  0xFC, 0x07, 0xDF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xFE, 0xFF, 0x0F, 0xF0,
  0x7F, 0x0F, 0xE0, 0x3F, 0x0F, 0xE0, 0x3F, 0x0F, 0xC0, 0x3F, 0x1F, 0xC0,
  0x3E, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x3F, 0x00,
  0x7E, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00,
  0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x7E, 0x01,
  0xF8, 0x7C, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x03, 0xF0, 0xFC, 0x03,
  0xF0, 0xFC, 0x03, 0xF0, 0x00, 0x60, 0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x3F,
  0x80, 0xFC, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x81, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x00, 0x40, 0x00, 0x1F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x8F, 0xE0, 0x0F, 0xFE,
  0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x04, 0x1F,
  0x80, 0x7E, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x1F, 0x80, 0x7C, 0x0F, 0xC0,
  0x3F, 0x07, 0xE0, 0x0F, 0xC3, 0xF8, 0x03, 0xF1, 0xFC, 0x00, 0xFC, 0xFE,
  0x00, 0x3E, 0x7F, 0x00, 0x1F, 0x9F, 0x80, 0x07, 0xEF, 0xC0, 0x01, 0xF7,
  0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x03,
  0xFF, 0xF0, 0x00, 0xFE, 0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x1F, 0x87, 0xF0,
  0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x0F, 0xE0, 0x1F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0xC0, 0xFC, 0x03, 0xF0, 0x3F,
  0x00, 0xFE, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0xC0, 0x03, 0x00, 0x3E, 0x3F, 0xC0, 0xFF, 0x01, 0xF3, 0xFF, 0x0F, 0xFC,
  0x0F, 0xBF, 0xFC, 0xFF, 0xE0, 0x7F, 0xFF, 0xEF, 0xFF, 0x87, 0xFE, 0x7F,
  0xF9, 0xFC, 0x3F, 0xC1, 0xFF, 0x07, 0xE1, 0xFC, 0x0F, 0xF0, 0x3F, 0x0F,
  0xE0, 0x7F, 0x01, 0xF8, 0x7E, 0x03, 0xF8, 0x0F, 0xC7, 0xF0, 0x1F, 0x80,
  0x7E, 0x3F, 0x00, 0xFC, 0x03, 0xF1, 0xF8, 0x07, 0xE0, 0x3F, 0x0F, 0xC0,
  0x7E, 0x01, 0xF8, 0xFC, 0x03, 0xF0, 0x0F, 0xC7, 0xE0, 0x1F, 0x80, 0x7E,
  0x3F, 0x00, 0xFC, 0x03, 0xF1, 0xF8, 0x07, 0xE0, 0x3F, 0x0F, 0xC0, 0x7E,
  0x01, 0xF8, 0xFC, 0x03, 0xF0, 0x0F, 0xC7, 0xE0, 0x1F, 0x80, 0x7E, 0x3F,
  0x00, 0xFC, 0x03, 0xE1, 0xF8, 0x07, 0xC0, 0x3F, 0x0F, 0x80, 0x7E, 0x01,
  0xF8, 0xFC, 0x03, 0xF0, 0x0F, 0xC7, 0xE0, 0x1F, 0x80, 0x7E, 0x3F, 0x00,
  0xFC, 0x03, 0xE1, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x00, 0xE0, 0x07,
  0xC3, 0xF8, 0x07, 0xCF, 0xFC, 0x07, 0xDF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0x0F, 0xF0, 0x7F, 0x0F, 0xF0, 0x3F, 0x0F, 0xE0, 0x3F, 0x1F,
  0xC0, 0x3F, 0x1F, 0xC0, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x1F,
  0x80, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3F,
  0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x01, 0xF8, 0x7E,
  0x01, 0xF8, 0x7E, 0x01, 0xF8, 0xFE, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC,
  0x03, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0x00, 0x0C, 0x00, 0x03,
  0xFF, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0xDF,
  0xE1, 0xFC, 0x1F, 0xCF, 0xE0, 0x3F, 0x3F, 0x00, 0xFD, 0xFC, 0x03, 0xF7,
  0xE0, 0x0F, 0xDF, 0x80, 0x3F, 0x7E, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xEF, 0xC0, 0x1F,
  0xBF, 0x00, 0xFE, 0xFC, 0x03, 0xF3, 0xF0, 0x1F, 0xCF, 0xE0, 0xFE, 0x1F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xC0, 0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x01, 0xFF,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x1F, 0x1F, 0xE0, 0x03,
  0xE7, 0xFE, 0x00, 0x7D, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0x3F,
  0xC0, 0x7F, 0x83, 0xF8, 0x0F, 0xE0, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x3F,
  0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x81, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0x7E,
  0x07, 0xC0, 0x0F, 0xC1, 0xF8, 0x03, 0xF8, 0x3F, 0x00, 0x7E, 0x07, 0xE0,
  0x0F, 0xC0, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x7E, 0x07, 0xF0, 0x0F, 0xC0,
  0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x03, 0xFC, 0x1F, 0xC0, 0x7F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFC, 0x03, 0xF7, 0xFF, 0x00, 0x7E, 0xFF, 0xC0, 0x0F,
  0xCF, 0xF0, 0x03, 0xF0, 0x20, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0xFF,
  0x1F, 0x03, 0xFF, 0x9F, 0x07, 0xFF, 0xDF, 0x07, 0xFF, 0xFE, 0x0F, 0xF3,
  0xFE, 0x1F, 0xC1, 0xFE, 0x1F, 0x80, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x00,
  0xFC, 0x7F, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0xFE, 0x00,
  0xFC, 0xFC, 0x00, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01,
  0xF8, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x07, 0xF0, 0xFC, 0x07,
  0xF0, 0xFE, 0x0F, 0xF0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFB, 0xE0, 0x7F, 0xF7,
  0xE0, 0x3F, 0xE7, 0xE0, 0x1F, 0xC7, 0xE0, 0x02, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xE0, 0x7C, 0x7F,
  0x07, 0xCF, 0xE0, 0x7D, 0xFE, 0x07, 0xDF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFC,
  0x40, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x1F, 0xFC, 0x03, 0xFF,
  0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xE0, 0xFE, 0x1E, 0x1F, 0xC0, 0x21, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0x80,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0xC0, 0x1F, 0x8F, 0x8F, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFE,
  0x07, 0xFF, 0x80, 0x03, 0x00, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x1F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFE, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFF, 0x70, 0xFF, 0xF0, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF0,
  0x02, 0x00, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0x80, 0x3F, 0x1F,
  0x80, 0x3E, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x1F,
  0x00, 0x7E, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3F,
  0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x7E,
  0x01, 0xF8, 0x7E, 0x01, 0xF8, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0xFC,
  0x07, 0xF0, 0xFC, 0x0F, 0xF0, 0xFE, 0x1F, 0xF0, 0xFF, 0x7F, 0xE0, 0x7F,
  0xFB, 0xE0, 0x7F, 0xFB, 0xE0, 0x3F, 0xF3, 0xE0, 0x1F, 0xC3, 0xE0, 0x02,
  0x00, 0x00, 0xF8, 0x00, 0xFF, 0xF0, 0x07, 0xEF, 0xC0, 0x1F, 0xBF, 0x00,
  0xFC, 0xFC, 0x03, 0xF3, 0xF0, 0x1F, 0x8F, 0xC0, 0x7E, 0x3F, 0x03, 0xF0,
  0xFC, 0x0F, 0xC3, 0xF0, 0x7E, 0x07, 0xC1, 0xF8, 0x1F, 0x0F, 0xC0, 0x7C,
  0x3F, 0x01, 0xF1, 0xF8, 0x07, 0xC7, 0xE0, 0x1F, 0x1F, 0x00, 0x7C, 0xFC,
  0x01, 0xF3, 0xE0, 0x07, 0xDF, 0x80, 0x1F, 0x7C, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x07, 0xF0, 0x0F, 0xFF, 0x01, 0xFC,
  0x03, 0xFF, 0xC0, 0x7F, 0x01, 0xFB, 0xF0, 0x3F, 0xC0, 0x7E, 0xFC, 0x0F,
  0xF0, 0x3F, 0x3F, 0x07, 0xFC, 0x0F, 0xCF, 0xC1, 0xEF, 0x03, 0xE3, 0xF0,
  0x7B, 0xC1, 0xF8, 0xFC, 0x3E, 0xF0, 0x7C, 0x3F, 0x0F, 0x3C, 0x3F, 0x0F,
  0xC7, 0xCF, 0x0F, 0xC3, 0xF1, 0xF3, 0xC7, 0xE0, 0xFC, 0xF8, 0xF1, 0xF8,
  0x3F, 0x3E, 0x3C, 0x7C, 0x0F, 0xCF, 0x0F, 0x3F, 0x03, 0xF7, 0xC3, 0xCF,
  0x80, 0xFD, 0xF0, 0xF7, 0xE0, 0x3E, 0xF8, 0x3D, 0xF0, 0x0F, 0xBE, 0x0F,
  0x7C, 0x03, 0xEF, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x3F, 0xE0,
  0x3F, 0xE0, 0x0F, 0xF8, 0x0F, 0xF0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x7F,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x07, 0xE0, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x0F, 0xE0, 0x7E, 0x03, 0xF8, 0x07, 0xE0, 0x7E, 0x00, 0xFC,
  0x1F, 0xC0, 0x1F, 0x87, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x3F, 0x00,
  0x07, 0xEF, 0xE0, 0x00, 0x7D, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xDF, 0x80, 0x03, 0xFB, 0xF0, 0x00, 0x7E, 0x3F, 0x00, 0x1F,
  0x87, 0xE0, 0x07, 0xF0, 0xFC, 0x01, 0xFC, 0x0F, 0xC0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x3F, 0x03, 0xF8, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x01, 0xF8,
  0x0F, 0xC0, 0x1F, 0xC0, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x1F,
  0x80, 0x7E, 0x00, 0xFC, 0x07, 0xF0, 0x07, 0xE0, 0x3F, 0x00, 0x1F, 0x03,
  0xF8, 0x00, 0xF8, 0x1F, 0x80, 0x07, 0xC0, 0xFC, 0x00, 0x3E, 0x0F, 0xC0,
  0x01, 0xF0, 0x7E, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x7E, 0x3E, 0x00, 0x03,
  0xF3, 0xF0, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x03, 0xEF,
  0x80, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xF8,
  0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x07, 0xFE, 0x00, 0x7F,
  0xC0, 0x07, 0xF8, 0x00, 0x7E, 0x00, 0x07, 0xF8, 0x00, 0xBF, 0xC0, 0x00,
  0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x70, 0x00, 0x07, 0xE0,
  0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x1F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x00, 0x07, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xE0,
  0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x0F, 0xFC, 0x00, 0xFF,
  0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0xC0, 0x07,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0x00,
  0xFF, 0xE8, 0x00, 0xFE, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_SemiBoldItalic50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 14, 37, 13, 1, -36 },
  { 66, 17, 13, 20, 5, -36 },
  { 94, 29, 36, 29, 1, -36 },
  { 225, 24, 41, 25, 1, -38 },
  { 348, 34, 36, 39, 3, -36 },
  { 501, 29, 37, 31, 1, -36 },
  { 636, 8, 13, 12, 5, -36 },
  { 649, 18, 44, 15, 1, -36 },
  { 748, 18, 44, 15, -4, -36 },
  { 847, 22, 22, 25, 4, -38 },
  { 908, 22, 24, 26, 3, -30 },
  { 974, 10, 13, 13, -2, -6 },
  { 991, 13, 5, 15, 1, -16 },
  { 1000, 8, 8, 13, 0, -7 },
  { 1008, 25, 36, 19, -2, -36 },
  { 1121, 23, 37, 25, 2, -36 },
  { 1228, 17, 36, 25, 5, -36 },
  { 1305, 26, 36, 25, -1, -36 },
  { 1422, 25, 37, 25, 0, -36 },
  { 1538, 25, 36, 25, 0, -36 },
  { 1651, 24, 37, 25, 1, -36 },
  { 1762, 24, 37, 25, 2, -36 },
  { 1873, 25, 36, 25, 2, -36 },
  { 1986, 24, 37, 25, 1, -36 },
  { 2097, 23, 37, 25, 1, -36 },
  { 2204, 12, 29, 13, 0, -28 },
  { 2248, 15, 35, 13, -3, -28 },
  { 2314, 22, 24, 26, 3, -30 },
  { 2380, 22, 15, 26, 3, -25 },
  { 2422, 22, 24, 26, 3, -30 },
  { 2488, 19, 37, 20, 3, -36 },
  { 2576, 36, 40, 38, 2, -36 },
  { 2756, 27, 36, 27, -3, -36 },
  { 2878, 27, 36, 28, 1, -36 },
  { 3000, 26, 37, 27, 3, -36 },
  { 3121, 28, 36, 30, 1, -36 },
  { 3247, 25, 36, 24, 1, -36 },
  { 3360, 25, 36, 23, 1, -36 },
  { 3473, 28, 37, 31, 3, -36 },
  { 3603, 31, 36, 31, 1, -36 },
  { 3743, 22, 36, 17, -2, -36 },
  { 3842, 23, 46, 14, -8, -36 },
  { 3975, 30, 36, 27, 1, -36 },
  { 4110, 18, 36, 23, 1, -36 },
  { 4191, 39, 36, 40, 1, -36 },
  { 4367, 33, 36, 33, 1, -36 },
  { 4516, 29, 37, 33, 3, -36 },
  { 4651, 27, 36, 27, 1, -36 },
  { 4773, 29, 45, 33, 3, -36 },
  { 4937, 26, 36, 27, 1, -36 },
  { 5054, 25, 37, 24, 0, -36 },
  { 5170, 23, 36, 23, 4, -36 },
  { 5274, 29, 37, 31, 3, -36 },
  { 5409, 27, 36, 26, 4, -36 },
  { 5531, 40, 36, 40, 5, -36 },
  { 5711, 33, 36, 26, -3, -36 },
  { 5860, 25, 36, 25, 4, -36 },
  { 5973, 27, 36, 24, -1, -36 },
  { 6095, 20, 44, 15, -1, -36 },
  { 6205, 11, 36, 19, 5, -36 },
  { 6255, 19, 44, 15, -3, -36 },
  { 6360, 23, 22, 25, 1, -36 },
  { 6424, 20, 4, 18, -5, 4 },
  { 6434, 9, 8, 15, 7, -38 },
  { 6443, 24, 29, 27, 2, -28 },
  { 6530, 24, 39, 27, 1, -38 },
  { 6647, 20, 29, 21, 2, -28 },
  { 6720, 27, 39, 27, 2, -38 },
  { 6852, 21, 29, 24, 2, -28 },
  { 6929, 28, 50, 16, -6, -38 },
  { 7104, 26, 40, 27, 0, -28 },
  { 7234, 24, 38, 27, 1, -38 },
  { 7348, 13, 38, 13, 1, -38 },
  { 7410, 20, 50, 13, -6, -38 },
  { 7535, 26, 38, 24, 1, -38 },
  { 7659, 14, 38, 13, 1, -38 },
  { 7726, 37, 28, 40, 1, -28 },
  { 7856, 24, 28, 27, 1, -28 },
  { 7940, 22, 29, 26, 2, -28 },
  { 8020, 27, 40, 27, -2, -28 },
  { 8155, 24, 40, 27, 2, -28 },
  { 8275, 20, 28, 19, 1, -28 },
  { 8345, 20, 29, 21, 0, -28 },
  { 8418, 16, 34, 17, 2, -33 },
  { 8486, 24, 28, 27, 2, -27 },
  { 8570, 22, 27, 23, 3, -27 },
  { 8645, 34, 27, 35, 3, -27 },
  { 8760, 27, 27, 23, -2, -27 },
  { 8852, 29, 39, 23, -4, -27 },
  { 8994, 22, 27, 20, -1, -27 },
  { 9069, 20, 44, 17, 0, -36 },
  { 9179, 5, 50, 24, 10, -38 },
  { 9211, 20, 44, 17, -3, -36 },
  { 9321, 22, 7, 26, 3, -21 },
};

const GFXfont NotoSans_SemiCondensed_SemiBoldItalic50pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_SemiBoldItalic50pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_SemiBoldItalic50pt7bGlyphs,
  0x20, 0x7E, 68
};

#endif // _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC50PT7B_H_
