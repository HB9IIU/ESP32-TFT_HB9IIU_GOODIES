#ifndef _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC24PT7B_H_
#define _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC24PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-SemiBoldItalic.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_SemiBoldItalic24pt7bBitmaps[] PROGMEM = {
  0x00, 0x0E, 0x3C, 0x70, 0xE1, 0xC3, 0x8E, 0x1C, 0x38, 0x70, 0xC1, 0x80,
  0x00, 0x1C, 0x78, 0xE0, 0x73, 0x77, 0x67, 0x66, 0x66, 0xE6, 0x03, 0x98,
  0x0C, 0x60, 0x33, 0x01, 0x8C, 0x06, 0x30, 0xFF, 0xF3, 0xFF, 0xC3, 0x18,
  0x0C, 0xE0, 0x33, 0x07, 0xFF, 0xBF, 0xFE, 0x19, 0x80, 0xE6, 0x03, 0x18,
  0x0C, 0xC0, 0x73, 0x00, 0x00, 0x80, 0x18, 0x0F, 0xF1, 0xFF, 0x1D, 0x23,
  0x90, 0x3B, 0x01, 0xF0, 0x1F, 0x00, 0xFC, 0x03, 0xC0, 0x7E, 0x04, 0xE8,
  0x4E, 0x77, 0xCF, 0xF8, 0x3F, 0x00, 0x80, 0x08, 0x00, 0x1E, 0x06, 0x1F,
  0x86, 0x1C, 0xC7, 0x0C, 0x63, 0x06, 0x73, 0x03, 0x3B, 0x83, 0x99, 0x91,
  0xCD, 0xBE, 0x7D, 0xDF, 0xBC, 0xD9, 0xC0, 0xCC, 0xE0, 0xE6, 0x70, 0x67,
  0x30, 0x63, 0x98, 0x71, 0xDC, 0x30, 0x7C, 0x30, 0x3C, 0x00, 0x07, 0xE0,
  0x1F, 0xE0, 0x39, 0xC0, 0x63, 0x80, 0xC7, 0x01, 0xDC, 0x03, 0xF0, 0x07,
  0xC0, 0x1F, 0x0E, 0x77, 0x39, 0xCE, 0x73, 0x8F, 0xCE, 0x1F, 0x1C, 0x1E,
  0x1C, 0x7C, 0x3F, 0xF8, 0x3F, 0x38, 0x77, 0x66, 0x6E, 0x07, 0x0E, 0x1C,
  0x18, 0x38, 0x30, 0x70, 0x60, 0xE0, 0xE0, 0xE0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xE0, 0xE0, 0x60, 0x60, 0x06, 0x07, 0x07, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x07, 0x07, 0x07, 0x06, 0x0E, 0x0C, 0x1C, 0x18,
  0x38, 0x70, 0xE0, 0x06, 0x01, 0x84, 0x63, 0xD1, 0x7F, 0xC7, 0xF3, 0xE1,
  0xD8, 0x63, 0x08, 0xC0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF8, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x00, 0x39, 0xDC, 0xE6, 0x60,
  0x7E, 0xFF, 0xF0, 0x7F, 0xE0, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x1C, 0x01,
  0xC0, 0x38, 0x03, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x38,
  0x03, 0x80, 0x70, 0x06, 0x00, 0xE0, 0x00, 0x0F, 0xC3, 0xF8, 0xF7, 0x9C,
  0x77, 0x0E, 0xE1, 0xDC, 0x3F, 0x07, 0xE0, 0xFC, 0x3B, 0x87, 0x70, 0xEE,
  0x39, 0xC7, 0x39, 0xC3, 0xF8, 0x7C, 0x00, 0x0F, 0x1E, 0x7E, 0xFE, 0xEE,
  0x8C, 0x1C, 0x1C, 0x1C, 0x1C, 0x18, 0x38, 0x38, 0x38, 0x38, 0x70, 0x70,
  0x07, 0xE0, 0xFF, 0x83, 0x9E, 0x10, 0x70, 0x03, 0x80, 0x18, 0x01, 0xC0,
  0x1C, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xFF,
  0x8F, 0xFC, 0xFF, 0xE0, 0x0F, 0xE1, 0xFE, 0x18, 0xF0, 0x07, 0x00, 0x70,
  0x0E, 0x01, 0xE0, 0xF8, 0x0F, 0x81, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0xE0,
  0x1C, 0xC3, 0xCF, 0xF8, 0xFF, 0x00, 0x00, 0xF0, 0x0F, 0x01, 0xE0, 0x3E,
  0x07, 0xE0, 0xEE, 0x0C, 0xC1, 0xDC, 0x39, 0xC7, 0x1C, 0x61, 0xCF, 0xFF,
  0xFF, 0xE0, 0x38, 0x03, 0x80, 0x38, 0x07, 0x00, 0x0F, 0xF0, 0xFF, 0x0C,
  0x01, 0xC0, 0x1C, 0x01, 0x80, 0x3F, 0x03, 0xFC, 0x3F, 0xC0, 0x1E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x1C, 0xC7, 0xCF, 0xF8, 0x7F, 0x00, 0x07, 0xE1,
  0xFC, 0x78, 0x1C, 0x03, 0x80, 0xE0, 0x1D, 0xE3, 0x7E, 0xFB, 0xDE, 0x3B,
  0x87, 0x70, 0xEE, 0x1D, 0xC7, 0x3D, 0xE3, 0xF8, 0x3E, 0x00, 0x3F, 0xF7,
  0xFF, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x70, 0x07, 0x00,
  0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x00,
  0x07, 0xE0, 0xFF, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1F, 0xE0, 0xFC,
  0x1F, 0x83, 0xFC, 0x71, 0xE7, 0x0E, 0xE0, 0xEE, 0x0E, 0x71, 0xC7, 0xFC,
  0x3F, 0x00, 0x1F, 0x87, 0xF8, 0xE7, 0x38, 0x77, 0x0E, 0xC1, 0xD8, 0x7B,
  0x8E, 0x7F, 0xCF, 0xF8, 0xF7, 0x00, 0xC0, 0x38, 0x0E, 0x23, 0xC7, 0xF0,
  0xF8, 0x00, 0x1C, 0xF3, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0x3C, 0xE0,
  0x0E, 0x3C, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE1, 0x87, 0x0C,
  0x38, 0x60, 0x00, 0x20, 0x0C, 0x07, 0x83, 0xE1, 0xF0, 0xF0, 0x38, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x30, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x80, 0x18, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x38, 0x1F, 0x1F, 0x0F, 0x83, 0xC0, 0x60, 0x00, 0x3F, 0x3F,
  0xC8, 0xE0, 0x30, 0x38, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x0C, 0x06, 0x00,
  0x00, 0x01, 0xC1, 0xE0, 0xE0, 0x00, 0x01, 0xFC, 0x03, 0xFF, 0x03, 0x81,
  0xC3, 0x00, 0x73, 0x06, 0x1B, 0x8F, 0xCD, 0x8E, 0xE6, 0xCC, 0x63, 0xC6,
  0x31, 0xE7, 0x18, 0xF3, 0x1C, 0xD9, 0x8C, 0x6C, 0xEF, 0x66, 0x3D, 0xE3,
  0x80, 0x00, 0xC0, 0x00, 0x70, 0x10, 0x1F, 0xF8, 0x03, 0xF8, 0x00, 0x00,
  0xE0, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x37, 0x03, 0xB8, 0x19, 0xC1, 0xCE,
  0x0E, 0x70, 0xE3, 0x87, 0xFC, 0x7F, 0xE3, 0x83, 0x38, 0x19, 0xC0, 0xFC,
  0x07, 0xE0, 0x38, 0x0F, 0xE0, 0x7F, 0xC3, 0x1E, 0x38, 0x71, 0xC3, 0x8E,
  0x1C, 0x71, 0xC7, 0xFC, 0x3F, 0xC1, 0xC7, 0x8E, 0x1C, 0x70, 0xE7, 0x07,
  0x38, 0x79, 0xCF, 0x8F, 0xF8, 0xFF, 0x80, 0x07, 0xF8, 0x7F, 0xC7, 0x84,
  0x78, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE3, 0x07, 0xF8, 0x1F, 0xC0, 0x0F,
  0xE0, 0x3F, 0xE0, 0xCF, 0x87, 0x0F, 0x1C, 0x1C, 0x70, 0x71, 0xC1, 0xCE,
  0x07, 0x38, 0x1C, 0xE0, 0x73, 0x83, 0x8E, 0x0E, 0x70, 0x71, 0xC3, 0xC7,
  0xFE, 0x1F, 0xF0, 0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x0C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x1C, 0x03, 0xFE, 0x3F, 0xC3, 0x80, 0x38, 0x03, 0x80, 0x70,
  0x07, 0x00, 0x7F, 0x87, 0xF8, 0xFF, 0x80, 0x0F, 0xF0, 0xFF, 0x0C, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0xFC, 0x3F, 0xC3, 0xFC, 0x38, 0x03,
  0x80, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x00, 0x03, 0xFC, 0x3F,
  0xF1, 0xF1, 0x8F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xF1,
  0xFB, 0x87, 0xEE, 0x07, 0x38, 0x1C, 0xF0, 0x71, 0xC1, 0xC7, 0xCF, 0x0F,
  0xF8, 0x1F, 0xE0, 0x0E, 0x0E, 0x1C, 0x1C, 0x30, 0x38, 0xE0, 0x71, 0xC1,
  0xC3, 0x83, 0x87, 0x07, 0x1F, 0xFE, 0x3F, 0xFC, 0x70, 0x70, 0xE0, 0xE1,
  0xC1, 0xC7, 0x03, 0x8E, 0x06, 0x1C, 0x1C, 0x38, 0x38, 0xF0, 0x70, 0x0F,
  0xE3, 0xF8, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x03, 0xF0, 0xFE, 0x00, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xC0,
  0x38, 0x7F, 0x0F, 0xC1, 0xF0, 0x00, 0x0E, 0x1E, 0x1C, 0x78, 0x30, 0xE0,
  0xE3, 0x81, 0xCE, 0x03, 0xB8, 0x07, 0xF0, 0x1D, 0xC0, 0x3F, 0x80, 0x7F,
  0x00, 0xEE, 0x01, 0xCE, 0x07, 0x1C, 0x0E, 0x38, 0x1C, 0x38, 0x38, 0x70,
  0xE0, 0xF0, 0x0E, 0x07, 0x03, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x07, 0x03, 0x81, 0xFE, 0xFF, 0xFF, 0x80, 0x0F, 0x01,
  0xE1, 0xE0, 0x7C, 0x3C, 0x0F, 0x8F, 0x83, 0xF1, 0xF0, 0x7C, 0x3E, 0x0D,
  0x86, 0xC3, 0xF1, 0xD8, 0x6E, 0x3B, 0x9D, 0xC7, 0x73, 0x30, 0xEE, 0xEE,
  0x19, 0xD9, 0xC7, 0x3F, 0x38, 0xE7, 0xC7, 0x1C, 0x78, 0xC3, 0x0E, 0x38,
  0xE1, 0xC7, 0x00, 0x0F, 0x07, 0x0F, 0x07, 0x0F, 0x07, 0x1F, 0x07, 0x1F,
  0x86, 0x1B, 0x8E, 0x19, 0x8E, 0x39, 0xCE, 0x39, 0xCE, 0x39, 0xCC, 0x38,
  0xDC, 0x30, 0xFC, 0x70, 0xFC, 0x70, 0xF8, 0x70, 0x78, 0x60, 0x78, 0xE0,
  0x78, 0x07, 0xF0, 0x3F, 0xE1, 0xE3, 0xCF, 0x07, 0x38, 0x1D, 0xC0, 0x77,
  0x01, 0xDC, 0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xB8, 0x0E, 0xE0, 0x79,
  0xC1, 0xC7, 0x9E, 0x0F, 0xF0, 0x1F, 0x80, 0x0F, 0xE0, 0x7F, 0x83, 0x1E,
  0x38, 0x71, 0xC3, 0x8E, 0x1C, 0x70, 0xE7, 0x0E, 0x3F, 0xF1, 0xFF, 0x0F,
  0xC0, 0x70, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x00, 0x07,
  0xF0, 0x3F, 0xE1, 0xE3, 0xCF, 0x07, 0x38, 0x1D, 0xE0, 0x77, 0x01, 0xDC,
  0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xB8, 0x0E, 0xE0, 0x79, 0xC1, 0xC7,
  0x9E, 0x0F, 0xF0, 0x1F, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xE0,
  0x0F, 0xE0, 0x7F, 0x83, 0x1E, 0x38, 0x71, 0xC3, 0x8E, 0x1C, 0x71, 0xC7,
  0x1E, 0x3F, 0xE1, 0xFC, 0x0E, 0x60, 0x73, 0x87, 0x1C, 0x38, 0xE1, 0xC3,
  0x8E, 0x1C, 0xE0, 0xF0, 0x07, 0xF1, 0xFF, 0x1E, 0x63, 0xC0, 0x38, 0x03,
  0xC0, 0x1C, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0xE7, 0x8F, 0xF8, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x38, 0x07, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x00, 0x1C, 0x1C, 0x70, 0x73, 0x81, 0xCE,
  0x06, 0x38, 0x38, 0xE0, 0xE3, 0x03, 0x9C, 0x0E, 0x70, 0x71, 0xC1, 0xC7,
  0x07, 0x38, 0x1C, 0xE0, 0xE3, 0xC3, 0x87, 0xBE, 0x1F, 0xF0, 0x3F, 0x80,
  0xE0, 0x7F, 0x03, 0xB8, 0x39, 0xC1, 0xCE, 0x0E, 0x30, 0xE1, 0x87, 0x0C,
  0x70, 0x63, 0x83, 0x38, 0x19, 0xC0, 0xDC, 0x06, 0xE0, 0x36, 0x01, 0xF0,
  0x0F, 0x00, 0x78, 0x00, 0xE0, 0xE0, 0xFE, 0x0E, 0x0E, 0xE1, 0xE1, 0xCE,
  0x1E, 0x1C, 0xE1, 0xE1, 0xCE, 0x3E, 0x38, 0xE3, 0x63, 0x8E, 0x76, 0x70,
  0xE6, 0x67, 0x0E, 0xE6, 0x60, 0xEC, 0x6E, 0x0E, 0xC6, 0xE0, 0xFC, 0x7C,
  0x0F, 0x87, 0xC0, 0xF8, 0x78, 0x0F, 0x07, 0x80, 0xF0, 0x70, 0x00, 0x0E,
  0x0E, 0x1C, 0x38, 0x38, 0xE0, 0x39, 0xC0, 0x77, 0x00, 0xFC, 0x01, 0xF8,
  0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0xFE, 0x01, 0xCE, 0x07,
  0x1C, 0x1E, 0x38, 0x38, 0x78, 0xE0, 0x70, 0xE0, 0xFE, 0x0E, 0x71, 0xC7,
  0x1C, 0x73, 0x87, 0x70, 0x37, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x38, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x30, 0x07, 0x00, 0x70, 0x00, 0x0F, 0xFC, 0x3F,
  0xE0, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0xFE, 0x1F,
  0xF8, 0xFF, 0xC0, 0x07, 0xC1, 0xF0, 0xE0, 0x38, 0x0E, 0x03, 0x01, 0xC0,
  0x70, 0x1C, 0x06, 0x01, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x00, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xF0, 0xFC, 0x00, 0xC6, 0x31, 0xCE, 0x73, 0x8C, 0x63,
  0x1C, 0xE7, 0x38, 0xC6, 0x38, 0x07, 0xC3, 0xF0, 0x18, 0x06, 0x03, 0x80,
  0xE0, 0x30, 0x0C, 0x07, 0x01, 0xC0, 0x70, 0x18, 0x06, 0x03, 0x80, 0xE0,
  0x38, 0x0C, 0x03, 0x01, 0xC1, 0xF0, 0xF8, 0x00, 0x03, 0x00, 0x38, 0x07,
  0x80, 0xF8, 0x0D, 0xC1, 0xCC, 0x18, 0xC3, 0x8E, 0x30, 0x6E, 0x07, 0xFF,
  0xFF, 0xC0, 0xF3, 0x8E, 0x1F, 0x73, 0xF6, 0x39, 0xE7, 0x0E, 0x70, 0xEE,
  0x0C, 0xE1, 0xCE, 0x1C, 0xE1, 0xCE, 0x3C, 0xE7, 0x8F, 0xD8, 0x79, 0x80,
  0x0E, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0xDE, 0x1B, 0xF1, 0xE7,
  0x3C, 0x73, 0x87, 0x38, 0x73, 0x07, 0x70, 0x77, 0x0E, 0x70, 0xE7, 0x9C,
  0x7F, 0xCE, 0xF0, 0x0F, 0xCF, 0xE3, 0x89, 0xC0, 0x70, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0F, 0x31, 0xFC, 0x3E, 0x00, 0x00, 0x38, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x0F, 0xB0, 0xFD, 0x87, 0x3C, 0x70, 0xE3, 0x87,
  0x38, 0x31, 0xC3, 0x8E, 0x1C, 0x70, 0xE3, 0x8F, 0x1C, 0xF0, 0xFD, 0x83,
  0xCC, 0x00, 0x0F, 0x8F, 0xF3, 0x9D, 0xC7, 0x61, 0xFB, 0xEF, 0xF3, 0x80,
  0xE0, 0x38, 0x0E, 0x11, 0xFC, 0x3F, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x70,
  0x03, 0x80, 0x18, 0x03, 0xF8, 0x3F, 0x80, 0x70, 0x03, 0x80, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x00, 0x38, 0x01, 0xC0, 0x7E, 0x03, 0xE0, 0x1E, 0x00, 0x0F, 0xB8,
  0xFD, 0x87, 0x3C, 0x70, 0xE3, 0x87, 0x38, 0x31, 0xC3, 0x8E, 0x1C, 0x70,
  0xE3, 0x8F, 0x1C, 0xF0, 0xFF, 0x83, 0xDC, 0x00, 0xE0, 0x06, 0x10, 0x70,
  0xFF, 0x87, 0xF8, 0x0F, 0x00, 0x0E, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x1C,
  0x01, 0xDE, 0x1B, 0xF1, 0xE7, 0x3C, 0x73, 0x87, 0x38, 0x73, 0x8E, 0x70,
  0xE7, 0x0E, 0x70, 0xE7, 0x0C, 0x61, 0xCE, 0x1C, 0x0E, 0x1C, 0x30, 0x00,
  0x03, 0x87, 0x1C, 0x38, 0x70, 0xE1, 0xC7, 0x0E, 0x1C, 0x38, 0x71, 0xC0,
  0x01, 0xC0, 0x70, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x38, 0x0C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x3E, 0x0F, 0x83, 0x80, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x3C, 0x73, 0x83, 0x3C, 0x3B, 0xC1, 0xDC, 0x0F, 0xC0,
  0x7E, 0x07, 0xF0, 0x39, 0xC1, 0xCE, 0x0E, 0x70, 0x61, 0xC7, 0x0E, 0x00,
  0x0E, 0x1C, 0x30, 0xE1, 0xC3, 0x87, 0x1C, 0x38, 0x70, 0xE1, 0xC7, 0x0E,
  0x1C, 0x38, 0x61, 0xC0, 0x19, 0xE7, 0x86, 0xFB, 0xF3, 0xE7, 0x9C, 0xF1,
  0xC7, 0x38, 0x71, 0xCE, 0x38, 0x73, 0x0E, 0x1D, 0xC3, 0x87, 0x70, 0xE3,
  0x9C, 0x30, 0xE7, 0x1C, 0x39, 0x87, 0x0E, 0xE1, 0xC3, 0x00, 0x19, 0xE1,
  0xBF, 0x3E, 0x73, 0xC7, 0x38, 0x73, 0x87, 0x38, 0xE7, 0x0E, 0x70, 0xE7,
  0x0E, 0x70, 0xE6, 0x1C, 0xE1, 0xC0, 0x0F, 0x87, 0xF8, 0xE7, 0x38, 0x77,
  0x0F, 0xC1, 0xF8, 0x3F, 0x0E, 0xE1, 0xDC, 0x3B, 0xCE, 0x3F, 0x83, 0xE0,
  0x0C, 0xF0, 0x6F, 0xC3, 0xCE, 0x3C, 0x71, 0xC3, 0x8E, 0x1C, 0x60, 0xE7,
  0x07, 0x38, 0x71, 0xC3, 0x8F, 0x38, 0x7F, 0xC7, 0x7C, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x60, 0x07, 0x00, 0x38, 0x00, 0x1F, 0x73, 0xFE, 0x39, 0xE7,
  0x0E, 0x70, 0xEE, 0x0C, 0xE1, 0xCE, 0x1C, 0xE1, 0xCE, 0x3C, 0xE7, 0x8F,
  0xF8, 0x7B, 0x80, 0x38, 0x03, 0x80, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x19, 0xC6, 0xF3, 0xF8, 0xF0, 0x38, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0xE0, 0x00, 0x1F, 0xCF, 0xE3, 0x88, 0xC0, 0x38, 0x0F,
  0x01, 0xF0, 0x3C, 0x07, 0x81, 0xC8, 0x73, 0xFC, 0xFE, 0x00, 0x0C, 0x18,
  0x18, 0x7F, 0xFF, 0x30, 0x70, 0x70, 0x70, 0x70, 0x60, 0xE0, 0xE0, 0xE0,
  0xFC, 0x7C, 0x38, 0x73, 0x0E, 0x70, 0xE7, 0x0E, 0x70, 0xE7, 0x0C, 0x61,
  0xCE, 0x1C, 0xE1, 0xCE, 0x3C, 0xE7, 0x8F, 0xD8, 0x79, 0x80, 0xE0, 0xFC,
  0x3B, 0x87, 0x31, 0xC6, 0x38, 0xCE, 0x19, 0xC3, 0x30, 0x6E, 0x0D, 0x81,
  0xF0, 0x3C, 0x07, 0x80, 0xE1, 0xC3, 0xF1, 0xE3, 0x98, 0xF1, 0xCC, 0x78,
  0xC6, 0x6C, 0xE3, 0x36, 0x61, 0xBB, 0x70, 0xD9, 0xB8, 0x7C, 0xD8, 0x3C,
  0x7C, 0x1E, 0x3C, 0x0E, 0x1E, 0x07, 0x0E, 0x00, 0x1C, 0x38, 0xE3, 0x83,
  0xB8, 0x1D, 0xC0, 0xFC, 0x03, 0xC0, 0x1C, 0x01, 0xF0, 0x1F, 0x80, 0xEC,
  0x0E, 0x70, 0xE3, 0x8E, 0x1E, 0x00, 0x1C, 0x1C, 0x70, 0xE0, 0xC3, 0x83,
  0x1C, 0x0C, 0x70, 0x31, 0x80, 0xEE, 0x03, 0xB0, 0x0F, 0xC0, 0x3E, 0x00,
  0xF8, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0xFC, 0x03,
  0xE0, 0x0E, 0x00, 0x00, 0x1F, 0xE3, 0xFC, 0x07, 0x01, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xF0, 0x1C, 0x07, 0x01, 0xC0, 0x3F, 0xCF, 0xF8, 0x03, 0xC1,
  0xE0, 0x70, 0x38, 0x0E, 0x03, 0x80, 0xC0, 0x30, 0x1C, 0x1E, 0x0E, 0x01,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x30, 0x1C, 0x03, 0xC0, 0xF0, 0x1C,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0E, 0x0F, 0x81, 0xC0, 0xE0,
  0x70, 0x30, 0x18, 0x1C, 0x0E, 0x03, 0xC0, 0xE1, 0xF1, 0xC0, 0xE0, 0x60,
  0x30, 0x38, 0x1C, 0x3C, 0x1E, 0x0C, 0x00, 0x7C, 0x3F, 0xFE, 0x1F, 0x80,
};

const GFXglyph NotoSans_SemiCondensed_SemiBoldItalic24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 7, 17, 6, 0, -17 },
  { 16, 8, 6, 10, 2, -17 },
  { 22, 14, 17, 14, 0, -17 },
  { 52, 12, 19, 12, 0, -18 },
  { 81, 17, 17, 19, 1, -17 },
  { 118, 15, 17, 15, 0, -17 },
  { 150, 4, 6, 6, 2, -17 },
  { 153, 8, 21, 7, 1, -17 },
  { 174, 8, 21, 7, -2, -17 },
  { 195, 10, 10, 12, 2, -18 },
  { 208, 11, 11, 13, 1, -14 },
  { 224, 5, 6, 6, -1, -3 },
  { 228, 7, 3, 7, 0, -8 },
  { 231, 4, 3, 6, 0, -3 },
  { 233, 12, 17, 9, -1, -17 },
  { 259, 11, 17, 12, 1, -17 },
  { 283, 8, 17, 12, 3, -17 },
  { 300, 13, 17, 12, -1, -17 },
  { 328, 12, 17, 12, 0, -17 },
  { 354, 12, 17, 12, 0, -17 },
  { 380, 12, 17, 12, 0, -17 },
  { 406, 11, 17, 12, 1, -17 },
  { 430, 12, 17, 12, 1, -17 },
  { 456, 12, 17, 12, 0, -17 },
  { 482, 11, 17, 12, 1, -17 },
  { 506, 6, 13, 6, 0, -13 },
  { 516, 7, 16, 6, -1, -13 },
  { 530, 11, 12, 13, 1, -15 },
  { 547, 11, 7, 13, 1, -12 },
  { 557, 11, 12, 13, 1, -15 },
  { 574, 9, 17, 10, 1, -17 },
  { 594, 17, 19, 18, 1, -17 },
  { 635, 13, 17, 13, -1, -17 },
  { 663, 13, 17, 13, 0, -17 },
  { 691, 13, 17, 13, 1, -17 },
  { 719, 14, 17, 15, 0, -17 },
  { 749, 12, 17, 12, 0, -17 },
  { 775, 12, 17, 11, 0, -17 },
  { 801, 14, 17, 15, 1, -17 },
  { 831, 15, 17, 15, 0, -17 },
  { 863, 11, 17, 8, -1, -17 },
  { 887, 11, 22, 7, -4, -17 },
  { 918, 15, 17, 13, 0, -17 },
  { 950, 9, 17, 11, 0, -17 },
  { 970, 19, 17, 19, 0, -17 },
  { 1011, 16, 17, 16, 0, -17 },
  { 1045, 14, 17, 16, 1, -17 },
  { 1075, 13, 17, 13, 0, -17 },
  { 1103, 14, 21, 16, 1, -17 },
  { 1140, 13, 17, 13, 0, -17 },
  { 1168, 12, 17, 11, 0, -17 },
  { 1194, 11, 17, 11, 2, -17 },
  { 1218, 14, 17, 15, 1, -17 },
  { 1248, 13, 17, 13, 2, -17 },
  { 1276, 20, 17, 19, 2, -17 },
  { 1319, 15, 17, 12, -1, -17 },
  { 1351, 12, 17, 12, 2, -17 },
  { 1377, 14, 17, 11, -1, -17 },
  { 1407, 10, 21, 7, -1, -17 },
  { 1434, 5, 17, 9, 3, -17 },
  { 1445, 10, 21, 7, -2, -17 },
  { 1472, 12, 10, 12, 0, -17 },
  { 1487, 9, 2, 9, -2, 2 },
  { 1490, 5, 3, 7, 3, -18 },
  { 1492, 12, 13, 13, 1, -13 },
  { 1512, 12, 18, 13, 0, -18 },
  { 1539, 10, 13, 10, 1, -13 },
  { 1556, 13, 18, 13, 1, -18 },
  { 1586, 10, 13, 12, 1, -13 },
  { 1603, 13, 24, 8, -3, -18 },
  { 1642, 13, 19, 13, 0, -13 },
  { 1673, 12, 18, 13, 0, -18 },
  { 1700, 7, 18, 6, 0, -18 },
  { 1716, 10, 24, 6, -3, -18 },
  { 1746, 13, 18, 12, 0, -18 },
  { 1776, 7, 18, 6, 0, -18 },
  { 1792, 18, 13, 19, 0, -13 },
  { 1822, 12, 13, 13, 0, -13 },
  { 1842, 11, 13, 13, 1, -13 },
  { 1860, 13, 19, 13, -1, -13 },
  { 1891, 12, 19, 13, 1, -13 },
  { 1920, 10, 13, 9, 0, -13 },
  { 1937, 10, 13, 10, 0, -13 },
  { 1954, 8, 16, 8, 1, -16 },
  { 1970, 12, 13, 13, 1, -13 },
  { 1990, 11, 13, 11, 1, -13 },
  { 2008, 17, 13, 17, 1, -13 },
  { 2036, 13, 13, 11, -1, -13 },
  { 2058, 14, 19, 11, -2, -13 },
  { 2092, 11, 13, 10, -1, -13 },
  { 2110, 10, 21, 8, 0, -17 },
  { 2137, 2, 24, 12, 5, -18 },
  { 2143, 9, 21, 8, -1, -17 },
  { 2167, 11, 3, 13, 1, -10 },
};

const GFXfont NotoSans_SemiCondensed_SemiBoldItalic24pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_SemiBoldItalic24pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_SemiBoldItalic24pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC24PT7B_H_
