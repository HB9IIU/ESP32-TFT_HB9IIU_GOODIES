#ifndef _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC21PT7B_H_
#define _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC21PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-SemiBoldItalic.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_SemiBoldItalic21pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0x71, 0x86, 0x38, 0xE3, 0x0C, 0x30, 0xC4, 0x00, 0x63, 0x8E,
  0x00, 0x66, 0xDD, 0xB6, 0x6C, 0xC0, 0x03, 0x60, 0x66, 0x06, 0x60, 0x44,
  0x3F, 0xF3, 0xFF, 0x0C, 0xC1, 0x98, 0x19, 0x8F, 0xFE, 0xFF, 0xE3, 0x30,
  0x33, 0x03, 0x20, 0x66, 0x00, 0x01, 0x00, 0x20, 0x3F, 0x8F, 0xE3, 0xA4,
  0x64, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x16, 0x06, 0xC4, 0xB9, 0xFE,
  0x1F, 0x80, 0x40, 0x18, 0x00, 0x3C, 0x18, 0xFC, 0x61, 0x98, 0xC3, 0x33,
  0x0C, 0x6C, 0x19, 0x98, 0x33, 0x6F, 0x7D, 0xBE, 0x7B, 0x66, 0x0D, 0x98,
  0x33, 0x30, 0x66, 0x61, 0x8C, 0xC6, 0x1F, 0x1C, 0x1C, 0x00, 0x07, 0x80,
  0x7E, 0x07, 0x30, 0x39, 0x81, 0xDC, 0x0F, 0xC0, 0x3C, 0x03, 0xC7, 0x3F,
  0x33, 0x9B, 0x98, 0xF9, 0xC3, 0x8E, 0x3C, 0x3F, 0xF0, 0xFB, 0xC0, 0x6D,
  0xEC, 0x0E, 0x38, 0x61, 0x87, 0x0C, 0x18, 0x70, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC0, 0xC0, 0x0E, 0x06, 0x06, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x06, 0x06, 0x06, 0x0E, 0x0C, 0x0C, 0x18, 0x18, 0x30, 0xE0, 0x0C,
  0x06, 0x33, 0x1F, 0x33, 0xF9, 0xE5, 0xF1, 0xCC, 0x46, 0x00, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0xFF, 0xFF, 0xF0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x39,
  0x9C, 0xC6, 0x60, 0x7F, 0xF0, 0x7F, 0x80, 0x00, 0xE0, 0x38, 0x06, 0x01,
  0xC0, 0x30, 0x0E, 0x01, 0x80, 0x70, 0x0C, 0x03, 0x00, 0x60, 0x18, 0x07,
  0x00, 0xC0, 0x38, 0x00, 0x0F, 0x1F, 0xCE, 0x6E, 0x36, 0x1F, 0x0F, 0x87,
  0xC3, 0xC3, 0xE1, 0xF0, 0xD8, 0xEE, 0x67, 0xF1, 0xF0, 0x0E, 0x3C, 0xFF,
  0xF4, 0xC1, 0x87, 0x0E, 0x18, 0x30, 0x61, 0xC3, 0x86, 0x0C, 0x00, 0x0F,
  0x8F, 0xF1, 0x9C, 0x03, 0x00, 0xC0, 0x70, 0x18, 0x0E, 0x07, 0x03, 0x81,
  0x80, 0xC0, 0x60, 0x3F, 0xEF, 0xF0, 0x0F, 0x8F, 0xF1, 0x0C, 0x03, 0x00,
  0xC0, 0x71, 0xF8, 0x78, 0x03, 0x80, 0x60, 0x18, 0x0E, 0x83, 0xBF, 0xCF,
  0xE0, 0x01, 0xC0, 0x70, 0x3C, 0x1F, 0x0D, 0x83, 0x61, 0x98, 0xCE, 0x63,
  0xB8, 0xCF, 0xFF, 0xFF, 0x07, 0x01, 0xC0, 0x60, 0x0F, 0xE3, 0xF8, 0x60,
  0x0C, 0x03, 0x80, 0x70, 0x0F, 0xC1, 0xFC, 0x03, 0x80, 0x30, 0x06, 0x01,
  0xC8, 0x39, 0xFE, 0x3F, 0x80, 0x07, 0xC7, 0xF3, 0x80, 0xC0, 0x70, 0x19,
  0x8F, 0xF3, 0xDE, 0xE3, 0xB8, 0xEC, 0x3B, 0x0C, 0xE7, 0x3F, 0x87, 0xC0,
  0x7F, 0xDF, 0xF0, 0x1C, 0x0E, 0x03, 0x01, 0xC0, 0x60, 0x38, 0x0C, 0x07,
  0x03, 0x80, 0xE0, 0x70, 0x1C, 0x0E, 0x00, 0x0F, 0x83, 0xF8, 0x63, 0x9C,
  0x73, 0x8C, 0x33, 0x87, 0xE0, 0xF8, 0x3B, 0x8E, 0x31, 0x86, 0x70, 0xC6,
  0x38, 0xFF, 0x0F, 0x80, 0x1F, 0x1F, 0xDC, 0xEC, 0x3E, 0x1F, 0x0F, 0x8E,
  0xEF, 0x7F, 0x99, 0x80, 0xC0, 0xC0, 0xE7, 0xE3, 0xE0, 0x11, 0xCE, 0x20,
  0x00, 0x00, 0x03, 0x39, 0xC0, 0x08, 0x71, 0xC2, 0x00, 0x00, 0x00, 0x00,
  0xC3, 0x1C, 0x63, 0x8C, 0x00, 0x00, 0x40, 0x70, 0x78, 0x78, 0x78, 0x38,
  0x07, 0x80, 0x78, 0x07, 0xC0, 0x70, 0x04, 0xFF, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xFC, 0x80, 0x38, 0x0F, 0x80, 0xF8, 0x07, 0x80, 0x70, 0x78, 0xF8,
  0xF8, 0x38, 0x08, 0x00, 0x3E, 0x7F, 0x43, 0x03, 0x07, 0x0E, 0x1C, 0x38,
  0x30, 0x70, 0x00, 0x00, 0x60, 0xE0, 0xE0, 0x03, 0xF0, 0x1F, 0xF0, 0x70,
  0x31, 0x80, 0x36, 0x3E, 0x6C, 0xFC, 0xF3, 0x99, 0xE6, 0x33, 0xCC, 0xC7,
  0x91, 0x9B, 0x23, 0x36, 0x7F, 0xCC, 0x67, 0x1C, 0x00, 0x1C, 0x08, 0x1F,
  0xE0, 0x0F, 0x80, 0x01, 0xC0, 0x78, 0x0F, 0x03, 0xE0, 0x6C, 0x1D, 0xC3,
  0x38, 0xE7, 0x18, 0xE7, 0xFC, 0xFF, 0xB8, 0x37, 0x07, 0xC0, 0xF8, 0x18,
  0x1F, 0xC1, 0xFE, 0x1C, 0x71, 0x87, 0x18, 0x63, 0x8E, 0x3F, 0xC3, 0xF8,
  0x31, 0xC3, 0x0C, 0x70, 0xE7, 0x0C, 0x61, 0xC7, 0xF8, 0xFF, 0x00, 0x07,
  0xE3, 0xFC, 0xF0, 0x9C, 0x07, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x07, 0x08, 0xFE, 0x0F, 0xC0, 0x1F, 0xC1, 0xFE, 0x1C,
  0xF1, 0x87, 0x18, 0x33, 0x83, 0x38, 0x33, 0x87, 0x30, 0x73, 0x07, 0x70,
  0xE7, 0x1E, 0x73, 0xC7, 0xF8, 0xFE, 0x00, 0x1F, 0xE3, 0xFC, 0x70, 0x0C,
  0x01, 0x80, 0x70, 0x0F, 0xE1, 0xFC, 0x30, 0x06, 0x01, 0xC0, 0x38, 0x06,
  0x00, 0xFE, 0x3F, 0xC0, 0x1F, 0xE3, 0xFC, 0x70, 0x0C, 0x01, 0x80, 0x70,
  0x0E, 0x01, 0xFC, 0x3F, 0x86, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x38,
  0x00, 0x07, 0xF1, 0xFF, 0x3C, 0x23, 0x80, 0x70, 0x07, 0x00, 0x60, 0x0E,
  0x3E, 0xE3, 0xEE, 0x0E, 0xE0, 0xCE, 0x0C, 0x71, 0xC7, 0xFC, 0x3F, 0x80,
  0x1C, 0x18, 0xE0, 0xC7, 0x0E, 0x30, 0x71, 0x83, 0x9C, 0x18, 0xFF, 0xC7,
  0xFE, 0x30, 0x71, 0x83, 0x1C, 0x18, 0xE1, 0xC7, 0x0E, 0x30, 0x73, 0x83,
  0x00, 0x1F, 0x8F, 0xC1, 0x81, 0xC0, 0xE0, 0x70, 0x30, 0x18, 0x1C, 0x0E,
  0x06, 0x03, 0x01, 0x83, 0xF3, 0xF0, 0x01, 0x81, 0xC0, 0xE0, 0x70, 0x30,
  0x18, 0x1C, 0x0E, 0x06, 0x03, 0x03, 0x81, 0xC0, 0xE0, 0x60, 0x30, 0x38,
  0x1C, 0x7C, 0x3C, 0x00, 0x1C, 0x38, 0xE3, 0x87, 0x38, 0x33, 0x81, 0x98,
  0x1D, 0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0x98, 0x1C, 0xE0, 0xE7, 0x06,
  0x18, 0x30, 0xE3, 0x87, 0x00, 0x1C, 0x1C, 0x1C, 0x18, 0x18, 0x38, 0x38,
  0x38, 0x30, 0x30, 0x70, 0x70, 0x60, 0x7F, 0xFF, 0x1E, 0x07, 0x8F, 0x03,
  0xC7, 0x83, 0xC3, 0xC1, 0xE1, 0xE1, 0xB1, 0xF0, 0xF8, 0xF8, 0xDC, 0x6C,
  0x6C, 0x37, 0x66, 0x19, 0xB3, 0x1C, 0xF3, 0x8C, 0x79, 0xC6, 0x38, 0xC3,
  0x1C, 0x63, 0x8C, 0x70, 0x1E, 0x0C, 0x78, 0x31, 0xE1, 0xC7, 0x87, 0x1F,
  0x18, 0xEC, 0x63, 0xB1, 0x8C, 0xEE, 0x33, 0xB0, 0xC6, 0xC7, 0x1B, 0x18,
  0x7C, 0x60, 0xF1, 0x83, 0x8E, 0x0E, 0x00, 0x07, 0xC1, 0xFE, 0x3C, 0x73,
  0x87, 0x70, 0x37, 0x03, 0x60, 0x3E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xEE,
  0x0E, 0x71, 0xC7, 0xF8, 0x3F, 0x00, 0x1F, 0xC1, 0xFE, 0x1C, 0xE1, 0x87,
  0x18, 0x73, 0x86, 0x38, 0xE3, 0xFC, 0x3F, 0x83, 0x00, 0x70, 0x07, 0x00,
  0x60, 0x06, 0x00, 0xE0, 0x00, 0x07, 0xC1, 0xFE, 0x3C, 0x73, 0x87, 0x70,
  0x37, 0x03, 0x60, 0x3E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xEE, 0x0E, 0x71,
  0xC7, 0xF8, 0x3F, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x1F, 0x83,
  0xFC, 0x73, 0x8C, 0x31, 0x86, 0x71, 0xCE, 0x79, 0xFE, 0x3F, 0x06, 0x61,
  0xCE, 0x39, 0xC6, 0x18, 0xC3, 0xB8, 0x70, 0x0F, 0xE3, 0xF8, 0xE1, 0x1C,
  0x03, 0x80, 0x70, 0x07, 0x00, 0xF8, 0x07, 0x00, 0x70, 0x0E, 0x01, 0xC8,
  0x71, 0xFE, 0x3F, 0x80, 0xFF, 0xFF, 0xC7, 0x03, 0x01, 0x81, 0xC0, 0xE0,
  0x70, 0x30, 0x18, 0x1C, 0x0E, 0x06, 0x03, 0x03, 0x80, 0x38, 0x33, 0x87,
  0x30, 0x73, 0x07, 0x30, 0x67, 0x06, 0x70, 0xE6, 0x0E, 0x60, 0xEE, 0x0C,
  0xE1, 0xCE, 0x1C, 0xE3, 0x87, 0xF8, 0x3E, 0x00, 0xC0, 0xF8, 0x1B, 0x07,
  0x70, 0xCE, 0x39, 0xC6, 0x39, 0xC7, 0x30, 0xEE, 0x1D, 0x81, 0xF0, 0x3C,
  0x07, 0x80, 0xE0, 0x1C, 0x00, 0xC1, 0xC3, 0xE0, 0xE1, 0xB0, 0xF1, 0xD8,
  0x78, 0xCC, 0x6C, 0xE6, 0x36, 0x63, 0x3B, 0x31, 0x99, 0xB8, 0xCC, 0xD8,
  0x6C, 0x7C, 0x36, 0x3C, 0x1E, 0x1E, 0x0F, 0x0E, 0x07, 0x87, 0x03, 0x83,
  0x80, 0x1C, 0x38, 0x61, 0x83, 0x9C, 0x1D, 0xC0, 0x6C, 0x03, 0xE0, 0x1E,
  0x00, 0xE0, 0x0F, 0x80, 0x6C, 0x07, 0x60, 0x73, 0x83, 0x1C, 0x38, 0xE3,
  0x83, 0x80, 0xE1, 0xF8, 0x6E, 0x39, 0x9C, 0x66, 0x1B, 0x87, 0xC1, 0xE0,
  0x38, 0x0C, 0x03, 0x01, 0xC0, 0x70, 0x18, 0x06, 0x00, 0x0F, 0xF1, 0xFF,
  0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x70, 0x0E, 0x01, 0xC0,
  0x1C, 0x03, 0x80, 0x70, 0x47, 0xF8, 0xFF, 0x80, 0x1F, 0x1F, 0x18, 0x18,
  0x38, 0x30, 0x30, 0x30, 0x30, 0x70, 0x60, 0x60, 0x60, 0x60, 0xE0, 0xC0,
  0xF0, 0xF0, 0xC7, 0x18, 0xC6, 0x31, 0x8C, 0x71, 0x8C, 0x63, 0x18, 0xE0,
  0x1F, 0x1F, 0x06, 0x06, 0x06, 0x0E, 0x0C, 0x0C, 0x0C, 0x0C, 0x1C, 0x18,
  0x18, 0x18, 0x18, 0x38, 0xF0, 0xF0, 0x02, 0x01, 0xC0, 0xF0, 0x3C, 0x19,
  0x86, 0x63, 0x19, 0x83, 0xE0, 0xC0, 0xFF, 0xE6, 0x30, 0x0C, 0x0F, 0xB7,
  0xFD, 0xC6, 0xE1, 0xB8, 0x6E, 0x3B, 0x0E, 0xC3, 0x39, 0xCF, 0xF1, 0xEC,
  0x0C, 0x03, 0x80, 0x70, 0x0C, 0x01, 0x90, 0x7F, 0x8F, 0x71, 0xC6, 0x30,
  0xE6, 0x19, 0xC3, 0x38, 0xE7, 0x1C, 0xE7, 0x1F, 0xE6, 0xF0, 0x0E, 0x3F,
  0x7B, 0x70, 0xE0, 0xE0, 0xC0, 0xC0, 0xC0, 0xE2, 0xFE, 0x7C, 0x00, 0xE0,
  0x1C, 0x03, 0x00, 0x60, 0xCC, 0x7F, 0x9F, 0xF3, 0x8C, 0xE1, 0x9C, 0x33,
  0x0E, 0x61, 0xCC, 0x31, 0xCE, 0x3F, 0xC3, 0xD8, 0x06, 0x1F, 0x8E, 0xEC,
  0x7E, 0x3F, 0xFB, 0xF9, 0x80, 0xC0, 0x70, 0xBF, 0x8F, 0xC0, 0x01, 0xE0,
  0x7C, 0x0C, 0x03, 0x80, 0x74, 0x3F, 0x07, 0xE0, 0x70, 0x0E, 0x01, 0xC0,
  0x30, 0x06, 0x01, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xC0,
  0x78, 0x0E, 0x00, 0x06, 0x03, 0xEC, 0xFF, 0x9C, 0x67, 0x0C, 0xE1, 0x9C,
  0x73, 0x0E, 0x61, 0x8E, 0x71, 0xF6, 0x1D, 0xC0, 0x30, 0x06, 0x21, 0xC7,
  0xF0, 0xFC, 0x00, 0x0C, 0x07, 0x01, 0xC0, 0x60, 0x19, 0x8F, 0xF3, 0xFC,
  0xE3, 0x38, 0xCC, 0x37, 0x1D, 0xC7, 0x61, 0x98, 0x66, 0x1B, 0x8E, 0x0C,
  0x71, 0xC0, 0x00, 0xE3, 0x8E, 0x30, 0xC7, 0x1C, 0x71, 0x86, 0x38, 0x01,
  0x81, 0xC0, 0xE0, 0x00, 0x00, 0x18, 0x1C, 0x0E, 0x06, 0x03, 0x03, 0x81,
  0xC0, 0xE0, 0x60, 0x30, 0x38, 0x1C, 0x0C, 0x0E, 0x1F, 0x0F, 0x00, 0x0C,
  0x03, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x71, 0xCE, 0x61, 0xDC, 0x37, 0x07,
  0xC1, 0xF8, 0x3B, 0x06, 0x70, 0xC6, 0x18, 0xE7, 0x1C, 0x0C, 0x71, 0xC6,
  0x18, 0xE3, 0x8E, 0x30, 0xC7, 0x1C, 0x61, 0x86, 0x38, 0x01, 0x04, 0x3F,
  0xDF, 0x3F, 0xF7, 0x38, 0xE7, 0x38, 0xC7, 0x31, 0xC7, 0x71, 0xC6, 0x71,
  0x86, 0x61, 0x86, 0x61, 0x8E, 0x63, 0x8E, 0xE3, 0x8C, 0x01, 0x8F, 0xF3,
  0xFC, 0xE3, 0x38, 0xCC, 0x37, 0x1D, 0xC7, 0x61, 0x98, 0x66, 0x1B, 0x8E,
  0x0C, 0x1F, 0x9F, 0xEE, 0x3E, 0x1F, 0x0F, 0x07, 0x87, 0xC3, 0xF3, 0xBF,
  0x8F, 0x80, 0x00, 0x81, 0xFE, 0x1E, 0xE1, 0xC6, 0x18, 0x71, 0x86, 0x38,
  0x63, 0x8E, 0x38, 0xE3, 0x9C, 0x3F, 0xC7, 0x78, 0x70, 0x06, 0x00, 0x60,
  0x06, 0x00, 0xE0, 0x00, 0x0C, 0x0F, 0xB7, 0xFD, 0xC6, 0xE1, 0xB8, 0x6C,
  0x3B, 0x0E, 0xC3, 0x39, 0xCF, 0xB1, 0xDC, 0x06, 0x01, 0x80, 0x60, 0x38,
  0x0E, 0x00, 0x01, 0x9F, 0x8D, 0xC7, 0x03, 0x81, 0x81, 0xC0, 0xE0, 0x70,
  0x30, 0x18, 0x1C, 0x00, 0x0C, 0x1F, 0xCE, 0xCE, 0x07, 0x01, 0xE0, 0x78,
  0x1C, 0x06, 0x43, 0x3F, 0x9F, 0x80, 0x18, 0x30, 0xC7, 0xFF, 0xCE, 0x18,
  0x30, 0x61, 0xC3, 0x86, 0x0F, 0x8F, 0x00, 0x71, 0xDC, 0x76, 0x19, 0x86,
  0x61, 0xB8, 0xEE, 0x3B, 0x0C, 0xC7, 0x3E, 0xC7, 0xB0, 0xE1, 0xF8, 0xEE,
  0x33, 0x9C, 0x66, 0x1B, 0x86, 0xC1, 0xF0, 0x78, 0x1E, 0x07, 0x00, 0xE3,
  0x8F, 0xCF, 0x3B, 0x9E, 0x67, 0x6C, 0xCE, 0xDB, 0x9D, 0xB6, 0x3E, 0x7C,
  0x7C, 0xF0, 0xF1, 0xE1, 0xE3, 0x81, 0x87, 0x00, 0x18, 0xF1, 0xCC, 0x0D,
  0x80, 0xF8, 0x0F, 0x00, 0xE0, 0x1F, 0x01, 0xB0, 0x3B, 0x87, 0x38, 0xE1,
  0x80, 0x1C, 0x38, 0xE3, 0x87, 0x18, 0x19, 0xC0, 0xCC, 0x06, 0xE0, 0x36,
  0x01, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x03,
  0xE0, 0x1E, 0x00, 0x1F, 0xC7, 0xE0, 0x38, 0x1C, 0x0E, 0x03, 0x01, 0xC0,
  0xE0, 0x30, 0x1F, 0xCF, 0xF0, 0x03, 0x87, 0x83, 0x81, 0x80, 0xC0, 0xE0,
  0x60, 0x30, 0x70, 0x70, 0x0C, 0x06, 0x03, 0x01, 0x81, 0xC0, 0xE0, 0x78,
  0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1C, 0x1E, 0x0E, 0x06,
  0x0E, 0x0C, 0x0C, 0x0C, 0x0F, 0x0F, 0x1C, 0x18, 0x18, 0x38, 0x38, 0x30,
  0xF0, 0xE0, 0x78, 0x7F, 0xF8, 0xF8,
};

const GFXglyph NotoSans_SemiCondensed_SemiBoldItalic21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 6, 15, 6, 0, -15 },
  { 13, 7, 5, 9, 2, -15 },
  { 18, 12, 15, 12, 0, -15 },
  { 41, 11, 17, 11, 0, -16 },
  { 65, 15, 15, 16, 1, -15 },
  { 94, 13, 15, 13, 0, -15 },
  { 119, 3, 5, 5, 2, -15 },
  { 121, 7, 18, 6, 1, -15 },
  { 137, 8, 18, 6, -2, -15 },
  { 155, 9, 9, 10, 2, -16 },
  { 166, 10, 10, 11, 1, -12 },
  { 179, 5, 6, 5, -1, -3 },
  { 183, 6, 2, 6, 0, -7 },
  { 185, 3, 3, 5, 0, -3 },
  { 187, 11, 15, 8, -1, -15 },
  { 208, 9, 15, 11, 1, -15 },
  { 225, 7, 15, 11, 2, -15 },
  { 239, 10, 15, 11, 0, -15 },
  { 258, 10, 15, 11, 0, -15 },
  { 277, 10, 15, 11, 0, -15 },
  { 296, 11, 15, 11, 0, -15 },
  { 317, 10, 15, 11, 1, -15 },
  { 336, 10, 15, 11, 1, -15 },
  { 355, 11, 15, 11, 0, -15 },
  { 376, 9, 15, 11, 1, -15 },
  { 393, 5, 12, 5, 0, -12 },
  { 401, 6, 15, 5, -1, -12 },
  { 413, 10, 11, 11, 1, -13 },
  { 427, 9, 6, 11, 1, -10 },
  { 434, 10, 11, 11, 1, -13 },
  { 448, 8, 15, 8, 1, -15 },
  { 463, 15, 17, 16, 1, -15 },
  { 495, 11, 15, 11, -1, -15 },
  { 516, 12, 15, 12, 0, -15 },
  { 539, 11, 15, 11, 1, -15 },
  { 560, 12, 15, 13, 0, -15 },
  { 583, 11, 15, 10, 0, -15 },
  { 604, 11, 15, 10, 0, -15 },
  { 625, 12, 15, 13, 1, -15 },
  { 648, 13, 15, 13, 0, -15 },
  { 673, 9, 15, 7, -1, -15 },
  { 690, 9, 19, 6, -3, -15 },
  { 712, 13, 15, 11, 0, -15 },
  { 737, 8, 15, 10, 0, -15 },
  { 752, 17, 15, 17, 0, -15 },
  { 784, 14, 15, 14, 0, -15 },
  { 811, 12, 15, 14, 1, -15 },
  { 834, 12, 15, 11, 0, -15 },
  { 857, 12, 19, 14, 1, -15 },
  { 886, 11, 15, 11, 0, -15 },
  { 907, 11, 15, 10, 0, -15 },
  { 928, 9, 15, 10, 2, -15 },
  { 945, 12, 15, 13, 1, -15 },
  { 968, 11, 15, 11, 2, -15 },
  { 989, 17, 15, 17, 2, -15 },
  { 1021, 13, 15, 11, -1, -15 },
  { 1046, 10, 15, 10, 2, -15 },
  { 1065, 12, 15, 10, -1, -15 },
  { 1088, 8, 18, 6, 0, -15 },
  { 1106, 5, 15, 8, 2, -15 },
  { 1116, 8, 18, 6, -1, -15 },
  { 1134, 10, 9, 11, 0, -15 },
  { 1146, 8, 1, 8, -2, 2 },
  { 1147, 4, 3, 6, 3, -16 },
  { 1149, 10, 12, 11, 1, -12 },
  { 1164, 11, 16, 11, 0, -16 },
  { 1186, 8, 12, 9, 1, -12 },
  { 1198, 11, 16, 11, 1, -16 },
  { 1220, 9, 12, 10, 1, -12 },
  { 1234, 11, 21, 7, -2, -16 },
  { 1263, 11, 17, 11, 0, -12 },
  { 1287, 10, 16, 11, 0, -16 },
  { 1307, 6, 16, 5, 0, -16 },
  { 1319, 9, 21, 5, -3, -16 },
  { 1343, 11, 16, 10, 0, -16 },
  { 1365, 6, 16, 5, 0, -16 },
  { 1377, 16, 12, 17, 0, -12 },
  { 1401, 10, 12, 11, 0, -12 },
  { 1416, 9, 12, 11, 1, -12 },
  { 1430, 12, 17, 11, -1, -12 },
  { 1456, 10, 17, 11, 1, -12 },
  { 1478, 9, 12, 8, 0, -12 },
  { 1492, 9, 12, 9, 0, -12 },
  { 1506, 7, 14, 7, 1, -14 },
  { 1519, 10, 11, 11, 1, -11 },
  { 1533, 10, 11, 9, 1, -11 },
  { 1547, 15, 11, 15, 1, -11 },
  { 1568, 12, 11, 10, -1, -11 },
  { 1585, 13, 16, 10, -2, -11 },
  { 1611, 10, 11, 9, -1, -11 },
  { 1625, 9, 18, 7, 0, -15 },
  { 1646, 2, 21, 10, 4, -16 },
  { 1652, 8, 18, 7, -1, -15 },
  { 1670, 10, 3, 11, 1, -9 },
};

const GFXfont NotoSans_SemiCondensed_SemiBoldItalic21pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_SemiBoldItalic21pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_SemiBoldItalic21pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC21PT7B_H_
