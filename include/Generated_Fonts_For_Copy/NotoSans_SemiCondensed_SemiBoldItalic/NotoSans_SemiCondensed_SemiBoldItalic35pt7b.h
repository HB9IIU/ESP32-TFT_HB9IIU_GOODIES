#ifndef _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC35PT7B_H_
#define _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC35PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-SemiBoldItalic.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_SemiBoldItalic35pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xC1, 0xF0, 0x7C, 0x1E, 0x07, 0x83, 0xE0, 0xF8, 0x3C, 0x0F,
  0x03, 0xC1, 0xF0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x70, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x1F, 0x0F, 0xC3, 0xE0, 0x78, 0x00, 0x3C, 0xF3, 0x8F,
  0x78, 0xF7, 0x8E, 0x79, 0xE7, 0x1E, 0x71, 0xC7, 0x1C, 0xF1, 0xC0, 0x00,
  0xF1, 0xC0, 0x0E, 0x1C, 0x00, 0xE3, 0x80, 0x1C, 0x38, 0x01, 0xC3, 0x80,
  0x1C, 0x70, 0x03, 0xC7, 0x03, 0xFF, 0xFF, 0x3F, 0xFF, 0xF3, 0xFF, 0xFE,
  0x07, 0x0E, 0x00, 0x70, 0xE0, 0x07, 0x1C, 0x00, 0xE1, 0xC0, 0x0E, 0x1C,
  0x0F, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x1C, 0x38, 0x01, 0xC7,
  0x00, 0x38, 0x70, 0x03, 0x87, 0x00, 0x38, 0xE0, 0x07, 0x8E, 0x00, 0x70,
  0xE0, 0x00, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x1F, 0x80, 0x7F,
  0xF8, 0x7F, 0xF8, 0x7F, 0xFC, 0x3C, 0xC4, 0x1E, 0x60, 0x1E, 0x60, 0x07,
  0xB0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xDE, 0x00, 0x6F, 0x80, 0x67, 0xC8, 0x33, 0xC7, 0x1B,
  0xE3, 0xFF, 0xE1, 0xFF, 0xF0, 0xFF, 0xE0, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x0F, 0x80, 0x3C, 0x1F, 0xC0, 0x38, 0x3F, 0xE0,
  0x70, 0x38, 0xE0, 0xF0, 0x78, 0xE0, 0xE0, 0x70, 0xE1, 0xC0, 0x71, 0xE3,
  0xC0, 0xF1, 0xE3, 0x80, 0xF1, 0xC7, 0x00, 0xE1, 0xCF, 0x00, 0xE3, 0xCE,
  0x7C, 0xE3, 0x9C, 0xFE, 0xFF, 0xBD, 0xFF, 0x7F, 0x3B, 0xCF, 0x3E, 0x73,
  0x87, 0x00, 0xF3, 0x8F, 0x00, 0xE7, 0x8F, 0x01, 0xC7, 0x8F, 0x03, 0xC7,
  0x0E, 0x03, 0x87, 0x0E, 0x07, 0x07, 0x1E, 0x0F, 0x07, 0x1C, 0x0E, 0x07,
  0xFC, 0x1C, 0x03, 0xF8, 0x3C, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0xE0,
  0x07, 0xFF, 0x00, 0x78, 0xF0, 0x07, 0x8F, 0x00, 0xF0, 0xF0, 0x0F, 0x0F,
  0x00, 0xF1, 0xF0, 0x07, 0xBE, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x7E,
  0x00, 0x0F, 0xE0, 0xF3, 0xFE, 0x0F, 0x7C, 0xF1, 0xE7, 0x8F, 0x9E, 0xF8,
  0x7B, 0xCF, 0x07, 0xFC, 0xF0, 0x3F, 0x8F, 0x03, 0xF0, 0xF0, 0x3F, 0x0F,
  0x8F, 0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0x7C, 0x3F, 0xC7, 0xC0, 0x7B, 0xFD,
  0xEF, 0x73, 0x9C, 0xE0, 0x00, 0xF0, 0x1E, 0x03, 0xC0, 0x38, 0x07, 0x80,
  0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07,
  0x80, 0x78, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x78, 0x03,
  0x80, 0x3C, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x78, 0x07, 0x80, 0xF0, 0x1E, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x00, 0x01, 0x80, 0x03, 0xC0, 0x07, 0x02, 0x0E, 0x07, 0x1C, 0x0F,
  0xB0, 0x3F, 0xFF, 0x9F, 0xFF, 0x07, 0xFE, 0x1F, 0x84, 0x7F, 0x01, 0xEF,
  0x07, 0x8E, 0x07, 0x1E, 0x04, 0x3C, 0x00, 0x20, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x1F, 0x1E, 0x1E, 0x3C, 0x3C, 0x38,
  0x78, 0x70, 0xF0, 0xFF, 0xFF, 0xBF, 0xC0, 0x39, 0xEF, 0xFE, 0x78, 0x00,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x03, 0xFE,
  0x07, 0xFE, 0x0F, 0x9F, 0x1F, 0x0F, 0x1E, 0x0F, 0x3E, 0x0F, 0x3C, 0x0F,
  0x3C, 0x0F, 0x7C, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0xF8, 0x1F,
  0xF8, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x3E, 0xF0, 0x3C, 0xF0, 0x7C,
  0xF8, 0x78, 0x79, 0xF8, 0x7F, 0xF0, 0x3F, 0xE0, 0x1F, 0x80, 0x01, 0xE0,
  0x7C, 0x3F, 0x8F, 0xF3, 0xFF, 0xFF, 0xBE, 0xF3, 0x1E, 0x43, 0xC0, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x1F, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x7C,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x81, 0xF0, 0x3C, 0x00, 0x00, 0xFF, 0x00,
  0xFF, 0xE0, 0x7F, 0xFC, 0x1F, 0x3F, 0x03, 0x03, 0xC0, 0x80, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0xFF, 0xC7, 0xFF,
  0xE1, 0xFF, 0xF8, 0xFF, 0xFE, 0x00, 0x01, 0xFE, 0x03, 0xFF, 0x83, 0xFF,
  0xE0, 0xF1, 0xF0, 0x40, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x80, 0x7F, 0x80, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0xE0,
  0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC8, 0x03, 0xE7, 0x87, 0xE3, 0xFF, 0xE1, 0xFF, 0xE0, 0x7F, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x03,
  0xF8, 0x03, 0xBC, 0x03, 0xDE, 0x03, 0xCF, 0x01, 0xCF, 0x01, 0xE7, 0x81,
  0xE3, 0xC1, 0xE1, 0xE0, 0xE1, 0xE0, 0xE0, 0xF0, 0xF0, 0x78, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xE0, 0x07, 0x80, 0x03, 0xC0, 0x03,
  0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F,
  0xF8, 0x1F, 0xFE, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xB8, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xFE, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xE0, 0x00, 0xF8, 0x80, 0x3E, 0x3C, 0x7F, 0x0F, 0xFF, 0x83, 0xFF, 0xC0,
  0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0xFF, 0xC0, 0xFF, 0xE0, 0xFC, 0x10,
  0xF8, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x7C,
  0x0F, 0xFF, 0x0F, 0xFF, 0xC7, 0xF7, 0xE3, 0xE0, 0xF1, 0xE0, 0x78, 0xF0,
  0x3C, 0xF8, 0x1E, 0x7C, 0x0F, 0x3E, 0x0F, 0x8F, 0x07, 0x87, 0x87, 0xC3,
  0xE7, 0xE1, 0xFF, 0xE0, 0x7F, 0xE0, 0x1F, 0xC0, 0x00, 0x3F, 0xFF, 0x9F,
  0xFF, 0xCF, 0xFF, 0xCF, 0xFF, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07,
  0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0xC1, 0xE1, 0xE1,
  0xE0, 0xF8, 0xF0, 0x3C, 0x78, 0x3E, 0x3C, 0x1E, 0x1F, 0x1F, 0x07, 0x9F,
  0x03, 0xFF, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0xC1, 0xF9, 0xF0, 0xF0,
  0x78, 0xF8, 0x3E, 0x78, 0x0F, 0x3C, 0x07, 0x9E, 0x07, 0xCF, 0x03, 0xC7,
  0xC3, 0xE1, 0xFF, 0xE0, 0xFF, 0xE0, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x07,
  0xFC, 0x0F, 0xFE, 0x1F, 0x3F, 0x3E, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x7C,
  0x0F, 0x78, 0x0F, 0x78, 0x1F, 0x78, 0x1F, 0x7C, 0x3F, 0x3E, 0xFE, 0x3F,
  0xFE, 0x1F, 0xDE, 0x0F, 0x9E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0x78, 0x00, 0xF0, 0x83, 0xF0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0x00, 0x0F,
  0x07, 0xC7, 0xC3, 0xE0, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0xF0, 0xFC, 0x7C, 0x1E, 0x00, 0x03, 0xC0, 0x7C,
  0x1F, 0x03, 0xE0, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x1E, 0x03, 0xC0, 0xF0, 0x1E,
  0x07, 0x80, 0xF0, 0x1C, 0x07, 0x00, 0x00, 0x03, 0x00, 0x0F, 0x00, 0x3F,
  0x00, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x00, 0xF8, 0x00,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x3F,
  0x00, 0x0F, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80,
  0x00, 0xE0, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x7F, 0x01, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFE, 0x00, 0xF8, 0x00, 0xE0, 0x00, 0x80, 0x00, 0x1F, 0xE3, 0xFF,
  0x9F, 0xFE, 0x71, 0xF2, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF8, 0x1F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0,
  0x0F, 0x80, 0x7C, 0x07, 0x80, 0x07, 0x03, 0xC0, 0x01, 0xE0, 0xE0, 0x00,
  0x38, 0x70, 0x7F, 0x8E, 0x3C, 0x3F, 0xE3, 0x8E, 0x1E, 0x38, 0xF3, 0x8F,
  0x0E, 0x39, 0xC3, 0x87, 0x0E, 0x71, 0xE1, 0xC3, 0x9C, 0x70, 0x70, 0xE7,
  0x1C, 0x3C, 0x3B, 0xC7, 0x0E, 0x1C, 0xE1, 0xC3, 0x87, 0x38, 0x71, 0xE3,
  0x8E, 0x1E, 0xFD, 0xE3, 0xC7, 0xF7, 0xF0, 0x70, 0xF8, 0xF8, 0x1C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0xC0, 0x07,
  0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0xF7, 0x80,
  0x1E, 0xF0, 0x07, 0x9E, 0x00, 0xF3, 0xC0, 0x1C, 0x78, 0x07, 0x8F, 0x00,
  0xF1, 0xE0, 0x3C, 0x3C, 0x07, 0x87, 0x81, 0xE0, 0xF0, 0x3F, 0xFE, 0x0F,
  0xFF, 0xC1, 0xFF, 0xFC, 0x78, 0x0F, 0x8F, 0x00, 0xF3, 0xE0, 0x1E, 0x78,
  0x03, 0xDF, 0x00, 0x7B, 0xC0, 0x0F, 0xF8, 0x01, 0xE0, 0x07, 0xFE, 0x01,
  0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0xFF, 0x0F, 0x07, 0xC3, 0xC0, 0xF0, 0xF0,
  0x3C, 0x7C, 0x0F, 0x1E, 0x07, 0xC7, 0x83, 0xE1, 0xFF, 0xF0, 0x7F, 0xF0,
  0x3F, 0xFC, 0x0F, 0xFF, 0x83, 0xC1, 0xF0, 0xF0, 0x3C, 0x7C, 0x0F, 0x9E,
  0x03, 0xE7, 0x80, 0xF1, 0xE0, 0x3C, 0x78, 0x1F, 0x3F, 0xFF, 0x8F, 0xFF,
  0xC3, 0xFF, 0xE0, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0xFC, 0x1F,
  0xFF, 0x07, 0xFB, 0xC1, 0xF8, 0x08, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x40, 0xFE, 0x78, 0x0F, 0xFF,
  0x01, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0xE0, 0x3F,
  0xFE, 0x07, 0xFF, 0xE0, 0xF0, 0x7E, 0x1E, 0x07, 0xC3, 0xC0, 0x78, 0xF8,
  0x0F, 0x1E, 0x01, 0xE3, 0xC0, 0x3C, 0x78, 0x07, 0x8F, 0x00, 0xF3, 0xE0,
  0x1E, 0x78, 0x07, 0xCF, 0x00, 0xF9, 0xE0, 0x1E, 0x7C, 0x07, 0xCF, 0x80,
  0xF9, 0xE0, 0x3E, 0x3C, 0x0F, 0xC7, 0x83, 0xF1, 0xFF, 0xFC, 0x3F, 0xFF,
  0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x83, 0xFF, 0xC3, 0xFF,
  0xE1, 0xFF, 0xE0, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0,
  0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x07, 0xFF, 0xC3, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0x83, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xE0, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x78, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xFF, 0x07,
  0xFF, 0xE0, 0xFF, 0x3E, 0x1F, 0x80, 0x41, 0xF0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x83, 0xFC,
  0xF8, 0x3F, 0xCF, 0x83, 0xFC, 0xF0, 0x7F, 0xCF, 0x00, 0x78, 0xF0, 0x07,
  0x8F, 0x00, 0x78, 0xF8, 0x07, 0x8F, 0x80, 0xF8, 0x7C, 0x0F, 0x07, 0xF1,
  0xF0, 0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x07, 0x80, 0x78,
  0x3C, 0x03, 0xC3, 0xE0, 0x1E, 0x1F, 0x01, 0xF0, 0xF0, 0x0F, 0x07, 0x80,
  0x78, 0x3C, 0x03, 0xC3, 0xE0, 0x1E, 0x1E, 0x01, 0xF0, 0xF0, 0x0F, 0x07,
  0xFF, 0xF8, 0x3F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0xF0, 0x0F,
  0x07, 0x80, 0x78, 0x7C, 0x03, 0xC3, 0xE0, 0x3E, 0x1E, 0x01, 0xF0, 0xF0,
  0x0F, 0x07, 0x80, 0x78, 0x7C, 0x03, 0xC3, 0xE0, 0x3E, 0x1E, 0x01, 0xE0,
  0xF0, 0x0F, 0x00, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF0, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x1F, 0xF0, 0x7F, 0xE0,
  0xFF, 0xC0, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x1F, 0x00, 0x7C, 0x0F, 0xF8, 0x1F, 0xE0, 0x3F, 0x80,
  0x7E, 0x00, 0x07, 0x80, 0xF8, 0x3C, 0x0F, 0x83, 0xE0, 0xF8, 0x1E, 0x0F,
  0x80, 0xF0, 0xF8, 0x07, 0x87, 0x80, 0x3C, 0x7C, 0x03, 0xE7, 0xC0, 0x1E,
  0x7C, 0x00, 0xF7, 0xC0, 0x07, 0xBC, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00,
  0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0x9F, 0x00, 0x7C, 0x78, 0x03, 0xC3,
  0xC0, 0x1E, 0x1F, 0x00, 0xF0, 0x78, 0x07, 0x83, 0xC0, 0x7C, 0x1F, 0x03,
  0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0xF0, 0x1F, 0x00, 0x07, 0x80, 0x3C, 0x03,
  0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x7F, 0xFF, 0xFF, 0xDF, 0xFE, 0xFF,
  0xF0, 0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x3F, 0x80, 0x3F, 0x87,
  0xF0, 0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x83, 0xB8, 0x0F,
  0xF0, 0xF7, 0x01, 0xDE, 0x1E, 0xE0, 0x7B, 0xC3, 0xDC, 0x0E, 0xF0, 0x7B,
  0x83, 0xDE, 0x0E, 0x70, 0x73, 0xC3, 0xCE, 0x1E, 0x78, 0x79, 0xC3, 0x9E,
  0x0F, 0x3C, 0xF3, 0xC1, 0xE7, 0x9C, 0x78, 0x78, 0xF7, 0x8F, 0x0F, 0x1E,
  0xE1, 0xE1, 0xE3, 0xFC, 0x78, 0x3C, 0x7F, 0x0F, 0x07, 0x87, 0xE1, 0xE1,
  0xE0, 0xF8, 0x3C, 0x3C, 0x1F, 0x07, 0x87, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x00, 0x07, 0xC0, 0x1E, 0x0F, 0x80, 0x38, 0x3F, 0x00, 0xF0, 0x7F,
  0x01, 0xE0, 0xFE, 0x03, 0xC1, 0xFC, 0x07, 0x83, 0xBC, 0x1E, 0x0F, 0x78,
  0x3C, 0x1E, 0xF0, 0x78, 0x3D, 0xE0, 0xF0, 0x79, 0xE1, 0xE0, 0xE3, 0xC7,
  0x83, 0xC7, 0x8F, 0x07, 0x87, 0x9E, 0x0F, 0x0F, 0x3C, 0x1E, 0x1E, 0x78,
  0x78, 0x3D, 0xE0, 0xF0, 0x3F, 0xC1, 0xE0, 0x7F, 0x83, 0xC0, 0xFF, 0x07,
  0x80, 0xFC, 0x1E, 0x01, 0xF8, 0x3C, 0x03, 0xF0, 0x78, 0x07, 0xE0, 0xF0,
  0x07, 0xC0, 0x00, 0xFF, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0xFE, 0x7E,
  0x1F, 0x83, 0xE1, 0xF0, 0x1F, 0x3E, 0x01, 0xF3, 0xC0, 0x0F, 0x7C, 0x00,
  0xF7, 0x80, 0x0F, 0x78, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF0, 0x01, 0xEF, 0x00, 0x3E, 0xF0, 0x03, 0xEF, 0x00, 0x3C, 0xF8,
  0x07, 0xCF, 0x80, 0xF8, 0xFC, 0x1F, 0x87, 0xE7, 0xF0, 0x7F, 0xFE, 0x03,
  0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xF8,
  0x3F, 0xFF, 0x0F, 0x07, 0xC3, 0xC0, 0xF0, 0xF0, 0x3C, 0x7C, 0x0F, 0x1E,
  0x03, 0xC7, 0x81, 0xF1, 0xE0, 0x78, 0x78, 0x7E, 0x3F, 0xFF, 0x0F, 0xFF,
  0x83, 0xFF, 0xC0, 0xFF, 0x80, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0xFE, 0x7E,
  0x1F, 0x83, 0xE1, 0xF0, 0x1F, 0x3E, 0x01, 0xF3, 0xC0, 0x0F, 0x7C, 0x00,
  0xF7, 0xC0, 0x0F, 0x78, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF0, 0x01, 0xEF, 0x00, 0x3E, 0xF0, 0x03, 0xEF, 0x00, 0x3C, 0xF8,
  0x07, 0xCF, 0x80, 0xF8, 0xFC, 0x1F, 0x87, 0xE7, 0xF0, 0x3F, 0xFE, 0x03,
  0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x07, 0xFC, 0x01, 0xFF,
  0xC0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0x07, 0xC3, 0xC1, 0xF0, 0xF0, 0x7C,
  0x7C, 0x1F, 0x1E, 0x07, 0xC7, 0x81, 0xE1, 0xE0, 0xF8, 0x79, 0xFC, 0x3F,
  0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0x00, 0xF1, 0xE0, 0x7C, 0x78, 0x1F, 0x1E,
  0x07, 0x87, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x3E, 0x0F, 0x8F, 0x01, 0xE3,
  0xC0, 0x78, 0xF0, 0x1F, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0xF0, 0x7F, 0xF8,
  0x3F, 0xBC, 0x0F, 0x81, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF0, 0xC0, 0x7C, 0x3E, 0x7F, 0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0x7F,
  0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xC0,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x78, 0x00, 0x0F, 0x00, 0xF1, 0xF0, 0x0F, 0x1F, 0x01, 0xF1,
  0xE0, 0x1F, 0x1E, 0x01, 0xE1, 0xE0, 0x1E, 0x3E, 0x01, 0xE3, 0xC0, 0x3E,
  0x3C, 0x03, 0xC3, 0xC0, 0x3C, 0x3C, 0x03, 0xC7, 0xC0, 0x7C, 0x78, 0x07,
  0xC7, 0x80, 0x78, 0x78, 0x07, 0x8F, 0x80, 0x78, 0xF8, 0x0F, 0x8F, 0x00,
  0xF0, 0xF0, 0x0F, 0x0F, 0x01, 0xF0, 0xF8, 0x1E, 0x0F, 0xE7, 0xE0, 0x7F,
  0xFC, 0x03, 0xFF, 0x80, 0x1F, 0xE0, 0x00, 0xF0, 0x03, 0xFE, 0x00, 0xFB,
  0xC0, 0x1E, 0x78, 0x07, 0xCF, 0x00, 0xF1, 0xF0, 0x1E, 0x1E, 0x07, 0x83,
  0xC0, 0xF0, 0x78, 0x3C, 0x0F, 0x07, 0x81, 0xE1, 0xE0, 0x3C, 0x3C, 0x07,
  0x8F, 0x00, 0xF1, 0xE0, 0x1E, 0x7C, 0x03, 0xCF, 0x00, 0x7B, 0xE0, 0x0F,
  0x78, 0x01, 0xEF, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x0F,
  0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0xFF, 0x00,
  0xF0, 0x1F, 0xF0, 0x1F, 0x01, 0xEF, 0x01, 0xF0, 0x1E, 0xF0, 0x3F, 0x03,
  0xCF, 0x03, 0xF0, 0x3C, 0xF0, 0x3F, 0x07, 0xCF, 0x07, 0xF0, 0x78, 0xF0,
  0x77, 0x07, 0x8F, 0x0F, 0x70, 0xF0, 0xF0, 0xE7, 0x0F, 0x0F, 0x1E, 0x71,
  0xE0, 0xF1, 0xE7, 0x1E, 0x0F, 0x1C, 0x71, 0xE0, 0xF3, 0xC7, 0x3C, 0x0F,
  0x38, 0x73, 0xC0, 0xF7, 0x87, 0x78, 0x0F, 0x70, 0x77, 0x80, 0xF7, 0x07,
  0x70, 0x07, 0xF0, 0x7F, 0x00, 0x7E, 0x07, 0xF0, 0x07, 0xE0, 0x7E, 0x00,
  0x7C, 0x07, 0xE0, 0x07, 0xC0, 0x7C, 0x00, 0x78, 0x07, 0xC0, 0x00, 0x03,
  0xC0, 0x3E, 0x07, 0xC0, 0xF8, 0x0F, 0x83, 0xE0, 0x0F, 0x07, 0x80, 0x1E,
  0x1F, 0x00, 0x3E, 0x7C, 0x00, 0x3C, 0xF0, 0x00, 0x7B, 0xE0, 0x00, 0xFF,
  0x80, 0x01, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xDF, 0x00,
  0x0F, 0x9E, 0x00, 0x1E, 0x3C, 0x00, 0x78, 0x78, 0x01, 0xF0, 0xF8, 0x07,
  0xC0, 0xF0, 0x0F, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0xF8, 0x07, 0xC0, 0xF8,
  0x0F, 0xFC, 0x07, 0x9E, 0x07, 0xCF, 0x03, 0xC7, 0x83, 0xE3, 0xC3, 0xE0,
  0xF1, 0xE0, 0x79, 0xF0, 0x3C, 0xF0, 0x1E, 0xF0, 0x0F, 0xF8, 0x03, 0xF8,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF,
  0x83, 0xFF, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x03, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0xFC, 0x3F, 0xFF, 0x87,
  0xFF, 0xF0, 0xFF, 0xFE, 0x00, 0x01, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xF0,
  0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x38,
  0x01, 0xE0, 0x07, 0x80, 0x1F, 0xC0, 0x7F, 0x03, 0xFC, 0x0F, 0xF0, 0x00,
  0xE1, 0xE3, 0xC7, 0x8F, 0x1E, 0x1C, 0x38, 0x78, 0xF1, 0xE3, 0xC7, 0x87,
  0x0E, 0x1E, 0x3C, 0x78, 0xF1, 0xE1, 0xC3, 0x87, 0x8F, 0x1E, 0x03, 0xF8,
  0x1F, 0xC1, 0xFE, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xE0, 0x07, 0x00, 0x78, 0x03, 0xC1, 0xFE, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x00, 0x00, 0xE0, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF8, 0x07,
  0xF8, 0x07, 0x38, 0x0F, 0x38, 0x0E, 0x3C, 0x1E, 0x1C, 0x3C, 0x1C, 0x38,
  0x1E, 0x78, 0x0E, 0x70, 0x0E, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xF9,
  0xE7, 0x8F, 0x1C, 0x30, 0x03, 0xE3, 0x87, 0xFB, 0xC3, 0xFF, 0xE3, 0xE3,
  0xF3, 0xE1, 0xF1, 0xE0, 0x79, 0xF0, 0x3C, 0xF8, 0x1E, 0x78, 0x1F, 0x3C,
  0x0F, 0x3E, 0x07, 0x9F, 0x03, 0xCF, 0x83, 0xE7, 0xC1, 0xF3, 0xE1, 0xF1,
  0xF9, 0xF8, 0x7F, 0xFC, 0x3F, 0xDE, 0x0F, 0xCE, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x0F, 0x3E, 0x03, 0xDF, 0xC0, 0xFF, 0xF8, 0x3F, 0x3E,
  0x1F, 0x87, 0x87, 0xC1, 0xF1, 0xE0, 0x78, 0x78, 0x1E, 0x1E, 0x07, 0x8F,
  0x01, 0xE3, 0xC0, 0x78, 0xF0, 0x3E, 0x3C, 0x0F, 0x0F, 0x07, 0xC7, 0xC1,
  0xE1, 0xF8, 0xF8, 0x7F, 0xFC, 0x1D, 0xFE, 0x0F, 0x3F, 0x00, 0x03, 0xFE,
  0x0F, 0xF8, 0x3F, 0xF0, 0xF8, 0x43, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x3E, 0x38, 0x7F, 0xF0, 0x7F, 0xE0, 0x7F, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x3C, 0x03, 0xE7, 0x81, 0xFE, 0xF0, 0x3F, 0xFE,
  0x0F, 0x8F, 0xC3, 0xE1, 0xF0, 0x78, 0x1E, 0x1F, 0x03, 0xC3, 0xC0, 0x78,
  0x78, 0x1F, 0x0F, 0x03, 0xC3, 0xE0, 0x78, 0x7C, 0x0F, 0x0F, 0x83, 0xE1,
  0xF0, 0x78, 0x3E, 0x1F, 0x07, 0xC7, 0xE0, 0x7F, 0xFC, 0x0F, 0xF7, 0x80,
  0xFC, 0xE0, 0x00, 0x03, 0xF8, 0x0F, 0xF8, 0x3F, 0xF8, 0xF8, 0xF3, 0xE1,
  0xE7, 0x83, 0xDF, 0x07, 0xBC, 0x3E, 0x7F, 0xFC, 0xFF, 0xE3, 0xFF, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x0C, 0x7F, 0xF8, 0x7F,
  0xF0, 0x7F, 0x80, 0x00, 0x03, 0xC0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xFF,
  0x80, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xF1, 0xC1, 0xFE, 0xF0, 0x7F, 0xFC, 0x3E, 0x3F,
  0x1F, 0x0F, 0x87, 0x81, 0xE3, 0xE0, 0x78, 0xF8, 0x1E, 0x3C, 0x0F, 0x8F,
  0x03, 0xC7, 0xC0, 0xF1, 0xF0, 0x3C, 0x7C, 0x1F, 0x1F, 0x07, 0xC7, 0xC3,
  0xE1, 0xF9, 0xF8, 0x3F, 0xFE, 0x0F, 0xF7, 0x81, 0xFB, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x83, 0x03, 0xE0, 0xFF, 0xF0, 0x3F,
  0xF8, 0x07, 0xFC, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x3F, 0x07,
  0xBF, 0xC3, 0xFF, 0xE1, 0xF9, 0xF1, 0xF8, 0x78, 0xF8, 0x3C, 0x7C, 0x1E,
  0x3C, 0x0F, 0x1E, 0x07, 0x9F, 0x07, 0xCF, 0x03, 0xC7, 0x81, 0xE3, 0xC0,
  0xF1, 0xE0, 0x79, 0xF0, 0x78, 0xF0, 0x3C, 0x78, 0x1E, 0x3C, 0x0F, 0x3E,
  0x0F, 0x80, 0x03, 0xC1, 0xF0, 0x7C, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x0F, 0x03, 0xC0, 0xF0, 0x7C, 0x1F, 0x07, 0x81, 0xE0, 0x78, 0x3E, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x1F, 0x07, 0x81, 0xE0, 0x78, 0x3E, 0x00, 0x00,
  0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x1F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xC0,
  0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x3F, 0x80, 0xFC, 0x03, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x03, 0xE1, 0xE0, 0xF0, 0x3C,
  0x3C, 0x07, 0x8F, 0x81, 0xF3, 0xE0, 0x3C, 0xF8, 0x07, 0xBE, 0x00, 0xFF,
  0x80, 0x1F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0x78, 0x03, 0xCF,
  0x80, 0x78, 0xF0, 0x1E, 0x1F, 0x03, 0xC3, 0xE0, 0x78, 0x3C, 0x0F, 0x07,
  0xC3, 0xE0, 0xF8, 0x00, 0x03, 0xC0, 0xF0, 0x3C, 0x1F, 0x07, 0x81, 0xE0,
  0x78, 0x1E, 0x0F, 0x83, 0xC0, 0xF0, 0x3C, 0x1F, 0x07, 0x81, 0xE0, 0x78,
  0x1E, 0x0F, 0x83, 0xC0, 0xF0, 0x3C, 0x0F, 0x07, 0xC1, 0xE0, 0x78, 0x1E,
  0x0F, 0x80, 0x0F, 0x3E, 0x0F, 0x81, 0xEF, 0xE7, 0xF8, 0x3B, 0xFF, 0xFF,
  0x07, 0xE7, 0xF9, 0xF1, 0xF8, 0x7C, 0x3E, 0x3E, 0x0F, 0x87, 0xC7, 0xC1,
  0xE0, 0xF0, 0xF0, 0x3C, 0x1E, 0x1E, 0x0F, 0x03, 0xC7, 0xC1, 0xE0, 0x78,
  0xF0, 0x3C, 0x0F, 0x1E, 0x07, 0x83, 0xC3, 0xC1, 0xF0, 0x78, 0x78, 0x3C,
  0x0F, 0x1E, 0x07, 0x81, 0xE3, 0xC0, 0xF0, 0x7C, 0x78, 0x1E, 0x0F, 0x0F,
  0x07, 0xC1, 0xE3, 0xE0, 0xF0, 0x3C, 0x00, 0x0F, 0x3F, 0x07, 0xBF, 0xC3,
  0xBF, 0xE1, 0xF9, 0xF1, 0xF8, 0x78, 0xF8, 0x3C, 0x7C, 0x1E, 0x3C, 0x0F,
  0x1E, 0x07, 0x9F, 0x07, 0xCF, 0x03, 0xC7, 0x81, 0xE3, 0xC0, 0xF1, 0xE0,
  0x79, 0xF0, 0x7C, 0xF0, 0x3C, 0x78, 0x1E, 0x3C, 0x0F, 0x3E, 0x0F, 0x80,
  0x03, 0xF8, 0x07, 0xFC, 0x0F, 0xFE, 0x1F, 0x3F, 0x3E, 0x1F, 0x3C, 0x0F,
  0x7C, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0xF8, 0x1F, 0xF0, 0x1E,
  0xF0, 0x1E, 0xF8, 0x3E, 0xF8, 0x3C, 0x7C, 0xFC, 0x7F, 0xF8, 0x3F, 0xF0,
  0x1F, 0xC0, 0x07, 0x9F, 0x00, 0xF7, 0xF0, 0x1D, 0xFF, 0x03, 0xF3, 0xE0,
  0xFC, 0x3C, 0x1F, 0x07, 0xC3, 0xC0, 0xF0, 0x78, 0x1E, 0x0F, 0x03, 0xC3,
  0xC0, 0x78, 0x78, 0x0F, 0x0F, 0x03, 0xE1, 0xE0, 0x78, 0x3C, 0x1F, 0x0F,
  0x83, 0xC1, 0xF8, 0xF8, 0x3F, 0xFE, 0x07, 0xBF, 0x80, 0xF7, 0xE0, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE3, 0x83, 0xFB, 0xC3,
  0xFF, 0xE3, 0xE3, 0xF3, 0xE1, 0xF1, 0xE0, 0x79, 0xF0, 0x3C, 0xF0, 0x1E,
  0x78, 0x1F, 0x3C, 0x0F, 0x3E, 0x07, 0x9F, 0x03, 0xCF, 0x83, 0xE7, 0xC1,
  0xF3, 0xE1, 0xF1, 0xF1, 0xF8, 0x7F, 0xFC, 0x3F, 0xDE, 0x0F, 0xDE, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x7C, 0x00, 0x0F, 0x3C, 0x3D, 0xF0, 0xFF, 0xC3, 0xFF,
  0x1F, 0xC0, 0x7E, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x0F, 0x80, 0x00, 0x07, 0xF8, 0x3F, 0xF1, 0xFF, 0xCF, 0x86, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0x7C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x30, 0x7C, 0xFF, 0xF3, 0xFF, 0x87, 0xF8,
  0x00, 0x07, 0x01, 0xC0, 0x38, 0x0F, 0x03, 0xFF, 0xFF, 0xFF, 0xF1, 0xE0,
  0x3C, 0x0F, 0x81, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x8F, 0xF1, 0xFE, 0x1F, 0xC0, 0x1E, 0x07, 0x8F,
  0x03, 0xC7, 0x81, 0xE3, 0xC1, 0xF3, 0xC0, 0xF1, 0xE0, 0x78, 0xF0, 0x3C,
  0x78, 0x1E, 0x7C, 0x1F, 0x3C, 0x0F, 0x1E, 0x07, 0x8F, 0x03, 0xC7, 0x83,
  0xE3, 0xC1, 0xF3, 0xE1, 0xF0, 0xF1, 0xF8, 0x7F, 0xFC, 0x3F, 0xDE, 0x0F,
  0xCE, 0x00, 0xF0, 0x1F, 0xF0, 0x1E, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x78,
  0xF0, 0x78, 0xF0, 0xF0, 0xF0, 0xF0, 0x71, 0xE0, 0x71, 0xE0, 0x73, 0xC0,
  0x73, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7C, 0x00, 0xF0, 0x3C, 0x0F, 0xF0, 0x7C, 0x1E, 0xF0, 0x7C,
  0x1E, 0xF0, 0xFC, 0x3E, 0xF0, 0xFC, 0x3C, 0xF1, 0xFC, 0x3C, 0xF1, 0xDC,
  0x78, 0xF1, 0xDC, 0x78, 0xF3, 0x9C, 0xF0, 0xF3, 0x9C, 0xF0, 0xF7, 0x9C,
  0xE0, 0xF7, 0x1D, 0xE0, 0xF7, 0x1D, 0xE0, 0xFE, 0x1D, 0xC0, 0xFE, 0x1F,
  0xC0, 0xFE, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0x00, 0xF8, 0x1F,
  0x00, 0x07, 0x81, 0xF0, 0x78, 0x3E, 0x07, 0xC7, 0xC0, 0x3C, 0x78, 0x03,
  0xCF, 0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xFC, 0x00, 0x7B, 0xC0,
  0x0F, 0x3C, 0x01, 0xF1, 0xE0, 0x3E, 0x1E, 0x03, 0xC1, 0xE0, 0xF8, 0x1F,
  0x00, 0x07, 0x80, 0xF8, 0x3C, 0x07, 0x81, 0xE0, 0x7C, 0x0F, 0x03, 0xC0,
  0x78, 0x3E, 0x01, 0xC1, 0xE0, 0x0E, 0x1E, 0x00, 0x78, 0xF0, 0x03, 0xCF,
  0x00, 0x1E, 0x78, 0x00, 0xF7, 0x80, 0x07, 0xBC, 0x00, 0x3D, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xFF, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x78,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x0F, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7F, 0xF8, 0xFF, 0xF0,
  0xFF, 0xF0, 0x00, 0x3C, 0x03, 0xF0, 0x1F, 0xC0, 0x7C, 0x01, 0xE0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x0F,
  0x81, 0xFC, 0x07, 0xE0, 0x1E, 0x00, 0xFC, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0x10, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03,
  0xC0, 0x0F, 0x80, 0x3F, 0x01, 0xFC, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x38, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0xC0,
  0x0F, 0xC0, 0x1F, 0x01, 0xF8, 0x0F, 0x80, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x3F, 0x80,
  0xFC, 0x03, 0xE0, 0x08, 0x00, 0x00, 0x3E, 0x01, 0xFF, 0x83, 0xFF, 0xFF,
  0xC7, 0xFF, 0x80, 0xFC,
};

const GFXglyph NotoSans_SemiCondensed_SemiBoldItalic35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 10, 25, 9, 0, -25 },
  { 33, 12, 9, 14, 3, -25 },
  { 47, 20, 25, 20, 1, -25 },
  { 110, 17, 29, 18, 1, -27 },
  { 172, 24, 25, 27, 2, -25 },
  { 247, 20, 25, 22, 1, -25 },
  { 310, 5, 9, 8, 4, -25 },
  { 316, 12, 31, 11, 1, -25 },
  { 363, 12, 31, 11, -3, -25 },
  { 410, 15, 16, 17, 3, -27 },
  { 440, 16, 17, 18, 2, -21 },
  { 474, 8, 9, 9, -2, -4 },
  { 483, 9, 3, 11, 1, -11 },
  { 487, 6, 5, 9, 0, -5 },
  { 491, 18, 25, 13, -2, -25 },
  { 548, 16, 25, 18, 1, -25 },
  { 598, 11, 25, 18, 4, -25 },
  { 633, 18, 25, 18, -1, -25 },
  { 690, 17, 25, 18, 0, -25 },
  { 744, 17, 25, 18, 0, -25 },
  { 798, 18, 25, 18, 0, -25 },
  { 855, 17, 25, 18, 1, -25 },
  { 909, 17, 25, 18, 2, -25 },
  { 963, 17, 25, 18, 1, -25 },
  { 1017, 16, 25, 18, 1, -25 },
  { 1067, 9, 19, 9, 0, -19 },
  { 1089, 11, 24, 9, -2, -19 },
  { 1122, 16, 17, 18, 2, -21 },
  { 1156, 15, 10, 18, 2, -17 },
  { 1175, 16, 17, 18, 2, -21 },
  { 1209, 13, 25, 14, 2, -25 },
  { 1250, 26, 28, 27, 1, -25 },
  { 1341, 19, 25, 19, -2, -25 },
  { 1401, 18, 25, 19, 1, -25 },
  { 1458, 19, 25, 19, 2, -25 },
  { 1518, 19, 25, 21, 1, -25 },
  { 1578, 17, 25, 17, 1, -25 },
  { 1632, 17, 25, 16, 1, -25 },
  { 1686, 20, 25, 22, 2, -25 },
  { 1749, 21, 25, 22, 1, -25 },
  { 1815, 15, 25, 12, -1, -25 },
  { 1862, 15, 32, 10, -5, -25 },
  { 1922, 21, 25, 19, 1, -25 },
  { 1988, 13, 25, 16, 1, -25 },
  { 2029, 27, 25, 28, 1, -25 },
  { 2114, 23, 25, 23, 1, -25 },
  { 2186, 20, 25, 23, 2, -25 },
  { 2249, 18, 25, 19, 1, -25 },
  { 2306, 20, 31, 23, 2, -25 },
  { 2384, 18, 25, 19, 1, -25 },
  { 2441, 18, 25, 17, 0, -25 },
  { 2498, 16, 25, 16, 3, -25 },
  { 2548, 20, 25, 22, 2, -25 },
  { 2611, 19, 25, 18, 3, -25 },
  { 2671, 28, 25, 28, 3, -25 },
  { 2759, 23, 25, 18, -2, -25 },
  { 2831, 17, 25, 17, 3, -25 },
  { 2885, 19, 25, 17, -1, -25 },
  { 2945, 14, 31, 11, -1, -25 },
  { 3000, 7, 25, 13, 4, -25 },
  { 3022, 13, 31, 11, -2, -25 },
  { 3073, 16, 15, 18, 1, -25 },
  { 3103, 13, 2, 13, -3, 3 },
  { 3107, 6, 6, 10, 5, -27 },
  { 3112, 17, 19, 19, 1, -19 },
  { 3153, 18, 27, 19, 0, -27 },
  { 3214, 15, 19, 15, 1, -19 },
  { 3250, 19, 27, 19, 1, -27 },
  { 3315, 15, 19, 17, 1, -19 },
  { 3351, 19, 35, 11, -4, -27 },
  { 3435, 18, 27, 19, 0, -19 },
  { 3496, 17, 27, 19, 0, -27 },
  { 3554, 10, 26, 9, 0, -26 },
  { 3587, 14, 34, 9, -4, -26 },
  { 3647, 19, 27, 17, 0, -27 },
  { 3712, 10, 27, 9, 0, -27 },
  { 3746, 27, 19, 28, 0, -19 },
  { 3811, 17, 19, 19, 0, -19 },
  { 3852, 16, 19, 18, 1, -19 },
  { 3890, 19, 27, 19, -1, -19 },
  { 3955, 17, 27, 19, 1, -19 },
  { 4013, 14, 19, 13, 0, -19 },
  { 4047, 14, 19, 15, 0, -19 },
  { 4081, 11, 23, 12, 2, -23 },
  { 4113, 17, 19, 19, 1, -19 },
  { 4154, 16, 19, 16, 2, -19 },
  { 4192, 24, 19, 24, 2, -19 },
  { 4249, 20, 19, 16, -2, -19 },
  { 4297, 21, 27, 16, -3, -19 },
  { 4368, 16, 19, 14, -1, -19 },
  { 4406, 14, 31, 12, 0, -25 },
  { 4461, 3, 35, 17, 7, -27 },
  { 4475, 14, 31, 12, -2, -25 },
  { 4530, 16, 5, 18, 2, -15 },
};

const GFXfont NotoSans_SemiCondensed_SemiBoldItalic35pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_SemiBoldItalic35pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_SemiBoldItalic35pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC35PT7B_H_
