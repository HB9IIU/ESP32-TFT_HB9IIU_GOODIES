#ifndef _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC34PT7B_H_
#define _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC34PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-SemiBoldItalic.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_SemiBoldItalic34pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xC1, 0xE0, 0x78, 0x1E, 0x0F, 0x83, 0xC0, 0xF0, 0x3C, 0x0F,
  0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x01, 0xC0, 0xF0, 0x3C, 0x00, 0x00,
  0x00, 0xE0, 0x78, 0x3E, 0x0F, 0x81, 0xE0, 0x3C, 0xF7, 0x8E, 0x79, 0xE7,
  0x9E, 0x71, 0xC7, 0x1C, 0x71, 0xC6, 0x1C, 0xE1, 0x80, 0x00, 0xE3, 0xC0,
  0x1C, 0x70, 0x07, 0x0E, 0x00, 0xE3, 0x80, 0x1C, 0x70, 0x07, 0x0E, 0x00,
  0xE1, 0xC1, 0xFF, 0xFF, 0x3F, 0xFF, 0xE0, 0xE1, 0xC0, 0x1C, 0x70, 0x03,
  0x8E, 0x00, 0xE1, 0xC0, 0x1C, 0x30, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF,
  0xFF, 0x83, 0x8E, 0x00, 0x71, 0xC0, 0x1C, 0x38, 0x03, 0x8E, 0x00, 0x71,
  0xC0, 0x1C, 0x38, 0x03, 0x8F, 0x00, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x03, 0xFE, 0x07, 0xFF, 0x0F, 0xFE, 0x1F, 0x6E, 0x1E, 0xC2, 0x3C, 0xC0,
  0x3C, 0xC0, 0x3E, 0xC0, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x01, 0xFC, 0x03, 0x3C, 0x03, 0x3C, 0x83, 0x3C, 0xC3, 0x7C,
  0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x00, 0x3F, 0x00, 0xF0, 0xFF, 0x01, 0xC1, 0xEE,
  0x07, 0x07, 0x9E, 0x1E, 0x0E, 0x3C, 0x38, 0x1C, 0x70, 0xE0, 0x78, 0xE3,
  0xC0, 0xE1, 0xC7, 0x01, 0xC3, 0x9C, 0x03, 0x8F, 0x79, 0xE7, 0x1C, 0xE7,
  0xEF, 0x7B, 0x9F, 0xEF, 0xEF, 0x79, 0xDF, 0x9C, 0xE3, 0x8C, 0x73, 0xC7,
  0x01, 0xE7, 0x0E, 0x03, 0x8E, 0x1C, 0x0E, 0x1C, 0x78, 0x3C, 0x38, 0xE0,
  0x70, 0x71, 0xC1, 0xC0, 0xE7, 0x87, 0x81, 0xFE, 0x0E, 0x03, 0xF8, 0x38,
  0x03, 0xE0, 0x00, 0x70, 0x00, 0x1F, 0xC0, 0x03, 0xFE, 0x00, 0x7F, 0xF0,
  0x07, 0x8F, 0x00, 0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0xF1, 0xE0, 0x0F, 0x1E,
  0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x11, 0xFE,
  0x1E, 0x3D, 0xE1, 0xE7, 0x8F, 0x3C, 0xF0, 0xFB, 0xCF, 0x07, 0xF8, 0xF0,
  0x7F, 0x8F, 0x03, 0xF0, 0xF0, 0x3E, 0x0F, 0x8F, 0xF0, 0xFF, 0xFF, 0x07,
  0xFE, 0xF8, 0x3F, 0xC7, 0xC0, 0x3D, 0xE7, 0x9E, 0x71, 0xC7, 0x1C, 0xE0,
  0x01, 0xF0, 0x1C, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xE0,
  0x3C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x78, 0x07, 0x00, 0x70, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x07, 0x00, 0x70, 0x07, 0x80, 0x38, 0x00, 0x01, 0xC0, 0x1E, 0x00,
  0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x1E, 0x01,
  0xE0, 0x1E, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x1E,
  0x01, 0xC0, 0x3C, 0x0F, 0x80, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x10, 0xF0,
  0x73, 0x83, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF, 0x0F, 0xFC, 0x7F, 0x03, 0xDC,
  0x1F, 0x78, 0x38, 0xE0, 0x43, 0xC0, 0x0C, 0x00, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x1F, 0x1E, 0x1E, 0x3C, 0x3C, 0x38, 0x78, 0xF0, 0xFF, 0xFF,
  0xBF, 0xDF, 0xE0, 0x3B, 0xFF, 0xF7, 0x80, 0x00, 0x07, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00,
  0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xE0,
  0x00, 0x00, 0x60, 0x03, 0xFC, 0x07, 0xFE, 0x0F, 0xFE, 0x0F, 0x1E, 0x1E,
  0x0F, 0x3E, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x7C, 0x0F, 0x78, 0x0F, 0x78,
  0x1F, 0x78, 0x1E, 0xF8, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x3C, 0xF0,
  0x3C, 0xF0, 0x3C, 0xF0, 0x78, 0xF0, 0xF8, 0x79, 0xF0, 0x7F, 0xF0, 0x3F,
  0xE0, 0x1F, 0x80, 0x03, 0xE0, 0xFC, 0x3F, 0x1F, 0xE7, 0xFD, 0xF7, 0xBC,
  0xF2, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x01, 0xE0,
  0x00, 0x18, 0x00, 0x7F, 0xC0, 0x3F, 0xF8, 0x3F, 0xFE, 0x07, 0x87, 0xC0,
  0x81, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0xFF, 0xFE, 0x00, 0x00, 0x70, 0x01,
  0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0x60, 0xF8, 0x20, 0x7C, 0x00, 0x1E,
  0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x1F, 0x80, 0xFF, 0x80, 0x7E,
  0x00, 0x3F, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x07, 0xC8, 0x03, 0xC7, 0x07, 0xE3, 0xFF, 0xE1, 0xFF, 0xE0,
  0x7F, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x07, 0xF0, 0x07, 0x78, 0x07, 0xB8, 0x03, 0xBC, 0x03, 0x9E, 0x03, 0xCF,
  0x03, 0xC7, 0x83, 0xC7, 0x81, 0xC3, 0xC1, 0xE1, 0xE1, 0xE0, 0xF1, 0xFF,
  0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xC0, 0x0F, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x03, 0xFF, 0x81, 0xFF, 0xC1, 0xFF,
  0xE0, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E,
  0x00, 0x0F, 0xF8, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x87, 0xE0, 0x01, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x90, 0x0F,
  0x8E, 0x0F, 0xC7, 0xFF, 0xC3, 0xFF, 0xC0, 0xFF, 0x80, 0x00, 0x0E, 0x80,
  0x7F, 0x80, 0x7F, 0xC0, 0x7F, 0xE0, 0x7C, 0x00, 0x78, 0x00, 0x7C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x30, 0x0E, 0x7E, 0x0F, 0x7F, 0x87, 0xFF,
  0xC3, 0xE1, 0xF1, 0xE0, 0x78, 0xF0, 0x3C, 0xF8, 0x1E, 0x78, 0x1F, 0x3C,
  0x0F, 0x1E, 0x07, 0x87, 0x87, 0xC3, 0xE7, 0xC1, 0xFF, 0xC0, 0x7F, 0xE0,
  0x1F, 0xC0, 0x00, 0x1F, 0xFF, 0x8F, 0xFF, 0xCF, 0xFF, 0xE0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F,
  0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01,
  0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x03, 0xFC, 0x07, 0xFE,
  0x0F, 0xFF, 0x1F, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x1E, 0x1F,
  0x1F, 0x3E, 0x0F, 0xFC, 0x07, 0xF8, 0x07, 0xE0, 0x1F, 0xF0, 0x3E, 0xF8,
  0x78, 0x7C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C,
  0xF8, 0x7C, 0xFF, 0xF8, 0x7F, 0xF0, 0x3F, 0xC0, 0x00, 0xE0, 0x07, 0xF8,
  0x0F, 0xFC, 0x1F, 0xFE, 0x1E, 0x1E, 0x3C, 0x1E, 0x3C, 0x1F, 0x7C, 0x0F,
  0x78, 0x1F, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x3E, 0x7C, 0x7E, 0x3F, 0xFE,
  0x3F, 0xDE, 0x1F, 0xBC, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF8,
  0x01, 0xF0, 0x83, 0xE0, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x00, 0x06, 0x0F,
  0x1F, 0x1F, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x30, 0x78, 0xF8, 0xF8, 0x78, 0x01, 0x80, 0xF0, 0x7C, 0x1F, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x78, 0x1E, 0x0F, 0x00, 0x00, 0x02,
  0x00, 0x0C, 0x00, 0x78, 0x03, 0xF0, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F,
  0x00, 0xF8, 0x01, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0xC0, 0x1F, 0x80, 0x0F, 0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x80, 0x01, 0x80, 0x03, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0xFC, 0x07, 0xF0, 0x3F, 0x83,
  0xFC, 0x1F, 0xE0, 0x3F, 0x00, 0x70, 0x00, 0x80, 0x00, 0x03, 0x01, 0xFF,
  0x1F, 0xFC, 0xFF, 0xE3, 0x0F, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0xF0,
  0x0F, 0x00, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x7E, 0x1F, 0x80,
  0x78, 0x03, 0xC0, 0x70, 0x00, 0xF0, 0x70, 0x00, 0x38, 0x78, 0x3E, 0x1C,
  0x38, 0x7F, 0xC7, 0x38, 0x7F, 0xE3, 0x9C, 0x78, 0xE1, 0xDC, 0x38, 0x70,
  0xEE, 0x38, 0x38, 0x77, 0x1C, 0x3C, 0x73, 0x8E, 0x1C, 0x3B, 0x8E, 0x0E,
  0x1D, 0xC7, 0x0F, 0x1C, 0xE3, 0x87, 0x8E, 0x71, 0xE7, 0xCE, 0x38, 0x7F,
  0xFE, 0x0E, 0x1F, 0x3E, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x7C, 0x01, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xB8, 0x00, 0xF7, 0x00, 0x1C, 0xE0, 0x07, 0x9C, 0x00, 0xE3,
  0x80, 0x3C, 0x78, 0x07, 0x8F, 0x01, 0xE1, 0xE0, 0x3C, 0x3C, 0x0F, 0x07,
  0x81, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC3, 0xC0, 0x78, 0x78, 0x0F,
  0x1E, 0x01, 0xE3, 0xC0, 0x3C, 0xF0, 0x07, 0x9E, 0x00, 0xF7, 0xC0, 0x1F,
  0x07, 0xFE, 0x03, 0xFF, 0xE0, 0xFF, 0xF8, 0x3C, 0x3F, 0x0F, 0x07, 0xC3,
  0xC0, 0xF1, 0xE0, 0x7C, 0x78, 0x1E, 0x1E, 0x0F, 0x87, 0x8F, 0xC3, 0xFF,
  0xE0, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0x07, 0x83, 0xC0, 0xF1, 0xF0, 0x3C,
  0x78, 0x0F, 0x1E, 0x03, 0xC7, 0x81, 0xF1, 0xE0, 0xF8, 0xF0, 0xFE, 0x3F,
  0xFF, 0x0F, 0xFF, 0x83, 0xFF, 0x80, 0x00, 0x38, 0x00, 0x7F, 0xE0, 0x3F,
  0xFC, 0x1F, 0xFE, 0x0F, 0xC1, 0x87, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x8E, 0x07, 0xFF, 0x80, 0xFF, 0xE0,
  0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0x8F,
  0xE0, 0xF0, 0x7C, 0x1E, 0x07, 0xC7, 0xC0, 0xF8, 0xF0, 0x0F, 0x1E, 0x01,
  0xE3, 0xC0, 0x3C, 0xF8, 0x0F, 0x9E, 0x01, 0xF3, 0xC0, 0x3E, 0x78, 0x07,
  0x8F, 0x00, 0xF3, 0xE0, 0x3E, 0x78, 0x07, 0x8F, 0x01, 0xF1, 0xE0, 0x7C,
  0x3C, 0x1F, 0x0F, 0xFF, 0xC1, 0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFC, 0x00,
  0x07, 0xFF, 0x87, 0xFF, 0x83, 0xFF, 0xC1, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0xFF, 0x07,
  0xFF, 0x83, 0xFF, 0x81, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF,
  0xC1, 0xFF, 0xE0, 0x07, 0xFF, 0x87, 0xFF, 0x83, 0xFF, 0xC1, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x0F, 0x80, 0x07, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0xC0, 0xF0, 0x00, 0xF8,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x1F, 0xF8, 0x0F,
  0xFF, 0x83, 0xFF, 0xE0, 0xFC, 0x0C, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x83,
  0xFD, 0xE0, 0xFF, 0x3C, 0x1F, 0xE7, 0x80, 0x3C, 0xF0, 0x07, 0x9E, 0x01,
  0xF3, 0xC0, 0x3C, 0x7C, 0x07, 0x8F, 0x80, 0xF0, 0xFC, 0x3E, 0x0F, 0xFF,
  0x81, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x07, 0x80, 0xF8, 0x7C, 0x07, 0x83,
  0xC0, 0x3C, 0x1E, 0x01, 0xE0, 0xF0, 0x0F, 0x07, 0x80, 0xF8, 0x7C, 0x07,
  0x83, 0xC0, 0x3C, 0x1E, 0x01, 0xE0, 0xF0, 0x0F, 0x07, 0xFF, 0xF8, 0x7F,
  0xFF, 0x83, 0xFF, 0xFC, 0x1E, 0x01, 0xE0, 0xF0, 0x1F, 0x0F, 0x80, 0xF0,
  0x78, 0x07, 0x83, 0xC0, 0x3C, 0x1E, 0x01, 0xE0, 0xF0, 0x1F, 0x0F, 0x80,
  0xF0, 0x78, 0x07, 0x83, 0xC0, 0x3C, 0x1E, 0x03, 0xE0, 0x07, 0xFE, 0x0F,
  0xF8, 0x0F, 0xE0, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0,
  0x0F, 0xF0, 0x3F, 0xF0, 0x7F, 0xE0, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x3E, 0x07, 0xFC, 0x0F, 0xF0,
  0x1F, 0xC0, 0x3E, 0x00, 0x00, 0x07, 0x81, 0xF0, 0xF0, 0x3E, 0x0F, 0x07,
  0xC0, 0xF0, 0x78, 0x0F, 0x0F, 0x00, 0xF1, 0xF0, 0x1E, 0x3E, 0x01, 0xE7,
  0xC0, 0x1E, 0xF8, 0x01, 0xEF, 0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x3F,
  0xF0, 0x03, 0xFF, 0x00, 0x3C, 0xF0, 0x07, 0xCF, 0x80, 0x78, 0x78, 0x07,
  0x87, 0x80, 0x78, 0x7C, 0x07, 0x83, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xE0,
  0xF0, 0x3E, 0x0F, 0x01, 0xE0, 0x07, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xC0, 0x0F, 0xE1, 0xF8, 0x01, 0xF8,
  0x3F, 0x00, 0x7F, 0x07, 0xF0, 0x0F, 0xE0, 0xFE, 0x03, 0xFC, 0x1F, 0xC0,
  0x77, 0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x03, 0xBC, 0x1E, 0xE0, 0xF7, 0x83,
  0x9C, 0x1C, 0xE0, 0xF3, 0x87, 0xBC, 0x1E, 0x70, 0xE7, 0x83, 0xCE, 0x3C,
  0xF0, 0x79, 0xC7, 0x1E, 0x0E, 0x39, 0xE3, 0x83, 0xC7, 0x38, 0xF0, 0x78,
  0xEF, 0x1E, 0x0F, 0x1D, 0xC3, 0xC1, 0xE3, 0xF8, 0x78, 0x38, 0x7E, 0x1E,
  0x0F, 0x0F, 0xC3, 0xC1, 0xE1, 0xF0, 0x78, 0x3C, 0x3E, 0x0F, 0x07, 0x87,
  0x81, 0xE0, 0x07, 0xC0, 0x3C, 0x3F, 0x00, 0xF0, 0xFC, 0x03, 0xC3, 0xF0,
  0x0E, 0x0F, 0xE0, 0x78, 0x3F, 0x81, 0xE1, 0xFE, 0x07, 0x87, 0xBC, 0x1C,
  0x1E, 0xF0, 0xF0, 0x73, 0xC3, 0xC3, 0xC7, 0x0F, 0x0F, 0x1E, 0x3C, 0x3C,
  0x78, 0xE0, 0xF1, 0xE7, 0x83, 0x83, 0xDE, 0x1E, 0x0F, 0x78, 0x78, 0x3D,
  0xE1, 0xE0, 0x77, 0x07, 0x81, 0xFC, 0x1C, 0x07, 0xF0, 0xF0, 0x1F, 0xC3,
  0xC0, 0x3F, 0x0F, 0x00, 0xF8, 0x3C, 0x03, 0xE0, 0x00, 0x38, 0x00, 0x3F,
  0xE0, 0x0F, 0xFE, 0x07, 0xFF, 0xE0, 0xF8, 0x7E, 0x3E, 0x07, 0xCF, 0x80,
  0x79, 0xE0, 0x0F, 0x7C, 0x01, 0xEF, 0x00, 0x3D, 0xE0, 0x07, 0xFC, 0x00,
  0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03,
  0xDE, 0x00, 0xFB, 0xC0, 0x1E, 0x7C, 0x07, 0xCF, 0x81, 0xF0, 0xFC, 0xFE,
  0x1F, 0xFF, 0x81, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x07, 0xFE, 0x03, 0xFF,
  0xC0, 0xFF, 0xF8, 0x3C, 0x3E, 0x0F, 0x07, 0xC3, 0xC1, 0xF1, 0xE0, 0x7C,
  0x78, 0x1F, 0x1E, 0x07, 0x87, 0x81, 0xE3, 0xE0, 0xF8, 0xF3, 0xFC, 0x3F,
  0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x3F, 0xE0, 0x0F, 0xFE, 0x07, 0xFF, 0xE0,
  0xF8, 0x7E, 0x3E, 0x07, 0xCF, 0x80, 0x79, 0xE0, 0x0F, 0x7C, 0x01, 0xEF,
  0x00, 0x3D, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xDE, 0x00, 0xFB, 0xC0, 0x1E, 0x7C,
  0x07, 0xCF, 0x81, 0xF0, 0xFC, 0xFE, 0x1F, 0xFF, 0x81, 0xFF, 0xC0, 0x0F,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x07, 0xFC, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xE1,
  0xF0, 0xF0, 0x78, 0x78, 0x3C, 0x78, 0x1E, 0x3C, 0x0F, 0x1E, 0x07, 0x8F,
  0x07, 0xCF, 0x87, 0xC7, 0xFF, 0xC3, 0xFF, 0xC1, 0xFF, 0x80, 0xF3, 0xC0,
  0xF8, 0xF0, 0x78, 0x78, 0x3C, 0x3C, 0x1E, 0x1F, 0x0F, 0x07, 0x8F, 0x83,
  0xC7, 0x81, 0xF3, 0xC0, 0x79, 0xE0, 0x3C, 0x00, 0x30, 0x00, 0xFF, 0x81,
  0xFF, 0xE1, 0xFF, 0xE0, 0xF8, 0x70, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x88, 0x07, 0xC7, 0x8F, 0xC3, 0xFF, 0xE1, 0xFF, 0xE0, 0x7F, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x1F, 0x01, 0xF1, 0xE0, 0x1E, 0x1E, 0x01, 0xE1, 0xE0, 0x1E, 0x1E,
  0x03, 0xE3, 0xE0, 0x3C, 0x3C, 0x03, 0xC3, 0xC0, 0x3C, 0x3C, 0x03, 0xC3,
  0xC0, 0x7C, 0x78, 0x07, 0x87, 0x80, 0x78, 0x78, 0x07, 0x87, 0x80, 0xF8,
  0xF8, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x0F, 0x01, 0xF0, 0xF0, 0x1E,
  0x0F, 0x83, 0xE0, 0xFC, 0x7C, 0x07, 0xFF, 0xC0, 0x3F, 0xF8, 0x01, 0xFE,
  0x00, 0xF0, 0x07, 0xFC, 0x01, 0xEF, 0x00, 0xFB, 0xC0, 0x3C, 0xF0, 0x1F,
  0x3C, 0x07, 0x8F, 0x03, 0xE1, 0xC0, 0xF0, 0x70, 0x7C, 0x1E, 0x1E, 0x07,
  0x87, 0x81, 0xE3, 0xC0, 0x78, 0xF0, 0x1E, 0x78, 0x07, 0x9E, 0x01, 0xEF,
  0x00, 0x7B, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x0F, 0x01, 0xFE, 0x03,
  0xE0, 0x3F, 0xC0, 0x7C, 0x0F, 0x78, 0x1F, 0x81, 0xEF, 0x03, 0xF0, 0x79,
  0xE0, 0xFE, 0x0F, 0x3C, 0x1F, 0xC3, 0xE7, 0x83, 0xF8, 0x78, 0xF0, 0xFF,
  0x0F, 0x1E, 0x1D, 0xE3, 0xC3, 0xC7, 0xBC, 0x78, 0x78, 0xE7, 0x9E, 0x0F,
  0x3C, 0xF3, 0xC1, 0xE7, 0x1E, 0x78, 0x3C, 0xE3, 0xDE, 0x07, 0xBC, 0x7B,
  0xC0, 0xF7, 0x0F, 0x70, 0x1F, 0xE1, 0xFE, 0x03, 0xF8, 0x3F, 0x80, 0x7F,
  0x07, 0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0x80, 0x3F, 0x01, 0xF0,
  0x07, 0xC0, 0x3C, 0x00, 0x03, 0xC0, 0x7C, 0x0F, 0x03, 0xE0, 0x3E, 0x0F,
  0x00, 0x78, 0x7C, 0x01, 0xE3, 0xE0, 0x07, 0x8F, 0x00, 0x0F, 0x78, 0x00,
  0x3D, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xF7, 0x80,
  0x07, 0xDE, 0x00, 0x1E, 0x3C, 0x00, 0xF0, 0xF0, 0x07, 0xC3, 0xC0, 0x3E,
  0x0F, 0x80, 0xF0, 0x1E, 0x07, 0xC0, 0x78, 0x3E, 0x01, 0xF0, 0xF0, 0x0F,
  0xFC, 0x0F, 0x9E, 0x07, 0x8F, 0x07, 0x87, 0x87, 0xC3, 0xC3, 0xC1, 0xE3,
  0xC0, 0x79, 0xE0, 0x3D, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x00, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F,
  0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1E, 0x00,
  0x07, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0x03, 0xFC,
  0x0F, 0xE0, 0x3F, 0x80, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0xF0, 0x1F, 0xC0, 0xFF,
  0x00, 0xE1, 0xC3, 0xC7, 0x8F, 0x1E, 0x1C, 0x38, 0x70, 0xF1, 0xE3, 0xC7,
  0x87, 0x0E, 0x1C, 0x3C, 0x78, 0xF1, 0xE1, 0xC3, 0x87, 0x0F, 0x03, 0xF8,
  0x1F, 0xC1, 0xFE, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x00, 0x00, 0xE0,
  0x01, 0xE0, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0x78, 0x0F, 0x38,
  0x0E, 0x38, 0x1E, 0x3C, 0x1C, 0x1C, 0x38, 0x1C, 0x78, 0x1E, 0x70, 0x0E,
  0xF0, 0x0E, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xF1, 0xE7, 0x8F, 0x1C,
  0x01, 0xC0, 0x03, 0xFB, 0xC3, 0xFD, 0xC3, 0xFF, 0xE3, 0xE1, 0xF1, 0xE0,
  0xF9, 0xF0, 0x7C, 0xF0, 0x3C, 0x78, 0x1E, 0x3C, 0x0F, 0x3E, 0x07, 0x9E,
  0x07, 0xCF, 0x03, 0xC7, 0x81, 0xE3, 0xE1, 0xF1, 0xF1, 0xF8, 0x7F, 0xF8,
  0x3F, 0xDC, 0x0F, 0xCE, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x38, 0x0F, 0x7E,
  0x07, 0xFF, 0x83, 0xFF, 0xE3, 0xF1, 0xF1, 0xF0, 0x78, 0xF0, 0x3C, 0x78,
  0x1E, 0x3C, 0x0F, 0x3C, 0x07, 0x9E, 0x07, 0x8F, 0x03, 0xC7, 0x81, 0xE3,
  0xC1, 0xF3, 0xE0, 0xF1, 0xF8, 0xF8, 0xFF, 0xF8, 0x77, 0xF8, 0x79, 0xF8,
  0x00, 0x01, 0xF0, 0x1F, 0xF0, 0xFF, 0xC7, 0xFE, 0x3E, 0x00, 0xF0, 0x07,
  0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x80, 0x1F, 0x18, 0x7F, 0xE0, 0xFF, 0x81, 0xFC, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x07, 0x1E, 0x07, 0xE7, 0x83, 0xFD, 0xC1, 0xFF, 0xF0,
  0xF8, 0x7C, 0x3C, 0x1F, 0x1F, 0x07, 0xC7, 0x81, 0xE1, 0xE0, 0x78, 0x78,
  0x1E, 0x3E, 0x07, 0x8F, 0x03, 0xE3, 0xC0, 0xF0, 0xF0, 0x3C, 0x3E, 0x1F,
  0x0F, 0x8F, 0xC1, 0xFF, 0xE0, 0x7F, 0xB8, 0x0F, 0xCE, 0x00, 0x01, 0xF0,
  0x0F, 0xF8, 0x3F, 0xF0, 0xF9, 0xF3, 0xE1, 0xE7, 0x83, 0xDE, 0x07, 0xBC,
  0x1E, 0x7F, 0xFC, 0xFF, 0xE3, 0xFF, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3E, 0x00, 0x3C, 0x08, 0x7F, 0xF0, 0x7F, 0xE0, 0x7F, 0x80, 0x00, 0x07,
  0xC0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0x20, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x27, 0xC0, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0xFE, 0xF0,
  0x7F, 0xB8, 0x3F, 0xFE, 0x1F, 0x0F, 0x87, 0x83, 0xE3, 0xE0, 0xF8, 0xF0,
  0x3C, 0x3C, 0x0F, 0x0F, 0x03, 0xC7, 0xC0, 0xF1, 0xE0, 0x7C, 0x78, 0x1E,
  0x1E, 0x0F, 0x87, 0xC3, 0xE1, 0xF1, 0xF8, 0x3F, 0xDC, 0x0F, 0xFF, 0x01,
  0xF3, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x08, 0x07, 0x83, 0x87,
  0xC0, 0xFF, 0xF0, 0x3F, 0xF8, 0x07, 0xF8, 0x00, 0x03, 0xC0, 0x01, 0xE0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E,
  0x38, 0x0F, 0x7F, 0x07, 0xFF, 0x83, 0xFF, 0xE3, 0xF0, 0xF1, 0xF0, 0x78,
  0xF8, 0x3C, 0x78, 0x3E, 0x3C, 0x1E, 0x3C, 0x0F, 0x1E, 0x07, 0x8F, 0x03,
  0xC7, 0x83, 0xC3, 0xC1, 0xE3, 0xC0, 0xF1, 0xE0, 0x78, 0xF0, 0x3C, 0x78,
  0x3C, 0x7C, 0x1E, 0x00, 0x01, 0x00, 0xF0, 0x7C, 0x1E, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x0F, 0x03, 0xC0, 0xF0, 0x7C, 0x1E, 0x07, 0x81, 0xE0, 0x78,
  0x3E, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x3E,
  0x00, 0x00, 0x10, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x0B, 0xE0, 0x3F, 0x80, 0xFC, 0x03, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x01, 0x0F, 0x07, 0x83, 0xC3, 0xC0,
  0xF1, 0xE0, 0x78, 0xF8, 0x1E, 0x7C, 0x07, 0xBE, 0x01, 0xFF, 0x00, 0x77,
  0x80, 0x3F, 0xE0, 0x0F, 0xFC, 0x03, 0xEF, 0x00, 0xF3, 0xC0, 0x3C, 0xF8,
  0x1E, 0x1E, 0x07, 0x87, 0x81, 0xE1, 0xF0, 0x78, 0x3C, 0x3E, 0x0F, 0x80,
  0x03, 0xC0, 0xF0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x7C, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x3E, 0x00, 0x00, 0x1C, 0x0F,
  0x03, 0x9F, 0x8F, 0xE0, 0xEF, 0xF7, 0xFC, 0x3F, 0xFD, 0xFF, 0x1F, 0x8F,
  0xC3, 0xC7, 0xC1, 0xE0, 0xF1, 0xF0, 0xF8, 0x3C, 0x78, 0x3C, 0x0F, 0x1E,
  0x0F, 0x07, 0x8F, 0x03, 0xC1, 0xE3, 0xC0, 0xF0, 0x78, 0xF0, 0x78, 0x1E,
  0x3C, 0x1E, 0x07, 0x8F, 0x07, 0x83, 0xC7, 0x81, 0xE0, 0xF1, 0xE0, 0x78,
  0x3C, 0x78, 0x3C, 0x0F, 0x1E, 0x0F, 0x07, 0x8F, 0x83, 0xC1, 0xE0, 0x00,
  0x1C, 0x07, 0x3F, 0x83, 0xBF, 0xC1, 0xFF, 0xF1, 0xF8, 0x78, 0xF8, 0x3C,
  0x7C, 0x1E, 0x3C, 0x1F, 0x1E, 0x0F, 0x1E, 0x07, 0x8F, 0x03, 0xC7, 0x81,
  0xE3, 0xC1, 0xF1, 0xE0, 0xF1, 0xE0, 0x78, 0xF0, 0x3C, 0x78, 0x1E, 0x3C,
  0x1E, 0x3E, 0x0F, 0x00, 0x01, 0xE0, 0x07, 0xF8, 0x0F, 0xFC, 0x1F, 0xFE,
  0x3E, 0x1E, 0x3C, 0x1E, 0x7C, 0x1F, 0x78, 0x1F, 0x78, 0x1F, 0x78, 0x1E,
  0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x3E, 0xF0, 0x3C, 0xF8, 0x7C, 0x78, 0xF8,
  0x7F, 0xF8, 0x3F, 0xF0, 0x1F, 0xC0, 0x00, 0x0E, 0x01, 0xCF, 0xE0, 0x77,
  0xF8, 0x1F, 0xFF, 0x0F, 0xC7, 0xC3, 0xE0, 0xF0, 0xF0, 0x3C, 0x3C, 0x0F,
  0x0F, 0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x7C, 0x78, 0x1E, 0x1E, 0x07, 0x87,
  0x83, 0xE3, 0xE0, 0xF0, 0xFC, 0x7C, 0x3F, 0xFE, 0x0F, 0xFF, 0x03, 0x9F,
  0x81, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x03, 0xFB, 0xC3,
  0xFD, 0xC3, 0xFF, 0xE3, 0xE1, 0xF1, 0xE0, 0xF9, 0xF0, 0x7C, 0xF0, 0x3C,
  0x78, 0x1E, 0x3C, 0x0F, 0x3E, 0x07, 0x9E, 0x07, 0xCF, 0x03, 0xC7, 0x81,
  0xE3, 0xE1, 0xF1, 0xF1, 0xF8, 0x7F, 0xF8, 0x3F, 0xFC, 0x0F, 0x9E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0xF8, 0x00, 0x78, 0x00, 0x01, 0x1C, 0x39, 0xF0, 0xEF, 0xC3, 0xBE,
  0x1F, 0xC0, 0x7E, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x3F, 0xF1, 0xFF, 0x87, 0xDE, 0x3C, 0x08,
  0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x30, 0x7C, 0xFF, 0xE3, 0xFF, 0x07, 0xF8,
  0x00, 0x0E, 0x03, 0x81, 0xE0, 0x78, 0x7F, 0xFF, 0xFF, 0xFC, 0xF0, 0x78,
  0x1E, 0x07, 0x81, 0xE0, 0x78, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xF8, 0xFE, 0x1F, 0x80, 0x1E, 0x07, 0x8F, 0x07, 0x87, 0x83, 0xC7,
  0x81, 0xE3, 0xC0, 0xF1, 0xE0, 0x78, 0xF0, 0x78, 0xF8, 0x3C, 0x78, 0x1E,
  0x3C, 0x0F, 0x1E, 0x0F, 0x8F, 0x07, 0x87, 0x87, 0xC7, 0xC3, 0xE3, 0xE3,
  0xF0, 0xFF, 0xF0, 0x7F, 0xB8, 0x1F, 0x9C, 0x00, 0xF0, 0x3F, 0xE0, 0x7B,
  0xC0, 0xF7, 0x83, 0xCF, 0x07, 0x9E, 0x1E, 0x3C, 0x3C, 0x78, 0xF0, 0x71,
  0xE0, 0xE7, 0x81, 0xCF, 0x03, 0xBC, 0x07, 0x78, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0xF0, 0x7C, 0x1F, 0xE0, 0xF8, 0x7F,
  0xC3, 0xF0, 0xF7, 0x87, 0xE1, 0xEF, 0x1D, 0xC7, 0x9E, 0x3B, 0x8F, 0x3C,
  0xF7, 0x3C, 0x79, 0xCE, 0x78, 0xF3, 0x9C, 0xE1, 0xEE, 0x3B, 0xC3, 0xDC,
  0x77, 0x87, 0xF8, 0xFE, 0x0F, 0xE1, 0xFC, 0x1F, 0xC3, 0xF0, 0x3F, 0x07,
  0xE0, 0x7E, 0x0F, 0x80, 0xFC, 0x1F, 0x01, 0xF0, 0x3C, 0x00, 0x07, 0x83,
  0xE0, 0xF0, 0xF8, 0x0F, 0x1E, 0x01, 0xE7, 0x80, 0x3D, 0xF0, 0x03, 0xBC,
  0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x00, 0xF0, 0x00, 0x3F, 0x00, 0x0F, 0xE0,
  0x03, 0xFC, 0x00, 0x7B, 0xC0, 0x1E, 0x78, 0x07, 0x8F, 0x01, 0xF0, 0xF0,
  0x3C, 0x1E, 0x1F, 0x03, 0xE0, 0x07, 0x80, 0xF0, 0x78, 0x1E, 0x07, 0x81,
  0xE0, 0x78, 0x3C, 0x07, 0x83, 0xC0, 0x38, 0x78, 0x03, 0x87, 0x80, 0x38,
  0xF0, 0x03, 0x8F, 0x00, 0x3D, 0xE0, 0x03, 0xDE, 0x00, 0x3F, 0xC0, 0x03,
  0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x80, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xFE,
  0x1F, 0xFC, 0x3F, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x7C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1F, 0x00, 0x3F, 0xF8, 0xFF, 0xF1, 0xFF, 0xE0, 0x00, 0x7C, 0x03, 0xE0,
  0x1F, 0x80, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0x01, 0xF8, 0x07, 0x00, 0x3F, 0x00,
  0x3E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x03, 0xC0, 0x0F, 0x80, 0x7E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0x80, 0x0E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x78, 0x01, 0xE0, 0x03,
  0xF0, 0x07, 0x80, 0x7E, 0x03, 0xE0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x0F, 0xE0, 0x3F,
  0x00, 0xF8, 0x00, 0x18, 0x02, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F,
  0xD0, 0x06, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_SemiBoldItalic34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 10, 24, 9, 0, -24 },
  { 31, 12, 9, 14, 3, -24 },
  { 45, 19, 24, 20, 1, -24 },
  { 102, 16, 28, 17, 1, -26 },
  { 158, 23, 25, 26, 2, -25 },
  { 230, 20, 25, 21, 1, -25 },
  { 293, 6, 9, 8, 3, -24 },
  { 300, 12, 29, 10, 1, -24 },
  { 344, 12, 30, 10, -3, -25 },
  { 389, 14, 15, 17, 3, -26 },
  { 416, 15, 16, 18, 2, -20 },
  { 446, 8, 8, 9, -2, -4 },
  { 454, 9, 4, 10, 1, -11 },
  { 459, 5, 5, 9, 0, -5 },
  { 463, 18, 24, 13, -2, -24 },
  { 517, 16, 25, 17, 1, -25 },
  { 567, 11, 24, 17, 4, -24 },
  { 600, 18, 25, 17, -1, -25 },
  { 657, 17, 25, 17, 0, -25 },
  { 711, 17, 24, 17, 0, -24 },
  { 762, 17, 24, 17, 0, -24 },
  { 813, 17, 25, 17, 1, -25 },
  { 867, 17, 24, 17, 1, -24 },
  { 918, 16, 25, 17, 1, -25 },
  { 968, 16, 25, 17, 1, -25 },
  { 1018, 8, 19, 9, 0, -19 },
  { 1037, 10, 23, 9, -2, -19 },
  { 1066, 15, 17, 18, 2, -21 },
  { 1098, 15, 10, 18, 2, -17 },
  { 1117, 15, 17, 18, 2, -21 },
  { 1149, 13, 25, 14, 2, -25 },
  { 1190, 25, 27, 26, 1, -24 },
  { 1275, 19, 24, 19, -2, -24 },
  { 1332, 18, 24, 19, 1, -24 },
  { 1386, 18, 25, 18, 2, -25 },
  { 1443, 19, 24, 21, 1, -24 },
  { 1500, 17, 24, 16, 1, -24 },
  { 1551, 17, 24, 16, 1, -24 },
  { 1602, 19, 25, 21, 2, -25 },
  { 1662, 21, 24, 21, 1, -24 },
  { 1725, 15, 24, 11, -1, -24 },
  { 1770, 15, 31, 10, -5, -24 },
  { 1829, 20, 24, 18, 1, -24 },
  { 1889, 12, 24, 15, 1, -24 },
  { 1925, 27, 24, 27, 1, -24 },
  { 2006, 22, 24, 23, 1, -24 },
  { 2072, 19, 25, 22, 2, -25 },
  { 2132, 18, 24, 18, 1, -24 },
  { 2186, 19, 31, 22, 2, -25 },
  { 2260, 17, 24, 19, 1, -24 },
  { 2311, 17, 25, 16, 0, -25 },
  { 2365, 16, 24, 16, 3, -24 },
  { 2413, 20, 24, 21, 2, -24 },
  { 2473, 18, 24, 18, 3, -24 },
  { 2527, 27, 24, 27, 3, -24 },
  { 2608, 22, 24, 18, -2, -24 },
  { 2674, 17, 24, 17, 3, -24 },
  { 2725, 19, 24, 16, -1, -24 },
  { 2782, 14, 29, 10, -1, -24 },
  { 2833, 7, 24, 13, 4, -24 },
  { 2854, 13, 29, 10, -2, -24 },
  { 2902, 16, 15, 17, 1, -24 },
  { 2932, 13, 2, 13, -3, 3 },
  { 2936, 6, 5, 10, 5, -26 },
  { 2940, 17, 19, 18, 1, -19 },
  { 2981, 17, 26, 18, 0, -26 },
  { 3037, 14, 19, 15, 1, -19 },
  { 3071, 18, 26, 18, 1, -26 },
  { 3130, 15, 19, 17, 1, -19 },
  { 3166, 19, 34, 11, -4, -26 },
  { 3247, 18, 27, 18, 0, -19 },
  { 3308, 17, 26, 18, 0, -26 },
  { 3364, 10, 26, 9, 0, -26 },
  { 3397, 14, 34, 9, -4, -26 },
  { 3457, 18, 26, 17, 0, -26 },
  { 3516, 10, 26, 9, 0, -26 },
  { 3549, 26, 19, 27, 0, -19 },
  { 3611, 17, 19, 18, 0, -19 },
  { 3652, 16, 19, 18, 1, -19 },
  { 3690, 18, 27, 18, -1, -19 },
  { 3751, 17, 27, 18, 1, -19 },
  { 3809, 14, 19, 13, 0, -19 },
  { 3843, 14, 19, 14, 0, -19 },
  { 3877, 10, 22, 12, 2, -22 },
  { 3905, 17, 18, 18, 1, -18 },
  { 3944, 15, 18, 15, 2, -18 },
  { 3978, 23, 18, 24, 2, -18 },
  { 4030, 19, 18, 16, -2, -18 },
  { 4073, 20, 26, 15, -3, -18 },
  { 4138, 15, 18, 14, -1, -18 },
  { 4172, 14, 29, 12, 0, -24 },
  { 4223, 3, 34, 16, 7, -26 },
  { 4236, 14, 29, 12, -2, -24 },
  { 4287, 15, 6, 18, 2, -15 },
};

const GFXfont NotoSans_SemiCondensed_SemiBoldItalic34pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_SemiBoldItalic34pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_SemiBoldItalic34pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC34PT7B_H_
