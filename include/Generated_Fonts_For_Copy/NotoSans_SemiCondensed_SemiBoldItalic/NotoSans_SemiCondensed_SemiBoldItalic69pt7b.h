#ifndef _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC69PT7B_H_
#define _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC69PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-SemiBoldItalic.ttf
// Size: 69pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_SemiBoldItalic69pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07,
  0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x3F, 0x80, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0x00, 0x07, 0x80, 0x00,
  0x3F, 0xE1, 0xFE, 0x7F, 0x83, 0xFC, 0xFF, 0x07, 0xF1, 0xFC, 0x1F, 0xE3,
  0xF8, 0x3F, 0xC7, 0xF0, 0x7F, 0x1F, 0xE0, 0xFE, 0x3F, 0x81, 0xFC, 0x7F,
  0x03, 0xF8, 0xFE, 0x07, 0xE1, 0xFC, 0x1F, 0xC3, 0xF0, 0x3F, 0x87, 0xE0,
  0x7E, 0x1F, 0xC0, 0xFC, 0x3F, 0x01, 0xF8, 0x7E, 0x03, 0xF0, 0xFC, 0x07,
  0xC1, 0xF8, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x00, 0x7E,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x07, 0xF0,
  0x1F, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0xFE,
  0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0xFC, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x03, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01,
  0xF8, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x1F,
  0xC0, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0x9E, 0x3E, 0x00, 0x7F, 0x8F, 0x83, 0x80, 0x3F, 0xC3, 0xC0,
  0x20, 0x0F, 0xF0, 0xF0, 0x00, 0x03, 0xFC, 0x3C, 0x00, 0x00, 0xFF, 0x0F,
  0x00, 0x00, 0x3F, 0xC7, 0x80, 0x00, 0x0F, 0xF1, 0xE0, 0x00, 0x03, 0xFE,
  0x78, 0x00, 0x00, 0xFF, 0xDE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x01, 0xCF, 0xF8, 0x00, 0x00, 0xF1, 0xFF, 0x00, 0x00, 0x3C,
  0x7F, 0xC0, 0x00, 0x0F, 0x0F, 0xF0, 0x00, 0x03, 0xC3, 0xFC, 0x00, 0x01,
  0xE0, 0xFF, 0x08, 0x00, 0x78, 0x7F, 0x81, 0x80, 0x1E, 0x1F, 0xE0, 0x78,
  0x07, 0x8F, 0xF8, 0x1F, 0xC1, 0xEF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xC0, 0x07, 0xFF, 0x80, 0x00, 0x7F,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xF8,
  0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x1F, 0x80,
  0x0F, 0xE0, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x81, 0xF8, 0x01, 0xFC, 0x00,
  0x7F, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0xFE, 0x07, 0xE0, 0x0F, 0xE0, 0x01,
  0xF8, 0x0F, 0xC0, 0x3F, 0x80, 0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x00, 0x0F,
  0xE0, 0x3F, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0xFE, 0x07, 0xF0, 0x00, 0x3F,
  0x01, 0xFC, 0x0F, 0xC0, 0x00, 0xFE, 0x03, 0xF8, 0x3F, 0x80, 0x01, 0xFC,
  0x07, 0xE0, 0xFE, 0x00, 0x03, 0xF8, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xF0,
  0x3F, 0x87, 0xF0, 0x00, 0x0F, 0xE0, 0x7F, 0x1F, 0xC1, 0xFE, 0x1F, 0xC1,
  0xFC, 0x3F, 0x0F, 0xFE, 0x3F, 0x83, 0xF8, 0xFE, 0x3F, 0xFE, 0x7F, 0x0F,
  0xE3, 0xF8, 0xFF, 0xFE, 0xFE, 0x1F, 0xC7, 0xE3, 0xFF, 0xFC, 0xFF, 0xFF,
  0x1F, 0xC7, 0xFF, 0xF9, 0xFF, 0xFC, 0x7F, 0x1F, 0xC3, 0xF9, 0xFF, 0xF8,
  0xFC, 0x7F, 0x07, 0xF3, 0xFF, 0xE3, 0xF8, 0xFE, 0x0F, 0xE3, 0xFF, 0x0F,
  0xE1, 0xF8, 0x1F, 0xC1, 0xF8, 0x1F, 0x87, 0xF0, 0x3F, 0x80, 0x00, 0x7F,
  0x0F, 0xE0, 0x7F, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0xFE, 0x00, 0x03, 0xF0,
  0x7F, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0xFE, 0x03, 0xF0, 0x00, 0x3F, 0x81,
  0xFC, 0x07, 0xE0, 0x00, 0x7E, 0x03, 0xF0, 0x1F, 0xC0, 0x01, 0xFC, 0x07,
  0xE0, 0x3F, 0x80, 0x07, 0xF0, 0x0F, 0xC0, 0x7F, 0x00, 0x0F, 0xC0, 0x1F,
  0x80, 0xFC, 0x00, 0x3F, 0x80, 0x3F, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7E,
  0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xF8,
  0x3F, 0x80, 0x1F, 0xC0, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x03, 0xF8, 0x00, 0x0F, 0xFF,
  0xC0, 0x07, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x07,
  0xF8, 0x00, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x00, 0x1F,
  0xE3, 0xFE, 0x00, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0xFF, 0x80,
  0x3F, 0xC0, 0xFF, 0xFF, 0xE0, 0x1F, 0xE0, 0xFF, 0xDF, 0xF0, 0x1F, 0xE0,
  0x7F, 0xC7, 0xFC, 0x0F, 0xF0, 0x7F, 0xC3, 0xFE, 0x0F, 0xF0, 0x7F, 0xC0,
  0xFF, 0x87, 0xF8, 0x3F, 0xC0, 0x3F, 0xE7, 0xF8, 0x3F, 0xE0, 0x1F, 0xF7,
  0xFC, 0x1F, 0xE0, 0x07, 0xFF, 0xFC, 0x0F, 0xF0, 0x03, 0xFF, 0xFC, 0x0F,
  0xF8, 0x00, 0xFF, 0xFE, 0x07, 0xFC, 0x00, 0x7F, 0xFE, 0x03, 0xFE, 0x00,
  0x1F, 0xFE, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xF0, 0x07, 0xFF, 0xE0, 0x0F,
  0xFE, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x7F,
  0xE0, 0x07, 0xFF, 0xFC, 0x1F, 0xF0, 0x01, 0xFF, 0xF0, 0x0F, 0xFC, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xE7, 0xF8, 0xFF, 0x1F, 0xE3, 0xF8,
  0x7F, 0x0F, 0xE3, 0xFC, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x07, 0xE0, 0xFC,
  0x3F, 0x87, 0xE0, 0xFC, 0x1F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x80, 0x1F, 0xC0, 0x07, 0x00,
  0xFC, 0x00, 0x3E, 0x07, 0xE0, 0x01, 0xFC, 0x3F, 0x00, 0x1F, 0xF9, 0xF0,
  0x00, 0xFF, 0xEF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xC0, 0x3F, 0xF8, 0x02, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xBF,
  0x00, 0x03, 0xFD, 0xFC, 0x00, 0x3F, 0xC7, 0xE0, 0x07, 0xFC, 0x3F, 0x80,
  0x3F, 0xE1, 0xFC, 0x00, 0xFE, 0x07, 0xF0, 0x03, 0xE0, 0x3F, 0x80, 0x06,
  0x01, 0xFE, 0x00, 0x10, 0x07, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFE,
  0x07, 0xF8, 0x1F, 0xF0, 0x3F, 0xC0, 0x7F, 0x81, 0xFE, 0x03, 0xFC, 0x07,
  0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xE0,
  0x1F, 0xC0, 0x7F, 0x00, 0xFC, 0x00, 0x3F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF,
  0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0x9F, 0xFF, 0xEF, 0xFF, 0xF8, 0x06, 0x0F,
  0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xBF, 0xC3, 0xC0,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xC3, 0xFE, 0x01,
  0xFF, 0x81, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0x03,
  0xFC, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x0F,
  0xF8, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0xFF, 0x1F, 0xF0, 0x00, 0xFF, 0x1F,
  0xF0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0xFF, 0x3F,
  0xE0, 0x01, 0xFF, 0x3F, 0xE0, 0x01, 0xFF, 0x3F, 0xC0, 0x01, 0xFF, 0x3F,
  0xC0, 0x01, 0xFE, 0x7F, 0xC0, 0x01, 0xFE, 0x7F, 0xC0, 0x01, 0xFE, 0x7F,
  0x80, 0x01, 0xFE, 0x7F, 0x80, 0x03, 0xFE, 0x7F, 0x80, 0x03, 0xFE, 0x7F,
  0x80, 0x03, 0xFC, 0x7F, 0x80, 0x03, 0xFC, 0xFF, 0x80, 0x07, 0xFC, 0xFF,
  0x80, 0x07, 0xFC, 0xFF, 0x80, 0x07, 0xF8, 0xFF, 0x00, 0x0F, 0xF8, 0xFF,
  0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x1F, 0xF0, 0xFF,
  0x80, 0x1F, 0xE0, 0x7F, 0x80, 0x3F, 0xE0, 0x7F, 0x80, 0x7F, 0xC0, 0x7F,
  0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF, 0x80, 0x7F, 0xF7, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE,
  0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFC,
  0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8,
  0xFF, 0xF7, 0xF8, 0x7F, 0xC7, 0xF8, 0x3F, 0x87, 0xF8, 0x3E, 0x0F, 0xF0,
  0x1C, 0x0F, 0xF0, 0x08, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0x0F, 0xFE, 0x00, 0x3F, 0xC0, 0x3F, 0xF0, 0x01,
  0xF0, 0x01, 0xFF, 0x00, 0x0E, 0x00, 0x1F, 0xF0, 0x00, 0x80, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFE, 0x07,
  0xFF, 0x00, 0x3C, 0x00, 0xFF, 0xC0, 0x0E, 0x00, 0x1F, 0xF0, 0x02, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x30, 0x00, 0x07,
  0xFE, 0x0F, 0x00, 0x07, 0xFF, 0x03, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0x07, 0xF7,
  0xF0, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x1F,
  0xE7, 0xF8, 0x00, 0x03, 0xF8, 0xFF, 0x00, 0x00, 0xFE, 0x3F, 0xC0, 0x00,
  0x3F, 0x87, 0xF8, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x03, 0xFC, 0x1F, 0xE0,
  0x00, 0x7F, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x07, 0xF0, 0x1F,
  0xE0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x0F, 0xE0,
  0x0F, 0xE0, 0x03, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x1F,
  0xC0, 0x0F, 0xF0, 0x07, 0xF0, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0x7F, 0x80,
  0x3F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xDF, 0x80, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xF8, 0x00, 0x70, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x82, 0x00, 0x00, 0x7F, 0xC0, 0xC0, 0x00, 0x7F, 0xF0, 0x3C, 0x00, 0x3F,
  0xF8, 0x0F, 0xF9, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x04, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x07, 0xF8, 0x1E, 0x00, 0x03, 0xFC, 0x7F, 0xE0, 0x03, 0xFC,
  0x7F, 0xFC, 0x01, 0xFE, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFE, 0x1F, 0xF8, 0x1F,
  0xFC, 0x03, 0xFE, 0x0F, 0xFC, 0x01, 0xFF, 0x0F, 0xFC, 0x00, 0x7F, 0x87,
  0xFC, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x0F, 0xF0,
  0xFF, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFE,
  0x1F, 0xE0, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x7F,
  0x83, 0xFC, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x3F,
  0xE0, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x3F, 0xF0, 0x0F, 0xFE, 0x7F,
  0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x17, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x1F, 0xF0, 0x1F, 0xE0, 0x03, 0xFC, 0x07,
  0xF8, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x0F, 0xF0,
  0x1F, 0xE0, 0x07, 0xF8, 0x07, 0xF8, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0xFF,
  0x80, 0x3F, 0xC0, 0x7F, 0xC0, 0x0F, 0xF8, 0x3F, 0xE0, 0x03, 0xFF, 0x1F,
  0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07,
  0xFE, 0x3F, 0xF0, 0x03, 0xFF, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0xFF, 0x80, 0x1F, 0xE0, 0x3F, 0xC0, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0xFF,
  0x07, 0xF8, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x03,
  0xFC, 0x3F, 0xE0, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0xC3, 0xFE, 0x00,
  0x0F, 0xF0, 0xFF, 0x80, 0x07, 0xF8, 0x1F, 0xE0, 0x03, 0xFE, 0x07, 0xFC,
  0x00, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0x07, 0xFE, 0x07, 0xFE, 0x03,
  0xFE, 0x07, 0xFC, 0x01, 0xFE, 0x0F, 0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x01,
  0xFE, 0x0F, 0xF0, 0x01, 0xFF, 0x1F, 0xF0, 0x01, 0xFF, 0x1F, 0xE0, 0x01,
  0xFF, 0x1F, 0xE0, 0x01, 0xFF, 0x1F, 0xE0, 0x01, 0xFF, 0x1F, 0xE0, 0x01,
  0xFF, 0x3F, 0xE0, 0x01, 0xFE, 0x3F, 0xE0, 0x03, 0xFE, 0x3F, 0xE0, 0x03,
  0xFE, 0x3F, 0xE0, 0x03, 0xFE, 0x1F, 0xE0, 0x07, 0xFE, 0x1F, 0xF0, 0x0F,
  0xFE, 0x1F, 0xF0, 0x1F, 0xFE, 0x1F, 0xFE, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFB, 0xFC, 0x07, 0xFF, 0xF7,
  0xFC, 0x03, 0xFF, 0xE7, 0xF8, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x00, 0x80, 0x07, 0xFE, 0x00, 0xF8, 0x7F, 0xFC, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x7C, 0x01, 0xFE, 0x01, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03,
  0xFF, 0x07, 0xFE, 0x03, 0xFE, 0x03, 0xFC, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x3F,
  0x80, 0x7F, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF,
  0x80, 0xFF, 0x80, 0xFF, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x7F,
  0x80, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xE0,
  0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0C, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xF8, 0x7F, 0x03, 0xFF, 0x0E, 0x00, 0x7F, 0xC2, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x01, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0x00,
  0x07, 0xE0, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x07, 0xFE,
  0x01, 0xFC, 0x1F, 0xC0, 0x1F, 0xFF, 0xE0, 0x7E, 0x1F, 0xC0, 0x1F, 0xFF,
  0xF0, 0x3F, 0x0F, 0xC0, 0x1F, 0xFF, 0xF8, 0x1F, 0x8F, 0xE0, 0x1F, 0xFF,
  0xFC, 0x0F, 0xC7, 0xE0, 0x1F, 0xE0, 0xFC, 0x07, 0xE7, 0xF0, 0x1F, 0xC0,
  0x7E, 0x03, 0xF3, 0xF0, 0x1F, 0xC0, 0x3F, 0x01, 0xF9, 0xF8, 0x0F, 0xC0,
  0x3F, 0x80, 0xFD, 0xFC, 0x0F, 0xE0, 0x1F, 0x80, 0x7E, 0xFC, 0x07, 0xE0,
  0x0F, 0xC0, 0x3F, 0x7E, 0x07, 0xF0, 0x07, 0xE0, 0x1F, 0xBF, 0x03, 0xF0,
  0x07, 0xF0, 0x1F, 0xFF, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xDF, 0x81, 0xFC,
  0x01, 0xF8, 0x07, 0xEF, 0xC0, 0xFC, 0x01, 0xFC, 0x03, 0xF7, 0xE0, 0x7E,
  0x00, 0xFE, 0x03, 0xF3, 0xF0, 0x3F, 0x00, 0x7E, 0x01, 0xF9, 0xF8, 0x1F,
  0x80, 0x7F, 0x01, 0xFC, 0xFC, 0x0F, 0xC0, 0x3F, 0x80, 0xFC, 0x7E, 0x07,
  0xE0, 0x3F, 0xC0, 0xFE, 0x3F, 0x03, 0xF0, 0x1F, 0xE0, 0x7E, 0x1F, 0x81,
  0xFC, 0x1F, 0xF0, 0x7E, 0x0F, 0xC0, 0xFF, 0xFE, 0xFF, 0xFF, 0x07, 0xE0,
  0x3F, 0xFF, 0x7F, 0xFF, 0x03, 0xF0, 0x1F, 0xFF, 0x1F, 0xFF, 0x01, 0xF8,
  0x07, 0xFF, 0x0F, 0xFF, 0x00, 0xFE, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x3F,
  0x00, 0x1E, 0x00, 0x10, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xFF, 0xE0, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x03, 0xFB, 0xF8, 0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x00, 0x7F, 0xBF,
  0x80, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x00,
  0x3F, 0x8F, 0xE0, 0x00, 0x01, 0xFE, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0xFE,
  0x00, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x07,
  0xF8, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x00, 0xFF, 0x03, 0xF8,
  0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0xFF, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x0F, 0xF0,
  0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x0F, 0xF8,
  0x03, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x1F, 0xF0, 0x00,
  0x1F, 0xE0, 0x7F, 0xC0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x01, 0xFE, 0x0F,
  0xF8, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x00,
  0x7F, 0x87, 0xF8, 0x00, 0x01, 0xFE, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0xFF,
  0x00, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xF8,
  0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x03, 0xFE, 0x01, 0xFF, 0x00,
  0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x07, 0xFC, 0x03,
  0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x1F,
  0xF0, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xF8, 0x03, 0xFC,
  0x03, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0xF0, 0x07, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x7F,
  0xC0, 0x3F, 0xC0, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x0F, 0xF0,
  0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x3F, 0xC0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00,
  0x7F, 0xC0, 0x7F, 0x80, 0x07, 0xFE, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x3F,
  0xC0, 0x07, 0xFF, 0x01, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xC7, 0xF8, 0x01, 0xFF, 0xE0, 0x03, 0xC0, 0x0F,
  0xFE, 0x00, 0x04, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x01, 0x00, 0x0F, 0xFE, 0x00, 0x78, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xE0, 0x3F, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0x00,
  0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x3F, 0xF0,
  0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x3F, 0xC0,
  0x00, 0xFF, 0x80, 0xFF, 0x80, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x01, 0xFE,
  0x03, 0xFC, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x00, 0x7F,
  0xC0, 0xFF, 0x00, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x01, 0xFF, 0x07, 0xFC,
  0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x0F,
  0xF0, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x00, 0x7F, 0xC1, 0xFF,
  0x00, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x07,
  0xFC, 0x0F, 0xF0, 0x00, 0x1F, 0xF8, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x7F,
  0xC0, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x03, 0xFF, 0x01, 0xFE, 0x00, 0x07,
  0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xF8, 0x07, 0xF8, 0x00, 0x7F, 0xE0, 0x1F,
  0xF0, 0x03, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xFF, 0x00, 0x7F, 0x81, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x02, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x8F,
  0xFC, 0x00, 0xFF, 0xF0, 0x00, 0xF0, 0x03, 0xFF, 0x80, 0x00, 0x60, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0xF8, 0xFF, 0x80, 0x0F, 0xFF, 0xF1,
  0xFF, 0x00, 0x1F, 0xFF, 0xE3, 0xFE, 0x00, 0x7F, 0xFF, 0x87, 0xFC, 0x00,
  0xFF, 0xFF, 0x0F, 0xF8, 0x01, 0xFF, 0xFE, 0x1F, 0xF0, 0x03, 0xFF, 0xFC,
  0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0xFF, 0x00,
  0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x01, 0xFF,
  0x07, 0xFC, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x1F, 0xF0,
  0x00, 0x0F, 0xF0, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x00, 0x7F,
  0xC0, 0x7F, 0xE0, 0x00, 0xFF, 0x00, 0xFF, 0xE0, 0x01, 0xFE, 0x00, 0xFF,
  0xE0, 0x03, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xE0, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0,
  0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x07, 0xF8,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x07,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x61, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFC,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x07,
  0xFC, 0x00, 0x0F, 0xF0, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0x80,
  0x01, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x00, 0x1F,
  0xE0, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xC1, 0xFF, 0x80,
  0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x01,
  0xFE, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0x8F, 0xFC, 0x00, 0x00, 0x1F, 0xE7,
  0xFE, 0x00, 0x00, 0x07, 0xF9, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xDF, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0x7F, 0x80, 0x00, 0x03, 0xFF, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0x87, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x1F, 0xF0,
  0x00, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80,
  0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xE0, 0x07, 0xF7, 0xF0, 0x00, 0x3F, 0xBF, 0x80, 0x0F, 0xEF, 0xE0, 0x00,
  0x7F, 0x7F, 0x00, 0x1F, 0xDF, 0xC0, 0x01, 0xFD, 0xFE, 0x00, 0x3F, 0xBF,
  0x80, 0x03, 0xFB, 0xFC, 0x00, 0xFF, 0x7F, 0x00, 0x0F, 0xE7, 0xF8, 0x01,
  0xFE, 0xFE, 0x00, 0x1F, 0xCF, 0xE0, 0x03, 0xFD, 0xFC, 0x00, 0x7F, 0x3F,
  0xC0, 0x07, 0xF3, 0xF8, 0x00, 0xFE, 0x7F, 0x80, 0x0F, 0xE7, 0xF0, 0x03,
  0xF8, 0xFF, 0x00, 0x3F, 0xCF, 0xE0, 0x07, 0xF1, 0xFC, 0x00, 0x7F, 0x8F,
  0xC0, 0x1F, 0xC7, 0xF8, 0x00, 0xFF, 0x1F, 0x80, 0x3F, 0x8F, 0xF0, 0x01,
  0xFC, 0x3F, 0x00, 0xFE, 0x1F, 0xE0, 0x07, 0xF8, 0x7F, 0x01, 0xFC, 0x3F,
  0xC0, 0x0F, 0xF0, 0xFE, 0x07, 0xF0, 0x7F, 0x00, 0x1F, 0xE1, 0xFC, 0x0F,
  0xE1, 0xFE, 0x00, 0x3F, 0xC3, 0xF8, 0x3F, 0x83, 0xFC, 0x00, 0x7F, 0x07,
  0xF0, 0x7F, 0x07, 0xF8, 0x01, 0xFE, 0x0F, 0xE1, 0xFC, 0x0F, 0xF0, 0x03,
  0xFC, 0x1F, 0xC3, 0xF8, 0x1F, 0xC0, 0x07, 0xF8, 0x3F, 0x8F, 0xE0, 0x7F,
  0x80, 0x0F, 0xE0, 0x7F, 0x1F, 0xC0, 0xFF, 0x00, 0x1F, 0xC0, 0xFE, 0x7F,
  0x01, 0xFE, 0x00, 0x7F, 0x81, 0xFC, 0xFE, 0x03, 0xFC, 0x00, 0xFF, 0x03,
  0xFB, 0xF8, 0x0F, 0xF0, 0x01, 0xFE, 0x03, 0xF7, 0xF0, 0x1F, 0xE0, 0x03,
  0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xC0, 0x07, 0xF0, 0x0F, 0xFF, 0x80, 0x7F,
  0x80, 0x1F, 0xE0, 0x1F, 0xFE, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x3F, 0xFC,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x7F, 0xF0, 0x07, 0xF8, 0x00, 0xFE, 0x00,
  0xFF, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xE0, 0x07,
  0xF8, 0x03, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x07, 0xFC, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xF0, 0x03, 0xFF,
  0x80, 0x00, 0x3F, 0x80, 0x0F, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xE0, 0x07, 0xFF, 0xC0,
  0x00, 0x7F, 0x80, 0x1F, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xFE, 0x00,
  0x0F, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0xE0, 0x00,
  0xFF, 0x00, 0x3F, 0xBF, 0x80, 0x03, 0xF8, 0x00, 0xFE, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xFB, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE7, 0xF0, 0x01, 0xFE,
  0x00, 0x7F, 0x9F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x7F, 0x80, 0x1F, 0xC0,
  0x07, 0xF1, 0xFE, 0x00, 0xFF, 0x00, 0x1F, 0xC3, 0xF8, 0x03, 0xFC, 0x00,
  0x7F, 0x0F, 0xF0, 0x0F, 0xF0, 0x03, 0xFC, 0x3F, 0xC0, 0x3F, 0xC0, 0x0F,
  0xF0, 0xFF, 0x00, 0xFE, 0x00, 0x3F, 0xC1, 0xFE, 0x07, 0xF8, 0x00, 0xFE,
  0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x80, 0x1F, 0xE0,
  0x3F, 0x81, 0xFC, 0x00, 0x7F, 0x80, 0xFF, 0x07, 0xF0, 0x01, 0xFE, 0x03,
  0xFC, 0x3F, 0xC0, 0x07, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0x3F, 0xC0, 0x1F,
  0xE3, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x8F, 0xE0, 0x03, 0xFC, 0x01, 0xFE,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF9, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xF7,
  0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xDF, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x7F,
  0x00, 0x1F, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0xF0,
  0x01, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x3F, 0xFF, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x03,
  0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x1F, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0xF0, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0xF8,
  0x00, 0x07, 0xFF, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFC, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x1F, 0xFC,
  0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x3F, 0xF0,
  0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0x3F, 0xE1, 0xFF, 0x80, 0x00, 0x7F,
  0xC3, 0xFE, 0x00, 0x00, 0x7F, 0x8F, 0xF8, 0x00, 0x00, 0xFF, 0x1F, 0xF0,
  0x00, 0x01, 0xFE, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0xFF, 0x80, 0x00, 0x07,
  0xF9, 0xFF, 0x00, 0x00, 0x0F, 0xF7, 0xFC, 0x00, 0x00, 0x1F, 0xEF, 0xF8,
  0x00, 0x00, 0x3F, 0xDF, 0xF0, 0x00, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x00,
  0x7F, 0xDF, 0xF0, 0x00, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x01, 0xFF, 0x7F,
  0x80, 0x00, 0x07, 0xFC, 0xFF, 0x00, 0x00, 0x0F, 0xF9, 0xFE, 0x00, 0x00,
  0x1F, 0xF3, 0xFC, 0x00, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x00, 0xFF, 0x8F,
  0xF8, 0x00, 0x03, 0xFF, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x3F, 0xE0, 0x00,
  0x1F, 0xF8, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xF0,
  0x0F, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0xC0,
  0x3F, 0xE0, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x0F, 0xF0, 0x00,
  0xFF, 0x80, 0x7F, 0x80, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x3F,
  0xE0, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x7F, 0x80, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0xE0,
  0x03, 0xFE, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xF0, 0x07, 0xFF, 0x00,
  0x7F, 0x83, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFC, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x1F,
  0xF8, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x7F,
  0xC0, 0x00, 0x3F, 0xE1, 0xFF, 0x80, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x00,
  0x7F, 0x8F, 0xF8, 0x00, 0x00, 0xFF, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x7F,
  0xE0, 0x00, 0x03, 0xFC, 0xFF, 0x80, 0x00, 0x07, 0xF9, 0xFF, 0x00, 0x00,
  0x0F, 0xF7, 0xFC, 0x00, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x00, 0x3F, 0xDF,
  0xF0, 0x00, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x00, 0x7F, 0xDF, 0xF0, 0x00,
  0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x01, 0xFF, 0x7F, 0x80, 0x00, 0x07, 0xFC,
  0xFF, 0x00, 0x00, 0x0F, 0xF9, 0xFE, 0x00, 0x00, 0x1F, 0xF3, 0xFC, 0x00,
  0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x03, 0xFE,
  0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x7F, 0xE0,
  0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x07, 0xFF,
  0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07,
  0xF8, 0x07, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xF0, 0x07, 0xF8, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0xFF, 0x00,
  0x1F, 0xF0, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x1F,
  0xF0, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0x01, 0xFE,
  0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x07, 0xFE, 0x03, 0xFE, 0x00,
  0xFF, 0xC0, 0x3F, 0xC0, 0x1F, 0xFC, 0x03, 0xFC, 0x0F, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x00, 0xFF,
  0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0xFF, 0x01, 0xFE, 0x00,
  0x1F, 0xF0, 0x1F, 0xF0, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x7F, 0xC0,
  0x3F, 0xC0, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x03,
  0xFE, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x01, 0xFF, 0x07, 0xF8,
  0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xEF, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0x00,
  0x3F, 0xF0, 0x00, 0x40, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x40, 0x00, 0x1F, 0xF0, 0x0E, 0x00, 0x07, 0xFE, 0x01,
  0xF0, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x01,
  0xFF, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x01,
  0xFE, 0x00, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x03, 0xFE, 0x00,
  0x03, 0xFE, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x03, 0xFC,
  0x03, 0xFC, 0x00, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x07, 0xFC,
  0x00, 0x07, 0xFC, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x0F,
  0xF0, 0x00, 0x0F, 0xF8, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x1F, 0xE0,
  0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0x3F,
  0xE0, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x7F,
  0xC0, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x00,
  0x7F, 0xC0, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x00, 0x7F, 0x80,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0xFF, 0x80,
  0x00, 0xFF, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x1F,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x03, 0xFE,
  0x7F, 0x80, 0x00, 0x7F, 0xC7, 0xF8, 0x00, 0x07, 0xFC, 0x7F, 0x80, 0x00,
  0x7F, 0x87, 0xF8, 0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x00, 0xFF, 0x07, 0xF8,
  0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x3F, 0xE0,
  0x7F, 0x80, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x07,
  0xF8, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x0F, 0xF0, 0x07, 0xF8,
  0x01, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFE, 0x00,
  0x3F, 0x80, 0x3F, 0xC0, 0x03, 0xF8, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x7F,
  0x80, 0x03, 0xF8, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x03, 0xF8,
  0x0F, 0xF0, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00,
  0x3F, 0xC3, 0xFC, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x3F, 0xC7, 0xF8,
  0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0x3F, 0xCF, 0xF8, 0x00, 0x03, 0xFC,
  0xFF, 0x00, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x00,
  0x1F, 0xDF, 0xE0, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x7F, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x7F, 0x00, 0x01, 0xFF,
  0x00, 0x03, 0xFC, 0x7F, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x7F, 0x00,
  0x03, 0xFF, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xF8,
  0x7F, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xF8, 0x7F, 0x00, 0x07, 0xFF, 0x00,
  0x0F, 0xF0, 0x7F, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xF0, 0x7F, 0x00, 0x0F,
  0xFF, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xE0, 0x7F,
  0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x3F, 0xFF, 0x00, 0x3F,
  0xC0, 0x7F, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0x00, 0x7F, 0x7F,
  0x00, 0x7F, 0x80, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0xFF, 0x80, 0x7F, 0x00,
  0x7F, 0x7F, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFF, 0x00,
  0x7F, 0x00, 0xFE, 0x7F, 0x01, 0xFE, 0x00, 0x7F, 0x01, 0xFC, 0x7F, 0x01,
  0xFE, 0x00, 0x7F, 0x01, 0xFC, 0x7F, 0x03, 0xFE, 0x00, 0x7F, 0x03, 0xFC,
  0x7F, 0x03, 0xFC, 0x00, 0x7F, 0x03, 0xF8, 0x7F, 0x03, 0xFC, 0x00, 0x7F,
  0x03, 0xF8, 0x7F, 0x07, 0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF8,
  0x00, 0x7F, 0x07, 0xF0, 0x7F, 0x0F, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x7F,
  0x0F, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x7F, 0x0F, 0xF0, 0x00, 0x7F, 0x1F,
  0xE0, 0x7F, 0x1F, 0xE0, 0x00, 0x7F, 0x1F, 0xC0, 0x7F, 0x1F, 0xE0, 0x00,
  0x7F, 0x1F, 0xC0, 0x7F, 0x3F, 0xC0, 0x00, 0x7F, 0x3F, 0x80, 0x7F, 0x3F,
  0xC0, 0x00, 0x7F, 0x3F, 0x80, 0x7F, 0x3F, 0x80, 0x00, 0x7F, 0x7F, 0x00,
  0x7F, 0x7F, 0x80, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0x7F,
  0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x1F,
  0xF0, 0x00, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x8F, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xEF, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x8F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0x83, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0xC0, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x03,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xDF, 0xE0,
  0x00, 0x3F, 0xE7, 0xF8, 0x00, 0x1F, 0xF1, 0xFE, 0x00, 0x07, 0xFC, 0x7F,
  0x80, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x7F, 0xC0,
  0xFF, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x0F, 0xF8, 0x0F, 0xF0, 0x07, 0xFC,
  0x03, 0xFE, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x1F, 0xE0, 0x7F,
  0xC0, 0x07, 0xF8, 0x1F, 0xE0, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x7F, 0x83,
  0xFC, 0x00, 0x0F, 0xF1, 0xFF, 0x00, 0x03, 0xFC, 0xFF, 0x80, 0x00, 0xFF,
  0x3F, 0xC0, 0x00, 0x3F, 0xDF, 0xF0, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFE, 0x01,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xF3, 0xF0, 0x00,
  0x03, 0xF9, 0xFC, 0x00, 0x01, 0xF8, 0xFE, 0x00, 0x01, 0xFC, 0x3F, 0x00,
  0x01, 0xFC, 0x1F, 0xC0, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0xFE, 0x03, 0xF0,
  0x00, 0x7E, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x3F, 0x80, 0x0F, 0xE0, 0x1F, 0x80, 0x03,
  0xF0, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0xFE, 0x0F, 0xE0, 0x00,
  0x3F, 0x0F, 0xE0, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x0F, 0xE7, 0xF0, 0x00,
  0x03, 0xF7, 0xF0, 0x00, 0x01, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0x87, 0xFC, 0x1F, 0xF0, 0xFF, 0x83, 0xFC, 0x0F, 0xF0, 0x3F, 0x81, 0xFC,
  0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0x07, 0xF0, 0x03, 0xFF, 0xE1, 0xFC, 0x01, 0xFF, 0xFC, 0xFF, 0x00, 0xFF,
  0xFF, 0xBF, 0x80, 0x7F, 0xFF, 0xEF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFC, 0x1F, 0xFE, 0x07, 0xFE, 0x03, 0xFF, 0x83, 0xFF, 0x00, 0xFF, 0xC0,
  0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0xE0, 0x07, 0xFC, 0x1F, 0xF0, 0x01, 0xFF,
  0x07, 0xFC, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x07,
  0xF8, 0x3F, 0xC0, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x87, 0xFC, 0x00,
  0x3F, 0xC1, 0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x03, 0xFC, 0x1F, 0xE0,
  0x00, 0xFF, 0x07, 0xF8, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x1F, 0xE0, 0x7F,
  0x80, 0x07, 0xF8, 0x3F, 0xE0, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0x83,
  0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0x80, 0x3F, 0xF0, 0x1F, 0xF0, 0x1F, 0xFC,
  0x07, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xCF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFB, 0xF8, 0x03, 0xFF, 0xFC, 0xFE, 0x00, 0x7F, 0xFE,
  0x3F, 0x80, 0x0F, 0xFF, 0x0F, 0xE0, 0x01, 0xFF, 0x83, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x7E, 0x00, 0x03, 0xFC, 0x7F, 0xE0, 0x01,
  0xFE, 0x3F, 0xFC, 0x00, 0x7F, 0x9F, 0xFF, 0x80, 0x1F, 0xEF, 0xFF, 0xF0,
  0x07, 0xF7, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xF0, 0x7F,
  0xE0, 0x3F, 0xF8, 0x0F, 0xF8, 0x0F, 0xFC, 0x01, 0xFE, 0x03, 0xFE, 0x00,
  0x7F, 0x81, 0xFF, 0x80, 0x1F, 0xE0, 0x7F, 0xC0, 0x07, 0xFC, 0x1F, 0xF0,
  0x01, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x1F, 0xE0, 0xFF,
  0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x83,
  0xFC, 0x00, 0x3F, 0xE0, 0xFE, 0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x03, 0xFC,
  0x1F, 0xE0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x1F,
  0xE0, 0xFF, 0x80, 0x0F, 0xF8, 0x3F, 0xE0, 0x03, 0xFE, 0x0F, 0xF8, 0x01,
  0xFF, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x3F, 0xE0, 0x7F, 0xF0,
  0x1F, 0xF8, 0x1F, 0xFF, 0x1F, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFD,
  0xFF, 0xFF, 0x80, 0x7F, 0x7F, 0xFF, 0xC0, 0x3F, 0x8F, 0xFF, 0xE0, 0x0F,
  0xE1, 0xFF, 0xE0, 0x03, 0xF0, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xC0, 0x7F, 0xE0, 0x38, 0x0F, 0xFC, 0x00, 0x81, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x40, 0xFF, 0xC0,
  0x1C, 0x07, 0xFF, 0x0F, 0xC0, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xC0, 0xFF, 0x00, 0x03, 0xFF, 0x87, 0xF8, 0x00, 0x3F, 0xFE, 0x3F,
  0xC0, 0x03, 0xFF, 0xF9, 0xFE, 0x00, 0x3F, 0xFF, 0xEF, 0xE0, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0x83, 0xFF, 0xC0,
  0x1F, 0xF8, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x01,
  0xFF, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x3F,
  0xC0, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x1F, 0xF0, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x7F, 0xC0,
  0x03, 0xFC, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x07, 0xFC,
  0x00, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x07, 0xFF, 0x00, 0x3F, 0xF0,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xEF, 0xE0, 0x00, 0xFF, 0xFE, 0x7F, 0x00, 0x03, 0xFF, 0xC3,
  0xF8, 0x00, 0x0F, 0xFC, 0x1F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x1F, 0xFC,
  0x3F, 0xE0, 0xFF, 0x80, 0xFF, 0x0F, 0xF8, 0x07, 0xF8, 0xFF, 0x80, 0x3F,
  0xC7, 0xF8, 0x01, 0xFE, 0x7F, 0xC0, 0x0F, 0xF3, 0xFC, 0x00, 0x7F, 0x9F,
  0xE0, 0x07, 0xF9, 0xFE, 0x00, 0x7F, 0xCF, 0xF0, 0x0F, 0xFC, 0x7F, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x0C, 0x0F, 0xFC, 0x03, 0xE0, 0x7F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x04,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x0C, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x7F, 0x00, 0x0F, 0xFF, 0xC7, 0xF0, 0x01, 0xFF, 0xFC,
  0xFF, 0x00, 0x3F, 0xFF, 0xEF, 0xE0, 0x07, 0xFF, 0xFE, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFC, 0x1F, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xE0,
  0x3F, 0xF0, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x07,
  0xFC, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x07, 0xF8, 0x0F, 0xF8,
  0x00, 0x7F, 0x80, 0xFF, 0x80, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0xFF, 0x00, 0x07, 0xF8, 0x1F, 0xF0, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x0F,
  0xF0, 0x1F, 0xE0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x1F, 0xE0,
  0x01, 0xFF, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x03, 0xFE, 0x03,
  0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x07, 0xFE, 0x01, 0xFE, 0x00, 0x7F,
  0xE0, 0x1F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0xC0, 0x1F, 0xF0,
  0x3F, 0xFC, 0x01, 0xFF, 0xC7, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF7, 0xF8, 0x00, 0x7F, 0xFE, 0x7F,
  0x80, 0x03, 0xFF, 0xC7, 0xF8, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x00, 0x18,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x08, 0x00, 0x07, 0xFC, 0x00, 0xF0, 0x00,
  0xFF, 0xC0, 0x0F, 0xE0, 0x7F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x01, 0xFE, 0x3F, 0xF8, 0x01, 0xFE, 0x3F,
  0xFE, 0x00, 0xFF, 0x7F, 0xFF, 0x80, 0x7F, 0xBF, 0xFF, 0xC0, 0x3F, 0xBF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0x07, 0xFC, 0x0F, 0xFE,
  0x03, 0xFE, 0x07, 0xFE, 0x00, 0xFF, 0x03, 0xFF, 0x00, 0x7F, 0x83, 0xFF,
  0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x0F, 0xF0, 0x7F,
  0xC0, 0x0F, 0xF8, 0x3F, 0xC0, 0x07, 0xF8, 0x3F, 0xE0, 0x03, 0xFC, 0x1F,
  0xF0, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x83,
  0xFC, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x1F, 0xE0,
  0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x0F, 0xF0, 0x7F, 0xC0, 0x07, 0xF8,
  0x3F, 0xC0, 0x03, 0xFC, 0x1F, 0xE0, 0x01, 0xFE, 0x0F, 0xF0, 0x01, 0xFF,
  0x07, 0xF8, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x3F,
  0xC1, 0xFE, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x0F,
  0xF0, 0x7F, 0xC0, 0x07, 0xF8, 0x3F, 0xC0, 0x03, 0xFC, 0x1F, 0xE0, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0x80, 0x03, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF0,
  0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x01, 0xFF,
  0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xFC,
  0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xF0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x73,
  0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x10, 0x0F, 0xF0, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xF8, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x3F, 0xE0, 0x03,
  0xFE, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x03, 0xFC, 0x0F, 0xF8,
  0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x03, 0xFC, 0x3F, 0xE0, 0x00, 0x7F, 0x87,
  0xFC, 0x00, 0x07, 0xF8, 0xFF, 0x80, 0x00, 0x7F, 0x9F, 0xF0, 0x00, 0x07,
  0xFB, 0xFE, 0x00, 0x00, 0x7F, 0x7F, 0xC0, 0x00, 0x0F, 0xF7, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x1F,
  0xFD, 0xFE, 0x00, 0x01, 0xFF, 0x9F, 0xF0, 0x00, 0x1F, 0xF1, 0xFF, 0x00,
  0x03, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x03, 0xFC, 0x0F,
  0xF8, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0x7F,
  0x80, 0x7F, 0xC0, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x3F, 0xE0,
  0x07, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x0F, 0xF0, 0x01,
  0xFF, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3F,
  0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0xFF,
  0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x03, 0xFE,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC1,
  0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xFC, 0x7F, 0xFC, 0x0F, 0xFF, 0xC0, 0x1F,
  0xCF, 0xFF, 0xE1, 0xFF, 0xFC, 0x01, 0xFD, 0xFF, 0xFF, 0x3F, 0xFF, 0xE0,
  0x1F, 0xDF, 0xFF, 0xF7, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xE0, 0x3F, 0xFC, 0x1F, 0xFF, 0x83, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xF0,
  0x1F, 0xF0, 0x3F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0xFF,
  0xC0, 0x1F, 0xF0, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFE, 0x07, 0xFC, 0x00,
  0xFF, 0x80, 0x1F, 0xE0, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFE, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x0F,
  0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xFC, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x83, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xF8, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x0F, 0xF0,
  0x01, 0xFE, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x7E, 0x0F, 0xFE, 0x00, 0x7F, 0x1F, 0xFF, 0x80, 0x3F,
  0x9F, 0xFF, 0xE0, 0x1F, 0xDF, 0xFF, 0xF0, 0x0F, 0xEF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xC1, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0x81,
  0xFF, 0x80, 0x3F, 0xC0, 0xFF, 0xC0, 0x1F, 0xE0, 0xFF, 0xC0, 0x0F, 0xF0,
  0x7F, 0xE0, 0x07, 0xF8, 0x3F, 0xE0, 0x03, 0xFC, 0x1F, 0xF0, 0x03, 0xFE,
  0x0F, 0xF0, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x7F,
  0x83, 0xFC, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x1F,
  0xE0, 0xFF, 0x80, 0x0F, 0xF0, 0x7F, 0x80, 0x07, 0xF8, 0x3F, 0xC0, 0x07,
  0xFC, 0x1F, 0xE0, 0x03, 0xFE, 0x1F, 0xF0, 0x01, 0xFE, 0x0F, 0xF0, 0x00,
  0xFF, 0x07, 0xF8, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x7F, 0xC1, 0xFE, 0x00,
  0x3F, 0xC1, 0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0x80,
  0x07, 0xF8, 0x3F, 0xC0, 0x07, 0xFC, 0x3F, 0xE0, 0x03, 0xFC, 0x1F, 0xF0,
  0x01, 0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0x07, 0xFE, 0x0F, 0xF8, 0x07, 0xFC, 0x3F, 0xE0,
  0x07, 0xF8, 0x7F, 0xC0, 0x0F, 0xF1, 0xFF, 0x00, 0x1F, 0xE3, 0xFC, 0x00,
  0x3F, 0xEF, 0xF8, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0xFF, 0xBF, 0xC0, 0x01,
  0xFF, 0x7F, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFB, 0xFE, 0x00, 0x0F,
  0xF7, 0xF8, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0xFF,
  0xBF, 0xC0, 0x01, 0xFF, 0x7F, 0x80, 0x03, 0xFC, 0xFF, 0x00, 0x0F, 0xF9,
  0xFE, 0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0xFF, 0x8F,
  0xF0, 0x03, 0xFE, 0x1F, 0xF0, 0x0F, 0xFC, 0x3F, 0xE0, 0x3F, 0xF0, 0x3F,
  0xF0, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x07, 0xFE, 0x00, 0x01, 0xFC, 0x7F, 0xFC, 0x00, 0x07, 0xF3,
  0xFF, 0xF8, 0x00, 0x1F, 0xDF, 0xFF, 0xF0, 0x00, 0x7F, 0x7F, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0x07, 0xFE, 0x00, 0x3F, 0xF8,
  0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0x80,
  0x1F, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0x1F, 0xE0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0xFE, 0x00, 0x0F, 0xF8, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x07,
  0xFC, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F,
  0xC0, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xF8, 0x01, 0xFF,
  0xF1, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xDF, 0xFF, 0xF8,
  0x00, 0x7F, 0x3F, 0xFF, 0xC0, 0x03, 0xFC, 0xFF, 0xFE, 0x00, 0x0F, 0xF1,
  0xFF, 0xE0, 0x00, 0x3F, 0xC3, 0xFF, 0x00, 0x00, 0xFF, 0x01, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x87, 0xF0, 0x03, 0xFF, 0xF1,
  0xFC, 0x01, 0xFF, 0xFC, 0x7F, 0x00, 0xFF, 0xFF, 0xBF, 0x80, 0x7F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFC, 0x1F, 0xFE, 0x07, 0xFE,
  0x03, 0xFF, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x1F, 0xF0, 0x3F,
  0xC0, 0x07, 0xFC, 0x1F, 0xF0, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x7F, 0x83,
  0xFE, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x07, 0xF8, 0x3F, 0xC0, 0x01, 0xFE,
  0x0F, 0xF0, 0x00, 0x7F, 0x87, 0xFC, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x0F,
  0xF0, 0x7F, 0x80, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0x07, 0xF8, 0x00,
  0x7F, 0xC1, 0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x07, 0xF8, 0x3F, 0xE0,
  0x03, 0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x7F, 0xC0, 0x7F,
  0x80, 0x1F, 0xF0, 0x1F, 0xE0, 0x0F, 0xFC, 0x07, 0xFC, 0x07, 0xFF, 0x01,
  0xFF, 0x87, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFD, 0xFE, 0x00, 0x7F, 0xFE, 0x7F, 0x80, 0x0F, 0xFF, 0x1F,
  0xE0, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0x0F, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x0F, 0xC1,
  0xFE, 0x01, 0xFC, 0x7F, 0xE0, 0x1F, 0xCF, 0xFE, 0x01, 0xFC, 0xFF, 0xC0,
  0x1F, 0xDF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF,
  0xE0, 0x40, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0x1F, 0xC0, 0x7F, 0xC0, 0x1C, 0x07,
  0xF8, 0x00, 0x40, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x08, 0x00, 0x1F, 0xF0, 0xE0, 0x01, 0xFF, 0x0F, 0xC0, 0x7F, 0xE0, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC,
  0x00, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFD,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x81, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xE0, 0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF,
  0xC0, 0x3F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x1C, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x7F, 0x83, 0xFC, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x3F, 0xE0, 0xFF,
  0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x0F, 0xF0, 0x7F, 0x80, 0x07, 0xF8, 0x3F,
  0xC0, 0x03, 0xFC, 0x1F, 0xE0, 0x03, 0xFC, 0x0F, 0xF0, 0x01, 0xFE, 0x0F,
  0xF0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x3F, 0xC1,
  0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x0F, 0xF0,
  0x7F, 0x80, 0x07, 0xF8, 0x3F, 0xC0, 0x07, 0xFC, 0x1F, 0xE0, 0x03, 0xFC,
  0x1F, 0xF0, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0xFF,
  0x83, 0xFC, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x3F,
  0xE0, 0xFF, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x1F, 0xF8, 0x3F, 0xC0, 0x0F,
  0xF8, 0x1F, 0xE0, 0x0F, 0xFC, 0x0F, 0xF0, 0x0F, 0xFE, 0x07, 0xFC, 0x0F,
  0xFF, 0x03, 0xFF, 0x1F, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xDF, 0xC0, 0x3F, 0xFF, 0xCF, 0xE0, 0x0F, 0xFF, 0xC7, 0xF0, 0x07, 0xFF,
  0xC3, 0xF8, 0x00, 0xFF, 0x81, 0xF8, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFB, 0xFC, 0x00, 0x1F, 0xE7, 0xF8,
  0x00, 0x7F, 0xCF, 0xF0, 0x00, 0xFF, 0x1F, 0xE0, 0x03, 0xFE, 0x3F, 0xC0,
  0x07, 0xF8, 0x7F, 0x80, 0x1F, 0xF0, 0xFF, 0x00, 0x3F, 0xC1, 0xFE, 0x00,
  0xFF, 0x81, 0xFC, 0x01, 0xFE, 0x03, 0xF8, 0x03, 0xFC, 0x07, 0xF0, 0x0F,
  0xF0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x7F, 0x80, 0x3F, 0xC0, 0xFF,
  0x00, 0x7F, 0x83, 0xFC, 0x00, 0xFF, 0x07, 0xF8, 0x01, 0xFE, 0x1F, 0xE0,
  0x03, 0xFC, 0x3F, 0xC0, 0x07, 0xF8, 0xFF, 0x00, 0x07, 0xF1, 0xFE, 0x00,
  0x0F, 0xE7, 0xF8, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x3F, 0xBF, 0xC0, 0x00,
  0x7F, 0x7F, 0x80, 0x00, 0xFE, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0xFC,
  0x00, 0xFF, 0xC0, 0x0F, 0xF7, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xEF, 0xF0,
  0x07, 0xFF, 0x00, 0x7F, 0x9F, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0x3F, 0xC0,
  0x3F, 0xFC, 0x03, 0xFC, 0x7F, 0x80, 0x7F, 0xF8, 0x07, 0xF8, 0xFF, 0x01,
  0xFF, 0xF0, 0x1F, 0xF1, 0xFE, 0x03, 0xF7, 0xE0, 0x3F, 0xC3, 0xFC, 0x0F,
  0xEF, 0xC0, 0x7F, 0x87, 0xF8, 0x1F, 0x9F, 0x81, 0xFE, 0x0F, 0xF0, 0x3F,
  0x3F, 0x03, 0xFC, 0x1F, 0xE0, 0xFE, 0x7E, 0x0F, 0xF0, 0x1F, 0xC1, 0xF8,
  0xFC, 0x1F, 0xE0, 0x3F, 0x87, 0xF1, 0xF8, 0x3F, 0x80, 0x7F, 0x0F, 0xE3,
  0xF0, 0xFF, 0x00, 0xFE, 0x1F, 0x87, 0xE1, 0xFE, 0x01, 0xFC, 0x7F, 0x0F,
  0xC7, 0xF8, 0x03, 0xF8, 0xFC, 0x1F, 0x8F, 0xF0, 0x07, 0xF3, 0xF8, 0x3F,
  0x1F, 0xC0, 0x0F, 0xE7, 0xE0, 0x7E, 0x7F, 0x80, 0x1F, 0xCF, 0xC0, 0xFC,
  0xFE, 0x00, 0x3F, 0xBF, 0x81, 0xFB, 0xFC, 0x00, 0x7F, 0x7E, 0x03, 0xF7,
  0xF0, 0x00, 0xFF, 0xFC, 0x07, 0xEF, 0xE0, 0x01, 0xFF, 0xF0, 0x0F, 0xFF,
  0xC0, 0x03, 0xF7, 0xE0, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x3F, 0xFE,
  0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0xE0, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x7F,
  0xC0, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x07,
  0xF8, 0x7F, 0xC0, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x00, 0x3F, 0xCF, 0xF0,
  0x00, 0x00, 0xFF, 0x7F, 0xC0, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x01, 0xFE, 0xFF, 0x80, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x00, 0x7F, 0xC7,
  0xF8, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x00,
  0x7F, 0xC0, 0xFF, 0x00, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x07,
  0xF8, 0x00, 0xFF, 0xC0, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x1F,
  0xF0, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x7F,
  0xC0, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x01,
  0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0x80,
  0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x07, 0xF8,
  0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x81,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0xFF, 0x00,
  0x00, 0x07, 0xF0, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x7F, 0x80, 0x00, 0x01,
  0xFC, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x00, 0x1F, 0xCF, 0xF0, 0x00,
  0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x00, 0x03, 0xF7, 0xF8, 0x00, 0x00, 0x01,
  0xFB, 0xF8, 0x00, 0x00, 0x00, 0xFD, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x01, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xE0,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x02, 0x3F, 0xF0, 0x00, 0x0D, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0xC0, 0x07, 0xFF, 0xF9, 0x00,
  0x01, 0xFF, 0xE2, 0x00, 0x00, 0x7E, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_SemiBoldItalic69pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 19, 50, 18, 1, -49 },
  { 120, 23, 18, 28, 7, -49 },
  { 172, 40, 49, 40, 1, -49 },
  { 417, 34, 56, 35, 1, -52 },
  { 655, 47, 51, 53, 4, -50 },
  { 955, 41, 51, 43, 1, -50 },
  { 1217, 11, 18, 16, 7, -49 },
  { 1242, 24, 60, 21, 2, -49 },
  { 1422, 24, 61, 21, -5, -50 },
  { 1605, 29, 31, 34, 6, -53 },
  { 1718, 31, 33, 36, 4, -41 },
  { 1846, 15, 17, 18, -3, -8 },
  { 1878, 18, 7, 21, 1, -22 },
  { 1894, 10, 11, 18, 1, -10 },
  { 1908, 35, 50, 26, -3, -50 },
  { 2127, 32, 51, 35, 2, -50 },
  { 2331, 24, 49, 35, 7, -49 },
  { 2478, 36, 50, 35, -2, -50 },
  { 2703, 34, 51, 35, 0, -50 },
  { 2920, 35, 49, 35, -1, -49 },
  { 3135, 34, 50, 35, 1, -49 },
  { 3348, 33, 51, 35, 3, -50 },
  { 3559, 34, 49, 35, 3, -49 },
  { 3768, 34, 51, 35, 1, -50 },
  { 3985, 32, 51, 35, 2, -50 },
  { 4189, 16, 39, 18, 1, -38 },
  { 4267, 21, 47, 18, -4, -38 },
  { 4391, 31, 34, 36, 4, -42 },
  { 4523, 30, 20, 36, 4, -34 },
  { 4598, 31, 34, 36, 4, -42 },
  { 4730, 26, 51, 28, 4, -50 },
  { 4896, 49, 55, 53, 3, -49 },
  { 5233, 38, 49, 38, -4, -49 },
  { 5466, 37, 49, 38, 1, -49 },
  { 5693, 37, 51, 37, 4, -50 },
  { 5929, 39, 49, 42, 1, -49 },
  { 6168, 35, 49, 33, 1, -49 },
  { 6383, 35, 49, 32, 1, -49 },
  { 6598, 39, 51, 43, 4, -50 },
  { 6847, 43, 49, 43, 1, -49 },
  { 7111, 30, 49, 23, -2, -49 },
  { 7295, 32, 63, 19, -11, -49 },
  { 7547, 42, 49, 37, 1, -49 },
  { 7805, 26, 49, 31, 1, -49 },
  { 7965, 55, 49, 55, 1, -49 },
  { 8302, 46, 49, 46, 1, -49 },
  { 8584, 39, 51, 45, 4, -50 },
  { 8833, 37, 49, 37, 1, -49 },
  { 9060, 39, 62, 45, 4, -50 },
  { 9363, 36, 49, 38, 1, -49 },
  { 9584, 35, 51, 33, 0, -50 },
  { 9808, 32, 49, 32, 6, -49 },
  { 10004, 40, 50, 43, 4, -49 },
  { 10254, 36, 49, 36, 6, -49 },
  { 10475, 56, 49, 56, 6, -49 },
  { 10818, 45, 49, 36, -4, -49 },
  { 11094, 34, 49, 34, 6, -49 },
  { 11303, 38, 49, 33, -2, -49 },
  { 11536, 28, 60, 21, -2, -49 },
  { 11746, 15, 50, 27, 7, -50 },
  { 11840, 28, 60, 21, -5, -49 },
  { 12050, 33, 30, 35, 1, -49 },
  { 12174, 26, 5, 25, -6, 6 },
  { 12191, 13, 11, 21, 10, -53 },
  { 12209, 34, 39, 37, 2, -38 },
  { 12375, 34, 53, 37, 1, -52 },
  { 12601, 28, 39, 29, 3, -38 },
  { 12738, 37, 53, 37, 2, -52 },
  { 12984, 29, 39, 34, 3, -38 },
  { 13126, 38, 70, 22, -8, -53 },
  { 13459, 36, 55, 37, 0, -38 },
  { 13707, 33, 52, 37, 1, -52 },
  { 13922, 19, 52, 18, 1, -52 },
  { 14046, 29, 69, 18, -9, -52 },
  { 14297, 36, 52, 34, 1, -52 },
  { 14531, 19, 52, 18, 1, -52 },
  { 14655, 52, 38, 55, 1, -38 },
  { 14902, 33, 38, 37, 1, -38 },
  { 15059, 31, 39, 36, 3, -38 },
  { 15211, 38, 54, 37, -3, -38 },
  { 15468, 34, 55, 37, 2, -38 },
  { 15702, 28, 38, 26, 1, -38 },
  { 15835, 28, 39, 29, 0, -38 },
  { 15972, 22, 47, 24, 3, -46 },
  { 16102, 33, 38, 37, 3, -37 },
  { 16259, 31, 37, 31, 4, -37 },
  { 16403, 47, 37, 48, 4, -37 },
  { 16621, 38, 37, 32, -3, -37 },
  { 16797, 41, 54, 31, -6, -37 },
  { 17074, 31, 37, 28, -2, -37 },
  { 17218, 27, 60, 24, 1, -49 },
  { 17421, 6, 69, 33, 14, -53 },
  { 17473, 27, 60, 24, -4, -49 },
  { 17676, 31, 11, 36, 4, -30 },
};

const GFXfont NotoSans_SemiCondensed_SemiBoldItalic69pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_SemiBoldItalic69pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_SemiBoldItalic69pt7bGlyphs,
  0x20, 0x7E, 94
};

#endif // _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC69PT7B_H_
