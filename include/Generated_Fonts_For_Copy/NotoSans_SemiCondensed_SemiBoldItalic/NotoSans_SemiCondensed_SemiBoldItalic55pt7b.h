#ifndef _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC55PT7B_H_
#define _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC55PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-SemiBoldItalic.ttf
// Size: 55pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_SemiBoldItalic55pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F,
  0x80, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x7E, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x00, 0x18, 0x00, 0x3F, 0x8F, 0xE7, 0xE1, 0xF8, 0xFC, 0x3F, 0x1F,
  0x87, 0xE3, 0xF0, 0xFC, 0x7C, 0x1F, 0x0F, 0x83, 0xE3, 0xF0, 0xFC, 0x7E,
  0x1F, 0x8F, 0x83, 0xE1, 0xF0, 0x7C, 0x3E, 0x0F, 0x87, 0x81, 0xE1, 0xF0,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x07,
  0xC1, 0xF0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x0F,
  0x83, 0xE0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x1F,
  0x03, 0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1E, 0x07, 0xC1, 0x0F, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0xFE, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x78,
  0x1F, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0xF0,
  0x3E, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xC0, 0xF0, 0x00, 0x07, 0xC1,
  0xF0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x0F, 0x83,
  0xE0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x1F, 0x03,
  0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x3E, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x1F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0,
  0x1F, 0xE7, 0x3E, 0x03, 0xF9, 0xE0, 0x80, 0x7E, 0x38, 0x00, 0x0F, 0xC7,
  0x00, 0x03, 0xF8, 0xE0, 0x00, 0x3F, 0x1C, 0x00, 0x07, 0xE7, 0x80, 0x00,
  0xFE, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x73, 0xF8, 0x00, 0x0E, 0x3F,
  0x00, 0x01, 0xC7, 0xE0, 0x00, 0x38, 0xFC, 0x00, 0x0F, 0x1F, 0x84, 0x01,
  0xC3, 0xF0, 0xE0, 0x38, 0xFE, 0x1F, 0x07, 0x3F, 0x83, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x20, 0x0F, 0xF8, 0x00, 0x1F, 0x00, 0x7F, 0xF0, 0x00, 0xF8,
  0x03, 0xFF, 0xC0, 0x07, 0xE0, 0x0F, 0xFF, 0x80, 0x1F, 0x00, 0x7E, 0x3E,
  0x00, 0xF8, 0x03, 0xF0, 0xF8, 0x07, 0xE0, 0x0F, 0x83, 0xE0, 0x1F, 0x00,
  0x3E, 0x0F, 0x80, 0xF8, 0x01, 0xF8, 0x3E, 0x07, 0xE0, 0x07, 0xC0, 0xF8,
  0x1F, 0x00, 0x1F, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x0F, 0x87, 0xE0, 0x01,
  0xF0, 0x7E, 0x1F, 0x00, 0x0F, 0xC1, 0xF0, 0xF8, 0x00, 0x3F, 0x07, 0xC7,
  0xE0, 0x00, 0xF8, 0x3F, 0x1F, 0x0F, 0xC3, 0xE0, 0xF8, 0xF8, 0xFF, 0xCF,
  0xC7, 0xE7, 0xE7, 0xFF, 0x3F, 0x1F, 0x1F, 0x3F, 0xFE, 0x7F, 0xFC, 0xF8,
  0xFD, 0xF9, 0xFF, 0xE7, 0xE7, 0xE3, 0xE3, 0xFF, 0x1F, 0x1F, 0x0F, 0xC7,
  0xF8, 0xF8, 0xFC, 0x3F, 0x07, 0x87, 0xE3, 0xE0, 0xFC, 0x00, 0x1F, 0x0F,
  0x83, 0xE0, 0x00, 0xF8, 0x7E, 0x0F, 0x80, 0x07, 0xE1, 0xF0, 0x3E, 0x00,
  0x1F, 0x07, 0xC0, 0xF8, 0x00, 0xF8, 0x1F, 0x03, 0xE0, 0x07, 0xE0, 0x7C,
  0x1F, 0x80, 0x1F, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x07, 0xC1, 0xF0, 0x07,
  0xE0, 0x1F, 0x0F, 0xC0, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x01, 0xF1,
  0xF8, 0x07, 0xE0, 0x07, 0xFF, 0xC0, 0x1F, 0x00, 0x0F, 0xFE, 0x00, 0xF8,
  0x00, 0x3F, 0xF0, 0x07, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0x1F,
  0xC0, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0xFC, 0x0F,
  0xC0, 0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xFC, 0x0F, 0xC0, 0x01, 0xFC, 0x1F,
  0x80, 0x00, 0xFC, 0x3F, 0x80, 0x00, 0xFC, 0x7F, 0x00, 0x00, 0xFC, 0xFF,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0,
  0x3F, 0x07, 0xFF, 0xC0, 0x7F, 0x0F, 0xFF, 0xE0, 0x7E, 0x1F, 0xCF, 0xE0,
  0xFE, 0x3F, 0x87, 0xF0, 0xFC, 0x7F, 0x03, 0xF9, 0xFC, 0x7F, 0x03, 0xF9,
  0xF8, 0x7E, 0x01, 0xFF, 0xF8, 0xFE, 0x01, 0xFF, 0xF0, 0xFE, 0x00, 0xFF,
  0xE0, 0xFE, 0x00, 0xFF, 0xE0, 0xFE, 0x00, 0x7F, 0xC0, 0xFE, 0x00, 0x7F,
  0x80, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0x83, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xEF, 0xF0, 0x1F, 0xFF, 0x87,
  0xF8, 0x07, 0xFF, 0x03, 0xFC, 0x00, 0x40, 0x00, 0x00, 0x7F, 0x7F, 0x7E,
  0x7E, 0x7E, 0x7C, 0x7C, 0xFC, 0xFC, 0xF8, 0xF8, 0xF8, 0xF8, 0xF0, 0x00,
  0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x0F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x04, 0x07, 0xC0, 0x1E, 0x0F, 0x80, 0x3F, 0x1F,
  0x00, 0x7F, 0xBC, 0x01, 0xFF, 0xF9, 0xFD, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0x80, 0x83, 0xFF, 0x00,
  0x0F, 0xDF, 0x00, 0x3F, 0xBF, 0x00, 0xFE, 0x3E, 0x03, 0xF8, 0x7E, 0x01,
  0xE0, 0xFC, 0x01, 0xC0, 0xFC, 0x01, 0x01, 0xF0, 0x00, 0x03, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xF0, 0x7F, 0x07, 0xF0, 0x7E, 0x0F, 0xE0, 0xFC, 0x1F, 0xC1, 0xF8,
  0x1F, 0x83, 0xF0, 0x3F, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0x7F, 0xFD, 0xFF,
  0xF7, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1C, 0x7E, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFE, 0xFC, 0x30, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xE1, 0xFE, 0x0F, 0xE0, 0x7F, 0x0F,
  0xF0, 0x3F, 0x87, 0xF0, 0x0F, 0xC7, 0xF0, 0x07, 0xE3, 0xF8, 0x03, 0xF1,
  0xFC, 0x01, 0xF9, 0xFC, 0x00, 0xFC, 0xFE, 0x00, 0x7E, 0x7F, 0x00, 0x7F,
  0x7F, 0x00, 0x3F, 0xBF, 0x80, 0x1F, 0xDF, 0xC0, 0x0F, 0xEF, 0xC0, 0x07,
  0xF7, 0xE0, 0x03, 0xF7, 0xF0, 0x03, 0xFB, 0xF8, 0x01, 0xFD, 0xFC, 0x00,
  0xFE, 0xFE, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x3F, 0x00, 0x3F, 0x9F, 0x80,
  0x1F, 0xCF, 0xC0, 0x1F, 0xC7, 0xE0, 0x0F, 0xE3, 0xF0, 0x07, 0xF1, 0xFC,
  0x07, 0xF0, 0xFE, 0x07, 0xF8, 0x7F, 0x03, 0xF8, 0x1F, 0xC7, 0xF8, 0x0F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x0F, 0xF0,
  0x07, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xE1, 0xFF, 0xF8, 0xFF,
  0xFE, 0xFF, 0xBF, 0x3F, 0xCF, 0xC7, 0xE3, 0xF1, 0xE1, 0xFC, 0x30, 0x7F,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFC, 0x1F, 0xF0,
  0x0F, 0x00, 0x7F, 0x00, 0x60, 0x07, 0xF0, 0x04, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xC0, 0x3C, 0x07, 0xF8, 0x06, 0x00, 0x7F, 0x00, 0x80,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00,
  0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x80, 0x00, 0xFE, 0x18, 0x00,
  0x3F, 0xC3, 0xE0, 0x1F, 0xF0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3E,
  0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0x9F, 0x80,
  0x01, 0xF1, 0xF8, 0x00, 0x3F, 0x1F, 0x80, 0x07, 0xE1, 0xF8, 0x00, 0xFC,
  0x3F, 0x80, 0x0F, 0x83, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x03, 0xF0,
  0x07, 0xE0, 0x7F, 0x00, 0x7C, 0x07, 0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x3F, 0x00, 0x7E, 0x03, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF9, 0x80, 0x00, 0x7F, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0x00, 0x60, 0x3F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x84, 0x00, 0x0F, 0xE0, 0xC0, 0x07, 0xFC, 0x1F, 0x03,
  0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x14, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00,
  0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x3F, 0x80, 0x3F, 0xBF, 0xF8, 0x0F, 0xDF, 0xFF, 0x03, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xF8, 0x7F, 0xE1, 0xFE, 0x1F, 0xF0, 0x3F, 0x87, 0xF8, 0x07,
  0xE1, 0xFC, 0x01, 0xF8, 0xFF, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0x8F, 0xE0,
  0x07, 0xE3, 0xF8, 0x01, 0xF8, 0xFE, 0x00, 0xFE, 0x3F, 0x80, 0x3F, 0x8F,
  0xE0, 0x0F, 0xE3, 0xF8, 0x07, 0xF0, 0x7E, 0x01, 0xFC, 0x1F, 0xC0, 0xFE,
  0x07, 0xF8, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x07, 0xFF,
  0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x03, 0xFC,
  0x7F, 0x80, 0xFE, 0x07, 0xF8, 0x1F, 0x80, 0x7F, 0x07, 0xF0, 0x0F, 0xE0,
  0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x07, 0xE0, 0x7F, 0x00,
  0xFC, 0x07, 0xE0, 0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0x1F, 0xE3, 0xF8, 0x01,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0xFF,
  0x0F, 0xE0, 0x3F, 0xC0, 0xFE, 0x0F, 0xE0, 0x1F, 0xC1, 0xFC, 0x01, 0xFC,
  0x3F, 0x00, 0x3F, 0x8F, 0xE0, 0x07, 0xF1, 0xFC, 0x00, 0xFE, 0x3F, 0x80,
  0x1F, 0xC7, 0xF0, 0x03, 0xF8, 0xFE, 0x00, 0x7E, 0x1F, 0xE0, 0x1F, 0xC1,
  0xFE, 0x07, 0xF0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x58, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x07, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x7F, 0x83, 0xF8, 0x1F,
  0xC0, 0xFE, 0x0F, 0xE0, 0x1F, 0xC3, 0xF0, 0x07, 0xF1, 0xFC, 0x01, 0xFC,
  0x7F, 0x00, 0x7F, 0x1F, 0x80, 0x1F, 0xC7, 0xE0, 0x07, 0xF1, 0xF8, 0x01,
  0xFC, 0x7E, 0x00, 0x7F, 0x1F, 0x80, 0x3F, 0xC7, 0xE0, 0x0F, 0xE1, 0xFC,
  0x07, 0xF8, 0x7F, 0x03, 0xFE, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFE, 0xFC, 0x03, 0xFE, 0x7F, 0x00, 0x3E, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x0C, 0x03, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x1F, 0xC0, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC,
  0x0F, 0xC0, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x07, 0xE0, 0x7F, 0x83, 0xFC, 0x3F, 0xE1, 0xFE, 0x07,
  0xF0, 0x3F, 0x00, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3E,
  0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x1F,
  0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xFF,
  0x80, 0x07, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x3F, 0xFC, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF8, 0x78, 0x1F, 0xE3, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xE0, 0x0F, 0xF0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x00,
  0x7C, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x07,
  0xC0, 0x0F, 0xC0, 0x3E, 0x0F, 0xC0, 0x7F, 0xFC, 0x3E, 0x0F, 0x80, 0xFF,
  0xFC, 0x1E, 0x1F, 0x01, 0xFF, 0xFC, 0x1F, 0x1F, 0x03, 0xF8, 0xF8, 0x1F,
  0x3E, 0x07, 0xE0, 0xF8, 0x1F, 0x3E, 0x0F, 0xC0, 0xF8, 0x1F, 0x3E, 0x0F,
  0x80, 0xF8, 0x1F, 0x7C, 0x1F, 0x81, 0xF0, 0x1E, 0x7C, 0x1F, 0x01, 0xF0,
  0x3E, 0x7C, 0x1F, 0x01, 0xF0, 0x3E, 0x78, 0x3E, 0x01, 0xF0, 0x3E, 0xF8,
  0x3E, 0x03, 0xE0, 0x3C, 0xF8, 0x3E, 0x03, 0xE0, 0x7C, 0xF8, 0x3E, 0x03,
  0xE0, 0x7C, 0xF8, 0x3E, 0x07, 0xE0, 0xF8, 0xF8, 0x3E, 0x07, 0xE0, 0xF8,
  0xF8, 0x3E, 0x0F, 0xE1, 0xF0, 0xF8, 0x3F, 0x1F, 0xE3, 0xF0, 0xF8, 0x3F,
  0xFD, 0xFF, 0xE0, 0xF8, 0x1F, 0xF9, 0xFF, 0xC0, 0x7C, 0x0F, 0xF0, 0xFF,
  0x80, 0x7C, 0x07, 0xE0, 0x7E, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x10, 0x00, 0x0F, 0xE0, 0x00, 0xE0, 0x00,
  0x07, 0xFF, 0xBF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x0F, 0xBE, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x01, 0xFB, 0xF0, 0x00,
  0x0F, 0xCF, 0xC0, 0x00, 0x3F, 0x3F, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x07,
  0xE3, 0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFE, 0x0F, 0xC0, 0x03, 0xF0, 0x3F,
  0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x7E, 0x03, 0xF0, 0x03, 0xF8, 0x0F, 0xE0,
  0x0F, 0xC0, 0x3F, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x07, 0xF0,
  0x01, 0xF8, 0x3F, 0x80, 0x07, 0xE0, 0xFE, 0x00, 0x1F, 0x87, 0xF0, 0x00,
  0x7E, 0x1F, 0xC0, 0x01, 0xF8, 0xFE, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x1F,
  0x9F, 0xC0, 0x00, 0x7F, 0x7F, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0xFE,
  0x0F, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x00, 0x7F, 0x03, 0xF8, 0x03,
  0xF8, 0x1F, 0xC0, 0x0F, 0xC0, 0xFE, 0x00, 0xFE, 0x07, 0xE0, 0x07, 0xF0,
  0x3F, 0x00, 0x3F, 0x83, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x3F, 0xC0, 0xFE,
  0x07, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xE0, 0x3F, 0xC0,
  0x3F, 0x00, 0x7F, 0x03, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x0F, 0xC0, 0xFC,
  0x00, 0x7F, 0x07, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xC3, 0xF8, 0x00,
  0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0xFC, 0x00, 0x7F, 0x07, 0xE0, 0x07, 0xF8,
  0x7F, 0x00, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFE, 0x07, 0x80, 0x7F, 0xC0, 0x0C, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x60, 0x0F, 0xFC, 0x7F, 0x00, 0x7F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0x01, 0xFF, 0x00, 0xFC,
  0x01, 0xFE, 0x03, 0xF8, 0x01, 0xFE, 0x07, 0xF0, 0x03, 0xFC, 0x0F, 0xE0,
  0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xF0, 0x3F, 0x00, 0x0F, 0xE0, 0xFE, 0x00,
  0x1F, 0xC1, 0xFC, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x00,
  0xFE, 0x0F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xF8, 0x7F, 0x00, 0x07,
  0xF0, 0xFE, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x7F,
  0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xFC, 0x3F, 0x80, 0x07, 0xF0,
  0x7E, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFF, 0x07,
  0xF0, 0x03, 0xFC, 0x0F, 0xE0, 0x0F, 0xF0, 0x1F, 0x80, 0x3F, 0xE0, 0x7F,
  0x01, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xC0, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80,
  0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0x80, 0x7F, 0xE0, 0x3E, 0x01, 0xFF, 0x00, 0x0C, 0x07, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x03, 0xFF, 0xE3, 0xF8, 0x07, 0xFF, 0xCF, 0xE0, 0x0F, 0xFF,
  0x9F, 0xC0, 0x1F, 0xFE, 0x3F, 0x80, 0x7F, 0xFC, 0x7F, 0x00, 0xFF, 0xF8,
  0xFE, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x1F, 0x87,
  0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x3F,
  0xC0, 0x03, 0xF0, 0x3F, 0x80, 0x07, 0xE0, 0x7F, 0x80, 0x1F, 0xC0, 0xFF,
  0x80, 0x3F, 0x80, 0xFF, 0xC1, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x3F,
  0x80, 0x07, 0xF0, 0x0F, 0xE0, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x7E, 0x01,
  0xFC, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x03, 0xF8,
  0x07, 0xE0, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x3F, 0x80, 0x07, 0xF0, 0x0F, 0xE0, 0x01, 0xFC, 0x03, 0xF0, 0x00,
  0x7F, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x0F, 0xE0, 0x1F, 0xC0,
  0x03, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03,
  0xF0, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x0F, 0xE0,
  0x1F, 0xC0, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x3F,
  0x80, 0x7E, 0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x07, 0xF0, 0x0F, 0xE0, 0x01,
  0xFC, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0x00,
  0x07, 0xE0, 0x1F, 0xC0, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0xFE, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x7E, 0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x07, 0xF0, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xFC,
  0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0,
  0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x7F, 0x80, 0x3F,
  0x00, 0x3F, 0x80, 0x1F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x3F, 0xC0, 0x0F,
  0xE0, 0x3F, 0xC0, 0x07, 0xF0, 0x3F, 0xC0, 0x03, 0xF0, 0x1F, 0xC0, 0x01,
  0xF8, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0xE0, 0x00, 0xFE, 0x1F, 0xE0, 0x00,
  0x7E, 0x1F, 0xE0, 0x00, 0x3F, 0x1F, 0xE0, 0x00, 0x3F, 0x8F, 0xE0, 0x00,
  0x1F, 0xCF, 0xE0, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x07, 0xEF, 0xF0, 0x00,
  0x03, 0xF7, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xDF, 0xC0,
  0x00, 0x3F, 0xC7, 0xE0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x0F, 0xE1, 0xFC,
  0x00, 0x07, 0xE0, 0xFE, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x03, 0xF8, 0x1F,
  0xC0, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0x7E, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0xC0,
  0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xF8, 0x07, 0xF0,
  0x01, 0xFC, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x00, 0xFF,
  0xE0, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0,
  0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x03, 0xEF, 0xC0, 0x3F,
  0xFC, 0x00, 0x7F, 0xF8, 0x03, 0xF7, 0xC0, 0x07, 0xFF, 0x80, 0x3F, 0x7C,
  0x00, 0xFD, 0xF8, 0x03, 0xF7, 0xC0, 0x0F, 0xDF, 0x80, 0x7E, 0x7C, 0x01,
  0xFB, 0xF8, 0x07, 0xE7, 0xC0, 0x1F, 0xBF, 0x00, 0x7E, 0x7C, 0x03, 0xF3,
  0xF0, 0x07, 0xE7, 0xC0, 0x3F, 0x3F, 0x00, 0x7E, 0x7C, 0x07, 0xE3, 0xF0,
  0x0F, 0xC7, 0xC0, 0x7E, 0x7F, 0x00, 0xFC, 0x7E, 0x0F, 0xC7, 0xE0, 0x0F,
  0xC7, 0xE0, 0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x1F, 0x87, 0xE0, 0x0F, 0xC7,
  0xE1, 0xF8, 0xFE, 0x01, 0xF8, 0x7E, 0x3F, 0x0F, 0xE0, 0x1F, 0x87, 0xE3,
  0xF0, 0xFC, 0x01, 0xF8, 0x3E, 0x7E, 0x0F, 0xC0, 0x1F, 0x83, 0xE7, 0xE0,
  0xFC, 0x03, 0xF8, 0x3E, 0xFC, 0x1F, 0xC0, 0x3F, 0x03, 0xEF, 0xC1, 0xF8,
  0x03, 0xF0, 0x3F, 0xF8, 0x1F, 0x80, 0x3F, 0x03, 0xFF, 0x81, 0xF8, 0x03,
  0xF0, 0x3F, 0xF0, 0x1F, 0x80, 0x7F, 0x03, 0xFF, 0x03, 0xF8, 0x07, 0xE0,
  0x3F, 0xE0, 0x3F, 0x00, 0x7E, 0x03, 0xFE, 0x03, 0xF0, 0x07, 0xE0, 0x3F,
  0xC0, 0x3F, 0x00, 0x7E, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x03,
  0xF0, 0x0F, 0xF0, 0x00, 0x3F, 0x00, 0xFF, 0x80, 0x03, 0xF0, 0x0F, 0xF8,
  0x00, 0x7F, 0x01, 0xFF, 0x80, 0x07, 0xE0, 0x1F, 0xF8, 0x00, 0x7E, 0x01,
  0xFF, 0xC0, 0x07, 0xE0, 0x1F, 0xFC, 0x00, 0x7E, 0x03, 0xFF, 0xC0, 0x0F,
  0xE0, 0x3F, 0xFE, 0x00, 0xFC, 0x03, 0xF7, 0xE0, 0x0F, 0xC0, 0x3F, 0x7E,
  0x00, 0xFC, 0x03, 0xF7, 0xE0, 0x0F, 0xC0, 0x7E, 0x3F, 0x01, 0xFC, 0x07,
  0xE3, 0xF0, 0x1F, 0x80, 0x7E, 0x3F, 0x01, 0xF8, 0x07, 0xE3, 0xF8, 0x1F,
  0x80, 0x7E, 0x1F, 0x83, 0xF8, 0x0F, 0xE1, 0xF8, 0x3F, 0x00, 0xFC, 0x1F,
  0x83, 0xF0, 0x0F, 0xC1, 0xFC, 0x3F, 0x00, 0xFC, 0x0F, 0xC3, 0xF0, 0x0F,
  0xC0, 0xFC, 0x7F, 0x01, 0xF8, 0x0F, 0xE7, 0xE0, 0x1F, 0x80, 0x7E, 0x7E,
  0x01, 0xF8, 0x07, 0xE7, 0xE0, 0x1F, 0x80, 0x7E, 0x7E, 0x03, 0xF8, 0x07,
  0xF7, 0xE0, 0x3F, 0x00, 0x3F, 0xFC, 0x03, 0xF0, 0x03, 0xFF, 0xC0, 0x3F,
  0x00, 0x3F, 0xFC, 0x03, 0xF0, 0x01, 0xFF, 0xC0, 0x7F, 0x00, 0x1F, 0xF8,
  0x07, 0xE0, 0x01, 0xFF, 0x80, 0x7E, 0x00, 0x1F, 0xF8, 0x07, 0xE0, 0x00,
  0xFF, 0x80, 0x7E, 0x00, 0x0F, 0xF8, 0x0F, 0xC0, 0x00, 0xFF, 0x00, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0x07, 0xFC, 0x03, 0xFC, 0x01, 0xFE,
  0x07, 0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFE,
  0x1F, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x7F,
  0x3F, 0x80, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F,
  0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE,
  0xFF, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFE,
  0xFE, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x01, 0xFC,
  0xFE, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x07, 0xF8,
  0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x1F, 0xE0,
  0x7F, 0x80, 0x3F, 0xE0, 0x7F, 0x80, 0x7F, 0xC0, 0x3F, 0xF1, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0xFE, 0x1F, 0xF8, 0x07, 0xF0,
  0x1F, 0xE0, 0x3F, 0x00, 0x7F, 0x03, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x1F,
  0xC0, 0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x07, 0xF0, 0x3F, 0x00, 0x3F, 0x83,
  0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x07, 0xF0,
  0x0F, 0xF0, 0x3F, 0x00, 0xFF, 0x03, 0xF8, 0x1F, 0xF8, 0x1F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0x07, 0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x07, 0xF8, 0x01, 0xFE, 0x0F, 0xF0,
  0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0xFE, 0x1F, 0xC0,
  0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x7F, 0x3F, 0x80,
  0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x00,
  0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00,
  0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x01, 0xFC, 0xFE, 0x00,
  0x01, 0xFC, 0xFE, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x03, 0xFC, 0xFE, 0x00,
  0x03, 0xF8, 0xFE, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00,
  0x0F, 0xF0, 0xFF, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x3F, 0xE0, 0x7F, 0x80,
  0x7F, 0xC0, 0x3F, 0xF1, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFE, 0x1F, 0xF8,
  0x07, 0xF0, 0x3F, 0xC0, 0x3F, 0x00, 0xFE, 0x03, 0xF8, 0x03, 0xF0, 0x1F,
  0xC0, 0x1F, 0xC0, 0xFE, 0x00, 0xFC, 0x07, 0xF0, 0x07, 0xE0, 0x3F, 0x00,
  0x7F, 0x03, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0xC0, 0xFE, 0x01, 0xFC,
  0x07, 0xE0, 0x1F, 0xE0, 0x3F, 0x03, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xC0, 0x03, 0xF8, 0x7E, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0xFE, 0x1F, 0xC0,
  0x07, 0xE0, 0x7E, 0x00, 0x7F, 0x03, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x1F,
  0xC0, 0x7E, 0x00, 0xFE, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x7F, 0x00,
  0xFE, 0x03, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0xC0, 0xFC, 0x00, 0xFE,
  0x07, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0x07,
  0xC0, 0x3F, 0xC0, 0x18, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x40, 0x01, 0xFC, 0x07, 0x00, 0x3F, 0xC0, 0xFE,
  0x1F, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF8, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x7F, 0x07, 0xF0,
  0x00, 0x7E, 0x07, 0xF0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x07, 0xF0,
  0x00, 0xFE, 0x07, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFC, 0x0F, 0xE0,
  0x01, 0xFC, 0x0F, 0xE0, 0x01, 0xFC, 0x0F, 0xE0, 0x01, 0xFC, 0x0F, 0xC0,
  0x01, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0,
  0x03, 0xF8, 0x1F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF0, 0x3F, 0x80,
  0x07, 0xF0, 0x3F, 0x80, 0x07, 0xF0, 0x3F, 0x80, 0x07, 0xF0, 0x3F, 0x00,
  0x07, 0xF0, 0x7F, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x0F, 0xE0, 0x7F, 0x00,
  0x0F, 0xE0, 0x7F, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x0F, 0xC0, 0xFE, 0x00,
  0x1F, 0xC0, 0xFE, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x1F, 0xC0, 0xFE, 0x00,
  0x3F, 0x80, 0xFE, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0x00,
  0xFF, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x3F, 0xBF, 0x80, 0x01, 0xF9, 0xFC, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0xFE,
  0x7F, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xF0, 0x7E,
  0x00, 0x3F, 0x83, 0xF0, 0x03, 0xF8, 0x1F, 0x80, 0x1F, 0xC0, 0xFC, 0x01,
  0xFC, 0x07, 0xE0, 0x0F, 0xE0, 0x3F, 0x00, 0xFE, 0x01, 0xF8, 0x07, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x03, 0xF8, 0x03, 0xF0, 0x1F, 0x80, 0x1F,
  0x81, 0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0xFE, 0x00, 0x3F, 0x07,
  0xE0, 0x01, 0xF8, 0x7F, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x3F, 0x3F, 0x80,
  0x01, 0xF9, 0xF8, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x03,
  0xF7, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xDF,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xEF, 0xC0, 0x03, 0xF8,
  0x00, 0xFE, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xCF, 0xC0, 0x07, 0xF8, 0x01,
  0xFC, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0x8F, 0xC0, 0x0F, 0xF8, 0x03, 0xF8,
  0xFC, 0x01, 0xFF, 0x80, 0x3F, 0x8F, 0xC0, 0x1F, 0xF8, 0x03, 0xF0, 0xFC,
  0x01, 0xFF, 0x80, 0x7F, 0x0F, 0xC0, 0x3E, 0xF8, 0x07, 0xE0, 0xFC, 0x03,
  0xEF, 0x80, 0xFE, 0x0F, 0xC0, 0x7E, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xCF,
  0x81, 0xFC, 0x0F, 0xC0, 0xFC, 0xF8, 0x1F, 0xC0, 0xFC, 0x0F, 0xCF, 0x81,
  0xF8, 0x0F, 0xC1, 0xF8, 0xF8, 0x3F, 0x80, 0xFC, 0x1F, 0x8F, 0x83, 0xF0,
  0x0F, 0xC1, 0xF0, 0xF8, 0x7F, 0x00, 0xFC, 0x3F, 0x0F, 0x87, 0xE0, 0x0F,
  0xC3, 0xE0, 0xF8, 0x7E, 0x00, 0xFC, 0x7E, 0x0F, 0x8F, 0xE0, 0x0F, 0xC7,
  0xE0, 0xF8, 0xFC, 0x00, 0xFC, 0xFC, 0x0F, 0x9F, 0xC0, 0x0F, 0xCF, 0xC0,
  0xF9, 0xF8, 0x00, 0xFC, 0xF8, 0x0F, 0x9F, 0x80, 0x0F, 0xDF, 0x80, 0xFB,
  0xF0, 0x00, 0xFD, 0xF0, 0x0F, 0xBF, 0x00, 0x07, 0xDF, 0x00, 0xFB, 0xF0,
  0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xC0, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80,
  0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x7F, 0x00, 0x01, 0xF8, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x01,
  0xFC, 0x1F, 0xC0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x00, 0xFC, 0x3F, 0x80,
  0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0x07, 0xEF,
  0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xF3, 0xF0, 0x00,
  0x00, 0x7F, 0x3F, 0x80, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x01, 0xFC, 0x3F,
  0x80, 0x00, 0x3F, 0xC1, 0xF8, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x7F,
  0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xF9, 0xF8, 0x00, 0xFE, 0x3F, 0x00, 0x3F,
  0xC7, 0xE0, 0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x81, 0xF8,
  0x0F, 0xE0, 0x3F, 0x03, 0xF8, 0x07, 0xE0, 0x7F, 0x00, 0xFE, 0x1F, 0xC0,
  0x1F, 0xC3, 0xF8, 0x01, 0xF8, 0xFE, 0x00, 0x3F, 0x1F, 0x80, 0x07, 0xE7,
  0xF0, 0x00, 0xFD, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC0, 0xF8, 0x1F, 0x03, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x03,
  0xE0, 0x7C, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x0F, 0x81, 0xF0,
  0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x3E, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC0, 0xF8, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFE,
  0x00, 0x7F, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x1F,
  0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x7C, 0xF8, 0x00, 0x3F, 0x3E, 0x00, 0x0F, 0x8F,
  0x80, 0x07, 0xE3, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x1F, 0x00, 0x7E,
  0x07, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x3E, 0x03, 0xE0, 0x0F, 0xC1,
  0xF8, 0x01, 0xF0, 0xFC, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x9F, 0x80, 0x03,
  0xE7, 0xC0, 0x00, 0xFB, 0xF0, 0x00, 0x3F, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFE, 0x1F, 0xC7, 0xF0, 0xFC, 0x3F,
  0x87, 0xE0, 0xF8, 0x1F, 0x03, 0xC0, 0x00, 0x7F, 0x87, 0xE0, 0x1F, 0xF8,
  0xFC, 0x07, 0xFF, 0x9F, 0x01, 0xFF, 0xF7, 0xE0, 0x7F, 0xFF, 0xFC, 0x1F,
  0xF1, 0xFF, 0x83, 0xF8, 0x1F, 0xF0, 0xFF, 0x01, 0xFC, 0x1F, 0xC0, 0x3F,
  0x87, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0x87, 0xF0,
  0x03, 0xF0, 0xFE, 0x00, 0x7E, 0x1F, 0xC0, 0x1F, 0xC7, 0xF0, 0x03, 0xF8,
  0xFE, 0x00, 0x7E, 0x1F, 0xC0, 0x0F, 0xC3, 0xF8, 0x03, 0xF8, 0x7F, 0x00,
  0x7F, 0x0F, 0xE0, 0x1F, 0xE1, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0xFF, 0x07,
  0xF0, 0x3F, 0xE0, 0xFF, 0x0F, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFB,
  0xE0, 0x1F, 0xFE, 0xFC, 0x03, 0xFF, 0x9F, 0x80, 0x1F, 0xC3, 0xF0, 0x00,
  0x40, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x0F, 0xE0, 0x07,
  0xE7, 0xFE, 0x01, 0xFD, 0xFF, 0xE0, 0x3F, 0x7F, 0xFC, 0x07, 0xFF, 0xFF,
  0xC0, 0xFF, 0xC7, 0xF8, 0x1F, 0xE0, 0x7F, 0x07, 0xF8, 0x07, 0xE0, 0xFF,
  0x00, 0xFC, 0x1F, 0xC0, 0x1F, 0xC3, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0x7E,
  0x1F, 0xC0, 0x0F, 0xC3, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x7F, 0x0F, 0xC0,
  0x0F, 0xE1, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x0F, 0xE0, 0x0F, 0xE1,
  0xF8, 0x01, 0xFC, 0x3F, 0x00, 0x7F, 0x0F, 0xF0, 0x0F, 0xE1, 0xFE, 0x03,
  0xFC, 0x3F, 0xC0, 0xFF, 0x07, 0xFC, 0x3F, 0xC0, 0xFF, 0xFF, 0xF8, 0x3F,
  0x7F, 0xFE, 0x07, 0xEF, 0xFF, 0x80, 0xF8, 0xFF, 0xE0, 0x1F, 0x0F, 0xF0,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xF0, 0x1F,
  0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0xE0, 0xE0, 0xFE, 0x00,
  0x87, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x10, 0x7F,
  0x83, 0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xC0, 0x1F, 0xFC, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x07, 0xF8, 0xFE, 0x00, 0x7F, 0xE7, 0xF0, 0x07, 0xFF,
  0xBF, 0x00, 0x7F, 0xFD, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xC7, 0xFE,
  0x03, 0xF8, 0x1F, 0xE0, 0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x03, 0xF8, 0x1F,
  0xC0, 0x1F, 0xC0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xE0, 0x7F, 0x00,
  0x3F, 0x03, 0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x1F, 0xC1, 0xFC, 0x00, 0xFE,
  0x0F, 0xE0, 0x07, 0xE0, 0x7F, 0x00, 0x3F, 0x03, 0xF8, 0x03, 0xF8, 0x1F,
  0xC0, 0x1F, 0xC0, 0xFE, 0x01, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x80,
  0xFF, 0x01, 0xFC, 0x0F, 0xF8, 0x0F, 0xF0, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFB, 0xE0, 0x07, 0xFF, 0x9F, 0x00, 0x3F, 0xF8, 0xF8, 0x00,
  0x7F, 0x8F, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xF0,
  0x7F, 0x0F, 0xE0, 0x7F, 0x1F, 0xC0, 0x3F, 0x3F, 0x80, 0x7F, 0x3F, 0x80,
  0x7E, 0x3F, 0x00, 0xFE, 0x7F, 0x01, 0xFE, 0x7F, 0x0F, 0xFC, 0x7F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFE, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x10, 0x7F, 0x00, 0x60, 0x7F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF,
  0x80, 0x00, 0x20, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x03, 0xFC, 0x40, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x02, 0x3F, 0xC0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE1, 0xF8, 0x01,
  0xFF, 0x8F, 0xC0, 0x1F, 0xFE, 0x7C, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0x01, 0xFF, 0x1F, 0xF8, 0x0F, 0xE0, 0x7F, 0xC0, 0xFE, 0x01, 0xFC,
  0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0x03, 0xF8, 0x03, 0xF8, 0x3F,
  0x80, 0x1F, 0x81, 0xFC, 0x00, 0xFC, 0x0F, 0xE0, 0x07, 0xE0, 0x7E, 0x00,
  0x7F, 0x07, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0x81, 0xFC, 0x00, 0xFC,
  0x0F, 0xE0, 0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0x03, 0xF8, 0x07, 0xF8, 0x1F,
  0xC0, 0x3F, 0x80, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x3F, 0xE0, 0x3F, 0xC3,
  0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xDF, 0x80, 0x1F, 0xFE, 0xFC,
  0x00, 0xFF, 0xEF, 0xE0, 0x03, 0xFC, 0x7F, 0x00, 0x01, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xF0, 0x0C, 0x00, 0x7F, 0x80, 0x7C, 0x0F, 0xF8,
  0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0,
  0xFE, 0x00, 0xFC, 0xFF, 0xC0, 0x7F, 0x7F, 0xF8, 0x1F, 0xBF, 0xFF, 0x07,
  0xFF, 0xFF, 0xC1, 0xFF, 0x8F, 0xF0, 0x7F, 0xC1, 0xFC, 0x3F, 0xE0, 0x3F,
  0x0F, 0xF0, 0x0F, 0xC3, 0xF8, 0x03, 0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x80,
  0x7F, 0x1F, 0xC0, 0x1F, 0xC7, 0xF0, 0x07, 0xE1, 0xFC, 0x01, 0xF8, 0x7E,
  0x00, 0xFE, 0x1F, 0x80, 0x3F, 0x8F, 0xE0, 0x0F, 0xC3, 0xF8, 0x03, 0xF0,
  0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x7F, 0x1F, 0xC0, 0x1F, 0xC7, 0xF0, 0x07,
  0xE1, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0xFE, 0x1F, 0x80, 0x3F, 0x8F, 0xE0,
  0x0F, 0xE3, 0xF8, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x7F, 0x00,
  0x00, 0x7C, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x1F, 0x80,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x3F,
  0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7E, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x8F,
  0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF0, 0x07, 0xF0, 0x3F, 0x00, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x03,
  0xF8, 0x07, 0xF0, 0x7F, 0x00, 0x7E, 0x0F, 0xE0, 0x07, 0xE1, 0xFE, 0x00,
  0xFE, 0x1F, 0xC0, 0x0F, 0xE3, 0xF8, 0x00, 0xFC, 0x7F, 0x00, 0x0F, 0xCF,
  0xE0, 0x00, 0xFD, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF,
  0xFC, 0x00, 0x3F, 0xCF, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x0F, 0xE0,
  0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xE0, 0x7F, 0x00, 0x7E,
  0x03, 0xF8, 0x07, 0xE0, 0x3F, 0x80, 0xFE, 0x01, 0xFC, 0x0F, 0xE0, 0x1F,
  0xC0, 0xFC, 0x01, 0xFC, 0x0F, 0xC0, 0x0F, 0xE0, 0x00, 0xFE, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01,
  0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7E, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0x00, 0xFE, 0x01,
  0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE,
  0x01, 0xF8, 0x00, 0x03, 0xE1, 0xFE, 0x03, 0xFC, 0x01, 0xF1, 0xFF, 0x83,
  0xFF, 0x01, 0xF9, 0xFF, 0xE3, 0xFF, 0xC0, 0xFD, 0xFF, 0xF3, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFB, 0xFF, 0xF8, 0x3F, 0xF1, 0xFF, 0xE3, 0xFC, 0x1F, 0xE0,
  0x7F, 0xC0, 0xFE, 0x1F, 0xE0, 0x3F, 0xE0, 0x7F, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0x87, 0xF0, 0x0F, 0xE0, 0x1F, 0xC3, 0xF8, 0x07, 0xF0, 0x0F, 0xE1,
  0xF8, 0x03, 0xF8, 0x07, 0xE1, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x7E, 0x00, 0xFE, 0x01, 0xFC, 0x3F, 0x00, 0x7E, 0x00,
  0xFE, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x87, 0xE0, 0x0F, 0xE0, 0x1F, 0xC3, 0xF0, 0x07,
  0xE0, 0x0F, 0xC3, 0xF8, 0x03, 0xF0, 0x07, 0xE1, 0xFC, 0x03, 0xF8, 0x03,
  0xF0, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x7E, 0x00, 0xFC, 0x01, 0xFC, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x3F, 0x80, 0x3F, 0x00, 0x7E, 0x1F, 0xC0, 0x3F,
  0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0xC0, 0x3F, 0x87, 0xE0, 0x0F, 0xC0, 0x1F,
  0xC0, 0x03, 0xE0, 0xFE, 0x00, 0xF8, 0xFF, 0xC0, 0x7E, 0x7F, 0xF8, 0x1F,
  0xBF, 0xFF, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0x8F, 0xF0, 0x7F, 0xC1, 0xFC,
  0x3F, 0xE0, 0x3F, 0x0F, 0xF0, 0x0F, 0xC3, 0xF8, 0x03, 0xF0, 0xFE, 0x01,
  0xFC, 0x3F, 0x80, 0x7F, 0x1F, 0xC0, 0x1F, 0xC7, 0xF0, 0x07, 0xE1, 0xFC,
  0x01, 0xF8, 0x7E, 0x00, 0xFE, 0x3F, 0x80, 0x3F, 0x8F, 0xE0, 0x0F, 0xE3,
  0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xFC, 0x3F, 0x00, 0x7F, 0x1F, 0xC0, 0x1F,
  0xC7, 0xF0, 0x07, 0xE1, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0xFE, 0x1F, 0x80,
  0x3F, 0x8F, 0xE0, 0x0F, 0xE3, 0xF8, 0x03, 0xF0, 0xFE, 0x00, 0xFC, 0x3F,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF,
  0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x7F, 0xC7, 0xF8, 0x7F, 0x81,
  0xFC, 0x3F, 0x80, 0x7E, 0x3F, 0x80, 0x3F, 0x9F, 0xC0, 0x1F, 0xCF, 0xC0,
  0x0F, 0xEF, 0xE0, 0x07, 0xF7, 0xF0, 0x03, 0xFB, 0xF0, 0x01, 0xFF, 0xF8,
  0x00, 0xFF, 0xFC, 0x00, 0x7E, 0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x3F, 0xBF,
  0x80, 0x1F, 0xDF, 0xC0, 0x0F, 0xCF, 0xE0, 0x0F, 0xE7, 0xF0, 0x07, 0xF3,
  0xF8, 0x07, 0xF1, 0xFC, 0x07, 0xF8, 0x7F, 0x87, 0xF8, 0x3F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x7C, 0x1F, 0xC0, 0x01, 0xF1, 0xFF, 0x80,
  0x0F, 0xCF, 0xFF, 0x00, 0x3F, 0x7F, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0x1F, 0xE0, 0x0F, 0xF0, 0x3F, 0x80, 0x7F, 0x80, 0x7E, 0x01, 0xFE,
  0x01, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x1F, 0xC0, 0x1F, 0x80, 0x7E, 0x00,
  0x7E, 0x03, 0xF8, 0x01, 0xF8, 0x0F, 0xE0, 0x07, 0xE0, 0x3F, 0x00, 0x3F,
  0x80, 0xFC, 0x00, 0xFE, 0x03, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x0F, 0xC0,
  0x7F, 0x00, 0x7F, 0x01, 0xF8, 0x01, 0xFC, 0x07, 0xE0, 0x0F, 0xE0, 0x3F,
  0xC0, 0x3F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x0F, 0xF8,
  0x7F, 0x80, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xE7, 0xFF,
  0x80, 0x1F, 0x9F, 0xFC, 0x00, 0x7E, 0x3F, 0xC0, 0x01, 0xF8, 0x08, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x83, 0xE0, 0x1F, 0xF8, 0xFC, 0x07, 0xFF, 0x9F, 0x01, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFC, 0x1F, 0xF1, 0xFF, 0x83, 0xF8, 0x1F, 0xE0, 0xFE, 0x01,
  0xFC, 0x1F, 0xC0, 0x3F, 0x87, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x3F,
  0x80, 0x1F, 0x87, 0xF0, 0x03, 0xF0, 0xFE, 0x00, 0x7E, 0x1F, 0x80, 0x1F,
  0xC7, 0xF0, 0x03, 0xF8, 0xFE, 0x00, 0x7E, 0x1F, 0xC0, 0x0F, 0xC3, 0xF8,
  0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x0F, 0xE0, 0x1F, 0xE1, 0xFC, 0x03, 0xF8,
  0x3F, 0x80, 0xFF, 0x07, 0xF0, 0x3F, 0xE0, 0xFF, 0x0F, 0xFC, 0x0F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFE, 0xFC, 0x03, 0xFF, 0xBF, 0x80,
  0x1F, 0xC7, 0xF0, 0x00, 0x40, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xE1, 0xFC, 0x0F, 0x8F, 0xE0, 0x7E, 0x7F, 0x81, 0xFB, 0xFE, 0x07,
  0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x7F, 0xE0, 0x83, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x81, 0xFC, 0x07, 0x03, 0xF0, 0x02, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x40, 0x07, 0xF0, 0xE0, 0x1F, 0xE1, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x07, 0xFF,
  0x80, 0x00, 0x30, 0x00, 0x00, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x41, 0xFF,
  0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x1F, 0xFC, 0x07, 0xFE, 0x00, 0x30, 0x00,
  0x07, 0xE0, 0x0F, 0xE1, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x07, 0xF0,
  0x07, 0xE0, 0xFC, 0x01, 0xFC, 0x1F, 0x80, 0x3F, 0x87, 0xF0, 0x07, 0xE0,
  0xFE, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x07, 0xF0, 0x7E, 0x00,
  0xFE, 0x1F, 0xC0, 0x1F, 0x83, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0x7E, 0x0F,
  0xC0, 0x1F, 0xC3, 0xF8, 0x03, 0xF8, 0x7F, 0x00, 0x7E, 0x0F, 0xE0, 0x1F,
  0xC1, 0xF8, 0x03, 0xF8, 0x3F, 0x00, 0x7F, 0x07, 0xE0, 0x1F, 0xE1, 0xFC,
  0x03, 0xF8, 0x3F, 0x80, 0xFF, 0x07, 0xF0, 0x3F, 0xE0, 0xFF, 0x0F, 0xFC,
  0x0F, 0xFF, 0xDF, 0x01, 0xFF, 0xFB, 0xE0, 0x3F, 0xFE, 0x7C, 0x03, 0xFF,
  0x8F, 0x80, 0x3F, 0xC3, 0xF0, 0x00, 0x40, 0x00, 0x00, 0xFC, 0x00, 0x3F,
  0xFE, 0x00, 0x3F, 0xBF, 0x00, 0x1F, 0xDF, 0x80, 0x1F, 0xCF, 0xE0, 0x0F,
  0xE7, 0xF0, 0x0F, 0xE3, 0xF8, 0x07, 0xF0, 0xFC, 0x07, 0xF0, 0x7E, 0x03,
  0xF8, 0x3F, 0x03, 0xF8, 0x1F, 0x81, 0xFC, 0x0F, 0xC1, 0xFC, 0x07, 0xE0,
  0xFE, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x7F, 0x00, 0xFC, 0x3F, 0x00, 0x7E,
  0x3F, 0x80, 0x3F, 0x1F, 0x80, 0x1F, 0x9F, 0xC0, 0x07, 0xCF, 0xC0, 0x03,
  0xEF, 0xC0, 0x01, 0xF7, 0xE0, 0x00, 0xFB, 0xE0, 0x00, 0x7F, 0xF0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFF,
  0xF8, 0x07, 0xF8, 0x07, 0xEF, 0xE0, 0x3F, 0xE0, 0x1F, 0xBF, 0x80, 0xFF,
  0x80, 0xFE, 0xFE, 0x03, 0xFE, 0x03, 0xF3, 0xF8, 0x1F, 0xF8, 0x1F, 0xCF,
  0xE0, 0x7F, 0xE0, 0x7E, 0x3F, 0x83, 0xEF, 0x83, 0xF8, 0x7C, 0x0F, 0xBE,
  0x0F, 0xC1, 0xF0, 0x7E, 0xF8, 0x3F, 0x07, 0xC1, 0xF3, 0xE1, 0xF8, 0x1F,
  0x07, 0xCF, 0x87, 0xE0, 0x7C, 0x3E, 0x3E, 0x3F, 0x81, 0xF0, 0xF8, 0xF8,
  0xFC, 0x07, 0xC7, 0xE3, 0xE7, 0xF0, 0x1F, 0x1F, 0x1F, 0x9F, 0x80, 0x7C,
  0x7C, 0x7E, 0x7E, 0x01, 0xF3, 0xE1, 0xF3, 0xF0, 0x07, 0xCF, 0x87, 0xCF,
  0xC0, 0x1F, 0x7E, 0x1F, 0x3E, 0x00, 0x7D, 0xF0, 0x7D, 0xF8, 0x01, 0xF7,
  0xC1, 0xF7, 0xE0, 0x07, 0xFE, 0x07, 0xDF, 0x00, 0x1F, 0xF8, 0x1F, 0xFC,
  0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0x07, 0xFC,
  0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x7F, 0x80,
  0x01, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x01, 0xFE, 0x01, 0xF8,
  0x03, 0xF8, 0x03, 0xF8, 0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0x80, 0x07, 0xE0,
  0xFF, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x1F, 0x9F,
  0xC0, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x0F, 0xDF, 0xC0, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0xFE, 0x3F, 0x00, 0x03,
  0xF8, 0x7F, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x7F,
  0x01, 0xFC, 0x01, 0xFE, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x1F, 0xE0,
  0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0xFE, 0x01,
  0xFC, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x00,
  0xFC, 0x03, 0xF8, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0xFC, 0x07, 0xF0, 0x00,
  0xFC, 0x07, 0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xE0, 0x00,
  0xFC, 0x0F, 0xC0, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0xFC, 0x1F, 0x80, 0x00,
  0x7C, 0x3F, 0x80, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00,
  0x7E, 0x7E, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00,
  0x7E, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x8F, 0xF8, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xFF,
  0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF8, 0x01, 0xFF,
  0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x0E,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x7E, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0x80, 0x00, 0x7E, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x80, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3C, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x9F, 0xF0, 0x00, 0xDF, 0xFF, 0x00, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFD, 0x00, 0x1F,
  0xFC, 0x80, 0x01, 0xF0, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_SemiBoldItalic55pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 15, 40, 15, 1, -39 },
  { 76, 19, 14, 23, 5, -39 },
  { 110, 32, 39, 32, 1, -39 },
  { 266, 27, 45, 28, 1, -42 },
  { 418, 38, 41, 43, 3, -40 },
  { 613, 32, 41, 34, 1, -40 },
  { 777, 8, 14, 13, 6, -39 },
  { 791, 19, 48, 17, 2, -39 },
  { 905, 19, 49, 17, -4, -40 },
  { 1022, 23, 24, 27, 5, -42 },
  { 1091, 25, 27, 29, 3, -33 },
  { 1176, 12, 14, 14, -3, -7 },
  { 1197, 14, 6, 17, 1, -18 },
  { 1208, 8, 9, 14, 1, -8 },
  { 1217, 28, 39, 21, -3, -39 },
  { 1354, 25, 41, 28, 2, -40 },
  { 1483, 18, 39, 28, 6, -39 },
  { 1571, 28, 40, 28, -1, -40 },
  { 1711, 27, 41, 28, 0, -40 },
  { 1850, 28, 39, 28, -1, -39 },
  { 1987, 27, 40, 28, 1, -39 },
  { 2122, 26, 41, 28, 2, -40 },
  { 2256, 28, 39, 28, 2, -39 },
  { 2393, 27, 41, 28, 1, -40 },
  { 2532, 26, 41, 28, 1, -40 },
  { 2666, 13, 31, 14, 0, -30 },
  { 2717, 16, 37, 14, -3, -30 },
  { 2791, 25, 27, 29, 3, -33 },
  { 2876, 24, 16, 29, 3, -27 },
  { 2924, 25, 27, 29, 3, -33 },
  { 3009, 21, 41, 22, 3, -40 },
  { 3117, 40, 44, 42, 2, -39 },
  { 3337, 30, 39, 30, -3, -39 },
  { 3484, 29, 39, 31, 1, -39 },
  { 3626, 29, 41, 29, 3, -40 },
  { 3775, 31, 39, 33, 1, -39 },
  { 3927, 27, 39, 26, 1, -39 },
  { 4059, 27, 39, 25, 1, -39 },
  { 4191, 31, 41, 34, 3, -40 },
  { 4350, 34, 39, 34, 1, -39 },
  { 4516, 24, 39, 19, -2, -39 },
  { 4633, 25, 50, 15, -9, -39 },
  { 4790, 33, 39, 30, 1, -39 },
  { 4951, 20, 39, 25, 1, -39 },
  { 5049, 44, 39, 44, 1, -39 },
  { 5264, 36, 39, 37, 1, -39 },
  { 5440, 32, 41, 36, 3, -40 },
  { 5604, 29, 39, 30, 1, -39 },
  { 5746, 32, 49, 36, 3, -40 },
  { 5942, 29, 39, 30, 1, -39 },
  { 6084, 28, 41, 26, 0, -40 },
  { 6228, 25, 39, 26, 5, -39 },
  { 6350, 32, 40, 34, 3, -39 },
  { 6510, 29, 39, 29, 5, -39 },
  { 6652, 44, 39, 44, 5, -39 },
  { 6867, 36, 39, 28, -3, -39 },
  { 7043, 27, 39, 27, 5, -39 },
  { 7175, 31, 39, 26, -2, -39 },
  { 7327, 22, 48, 17, -1, -39 },
  { 7459, 11, 39, 21, 6, -39 },
  { 7513, 22, 48, 17, -4, -39 },
  { 7645, 26, 24, 28, 1, -39 },
  { 7723, 21, 4, 20, -5, 5 },
  { 7734, 10, 9, 16, 8, -42 },
  { 7746, 27, 31, 29, 2, -30 },
  { 7851, 27, 43, 29, 1, -42 },
  { 7997, 22, 31, 23, 2, -30 },
  { 8083, 29, 43, 29, 2, -42 },
  { 8239, 24, 31, 27, 2, -30 },
  { 8332, 30, 55, 18, -6, -42 },
  { 8539, 29, 43, 30, 0, -30 },
  { 8695, 26, 42, 30, 1, -42 },
  { 8832, 15, 41, 14, 1, -41 },
  { 8909, 23, 54, 14, -7, -41 },
  { 9065, 28, 42, 27, 1, -42 },
  { 9212, 15, 42, 14, 1, -42 },
  { 9291, 41, 30, 44, 1, -30 },
  { 9445, 26, 30, 30, 1, -30 },
  { 9543, 25, 31, 29, 2, -30 },
  { 9640, 30, 43, 29, -2, -30 },
  { 9802, 27, 43, 29, 2, -30 },
  { 9948, 22, 30, 21, 1, -30 },
  { 10031, 23, 31, 23, 0, -30 },
  { 10121, 17, 37, 19, 3, -36 },
  { 10200, 27, 31, 30, 2, -30 },
  { 10305, 25, 30, 25, 3, -30 },
  { 10399, 38, 30, 38, 3, -30 },
  { 10542, 31, 30, 26, -3, -30 },
  { 10659, 32, 43, 25, -4, -30 },
  { 10831, 24, 30, 22, -1, -30 },
  { 10921, 22, 48, 19, 0, -39 },
  { 11053, 5, 55, 27, 11, -42 },
  { 11088, 22, 48, 19, -3, -39 },
  { 11220, 25, 9, 29, 3, -24 },
};

const GFXfont NotoSans_SemiCondensed_SemiBoldItalic55pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_SemiBoldItalic55pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_SemiBoldItalic55pt7bGlyphs,
  0x20, 0x7E, 75
};

#endif // _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC55PT7B_H_
