#ifndef _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC57PT7B_H_
#define _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC57PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-SemiBoldItalic.ttf
// Size: 57pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_SemiBoldItalic57pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01,
  0xFC, 0x01, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x03,
  0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x7F, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x30,
  0x00, 0x3F, 0x0F, 0xE7, 0xE1, 0xFD, 0xFC, 0x3F, 0x3F, 0x87, 0xE7, 0xE0,
  0xFC, 0xFC, 0x3F, 0x1F, 0x87, 0xE3, 0xE0, 0xFC, 0x7C, 0x1F, 0x9F, 0x83,
  0xE3, 0xF0, 0x7C, 0x7C, 0x0F, 0x8F, 0x83, 0xE1, 0xF0, 0x7C, 0x3E, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0xF8,
  0x3E, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x3E,
  0x07, 0xC0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x0F,
  0x81, 0xF0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x03,
  0xE0, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0x00,
  0x3E, 0x07, 0xC0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x0F, 0x83, 0xE0, 0x00,
  0x0F, 0x81, 0xF0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x03, 0xE0, 0x7C, 0x00,
  0x03, 0xE0, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0x07, 0xC0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x0F, 0x81, 0xF0,
  0x00, 0x07, 0xC0, 0xF8, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x03, 0xE0, 0x7C,
  0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0xF8, 0x1F,
  0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3E, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFC, 0x03, 0xF9, 0xE7, 0xC0, 0x7F, 0x1C, 0x08, 0x07, 0xF1, 0xC0,
  0x00, 0x7E, 0x1C, 0x00, 0x07, 0xE3, 0xC0, 0x00, 0x7E, 0x38, 0x00, 0x07,
  0xF3, 0x80, 0x00, 0x7F, 0xB8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xF8,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0E,
  0xFF, 0x00, 0x00, 0xE7, 0xF0, 0x00, 0x1E, 0x7F, 0x00, 0x01, 0xE3, 0xF0,
  0x00, 0x1C, 0x3F, 0x00, 0x01, 0xC3, 0xF0, 0xC0, 0x1C, 0x7F, 0x0F, 0x03,
  0xCF, 0xF0, 0xFE, 0x39, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x03,
  0xF0, 0x07, 0xFE, 0x00, 0x07, 0xC0, 0x1F, 0xFE, 0x00, 0x1F, 0x00, 0x7F,
  0xFC, 0x00, 0x7E, 0x00, 0xFF, 0xFC, 0x00, 0xF8, 0x03, 0xF1, 0xF8, 0x03,
  0xE0, 0x07, 0xC1, 0xF0, 0x0F, 0xC0, 0x1F, 0x83, 0xE0, 0x1F, 0x00, 0x3E,
  0x07, 0xC0, 0x7C, 0x00, 0xFC, 0x0F, 0x81, 0xF8, 0x01, 0xF8, 0x3F, 0x03,
  0xE0, 0x03, 0xE0, 0x7E, 0x0F, 0x80, 0x07, 0xC0, 0xFC, 0x3F, 0x00, 0x0F,
  0x81, 0xF0, 0x7C, 0x00, 0x1F, 0x03, 0xE1, 0xF0, 0x00, 0x7E, 0x0F, 0xC7,
  0xE0, 0x00, 0xFC, 0x1F, 0x8F, 0x87, 0xE1, 0xF8, 0x3E, 0x3E, 0x1F, 0xF3,
  0xF0, 0xFC, 0xFC, 0xFF, 0xF3, 0xE3, 0xF1, 0xF1, 0xFF, 0xE7, 0xEF, 0xE7,
  0xC7, 0xFF, 0xEF, 0xFF, 0x9F, 0x9F, 0x8F, 0xCF, 0xFE, 0x3E, 0x3E, 0x0F,
  0x9F, 0xF8, 0xF8, 0xFC, 0x1F, 0x0F, 0xE3, 0xF1, 0xF0, 0x3E, 0x00, 0x07,
  0xC3, 0xE0, 0x7C, 0x00, 0x1F, 0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x1F, 0x83,
  0xF0, 0x00, 0xF8, 0x3E, 0x07, 0xE0, 0x03, 0xF0, 0x7C, 0x0F, 0x80, 0x0F,
  0xC0, 0xF8, 0x1F, 0x00, 0x1F, 0x01, 0xF0, 0x7E, 0x00, 0x7E, 0x07, 0xE0,
  0xFC, 0x01, 0xF8, 0x0F, 0xC1, 0xF0, 0x03, 0xE0, 0x1F, 0x87, 0xE0, 0x0F,
  0xC0, 0x1F, 0x0F, 0x80, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x7C, 0x00, 0x7F,
  0xFC, 0x01, 0xF8, 0x00, 0xFF, 0xF0, 0x07, 0xE0, 0x00, 0xFF, 0xE0, 0x1F,
  0x80, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x03, 0xF8,
  0x1F, 0x80, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x7E,
  0x03, 0xF0, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x0F,
  0xC1, 0xFC, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x01, 0xF8,
  0x3F, 0xFF, 0x01, 0xFC, 0x3F, 0xFF, 0x80, 0xFE, 0x3F, 0xCF, 0xE0, 0xFE,
  0x3F, 0xC7, 0xF8, 0x7F, 0x1F, 0xC1, 0xFC, 0x7F, 0x1F, 0xC0, 0xFF, 0x3F,
  0x8F, 0xE0, 0x3F, 0xBF, 0x8F, 0xE0, 0x1F, 0xFF, 0x87, 0xF0, 0x07, 0xFF,
  0xC3, 0xF8, 0x01, 0xFF, 0xC1, 0xFC, 0x00, 0xFF, 0xC0, 0xFE, 0x00, 0x3F,
  0xE0, 0x7F, 0x80, 0x3F, 0xE0, 0x3F, 0xC0, 0x3F, 0xF8, 0x0F, 0xF8, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xDF, 0xE0, 0x3F, 0xFF, 0x87, 0xF8, 0x07, 0xFF, 0x03, 0xFE, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x3F, 0x9F, 0x8F, 0xCF, 0xE7, 0xE3, 0xF1, 0xF8, 0xFC,
  0x7C, 0x3E, 0x3F, 0x1F, 0x0F, 0x87, 0xC3, 0xE0, 0x00, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00,
  0x30, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x7F, 0x1E, 0x00, 0x7F, 0xDE, 0x00,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x03, 0xFF, 0x01, 0x07, 0xFF, 0x00, 0x0F, 0xEF, 0x80,
  0x1F, 0xCF, 0x80, 0x3F, 0x8F, 0xC0, 0x7F, 0x87, 0xC0, 0x1F, 0x07, 0xE0,
  0x0E, 0x07, 0xE0, 0x06, 0x03, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF8, 0x3F, 0x81, 0xFC,
  0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x1F, 0x81, 0xF8, 0x0F,
  0xC0, 0x7C, 0x07, 0xE0, 0x7E, 0x00, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xF7,
  0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0x80, 0x3E, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFC, 0x30, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xC3, 0xFC, 0x1F, 0xE0, 0x7F, 0x07, 0xF0,
  0x1F, 0xC3, 0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x7F, 0x00, 0x7F, 0x1F,
  0xC0, 0x1F, 0xCF, 0xF0, 0x07, 0xF3, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0x7F,
  0x3F, 0x80, 0x1F, 0xDF, 0xC0, 0x07, 0xF7, 0xF0, 0x01, 0xFD, 0xFC, 0x00,
  0x7F, 0x7F, 0x00, 0x3F, 0x9F, 0x80, 0x0F, 0xEF, 0xE0, 0x03, 0xFB, 0xF8,
  0x00, 0xFE, 0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x1F, 0xCF, 0xE0, 0x07, 0xF3,
  0xF8, 0x01, 0xFC, 0xFE, 0x00, 0xFE, 0x3F, 0x80, 0x3F, 0x8F, 0xE0, 0x1F,
  0xE3, 0xF8, 0x07, 0xF0, 0xFE, 0x03, 0xFC, 0x3F, 0x80, 0xFE, 0x07, 0xF0,
  0x7F, 0x81, 0xFE, 0x7F, 0xC0, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x03,
  0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x1F,
  0xFC, 0x07, 0xFF, 0x81, 0xFF, 0xF0, 0xFF, 0xFE, 0x3F, 0xFF, 0x9F, 0xFB,
  0xF3, 0xFE, 0xFE, 0x3F, 0x1F, 0xC3, 0xC3, 0xF8, 0x60, 0x7E, 0x04, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x0F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF8, 0x03, 0xF0, 0x3F, 0xE0, 0x1F, 0x00, 0xFF, 0x00, 0x60, 0x03, 0xF8,
  0x02, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0xF0, 0x0F, 0xF0, 0x04, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00,
  0x7F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x08, 0x00, 0x0F, 0xF0, 0xE0, 0x01, 0xFF, 0x0F, 0xC0,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0xFD, 0xF8, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x7E, 0xFE, 0x00, 0x07,
  0xE7, 0xE0, 0x00, 0x7E, 0x3F, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x3F, 0x1F,
  0xC0, 0x03, 0xF0, 0xFE, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x3F, 0x00,
  0x3F, 0x03, 0xF8, 0x01, 0xF8, 0x1F, 0xC0, 0x1F, 0x80, 0xFC, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7F, 0x00, 0xFC, 0x03, 0xF8, 0x0F, 0xC0, 0x1F,
  0xC0, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFE, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x70, 0x3F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x08,
  0x00, 0x1F, 0xE0, 0xC0, 0x07, 0xFC, 0x0F, 0xC1, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE,
  0x00, 0xFF, 0xF7, 0x80, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x3F,
  0x80, 0x3F, 0x9F, 0xF8, 0x07, 0xF7, 0xFF, 0x80, 0xFD, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0x87, 0xFF, 0xBF, 0xF0, 0xFF, 0xC0, 0xFE, 0x1F, 0xE0, 0x1F,
  0xC3, 0xFC, 0x01, 0xF8, 0x7F, 0x00, 0x3F, 0x0F, 0xE0, 0x07, 0xE3, 0xF8,
  0x00, 0xFC, 0x7F, 0x00, 0x3F, 0x8F, 0xE0, 0x07, 0xF1, 0xFC, 0x00, 0xFE,
  0x3F, 0x80, 0x1F, 0xC7, 0xF0, 0x07, 0xF0, 0x7E, 0x00, 0xFE, 0x0F, 0xE0,
  0x3F, 0xC1, 0xFC, 0x0F, 0xF0, 0x3F, 0xE3, 0xFC, 0x03, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFE, 0x20, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x1F,
  0xE1, 0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0x80, 0x7F, 0x03, 0xF0, 0x07,
  0xF0, 0x3F, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0x3F, 0x00, 0x7E, 0x03,
  0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0xC7,
  0xF8, 0x01, 0xFE, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00,
  0x07, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF,
  0xFC, 0x01, 0xFF, 0x1F, 0xE0, 0x1F, 0xC0, 0xFE, 0x03, 0xF8, 0x07, 0xF0,
  0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x03, 0xF8, 0x7E, 0x00, 0x3F, 0x8F, 0xE0,
  0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x3F,
  0x0F, 0xE0, 0x07, 0xF0, 0xFF, 0x00, 0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0x7F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xE0, 0xFF, 0x03, 0xF8, 0x3F, 0x80, 0xFE, 0x1F, 0xC0,
  0x1F, 0xC7, 0xF0, 0x07, 0xF1, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0x7F, 0x3F,
  0x80, 0x1F, 0xCF, 0xE0, 0x07, 0xF3, 0xF8, 0x01, 0xFC, 0xFC, 0x00, 0xFF,
  0x3F, 0x00, 0x3F, 0x8F, 0xE0, 0x1F, 0xE3, 0xF8, 0x07, 0xF8, 0xFE, 0x03,
  0xFE, 0x3F, 0xE3, 0xFF, 0x87, 0xFF, 0xFF, 0xE1, 0xFF, 0xFB, 0xF0, 0x3F,
  0xFE, 0xFC, 0x07, 0xFF, 0x7F, 0x00, 0xFF, 0x1F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x03, 0x83, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0xF8, 0x0F, 0xF0, 0x3F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xE0,
  0x3F, 0x80, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x3F, 0x81, 0xFE, 0x07, 0xF8,
  0x3F, 0xE0, 0xFF, 0x81, 0xFC, 0x07, 0xE0, 0x06, 0x00, 0x00, 0x3F, 0x00,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x01, 0xFC,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7E,
  0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x0F,
  0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00,
  0x7F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xC0,
  0x07, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0x81,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x7F, 0xBF, 0xE1, 0xE0,
  0x3F, 0xC2, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x80, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0xFC,
  0x00, 0xFE, 0x03, 0xF0, 0xFC, 0x03, 0xFF, 0xE0, 0xF8, 0x7C, 0x03, 0xFF,
  0xF0, 0x7C, 0x7E, 0x07, 0xFF, 0xF8, 0x3E, 0x3E, 0x03, 0xF8, 0xFC, 0x1F,
  0x3F, 0x03, 0xF0, 0x7C, 0x0F, 0x9F, 0x03, 0xF0, 0x3E, 0x07, 0xCF, 0x81,
  0xF0, 0x1F, 0x03, 0xEF, 0xC1, 0xF0, 0x1F, 0x81, 0xF7, 0xC0, 0xF8, 0x0F,
  0x80, 0xFB, 0xE0, 0xF8, 0x07, 0xC0, 0x7D, 0xF0, 0x7C, 0x03, 0xE0, 0x7C,
  0xF8, 0x3E, 0x03, 0xF0, 0x3E, 0xF8, 0x3F, 0x01, 0xF0, 0x1F, 0x7C, 0x1F,
  0x80, 0xF8, 0x1F, 0x3E, 0x0F, 0x80, 0xFC, 0x0F, 0x9F, 0x07, 0xC0, 0x7E,
  0x0F, 0xCF, 0x83, 0xF0, 0x7F, 0x07, 0xC7, 0xC1, 0xF8, 0x7F, 0x87, 0xC3,
  0xE0, 0x7E, 0x7F, 0xEF, 0xE1, 0xF0, 0x3F, 0xFD, 0xFF, 0xE0, 0xFC, 0x1F,
  0xFC, 0xFF, 0xE0, 0x3E, 0x07, 0xFC, 0x3F, 0xE0, 0x1F, 0x00, 0xF8, 0x0F,
  0xC0, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x10, 0x00, 0x0F, 0xF0, 0x00, 0x70, 0x00, 0x03, 0xFF, 0xCF, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F,
  0x7C, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x03, 0xF3,
  0xE0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x3F, 0x1F,
  0x80, 0x00, 0xFC, 0x3F, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x07, 0xF0, 0xFC,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x7E, 0x07, 0xE0,
  0x01, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x1F, 0x80, 0x0F, 0xE0, 0x3F, 0x00,
  0x1F, 0x80, 0x7E, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x81, 0xFC, 0x00, 0x7F, 0x07, 0xF0,
  0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xF8, 0x7F, 0x00,
  0x03, 0xF1, 0xFC, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x0F, 0xCF, 0xF0, 0x00,
  0x1F, 0xDF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0x80, 0x7F, 0x01, 0xFF, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x01, 0xFC,
  0x03, 0xF8, 0x03, 0xFC, 0x07, 0xE0, 0x07, 0xF0, 0x1F, 0xC0, 0x0F, 0xE0,
  0x3F, 0x80, 0x1F, 0xC0, 0x7F, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0xFE, 0x03,
  0xF8, 0x03, 0xFC, 0x07, 0xF0, 0x1F, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xC0,
  0x0F, 0xE0, 0x3F, 0x80, 0x1F, 0xC0, 0x7F, 0x00, 0x1F, 0xC0, 0xFE, 0x00,
  0x3F, 0x81, 0xFC, 0x00, 0x7F, 0x07, 0xF0, 0x01, 0xFE, 0x0F, 0xE0, 0x03,
  0xF8, 0x1F, 0xC0, 0x07, 0xF0, 0x3F, 0x80, 0x1F, 0xE0, 0x7F, 0x00, 0x7F,
  0x81, 0xFC, 0x01, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xE0, 0x1F, 0xF8, 0x07, 0x00, 0xFF, 0x80, 0x04, 0x07, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0xE0, 0x0F, 0xFF, 0x7F, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFC, 0x1F, 0xFC, 0x01, 0xFC,
  0x03, 0xFE, 0x01, 0xFC, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0xFF, 0x01, 0xFC,
  0x00, 0xFF, 0x03, 0xF8, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x7F, 0x03, 0xF8,
  0x00, 0x7F, 0x03, 0xF8, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x7F, 0x07, 0xF0,
  0x00, 0x7F, 0x07, 0xF0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x7F, 0x07, 0xF0,
  0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0xFF, 0x0F, 0xE0,
  0x00, 0xFF, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0xC0,
  0x01, 0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xFC, 0x1F, 0xC0,
  0x03, 0xFC, 0x3F, 0xC0, 0x07, 0xF8, 0x3F, 0x80, 0x0F, 0xF8, 0x3F, 0x80,
  0x1F, 0xF0, 0x3F, 0x80, 0x3F, 0xE0, 0x3F, 0x80, 0x7F, 0xE0, 0x7F, 0x01,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xF8, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xF0, 0x07, 0xFE, 0x00, 0xF8, 0x07, 0xFE, 0x00, 0x18, 0x07, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x0F, 0xFF, 0x87, 0xF0,
  0x07, 0xFF, 0xC7, 0xF8, 0x07, 0xFF, 0xE3, 0xFC, 0x03, 0xFF, 0xE1, 0xFC,
  0x01, 0xFF, 0xF0, 0xFE, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x01, 0xFC, 0x3F,
  0x80, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x7F, 0x07,
  0xF8, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F, 0xC0,
  0x7F, 0x80, 0x0F, 0xE0, 0x3F, 0xC0, 0x07, 0xF0, 0x1F, 0xF8, 0x03, 0xF8,
  0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x01, 0xFC, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x1F, 0xC0, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x1F,
  0xC0, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x03, 0xF8,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x03, 0xF8, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x3F, 0x80, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x7F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFE, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x01, 0xFC, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x1F, 0xC0, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x03,
  0xF8, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x03, 0xF8, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0,
  0x07, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE,
  0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0xC0, 0x07, 0x7F, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x3F,
  0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x07, 0xF8, 0x03, 0xF8,
  0x01, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x1F, 0xE0, 0x01,
  0xF8, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x3F, 0xC0,
  0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x07, 0xE0, 0x7F,
  0x00, 0x01, 0xFC, 0x1F, 0xE0, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0x07, 0xF1,
  0xFE, 0x00, 0x00, 0xFE, 0x7F, 0x80, 0x00, 0x1F, 0x9F, 0xE0, 0x00, 0x07,
  0xF3, 0xF8, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x03, 0xF7, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xF3,
  0xF8, 0x00, 0x03, 0xFC, 0x7F, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0xFE, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x3F, 0x03, 0xFC, 0x00,
  0x0F, 0xE0, 0x3F, 0x80, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0xFF,
  0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x3F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F,
  0x80, 0x0F, 0xF0, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0xC0, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x07,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x1F, 0xFE, 0x01, 0xFF,
  0xC0, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xF8,
  0x00, 0xFD, 0xF8, 0x07, 0xEF, 0xC0, 0x07, 0xFF, 0xC0, 0x3F, 0x7E, 0x00,
  0x7E, 0xFE, 0x01, 0xFB, 0xF0, 0x03, 0xF7, 0xE0, 0x0F, 0xDF, 0x80, 0x3F,
  0x3F, 0x00, 0xFE, 0xFC, 0x01, 0xFB, 0xF8, 0x07, 0xF7, 0xE0, 0x1F, 0x9F,
  0xC0, 0x3F, 0x3F, 0x00, 0xFC, 0xFE, 0x01, 0xF8, 0xF8, 0x0F, 0xC7, 0xE0,
  0x0F, 0xC7, 0xC0, 0x7E, 0x3F, 0x00, 0xFE, 0x3E, 0x07, 0xE3, 0xF8, 0x07,
  0xF1, 0xF0, 0x3F, 0x1F, 0xC0, 0x3F, 0x0F, 0x83, 0xF0, 0xFC, 0x01, 0xF8,
  0x7C, 0x1F, 0x87, 0xE0, 0x0F, 0xC3, 0xE1, 0xF8, 0x3F, 0x00, 0xFE, 0x1F,
  0x8F, 0xC3, 0xF8, 0x07, 0xF0, 0xFC, 0xFC, 0x1F, 0xC0, 0x3F, 0x07, 0xE7,
  0xE0, 0xFC, 0x01, 0xF8, 0x3F, 0x7E, 0x07, 0xE0, 0x1F, 0xC1, 0xFB, 0xF0,
  0x7F, 0x00, 0xFE, 0x0F, 0xFF, 0x03, 0xF8, 0x07, 0xE0, 0x7F, 0xF8, 0x1F,
  0xC0, 0x3F, 0x03, 0xFF, 0x80, 0xFC, 0x01, 0xF8, 0x1F, 0xFC, 0x07, 0xE0,
  0x1F, 0xC0, 0x7F, 0xC0, 0x7F, 0x00, 0xFE, 0x03, 0xFE, 0x03, 0xF8, 0x07,
  0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0xFF, 0x00, 0xFC, 0x01, 0xF8,
  0x07, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01,
  0xF8, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x03, 0xFE, 0x00,
  0x07, 0xF0, 0x0F, 0xF8, 0x00, 0x1F, 0x80, 0x3F, 0xE0, 0x00, 0x7E, 0x00,
  0xFF, 0xC0, 0x03, 0xF8, 0x03, 0xFF, 0x00, 0x0F, 0xE0, 0x1F, 0xFC, 0x00,
  0x3F, 0x00, 0x7F, 0xF0, 0x00, 0xFC, 0x01, 0xFF, 0xE0, 0x03, 0xF0, 0x07,
  0xFF, 0x80, 0x1F, 0xC0, 0x1F, 0x7E, 0x00, 0x7F, 0x00, 0xFD, 0xFC, 0x01,
  0xF8, 0x03, 0xF7, 0xF0, 0x07, 0xE0, 0x0F, 0xCF, 0xC0, 0x1F, 0x80, 0x3F,
  0x3F, 0x00, 0xFE, 0x01, 0xFC, 0xFE, 0x03, 0xF8, 0x07, 0xF1, 0xF8, 0x0F,
  0xC0, 0x1F, 0x87, 0xE0, 0x3F, 0x00, 0x7E, 0x1F, 0xC1, 0xFC, 0x01, 0xF8,
  0x7F, 0x07, 0xF0, 0x0F, 0xE0, 0xFC, 0x1F, 0xC0, 0x3F, 0x83, 0xF0, 0x7E,
  0x00, 0xFC, 0x0F, 0xE1, 0xF8, 0x03, 0xF0, 0x1F, 0x87, 0xE0, 0x0F, 0xC0,
  0x7E, 0x3F, 0x80, 0x7F, 0x01, 0xFC, 0xFC, 0x01, 0xF8, 0x07, 0xF3, 0xF0,
  0x07, 0xE0, 0x0F, 0xCF, 0xC0, 0x1F, 0x80, 0x3F, 0x3F, 0x00, 0xFE, 0x00,
  0xFF, 0xFC, 0x03, 0xF8, 0x01, 0xFF, 0xE0, 0x0F, 0xC0, 0x07, 0xFF, 0x80,
  0x3F, 0x00, 0x1F, 0xFE, 0x00, 0xFC, 0x00, 0x7F, 0xF8, 0x07, 0xF0, 0x00,
  0xFF, 0xE0, 0x1F, 0xC0, 0x03, 0xFF, 0x00, 0x7E, 0x00, 0x0F, 0xFC, 0x01,
  0xF8, 0x00, 0x3F, 0xF0, 0x07, 0xE0, 0x00, 0x7F, 0xC0, 0x3F, 0x80, 0x01,
  0xFE, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFC, 0x0F, 0xF8,
  0x07, 0xF8, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x3F,
  0x83, 0xFC, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x03,
  0xF9, 0xFE, 0x00, 0x01, 0xFC, 0xFF, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00,
  0x7F, 0x7F, 0x80, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0x1F, 0xDF, 0xC0, 0x00,
  0x1F, 0xEF, 0xE0, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x07, 0xF7, 0xF8, 0x00,
  0x03, 0xFB, 0xFC, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x01, 0xFE, 0xFE, 0x00,
  0x00, 0xFF, 0x7F, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x7F, 0x9F, 0xC0,
  0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x1F, 0xE3, 0xFC,
  0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x0F, 0xF0, 0x3F,
  0xC0, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0A, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0,
  0x1F, 0xC0, 0xFF, 0xC0, 0x7F, 0x00, 0xFF, 0x01, 0xFC, 0x01, 0xFC, 0x07,
  0xF0, 0x07, 0xF0, 0x1F, 0x80, 0x1F, 0xC0, 0xFE, 0x00, 0x7F, 0x03, 0xF8,
  0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0x80, 0x1F, 0xC1, 0xFC, 0x00,
  0x7F, 0x07, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0xE0, 0x7F, 0x00, 0xFF,
  0x81, 0xFC, 0x0F, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0x80, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFC, 0x0F, 0xF8, 0x07, 0xFC, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0xFF,
  0x07, 0xFC, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x07,
  0xF1, 0xFE, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x01, 0xFC, 0xFF, 0x00, 0x00,
  0xFE, 0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0x3F, 0xBF, 0xC0, 0x00,
  0x1F, 0xDF, 0xC0, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x0F, 0xF7, 0xF0, 0x00,
  0x07, 0xF7, 0xF8, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x01, 0xFD, 0xFC, 0x00,
  0x01, 0xFE, 0xFE, 0x00, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0x7F, 0x3F, 0x80,
  0x00, 0x7F, 0x9F, 0xC0, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x1F, 0xC7, 0xF0,
  0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x0F, 0xF0, 0x7F,
  0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF8, 0x07,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xC0, 0xFF, 0x80, 0x7F, 0x01, 0xFE,
  0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0x1F, 0x80, 0x1F, 0xC0,
  0xFE, 0x00, 0x7F, 0x03, 0xF8, 0x03, 0xF8, 0x0F, 0xE0, 0x0F, 0xE0, 0x3F,
  0x80, 0x3F, 0x81, 0xFC, 0x01, 0xFE, 0x07, 0xF0, 0x07, 0xF0, 0x1F, 0xC0,
  0x3F, 0xC0, 0x7F, 0x03, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0x07, 0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x07,
  0xF0, 0x7F, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0xFE, 0x03, 0xF8, 0x03, 0xF8,
  0x0F, 0xE0, 0x0F, 0xE0, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01,
  0xFC, 0x07, 0xF0, 0x07, 0xF0, 0x1F, 0xC0, 0x1F, 0xE0, 0x7F, 0x00, 0x3F,
  0x81, 0xFC, 0x00, 0xFE, 0x07, 0xF0, 0x03, 0xFC, 0x3F, 0x80, 0x07, 0xF0,
  0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF0, 0x07, 0xFC, 0x0F, 0x80, 0x7F, 0x80, 0x08, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFE, 0x02, 0x00, 0x0F, 0xF0, 0x1C, 0x00, 0xFF, 0x81, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xE0, 0x07, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x1F, 0xC0,
  0xFE, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x07, 0xF0,
  0x3F, 0x80, 0x03, 0xF8, 0x1F, 0xC0, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0xFE,
  0x07, 0xF0, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x3F,
  0x81, 0xFC, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x0F,
  0xE0, 0x7F, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x03, 0xF8, 0x1F, 0xC0, 0x01,
  0xFC, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x07, 0xF0, 0x00,
  0x7F, 0x03, 0xF8, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x1F, 0xC0, 0xFE, 0x00,
  0x1F, 0xC0, 0xFE, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x07, 0xF0, 0x3F, 0x80,
  0x03, 0xF8, 0x1F, 0xC0, 0x01, 0xFC, 0x0F, 0xE0, 0x01, 0xFC, 0x0F, 0xE0,
  0x00, 0xFE, 0x07, 0xF0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x7F, 0x81, 0xFC,
  0x00, 0x3F, 0x80, 0xFF, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x1F, 0xC0, 0x1F,
  0xE0, 0x3F, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x3F, 0xBF, 0x80, 0x01, 0xFE,
  0xFE, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x3F, 0xC7, 0xE0, 0x00, 0xFE, 0x1F,
  0x80, 0x07, 0xF8, 0x7E, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x7F, 0x07, 0xE0,
  0x03, 0xF8, 0x1F, 0x80, 0x0F, 0xE0, 0x7E, 0x00, 0x7F, 0x01, 0xF8, 0x01,
  0xFC, 0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x01, 0xFC,
  0x01, 0xFC, 0x07, 0xF0, 0x07, 0xF0, 0x3F, 0x80, 0x1F, 0xC0, 0xFE, 0x00,
  0x7F, 0x07, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xF0, 0xFE, 0x00, 0x0F,
  0xC3, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xFC, 0x7F, 0x00, 0x03, 0xF1,
  0xF8, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0xFD, 0xFC,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01,
  0xFF, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0xBF, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF3,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xCF, 0xE0, 0x07, 0xFC, 0x00, 0x7E, 0x3F,
  0x80, 0x1F, 0xF0, 0x03, 0xF8, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xE3, 0xF8,
  0x03, 0xFF, 0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xFC, 0x01, 0xFC, 0x3F, 0x80,
  0x7F, 0xF0, 0x0F, 0xE0, 0x7E, 0x01, 0xF7, 0xC0, 0x3F, 0x81, 0xF8, 0x0F,
  0xDF, 0x00, 0xFC, 0x07, 0xE0, 0x3F, 0x7C, 0x07, 0xF0, 0x1F, 0x81, 0xF9,
  0xF0, 0x1F, 0xC0, 0x7E, 0x07, 0xE7, 0xC0, 0xFE, 0x01, 0xF8, 0x1F, 0x1F,
  0x03, 0xF8, 0x07, 0xE0, 0xFC, 0x7C, 0x0F, 0xC0, 0x1F, 0x83, 0xF1, 0xF0,
  0x7F, 0x00, 0x7E, 0x1F, 0x87, 0xC1, 0xF8, 0x01, 0xF8, 0x7E, 0x1F, 0x0F,
  0xE0, 0x07, 0xE3, 0xF0, 0x7C, 0x3F, 0x80, 0x1F, 0x8F, 0xC1, 0xF0, 0xFC,
  0x00, 0x7E, 0x3E, 0x07, 0xC7, 0xF0, 0x01, 0xF9, 0xF8, 0x1F, 0x1F, 0x80,
  0x07, 0xE7, 0xE0, 0x7C, 0xFE, 0x00, 0x1F, 0xBF, 0x01, 0xF3, 0xF0, 0x00,
  0x7E, 0xFC, 0x07, 0xCF, 0xC0, 0x01, 0xFB, 0xE0, 0x1F, 0x7F, 0x00, 0x07,
  0xFF, 0x80, 0x7D, 0xF8, 0x00, 0x1F, 0xFC, 0x01, 0xF7, 0xE0, 0x00, 0x7F,
  0xF0, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x03, 0xF8,
  0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x7F, 0x01, 0xFE, 0x00,
  0x03, 0xF8, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0x7F, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x00,
  0x7E, 0x7F, 0x00, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x00, 0xFE, 0x7F, 0x00,
  0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x7F, 0x00, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x7F, 0x00, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x1F,
  0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x01, 0xFE,
  0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFE, 0x7E, 0x00, 0x1F, 0xE7,
  0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x87, 0xF0, 0x07, 0xF8, 0x7F, 0x00,
  0x7F, 0x03, 0xF0, 0x0F, 0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x1F, 0xC0,
  0x3F, 0x81, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0x87, 0xF0, 0x01, 0xF8,
  0x7F, 0x00, 0x1F, 0xCF, 0xE0, 0x01, 0xFC, 0xFE, 0x00, 0x1F, 0xDF, 0xC0,
  0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x00, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8,
  0x1F, 0x81, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xF0, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3E, 0xF8, 0x00,
  0x0F, 0xDF, 0x80, 0x01, 0xF3, 0xF0, 0x00, 0x7E, 0x3E, 0x00, 0x0F, 0x87,
  0xE0, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x0F, 0x80, 0x1F, 0x01, 0xF8, 0x07,
  0xE0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x0F,
  0xC1, 0xF8, 0x00, 0xF8, 0x7E, 0x00, 0x1F, 0x8F, 0x80, 0x03, 0xF3, 0xF0,
  0x00, 0x3E, 0xFC, 0x00, 0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0x0F, 0xE1, 0xFC, 0x1F, 0xC3, 0xF8,
  0x3F, 0x03, 0xF0, 0x3E, 0x07, 0xE0, 0x00, 0x3F, 0xC3, 0xF0, 0x0F, 0xFE,
  0x3F, 0x01, 0xFF, 0xF7, 0xE0, 0x3F, 0xFF, 0x7E, 0x07, 0xFF, 0xFF, 0xE0,
  0xFF, 0xCF, 0xFE, 0x0F, 0xF0, 0x3F, 0xE1, 0xFE, 0x03, 0xFC, 0x1F, 0xC0,
  0x3F, 0xC3, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x1F, 0xC3, 0xF8, 0x01, 0xFC,
  0x7F, 0x80, 0x1F, 0x87, 0xF0, 0x03, 0xF8, 0x7F, 0x00, 0x3F, 0x87, 0xF0,
  0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7F,
  0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0xFF, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE,
  0x01, 0xFE, 0x0F, 0xE0, 0x3F, 0xE0, 0xFF, 0x03, 0xFE, 0x07, 0xF8, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xEF, 0xC0, 0x3F, 0xFC, 0xFC, 0x01,
  0xFF, 0x8F, 0xC0, 0x0F, 0xF0, 0xFC, 0x00, 0x10, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0xFF, 0x00, 0x3F, 0x9F, 0xF8, 0x03,
  0xF7, 0xFF, 0xC0, 0x7F, 0x7F, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xE1,
  0xFE, 0x07, 0xFC, 0x0F, 0xE0, 0x7F, 0x80, 0xFE, 0x0F, 0xF0, 0x0F, 0xE0,
  0xFF, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xE0, 0xFE, 0x00, 0x7E, 0x0F, 0xC0,
  0x0F, 0xE1, 0xFC, 0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xE1, 0xF8, 0x00, 0xFE,
  0x1F, 0x80, 0x0F, 0xE1, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x1F, 0xC3, 0xF8,
  0x01, 0xFC, 0x3F, 0x80, 0x3F, 0xC3, 0xF8, 0x03, 0xF8, 0x7F, 0x80, 0x7F,
  0x87, 0xF8, 0x07, 0xF0, 0x7F, 0xC0, 0xFF, 0x07, 0xFE, 0x1F, 0xE0, 0x7F,
  0xFF, 0xFC, 0x0F, 0xDF, 0xFF, 0xC0, 0xFD, 0xFF, 0xF8, 0x0F, 0xCF, 0xFF,
  0x00, 0xF8, 0x3F, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC1, 0xFF,
  0x87, 0x03, 0xFC, 0x02, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x40, 0xFF, 0x87, 0x81, 0xFF,
  0xFF, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x01, 0xFF,
  0xC0, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x3F, 0x87, 0xF0, 0x03, 0xFF, 0x9F, 0xC0, 0x1F, 0xFF, 0x7E,
  0x00, 0xFF, 0xFD, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xE3, 0xFF, 0x80,
  0xFF, 0x03, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x1F, 0xC0, 0xFF,
  0x00, 0x7F, 0x03, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xE0, 0x7F, 0x00,
  0x1F, 0x81, 0xFC, 0x00, 0xFE, 0x07, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x0F,
  0xE0, 0xFE, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0xFC, 0x0F, 0xE0, 0x07, 0xF0,
  0x3F, 0x80, 0x1F, 0xC0, 0xFE, 0x00, 0xFF, 0x03, 0xF8, 0x03, 0xF8, 0x0F,
  0xE0, 0x1F, 0xE0, 0x3F, 0x80, 0x7F, 0x80, 0xFF, 0x03, 0xFE, 0x03, 0xFE,
  0x3F, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFE,
  0xFC, 0x00, 0x7F, 0xE3, 0xF0, 0x00, 0xFF, 0x0F, 0x80, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x7F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xC1, 0xF8, 0x3F, 0x80, 0xFE, 0x3F,
  0x80, 0x7F, 0x1F, 0xC0, 0x3F, 0x1F, 0xC0, 0x1F, 0x8F, 0xE0, 0x1F, 0xC7,
  0xE0, 0x1F, 0xE7, 0xF0, 0x3F, 0xE3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x10, 0x3F, 0xC0, 0x38, 0x1F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xC2, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x04, 0x3F,
  0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0xFC, 0x00, 0xFF, 0xE3, 0xF0, 0x07, 0xFF,
  0xDF, 0x80, 0x3F, 0xFF, 0x7E, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFC, 0xFF,
  0xE0, 0x3F, 0xC0, 0xFF, 0x81, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x07, 0xF0,
  0x3F, 0xC0, 0x1F, 0xC0, 0xFE, 0x00, 0x7F, 0x03, 0xF8, 0x01, 0xFC, 0x1F,
  0xE0, 0x0F, 0xE0, 0x7F, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0xFE, 0x07, 0xF0,
  0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xC0, 0xFE, 0x00, 0x7F, 0x03, 0xF8, 0x01,
  0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0x80, 0x3F, 0xC0, 0xFE, 0x00, 0xFE,
  0x03, 0xF8, 0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0xE0, 0x3F, 0xC1, 0xFF, 0x80,
  0xFF, 0x8F, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xEF, 0xC0, 0x0F,
  0xFF, 0x7F, 0x00, 0x3F, 0xF9, 0xFC, 0x00, 0x3F, 0xC7, 0xE0, 0x00, 0x10,
  0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x03, 0x00, 0x0F, 0xE0,
  0x0F, 0x80, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x8F, 0xF0, 0x07,
  0xF3, 0xFF, 0x00, 0xFD, 0xFF, 0xF0, 0x3F, 0xBF, 0xFF, 0x07, 0xFF, 0xFF,
  0xE0, 0xFF, 0xE3, 0xFC, 0x1F, 0xF0, 0x3F, 0x83, 0xFC, 0x07, 0xF0, 0xFF,
  0x80, 0xFE, 0x1F, 0xE0, 0x1F, 0xC3, 0xF8, 0x03, 0xF8, 0x7F, 0x00, 0x7F,
  0x0F, 0xE0, 0x0F, 0xE3, 0xF8, 0x01, 0xF8, 0x7F, 0x00, 0x7F, 0x0F, 0xE0,
  0x0F, 0xE1, 0xFC, 0x01, 0xFC, 0x3F, 0x00, 0x3F, 0x8F, 0xE0, 0x07, 0xE1,
  0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x87, 0xE0, 0x07, 0xF1, 0xFC, 0x00,
  0xFC, 0x3F, 0x80, 0x3F, 0x87, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x1F,
  0x80, 0x1F, 0xC7, 0xF0, 0x03, 0xF0, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x1F,
  0xC3, 0xF8, 0x03, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0xFE, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x02, 0x3F, 0xE0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFC,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x38, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x7F, 0x81, 0xFC, 0x03,
  0xF8, 0x0F, 0xC0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x3F, 0x80,
  0x3F, 0x83, 0xF8, 0x01, 0xFC, 0x3F, 0xC0, 0x0F, 0xC3, 0xFC, 0x00, 0xFE,
  0x3F, 0xC0, 0x07, 0xF1, 0xFC, 0x00, 0x3F, 0x9F, 0xC0, 0x01, 0xF9, 0xFC,
  0x00, 0x0F, 0xDF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0xBF, 0x80, 0x07, 0xF9, 0xFC, 0x00, 0x3F, 0x87, 0xF0, 0x01, 0xF8, 0x3F,
  0x80, 0x1F, 0xC1, 0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x07, 0xF0, 0x3F, 0x80,
  0x3F, 0x81, 0xFE, 0x01, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0xFE,
  0x01, 0xFE, 0x07, 0xF0, 0x07, 0xF0, 0x3F, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xFC,
  0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF8,
  0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x80,
  0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0x03, 0xF0, 0xFF, 0x01, 0xFE, 0x00, 0xF8, 0xFF, 0xE0, 0xFF, 0xE0, 0x3E,
  0x7F, 0xFC, 0x7F, 0xF8, 0x0F, 0xBF, 0xFF, 0x3F, 0xFF, 0x07, 0xEF, 0xFF,
  0xDF, 0xFF, 0xC1, 0xFF, 0xC7, 0xFF, 0x8F, 0xF0, 0x7F, 0xC0, 0xFF, 0xC1,
  0xFC, 0x1F, 0xE0, 0x3F, 0xE0, 0x3F, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xC3,
  0xFC, 0x03, 0xFC, 0x03, 0xF0, 0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x3F, 0x80,
  0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC7, 0xF0, 0x07, 0xF0,
  0x07, 0xF1, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x7F, 0x00, 0x7E, 0x00, 0xFE,
  0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x87, 0xE0, 0x0F, 0xE0, 0x0F, 0xE3, 0xF8,
  0x03, 0xF8, 0x03, 0xF0, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x3F, 0x80, 0x3F,
  0x00, 0x7F, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC7, 0xF0, 0x07, 0xF0, 0x07,
  0xF1, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x1F,
  0xC0, 0x1F, 0x80, 0x3F, 0x87, 0xE0, 0x0F, 0xE0, 0x0F, 0xE3, 0xF8, 0x03,
  0xF8, 0x03, 0xF8, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x3F, 0x80, 0x3F, 0x00,
  0x7F, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x7C,
  0x1F, 0xE0, 0x0F, 0x87, 0xFE, 0x01, 0xF3, 0xFF, 0xE0, 0x7E, 0xFF, 0xFE,
  0x0F, 0xDF, 0xFF, 0xC1, 0xFF, 0xE7, 0xF8, 0x3F, 0xE0, 0x7F, 0x07, 0xF8,
  0x0F, 0xE1, 0xFF, 0x01, 0xFC, 0x3F, 0xC0, 0x3F, 0x87, 0xF8, 0x07, 0xF0,
  0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xC7, 0xF0, 0x03, 0xF0, 0xFE, 0x00,
  0xFE, 0x1F, 0xC0, 0x1F, 0xC3, 0xF8, 0x03, 0xF8, 0xFE, 0x00, 0x7F, 0x1F,
  0xC0, 0x0F, 0xC3, 0xF8, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x0F, 0xC0, 0x0F,
  0xE3, 0xF8, 0x01, 0xF8, 0x7F, 0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xE1, 0xFC,
  0x01, 0xFC, 0x3F, 0x00, 0x3F, 0x8F, 0xE0, 0x07, 0xE1, 0xFC, 0x01, 0xFC,
  0x3F, 0x80, 0x3F, 0x87, 0xF0, 0x07, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F,
  0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x03,
  0xFE, 0x3F, 0xE0, 0xFF, 0x03, 0xF8, 0x7F, 0x80, 0xFE, 0x1F, 0xC0, 0x1F,
  0xCF, 0xE0, 0x07, 0xF3, 0xF8, 0x01, 0xFD, 0xFC, 0x00, 0x7F, 0x7F, 0x00,
  0x1F, 0xDF, 0xC0, 0x07, 0xF7, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFE, 0xFE,
  0x00, 0x3F, 0xBF, 0x80, 0x0F, 0xEF, 0xE0, 0x03, 0xFB, 0xF8, 0x01, 0xFE,
  0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xCF, 0xE0, 0x0F, 0xE3, 0xF8, 0x07,
  0xF8, 0x7F, 0x03, 0xFC, 0x1F, 0xE1, 0xFF, 0x07, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x7E, 0x1F, 0xE0, 0x00, 0xF8, 0xFF, 0xE0, 0x01,
  0xF3, 0xFF, 0xE0, 0x03, 0xEF, 0xFF, 0xC0, 0x0F, 0xDF, 0xFF, 0xC0, 0x1F,
  0xF8, 0x7F, 0x80, 0x3F, 0xE0, 0x7F, 0x00, 0x7F, 0x80, 0xFE, 0x01, 0xFE,
  0x01, 0xFC, 0x03, 0xFC, 0x01, 0xFC, 0x07, 0xF0, 0x03, 0xF0, 0x0F, 0xE0,
  0x07, 0xE0, 0x1F, 0x80, 0x1F, 0xC0, 0x7F, 0x00, 0x3F, 0x80, 0xFE, 0x00,
  0x7F, 0x01, 0xFC, 0x00, 0xFE, 0x03, 0xF0, 0x01, 0xFC, 0x07, 0xE0, 0x07,
  0xF8, 0x1F, 0xC0, 0x0F, 0xE0, 0x3F, 0x80, 0x1F, 0xC0, 0x7F, 0x00, 0x7F,
  0x80, 0xFE, 0x00, 0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x07, 0xF0,
  0x0F, 0xF8, 0x1F, 0xE0, 0x1F, 0xF8, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFC, 0x01, 0xFD, 0xFF, 0xF0, 0x03, 0xF9, 0xFF, 0xC0, 0x07,
  0xE1, 0xFE, 0x00, 0x0F, 0xC0, 0x40, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xC3, 0xF0, 0x0F, 0xFE, 0x3F, 0x01, 0xFF, 0xF3, 0xE0, 0x3F, 0xFF, 0x7E,
  0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0x8F, 0xFE, 0x0F, 0xF0, 0x3F, 0xE1, 0xFE,
  0x03, 0xFC, 0x1F, 0xC0, 0x1F, 0xC3, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x1F,
  0xC3, 0xF8, 0x01, 0xF8, 0x7F, 0x00, 0x1F, 0x87, 0xF0, 0x03, 0xF8, 0x7F,
  0x00, 0x3F, 0x87, 0xF0, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x0F, 0xE0, 0x03,
  0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0xFF, 0x0F,
  0xE0, 0x0F, 0xE0, 0xFE, 0x01, 0xFE, 0x0F, 0xE0, 0x1F, 0xE0, 0xFF, 0x03,
  0xFE, 0x0F, 0xF8, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xEF, 0xC0,
  0x3F, 0xFD, 0xFC, 0x01, 0xFF, 0x9F, 0xC0, 0x0F, 0xF1, 0xF8, 0x00, 0x30,
  0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0xFE, 0x07, 0xE7, 0xF8, 0x0F, 0x9F, 0xF0, 0x1F, 0x3F, 0xE0,
  0x7E, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xC2, 0x03, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFE, 0x07, 0x83,
  0xF8, 0x02, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0xC0, 0x0F, 0xF1, 0xE0, 0x3F, 0xC3, 0xFF, 0xFF, 0x87,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x00,
  0x40, 0x00, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03,
  0xF8, 0x00, 0xFE, 0x08, 0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0x7F,
  0xF8, 0x0F, 0xFC, 0x00, 0x20, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x7E, 0x00,
  0x7F, 0x0F, 0xE0, 0x07, 0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0,
  0xFE, 0x00, 0xFE, 0x0F, 0xC0, 0x0F, 0xE1, 0xFC, 0x00, 0xFC, 0x1F, 0xC0,
  0x1F, 0xC1, 0xFC, 0x01, 0xFC, 0x1F, 0xC0, 0x1F, 0xC1, 0xF8, 0x01, 0xF8,
  0x3F, 0x80, 0x1F, 0x83, 0xF8, 0x03, 0xF8, 0x3F, 0x80, 0x3F, 0x83, 0xF0,
  0x03, 0xF8, 0x3F, 0x00, 0x3F, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x7F,
  0x07, 0xF0, 0x07, 0xF0, 0x7E, 0x00, 0xFF, 0x07, 0xE0, 0x0F, 0xE0, 0xFE,
  0x01, 0xFE, 0x0F, 0xE0, 0x3F, 0xE0, 0xFF, 0x07, 0xFE, 0x07, 0xF0, 0xFF,
  0xE0, 0x7F, 0xFF, 0x7C, 0x07, 0xFF, 0xEF, 0xC0, 0x7F, 0xFC, 0xFC, 0x03,
  0xFF, 0x8F, 0xC0, 0x1F, 0xF0, 0xF8, 0x00, 0x10, 0x00, 0x00, 0xFE, 0x00,
  0x3F, 0xFF, 0x80, 0x0F, 0xEF, 0xE0, 0x07, 0xFB, 0xF8, 0x01, 0xFC, 0xFE,
  0x00, 0x7F, 0x3F, 0x80, 0x3F, 0x87, 0xE0, 0x0F, 0xE1, 0xF8, 0x07, 0xF0,
  0x7E, 0x01, 0xFC, 0x1F, 0x80, 0xFE, 0x07, 0xE0, 0x3F, 0x81, 0xF8, 0x1F,
  0xC0, 0x7E, 0x07, 0xF0, 0x1F, 0x83, 0xF8, 0x07, 0xE0, 0xFC, 0x01, 0xF8,
  0x7F, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0xCF, 0xE0, 0x03, 0xF3, 0xF0, 0x00,
  0xFD, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xDF, 0x80, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x7E, 0x01, 0xFE, 0x00,
  0xFE, 0x7E, 0x01, 0xFE, 0x00, 0xFC, 0x7E, 0x01, 0xFE, 0x01, 0xFC, 0x7E,
  0x03, 0xFE, 0x01, 0xFC, 0x7E, 0x03, 0xFE, 0x03, 0xF8, 0x7E, 0x07, 0xFE,
  0x03, 0xF8, 0x7E, 0x07, 0xFE, 0x03, 0xF0, 0x7E, 0x07, 0xFE, 0x07, 0xF0,
  0x7E, 0x0F, 0xBE, 0x07, 0xE0, 0x7E, 0x0F, 0xBE, 0x0F, 0xE0, 0x7E, 0x1F,
  0xBE, 0x0F, 0xC0, 0x7E, 0x1F, 0x3E, 0x1F, 0xC0, 0x7E, 0x3F, 0x3E, 0x1F,
  0xC0, 0x7E, 0x3E, 0x3E, 0x1F, 0x80, 0x7E, 0x3E, 0x3E, 0x3F, 0x80, 0x7E,
  0x7E, 0x3E, 0x3F, 0x00, 0x7E, 0x7C, 0x3E, 0x7F, 0x00, 0x7E, 0xFC, 0x3E,
  0x7E, 0x00, 0x7E, 0xF8, 0x3E, 0x7E, 0x00, 0x7E, 0xF8, 0x3E, 0xFC, 0x00,
  0x7F, 0xF8, 0x3E, 0xFC, 0x00, 0x7F, 0xF0, 0x3E, 0xFC, 0x00, 0x7F, 0xF0,
  0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x3F, 0xF0,
  0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0x7F,
  0xC0, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0xFE,
  0x01, 0xFC, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x7F,
  0x0F, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x3F,
  0xBF, 0xC0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x03, 0xF8,
  0xFE, 0x00, 0x07, 0xF8, 0x7E, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xE0,
  0x7F, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0xC0, 0x3F, 0x80, 0x7F, 0x80,
  0x3F, 0x80, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x3F,
  0x80, 0x0F, 0xE0, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x00,
  0x7E, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0x07, 0xE0, 0x0F, 0xE0,
  0x01, 0xF8, 0x07, 0xF0, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0xFE,
  0x00, 0x07, 0xF0, 0x3F, 0x80, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x7F, 0x07,
  0xF0, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x00, 0xFC,
  0x7F, 0x00, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x03,
  0xF3, 0xF8, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x3F, 0x7F, 0x00, 0x00,
  0x0F, 0xDF, 0x80, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x0F, 0xFE,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x38, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xC0, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x03,
  0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x5F, 0xFF,
  0x00, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xEC, 0x00, 0xFF, 0xF2, 0x00, 0x07, 0xF8,
};

const GFXglyph NotoSans_SemiCondensed_SemiBoldItalic57pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 16, 42, 15, 1, -41 },
  { 85, 19, 15, 23, 6, -41 },
  { 121, 33, 41, 33, 1, -41 },
  { 291, 28, 46, 29, 1, -43 },
  { 452, 39, 42, 44, 3, -41 },
  { 657, 33, 42, 35, 1, -41 },
  { 831, 9, 15, 13, 6, -41 },
  { 848, 19, 50, 17, 2, -41 },
  { 967, 19, 50, 17, -4, -41 },
  { 1086, 24, 26, 28, 5, -44 },
  { 1164, 26, 28, 30, 3, -34 },
  { 1255, 13, 14, 15, -3, -7 },
  { 1278, 15, 6, 17, 1, -18 },
  { 1290, 8, 9, 15, 1, -8 },
  { 1299, 29, 41, 22, -3, -41 },
  { 1448, 26, 42, 29, 2, -41 },
  { 1585, 19, 41, 29, 6, -41 },
  { 1683, 29, 41, 29, -1, -41 },
  { 1832, 28, 42, 29, 0, -41 },
  { 1979, 29, 41, 29, -1, -41 },
  { 2128, 28, 42, 29, 1, -41 },
  { 2275, 27, 42, 29, 2, -41 },
  { 2417, 28, 41, 29, 3, -41 },
  { 2561, 28, 42, 29, 1, -41 },
  { 2708, 26, 42, 29, 2, -41 },
  { 2845, 14, 32, 15, 0, -31 },
  { 2901, 17, 38, 15, -3, -31 },
  { 2982, 26, 29, 30, 3, -35 },
  { 3077, 25, 16, 30, 3, -28 },
  { 3127, 26, 29, 30, 3, -35 },
  { 3222, 22, 42, 23, 3, -41 },
  { 3338, 41, 46, 44, 2, -41 },
  { 3574, 31, 41, 31, -3, -41 },
  { 3733, 31, 41, 32, 1, -41 },
  { 3892, 30, 42, 31, 3, -41 },
  { 4050, 32, 41, 35, 1, -41 },
  { 4214, 29, 41, 27, 1, -41 },
  { 4363, 29, 41, 26, 1, -41 },
  { 4512, 33, 42, 35, 3, -41 },
  { 4686, 36, 41, 36, 1, -41 },
  { 4871, 25, 41, 19, -2, -41 },
  { 5000, 26, 53, 16, -9, -41 },
  { 5173, 35, 41, 31, 1, -41 },
  { 5353, 21, 41, 26, 1, -41 },
  { 5461, 45, 41, 45, 1, -41 },
  { 5692, 38, 41, 38, 1, -41 },
  { 5887, 33, 42, 37, 3, -41 },
  { 6061, 30, 41, 31, 1, -41 },
  { 6215, 33, 51, 37, 3, -41 },
  { 6426, 30, 41, 31, 1, -41 },
  { 6580, 29, 42, 27, 0, -41 },
  { 6733, 26, 41, 27, 5, -41 },
  { 6867, 33, 42, 35, 3, -41 },
  { 7041, 30, 41, 30, 5, -41 },
  { 7195, 46, 41, 46, 5, -41 },
  { 7431, 37, 41, 30, -3, -41 },
  { 7621, 28, 41, 28, 5, -41 },
  { 7765, 32, 41, 27, -2, -41 },
  { 7929, 22, 50, 17, -1, -41 },
  { 8067, 12, 41, 22, 6, -41 },
  { 8129, 23, 50, 17, -4, -41 },
  { 8273, 27, 25, 29, 1, -41 },
  { 8358, 22, 4, 21, -5, 5 },
  { 8369, 11, 9, 17, 8, -44 },
  { 8382, 28, 32, 30, 2, -31 },
  { 8494, 28, 44, 31, 1, -43 },
  { 8648, 23, 32, 24, 2, -31 },
  { 8740, 30, 44, 31, 2, -43 },
  { 8905, 25, 32, 28, 2, -31 },
  { 9005, 31, 58, 18, -6, -44 },
  { 9230, 30, 45, 31, 0, -31 },
  { 9399, 27, 43, 31, 1, -43 },
  { 9545, 15, 43, 15, 1, -43 },
  { 9626, 23, 57, 15, -7, -43 },
  { 9790, 29, 43, 28, 1, -43 },
  { 9946, 16, 43, 15, 1, -43 },
  { 10032, 42, 31, 46, 1, -31 },
  { 10195, 27, 32, 31, 1, -32 },
  { 10303, 26, 32, 30, 2, -31 },
  { 10407, 31, 45, 31, -2, -31 },
  { 10582, 28, 45, 31, 2, -31 },
  { 10740, 23, 31, 21, 1, -31 },
  { 10830, 23, 32, 24, 0, -31 },
  { 10922, 18, 39, 19, 3, -38 },
  { 11010, 28, 32, 31, 2, -31 },
  { 11122, 26, 31, 26, 3, -31 },
  { 11223, 40, 31, 40, 3, -31 },
  { 11378, 32, 31, 27, -3, -31 },
  { 11502, 34, 45, 26, -5, -31 },
  { 11694, 25, 31, 23, -1, -31 },
  { 11791, 23, 50, 20, 0, -41 },
  { 11935, 6, 56, 28, 11, -43 },
  { 11977, 22, 50, 20, -3, -41 },
  { 12115, 26, 8, 30, 3, -24 },
};

const GFXfont NotoSans_SemiCondensed_SemiBoldItalic57pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_SemiBoldItalic57pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_SemiBoldItalic57pt7bGlyphs,
  0x20, 0x7E, 78
};

#endif // _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC57PT7B_H_
