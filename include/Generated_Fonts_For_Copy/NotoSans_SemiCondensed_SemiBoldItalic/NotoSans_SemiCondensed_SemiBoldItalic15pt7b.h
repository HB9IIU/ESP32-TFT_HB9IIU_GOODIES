#ifndef _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC15PT7B_H_
#define _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC15PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-SemiBoldItalic.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_SemiBoldItalic15pt7bBitmaps[] PROGMEM = {
  0x00, 0x33, 0x33, 0x26, 0x66, 0x0C, 0xC0, 0x6D, 0x25, 0xB6, 0x09, 0x04,
  0x86, 0xCF, 0xF7, 0xF9, 0xB0, 0xD1, 0xFE, 0x2C, 0x34, 0x12, 0x00, 0x04,
  0x1F, 0x3A, 0x68, 0x38, 0x3C, 0x1E, 0x16, 0x94, 0xFC, 0x20, 0x20, 0x30,
  0x94, 0x4D, 0xB2, 0x48, 0x94, 0xBF, 0xF6, 0xA4, 0x49, 0x36, 0xC9, 0xA4,
  0x38, 0x0E, 0x0F, 0x0C, 0x86, 0xC1, 0xC1, 0xC1, 0xB7, 0x9E, 0xC6, 0x77,
  0x1E, 0xC0, 0xFA, 0x0C, 0x63, 0x08, 0x61, 0x84, 0x10, 0xC3, 0x04, 0x10,
  0x60, 0x10, 0xC6, 0x31, 0x8C, 0x63, 0x11, 0x8C, 0xCC, 0x00, 0x18, 0xA3,
  0xF9, 0x96, 0x89, 0x80, 0x30, 0x60, 0xC7, 0xF3, 0x06, 0x0C, 0x00, 0x36,
  0x6C, 0x7F, 0xF0, 0x03, 0x02, 0x06, 0x0C, 0x0C, 0x18, 0x10, 0x30, 0x20,
  0x60, 0xC0, 0x39, 0xF6, 0x71, 0xC7, 0x38, 0xE3, 0x9B, 0x6F, 0x00, 0x1B,
  0xBD, 0x63, 0x18, 0x8C, 0x63, 0x10, 0x1C, 0x7C, 0x98, 0x30, 0x61, 0x86,
  0x18, 0x61, 0xFB, 0xF0, 0x1C, 0x7C, 0x08, 0x30, 0xE7, 0x03, 0x03, 0x05,
  0x3B, 0xE0, 0x06, 0x0C, 0x38, 0xF3, 0x64, 0x93, 0x7F, 0xFE, 0x10, 0x60,
  0x1F, 0x3E, 0x30, 0x20, 0x38, 0x7C, 0x06, 0x06, 0x06, 0xDC, 0xF8, 0x1E,
  0x79, 0x82, 0x0D, 0x9F, 0xB3, 0x46, 0x8D, 0xB3, 0xC0, 0x7F, 0xFC, 0x30,
  0x61, 0x83, 0x0C, 0x18, 0x60, 0x83, 0x00, 0x1E, 0x3E, 0x33, 0x32, 0x3E,
  0x38, 0x6C, 0xC6, 0xC6, 0xEC, 0x7C, 0x1C, 0x7D, 0x9B, 0x16, 0x6D, 0xCF,
  0x83, 0x0D, 0x33, 0xC0, 0x36, 0x00, 0x00, 0xCC, 0x19, 0x80, 0x00, 0x00,
  0x8C, 0x46, 0x00, 0x06, 0x39, 0xC6, 0x0F, 0x03, 0x81, 0x80, 0xFC, 0x0F,
  0xFF, 0x81, 0xC0, 0xE0, 0x71, 0xDE, 0x30, 0x00, 0x7B, 0xE0, 0xC2, 0x18,
  0xC6, 0x10, 0x03, 0x0C, 0x00, 0x0F, 0x0E, 0x66, 0x05, 0x3D, 0xDB, 0x64,
  0x9B, 0x26, 0xDB, 0xBB, 0xA0, 0x0C, 0x01, 0xF8, 0x07, 0x07, 0x0F, 0x0B,
  0x1B, 0x1B, 0x33, 0x3F, 0x63, 0x63, 0xC3, 0x1E, 0x3F, 0x33, 0x33, 0x27,
  0x7C, 0x66, 0x63, 0x66, 0x7E, 0xFC, 0x1E, 0x3F, 0x60, 0x60, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xEC, 0x7C, 0x1C, 0x1F, 0x8C, 0xE6, 0x33, 0x1B, 0x0D,
  0x84, 0xC6, 0x67, 0x3F, 0x3E, 0x00, 0x1F, 0x3F, 0x30, 0x30, 0x32, 0x7C,
  0x60, 0x60, 0x60, 0x7C, 0xFC, 0x1F, 0x3F, 0x30, 0x30, 0x30, 0x7E, 0x7C,
  0x60, 0x60, 0x40, 0xC0, 0x0F, 0x3F, 0x60, 0x60, 0xC0, 0xCF, 0xCE, 0xC6,
  0xC6, 0xEE, 0x7E, 0x10, 0xCC, 0x23, 0x18, 0xC6, 0x31, 0x9F, 0xE6, 0x31,
  0x8C, 0x63, 0x10, 0xCC, 0x60, 0x1E, 0x38, 0x20, 0xC1, 0x83, 0x04, 0x18,
  0x30, 0x63, 0xE0, 0x04, 0x30, 0xC3, 0x0C, 0x21, 0x86, 0x18, 0x63, 0x0C,
  0xF3, 0x80, 0x11, 0x99, 0x8C, 0xC6, 0xC2, 0xC3, 0xC1, 0xF0, 0xD8, 0x6C,
  0x23, 0x31, 0x80, 0x10, 0xC3, 0x0C, 0x21, 0x86, 0x18, 0x61, 0xFF, 0xC0,
  0x18, 0x73, 0x87, 0x38, 0xF2, 0x8E, 0x29, 0xA6, 0x9E, 0x69, 0x66, 0xB6,
  0x4E, 0x44, 0xEC, 0xCC, 0xC0, 0x18, 0xCE, 0x33, 0x8C, 0xB3, 0x2C, 0x9B,
  0x66, 0x59, 0x9E, 0x47, 0x11, 0xCC, 0x30, 0x1E, 0x3F, 0x63, 0x61, 0xC1,
  0xC3, 0xC3, 0xC3, 0xC6, 0xEE, 0x7C, 0x1E, 0x3F, 0x33, 0x33, 0x23, 0x7F,
  0x7C, 0x60, 0x60, 0x40, 0xC0, 0x1E, 0x3F, 0x63, 0x61, 0xC1, 0xC3, 0xC3,
  0xC3, 0xC6, 0xEE, 0x7C, 0x0C, 0x0C, 0x0E, 0x1C, 0x3F, 0x33, 0x33, 0x23,
  0x7E, 0x7C, 0x6C, 0x64, 0x46, 0xC6, 0x1F, 0x3E, 0x20, 0x60, 0x30, 0x38,
  0x0C, 0x0C, 0x0C, 0xDC, 0xF8, 0x7F, 0xFC, 0xC1, 0x83, 0x06, 0x08, 0x30,
  0x60, 0xC1, 0x80, 0x61, 0xB1, 0x98, 0xCC, 0x64, 0x36, 0x13, 0x19, 0x8C,
  0xC6, 0x76, 0x1E, 0x00, 0xC3, 0xC3, 0xC6, 0x46, 0x4C, 0x4C, 0x58, 0x58,
  0x50, 0x70, 0x60, 0xC2, 0x1C, 0x63, 0xC6, 0x2C, 0xE6, 0xCA, 0x6D, 0xAC,
  0xD2, 0xCD, 0x28, 0x73, 0x86, 0x38, 0x63, 0x00, 0x18, 0xC6, 0x61, 0xB0,
  0x2C, 0x0E, 0x03, 0x01, 0xE0, 0x78, 0x36, 0x18, 0x8C, 0x30, 0xC3, 0x46,
  0x6C, 0x6C, 0x78, 0x70, 0x30, 0x20, 0x60, 0x60, 0x60, 0x3F, 0x3F, 0x06,
  0x0C, 0x0C, 0x18, 0x30, 0x60, 0x60, 0xFC, 0xFC, 0x3C, 0xE3, 0x08, 0x21,
  0x86, 0x18, 0x43, 0x0C, 0x30, 0xE0, 0x92, 0x6D, 0xB2, 0x49, 0x80, 0x1C,
  0xF0, 0x82, 0x18, 0x61, 0x84, 0x10, 0xC3, 0x0C, 0xE0, 0x08, 0x38, 0x71,
  0xA2, 0x6C, 0xF0, 0x80, 0xF8, 0xCC, 0x7E, 0xDF, 0x36, 0x68, 0xD1, 0xB6,
  0x74, 0x30, 0x30, 0x30, 0x2E, 0x36, 0x63, 0x62, 0x66, 0x66, 0x6C, 0xFC,
  0x7D, 0xAC, 0x30, 0x82, 0x0D, 0x3C, 0x03, 0x06, 0x06, 0x7E, 0x6E, 0xCC,
  0xCC, 0x8C, 0x8C, 0xD8, 0xE8, 0x7D, 0xBC, 0xFE, 0xE2, 0x0C, 0xBE, 0x07,
  0x86, 0x03, 0x03, 0xC0, 0xC0, 0x40, 0x60, 0x30, 0x18, 0x0C, 0x04, 0x06,
  0x03, 0x07, 0x01, 0x00, 0x3F, 0x37, 0x66, 0x66, 0x46, 0x46, 0x6C, 0x74,
  0x0C, 0x0C, 0xF8, 0x60, 0x30, 0x60, 0xC1, 0x73, 0x6C, 0x59, 0xB3, 0x46,
  0x8F, 0x30, 0x33, 0x03, 0x26, 0x66, 0x64, 0xC0, 0x0C, 0x30, 0x03, 0x08,
  0x61, 0x86, 0x18, 0x43, 0x0C, 0x33, 0x8C, 0x00, 0x30, 0x30, 0x30, 0x37,
  0x26, 0x6C, 0x78, 0x78, 0x4C, 0x4C, 0xCE, 0x33, 0x33, 0x26, 0x66, 0x4C,
  0xC0, 0x2E, 0xE6, 0xE5, 0x98, 0xB3, 0x36, 0x66, 0x8C, 0xD1, 0x1E, 0x66,
  0x2E, 0x6D, 0x8B, 0x36, 0x68, 0xF1, 0xE6, 0x7D, 0xBC, 0xF3, 0x8E, 0x3D,
  0xBC, 0x17, 0x0D, 0x8C, 0x66, 0x23, 0x31, 0x98, 0xD8, 0xFC, 0x60, 0x30,
  0x10, 0x18, 0x00, 0x7E, 0xDF, 0x36, 0x68, 0xD1, 0xB6, 0x74, 0x18, 0x30,
  0x60, 0x80, 0x2C, 0xF6, 0x18, 0x61, 0x84, 0x30, 0x3D, 0x96, 0x1C, 0x18,
  0x69, 0xBC, 0x23, 0x7C, 0x8C, 0x63, 0x18, 0xD7, 0x00, 0x67, 0x8F, 0x16,
  0x6C, 0xD1, 0xB6, 0x74, 0xCF, 0x9B, 0x66, 0xCF, 0x1E, 0x38, 0x70, 0xCC,
  0xF7, 0x2D, 0x5B, 0xD6, 0xE7, 0x39, 0xCE, 0x63, 0x18, 0x33, 0x8B, 0x07,
  0x83, 0x81, 0xC1, 0xE1, 0x91, 0xCC, 0x33, 0x99, 0x8D, 0x86, 0xC3, 0x41,
  0xE0, 0x60, 0x30, 0x30, 0x18, 0x38, 0x18, 0x00, 0x7C, 0x31, 0x8C, 0x31,
  0x8C, 0x3E, 0x0C, 0x71, 0x04, 0x30, 0xCE, 0x38, 0x61, 0x86, 0x18, 0x70,
  0xFF, 0xFC, 0x10, 0xE0, 0x86, 0x18, 0x60, 0xC7, 0x30, 0xC3, 0x08, 0xE0,
  0xFF, 0x38,
};

const GFXglyph NotoSans_SemiCondensed_SemiBoldItalic15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 4, 11, 4, 0, -11 },
  { 7, 6, 4, 6, 1, -11 },
  { 10, 9, 11, 9, 0, -11 },
  { 23, 8, 12, 8, 0, -11 },
  { 35, 10, 11, 12, 1, -11 },
  { 49, 9, 11, 9, 0, -11 },
  { 62, 2, 4, 4, 2, -11 },
  { 63, 6, 13, 5, 0, -11 },
  { 73, 5, 13, 5, -1, -11 },
  { 82, 7, 6, 7, 1, -11 },
  { 88, 7, 7, 8, 1, -9 },
  { 95, 4, 4, 4, -1, -2 },
  { 97, 4, 2, 5, 0, -5 },
  { 98, 2, 2, 4, 0, -2 },
  { 99, 8, 11, 6, -1, -11 },
  { 110, 6, 11, 8, 1, -11 },
  { 119, 5, 11, 8, 2, -11 },
  { 126, 7, 11, 8, 0, -11 },
  { 136, 7, 11, 8, 0, -11 },
  { 146, 7, 11, 8, 0, -11 },
  { 156, 8, 11, 8, 0, -11 },
  { 167, 7, 11, 8, 1, -11 },
  { 177, 7, 11, 8, 1, -11 },
  { 187, 8, 11, 8, 0, -11 },
  { 198, 7, 11, 8, 0, -11 },
  { 208, 4, 8, 4, 0, -8 },
  { 212, 5, 10, 4, -1, -8 },
  { 219, 7, 7, 8, 1, -9 },
  { 226, 6, 4, 8, 1, -7 },
  { 229, 7, 7, 8, 1, -9 },
  { 236, 6, 11, 6, 1, -11 },
  { 245, 10, 12, 12, 1, -11 },
  { 260, 8, 11, 8, -1, -11 },
  { 271, 8, 11, 8, 0, -11 },
  { 282, 8, 11, 8, 1, -11 },
  { 293, 9, 11, 9, 0, -11 },
  { 306, 8, 11, 7, 0, -11 },
  { 317, 8, 11, 7, 0, -11 },
  { 328, 8, 11, 9, 1, -11 },
  { 339, 10, 11, 9, 0, -11 },
  { 353, 7, 11, 5, -1, -11 },
  { 363, 6, 14, 4, -2, -11 },
  { 374, 9, 11, 8, 0, -11 },
  { 387, 6, 11, 7, 0, -11 },
  { 396, 12, 11, 12, 0, -11 },
  { 413, 10, 11, 10, 0, -11 },
  { 427, 8, 11, 10, 1, -11 },
  { 438, 8, 11, 8, 0, -11 },
  { 449, 8, 14, 10, 1, -11 },
  { 463, 8, 11, 8, 0, -11 },
  { 474, 8, 11, 7, 0, -11 },
  { 485, 7, 11, 7, 1, -11 },
  { 495, 9, 11, 9, 1, -11 },
  { 508, 8, 11, 8, 1, -11 },
  { 519, 12, 11, 12, 1, -11 },
  { 536, 10, 11, 8, -1, -11 },
  { 550, 8, 11, 7, 1, -11 },
  { 561, 8, 11, 7, 0, -11 },
  { 572, 6, 13, 5, 0, -11 },
  { 582, 3, 11, 6, 2, -11 },
  { 587, 6, 13, 5, -1, -11 },
  { 597, 7, 7, 8, 0, -11 },
  { 604, 5, 1, 6, -1, 1 },
  { 605, 3, 2, 4, 2, -11 },
  { 606, 7, 8, 8, 1, -8 },
  { 613, 8, 11, 8, 0, -11 },
  { 624, 6, 8, 6, 1, -8 },
  { 630, 8, 11, 8, 1, -11 },
  { 641, 6, 8, 7, 1, -8 },
  { 647, 9, 15, 5, -2, -11 },
  { 664, 8, 12, 8, 0, -8 },
  { 676, 7, 11, 8, 0, -11 },
  { 686, 4, 11, 4, 0, -11 },
  { 692, 6, 15, 4, -2, -11 },
  { 704, 8, 11, 7, 0, -11 },
  { 715, 4, 11, 4, 0, -11 },
  { 721, 11, 8, 12, 0, -8 },
  { 732, 7, 8, 8, 0, -8 },
  { 739, 6, 8, 8, 1, -8 },
  { 745, 9, 12, 8, -1, -8 },
  { 759, 7, 12, 8, 1, -8 },
  { 770, 6, 8, 6, 0, -8 },
  { 776, 6, 8, 6, 0, -8 },
  { 782, 5, 10, 5, 1, -10 },
  { 789, 7, 8, 8, 1, -8 },
  { 796, 7, 8, 7, 1, -8 },
  { 803, 10, 8, 10, 1, -8 },
  { 813, 9, 8, 7, -1, -8 },
  { 822, 9, 12, 7, -1, -8 },
  { 836, 6, 8, 6, 0, -8 },
  { 842, 6, 13, 5, 0, -11 },
  { 852, 1, 14, 7, 3, -11 },
  { 854, 6, 13, 5, -1, -11 },
  { 864, 7, 2, 8, 1, -6 },
};

const GFXfont NotoSans_SemiCondensed_SemiBoldItalic15pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_SemiBoldItalic15pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_SemiBoldItalic15pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC15PT7B_H_
