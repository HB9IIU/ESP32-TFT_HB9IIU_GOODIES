#ifndef _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC70PT7B_H_
#define _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC70PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-SemiBoldItalic.ttf
// Size: 70pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_SemiBoldItalic70pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07,
  0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x1F,
  0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F,
  0xC0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x07, 0xF0, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x00,
  0xF0, 0x00, 0x00, 0x1F, 0xE1, 0xFF, 0x3F, 0xC1, 0xFE, 0x3F, 0xC1, 0xFE,
  0x3F, 0xC1, 0xFE, 0x3F, 0xC1, 0xFC, 0x3F, 0x83, 0xFC, 0x3F, 0x83, 0xFC,
  0x7F, 0x83, 0xF8, 0x7F, 0x03, 0xF8, 0x7F, 0x03, 0xF8, 0x7F, 0x03, 0xF8,
  0x7F, 0x03, 0xF0, 0x7E, 0x07, 0xF0, 0x7E, 0x07, 0xF0, 0xFE, 0x07, 0xE0,
  0xFC, 0x07, 0xE0, 0xFC, 0x07, 0xE0, 0xFC, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x01, 0xF8, 0x00, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x03, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xF8, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFE, 0xFF, 0x00, 0x7F, 0xC7, 0x83, 0x80, 0x1F, 0xE1, 0xE0, 0x20, 0x0F,
  0xF0, 0xF8, 0x00, 0x03, 0xFC, 0x3C, 0x00, 0x00, 0xFF, 0x0F, 0x00, 0x00,
  0x3F, 0xC3, 0xC0, 0x00, 0x0F, 0xF0, 0xF0, 0x00, 0x03, 0xFE, 0x78, 0x00,
  0x00, 0xFF, 0xDE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x79, 0xFF, 0x00, 0x00, 0x3C, 0x7F, 0xC0,
  0x00, 0x0F, 0x0F, 0xF0, 0x00, 0x03, 0xC3, 0xFC, 0x00, 0x00, 0xF0, 0xFF,
  0x00, 0x00, 0x3C, 0x3F, 0xC2, 0x00, 0x1E, 0x0F, 0xF0, 0x60, 0x07, 0x87,
  0xFC, 0x1E, 0x01, 0xE3, 0xFE, 0x07, 0xF0, 0x7B, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF0, 0x01, 0xFF,
  0xE0, 0x00, 0x0F, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xC0, 0x07, 0xFF,
  0xF8, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0x80, 0x0F, 0xF3,
  0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0xC1,
  0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x81, 0xFC, 0x01, 0xFC, 0x00, 0x3F, 0x81,
  0xFC, 0x01, 0xF8, 0x00, 0x3F, 0x81, 0xFC, 0x03, 0xF8, 0x00, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x00, 0x7F, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x7F, 0x01,
  0xF8, 0x0F, 0xE0, 0x00, 0x7E, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0x7E, 0x03,
  0xF8, 0x1F, 0x80, 0x00, 0xFE, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0xFE, 0x03,
  0xF8, 0x7F, 0x00, 0x00, 0xFE, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0xFE, 0x07,
  0xF0, 0xFE, 0x03, 0xC0, 0xFE, 0x07, 0xF1, 0xFC, 0x1F, 0xF0, 0xFE, 0x07,
  0xE1, 0xF8, 0x7F, 0xF8, 0xFE, 0x0F, 0xE3, 0xF8, 0xFF, 0xFC, 0xFE, 0x1F,
  0xC7, 0xF1, 0xFF, 0xFE, 0x7F, 0x3F, 0xC7, 0xE3, 0xFF, 0xFE, 0x7F, 0xFF,
  0x8F, 0xE3, 0xFC, 0xFE, 0x7F, 0xFF, 0x1F, 0xC7, 0xF0, 0x7E, 0x3F, 0xFF,
  0x1F, 0xC7, 0xF0, 0x7F, 0x1F, 0xFE, 0x3F, 0x8F, 0xE0, 0x7F, 0x0F, 0xF8,
  0x7F, 0x0F, 0xE0, 0x7F, 0x03, 0xC0, 0x7F, 0x0F, 0xC0, 0x7F, 0x00, 0x00,
  0xFE, 0x1F, 0xC0, 0x7F, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x7E, 0x00, 0x01,
  0xFC, 0x1F, 0xC0, 0x7E, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0xFE, 0x00, 0x07,
  0xF0, 0x3F, 0x80, 0xFE, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x00, 0x0F,
  0xE0, 0x3F, 0x80, 0xFC, 0x00, 0x1F, 0xC0, 0x3F, 0x81, 0xFC, 0x00, 0x1F,
  0xC0, 0x3F, 0x81, 0xFC, 0x00, 0x3F, 0x80, 0x3F, 0x81, 0xFC, 0x00, 0x7F,
  0x00, 0x3F, 0x83, 0xF8, 0x00, 0x7F, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x87, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0xCF, 0xF0, 0x01, 0xFC,
  0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xF0,
  0x00, 0x0F, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x07, 0xF0, 0x00,
  0x03, 0xFC, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x00, 0x3F, 0xC1, 0xFF,
  0x00, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x00, 0x0F, 0xF1, 0xFF, 0x00, 0x00,
  0x03, 0xFD, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x1F, 0xE0, 0x7F, 0xFF, 0xE0, 0x1F, 0xF0, 0x7F, 0xFF,
  0xF0, 0x0F, 0xF0, 0x7F, 0xE7, 0xFC, 0x0F, 0xF8, 0x7F, 0xE3, 0xFE, 0x07,
  0xF8, 0x3F, 0xE0, 0xFF, 0x87, 0xFC, 0x3F, 0xE0, 0x7F, 0xE3, 0xFC, 0x1F,
  0xE0, 0x1F, 0xF3, 0xFE, 0x1F, 0xF0, 0x07, 0xFD, 0xFE, 0x0F, 0xF0, 0x03,
  0xFF, 0xFE, 0x07, 0xF8, 0x00, 0xFF, 0xFF, 0x07, 0xFC, 0x00, 0x7F, 0xFF,
  0x03, 0xFE, 0x00, 0x1F, 0xFF, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0xFF,
  0x80, 0x03, 0xFF, 0x80, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x01,
  0xFF, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x9F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0x7F, 0xE0, 0x0F, 0xFF, 0xFF, 0x1F, 0xF0, 0x03, 0xFF, 0xFE,
  0x0F, 0xFC, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x1F, 0xE7, 0xFC, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x0F, 0xE1, 0xFC,
  0x7F, 0x8F, 0xE1, 0xFC, 0x3F, 0x87, 0xE0, 0xFC, 0x1F, 0x87, 0xF0, 0xFC,
  0x1F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x0F, 0xD0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x0C, 0x01, 0xFC, 0x00, 0x3C, 0x07, 0xF0, 0x00, 0xFC, 0x1F, 0x80,
  0x07, 0xFC, 0x7E, 0x00, 0x1F, 0xFD, 0xF8, 0x00, 0x7F, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFE, 0x0F, 0xC0, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xE7, 0xE0, 0x00, 0xFF, 0x9F,
  0x80, 0x07, 0xFC, 0x7F, 0x00, 0x3F, 0xE1, 0xFC, 0x00, 0x7F, 0x83, 0xF8,
  0x00, 0xFC, 0x0F, 0xE0, 0x01, 0xE0, 0x3F, 0xC0, 0x03, 0x00, 0x7F, 0x00,
  0x04, 0x01, 0xF8, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFE, 0x07, 0xF8,
  0x1F, 0xF0, 0x3F, 0xC0, 0x7F, 0x81, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x1F,
  0xE0, 0x3F, 0xC0, 0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0,
  0x7F, 0x00, 0xFE, 0x00, 0x3F, 0xFF, 0xE7, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F,
  0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xFF, 0xE7, 0xFF, 0xFC, 0x0F,
  0x0F, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0x9F, 0xC3,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80,
  0x3F, 0xC0, 0x7F, 0xC0, 0x1F, 0xE0, 0x7F, 0xC0, 0x0F, 0xF0, 0x3F, 0xE0,
  0x07, 0xFC, 0x1F, 0xE0, 0x03, 0xFE, 0x1F, 0xF0, 0x01, 0xFF, 0x0F, 0xF0,
  0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x3F, 0xC3, 0xFC,
  0x00, 0x1F, 0xE3, 0xFE, 0x00, 0x0F, 0xF1, 0xFF, 0x00, 0x07, 0xF8, 0xFF,
  0x80, 0x03, 0xFC, 0x7F, 0x80, 0x01, 0xFE, 0x3F, 0xC0, 0x01, 0xFF, 0x3F,
  0xE0, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x3F, 0xC7,
  0xF8, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x1F, 0xF1, 0xFE, 0x00, 0x0F, 0xF8,
  0xFF, 0x00, 0x07, 0xF8, 0xFF, 0x80, 0x03, 0xFC, 0x7F, 0xC0, 0x03, 0xFE,
  0x3F, 0xE0, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0xFF,
  0x87, 0xFC, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x3F,
  0xE0, 0x7F, 0x80, 0x3F, 0xE0, 0x3F, 0xC0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x0F, 0xF8, 0x1F, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFE,
  0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x3F, 0xFB, 0xFC,
  0xFF, 0xF3, 0xFC, 0x7F, 0xE7, 0xF8, 0x3F, 0xC7, 0xF8, 0x3F, 0x07, 0xF8,
  0x1E, 0x0F, 0xF8, 0x08, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xE0,
  0x3F, 0xF0, 0x01, 0xF8, 0x01, 0xFF, 0x00, 0x0E, 0x00, 0x1F, 0xF0, 0x00,
  0xC0, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xBF, 0xFE, 0x00, 0x3E,
  0x00, 0xFF, 0xC0, 0x07, 0x00, 0x0F, 0xF8, 0x00, 0x40, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x10, 0x00,
  0x01, 0xFF, 0x83, 0x00, 0x00, 0x7F, 0xE0, 0x7C, 0x00, 0x3F, 0xFC, 0x0F,
  0xFC, 0x3F, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xBF,
  0x80, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0x0F,
  0xF7, 0xF8, 0x00, 0x00, 0xFE, 0x7F, 0x80, 0x00, 0x1F, 0xCF, 0xF0, 0x00,
  0x03, 0xF8, 0xFF, 0x00, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x07, 0xF0, 0xFF,
  0x00, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x03, 0xFC,
  0x1F, 0xE0, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x07, 0xF0, 0x1F, 0xE0, 0x00,
  0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x03, 0xFC, 0x03, 0xFC,
  0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x3F,
  0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0x88, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x18,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x80, 0x00,
  0x1F, 0xF8, 0x30, 0x00, 0x0F, 0xFC, 0x0F, 0x80, 0x0F, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xA0, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x1E, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x01, 0xFE, 0x3F, 0xF8, 0x01,
  0xFE, 0x7F, 0xFE, 0x00, 0xFF, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFE, 0x07, 0xFE,
  0x0F, 0xFE, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0x7F, 0x87, 0xFE, 0x00, 0x3F,
  0xC3, 0xFE, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x07,
  0xF8, 0x7F, 0x80, 0x03, 0xFC, 0x3F, 0xC0, 0x01, 0xFE, 0x1F, 0xE0, 0x00,
  0xFF, 0x0F, 0xF0, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0x7F, 0xC3, 0xFC, 0x00,
  0x3F, 0xC1, 0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x1F, 0xF0, 0x7F, 0xC0,
  0x1F, 0xF0, 0x1F, 0xE0, 0x1F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF8, 0x07, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x3F, 0xC0, 0x0F, 0xF0, 0x1F, 0xF0, 0x03, 0xFC, 0x07, 0xF8,
  0x00, 0xFF, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x0F, 0xF0, 0x1F,
  0xE0, 0x03, 0xFC, 0x07, 0xF8, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0x80,
  0x7F, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x1F, 0xF0, 0x03, 0xFE, 0x0F, 0xF8,
  0x00, 0x7F, 0xCF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0x8F, 0xFC, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x7F,
  0xC0, 0x3F, 0xE0, 0x3F, 0xE0, 0x07, 0xFC, 0x0F, 0xF0, 0x00, 0xFF, 0x07,
  0xFC, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x03, 0xFE,
  0x1F, 0xE0, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x0F,
  0xF0, 0xFF, 0x80, 0x03, 0xFC, 0x1F, 0xE0, 0x01, 0xFF, 0x07, 0xFC, 0x00,
  0x7F, 0xC1, 0xFF, 0x80, 0x3F, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xCF, 0xFE,
  0x03, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x01, 0xFE, 0x07, 0xFC, 0x01, 0xFF,
  0x0F, 0xF8, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0xFF,
  0x1F, 0xF0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0xFF,
  0x1F, 0xE0, 0x00, 0xFF, 0x1F, 0xE0, 0x01, 0xFF, 0x3F, 0xE0, 0x01, 0xFF,
  0x3F, 0xE0, 0x01, 0xFF, 0x3F, 0xE0, 0x03, 0xFF, 0x1F, 0xE0, 0x03, 0xFF,
  0x1F, 0xE0, 0x07, 0xFE, 0x1F, 0xF0, 0x0F, 0xFE, 0x1F, 0xF8, 0x1F, 0xFE,
  0x1F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFB, 0xFC, 0x03, 0xFF, 0xF3, 0xFC, 0x01, 0xFF, 0xE7, 0xFC,
  0x00, 0x7F, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x80, 0x07, 0xFE, 0x00,
  0xFC, 0x7F, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x18, 0x00, 0xFE,
  0x01, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFE,
  0x03, 0xFE, 0x03, 0xFC, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x3F, 0x80, 0x7F, 0xC0,
  0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x80,
  0xFF, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x3F, 0x80, 0x03, 0xFE,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x7F,
  0xC7, 0xFF, 0x0F, 0x00, 0x7F, 0xC3, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8,
  0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0xFE,
  0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x7F, 0x00, 0x1F, 0xFF, 0x01, 0xFC, 0x1F,
  0x80, 0x1F, 0xFF, 0xF0, 0x3F, 0x0F, 0xE0, 0x0F, 0xFF, 0xFC, 0x0F, 0xC3,
  0xF0, 0x0F, 0xFF, 0xFE, 0x03, 0xF1, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFC,
  0x7E, 0x01, 0xFC, 0x07, 0xE0, 0x3F, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F,
  0xCF, 0xC0, 0x7F, 0x00, 0xFC, 0x03, 0xF3, 0xF0, 0x1F, 0x80, 0x3F, 0x00,
  0xFD, 0xFC, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x7E, 0x03, 0xF0, 0x07, 0xF0,
  0x1F, 0xDF, 0x81, 0xFC, 0x01, 0xF8, 0x07, 0xE7, 0xE0, 0x7F, 0x00, 0x7E,
  0x01, 0xFB, 0xF8, 0x1F, 0x80, 0x3F, 0x80, 0x7E, 0xFC, 0x07, 0xE0, 0x0F,
  0xE0, 0x3F, 0xBF, 0x03, 0xF8, 0x03, 0xF0, 0x0F, 0xCF, 0xC0, 0xFE, 0x01,
  0xFC, 0x03, 0xF3, 0xF0, 0x3F, 0x00, 0x7F, 0x01, 0xFC, 0xFC, 0x0F, 0xC0,
  0x1F, 0xC0, 0x7E, 0x3F, 0x03, 0xF0, 0x0F, 0xE0, 0x3F, 0x8F, 0xC0, 0xFE,
  0x03, 0xF8, 0x0F, 0xC3, 0xF0, 0x3F, 0x81, 0xFE, 0x07, 0xF0, 0xFC, 0x0F,
  0xE0, 0xFF, 0xC3, 0xF8, 0x3F, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xC0,
  0x7F, 0xFE, 0x7F, 0xFE, 0x03, 0xF0, 0x0F, 0xFF, 0x1F, 0xFF, 0x00, 0xFE,
  0x03, 0xFF, 0x83, 0xFF, 0x80, 0x3F, 0x80, 0x3F, 0xC0, 0x7F, 0x80, 0x07,
  0xE0, 0x03, 0x00, 0x03, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x40, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x7F, 0xFC, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x00,
  0x3F, 0xBF, 0x80, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x00, 0x07, 0xF3, 0xF8,
  0x00, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x07,
  0xF8, 0xFF, 0x00, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x00, 0xFF, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0x7F,
  0x83, 0xFC, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0xFF, 0x00, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x0F, 0xF8,
  0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x01, 0xFF, 0x00, 0x7F, 0x00,
  0x07, 0xF8, 0x01, 0xFC, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFE, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x0F,
  0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x01,
  0xFE, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x3F, 0xE0, 0x00, 0x1F, 0xE1, 0xFF,
  0x00, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x07,
  0xFC, 0xFF, 0x80, 0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x00, 0x7F, 0xDF, 0xF0,
  0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0xF0, 0x0F, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x3F,
  0xF0, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x07, 0xFC,
  0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x03, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xF8,
  0x01, 0xFE, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x01, 0xFE, 0x03,
  0xFF, 0xC0, 0x07, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xFE, 0x00,
  0xFF, 0x80, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x0F, 0xF0, 0x00,
  0x7F, 0xC0, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x07,
  0xFC, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x01,
  0xFF, 0x01, 0xFE, 0x00, 0x0F, 0xFC, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x3F,
  0xE0, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x0F, 0xFC, 0x03, 0xFC, 0x01, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xF8, 0x03, 0xC0, 0x0F, 0xFF, 0x00, 0x06, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x08, 0x00, 0x7F, 0xF0, 0x03, 0xC0, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xC1, 0xFF, 0xFC, 0x00, 0x7F, 0xC0, 0x1F, 0xFC, 0x00, 0x7F, 0xC0,
  0x0F, 0xFE, 0x00, 0x7F, 0x80, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x01,
  0xFF, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x01,
  0xFE, 0x00, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x07, 0xFC,
  0x00, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0x03,
  0xFE, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x0F,
  0xF8, 0x00, 0x0F, 0xFC, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x0F, 0xF0, 0x00,
  0x0F, 0xF8, 0x0F, 0xF0, 0x00, 0x1F, 0xF8, 0x1F, 0xF0, 0x00, 0x3F, 0xF0,
  0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x1F, 0xE0,
  0x00, 0xFF, 0xC0, 0x1F, 0xE0, 0x01, 0xFF, 0xC0, 0x3F, 0xE0, 0x07, 0xFF,
  0x80, 0x3F, 0xE0, 0x1F, 0xFF, 0x00, 0x3F, 0xE1, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x01,
  0xF8, 0x01, 0xFF, 0xE0, 0x00, 0x38, 0x01, 0xFF, 0xC0, 0x00, 0x08, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0xF8, 0xFF, 0x80, 0x0F,
  0xFF, 0xF0, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0xFF, 0x80, 0x0F, 0xFF, 0xF0,
  0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0xFF, 0x80,
  0x1F, 0xFF, 0xE0, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0xFF,
  0x80, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x00, 0x7F, 0x80,
  0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x7F, 0xF0,
  0x00, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x3F,
  0xE0, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0xC0, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80,
  0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x0F,
  0xF0, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x0F, 0xF8,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x01,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x40, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0xE0, 0x03, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x03, 0xFC, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x03, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x3F, 0xF0, 0x00,
  0x0F, 0xF0, 0x0F, 0xFC, 0x00, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x1F, 0xF8, 0x00, 0x01, 0xFE, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0xC1, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x3F, 0xE0,
  0x00, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE3, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x3F, 0xF0, 0x00, 0x00, 0x1F,
  0xE7, 0xFC, 0x00, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x7F,
  0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x0F,
  0xFC, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC1,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00,
  0x01, 0xFF, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x00, 0x07,
  0xF8, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0,
  0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xC0, 0x03,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xE0, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFE,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFB, 0xF8, 0x00,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x07, 0xF7,
  0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0xFE, 0xFE, 0x00,
  0x0F, 0xE7, 0xF0, 0x01, 0xFE, 0xFE, 0x00, 0x0F, 0xEF, 0xF0, 0x01, 0xFE,
  0xFE, 0x00, 0x1F, 0xCF, 0xF0, 0x01, 0xFE, 0x7E, 0x00, 0x1F, 0xCF, 0xF0,
  0x01, 0xFE, 0x7E, 0x00, 0x3F, 0x8F, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x3F,
  0x9F, 0xE0, 0x03, 0xFC, 0x7F, 0x00, 0x7F, 0x1F, 0xE0, 0x03, 0xFC, 0x7F,
  0x00, 0x7F, 0x1F, 0xE0, 0x03, 0xFC, 0x7F, 0x00, 0xFE, 0x1F, 0xE0, 0x03,
  0xFC, 0x7F, 0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xF8, 0x7F, 0x01, 0xFC, 0x3F,
  0xC0, 0x07, 0xF8, 0x7F, 0x01, 0xFC, 0x3F, 0xC0, 0x07, 0xF8, 0x7F, 0x03,
  0xF8, 0x3F, 0xC0, 0x07, 0xF8, 0x7F, 0x03, 0xF8, 0x3F, 0xC0, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x80, 0x0F, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x80,
  0x0F, 0xF0, 0x7F, 0x0F, 0xE0, 0x7F, 0x80, 0x0F, 0xF0, 0x7F, 0x0F, 0xE0,
  0x7F, 0x80, 0x0F, 0xF0, 0x3F, 0x1F, 0xC0, 0x7F, 0x80, 0x0F, 0xE0, 0x3F,
  0x1F, 0xC0, 0xFF, 0x00, 0x1F, 0xE0, 0x3F, 0xBF, 0x80, 0xFF, 0x00, 0x1F,
  0xE0, 0x3F, 0xBF, 0x80, 0xFF, 0x00, 0x1F, 0xE0, 0x3F, 0xFF, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x3F, 0xFF, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x3F, 0xFE,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x3F, 0xFE, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x3F, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x3F, 0xFC, 0x01, 0xFE, 0x00,
  0x3F, 0x80, 0x3F, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x3F, 0xF8, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x3F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x3F,
  0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x1F,
  0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xC0, 0x07, 0xFF, 0x80, 0x00, 0x7F,
  0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x7F, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xF0,
  0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0x80,
  0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xDF, 0xE0, 0x01, 0xFE, 0x00,
  0x3F, 0x9F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x3F, 0xC0, 0x0F, 0xF0, 0x01,
  0xFE, 0x7F, 0x80, 0x1F, 0xE0, 0x03, 0xFC, 0xFF, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0xFF, 0x00, 0x7F, 0x80, 0x0F, 0xE1, 0xFE, 0x00, 0xFE, 0x00, 0x1F,
  0xC3, 0xFC, 0x03, 0xFC, 0x00, 0x7F, 0x83, 0xFC, 0x07, 0xF8, 0x00, 0xFF,
  0x07, 0xF8, 0x0F, 0xF0, 0x01, 0xFE, 0x0F, 0xF0, 0x1F, 0xE0, 0x03, 0xFC,
  0x1F, 0xE0, 0x3F, 0x80, 0x07, 0xF0, 0x1F, 0xE0, 0xFF, 0x00, 0x1F, 0xE0,
  0x3F, 0xC1, 0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0x83, 0xFC, 0x00, 0x7F, 0x80,
  0x7F, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0xFF, 0x0F, 0xE0, 0x03, 0xFC, 0x01,
  0xFE, 0x3F, 0xC0, 0x07, 0xF8, 0x03, 0xFC, 0x7F, 0x80, 0x0F, 0xF0, 0x03,
  0xFC, 0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xF9, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xF3, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xE7, 0xF0, 0x01, 0xFE, 0x00, 0x1F,
  0xFF, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x7F,
  0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0xFC, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0x00, 0x03, 0xFF,
  0xF0, 0x01, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x07, 0xFF,
  0x80, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFE,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xF0,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xF0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x03, 0xFF, 0x80,
  0x07, 0xFE, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x3F,
  0xE0, 0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00,
  0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0xFF, 0x80,
  0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0x03,
  0xFE, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0xFF,
  0x80, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0xFF, 0xC0,
  0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x01, 0xFF,
  0xC0, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0x1F, 0xF0, 0x3F, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x01, 0xFE,
  0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x01, 0xFE,
  0x00, 0xFF, 0x80, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0x07, 0xF8,
  0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x7F, 0x80,
  0x07, 0xFE, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0xFF, 0xC0,
  0x3F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFC, 0x01, 0xFF,
  0xC0, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x03,
  0xFE, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x7F, 0xE0,
  0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x01,
  0xFF, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00,
  0x03, 0xFE, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0x07, 0xFE,
  0xFF, 0x80, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0xFF, 0x80,
  0x00, 0x0F, 0xFC, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x7F, 0xE0, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x03, 0xFF, 0x80,
  0x3F, 0xF8, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0xF8, 0x1F, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x07, 0xFC, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x1F, 0xE0, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x7F,
  0xC0, 0x1F, 0xE0, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xF8,
  0x0F, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xE0, 0xFF, 0x00, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x1F, 0xE0,
  0x00, 0x7F, 0x80, 0xFF, 0x00, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0x3F, 0xE0,
  0x3F, 0xE0, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x07, 0xFC, 0x00,
  0x7F, 0x80, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x7F,
  0x80, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x01, 0xFF,
  0x01, 0xFF, 0x00, 0x07, 0xFC, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x7F, 0x80,
  0x01, 0xFF, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x1F, 0x80,
  0x1F, 0xF8, 0x00, 0x60, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x08, 0x00, 0x03, 0xFE, 0x01,
  0xC0, 0x00, 0xFF, 0xC0, 0x3F, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0x80,
  0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x00, 0x3F,
  0xE0, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x0F,
  0xF8, 0x00, 0x07, 0xF8, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x03, 0xFC, 0x00,
  0x03, 0xFE, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x3F,
  0xC0, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x1F, 0xF0, 0x00,
  0x0F, 0xF0, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x07, 0xF8, 0x00, 0x07, 0xFC,
  0x03, 0xFC, 0x00, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x00,
  0x7F, 0xC0, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x00, 0x1F, 0xE0,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x07, 0xF8,
  0x00, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0x01,
  0xFE, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x3F, 0xE0,
  0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x01,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xBF,
  0xE0, 0x00, 0x07, 0xFC, 0xFF, 0x00, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x03,
  0xFE, 0x3F, 0xC0, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x01, 0xFF, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x07, 0xF8,
  0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00,
  0x3F, 0xE0, 0x3F, 0xC0, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x0F,
  0xF0, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0x7F,
  0xC0, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xE0, 0x03, 0xF8,
  0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x01, 0xFE, 0x07,
  0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x03,
  0xFC, 0x1F, 0xE0, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x01, 0xFE,
  0x3F, 0xC0, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x00, 0x3F, 0x9F, 0xE0, 0x00,
  0x01, 0xFD, 0xFE, 0x00, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x00, 0x7F, 0x7F,
  0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFE, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xFC, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xF8,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x07, 0xFE, 0x00,
  0x0F, 0xF8, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x0F,
  0xFE, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xE0, 0xFF,
  0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0xC0, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x7F, 0x7E,
  0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x80, 0xFF, 0x00,
  0x7F, 0x7F, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0xFE, 0x7F, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFE, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x01, 0xFC, 0x7F, 0x01,
  0xFE, 0x00, 0xFF, 0x01, 0xFC, 0x7F, 0x01, 0xFE, 0x00, 0xFF, 0x03, 0xFC,
  0x7F, 0x03, 0xFE, 0x00, 0xFF, 0x03, 0xF8, 0x7F, 0x03, 0xFC, 0x00, 0xFF,
  0x03, 0xF8, 0x7F, 0x07, 0xFC, 0x00, 0xFF, 0x07, 0xF0, 0x7F, 0x07, 0xF8,
  0x00, 0xFF, 0x07, 0xF0, 0x7F, 0x07, 0xF8, 0x00, 0xFF, 0x0F, 0xF0, 0x7F,
  0x0F, 0xF0, 0x00, 0xFF, 0x0F, 0xE0, 0x7F, 0x0F, 0xF0, 0x00, 0xFF, 0x1F,
  0xE0, 0x7F, 0x1F, 0xF0, 0x00, 0xFF, 0x1F, 0xC0, 0x7F, 0x1F, 0xE0, 0x00,
  0xFF, 0x1F, 0xC0, 0x7F, 0x1F, 0xE0, 0x00, 0xFF, 0x3F, 0x80, 0x7F, 0x3F,
  0xC0, 0x00, 0xFE, 0x3F, 0x80, 0x7F, 0x3F, 0xC0, 0x00, 0xFE, 0x7F, 0x80,
  0x7F, 0x3F, 0x80, 0x00, 0xFE, 0x7F, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0xFE,
  0x7F, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0xFE, 0xFE, 0x00, 0x7F, 0x7F, 0x00,
  0x00, 0xFE, 0xFE, 0x00, 0x7E, 0xFF, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x7E,
  0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x00,
  0x00, 0x7F, 0x81, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x00,
  0x07, 0xFC, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xCF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x7F, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xF9, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC7, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0x00,
  0x7F, 0xC0, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xF0, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0xEF, 0xF0, 0x00, 0x0F, 0xF9, 0xFE, 0x00, 0x03, 0xFE, 0x3F, 0xC0, 0x00,
  0xFF, 0x87, 0xFC, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x07, 0xFC, 0x0F, 0xF0,
  0x00, 0xFF, 0x81, 0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x0F, 0xF8, 0x07,
  0xF8, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x01, 0xFE, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x07, 0xF8, 0x1F,
  0xF0, 0x00, 0x7F, 0x87, 0xFC, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x01, 0xFE,
  0x3F, 0xE0, 0x00, 0x3F, 0xCF, 0xF8, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x00,
  0x7F, 0x7F, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x08, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03,
  0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F,
  0x00, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x80, 0xFF, 0x00, 0xFE, 0x01, 0xFC, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0x3F, 0x80, 0x7F,
  0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFE,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x01,
  0xFC, 0xFE, 0x00, 0x01, 0xFC, 0x3F, 0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00,
  0xFE, 0x0F, 0xE0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x7F, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x1F, 0xC0, 0x0F, 0xE0, 0x1F, 0xC0, 0x03, 0xF0, 0x1F, 0xC0, 0x01, 0xFC,
  0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x1F,
  0xC7, 0xF0, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0x87,
  0xFC, 0x1F, 0xF0, 0xFF, 0x83, 0xFC, 0x0F, 0xF0, 0x3F, 0x81, 0xFE, 0x07,
  0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0xFE, 0x07, 0xF0, 0x03, 0xFF, 0xC3, 0xF8, 0x03, 0xFF, 0xF8, 0xFE, 0x01,
  0xFF, 0xFF, 0x3F, 0x80, 0x7F, 0xFF, 0xDF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFE, 0x7F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0xFF,
  0xC1, 0xFF, 0x80, 0x3F, 0xF0, 0x7F, 0xC0, 0x0F, 0xFC, 0x3F, 0xF0, 0x03,
  0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x3F, 0xE1, 0xFF, 0x00,
  0x0F, 0xF8, 0x7F, 0xC0, 0x03, 0xFC, 0x1F, 0xF0, 0x00, 0xFF, 0x07, 0xF8,
  0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x07, 0xFC, 0x3F,
  0xE0, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x1F, 0xE0,
  0xFF, 0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x03, 0xFE, 0x0F, 0xF0, 0x01, 0xFF,
  0x03, 0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x3F, 0xF0, 0x3F, 0xC0, 0x1F,
  0xFC, 0x0F, 0xF8, 0x07, 0xFF, 0x03, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xE7,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFD, 0xFE, 0x01, 0xFF,
  0xFF, 0x7F, 0x00, 0x3F, 0xFF, 0x1F, 0xC0, 0x07, 0xFF, 0x87, 0xF0, 0x00,
  0xFF, 0xC1, 0xFC, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x1C, 0x00,
  0x03, 0xFC, 0x3F, 0xE0, 0x00, 0xFF, 0x3F, 0xFC, 0x00, 0x7F, 0x9F, 0xFF,
  0x80, 0x1F, 0xEF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFC, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xFC, 0x0F, 0xFE,
  0x01, 0xFF, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x1F, 0xF0, 0x7F,
  0xE0, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x7F, 0xC1,
  0xFE, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x07, 0xFC, 0x3F, 0xE0, 0x01, 0xFF,
  0x0F, 0xF0, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x07,
  0xF8, 0x3F, 0xC0, 0x03, 0xFE, 0x1F, 0xE0, 0x00, 0xFF, 0x87, 0xF8, 0x00,
  0x3F, 0xC1, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x07, 0xFC, 0x3F, 0xE0,
  0x01, 0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x3F, 0xE0, 0xFF,
  0x80, 0x1F, 0xF0, 0x3F, 0xF0, 0x0F, 0xFC, 0x1F, 0xFE, 0x07, 0xFE, 0x07,
  0xFF, 0xC3, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0x7F, 0xFF, 0xE0,
  0x1F, 0xDF, 0xFF, 0xF0, 0x0F, 0xE3, 0xFF, 0xF8, 0x03, 0xF8, 0x7F, 0xFC,
  0x00, 0xFC, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFC, 0x7C, 0x0F, 0xFE, 0x00, 0x80, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x04, 0x0F, 0xFC,
  0x01, 0xC0, 0x7F, 0xF0, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0xFC, 0x7F,
  0x80, 0x03, 0xFF, 0xF3, 0xFC, 0x00, 0x7F, 0xFF, 0xDF, 0xE0, 0x03, 0xFF,
  0xFE, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xCF, 0xFF, 0x80,
  0x3F, 0xF0, 0x1F, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x01, 0xFF,
  0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0xFF, 0x80,
  0x03, 0xFC, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0xE0, 0x00, 0xFF, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x03,
  0xFC, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x1F, 0xF0, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xFC,
  0x01, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x07, 0xFE, 0x00, 0x7F, 0xC0,
  0x7F, 0xF0, 0x03, 0xFF, 0x8F, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xEF, 0xE0, 0x03, 0xFF, 0xFE, 0x7E, 0x00, 0x0F, 0xFF, 0xE7,
  0xF0, 0x00, 0x3F, 0xFE, 0x3F, 0x80, 0x00, 0xFF, 0xC1, 0xFC, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0x81, 0xFE, 0x07, 0xFC,
  0x03, 0xFC, 0x3F, 0xE0, 0x0F, 0xF1, 0xFF, 0x00, 0x3F, 0xC7, 0xF8, 0x00,
  0xFE, 0x3F, 0xE0, 0x07, 0xF8, 0xFF, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0xFF,
  0x9F, 0xF0, 0x0F, 0xFC, 0x7F, 0x80, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0xC0, 0x7F, 0xE0, 0x1F, 0x01, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x8C,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x31, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x1F, 0xC0, 0x01, 0xFF,
  0xE1, 0xFC, 0x00, 0x3F, 0xFF, 0x8F, 0xE0, 0x03, 0xFF, 0xFE, 0x7F, 0x00,
  0x3F, 0xFF, 0xF7, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFE, 0x7F,
  0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF,
  0xC0, 0x1F, 0xF8, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x07, 0xFC,
  0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x01, 0xFF, 0x01, 0xFF, 0x00,
  0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x03, 0xFC, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0xE0, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x0F,
  0xF8, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x03, 0xFC, 0x03, 0xFC,
  0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x0F, 0xF8,
  0x07, 0xF8, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x07, 0xFC, 0x01, 0xFE, 0x00,
  0x7F, 0xE0, 0x0F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0xF8, 0x03,
  0xFE, 0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x7F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFE, 0xFF, 0x00, 0x1F, 0xFF, 0xEF, 0xF0, 0x00, 0x7F,
  0xFE, 0x7F, 0x80, 0x01, 0xFF, 0xE3, 0xFC, 0x00, 0x07, 0xFC, 0x1F, 0xE0,
  0x00, 0x03, 0x81, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x02, 0x00, 0x01, 0xFF,
  0x00, 0x1C, 0x00, 0x1F, 0xF8, 0x00, 0xFE, 0x03, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x1C, 0x00, 0x03,
  0xFC, 0x3F, 0xF0, 0x00, 0xFF, 0x3F, 0xFE, 0x00, 0x7F, 0x9F, 0xFF, 0xC0,
  0x1F, 0xEF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xFE, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFC, 0x0F, 0xFE, 0x01,
  0xFF, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x1F, 0xF0, 0x7F, 0xE0,
  0x07, 0xFC, 0x1F, 0xF0, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x7F, 0x81, 0xFF,
  0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x0F, 0xF8, 0x3F, 0xE0, 0x03, 0xFE, 0x0F,
  0xF8, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x0F, 0xF0,
  0x3F, 0xC0, 0x07, 0xFC, 0x1F, 0xF0, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x7F,
  0x81, 0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x07, 0xF8, 0x3F, 0xE0, 0x03,
  0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0x00,
  0x0F, 0xF0, 0x3F, 0xC0, 0x03, 0xFC, 0x1F, 0xF0, 0x01, 0xFF, 0x07, 0xF8,
  0x00, 0x7F, 0x81, 0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x07, 0xF8, 0x1F,
  0xE0, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x3F, 0xC0,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0x00, 0x03, 0xF8, 0x00, 0x7F,
  0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x01, 0xFE,
  0x00, 0x3F, 0x80, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xE0,
  0x07, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x80,
  0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x03, 0x1F, 0xFC, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFE,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x01,
  0xFF, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x1F, 0xF0, 0x01, 0xFE, 0x03, 0xFE, 0x00,
  0x1F, 0xE0, 0x7F, 0xC0, 0x03, 0xFE, 0x0F, 0xFC, 0x00, 0x3F, 0xC0, 0xFF,
  0x80, 0x03, 0xFC, 0x1F, 0xF0, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x07, 0xFC,
  0x7F, 0xC0, 0x00, 0x7F, 0x8F, 0xF8, 0x00, 0x07, 0xF9, 0xFF, 0x00, 0x00,
  0x7F, 0xBF, 0xE0, 0x00, 0x07, 0xF7, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xDF, 0xF0, 0x00, 0x1F, 0xF9, 0xFF, 0x00, 0x01, 0xFF, 0x0F, 0xF0,
  0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x03, 0xFC, 0x0F, 0xF8, 0x00, 0x3F, 0xC0,
  0x7F, 0x80, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x07,
  0xFC, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x07, 0xF8, 0x03, 0xFE,
  0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0x1F, 0xF0, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x3F,
  0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00,
  0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xF8,
  0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x1F,
  0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00,
  0x7F, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x0F, 0xC0, 0xFF, 0x80,
  0x1F, 0xF8, 0x00, 0xFC, 0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0x1F, 0xC7, 0xFF,
  0xE0, 0xFF, 0xFE, 0x01, 0xFC, 0xFF, 0xFF, 0x1F, 0xFF, 0xE0, 0x1F, 0xDF,
  0xFF, 0xF3, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0x1F, 0xFF, 0xE3, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xF0,
  0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xF0, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0x07, 0xFE, 0x00, 0x7F, 0xC0,
  0x0F, 0xF0, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0xFF,
  0x80, 0x0F, 0xF0, 0x7F, 0x80, 0x0F, 0xF8, 0x01, 0xFF, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x0F, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x3F, 0xE0, 0x03,
  0xFC, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xFC, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0x83, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xF8, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x07, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x07,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFF,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x1F, 0xF0,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0x03, 0xFF, 0x00,
  0x0F, 0xC3, 0xFF, 0xE0, 0x07, 0xF1, 0xFF, 0xFC, 0x01, 0xFC, 0xFF, 0xFF,
  0x80, 0x7F, 0x7F, 0xFF, 0xE0, 0x1F, 0xDF, 0xFF, 0xF8, 0x0F, 0xFF, 0xEF,
  0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xF0, 0x3F, 0xF0,
  0x07, 0xFC, 0x0F, 0xFC, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0x7F, 0xC1, 0xFF,
  0x80, 0x1F, 0xE0, 0x7F, 0xC0, 0x07, 0xF8, 0x1F, 0xF0, 0x01, 0xFE, 0x07,
  0xF8, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x0F, 0xF0,
  0x3F, 0xC0, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x7F,
  0xC1, 0xFF, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x07, 0xF8, 0x1F, 0xE0, 0x01,
  0xFE, 0x07, 0xF8, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0x80,
  0x0F, 0xF8, 0x3F, 0xC0, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0xFF, 0x03, 0xFC,
  0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x07, 0xF8, 0x1F,
  0xE0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x3F, 0xE0,
  0xFF, 0x80, 0x0F, 0xF8, 0x3F, 0xE0, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xCF, 0xFE, 0x0F, 0xFC, 0x07, 0xFC,
  0x1F, 0xF0, 0x07, 0xF8, 0x7F, 0xC0, 0x0F, 0xF8, 0xFF, 0x80, 0x1F, 0xF3,
  0xFE, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x3F, 0xDF, 0xF0, 0x00, 0x7F, 0xBF,
  0xE0, 0x00, 0xFF, 0x7F, 0x80, 0x01, 0xFE, 0xFF, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x7F, 0xBF, 0xC0, 0x00, 0xFF, 0x7F, 0x80, 0x03, 0xFE, 0xFF, 0x00,
  0x07, 0xFD, 0xFE, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x3F, 0xE7, 0xF8, 0x00,
  0x7F, 0xCF, 0xF0, 0x01, 0xFF, 0x1F, 0xE0, 0x07, 0xFE, 0x3F, 0xE0, 0x0F,
  0xF8, 0x7F, 0xE0, 0x3F, 0xF0, 0x7F, 0xF3, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3F, 0x03, 0xFE, 0x00, 0x00, 0xFC,
  0x3F, 0xFC, 0x00, 0x07, 0xF1, 0xFF, 0xF8, 0x00, 0x1F, 0xCF, 0xFF, 0xF0,
  0x00, 0x7F, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xC7, 0xFE, 0x00, 0x3F, 0xFC, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x1F, 0xF0,
  0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xE0,
  0x07, 0xFC, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x07, 0xFC, 0x00, 0x7F, 0xC0,
  0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x03, 0xFE, 0x00,
  0x1F, 0xF0, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x00,
  0xFF, 0x80, 0x7F, 0x80, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x07,
  0xF8, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F,
  0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0xE0, 0x7F, 0xE0, 0x07, 0xFF, 0xC7, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x01, 0xFE,
  0xFF, 0xFF, 0x00, 0x0F, 0xF3, 0xFF, 0xF8, 0x00, 0x3F, 0xC7, 0xFF, 0xC0,
  0x00, 0xFF, 0x0F, 0xFC, 0x00, 0x03, 0xFC, 0x07, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x07, 0xF0, 0x03,
  0xFF, 0xE1, 0xF8, 0x01, 0xFF, 0xFC, 0xFE, 0x00, 0xFF, 0xFF, 0x3F, 0x80,
  0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFE, 0x7F, 0xFC,
  0x0F, 0xFC, 0x07, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x3F,
  0xF0, 0x7F, 0xC0, 0x0F, 0xF8, 0x3F, 0xE0, 0x03, 0xFE, 0x0F, 0xF8, 0x00,
  0xFF, 0x83, 0xFC, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x0F, 0xF8, 0x7F, 0xC0,
  0x03, 0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x3F, 0xC3, 0xFE,
  0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x07, 0xFC, 0x3F, 0xC0, 0x01, 0xFE, 0x0F,
  0xF0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x0F, 0xF8,
  0x3F, 0xC0, 0x03, 0xFE, 0x0F, 0xF0, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x7F,
  0xC0, 0xFF, 0x00, 0x3F, 0xF0, 0x3F, 0xC0, 0x0F, 0xFC, 0x0F, 0xF8, 0x07,
  0xFE, 0x03, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE3, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFD, 0xFE, 0x01, 0xFF, 0xFE, 0xFF, 0x00, 0x3F,
  0xFF, 0x3F, 0xC0, 0x07, 0xFF, 0x8F, 0xF0, 0x00, 0xFF, 0xC3, 0xFC, 0x00,
  0x07, 0x81, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x0F, 0xE0, 0xFF, 0x00, 0xFC, 0x3F, 0xF0, 0x1F,
  0xC7, 0xFE, 0x01, 0xFC, 0xFF, 0xE0, 0x1F, 0xCF, 0xFE, 0x01, 0xFD, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xC0, 0xFC, 0x07, 0xFC,
  0x00, 0xC0, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC2, 0x00, 0x07, 0xFC, 0x1C, 0x00, 0x3F,
  0xE0, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x3F, 0xFF, 0xF9, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFE, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE1,
  0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8,
  0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x78, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x07, 0xF8, 0x1F,
  0xE0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x3F, 0xE0,
  0xFF, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0xFF,
  0x03, 0xFC, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x07,
  0xF8, 0x1F, 0xE0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0x81, 0xFE, 0x00,
  0x3F, 0xE0, 0xFF, 0x80, 0x0F, 0xF0, 0x3F, 0xC0, 0x03, 0xFC, 0x0F, 0xF0,
  0x00, 0xFF, 0x03, 0xFC, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x1F, 0xF0, 0x7F,
  0xC0, 0x07, 0xF8, 0x1F, 0xE0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0xFF, 0x81,
  0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x0F, 0xF8, 0x3F, 0xE0, 0x07, 0xFC,
  0x0F, 0xF0, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0x00, 0x7F,
  0xF0, 0x3F, 0xE0, 0x1F, 0xF8, 0x0F, 0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0x1F,
  0xFF, 0x80, 0xFF, 0xFF, 0xEF, 0xE0, 0x1F, 0xFF, 0xF3, 0xF8, 0x07, 0xFF,
  0xF8, 0xFC, 0x00, 0xFF, 0xFC, 0x7F, 0x00, 0x3F, 0xFE, 0x1F, 0xC0, 0x03,
  0xFF, 0x07, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xF7, 0xF8, 0x00, 0x3F, 0xEF,
  0xF0, 0x00, 0xFF, 0x9F, 0xE0, 0x01, 0xFF, 0x3F, 0xC0, 0x03, 0xFC, 0x7F,
  0x80, 0x0F, 0xF8, 0xFF, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x7F, 0xC1, 0xFC,
  0x00, 0xFF, 0x03, 0xF8, 0x03, 0xFE, 0x07, 0xF0, 0x07, 0xF8, 0x0F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0xFF, 0x80, 0x7F, 0x81,
  0xFE, 0x00, 0xFF, 0x07, 0xFC, 0x01, 0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x3F,
  0xC0, 0x07, 0xF8, 0x7F, 0x80, 0x07, 0xF1, 0xFE, 0x00, 0x0F, 0xE3, 0xFC,
  0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0x7F, 0x3F, 0x80,
  0x00, 0xFE, 0xFF, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFE, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFE,
  0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFC, 0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFC,
  0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xF8, 0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xF8,
  0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xF0, 0xFF, 0x01, 0xFF, 0xF0, 0x0F, 0xF0,
  0xFF, 0x01, 0xFB, 0xF0, 0x1F, 0xF0, 0xFF, 0x01, 0xFB, 0xF0, 0x1F, 0xE0,
  0x7F, 0x03, 0xFB, 0xF0, 0x1F, 0xE0, 0x7F, 0x03, 0xF3, 0xF0, 0x3F, 0xC0,
  0x7F, 0x07, 0xF3, 0xF0, 0x3F, 0xC0, 0x7F, 0x07, 0xF3, 0xF0, 0x7F, 0x80,
  0x7F, 0x0F, 0xE3, 0xF0, 0x7F, 0x80, 0x7F, 0x0F, 0xE3, 0xF0, 0x7F, 0x00,
  0x7F, 0x0F, 0xC3, 0xF0, 0xFF, 0x00, 0x7F, 0x1F, 0xC3, 0xF0, 0xFF, 0x00,
  0x7F, 0x1F, 0x83, 0xF1, 0xFE, 0x00, 0x7F, 0x3F, 0x83, 0xF1, 0xFE, 0x00,
  0x7F, 0x3F, 0x83, 0xF1, 0xFC, 0x00, 0x7F, 0x3F, 0x03, 0xF3, 0xFC, 0x00,
  0x7F, 0x7F, 0x03, 0xF3, 0xF8, 0x00, 0x7F, 0x7E, 0x03, 0xF3, 0xF8, 0x00,
  0x7F, 0x7E, 0x03, 0xF7, 0xF0, 0x00, 0x7F, 0xFE, 0x03, 0xF7, 0xF0, 0x00,
  0x7F, 0xFC, 0x03, 0xF7, 0xF0, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x00,
  0x7F, 0xF8, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x00,
  0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x00,
  0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFC,
  0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x3F, 0xE0,
  0x00, 0xFF, 0x81, 0xFF, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x07, 0xF8,
  0x3F, 0xE0, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x00, 0x7F, 0xC7, 0xF8, 0x00,
  0x00, 0xFF, 0x3F, 0xE0, 0x00, 0x03, 0xFD, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xF9, 0xFE, 0x00, 0x00, 0x3F, 0xC7, 0xF8,
  0x00, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x00, 0x7F,
  0xC0, 0xFF, 0x00, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x07, 0xF8,
  0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF8,
  0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x03, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x00, 0x7F, 0xC0,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x03, 0xFC,
  0x03, 0xFE, 0x00, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0xFF, 0x80, 0x00,
  0x0F, 0xE0, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x7F, 0xC0, 0x00, 0x03, 0xF8,
  0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x3F, 0xE0, 0x00, 0x00, 0xFE, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x00,
  0x1F, 0xE7, 0xF8, 0x00, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x00, 0x03, 0xFB,
  0xFC, 0x00, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x83, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFE,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x02, 0x7F, 0xFC, 0x00, 0x0D, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xF9, 0x00, 0x00, 0xFF, 0xE2, 0x00, 0x00, 0x0C, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_SemiBoldItalic70pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 19, 51, 19, 1, -50 },
  { 123, 24, 18, 29, 7, -50 },
  { 177, 40, 50, 40, 1, -50 },
  { 427, 34, 57, 35, 1, -53 },
  { 670, 48, 52, 54, 4, -51 },
  { 982, 41, 52, 43, 1, -51 },
  { 1249, 11, 18, 16, 7, -50 },
  { 1274, 24, 61, 21, 2, -50 },
  { 1457, 24, 62, 21, -5, -51 },
  { 1643, 30, 31, 34, 6, -54 },
  { 1760, 31, 34, 37, 4, -42 },
  { 1892, 15, 17, 18, -3, -8 },
  { 1924, 19, 8, 21, 1, -23 },
  { 1943, 10, 11, 18, 1, -10 },
  { 1957, 35, 50, 27, -3, -50 },
  { 2176, 33, 52, 35, 2, -51 },
  { 2391, 24, 50, 35, 7, -50 },
  { 2541, 36, 51, 35, -2, -51 },
  { 2771, 35, 52, 35, 0, -51 },
  { 2999, 36, 50, 35, -1, -50 },
  { 3224, 34, 51, 35, 1, -50 },
  { 3441, 33, 52, 35, 3, -51 },
  { 3656, 35, 50, 35, 3, -50 },
  { 3875, 34, 52, 35, 1, -51 },
  { 4096, 32, 52, 35, 2, -51 },
  { 4304, 16, 40, 18, 1, -39 },
  { 4384, 21, 48, 18, -4, -39 },
  { 4510, 31, 35, 37, 4, -43 },
  { 4646, 31, 20, 37, 4, -35 },
  { 4724, 31, 35, 37, 4, -43 },
  { 4860, 26, 52, 28, 4, -51 },
  { 5029, 50, 56, 54, 3, -50 },
  { 5379, 38, 50, 38, -4, -50 },
  { 5617, 38, 50, 39, 1, -50 },
  { 5855, 37, 52, 37, 4, -51 },
  { 6096, 40, 50, 43, 1, -50 },
  { 6346, 35, 50, 34, 1, -50 },
  { 6565, 35, 50, 32, 1, -50 },
  { 6784, 40, 52, 44, 4, -51 },
  { 7044, 44, 50, 44, 1, -50 },
  { 7319, 30, 50, 24, -2, -50 },
  { 7507, 32, 64, 20, -11, -50 },
  { 7763, 43, 50, 38, 1, -50 },
  { 8032, 26, 50, 32, 1, -50 },
  { 8195, 56, 50, 56, 1, -50 },
  { 8545, 47, 50, 47, 1, -50 },
  { 8839, 40, 52, 46, 4, -51 },
  { 9099, 38, 50, 38, 1, -50 },
  { 9337, 40, 63, 46, 4, -51 },
  { 9652, 37, 50, 38, 1, -50 },
  { 9884, 35, 52, 33, 0, -51 },
  { 10112, 32, 50, 33, 6, -50 },
  { 10312, 41, 51, 43, 4, -50 },
  { 10574, 37, 50, 37, 6, -50 },
  { 10806, 56, 50, 56, 7, -50 },
  { 11156, 46, 50, 36, -4, -50 },
  { 11444, 35, 50, 34, 6, -50 },
  { 11663, 39, 50, 33, -2, -50 },
  { 11907, 28, 61, 21, -2, -50 },
  { 12121, 15, 50, 27, 7, -50 },
  { 12215, 28, 61, 21, -5, -50 },
  { 12429, 33, 31, 36, 1, -50 },
  { 12557, 26, 5, 26, -6, 6 },
  { 12574, 13, 12, 21, 10, -54 },
  { 12594, 34, 40, 37, 3, -39 },
  { 12764, 34, 54, 37, 1, -53 },
  { 12994, 28, 40, 30, 3, -39 },
  { 13134, 37, 54, 38, 3, -53 },
  { 13384, 30, 40, 34, 3, -39 },
  { 13534, 38, 71, 22, -8, -54 },
  { 13872, 37, 56, 38, 0, -39 },
  { 14131, 34, 53, 38, 1, -53 },
  { 14357, 19, 53, 18, 1, -53 },
  { 14483, 29, 70, 18, -9, -53 },
  { 14737, 36, 53, 34, 1, -53 },
  { 14976, 20, 53, 18, 1, -53 },
  { 15109, 52, 39, 56, 1, -39 },
  { 15363, 34, 39, 38, 1, -39 },
  { 15529, 31, 40, 37, 3, -39 },
  { 15684, 38, 56, 37, -3, -39 },
  { 15950, 34, 56, 38, 3, -39 },
  { 16188, 28, 39, 26, 1, -39 },
  { 16325, 29, 40, 29, 0, -39 },
  { 16470, 23, 47, 24, 3, -46 },
  { 16606, 34, 39, 38, 3, -38 },
  { 16772, 31, 38, 32, 4, -38 },
  { 16920, 48, 38, 49, 4, -38 },
  { 17148, 38, 38, 33, -3, -38 },
  { 17329, 41, 55, 32, -6, -38 },
  { 17611, 32, 38, 29, -2, -38 },
  { 17763, 28, 61, 24, 1, -50 },
  { 17977, 6, 69, 34, 14, -53 },
  { 18029, 28, 61, 24, -4, -50 },
  { 18243, 31, 11, 37, 4, -30 },
};

const GFXfont NotoSans_SemiCondensed_SemiBoldItalic70pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_SemiBoldItalic70pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_SemiBoldItalic70pt7bGlyphs,
  0x20, 0x7E, 95
};

#endif // _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC70PT7B_H_
