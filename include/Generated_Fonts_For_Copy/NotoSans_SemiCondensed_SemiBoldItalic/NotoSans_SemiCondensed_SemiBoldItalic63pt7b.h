#ifndef _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC63PT7B_H_
#define _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC63PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-SemiBoldItalic.ttf
// Size: 63pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_SemiBoldItalic63pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0,
  0x07, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x03, 0xF8, 0x01, 0xFE, 0x01,
  0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x0F, 0xE0,
  0x01, 0xC0, 0x00, 0x1F, 0xC3, 0xF9, 0xFE, 0x1F, 0xCF, 0xE0, 0xFE, 0x7F,
  0x07, 0xE3, 0xF8, 0x7F, 0x1F, 0x83, 0xF8, 0xFC, 0x1F, 0xC7, 0xE0, 0xFC,
  0x7F, 0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0x81, 0xF8, 0xFC, 0x1F, 0x87, 0xE0,
  0xFC, 0x3E, 0x07, 0xE1, 0xF0, 0x3E, 0x1F, 0x81, 0xF0, 0x00, 0x00, 0xF8,
  0x0F, 0x80, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00,
  0x1F, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x07, 0xE0,
  0x7E, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00,
  0x7C, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x3F, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x3E, 0x00,
  0x00, 0x7E, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x00, 0x7C, 0x07,
  0xC0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x87, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xF0, 0x3F,
  0x00, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x7E,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0xFC, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0xF8,
  0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x01, 0xF8,
  0x1F, 0x80, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xC7, 0x87, 0x00, 0x7F,
  0x0E, 0x02, 0x00, 0xFE, 0x3C, 0x00, 0x03, 0xF8, 0x78, 0x00, 0x07, 0xF0,
  0xF0, 0x00, 0x0F, 0xF1, 0xC0, 0x00, 0x1F, 0xE3, 0x80, 0x00, 0x1F, 0xEF,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xEF, 0xF8, 0x00, 0x03, 0x8F, 0xF0,
  0x00, 0x07, 0x0F, 0xE0, 0x00, 0x1E, 0x1F, 0xC0, 0x00, 0x3C, 0x3F, 0x80,
  0x00, 0x78, 0xFF, 0x04, 0x00, 0xE1, 0xFE, 0x1E, 0x01, 0xC7, 0xF8, 0x3F,
  0x87, 0xBF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xC0, 0x0F, 0xFE, 0x00, 0x03, 0xF0, 0x03, 0xFF,
  0xE0, 0x00, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0x80, 0x3F, 0xFF, 0xC0,
  0x07, 0xE0, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xE0, 0xFC, 0x03, 0xF0, 0x01,
  0xF8, 0x1F, 0x80, 0x7E, 0x00, 0x3F, 0x03, 0xF0, 0x1F, 0x80, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0xFC, 0x00, 0x3F, 0x01, 0xF8,
  0x3F, 0x00, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0x00, 0xFC, 0x0F, 0xC1, 0xF8,
  0x00, 0x1F, 0x81, 0xF8, 0x7E, 0x00, 0x03, 0xF0, 0x3F, 0x1F, 0x81, 0xE0,
  0x7E, 0x0F, 0xC3, 0xF0, 0xFF, 0x0F, 0xC1, 0xF8, 0xFC, 0x7F, 0xF9, 0xF8,
  0x7E, 0x3F, 0x1F, 0xFF, 0x3F, 0x1F, 0xC7, 0xE7, 0xFF, 0xF7, 0xFF, 0xF1,
  0xF8, 0xFF, 0xFE, 0x7F, 0xFE, 0x7E, 0x3F, 0x8F, 0xCF, 0xFF, 0x8F, 0xC7,
  0xE1, 0xF8, 0xFF, 0xE3, 0xF1, 0xF8, 0x1F, 0x0F, 0xF0, 0xFC, 0x3F, 0x03,
  0xF0, 0x30, 0x1F, 0x8F, 0xC0, 0xFC, 0x00, 0x07, 0xE1, 0xF8, 0x1F, 0x80,
  0x01, 0xF8, 0x3F, 0x03, 0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x7E, 0x00, 0x0F,
  0xC1, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x00, 0x7E, 0x07,
  0xE0, 0x7E, 0x00, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0x1F, 0x81,
  0xF8, 0x00, 0xFC, 0x03, 0xF0, 0x7F, 0x00, 0x3F, 0x00, 0x7E, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC3, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x7E,
  0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0x80, 0x03, 0xFF, 0xF0, 0x03, 0xF0, 0x00,
  0x7F, 0xFC, 0x00, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x7F, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0xFE,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x3F, 0x81, 0xFC, 0x00,
  0x01, 0xFC, 0x1F, 0xE0, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x00, 0x7F, 0x1F,
  0xE0, 0x00, 0x03, 0xFD, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0x03, 0xFF,
  0xF8, 0x07, 0xF8, 0x3F, 0xFF, 0xE0, 0x3F, 0x83, 0xFE, 0xFF, 0x03, 0xFC,
  0x3F, 0xE3, 0xFC, 0x1F, 0xC3, 0xFE, 0x1F, 0xE1, 0xFE, 0x1F, 0xE0, 0x7F,
  0x8F, 0xE1, 0xFE, 0x03, 0xFE, 0xFF, 0x0F, 0xF0, 0x0F, 0xFF, 0xF0, 0x7F,
  0x00, 0x7F, 0xFF, 0x07, 0xF8, 0x01, 0xFF, 0xF8, 0x3F, 0xC0, 0x07, 0xFF,
  0x81, 0xFE, 0x00, 0x3F, 0xF8, 0x0F, 0xF0, 0x00, 0xFF, 0xC0, 0x7F, 0x80,
  0x07, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xF8, 0x1F, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xF1, 0xFE, 0x00, 0xFF, 0xFF, 0x0F, 0xF8, 0x01,
  0xFF, 0xE0, 0x3F, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xCF, 0xF3,
  0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF0, 0xFC, 0x7F, 0x1F, 0x87, 0xE1, 0xF8,
  0x7E, 0x1F, 0x07, 0xC3, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x10, 0x03, 0xE0, 0x07, 0x01, 0xF8, 0x01, 0xF0, 0x7E,
  0x00, 0x7F, 0x1F, 0x80, 0x3F, 0xF7, 0xC0, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0x01, 0xFF, 0x80, 0x40, 0xFF, 0xE0, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0x9F, 0x00, 0x3F, 0xC7, 0xE0, 0x1F, 0xE1, 0xF8, 0x03, 0xF8,
  0x3F, 0x00, 0x7C, 0x0F, 0xE0, 0x0E, 0x03, 0xF8, 0x01, 0x80, 0x7E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x0F, 0xF0, 0x7F,
  0x81, 0xFE, 0x07, 0xF0, 0x3F, 0xC0, 0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0x7F,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x01, 0xFC, 0x07, 0xE0, 0x3F, 0x00, 0x7F,
  0xFF, 0xBF, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xE7, 0xFF, 0xF7, 0xFF, 0xF0,
  0x1E, 0x3F, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xC0, 0x3F, 0xE1, 0xFE, 0x03, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x3F,
  0xC1, 0xFE, 0x01, 0xFE, 0x0F, 0xF0, 0x07, 0xF0, 0xFF, 0x00, 0x3F, 0x87,
  0xF8, 0x01, 0xFC, 0x7F, 0x80, 0x0F, 0xE3, 0xFC, 0x00, 0x7F, 0x1F, 0xC0,
  0x03, 0xF9, 0xFE, 0x00, 0x3F, 0xCF, 0xF0, 0x01, 0xFE, 0x7F, 0x80, 0x0F,
  0xF3, 0xF8, 0x00, 0x7F, 0xBF, 0xC0, 0x03, 0xFD, 0xFE, 0x00, 0x1F, 0xCF,
  0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x7F, 0xBF, 0xC0,
  0x03, 0xFD, 0xFE, 0x00, 0x1F, 0xCF, 0xF0, 0x01, 0xFE, 0x7F, 0x80, 0x0F,
  0xF3, 0xFC, 0x00, 0x7F, 0x9F, 0xE0, 0x07, 0xF8, 0xFF, 0x00, 0x3F, 0xC7,
  0xF8, 0x01, 0xFE, 0x3F, 0xC0, 0x1F, 0xE1, 0xFE, 0x00, 0xFF, 0x0F, 0xF0,
  0x0F, 0xF0, 0x7F, 0x80, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00,
  0x7F, 0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0x81, 0xFF, 0xFC,
  0x1F, 0xFF, 0xE3, 0xFF, 0x7F, 0x3F, 0xF7, 0xF9, 0xFF, 0x3F, 0x87, 0xF1,
  0xFC, 0x1E, 0x0F, 0xE0, 0xE0, 0xFF, 0x02, 0x07, 0xF8, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0x7E,
  0x01, 0xFF, 0x00, 0x38, 0x00, 0xFF, 0x00, 0x30, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0x03,
  0xFF, 0x00, 0x70, 0x03, 0xFE, 0x00, 0x40, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFF, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0x10, 0x00, 0x07, 0xFC, 0x30, 0x00, 0x1F,
  0xF0, 0x7C, 0x00, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3D, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0xFD, 0xFC, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x01, 0xFB,
  0xF8, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x0F, 0xE3,
  0xF8, 0x00, 0x0F, 0xC7, 0xF8, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x3F, 0x87,
  0xF0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFC, 0x0F,
  0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xF8, 0x0F, 0xE0, 0x07, 0xF0, 0x0F,
  0xE0, 0x07, 0xE0, 0x1F, 0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x3F, 0x80, 0x1F, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xF0, 0x01, 0xC0, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x08, 0x00, 0x07, 0xFC, 0x18, 0x00, 0x3F, 0xF0,
  0x3E, 0x01, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x1D, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x3F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFF, 0x0F, 0xC0, 0x03, 0xF8, 0xFF, 0xC0, 0x0F, 0xE7, 0xFF, 0xC0, 0x7F,
  0xBF, 0xFF, 0x01, 0xFD, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFE,
  0x3F, 0xF0, 0xFF, 0xE0, 0x3F, 0xC3, 0xFF, 0x00, 0xFF, 0x0F, 0xF8, 0x03,
  0xFC, 0x3F, 0xC0, 0x07, 0xF0, 0xFF, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x7F,
  0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xF0, 0xFE, 0x00, 0x3F, 0xC3,
  0xF8, 0x00, 0xFF, 0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xE0, 0xFE,
  0x00, 0x7F, 0x83, 0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0,
  0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80,
  0x3F, 0xE3, 0xFF, 0x00, 0xFF, 0x01, 0xFE, 0x01, 0xFC, 0x01, 0xFE, 0x03,
  0xF8, 0x03, 0xFC, 0x0F, 0xF0, 0x07, 0xF8, 0x1F, 0xE0, 0x0F, 0xF0, 0x3F,
  0x80, 0x1F, 0xE0, 0x7F, 0x80, 0x3F, 0x80, 0xFF, 0x00, 0x7F, 0x00, 0xFE,
  0x01, 0xFE, 0x01, 0xFE, 0x07, 0xF8, 0x03, 0xFC, 0x1F, 0xE0, 0x03, 0xFC,
  0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xF3, 0xFE, 0x00, 0xFF, 0x83, 0xFE,
  0x03, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x03, 0xFC, 0x1F, 0xE0, 0x07, 0xF8,
  0x3F, 0x80, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x1F, 0xC3,
  0xFC, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0xFE, 0x1F,
  0xE0, 0x03, 0xFC, 0x1F, 0xE0, 0x0F, 0xF0, 0x3F, 0xE0, 0x3F, 0xE0, 0x7F,
  0xF1, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0x83, 0xFE, 0x07, 0xF8, 0x0F, 0xF0,
  0x7F, 0x80, 0x3F, 0x83, 0xF8, 0x01, 0xFC, 0x3F, 0xC0, 0x0F, 0xF1, 0xFE,
  0x00, 0x7F, 0x8F, 0xE0, 0x03, 0xFC, 0xFF, 0x00, 0x1F, 0xE7, 0xF8, 0x00,
  0xFF, 0x3F, 0xC0, 0x07, 0xF9, 0xFE, 0x00, 0x3F, 0xCF, 0xF0, 0x03, 0xFC,
  0x7F, 0x80, 0x1F, 0xE3, 0xFC, 0x01, 0xFF, 0x1F, 0xE0, 0x1F, 0xF8, 0xFF,
  0x81, 0xFF, 0xC3, 0xFF, 0x3F, 0xFE, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFB, 0xF8, 0x0F, 0xFF, 0xBF, 0xC0, 0x3F, 0xF1, 0xFC,
  0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x10, 0x03, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x38, 0x01, 0xFC, 0x07, 0xF8,
  0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFE, 0x01, 0xFC, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x01, 0xFC, 0x07, 0xFC,
  0x0F, 0xF8, 0x1F, 0xF0, 0x7F, 0xE0, 0x7F, 0x80, 0xFF, 0x01, 0xFC, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x07, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x00,
  0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x03, 0xFF, 0xC0, 0x3F, 0xFF,
  0xC1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0x8F, 0x80, 0xFF, 0x18, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0xFE, 0x00, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x01, 0xFF, 0x01, 0xF8, 0x1F,
  0x80, 0x3F, 0xFF, 0x83, 0xE0, 0x7E, 0x01, 0xFF, 0xFE, 0x0F, 0x83, 0xF0,
  0x0F, 0xFF, 0xF0, 0x3F, 0x0F, 0x80, 0x7F, 0xFF, 0xC0, 0xFC, 0x7E, 0x03,
  0xF8, 0x3F, 0x03, 0xF1, 0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0xCF, 0xC0, 0xFE,
  0x03, 0xE0, 0x3F, 0x3F, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0xF8, 0x1F, 0x80,
  0x7E, 0x03, 0xE7, 0xE0, 0x7E, 0x01, 0xF8, 0x0F, 0x9F, 0x81, 0xF0, 0x07,
  0xC0, 0x7E, 0x7E, 0x0F, 0xC0, 0x3F, 0x01, 0xF9, 0xF0, 0x3F, 0x00, 0xFC,
  0x07, 0xE7, 0xC0, 0xFC, 0x03, 0xF0, 0x1F, 0x1F, 0x03, 0xE0, 0x1F, 0x80,
  0xFC, 0x7C, 0x0F, 0x80, 0x7E, 0x03, 0xF3, 0xF0, 0x3E, 0x01, 0xF8, 0x1F,
  0x8F, 0xC0, 0xF8, 0x0F, 0xE0, 0x7E, 0x3F, 0x03, 0xE0, 0x7F, 0x83, 0xF0,
  0xFC, 0x0F, 0xC1, 0xFE, 0x1F, 0x81, 0xF0, 0x3F, 0xDF, 0xFD, 0xFE, 0x07,
  0xC0, 0xFF, 0xFB, 0xFF, 0xF0, 0x1F, 0x01, 0xFF, 0xC7, 0xFF, 0x80, 0x7E,
  0x03, 0xFE, 0x1F, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x40, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0xFF, 0x8F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFD,
  0xF8, 0x00, 0x00, 0x3F, 0xBF, 0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x01,
  0xFC, 0xFC, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x0F, 0xE3, 0xF0, 0x00,
  0x01, 0xFC, 0x7E, 0x00, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x0F, 0xE1, 0xFC,
  0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0xFE, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x7F, 0x00, 0x07, 0xF8, 0x0F, 0xE0, 0x00, 0xFE, 0x01, 0xFC, 0x00,
  0x3F, 0xC0, 0x3F, 0x80, 0x07, 0xF0, 0x07, 0xF0, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0x80, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x7F, 0x03,
  0xFC, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x01, 0xFC, 0x1F, 0xE0, 0x00, 0x3F,
  0x87, 0xF8, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x00, 0xFE, 0x3F, 0xC0, 0x00,
  0x1F, 0xC7, 0xF8, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x00, 0x7F, 0xBF, 0xC0,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xF0, 0x7F,
  0xF8, 0x03, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0x80,
  0x0F, 0xF0, 0x1F, 0xE0, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0xFF, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x07, 0xF8, 0x0F,
  0xF0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x3F, 0x80, 0x0F, 0xF0, 0x0F, 0xE0, 0x01, 0xFC, 0x07, 0xF8,
  0x00, 0x7F, 0x81, 0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x07, 0xF8, 0x1F,
  0xC0, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0xFF, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x0F, 0xF8, 0x0F, 0xE0, 0x07, 0xFE,
  0x03, 0xF8, 0x1F, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0xFC, 0x01, 0xFF, 0xC0, 0x06, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x08, 0x00, 0xFF, 0xE0, 0x3E, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xE0, 0x03, 0xFE,
  0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x01, 0xFE, 0x01, 0xFE, 0x00,
  0x1F, 0xF0, 0x1F, 0xE0, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x3F,
  0xC0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0xFF,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x00, 0xFF, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x7F, 0x80, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x7F,
  0x80, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x01, 0xFE,
  0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x00,
  0x7F, 0xC1, 0xFE, 0x00, 0x07, 0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0x81, 0xFE,
  0x00, 0x0F, 0xF8, 0x1F, 0xE0, 0x01, 0xFF, 0x01, 0xFC, 0x00, 0x3F, 0xF0,
  0x3F, 0xC0, 0x07, 0xFE, 0x03, 0xFC, 0x00, 0xFF, 0xC0, 0x3F, 0xC0, 0x1F,
  0xFC, 0x03, 0xFC, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0x80, 0xFC, 0x01, 0xFF, 0xC0, 0x01, 0xC0, 0x1F, 0xF8, 0x00, 0x04, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x07, 0xF8, 0x01, 0xFF, 0xFC, 0x7F, 0x80, 0x1F, 0xFF, 0x87, 0xF8, 0x01,
  0xFF, 0xF8, 0x7F, 0x80, 0x3F, 0xFF, 0x87, 0xF8, 0x03, 0xFF, 0xF8, 0x7F,
  0x80, 0x3F, 0xFF, 0x8F, 0xF8, 0x03, 0xFF, 0xF0, 0xFF, 0x00, 0x00, 0xFF,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0xFF, 0x80, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x7F,
  0x80, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x01, 0xFC,
  0x07, 0xFE, 0x00, 0x1F, 0xC0, 0x3F, 0xF0, 0x03, 0xFC, 0x03, 0xFF, 0xC0,
  0x7F, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x07,
  0xF8, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x03,
  0xF8, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x01, 0xFE, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x0F, 0xF0,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x1F, 0xE0,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x07, 0xF8,
  0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x20,
  0x3F, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0x80, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x07, 0xFE, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0xFF,
  0x80, 0x07, 0xF0, 0x03, 0xFE, 0x00, 0x0F, 0xE0, 0x0F, 0xF8, 0x00, 0x3F,
  0xC0, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x00, 0xFE, 0x01, 0xFF,
  0x00, 0x01, 0xFC, 0x07, 0xFC, 0x00, 0x03, 0xF8, 0x1F, 0xF0, 0x00, 0x0F,
  0xF0, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0x3F, 0x83, 0xFC,
  0x00, 0x00, 0x7F, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x3F, 0xE0, 0x00, 0x03,
  0xFC, 0xFF, 0x80, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x00, 0x0F, 0xE7, 0xF8,
  0x00, 0x00, 0x1F, 0xDF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0xF7, 0xF8, 0x00, 0x00, 0x7F, 0xC7, 0xF8, 0x00, 0x00, 0xFE, 0x0F,
  0xF0, 0x00, 0x01, 0xFC, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x00, 0x3F, 0x80,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x03, 0xFE, 0x00, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0x0F, 0xE0,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0x1F,
  0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x03,
  0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x00,
  0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00,
  0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0,
  0x00, 0xFD, 0xFC, 0x01, 0xFD, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0x7E,
  0x00, 0x1F, 0xBF, 0x80, 0x1F, 0x9F, 0x80, 0x0F, 0xEF, 0xE0, 0x0F, 0xE7,
  0xE0, 0x03, 0xF3, 0xF8, 0x03, 0xF9, 0xF8, 0x01, 0xFD, 0xFE, 0x00, 0xFE,
  0x7E, 0x00, 0x7E, 0x7F, 0x00, 0x3F, 0x9F, 0x80, 0x3F, 0x9F, 0xC0, 0x0F,
  0xE7, 0xE0, 0x0F, 0xC7, 0xF0, 0x07, 0xF1, 0xF8, 0x07, 0xF3, 0xFC, 0x01,
  0xFC, 0x7E, 0x01, 0xF8, 0xFE, 0x00, 0x7F, 0x1F, 0x80, 0xFE, 0x3F, 0x80,
  0x1F, 0xC7, 0xE0, 0x3F, 0x0F, 0xE0, 0x07, 0xF1, 0xF8, 0x1F, 0xC3, 0xF8,
  0x03, 0xF8, 0x7F, 0x07, 0xE1, 0xFE, 0x00, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F,
  0x00, 0x3F, 0x83, 0xF0, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0xFC, 0x7F, 0x07,
  0xF0, 0x07, 0xF0, 0x3F, 0x1F, 0x81, 0xFC, 0x01, 0xFC, 0x0F, 0xCF, 0xE0,
  0xFF, 0x00, 0x7F, 0x03, 0xF3, 0xF0, 0x3F, 0x80, 0x1F, 0xC0, 0xFD, 0xFC,
  0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0x7E, 0x03, 0xF8, 0x03, 0xF8, 0x0F, 0xFF,
  0x80, 0xFE, 0x00, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0x80, 0x3F, 0x80, 0xFF,
  0xF0, 0x1F, 0xC0, 0x0F, 0xE0, 0x3F, 0xF8, 0x07, 0xF0, 0x03, 0xF8, 0x0F,
  0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x00,
  0xFF, 0xC0, 0x3F, 0x80, 0x1F, 0xC0, 0x3F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0,
  0x0F, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0,
  0x1F, 0xF8, 0x00, 0x0F, 0xF0, 0x07, 0xFE, 0x00, 0x03, 0xF8, 0x01, 0xFF,
  0x80, 0x00, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0x80, 0x1F, 0xFC, 0x00,
  0x0F, 0xE0, 0x0F, 0xFF, 0x00, 0x07, 0xF0, 0x03, 0xFF, 0xC0, 0x01, 0xFC,
  0x00, 0xFF, 0xF8, 0x00, 0x7F, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xC0, 0x1F,
  0xFF, 0x80, 0x07, 0xF0, 0x07, 0xFF, 0xF0, 0x03, 0xF8, 0x01, 0xFD, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x9F, 0xC0, 0x0F,
  0xE0, 0x0F, 0xE3, 0xF8, 0x07, 0xF8, 0x03, 0xF8, 0xFE, 0x01, 0xFC, 0x00,
  0xFE, 0x3F, 0x80, 0x7F, 0x00, 0x3F, 0x8F, 0xF0, 0x1F, 0xC0, 0x0F, 0xE1,
  0xFC, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x03, 0xFC, 0x01, 0xFC, 0x1F, 0xC0,
  0xFE, 0x00, 0x7F, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0,
  0x07, 0xF0, 0x3F, 0x83, 0xF8, 0x03, 0xF8, 0x0F, 0xF1, 0xFC, 0x00, 0xFE,
  0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x80, 0x7F, 0x1F, 0xC0, 0x0F, 0xE0, 0x1F,
  0xC7, 0xF0, 0x07, 0xF8, 0x07, 0xF9, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x7E,
  0x00, 0x7F, 0x00, 0x3F, 0xBF, 0x80, 0x1F, 0xC0, 0x0F, 0xEF, 0xE0, 0x07,
  0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0xFE, 0x00,
  0x1F, 0xFF, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0xFF,
  0xF0, 0x03, 0xF8, 0x00, 0x3F, 0xFC, 0x01, 0xFC, 0x00, 0x0F, 0xFF, 0x00,
  0x7F, 0x00, 0x01, 0xFF, 0x80, 0x1F, 0xC0, 0x00, 0x7F, 0xE0, 0x07, 0xF0,
  0x00, 0x1F, 0xF8, 0x01, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xFC, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xF8, 0x00,
  0xFF, 0x80, 0xFF, 0x80, 0x03, 0xFC, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0xFF,
  0x80, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x1F,
  0xE3, 0xFE, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x07, 0xF9, 0xFF, 0x00,
  0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x0F, 0xF3,
  0xFC, 0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x00,
  0x3F, 0xCF, 0xF0, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x0F, 0xF3, 0xFC,
  0x00, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x07, 0xFD, 0xFE, 0x00, 0x00, 0x3F,
  0xCF, 0xF0, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x1F, 0xF3, 0xFC, 0x00,
  0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0xFF, 0x80, 0x00, 0x7F, 0xC7,
  0xFC, 0x00, 0x07, 0xFC, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x03,
  0xFE, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0xFF,
  0x80, 0x3F, 0xF0, 0x07, 0xFF, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03,
  0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x1F, 0xE0,
  0x1F, 0xE0, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x7F, 0x80, 0x0F, 0xF0, 0x1F, 0xC0, 0x03, 0xF8, 0x0F, 0xF0, 0x01,
  0xFE, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x1F, 0xE0, 0x3F, 0x80,
  0x0F, 0xF0, 0x0F, 0xE0, 0x07, 0xFC, 0x07, 0xF8, 0x03, 0xFE, 0x01, 0xFE,
  0x07, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0xFC, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x1F,
  0xF8, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x03, 0xFC, 0x0F, 0xF8, 0x00, 0x1F,
  0xE0, 0xFF, 0x80, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x3F, 0xC0,
  0x00, 0x1F, 0xE3, 0xFE, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x07, 0xF9,
  0xFF, 0x00, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00,
  0x0F, 0xF3, 0xFC, 0x00, 0x00, 0xFF, 0xBF, 0xC0, 0x00, 0x07, 0xF9, 0xFE,
  0x00, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x0F,
  0xF3, 0xFC, 0x00, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x07, 0xFD, 0xFE, 0x00,
  0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x1F, 0xF3,
  0xFC, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00,
  0x7F, 0xC7, 0xFC, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0xFF,
  0x00, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x3F, 0xE0, 0x03, 0xFF,
  0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFF, 0x07, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFC, 0x3F, 0xFC, 0x01, 0xFE,
  0x03, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0x00, 0x3F, 0xC0, 0x7F,
  0x80, 0x1F, 0xE0, 0x3F, 0xC0, 0x0F, 0xF0, 0x1F, 0xE0, 0x07, 0xF8, 0x0F,
  0xF0, 0x03, 0xFC, 0x07, 0xF0, 0x01, 0xFE, 0x07, 0xF8, 0x01, 0xFE, 0x03,
  0xFC, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0xFE, 0x00, 0x7F, 0x80,
  0x7F, 0x00, 0xFF, 0xC0, 0x7F, 0x81, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFE, 0x1F, 0xE0,
  0x00, 0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x7F, 0x81, 0xFE,
  0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x0F, 0xE0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x01,
  0xFE, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0xFF, 0x00,
  0x1F, 0xE0, 0x7F, 0x80, 0x0F, 0xF0, 0x3F, 0xC0, 0x07, 0xF8, 0x1F, 0xC0,
  0x03, 0xFE, 0x0F, 0xE0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xC1, 0xF8, 0x01, 0xFF, 0x00, 0x38, 0x01,
  0xFE, 0x00, 0x08, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x3F, 0xC0, 0x40, 0x00, 0x7F, 0xC0, 0x70, 0x00, 0xFF, 0x80, 0x7E,
  0x03, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0xFF,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x00, 0xFE, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x7F, 0x80, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x7F,
  0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x03, 0xFC,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0xFE, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x7F, 0x81, 0xFE,
  0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x07, 0xF0,
  0x3F, 0xC0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00,
  0xFF, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x01, 0xFE, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x7F, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x03,
  0xFC, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x03, 0xFC, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0xFE, 0x00, 0x07, 0xF8, 0x0F, 0xE0, 0x00, 0x7F, 0x80,
  0xFE, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x1F,
  0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0xE0, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x7F, 0xBF, 0x80, 0x00, 0x3F, 0xDF, 0xC0, 0x00, 0x3F, 0xCF, 0xE0,
  0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x0F, 0xF1, 0xFC,
  0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x07, 0xF8, 0x3F,
  0xC0, 0x03, 0xFC, 0x1F, 0xE0, 0x03, 0xFC, 0x0F, 0xF0, 0x01, 0xFE, 0x03,
  0xF8, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x3F, 0xC0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x07, 0xF0, 0x1F, 0xE0, 0x03, 0xF8, 0x0F, 0xE0,
  0x01, 0xFC, 0x0F, 0xF0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x7F, 0x07, 0xF8,
  0x00, 0x3F, 0x83, 0xF8, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x0F, 0xE1, 0xFC,
  0x00, 0x07, 0xF0, 0xFE, 0x00, 0x01, 0xF8, 0xFE, 0x00, 0x00, 0xFC, 0x7F,
  0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x1F, 0xBF,
  0x80, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFB, 0xF8, 0x00, 0x3F, 0xE0, 0x01,
  0xFE, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xBF, 0x80, 0x07, 0xFE, 0x00,
  0x3F, 0xCF, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xF3, 0xF8, 0x00, 0xFF, 0xE0,
  0x03, 0xF8, 0xFE, 0x00, 0x3F, 0xF8, 0x01, 0xFE, 0x3F, 0x80, 0x0F, 0xFE,
  0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xFF, 0x80, 0x3F, 0xC3, 0xF8, 0x01, 0xFF,
  0xE0, 0x0F, 0xF0, 0xFE, 0x00, 0xFD, 0xF8, 0x03, 0xF8, 0x3F, 0x80, 0x3F,
  0x7E, 0x01, 0xFE, 0x0F, 0xE0, 0x1F, 0xDF, 0x80, 0x7F, 0x03, 0xF8, 0x07,
  0xE7, 0xE0, 0x3F, 0xC0, 0xFE, 0x01, 0xF9, 0xF8, 0x0F, 0xE0, 0x3F, 0x80,
  0xFE, 0x7E, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x1F, 0x81, 0xFE, 0x03, 0xF8,
  0x1F, 0xC7, 0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xE1, 0xF8, 0x3F, 0xC0, 0x3F,
  0x83, 0xF8, 0x7E, 0x0F, 0xE0, 0x0F, 0xE0, 0xFC, 0x1F, 0x87, 0xF8, 0x03,
  0xF8, 0x7F, 0x07, 0xE1, 0xFC, 0x00, 0xFE, 0x1F, 0xC1, 0xF8, 0x7F, 0x00,
  0x3F, 0x87, 0xE0, 0x7E, 0x3F, 0xC0, 0x0F, 0xE3, 0xF8, 0x1F, 0x8F, 0xE0,
  0x03, 0xF8, 0xFC, 0x07, 0xE3, 0xF8, 0x00, 0xFE, 0x7F, 0x01, 0xF9, 0xFC,
  0x00, 0x3F, 0x9F, 0x80, 0x7E, 0x7F, 0x00, 0x0F, 0xE7, 0xE0, 0x1F, 0xBF,
  0x80, 0x03, 0xFB, 0xF8, 0x07, 0xEF, 0xE0, 0x00, 0xFE, 0xFC, 0x01, 0xFB,
  0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x1F,
  0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0x00,
  0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0,
  0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x3F,
  0xE0, 0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00,
  0x07, 0xF8, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x00, 0xFE,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x00, 0x3F, 0xC7, 0xF8,
  0x00, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0x00,
  0xFF, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x9F, 0xE0, 0x00, 0x00, 0x7F, 0x8F,
  0xF0, 0x00, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x00, 0x7F, 0xC1, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x00, 0x3F,
  0xE0, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x07,
  0xF8, 0x00, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x0F, 0xF8,
  0x00, 0x1F, 0xE0, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0xFE, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x0F, 0xFB, 0xFC, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x7F,
  0x87, 0xF0, 0x00, 0xFF, 0x0F, 0xE0, 0x03, 0xFC, 0x1F, 0xC0, 0x0F, 0xF8,
  0x3F, 0xC0, 0x1F, 0xE0, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0xFF, 0x00,
  0xFE, 0x03, 0xFC, 0x01, 0xFC, 0x0F, 0xF0, 0x03, 0xFC, 0x1F, 0xE0, 0x07,
  0xF8, 0x7F, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x1F,
  0xC7, 0xF0, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x03, 0xFF,
  0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00,
  0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0,
  0x00, 0xFC, 0x07, 0xE0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x07, 0xFF,
  0xC0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x80,
  0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x03, 0xF3, 0xF0,
  0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x03, 0xF8, 0x7E, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0x0F,
  0xC0, 0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x01, 0xF8, 0x01, 0xF8, 0x0F, 0xE0,
  0x07, 0xE0, 0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3F, 0x0F, 0xE0, 0x00,
  0xFC, 0x3F, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x1F,
  0xBF, 0x80, 0x00, 0x3F, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xF8, 0x7F, 0x83, 0xF8, 0x1F, 0xC1,
  0xFC, 0x0F, 0xE0, 0x7E, 0x03, 0xE0, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3F, 0xE0, 0xFC, 0x01, 0xFF, 0xE3, 0xF8, 0x07, 0xFF, 0xE7, 0xF0, 0x1F,
  0xFF, 0xCF, 0xC0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x03, 0xFE,
  0x0F, 0xFE, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xE0, 0x0F, 0xF0, 0x7F, 0x80,
  0x1F, 0xE0, 0xFF, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x7F, 0x87, 0xF8, 0x00,
  0xFE, 0x0F, 0xF0, 0x01, 0xFC, 0x3F, 0xC0, 0x03, 0xF8, 0x7F, 0x80, 0x0F,
  0xF0, 0xFF, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x7F,
  0x0F, 0xF0, 0x01, 0xFE, 0x1F, 0xE0, 0x03, 0xFC, 0x3F, 0xC0, 0x07, 0xF0,
  0x7F, 0x80, 0x1F, 0xE0, 0xFF, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0xFF, 0x83,
  0xFC, 0x03, 0xFF, 0x07, 0xFC, 0x0F, 0xFC, 0x07, 0xF8, 0x3F, 0xF8, 0x0F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xDF, 0xC0, 0x3F,
  0xFF, 0x3F, 0x00, 0x3F, 0xFC, 0x7E, 0x00, 0x3F, 0xE0, 0xFC, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x81, 0xE0, 0x00, 0x7F, 0x1F,
  0xF0, 0x00, 0xFE, 0x7F, 0xF8, 0x03, 0xFD, 0xFF, 0xF0, 0x07, 0xF7, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xF0, 0x3F,
  0xC0, 0xFF, 0xC0, 0x7F, 0x81, 0xFF, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0xFE,
  0x07, 0xF8, 0x01, 0xFE, 0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0xC0, 0x07, 0xF0,
  0x7F, 0x80, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x7F, 0x87,
  0xF8, 0x00, 0xFF, 0x0F, 0xE0, 0x01, 0xFE, 0x1F, 0xC0, 0x03, 0xFC, 0x3F,
  0x80, 0x07, 0xF0, 0x7F, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x3F, 0xC3, 0xFC,
  0x00, 0xFF, 0x07, 0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x07, 0xFC, 0x1F, 0xE0,
  0x0F, 0xF0, 0x7F, 0xE0, 0x3F, 0xE0, 0xFF, 0xC0, 0xFF, 0x81, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xEF, 0xFF, 0xF0, 0x1F, 0xCF, 0xFF,
  0xC0, 0x3F, 0x1F, 0xFF, 0x00, 0x7E, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x03,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x7F, 0xFB, 0xF0,
  0x1F, 0xF0, 0x0C, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x20, 0x7F, 0xC0, 0x78, 0x1F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF0, 0x3F, 0x80, 0x01, 0xFF,
  0x0F, 0xE0, 0x01, 0xFF, 0xE7, 0xF8, 0x00, 0xFF, 0xFD, 0xFC, 0x00, 0x7F,
  0xFF, 0x7F, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFD, 0xFF, 0xF0, 0x07,
  0xFC, 0x1F, 0xFC, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x7F, 0x80, 0x1F, 0xE0, 0x1F, 0xE0, 0x07, 0xF8, 0x0F, 0xF0, 0x01, 0xFE,
  0x03, 0xFC, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x07,
  0xF0, 0x1F, 0xE0, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0xFE, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x7F, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x07, 0xF8, 0x0F, 0xF0,
  0x01, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x3F,
  0xC0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xFC, 0x03, 0xFC, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0xFF, 0x80, 0x1F, 0xE0, 0x7F, 0xE0, 0x07, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xBF, 0x80, 0x0F, 0xFF, 0xCF,
  0xC0, 0x01, 0xFF, 0xE3, 0xF0, 0x00, 0x1F, 0xE0, 0xFC, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0,
  0xFF, 0x87, 0xF8, 0x3F, 0xC0, 0x7F, 0x0F, 0xF0, 0x0F, 0xE1, 0xFC, 0x01,
  0xFC, 0x7F, 0x80, 0x3F, 0x8F, 0xE0, 0x07, 0xF3, 0xFC, 0x01, 0xFE, 0x7F,
  0x00, 0x7F, 0x8F, 0xE0, 0x3F, 0xF3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x01, 0x07, 0xFC, 0x00, 0xE0, 0xFF, 0xE0, 0xFC, 0x0F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFE, 0x10, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x87, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xFE, 0x0F, 0xC0, 0x07, 0xFF, 0x8F, 0xE0, 0x07, 0xFF,
  0xE7, 0xF0, 0x07, 0xFF, 0xFB, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFC, 0x03, 0xFE, 0x0F, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x01, 0xFE,
  0x00, 0xFF, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x3F, 0xC0, 0xFF,
  0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x0F, 0xE0, 0x3F, 0xC0, 0x07, 0xF0, 0x3F,
  0xC0, 0x03, 0xF8, 0x1F, 0xE0, 0x03, 0xFC, 0x0F, 0xF0, 0x01, 0xFE, 0x07,
  0xF8, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x7F, 0x81,
  0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x1F, 0xE0,
  0x3F, 0xC0, 0x0F, 0xF0, 0x1F, 0xE0, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xFC,
  0x07, 0xFC, 0x0F, 0xFC, 0x01, 0xFE, 0x0F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xBF, 0x80, 0x1F, 0xFF, 0xBF, 0xC0, 0x0F, 0xFF, 0xDF,
  0xC0, 0x03, 0xFF, 0x8F, 0xE0, 0x00, 0xFF, 0x87, 0xF0, 0x00, 0x04, 0x07,
  0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x40, 0x00,
  0x7F, 0x80, 0x38, 0x00, 0x7F, 0x80, 0x1F, 0x80, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x3E, 0x00, 0x1F, 0xC3, 0xFE, 0x00, 0x7F, 0x3F, 0xFC,
  0x03, 0xFD, 0xFF, 0xF8, 0x0F, 0xEF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0x03, 0xFC, 0x1F, 0xF8, 0x0F, 0xF0, 0x7F,
  0xC0, 0x1F, 0xC1, 0xFF, 0x00, 0x7F, 0x07, 0xF8, 0x01, 0xFC, 0x1F, 0xE0,
  0x0F, 0xF0, 0xFF, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0xFE, 0x0F, 0xF0, 0x03,
  0xF8, 0x3F, 0x80, 0x0F, 0xE1, 0xFE, 0x00, 0x7F, 0x87, 0xF8, 0x01, 0xFE,
  0x1F, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x7F, 0x0F,
  0xF0, 0x03, 0xFC, 0x3F, 0xC0, 0x0F, 0xF0, 0xFE, 0x00, 0x3F, 0x83, 0xF8,
  0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF8, 0x7F, 0x80, 0x1F, 0xE1, 0xFE, 0x00,
  0x7F, 0x87, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0xFF, 0x00, 0x3F,
  0xC3, 0xFC, 0x00, 0xFF, 0x0F, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xE0,
  0x00, 0x3F, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF8, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0,
  0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF8, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x02, 0x1F, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x04,
  0x07, 0xF0, 0x03, 0xFC, 0x03, 0xF8, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC,
  0x01, 0xFE, 0x03, 0xFC, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0x03, 0xFC,
  0x00, 0x3F, 0x83, 0xFE, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x1F, 0xE1, 0xFE,
  0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x07, 0xF1, 0xFE, 0x00, 0x03, 0xF9, 0xFE,
  0x00, 0x03, 0xF9, 0xFE, 0x00, 0x01, 0xFD, 0xFE, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFD,
  0xFE, 0x00, 0x07, 0xFC, 0x7F, 0x80, 0x03, 0xFC, 0x3F, 0xC0, 0x01, 0xFC,
  0x0F, 0xE0, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0xFF, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x1F, 0xC0, 0x3F, 0xC0, 0x0F,
  0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x03,
  0xF8, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0xFF, 0xC0,
  0x7F, 0xE0, 0x07, 0xE3, 0xFF, 0xC1, 0xFF, 0xE0, 0x1F, 0xCF, 0xFF, 0x87,
  0xFF, 0xE0, 0x3F, 0x3F, 0xFF, 0x9F, 0xFF, 0xC0, 0x7E, 0xFF, 0xFF, 0x7F,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0x81, 0xFF, 0x83, 0xFF, 0xE0,
  0xFF, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFE, 0x0F, 0xF8, 0x07, 0xFE, 0x03,
  0xFC, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE1, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x83, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFE,
  0x0F, 0xE0, 0x07, 0xF8, 0x03, 0xFC, 0x3F, 0xC0, 0x0F, 0xE0, 0x07, 0xF8,
  0x7F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC1,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x83, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0x0F,
  0xF0, 0x03, 0xF8, 0x01, 0xFE, 0x1F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x3F,
  0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x87, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x1F, 0xC0,
  0x0F, 0xF0, 0x07, 0xF8, 0x7F, 0x80, 0x1F, 0xC0, 0x0F, 0xF0, 0xFF, 0x00,
  0x3F, 0x80, 0x1F, 0xC1, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x83, 0xF8, 0x01,
  0xFE, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x07, 0xE1, 0xFF, 0x80,
  0x1F, 0x8F, 0xFF, 0x00, 0xFE, 0x7F, 0xFE, 0x03, 0xF3, 0xFF, 0xF8, 0x0F,
  0xDF, 0xFF, 0xF0, 0x3F, 0x7F, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0x07, 0xFE,
  0x03, 0xFC, 0x1F, 0xF8, 0x07, 0xF0, 0x7F, 0xC0, 0x1F, 0xC1, 0xFE, 0x00,
  0x7F, 0x0F, 0xF8, 0x03, 0xFC, 0x3F, 0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x3F,
  0xC3, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xF8, 0x7F, 0x80, 0x1F, 0xE1,
  0xFE, 0x00, 0x7F, 0x87, 0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0x7F,
  0x00, 0x3F, 0xC3, 0xFC, 0x00, 0xFF, 0x0F, 0xF0, 0x03, 0xFC, 0x3F, 0x80,
  0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0x87, 0xF8, 0x01, 0xFE, 0x1F, 0xE0, 0x07,
  0xF8, 0x7F, 0x80, 0x1F, 0xE1, 0xFC, 0x00, 0x7F, 0x07, 0xF0, 0x01, 0xFC,
  0x3F, 0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0xFE, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0x83, 0xFE, 0x0F, 0xF0, 0x0F,
  0xF0, 0xFF, 0x80, 0x3F, 0x87, 0xF8, 0x01, 0xFE, 0x7F, 0x80, 0x0F, 0xF3,
  0xFC, 0x00, 0x7F, 0x9F, 0xE0, 0x03, 0xFD, 0xFE, 0x00, 0x1F, 0xEF, 0xF0,
  0x00, 0xFF, 0x7F, 0x80, 0x07, 0xF3, 0xF8, 0x00, 0x3F, 0x9F, 0xC0, 0x01,
  0xFC, 0xFE, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0xFF, 0x7F, 0x80, 0x07, 0xFB,
  0xFC, 0x00, 0x7F, 0x9F, 0xE0, 0x03, 0xFC, 0xFF, 0x00, 0x1F, 0xE7, 0xF8,
  0x01, 0xFE, 0x1F, 0xC0, 0x1F, 0xF0, 0xFF, 0x01, 0xFF, 0x07, 0xFC, 0x1F,
  0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xC3, 0xFE, 0x00,
  0x03, 0xF1, 0xFF, 0xE0, 0x01, 0xFC, 0xFF, 0xF8, 0x00, 0x7E, 0x7F, 0xFF,
  0x00, 0x1F, 0xBF, 0xFF, 0xE0, 0x07, 0xFF, 0x9F, 0xF8, 0x01, 0xFF, 0x81,
  0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0x80, 0x3F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0,
  0x03, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x7F,
  0x80, 0x0F, 0xE0, 0x1F, 0xE0, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0xFE, 0x01,
  0xFC, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x07, 0xF8,
  0x0F, 0xE0, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x3F,
  0xC0, 0x7F, 0x80, 0x0F, 0xF0, 0x1F, 0xE0, 0x07, 0xF8, 0x07, 0xF8, 0x01,
  0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xF0,
  0x1F, 0xF0, 0x0F, 0xFC, 0x0F, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xCF, 0xFF, 0xC0, 0x07,
  0xF1, 0xFF, 0xE0, 0x01, 0xFC, 0x3F, 0xE0, 0x00, 0x7F, 0x01, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0xFC, 0x01, 0xFF, 0xE3, 0xF8,
  0x07, 0xFF, 0xE7, 0xE0, 0x1F, 0xFF, 0xEF, 0xC0, 0x7F, 0xFF, 0xFF, 0x81,
  0xFF, 0xDF, 0xFF, 0x03, 0xFE, 0x0F, 0xFE, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F,
  0xE0, 0x0F, 0xF0, 0x7F, 0x80, 0x1F, 0xE0, 0xFF, 0x00, 0x3F, 0xC3, 0xFC,
  0x00, 0x7F, 0x87, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0xC0,
  0x03, 0xF8, 0x7F, 0x80, 0x0F, 0xF0, 0xFF, 0x00, 0x1F, 0xC1, 0xFC, 0x00,
  0x3F, 0x83, 0xF8, 0x00, 0x7F, 0x0F, 0xF0, 0x01, 0xFE, 0x1F, 0xE0, 0x03,
  0xFC, 0x3F, 0xC0, 0x07, 0xF0, 0x7F, 0x80, 0x1F, 0xE0, 0xFF, 0x00, 0x3F,
  0xC1, 0xFE, 0x00, 0xFF, 0x83, 0xFC, 0x01, 0xFF, 0x07, 0xFC, 0x07, 0xFC,
  0x07, 0xF8, 0x1F, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xEF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0x7F, 0x00, 0x3F, 0xF8, 0xFE, 0x00,
  0x3F, 0xE1, 0xFC, 0x00, 0x06, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0xFC, 0x3F, 0xC0, 0x7E, 0x3F, 0xE0,
  0x7F, 0x3F, 0xE0, 0x3F, 0xBF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xDF, 0xFC,
  0x07, 0xFF, 0xFC, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x0F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0,
  0x7F, 0xC1, 0xF0, 0x3F, 0xC0, 0x0C, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC2, 0x00, 0x0F, 0xF0, 0xE0,
  0x07, 0xFC, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x0F, 0xFF, 0xF3,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0,
  0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x05, 0xC0,
  0x00, 0x07, 0xF0, 0x03, 0xFC, 0x3F, 0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x3F,
  0x83, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xE1,
  0xFE, 0x00, 0x7F, 0x87, 0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0x7F,
  0x00, 0x1F, 0xC3, 0xFC, 0x00, 0xFF, 0x0F, 0xF0, 0x03, 0xFC, 0x3F, 0x80,
  0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFE, 0x1F, 0xE0, 0x07,
  0xF8, 0x7F, 0x80, 0x1F, 0xC1, 0xFC, 0x00, 0x7F, 0x07, 0xF0, 0x01, 0xFC,
  0x1F, 0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0xFE, 0x0F,
  0xE0, 0x07, 0xF8, 0x3F, 0x80, 0x1F, 0xE0, 0xFE, 0x00, 0xFF, 0x83, 0xF8,
  0x07, 0xFE, 0x0F, 0xE0, 0x3F, 0xF0, 0x3F, 0xC1, 0xFF, 0xC0, 0xFF, 0xFF,
  0xBF, 0x03, 0xFF, 0xFD, 0xFC, 0x0F, 0xFF, 0xF7, 0xF0, 0x1F, 0xFF, 0x9F,
  0x80, 0x3F, 0xFC, 0x7E, 0x00, 0x7F, 0xC1, 0xF8, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0x9F, 0xC0, 0x03, 0xF8,
  0xFE, 0x00, 0x3F, 0xC7, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x1F, 0xE1, 0xFC,
  0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xF0, 0x7F, 0x00, 0x7F, 0x03, 0xF8, 0x07,
  0xF8, 0x1F, 0xC0, 0x3F, 0x80, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x3F, 0x81, 0xFE, 0x00, 0xFC, 0x0F, 0xE0, 0x07, 0xE0, 0xFF, 0x00, 0x3F,
  0x87, 0xF0, 0x01, 0xFC, 0x7F, 0x80, 0x0F, 0xE3, 0xF8, 0x00, 0x7F, 0x1F,
  0xC0, 0x03, 0xF9, 0xFC, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0xFE, 0xFE, 0x00,
  0x07, 0xF7, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xFF, 0xC0,
  0x1F, 0xF0, 0x03, 0xFB, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x7F, 0x00, 0x7F,
  0xC0, 0x1F, 0xCF, 0xE0, 0x1F, 0xF8, 0x03, 0xF9, 0xFC, 0x03, 0xFF, 0x00,
  0xFF, 0x3F, 0x80, 0xFF, 0xE0, 0x1F, 0xC7, 0xF0, 0x1F, 0xFC, 0x07, 0xF8,
  0xFE, 0x07, 0xEF, 0x80, 0xFE, 0x1F, 0xC0, 0xFD, 0xF0, 0x3F, 0xC3, 0xF8,
  0x1F, 0x3E, 0x07, 0xF0, 0x7F, 0x07, 0xE7, 0xC0, 0xFE, 0x0F, 0xE0, 0xFC,
  0xF8, 0x3F, 0x81, 0xFC, 0x3F, 0x1F, 0x07, 0xF0, 0x3F, 0x87, 0xE7, 0xE1,
  0xFE, 0x07, 0xF1, 0xF8, 0xFC, 0x3F, 0x80, 0xFE, 0x3F, 0x1F, 0x8F, 0xF0,
  0x1F, 0xC7, 0xE3, 0xF1, 0xFC, 0x03, 0xF9, 0xF8, 0x7E, 0x3F, 0x80, 0x7F,
  0x3F, 0x0F, 0xCF, 0xE0, 0x0F, 0xEF, 0xC1, 0xF9, 0xFC, 0x01, 0xFD, 0xF8,
  0x3F, 0x3F, 0x00, 0x3F, 0xBF, 0x07, 0xEF, 0xE0, 0x07, 0xFF, 0xC0, 0xFD,
  0xFC, 0x00, 0xFF, 0xF8, 0x1F, 0xBF, 0x00, 0x1F, 0xBE, 0x03, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x00, 0x0F,
  0xFE, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x3F, 0xF0,
  0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x1F,
  0xF0, 0x00, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x3F,
  0xE0, 0x1F, 0xE0, 0x0F, 0xF8, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x7F, 0x80, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0xFF, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x1F, 0xC7, 0xF0, 0x00,
  0x03, 0xF9, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x07, 0xFB, 0xF8, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x3F, 0x87,
  0xF0, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0xFF,
  0x01, 0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x07, 0xF8, 0x07, 0xF8, 0x01,
  0xFE, 0x00, 0x7F, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x1F, 0xF0, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x1F,
  0xC0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xE0,
  0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x01, 0xF8, 0x07, 0xF8, 0x00,
  0x0F, 0xE0, 0x3F, 0xC0, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x1F,
  0xE0, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x07,
  0xF0, 0x7F, 0x00, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0x01, 0xFC, 0x3F, 0x80,
  0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x01, 0xF9,
  0xFE, 0x00, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00,
  0x03, 0xF7, 0xF0, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x20, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xFC,
  0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x09, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFE,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x09, 0xFF, 0xE0, 0x00, 0xDF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xDC, 0x00, 0xFF, 0xFC, 0x80, 0x00, 0xFF, 0xC4, 0x00, 0x00, 0x20,
  0x00,
};

const GFXglyph NotoSans_SemiCondensed_SemiBoldItalic63pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 17, 46, 17, 1, -45 },
  { 99, 21, 16, 26, 6, -45 },
  { 141, 36, 45, 36, 1, -45 },
  { 344, 31, 52, 32, 1, -48 },
  { 546, 43, 47, 49, 4, -46 },
  { 799, 37, 47, 39, 1, -46 },
  { 1017, 10, 16, 15, 6, -45 },
  { 1037, 22, 55, 19, 2, -45 },
  { 1189, 22, 56, 19, -5, -46 },
  { 1343, 26, 28, 31, 6, -48 },
  { 1434, 29, 30, 33, 3, -37 },
  { 1543, 14, 16, 16, -3, -8 },
  { 1571, 17, 6, 19, 1, -20 },
  { 1584, 9, 10, 16, 1, -9 },
  { 1596, 32, 45, 24, -3, -45 },
  { 1776, 29, 47, 32, 2, -46 },
  { 1947, 21, 45, 32, 7, -45 },
  { 2066, 32, 46, 32, -1, -46 },
  { 2250, 31, 47, 32, 0, -46 },
  { 2433, 32, 45, 32, -1, -45 },
  { 2613, 31, 46, 32, 1, -45 },
  { 2792, 30, 47, 32, 3, -46 },
  { 2969, 31, 45, 32, 3, -45 },
  { 3144, 31, 47, 32, 1, -46 },
  { 3327, 29, 47, 32, 2, -46 },
  { 3498, 15, 36, 16, 0, -35 },
  { 3566, 18, 43, 16, -3, -35 },
  { 3663, 29, 31, 33, 3, -38 },
  { 3776, 28, 18, 33, 3, -31 },
  { 3839, 29, 31, 33, 3, -38 },
  { 3952, 23, 47, 25, 4, -46 },
  { 4088, 46, 51, 48, 2, -45 },
  { 4382, 35, 45, 34, -4, -45 },
  { 4579, 34, 45, 35, 1, -45 },
  { 4771, 34, 47, 34, 3, -46 },
  { 4971, 36, 45, 38, 1, -45 },
  { 5174, 32, 45, 30, 1, -45 },
  { 5354, 32, 45, 29, 1, -45 },
  { 5534, 36, 47, 39, 3, -46 },
  { 5746, 39, 45, 40, 1, -45 },
  { 5966, 27, 45, 21, -2, -45 },
  { 6118, 29, 58, 18, -10, -45 },
  { 6329, 39, 45, 34, 1, -45 },
  { 6549, 24, 45, 29, 1, -45 },
  { 6684, 50, 45, 50, 1, -45 },
  { 6966, 42, 45, 42, 1, -45 },
  { 7203, 37, 47, 41, 3, -46 },
  { 7421, 34, 45, 34, 1, -45 },
  { 7613, 37, 57, 41, 3, -46 },
  { 7877, 33, 45, 34, 1, -45 },
  { 8063, 32, 47, 30, 0, -46 },
  { 8251, 29, 45, 29, 5, -45 },
  { 8415, 36, 46, 39, 4, -45 },
  { 8622, 33, 45, 33, 6, -45 },
  { 8808, 50, 45, 51, 6, -45 },
  { 9090, 41, 45, 33, -4, -45 },
  { 9321, 31, 45, 31, 6, -45 },
  { 9496, 35, 45, 30, -2, -45 },
  { 9693, 25, 55, 19, -1, -45 },
  { 9865, 13, 45, 24, 7, -45 },
  { 9939, 25, 55, 19, -4, -45 },
  { 10111, 30, 28, 32, 1, -45 },
  { 10216, 24, 4, 23, -6, 6 },
  { 10228, 12, 10, 19, 9, -48 },
  { 10243, 31, 36, 34, 2, -35 },
  { 10383, 31, 49, 34, 1, -48 },
  { 10573, 26, 36, 27, 2, -35 },
  { 10690, 34, 49, 34, 2, -48 },
  { 10899, 27, 36, 31, 2, -35 },
  { 11021, 34, 63, 20, -7, -48 },
  { 11289, 33, 50, 34, 0, -35 },
  { 11496, 30, 48, 34, 1, -48 },
  { 11676, 17, 47, 16, 1, -47 },
  { 11776, 26, 62, 16, -8, -47 },
  { 11978, 33, 48, 31, 1, -48 },
  { 12176, 17, 48, 16, 1, -48 },
  { 12278, 47, 35, 51, 1, -35 },
  { 12484, 30, 35, 34, 1, -35 },
  { 12616, 29, 36, 33, 2, -35 },
  { 12747, 34, 50, 34, -2, -35 },
  { 12960, 31, 50, 34, 2, -35 },
  { 13154, 25, 35, 24, 1, -35 },
  { 13264, 26, 36, 26, 0, -35 },
  { 13381, 20, 43, 21, 3, -42 },
  { 13489, 30, 35, 34, 3, -34 },
  { 13621, 29, 34, 28, 3, -34 },
  { 13745, 43, 34, 44, 4, -34 },
  { 13928, 35, 34, 29, -3, -34 },
  { 14077, 37, 49, 29, -5, -34 },
  { 14304, 29, 34, 26, -2, -34 },
  { 14428, 26, 55, 22, 0, -45 },
  { 14607, 6, 63, 31, 12, -48 },
  { 14655, 24, 55, 22, -3, -45 },
  { 14820, 29, 10, 33, 3, -27 },
};

const GFXfont NotoSans_SemiCondensed_SemiBoldItalic63pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_SemiBoldItalic63pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_SemiBoldItalic63pt7bGlyphs,
  0x20, 0x7E, 86
};

#endif // _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC63PT7B_H_
