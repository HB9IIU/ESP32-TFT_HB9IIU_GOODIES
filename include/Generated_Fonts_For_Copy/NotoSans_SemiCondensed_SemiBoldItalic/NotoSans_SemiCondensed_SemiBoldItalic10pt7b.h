#ifndef _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC10PT7B_H_
#define _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC10PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-SemiBoldItalic.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_SemiBoldItalic10pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0x24, 0x30, 0xF4, 0x38, 0xA7, 0xCC, 0xF9, 0x47, 0x00, 0x11,
  0xD6, 0xC3, 0x1A, 0xCC, 0x40, 0xEE, 0xAB, 0x3B, 0x35, 0x59, 0xC0, 0x38,
  0xA3, 0x19, 0xDE, 0x67, 0xC0, 0xE0, 0x36, 0x44, 0x88, 0x84, 0x40, 0x21,
  0x11, 0x22, 0x24, 0x80, 0x2A, 0x7E, 0xA0, 0x44, 0xF4, 0x40, 0xE0, 0xE0,
  0xC0, 0x18, 0x88, 0xC4, 0x62, 0x00, 0x3A, 0x53, 0x9D, 0xE9, 0x80, 0x3C,
  0xB4, 0x90, 0x78, 0x46, 0x22, 0x23, 0xC0, 0x78, 0x46, 0xE1, 0x0B, 0xC0,
  0x19, 0x4C, 0xAF, 0x88, 0xC0, 0x3A, 0x10, 0xE1, 0x0B, 0xC0, 0x3B, 0x14,
  0xFD, 0xE9, 0xC0, 0x78, 0x44, 0x62, 0x33, 0x00, 0x3A, 0x5E, 0xED, 0x4D,
  0xC0, 0x7A, 0x52, 0xF1, 0x0B, 0x80, 0x50, 0x30, 0x24, 0x00, 0xF0, 0x16,
  0x86, 0x10, 0xF0, 0xF0, 0x86, 0x1E, 0x80, 0xE4, 0xA8, 0x20, 0x1E, 0x62,
  0x5D, 0xA5, 0xAA, 0xB4, 0x40, 0x38, 0x08, 0x61, 0xC9, 0x3D, 0x1C, 0x40,
  0x39, 0xB4, 0x9C, 0x49, 0x2F, 0x00, 0x7E, 0x21, 0x08, 0x43, 0x80, 0x39,
  0xB4, 0x53, 0x49, 0x6F, 0x00, 0x3B, 0x10, 0xE4, 0x23, 0xC0, 0x3B, 0x10,
  0xE4, 0x23, 0x00, 0x7E, 0x21, 0x79, 0xCB, 0xC0, 0x25, 0x94, 0x5F, 0x49,
  0x2C, 0x80, 0x72, 0x64, 0x44, 0xE0, 0x08, 0xC4, 0x21, 0x08, 0xC4, 0xE0,
  0x2D, 0xA5, 0x1C, 0x51, 0x49, 0x80, 0x26, 0x44, 0x44, 0xF0, 0x23, 0x63,
  0x67, 0x56, 0x5A, 0x5A, 0x96, 0x22, 0xE9, 0x52, 0xA5, 0x49, 0xA2, 0x00,
  0x7E, 0x63, 0x18, 0xCB, 0xC0, 0x39, 0xB4, 0x9E, 0x41, 0x0C, 0x00, 0x7E,
  0x63, 0x18, 0xCB, 0xC4, 0x10, 0x3B, 0x52, 0xF5, 0x2B, 0x60, 0x7A, 0x10,
  0x61, 0x0B, 0x80, 0xF6, 0x44, 0x4C, 0x80, 0x4E, 0x63, 0x39, 0x4B, 0x80,
  0x8C, 0xA5, 0x4A, 0x63, 0x00, 0x93, 0x92, 0xAA, 0xAC, 0xCC, 0xCC, 0xC8,
  0x26, 0x28, 0x60, 0xC2, 0x8D, 0x33, 0x00, 0x9C, 0xB8, 0xC4, 0x23, 0x00,
  0x78, 0xCC, 0x44, 0x63, 0xC0, 0x34, 0x44, 0x48, 0x88, 0xC0, 0xA9, 0x54,
  0x31, 0x12, 0x22, 0x22, 0xC0, 0x31, 0x95, 0x90, 0xF0, 0xD0, 0x23, 0xD3,
  0xBD, 0x38, 0x21, 0x14, 0xF4, 0xA7, 0x7E, 0x17, 0x4C, 0xC7, 0x0C, 0x22,
  0x9E, 0x4B, 0x6D, 0x1C, 0x13, 0xD7, 0xCC, 0x38, 0x08, 0x8E, 0xE2, 0x10,
  0x8C, 0x46, 0x00, 0x23, 0xD3, 0xBD, 0x38, 0x5E, 0x21, 0x14, 0xF4, 0xAF,
  0x52, 0x2C, 0x24, 0xB4, 0x11, 0x02, 0x22, 0x64, 0x4C, 0x21, 0x10, 0xB7,
  0x33, 0x52, 0x25, 0x24, 0xB4, 0x12, 0x7F, 0x4B, 0x5A, 0xD2, 0x92, 0x13,
  0xD2, 0xBD, 0x48, 0x13, 0xD3, 0x9D, 0x38, 0x13, 0xD2, 0x9D, 0xDA, 0x10,
  0x23, 0xD3, 0xBD, 0x38, 0x46, 0x17, 0x44, 0xC8, 0x25, 0x46, 0x3E, 0x26,
  0xF4, 0x4C, 0x60, 0x4A, 0x57, 0xA7, 0x00, 0xBA, 0xEC, 0xC0, 0xB6, 0xFD,
  0xB6, 0x90, 0x5B, 0x98, 0xC9, 0x00, 0x2C, 0xA3, 0x8C, 0x30, 0x8E, 0x00,
  0x72, 0x4C, 0xE0, 0x32, 0x24, 0xC4, 0x44, 0x40, 0xFF, 0xC0, 0x31, 0x33,
  0x32, 0x24, 0x80, 0xF0,
};

const GFXglyph NotoSans_SemiCondensed_SemiBoldItalic10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 3, 7, 3, 0, -7 },
  { 4, 3, 2, 4, 1, -7 },
  { 5, 6, 7, 6, 0, -7 },
  { 11, 5, 9, 5, 0, -8 },
  { 17, 6, 7, 8, 1, -7 },
  { 23, 6, 7, 6, 0, -7 },
  { 29, 2, 2, 2, 1, -7 },
  { 30, 4, 9, 3, 0, -7 },
  { 35, 4, 9, 3, -1, -7 },
  { 40, 4, 5, 5, 1, -8 },
  { 43, 4, 5, 5, 1, -6 },
  { 46, 2, 2, 3, 0, -1 },
  { 47, 3, 1, 3, 0, -3 },
  { 48, 2, 1, 3, 0, -1 },
  { 49, 5, 7, 4, 0, -7 },
  { 54, 5, 7, 5, 0, -7 },
  { 59, 3, 7, 5, 1, -7 },
  { 62, 5, 7, 5, 0, -7 },
  { 67, 5, 7, 5, 0, -7 },
  { 72, 5, 7, 5, 0, -7 },
  { 77, 5, 7, 5, 0, -7 },
  { 82, 5, 7, 5, 0, -7 },
  { 87, 5, 7, 5, 0, -7 },
  { 92, 5, 7, 5, 0, -7 },
  { 97, 5, 7, 5, 0, -7 },
  { 102, 2, 6, 3, 0, -6 },
  { 104, 3, 7, 3, -1, -6 },
  { 107, 4, 5, 5, 1, -6 },
  { 110, 4, 3, 5, 1, -5 },
  { 112, 4, 5, 5, 1, -6 },
  { 115, 3, 7, 4, 1, -7 },
  { 118, 8, 8, 8, 0, -7 },
  { 126, 6, 7, 5, -1, -7 },
  { 132, 6, 7, 6, 0, -7 },
  { 138, 5, 7, 5, 1, -7 },
  { 143, 6, 7, 6, 0, -7 },
  { 149, 5, 7, 5, 0, -7 },
  { 154, 5, 7, 5, 0, -7 },
  { 159, 5, 7, 6, 1, -7 },
  { 164, 6, 7, 6, 0, -7 },
  { 170, 4, 7, 3, 0, -7 },
  { 174, 5, 9, 3, -2, -7 },
  { 180, 6, 7, 5, 0, -7 },
  { 186, 4, 7, 5, 0, -7 },
  { 190, 8, 7, 8, 0, -7 },
  { 197, 7, 7, 7, 0, -7 },
  { 204, 5, 7, 7, 1, -7 },
  { 209, 6, 7, 5, 0, -7 },
  { 215, 5, 9, 7, 1, -7 },
  { 221, 5, 7, 5, 0, -7 },
  { 226, 5, 7, 5, 0, -7 },
  { 231, 4, 7, 5, 1, -7 },
  { 235, 5, 7, 6, 1, -7 },
  { 240, 5, 7, 5, 1, -7 },
  { 245, 8, 7, 8, 1, -7 },
  { 252, 7, 7, 5, -1, -7 },
  { 259, 5, 7, 5, 1, -7 },
  { 264, 5, 7, 5, 0, -7 },
  { 269, 4, 9, 3, 0, -7 },
  { 274, 2, 7, 4, 1, -7 },
  { 276, 4, 9, 3, -1, -7 },
  { 281, 5, 4, 5, 0, -7 },
  { 284, 4, 1, 4, -1, 1 },
  { 285, 2, 2, 3, 1, -8 },
  { 286, 5, 6, 5, 0, -6 },
  { 290, 5, 8, 5, 0, -8 },
  { 295, 4, 6, 4, 0, -6 },
  { 298, 6, 8, 5, 0, -8 },
  { 304, 5, 6, 5, 0, -6 },
  { 308, 5, 10, 3, -1, -8 },
  { 315, 5, 8, 5, 0, -6 },
  { 320, 5, 8, 5, 0, -8 },
  { 325, 3, 8, 3, 0, -8 },
  { 328, 4, 10, 3, -1, -8 },
  { 333, 5, 8, 5, 0, -8 },
  { 338, 3, 8, 3, 0, -8 },
  { 341, 8, 6, 8, 0, -6 },
  { 347, 5, 6, 5, 0, -6 },
  { 351, 5, 6, 5, 0, -6 },
  { 355, 5, 8, 5, 0, -6 },
  { 360, 5, 8, 5, 0, -6 },
  { 365, 4, 6, 4, 0, -6 },
  { 368, 4, 6, 4, 0, -6 },
  { 371, 4, 7, 3, 0, -7 },
  { 375, 5, 5, 5, 0, -5 },
  { 379, 4, 5, 5, 1, -5 },
  { 382, 6, 5, 7, 1, -5 },
  { 386, 5, 5, 5, 0, -5 },
  { 390, 6, 7, 5, -1, -5 },
  { 396, 4, 5, 4, 0, -5 },
  { 399, 4, 9, 3, 0, -7 },
  { 404, 1, 10, 5, 2, -8 },
  { 406, 4, 9, 3, -1, -7 },
  { 411, 4, 1, 5, 1, -4 },
};

const GFXfont NotoSans_SemiCondensed_SemiBoldItalic10pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_SemiBoldItalic10pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_SemiBoldItalic10pt7bGlyphs,
  0x20, 0x7E, 14
};

#endif // _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC10PT7B_H_
