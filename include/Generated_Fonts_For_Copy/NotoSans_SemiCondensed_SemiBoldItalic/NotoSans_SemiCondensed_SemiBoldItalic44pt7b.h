#ifndef _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC44PT7B_H_
#define _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC44PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-SemiBoldItalic.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_SemiBoldItalic44pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x1F, 0x80, 0xFC, 0x0F, 0xE0,
  0x3F, 0x01, 0xF0, 0x02, 0x00, 0x3E, 0x3E, 0x7C, 0x7C, 0xF0, 0xF3, 0xE3,
  0xE7, 0xC7, 0xCF, 0x8F, 0x9E, 0x1E, 0x3C, 0x3C, 0x78, 0x78, 0xE0, 0xE3,
  0xC3, 0xC0, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x0E, 0x00, 0x0F, 0x0F, 0x00,
  0x07, 0x87, 0x80, 0x07, 0x83, 0xC0, 0x03, 0xC3, 0xC0, 0x01, 0xE1, 0xE0,
  0x01, 0xE0, 0xF0, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xF0, 0x1E, 0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x07,
  0x80, 0x07, 0x87, 0x80, 0x03, 0xC3, 0xC0, 0x01, 0xC1, 0xE0, 0x3F, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE0, 0x3C,
  0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x07,
  0x87, 0x80, 0x03, 0x83, 0xC0, 0x03, 0xC1, 0xC0, 0x01, 0xE1, 0xE0, 0x00,
  0xF0, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x7F, 0x80, 0x1F, 0xFF, 0x01, 0xFF, 0xFC, 0x1F, 0xFF, 0xC1, 0xFF, 0xFE,
  0x0F, 0x9C, 0x20, 0x7C, 0xE0, 0x07, 0xC7, 0x00, 0x3E, 0x30, 0x01, 0xF9,
  0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x06, 0xFC, 0x00, 0x33,
  0xF0, 0x03, 0x9F, 0x80, 0x1C, 0xFC, 0x80, 0xE7, 0xC6, 0x06, 0x3E, 0x3E,
  0x37, 0xF1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x00, 0x7F, 0xE0,
  0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x20, 0x7F, 0x80, 0x1E, 0x07, 0xFC, 0x00,
  0xF0, 0x7F, 0xF0, 0x0F, 0x03, 0xC7, 0x80, 0xF0, 0x3E, 0x3C, 0x07, 0x81,
  0xE1, 0xE0, 0x78, 0x0F, 0x0F, 0x07, 0x80, 0xF0, 0x78, 0x3C, 0x07, 0x83,
  0xC3, 0xC0, 0x3C, 0x1E, 0x3C, 0x01, 0xE1, 0xF1, 0xE0, 0x0F, 0x0F, 0x1E,
  0x00, 0x78, 0x79, 0xE3, 0xF3, 0xC7, 0x8F, 0x3F, 0xDE, 0x7C, 0xF3, 0xFF,
  0xFF, 0xCF, 0x3E, 0xFF, 0xFE, 0x79, 0xE3, 0xDF, 0xE7, 0x9F, 0x1E, 0x3C,
  0x78, 0xF0, 0xF0, 0x03, 0xC7, 0x87, 0x80, 0x3C, 0x7C, 0x3C, 0x03, 0xC3,
  0xC1, 0xE0, 0x1E, 0x1E, 0x0F, 0x01, 0xE0, 0xF0, 0xF8, 0x1E, 0x07, 0x87,
  0x80, 0xF0, 0x3C, 0x3C, 0x0F, 0x01, 0xE3, 0xE0, 0xF0, 0x0F, 0xBE, 0x07,
  0x80, 0x7F, 0xE0, 0x78, 0x01, 0xFF, 0x07, 0xC0, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01,
  0xF1, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x83, 0xE0,
  0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x9F,
  0x80, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xFC, 0x0F, 0xC7, 0xFF, 0x83, 0xE3, 0xFB, 0xE1, 0xF9,
  0xF8, 0xFC, 0x7C, 0x7C, 0x1F, 0x3F, 0x3F, 0x07, 0xEF, 0x8F, 0x80, 0xFF,
  0xC3, 0xE0, 0x3F, 0xF0, 0xF8, 0x07, 0xF8, 0x3E, 0x00, 0xFC, 0x0F, 0xC0,
  0x7F, 0x03, 0xF8, 0x7F, 0xE0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x03,
  0xFF, 0xCF, 0xE0, 0x7F, 0xC1, 0xF8, 0x3E, 0x7C, 0xF3, 0xE7, 0xCF, 0x9E,
  0x3C, 0x78, 0xF3, 0xC0, 0x00, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0x80,
  0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3C,
  0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xE0, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C,
  0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x03,
  0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x00, 0x40, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x04, 0x0F, 0x00, 0xE1, 0xE0, 0x1F, 0x3C, 0x07, 0xFF,
  0x03, 0xFF, 0xFF, 0xE3, 0xFF, 0xFC, 0x0F, 0xFF, 0x83, 0xFB, 0xF0, 0xFF,
  0x00, 0x3E, 0xF0, 0x0F, 0xDE, 0x03, 0xF3, 0xE0, 0x3C, 0x3C, 0x03, 0x07,
  0xC0, 0x20, 0xF0, 0x00, 0x08, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x8F, 0xC7, 0xC3, 0xE3, 0xE1, 0xF0, 0xF0, 0xF8, 0x78, 0x7C, 0x3C, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3C, 0xFD, 0xFF, 0xFF, 0xEF,
  0x8C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x03, 0xFE, 0x00,
  0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x03, 0xF0, 0xF8, 0x3F, 0x07,
  0xE1, 0xF0, 0x3F, 0x1F, 0x80, 0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x7E, 0x7E,
  0x03, 0xF3, 0xE0, 0x1F, 0x9F, 0x00, 0xFD, 0xF8, 0x07, 0xCF, 0xC0, 0x3E,
  0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0x9F, 0x00, 0xFC, 0xF8, 0x07, 0xC7, 0xC0,
  0x3E, 0x3E, 0x03, 0xF3, 0xF0, 0x1F, 0x9F, 0x80, 0xF8, 0x7C, 0x0F, 0xC3,
  0xE0, 0x7C, 0x1F, 0x07, 0xE0, 0xFC, 0x7E, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0x00, 0x7F, 0xE0, 0x01, 0xFE, 0x00, 0x00, 0x7C, 0x07, 0xF0, 0x3F, 0xC3,
  0xFF, 0x1F, 0xF8, 0xFF, 0xEF, 0xEF, 0xBF, 0x3E, 0x79, 0xF9, 0x87, 0xC2,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x1F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xC0, 0x7C, 0x1F, 0x80, 0x60, 0x1F, 0x80, 0x80, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0x80,
  0x03, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0E,
  0x07, 0xF0, 0x10, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x80,
  0x1F, 0xF8, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x88, 0x00, 0xFC, 0x3C,
  0x0F, 0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xBC, 0x00,
  0x3F, 0xF0, 0x01, 0xF7, 0xC0, 0x07, 0x9F, 0x00, 0x3C, 0xF8, 0x01, 0xF3,
  0xE0, 0x0F, 0x8F, 0x80, 0x3C, 0x3E, 0x01, 0xE0, 0xF8, 0x0F, 0x87, 0xC0,
  0x7C, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x01, 0xF0, 0x7C, 0x0F, 0xC3, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF0, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF,
  0xFE, 0x07, 0xFF, 0xE0, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x60,
  0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC4, 0x00,
  0xFC, 0x38, 0x1F, 0xE1, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x03,
  0xFF, 0xE0, 0x3F, 0xFF, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE7,
  0xE0, 0x3E, 0x7F, 0xC1, 0xF7, 0xFE, 0x0F, 0xFF, 0xF8, 0xFF, 0x8F, 0xC7,
  0xF0, 0x3E, 0x3F, 0x01, 0xF1, 0xF8, 0x0F, 0x8F, 0x80, 0x7C, 0x7C, 0x03,
  0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x0F, 0xC7, 0xC0, 0x7C, 0x3F,
  0x07, 0xE1, 0xFC, 0x7E, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0xFF, 0xF0,
  0x01, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0x00, 0x7F,
  0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0x3F, 0x83, 0xE0, 0xFC, 0x3E, 0x03, 0xE1,
  0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x7C, 0x0F, 0x87,
  0xE0, 0x7E, 0x7E, 0x01, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xFF, 0x00, 0x7F, 0xFC, 0x0F, 0xE7, 0xE0, 0x7E, 0x1F, 0x87, 0xE0, 0x7C,
  0x7E, 0x03, 0xF3, 0xE0, 0x0F, 0x9F, 0x00, 0x7C, 0xF8, 0x03, 0xE7, 0xC0,
  0x3F, 0x3F, 0x01, 0xF1, 0xF8, 0x1F, 0x87, 0xFF, 0xF8, 0x3F, 0xFF, 0x80,
  0xFF, 0xF8, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0x00, 0x1F, 0xF8, 0x03, 0xFF,
  0xC0, 0x7F, 0xFE, 0x0F, 0xFF, 0xF0, 0xFC, 0x3F, 0x1F, 0x81, 0xF1, 0xF0,
  0x1F, 0x3F, 0x01, 0xF3, 0xE0, 0x1F, 0x3E, 0x01, 0xF3, 0xE0, 0x1F, 0x3E,
  0x01, 0xF3, 0xE0, 0x3F, 0x3E, 0x03, 0xF3, 0xF0, 0x7F, 0x3F, 0xFF, 0xF1,
  0xFF, 0xFE, 0x1F, 0xFB, 0xE0, 0xFF, 0x3E, 0x03, 0xC7, 0xE0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F,
  0x08, 0x0F, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFC,
  0x00, 0x03, 0xC0, 0xFC, 0x3F, 0x87, 0xF0, 0xFC, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x3F, 0x07, 0xE1, 0xFC, 0x3F, 0x03, 0xE0, 0x10, 0x00,
  0x00, 0xF0, 0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x01, 0xF8, 0x0F, 0x80,
  0x7C, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x78,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0xF0, 0x00, 0x3F, 0x00,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0x00, 0x00, 0x70, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x0E, 0x00, 0x00, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x00,
  0x0F, 0xF0, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xF0, 0x0F,
  0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0xF0, 0x00, 0x08, 0x00, 0x00,
  0x01, 0xF0, 0x07, 0xFF, 0x0F, 0xFF, 0xC7, 0xFF, 0xE1, 0xFF, 0xF8, 0xC0,
  0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0xC0, 0x07,
  0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0x80, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x1F, 0x00, 0xF8,
  0x00, 0x1F, 0x03, 0xC0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x1E, 0x3E, 0x03,
  0xF8, 0x3C, 0x78, 0x1F, 0xFC, 0x79, 0xE0, 0x7F, 0xF0, 0xF3, 0xC1, 0xF1,
  0xE1, 0xEF, 0x07, 0x83, 0xC3, 0xDE, 0x1F, 0x07, 0x87, 0xBC, 0x3C, 0x1E,
  0x0F, 0xF0, 0xF0, 0x3C, 0x1F, 0xE1, 0xE0, 0x78, 0x3F, 0xC3, 0xC0, 0xF0,
  0x77, 0x87, 0x83, 0xC1, 0xEF, 0x1E, 0x07, 0x83, 0xDE, 0x3C, 0x1F, 0x0F,
  0x3C, 0x7C, 0x3E, 0x1E, 0x78, 0x78, 0xFC, 0x78, 0xF0, 0xFF, 0xBF, 0xE1,
  0xE1, 0xFE, 0x7F, 0x83, 0xC1, 0xF8, 0x7E, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F,
  0x80, 0x0E, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x07,
  0xBE, 0x00, 0x0F, 0xBE, 0x00, 0x0F, 0xBE, 0x00, 0x1F, 0x3E, 0x00, 0x1F,
  0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C,
  0x3E, 0x00, 0xFC, 0x3E, 0x00, 0xF8, 0x3E, 0x01, 0xF8, 0x3E, 0x01, 0xF0,
  0x1E, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xC0, 0x1F, 0x0F, 0x80, 0x1F, 0x1F, 0x80,
  0x1F, 0x1F, 0x00, 0x1F, 0x3F, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x7E, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF0, 0x7E, 0x0F, 0xE0, 0xFC, 0x0F, 0xC1, 0xF0, 0x0F,
  0x83, 0xE0, 0x1F, 0x07, 0xC0, 0x3E, 0x1F, 0x80, 0xFC, 0x3E, 0x01, 0xF0,
  0x7C, 0x07, 0xE0, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x0F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x3E, 0x07, 0xE0, 0xFC, 0x07, 0xE1, 0xF8,
  0x07, 0xC3, 0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x7E, 0x3F, 0x00,
  0xFC, 0x7C, 0x03, 0xF0, 0xF8, 0x0F, 0xE1, 0xF0, 0xFF, 0x83, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF,
  0xFE, 0x07, 0xF8, 0x0C, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x40, 0x3F, 0xC3, 0xC0, 0x3F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x03, 0xFF,
  0xE0, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x7E,
  0x1F, 0xE0, 0x3F, 0x03, 0xF8, 0x1F, 0x00, 0xFC, 0x0F, 0x80, 0x3E, 0x07,
  0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xE1, 0xF0, 0x03, 0xF0,
  0xF8, 0x01, 0xF8, 0x7C, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x3E,
  0x1F, 0x00, 0x3F, 0x0F, 0x80, 0x1F, 0x8F, 0xC0, 0x0F, 0xC7, 0xE0, 0x0F,
  0xC3, 0xE0, 0x07, 0xE1, 0xF0, 0x07, 0xF0, 0xF8, 0x03, 0xF0, 0xFC, 0x03,
  0xF0, 0x7E, 0x03, 0xF8, 0x3E, 0x07, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x3F,
  0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7C, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xFF,
  0xF0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0,
  0x7F, 0xFE, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x1F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xE0, 0x38, 0x1F, 0xC0,
  0x04, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x0F, 0xFE, 0x7C, 0x07, 0xFE, 0x3E, 0x03, 0xFF, 0x3F,
  0x01, 0xFF, 0x9F, 0x81, 0x0F, 0xCF, 0xC0, 0x07, 0xC7, 0xE0, 0x03, 0xE3,
  0xF0, 0x01, 0xF0, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x3F, 0x00, 0x7C,
  0x1F, 0xC0, 0x3E, 0x07, 0xF8, 0x7F, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x03, 0xF0, 0x03, 0xE0, 0x7E,
  0x00, 0xFC, 0x0F, 0x80, 0x1F, 0x81, 0xF0, 0x03, 0xE0, 0x7E, 0x00, 0x7C,
  0x0F, 0xC0, 0x0F, 0x81, 0xF0, 0x03, 0xF0, 0x3E, 0x00, 0x7E, 0x07, 0xC0,
  0x0F, 0x81, 0xF8, 0x01, 0xF0, 0x3F, 0x00, 0x7E, 0x07, 0xC0, 0x0F, 0xC0,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0xE0, 0x07, 0xC0, 0x7C, 0x00, 0xF8, 0x1F,
  0x80, 0x1F, 0x03, 0xE0, 0x07, 0xE0, 0x7C, 0x00, 0xFC, 0x0F, 0x80, 0x1F,
  0x03, 0xF0, 0x03, 0xE0, 0x7E, 0x00, 0xFC, 0x0F, 0x80, 0x1F, 0x81, 0xF0,
  0x03, 0xE0, 0x3E, 0x00, 0x7C, 0x0F, 0xC0, 0x0F, 0x81, 0xF8, 0x03, 0xF0,
  0x3E, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFF, 0x00,
  0x7F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0xF0, 0x0F, 0xFF,
  0x81, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x07, 0xFF, 0x00,
  0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x0F, 0xE0, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0xFC, 0x01, 0xF0, 0x3F, 0x00,
  0x7E, 0x0F, 0xE0, 0x0F, 0xC1, 0xF8, 0x01, 0xF0, 0x7E, 0x00, 0x3E, 0x1F,
  0x80, 0x07, 0xC7, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0x3E, 0x3F, 0x00, 0x07,
  0xCF, 0xC0, 0x00, 0xFB, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7E,
  0x7C, 0x00, 0x1F, 0x8F, 0x80, 0x03, 0xE1, 0xF8, 0x00, 0x7C, 0x3F, 0x00,
  0x0F, 0x83, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0x80,
  0xF8, 0x01, 0xF0, 0x1F, 0x80, 0x3E, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x01,
  0xF0, 0x07, 0xE0, 0x3E, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F,
  0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7F,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x7F, 0x80, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0xFF, 0x01, 0xFE,
  0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x07, 0xFC, 0x0F, 0xF8, 0x01, 0xFF, 0x01,
  0xFF, 0x00, 0x3F, 0xE0, 0x3D, 0xE0, 0x0F, 0xFC, 0x07, 0xBC, 0x01, 0xEF,
  0x81, 0xF7, 0x80, 0x7D, 0xF0, 0x3E, 0xF0, 0x0F, 0x7C, 0x07, 0xDE, 0x03,
  0xEF, 0x80, 0xFB, 0xC0, 0x79, 0xF0, 0x1E, 0x7C, 0x1F, 0x3E, 0x07, 0xCF,
  0x83, 0xCF, 0x80, 0xF9, 0xF0, 0xF9, 0xF0, 0x1F, 0x3E, 0x1E, 0x3E, 0x03,
  0xE7, 0xC7, 0xC7, 0xC0, 0xF8, 0x78, 0xF0, 0xF8, 0x1F, 0x0F, 0x3E, 0x3E,
  0x03, 0xE1, 0xE7, 0x87, 0xC0, 0x7C, 0x3D, 0xF0, 0xF8, 0x0F, 0x87, 0xBC,
  0x1F, 0x03, 0xE0, 0xFF, 0x83, 0xE0, 0x7C, 0x1F, 0xE0, 0xF8, 0x0F, 0x83,
  0xFC, 0x1F, 0x01, 0xF0, 0x7F, 0x03, 0xE0, 0x3C, 0x0F, 0xE0, 0x7C, 0x0F,
  0x81, 0xF8, 0x1F, 0x81, 0xF0, 0x3F, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x7C,
  0x00, 0x03, 0xF8, 0x00, 0xF8, 0x1F, 0xC0, 0x07, 0xC0, 0xFE, 0x00, 0x7C,
  0x07, 0xF8, 0x03, 0xE0, 0x7F, 0xC0, 0x1F, 0x03, 0xFE, 0x00, 0xF8, 0x1F,
  0xF0, 0x07, 0x80, 0xF7, 0xC0, 0x7C, 0x07, 0xBE, 0x03, 0xE0, 0x7D, 0xF0,
  0x1F, 0x03, 0xE7, 0xC0, 0xF8, 0x1F, 0x3E, 0x0F, 0x80, 0xF9, 0xF0, 0x7C,
  0x07, 0x8F, 0x83, 0xE0, 0x7C, 0x3E, 0x1F, 0x03, 0xE1, 0xF0, 0xF8, 0x1F,
  0x0F, 0x8F, 0x80, 0xF8, 0x3E, 0x7C, 0x0F, 0x81, 0xF3, 0xE0, 0x7C, 0x0F,
  0x9F, 0x03, 0xE0, 0x7C, 0xF8, 0x1F, 0x01, 0xF7, 0x80, 0xF8, 0x0F, 0xFC,
  0x0F, 0x80, 0x7F, 0xE0, 0x7C, 0x01, 0xFF, 0x03, 0xE0, 0x0F, 0xF0, 0x1F,
  0x00, 0x7F, 0x80, 0xF0, 0x03, 0xFC, 0x0F, 0x80, 0x0F, 0xE0, 0x7C, 0x00,
  0x7F, 0x03, 0xE0, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xFE,
  0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x01, 0xFC,
  0x0F, 0xE0, 0xFE, 0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0x87,
  0xE0, 0x03, 0xF3, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x3F, 0x3E, 0x00, 0x0F,
  0xDF, 0x80, 0x03, 0xF7, 0xE0, 0x00, 0xFD, 0xF8, 0x00, 0x3E, 0x7C, 0x00,
  0x0F, 0x9F, 0x00, 0x07, 0xEF, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0x7E, 0xFC,
  0x00, 0x1F, 0x3F, 0x00, 0x0F, 0xCF, 0xC0, 0x03, 0xF3, 0xF0, 0x01, 0xF8,
  0x7C, 0x00, 0xFE, 0x1F, 0x80, 0x3F, 0x07, 0xF0, 0x1F, 0x80, 0xFE, 0x1F,
  0xE0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xE0, 0x7E, 0x0F, 0xE0, 0xFC, 0x0F, 0xC1, 0xF0, 0x0F, 0x83, 0xE0,
  0x1F, 0x07, 0xC0, 0x3E, 0x1F, 0x80, 0x7C, 0x3F, 0x01, 0xF8, 0x7C, 0x03,
  0xF0, 0xF8, 0x0F, 0xC1, 0xF0, 0x3F, 0x87, 0xE1, 0xFE, 0x0F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xFC, 0x01, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0x01, 0xFC, 0x0F, 0xE0, 0xFE, 0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x1F, 0x80,
  0x0F, 0x87, 0xE0, 0x03, 0xF3, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x3F, 0x3E,
  0x00, 0x0F, 0xDF, 0x80, 0x03, 0xF7, 0xE0, 0x00, 0xFD, 0xF8, 0x00, 0x3E,
  0x7C, 0x00, 0x0F, 0x9F, 0x00, 0x07, 0xEF, 0xC0, 0x01, 0xFB, 0xF0, 0x00,
  0x7E, 0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xCF, 0xC0, 0x03, 0xF3, 0xF0,
  0x01, 0xF8, 0x7C, 0x00, 0xFE, 0x1F, 0x80, 0x3F, 0x07, 0xF0, 0x3F, 0x80,
  0xFE, 0x1F, 0xE0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xE0, 0x7E, 0x1F, 0xC0, 0xFC, 0x0F, 0x81, 0xF0, 0x1F, 0x83,
  0xE0, 0x3F, 0x07, 0xC0, 0x7E, 0x1F, 0x80, 0xF8, 0x3F, 0x01, 0xF0, 0x7C,
  0x07, 0xE0, 0xF8, 0x1F, 0xC1, 0xF0, 0x7F, 0x07, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xF8, 0xF8,
  0x03, 0xE1, 0xF8, 0x07, 0xC1, 0xF0, 0x0F, 0x83, 0xE0, 0x3F, 0x07, 0xE0,
  0x7E, 0x07, 0xC0, 0xF8, 0x0F, 0x81, 0xF0, 0x1F, 0x83, 0xE0, 0x3F, 0x0F,
  0xC0, 0x3E, 0x1F, 0x00, 0x7E, 0x3E, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F,
  0xC0, 0xC0, 0x7E, 0x01, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x0C, 0x01, 0xFC, 0x3E,
  0x1F, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x01,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x1F, 0x87, 0xC0,
  0x0F, 0xC3, 0xE0, 0x07, 0xC3, 0xF0, 0x03, 0xE1, 0xF8, 0x01, 0xF0, 0xF8,
  0x01, 0xF8, 0x7C, 0x00, 0xFC, 0x3E, 0x00, 0x7C, 0x3F, 0x00, 0x3E, 0x1F,
  0x80, 0x3F, 0x0F, 0x80, 0x1F, 0x87, 0xC0, 0x0F, 0x87, 0xE0, 0x07, 0xC3,
  0xF0, 0x03, 0xE1, 0xF0, 0x03, 0xF0, 0xF8, 0x01, 0xF8, 0x7C, 0x00, 0xF8,
  0x7E, 0x00, 0x7C, 0x3F, 0x00, 0x3E, 0x1F, 0x00, 0x3F, 0x0F, 0x80, 0x1F,
  0x87, 0xC0, 0x0F, 0x83, 0xE0, 0x0F, 0xC1, 0xF0, 0x07, 0xE0, 0xF8, 0x07,
  0xE0, 0x7E, 0x03, 0xF0, 0x3F, 0x87, 0xF0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF,
  0xF8, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0xF8, 0x00, 0x7F, 0xF0,
  0x00, 0xFB, 0xE0, 0x03, 0xF7, 0xC0, 0x07, 0xCF, 0x80, 0x1F, 0x9F, 0x00,
  0x3E, 0x3E, 0x00, 0xFC, 0x7E, 0x01, 0xF0, 0x7C, 0x07, 0xE0, 0xF8, 0x0F,
  0x81, 0xF0, 0x3F, 0x03, 0xE0, 0x7C, 0x07, 0xC1, 0xF8, 0x0F, 0x83, 0xE0,
  0x1F, 0x07, 0xC0, 0x3E, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0xF8, 0x01,
  0xF1, 0xF0, 0x03, 0xE7, 0xC0, 0x07, 0xCF, 0x80, 0x0F, 0xBE, 0x00, 0x1F,
  0x7C, 0x00, 0x3E, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xFF, 0x00, 0x3E, 0x00, 0xFF, 0xE0,
  0x0F, 0xC0, 0x1F, 0x7C, 0x01, 0xF8, 0x07, 0xEF, 0x80, 0x7F, 0x00, 0xF9,
  0xF0, 0x0F, 0xE0, 0x1F, 0x3E, 0x03, 0xFC, 0x07, 0xC7, 0xC0, 0x7F, 0x80,
  0xF8, 0xF8, 0x1F, 0xF0, 0x3F, 0x1F, 0x03, 0xDE, 0x07, 0xC3, 0xE0, 0x7B,
  0xC0, 0xF8, 0x7C, 0x1F, 0x78, 0x3E, 0x0F, 0x83, 0xCF, 0x07, 0xC1, 0xF0,
  0xF9, 0xE1, 0xF0, 0x3E, 0x1E, 0x3C, 0x3E, 0x07, 0xC7, 0xC7, 0x8F, 0xC0,
  0xF8, 0xF8, 0xF1, 0xF0, 0x1F, 0x1E, 0x1E, 0x3E, 0x03, 0xE7, 0xC3, 0xCF,
  0x80, 0x7C, 0xF0, 0x79, 0xF0, 0x0F, 0xBE, 0x0F, 0x3E, 0x01, 0xF7, 0x81,
  0xEF, 0x80, 0x3E, 0xF0, 0x3D, 0xF0, 0x07, 0xFE, 0x07, 0xFC, 0x00, 0xFF,
  0x80, 0xFF, 0x80, 0x1F, 0xF0, 0x1F, 0xE0, 0x03, 0xFC, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x7F, 0x80, 0x0F, 0xE0, 0x0F, 0xE0, 0x01, 0xFC, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x1F, 0x01, 0xF8, 0x00, 0xF8, 0x0F, 0x80, 0x07, 0xE0, 0xFC,
  0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x07, 0xC7, 0xE0, 0x00,
  0x3F, 0x7E, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0xFC,
  0xF8, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x07, 0xE0, 0xF8,
  0x00, 0x7E, 0x07, 0xE0, 0x03, 0xE0, 0x3F, 0x00, 0x3F, 0x00, 0xF8, 0x03,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x3F, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xF8,
  0x01, 0xFF, 0xF0, 0x07, 0xC7, 0xC0, 0x3F, 0x1F, 0x01, 0xF8, 0x7C, 0x07,
  0xC1, 0xF0, 0x3F, 0x07, 0xE0, 0xF8, 0x0F, 0x87, 0xE0, 0x3E, 0x3F, 0x00,
  0xF8, 0xF8, 0x03, 0xE7, 0xE0, 0x0F, 0x9F, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x00,
  0xF0, 0x78, 0x3C, 0x1F, 0x0F, 0x87, 0xC3, 0xE0, 0xF0, 0x78, 0x3C, 0x1F,
  0x0F, 0x87, 0xC3, 0xE0, 0xF0, 0x78, 0x3C, 0x1F, 0x0F, 0x87, 0xC3, 0xE0,
  0xF0, 0x78, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE0, 0xF0, 0x78, 0x3E, 0x1F,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0,
  0x1F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFC, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x3D, 0xE0, 0x03, 0xEF, 0x80, 0x1E, 0x3C, 0x01,
  0xF1, 0xE0, 0x0F, 0x0F, 0x80, 0xF0, 0x3C, 0x0F, 0x81, 0xE0, 0x78, 0x0F,
  0x87, 0xC0, 0x3C, 0x3C, 0x01, 0xE3, 0xE0, 0x0F, 0x9E, 0x00, 0x3D, 0xE0,
  0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x7C, 0x7E,
  0x3E, 0x1E, 0x0F, 0x0F, 0x01, 0xF8, 0x78, 0x3F, 0xE7, 0xC3, 0xFF, 0xBE,
  0x1F, 0xFF, 0xE1, 0xFC, 0xFF, 0x1F, 0x83, 0xF8, 0xFC, 0x0F, 0xCF, 0xC0,
  0x7E, 0x7E, 0x03, 0xE3, 0xE0, 0x1F, 0x3F, 0x00, 0xF9, 0xF8, 0x07, 0xCF,
  0x80, 0x7C, 0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x01, 0xF8, 0xF8, 0x0F,
  0xC7, 0xC0, 0xFC, 0x3E, 0x0F, 0xE1, 0xF8, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F,
  0xF7, 0xC1, 0xFF, 0x3C, 0x07, 0xF1, 0xE0, 0x03, 0xF0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x7E, 0x03, 0xE7, 0xF8,
  0x1F, 0x7F, 0xE0, 0xFF, 0xFF, 0x07, 0xF1, 0xFC, 0x7F, 0x07, 0xE3, 0xF0,
  0x1F, 0x1F, 0x80, 0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x7E, 0x03, 0xF3,
  0xE0, 0x1F, 0x9F, 0x00, 0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x7E, 0x03,
  0xF3, 0xF0, 0x1F, 0x1F, 0x81, 0xF8, 0xFC, 0x1F, 0x8F, 0xF1, 0xFC, 0x7F,
  0xFF, 0xC3, 0xFF, 0xFC, 0x1E, 0x7F, 0xC0, 0xF1, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xC3, 0x0F, 0xC0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0xC0, 0x43, 0xF8, 0x70, 0x7F, 0xFC, 0x1F, 0xFF, 0x03,
  0xFF, 0xC0, 0x7F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x03, 0xF1, 0xF0, 0x1F, 0xF3, 0xE0,
  0x7F, 0xF7, 0xC0, 0xFF, 0xFF, 0x03, 0xF0, 0xFE, 0x0F, 0xC1, 0xFC, 0x1F,
  0x81, 0xF8, 0x7E, 0x03, 0xF0, 0xFC, 0x07, 0xC1, 0xF0, 0x0F, 0x87, 0xE0,
  0x1F, 0x0F, 0xC0, 0x3E, 0x1F, 0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x7C, 0x03,
  0xE0, 0xF8, 0x0F, 0xC1, 0xF0, 0x1F, 0x83, 0xE0, 0x7E, 0x07, 0xC0, 0xFC,
  0x0F, 0xC3, 0xF8, 0x1F, 0xFF, 0xF0, 0x1F, 0xFB, 0xE0, 0x3F, 0xE7, 0x80,
  0x3F, 0x8F, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x07, 0xFF,
  0xE1, 0xF8, 0x7C, 0x7E, 0x07, 0xCF, 0x80, 0xF3, 0xF0, 0x3E, 0x7C, 0x0F,
  0xCF, 0x83, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0x8F, 0xFF, 0xC1, 0xFF, 0xC0,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7E, 0x03, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x07, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF8,
  0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x7E, 0x1E, 0x03, 0xFE, 0x7C, 0x0F, 0xFE, 0xF8,
  0x1F, 0xFF, 0xE0, 0x7F, 0x1F, 0xC1, 0xF8, 0x3F, 0x83, 0xF0, 0x3F, 0x0F,
  0xC0, 0x7E, 0x1F, 0x80, 0xF8, 0x3E, 0x01, 0xF0, 0xFC, 0x03, 0xE1, 0xF8,
  0x07, 0xC3, 0xE0, 0x1F, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x7C, 0x1F, 0x01,
  0xF8, 0x3E, 0x03, 0xF0, 0x7C, 0x0F, 0xC0, 0xF8, 0x3F, 0x81, 0xF8, 0xFF,
  0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFD, 0xF0, 0x07, 0xF3, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x08,
  0x01, 0xF8, 0x1C, 0x07, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0xFF,
  0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x7E, 0x03, 0xE7,
  0xFC, 0x1F, 0x7F, 0xE0, 0xFF, 0xFF, 0x87, 0xF8, 0xFC, 0x7F, 0x07, 0xE3,
  0xF8, 0x3F, 0x1F, 0x81, 0xF8, 0xF8, 0x0F, 0xC7, 0xC0, 0x7C, 0x7E, 0x03,
  0xE3, 0xE0, 0x1F, 0x1F, 0x01, 0xF8, 0xF8, 0x0F, 0x87, 0xC0, 0x7C, 0x7E,
  0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x01, 0xF8, 0xF8, 0x0F, 0x8F, 0xC0, 0x7C,
  0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x01, 0xF8, 0xF8, 0x0F, 0x80, 0x01,
  0xE0, 0x3E, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x1F, 0x81, 0xF8, 0x1F,
  0x01, 0xF0, 0x1F, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7E,
  0x07, 0xC0, 0x7C, 0x07, 0xC0, 0xFC, 0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0xF8,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x07, 0xFE, 0x00,
  0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x08, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F,
  0x03, 0xF0, 0xF8, 0x1F, 0x83, 0xE0, 0x7C, 0x0F, 0x83, 0xE0, 0x3E, 0x1F,
  0x81, 0xF8, 0xFC, 0x07, 0xC7, 0xE0, 0x1F, 0x3F, 0x00, 0x7D, 0xF8, 0x01,
  0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x0F, 0xDF, 0x80, 0x7E, 0x7E, 0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xF0,
  0x1F, 0x0F, 0xC0, 0xFC, 0x1F, 0x03, 0xE0, 0x7E, 0x0F, 0x80, 0xF8, 0x3E,
  0x03, 0xF0, 0xF8, 0x0F, 0xC0, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x3F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x00, 0x07,
  0x8F, 0xC0, 0xFC, 0x07, 0xCF, 0xF1, 0xFF, 0x03, 0xCF, 0xFD, 0xFF, 0xC1,
  0xEF, 0xFE, 0xFF, 0xE0, 0xFF, 0x3F, 0xF3, 0xF0, 0xFE, 0x0F, 0xE0, 0xFC,
  0x7E, 0x07, 0xF0, 0x7C, 0x3F, 0x03, 0xF0, 0x3E, 0x1F, 0x01, 0xF0, 0x1F,
  0x0F, 0x80, 0xF8, 0x0F, 0x8F, 0xC0, 0x7C, 0x07, 0xC7, 0xC0, 0x7E, 0x07,
  0xE3, 0xE0, 0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0x80,
  0xF8, 0xFC, 0x0F, 0xC0, 0x7C, 0x7C, 0x07, 0xC0, 0x7E, 0x3E, 0x03, 0xE0,
  0x3E, 0x1F, 0x01, 0xF0, 0x1F, 0x1F, 0x80, 0xF8, 0x0F, 0x8F, 0x80, 0xFC,
  0x07, 0xC7, 0xC0, 0x7C, 0x07, 0xE3, 0xE0, 0x3E, 0x03, 0xE1, 0xF0, 0x1F,
  0x01, 0xF0, 0x07, 0xC7, 0xE0, 0x1F, 0x3F, 0xE0, 0x79, 0xFF, 0x81, 0xEF,
  0xFF, 0x07, 0xF8, 0xFC, 0x3F, 0x83, 0xF0, 0xFE, 0x0F, 0xC3, 0xF0, 0x3F,
  0x0F, 0xC0, 0xFC, 0x3E, 0x03, 0xE1, 0xF8, 0x0F, 0x87, 0xC0, 0x3E, 0x1F,
  0x01, 0xF8, 0x7C, 0x07, 0xE1, 0xF0, 0x1F, 0x0F, 0xC0, 0x7C, 0x3E, 0x01,
  0xF0, 0xF8, 0x0F, 0xC3, 0xE0, 0x3E, 0x1F, 0x80, 0xF8, 0x7E, 0x03, 0xE1,
  0xF0, 0x0F, 0x87, 0xC0, 0x7E, 0x3F, 0x01, 0xF0, 0x01, 0xFE, 0x00, 0x7F,
  0xF0, 0x3F, 0xFF, 0x0F, 0xFF, 0xE1, 0xF8, 0x7E, 0x7E, 0x07, 0xCF, 0x80,
  0xFB, 0xF0, 0x1F, 0x7C, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3E, 0xF8, 0x0F,
  0xDF, 0x01, 0xFB, 0xE0, 0x7E, 0x7E, 0x1F, 0x87, 0xFF, 0xF0, 0xFF, 0xFC,
  0x0F, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0xF1, 0xF8, 0x01, 0xF3, 0xFC, 0x01,
  0xE7, 0xFE, 0x01, 0xEF, 0xFE, 0x01, 0xFC, 0x3F, 0x03, 0xF8, 0x3F, 0x03,
  0xF0, 0x1F, 0x03, 0xF0, 0x1F, 0x03, 0xE0, 0x1F, 0x03, 0xE0, 0x1F, 0x07,
  0xE0, 0x3F, 0x07, 0xC0, 0x3F, 0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x3E, 0x07,
  0xC0, 0x3E, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x7C, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC1, 0xF8, 0x1F, 0xE3, 0xF8, 0x1F, 0xFF, 0xF0, 0x1F, 0x7F, 0xE0, 0x1F,
  0x7F, 0xC0, 0x1F, 0x3F, 0x80, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x78, 0x1F, 0xE7, 0xC3, 0xFF, 0xBE, 0x1F, 0xFF, 0xE1, 0xF8, 0x7F,
  0x1F, 0x83, 0xF8, 0xFC, 0x0F, 0xCF, 0xC0, 0x7E, 0x7C, 0x03, 0xE3, 0xE0,
  0x1F, 0x3F, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x7C, 0x7C, 0x03, 0xE3,
  0xE0, 0x1F, 0x1F, 0x01, 0xF8, 0xF8, 0x0F, 0xC7, 0xC0, 0xFC, 0x3E, 0x07,
  0xE1, 0xF8, 0x7F, 0x0F, 0xFF, 0xF8, 0x3F, 0xF7, 0xC1, 0xFF, 0x7C, 0x07,
  0xF3, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x07, 0x8F, 0x87, 0xCF, 0xC3,
  0xEF, 0xE1, 0xEF, 0xE0, 0xFF, 0xF0, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x01, 0xFF,
  0x01, 0xFF, 0xF0, 0xFF, 0xFC, 0x7F, 0xFE, 0x1F, 0x83, 0x87, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F,
  0x00, 0x0F, 0xC8, 0x03, 0xE3, 0x81, 0xF8, 0xFF, 0xFE, 0x3F, 0xFF, 0x0F,
  0xFF, 0x81, 0xFF, 0x80, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x0F,
  0x80, 0x7F, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xFC, 0x03,
  0xFF, 0x0F, 0xFC, 0x1F, 0xF0, 0x3F, 0xC0, 0x1F, 0x80, 0xF8, 0xF8, 0x07,
  0xC7, 0xC0, 0x7E, 0x3E, 0x03, 0xE3, 0xF0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8,
  0x07, 0xC7, 0xC0, 0x7E, 0x3E, 0x03, 0xE3, 0xF0, 0x1F, 0x1F, 0x00, 0xF8,
  0xF8, 0x0F, 0xC7, 0xC0, 0x7C, 0x3E, 0x03, 0xE3, 0xF0, 0x1F, 0x1F, 0x01,
  0xF8, 0xF8, 0x0F, 0xC7, 0xC0, 0xFC, 0x3E, 0x0F, 0xE1, 0xF8, 0xFF, 0x0F,
  0xFF, 0xF8, 0x7F, 0xF7, 0xC1, 0xFF, 0x3C, 0x07, 0xF1, 0xE0, 0xF8, 0x01,
  0xFF, 0xC0, 0x3F, 0x7C, 0x03, 0xE7, 0xC0, 0x7E, 0x7C, 0x07, 0xC7, 0xC0,
  0xFC, 0x7C, 0x0F, 0x87, 0xC1, 0xF8, 0x7C, 0x1F, 0x07, 0xC3, 0xE0, 0x7C,
  0x3E, 0x07, 0xC7, 0xC0, 0x7C, 0x7C, 0x07, 0xCF, 0x80, 0x3C, 0xF8, 0x03,
  0xDF, 0x00, 0x3D, 0xF0, 0x03, 0xDE, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0xF8, 0x0F,
  0x80, 0xFF, 0xE0, 0x7E, 0x03, 0xEF, 0x81, 0xF8, 0x0F, 0xBE, 0x0F, 0xE0,
  0x7C, 0xF8, 0x3F, 0x81, 0xF3, 0xE1, 0xFE, 0x0F, 0x8F, 0x87, 0xB8, 0x3E,
  0x3E, 0x1F, 0xE1, 0xF8, 0xF8, 0xF7, 0x87, 0xC3, 0xE3, 0xDE, 0x1F, 0x0F,
  0x9F, 0x78, 0xF8, 0x3E, 0x79, 0xE3, 0xE0, 0xFB, 0xE7, 0x9F, 0x03, 0xEF,
  0x1E, 0x7C, 0x0F, 0xBC, 0x79, 0xE0, 0x3D, 0xE1, 0xEF, 0x80, 0xF7, 0x87,
  0xBE, 0x03, 0xDE, 0x1E, 0xF0, 0x0F, 0xF0, 0x7F, 0xC0, 0x3F, 0xC1, 0xFE,
  0x00, 0xFE, 0x07, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x0F, 0xE0, 0x7F, 0x00,
  0x3F, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x3F, 0x03, 0xE0, 0x7E, 0x03, 0xE0,
  0x7E, 0x03, 0xF0, 0xFC, 0x01, 0xF1, 0xF8, 0x01, 0xF1, 0xF0, 0x01, 0xFB,
  0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x03, 0xFF, 0x80, 0x03, 0xEF, 0x80, 0x07, 0xCF, 0x80, 0x0F, 0xCF,
  0xC0, 0x1F, 0x87, 0xC0, 0x1F, 0x07, 0xC0, 0x3F, 0x07, 0xE0, 0x7E, 0x03,
  0xE0, 0xFC, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xC0, 0x7C, 0x03, 0xF0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x7E, 0x01, 0xF0, 0x1F, 0x00, 0x7C, 0x0F, 0xC0,
  0x1F, 0x03, 0xE0, 0x07, 0xC1, 0xF8, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x3F,
  0x00, 0x0F, 0x0F, 0x80, 0x03, 0xC7, 0xE0, 0x00, 0xF1, 0xF0, 0x00, 0x3C,
  0xFC, 0x00, 0x0F, 0xBE, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0B, 0x80, 0x00, 0x00, 0x07, 0xFF,
  0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x00, 0x07, 0xC0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0x7F, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x00, 0x0F,
  0xC0, 0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x7F, 0xC0,
  0x1F, 0xE0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFF, 0x00, 0x07, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xE0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xC0, 0x00, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF0,
  0x00, 0xFC, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x07, 0xE0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x3F,
  0xC0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xC0, 0x0F, 0xC0, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x1F, 0x80, 0x3F, 0xC0,
  0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x17, 0xFE, 0x03,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFC, 0x03, 0xFE, 0x80, 0x0F,
  0x80,
};

const GFXglyph NotoSans_SemiCondensed_SemiBoldItalic44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 13, 32, 12, 0, -31 },
  { 53, 15, 11, 18, 4, -31 },
  { 74, 25, 31, 25, 1, -31 },
  { 171, 21, 36, 22, 1, -33 },
  { 266, 29, 32, 34, 3, -32 },
  { 382, 26, 32, 27, 1, -32 },
  { 486, 7, 11, 10, 4, -31 },
  { 496, 15, 38, 13, 1, -31 },
  { 568, 15, 39, 13, -3, -32 },
  { 642, 19, 20, 22, 4, -34 },
  { 690, 20, 21, 23, 2, -26 },
  { 743, 9, 11, 11, -2, -5 },
  { 756, 11, 5, 13, 1, -14 },
  { 763, 7, 7, 11, 0, -6 },
  { 770, 22, 32, 17, -2, -32 },
  { 858, 21, 32, 22, 1, -32 },
  { 942, 14, 31, 22, 5, -31 },
  { 997, 23, 32, 22, -1, -32 },
  { 1089, 22, 32, 22, 0, -32 },
  { 1177, 22, 32, 22, 0, -32 },
  { 1265, 21, 31, 22, 1, -31 },
  { 1347, 21, 32, 22, 2, -32 },
  { 1431, 22, 31, 22, 2, -31 },
  { 1517, 21, 32, 22, 1, -32 },
  { 1601, 20, 32, 22, 1, -32 },
  { 1681, 11, 25, 11, 0, -24 },
  { 1716, 13, 30, 11, -2, -24 },
  { 1765, 20, 22, 23, 2, -27 },
  { 1820, 20, 13, 23, 2, -22 },
  { 1853, 20, 22, 23, 2, -27 },
  { 1908, 17, 33, 18, 2, -32 },
  { 1979, 31, 36, 34, 2, -32 },
  { 2119, 24, 31, 24, -3, -31 },
  { 2212, 23, 31, 24, 1, -31 },
  { 2302, 24, 32, 24, 2, -32 },
  { 2398, 25, 31, 27, 1, -31 },
  { 2495, 22, 31, 21, 1, -31 },
  { 2581, 22, 31, 20, 1, -31 },
  { 2667, 25, 32, 27, 2, -32 },
  { 2767, 27, 31, 28, 1, -31 },
  { 2872, 19, 31, 15, -1, -31 },
  { 2946, 20, 40, 12, -7, -31 },
  { 3046, 27, 31, 24, 1, -31 },
  { 3151, 16, 31, 20, 1, -31 },
  { 3213, 35, 31, 35, 1, -31 },
  { 3349, 29, 31, 29, 1, -31 },
  { 3462, 26, 32, 29, 2, -32 },
  { 3566, 23, 31, 24, 1, -31 },
  { 3656, 26, 39, 29, 2, -32 },
  { 3783, 23, 31, 24, 1, -31 },
  { 3873, 22, 32, 21, 0, -32 },
  { 3961, 20, 31, 21, 4, -31 },
  { 4039, 25, 31, 27, 3, -31 },
  { 4136, 23, 31, 23, 4, -31 },
  { 4226, 35, 31, 36, 4, -31 },
  { 4362, 29, 31, 23, -3, -31 },
  { 4475, 22, 31, 22, 4, -31 },
  { 4561, 24, 31, 21, -1, -31 },
  { 4654, 18, 38, 13, -1, -31 },
  { 4740, 9, 32, 17, 5, -32 },
  { 4776, 17, 38, 13, -3, -31 },
  { 4857, 21, 20, 22, 1, -32 },
  { 4910, 17, 3, 16, -4, 4 },
  { 4917, 8, 7, 13, 6, -34 },
  { 4924, 21, 24, 23, 2, -24 },
  { 4987, 21, 33, 24, 1, -33 },
  { 5074, 18, 24, 19, 2, -24 },
  { 5128, 23, 33, 24, 2, -33 },
  { 5223, 19, 24, 21, 2, -24 },
  { 5280, 24, 45, 14, -5, -34 },
  { 5415, 23, 35, 24, 0, -24 },
  { 5516, 21, 33, 24, 1, -33 },
  { 5603, 12, 33, 11, 1, -33 },
  { 5653, 19, 44, 11, -6, -33 },
  { 5758, 22, 33, 22, 1, -33 },
  { 5849, 13, 33, 11, 0, -33 },
  { 5903, 33, 24, 35, 1, -24 },
  { 6002, 22, 24, 24, 0, -24 },
  { 6068, 19, 24, 23, 2, -24 },
  { 6125, 24, 34, 24, -2, -24 },
  { 6227, 21, 35, 24, 2, -24 },
  { 6319, 17, 24, 16, 1, -24 },
  { 6370, 18, 24, 18, 0, -24 },
  { 6424, 14, 29, 15, 2, -29 },
  { 6475, 21, 24, 24, 2, -24 },
  { 6538, 20, 24, 20, 2, -24 },
  { 6598, 30, 24, 31, 3, -24 },
  { 6688, 24, 24, 21, -2, -24 },
  { 6760, 26, 35, 20, -4, -24 },
  { 6874, 20, 24, 18, -1, -24 },
  { 6934, 18, 38, 15, 0, -31 },
  { 7020, 4, 43, 21, 9, -33 },
  { 7042, 17, 38, 15, -2, -31 },
  { 7123, 20, 7, 23, 2, -19 },
};

const GFXfont NotoSans_SemiCondensed_SemiBoldItalic44pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_SemiBoldItalic44pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_SemiBoldItalic44pt7bGlyphs,
  0x20, 0x7E, 60
};

#endif // _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC44PT7B_H_
