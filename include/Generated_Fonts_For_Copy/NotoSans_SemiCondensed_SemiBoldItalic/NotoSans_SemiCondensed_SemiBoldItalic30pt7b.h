#ifndef _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC30PT7B_H_
#define _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC30PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-SemiBoldItalic.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_SemiBoldItalic30pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x87, 0x83, 0xC1, 0xE0, 0xF0, 0x70, 0x78, 0x3C, 0x1E, 0x0E,
  0x07, 0x07, 0x83, 0xC1, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x3E, 0x1F, 0x07,
  0x00, 0x7B, 0xDC, 0xF7, 0x39, 0xCE, 0xE3, 0xB8, 0xCE, 0x70, 0x00, 0xE7,
  0x00, 0x71, 0xC0, 0x1C, 0x70, 0x07, 0x18, 0x01, 0x8E, 0x00, 0xE3, 0x83,
  0xFF, 0xFC, 0xFF, 0xFF, 0x07, 0x1C, 0x01, 0xC6, 0x00, 0x61, 0x80, 0x18,
  0xE0, 0x7F, 0xFF, 0x1F, 0xFF, 0xCF, 0xFF, 0xF0, 0x71, 0xC0, 0x1C, 0x60,
  0x06, 0x38, 0x03, 0x8E, 0x00, 0xE3, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x40,
  0x03, 0x00, 0x0C, 0x01, 0xFE, 0x1F, 0xFC, 0x7F, 0xE3, 0xD8, 0x8E, 0x60,
  0x39, 0x80, 0xF6, 0x03, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x2F,
  0x00, 0x9C, 0x06, 0x72, 0x1B, 0xCE, 0x7F, 0x3F, 0xF8, 0xFF, 0xC0, 0x78,
  0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x0E, 0x00, 0x01, 0xF0, 0x1C, 0x3F,
  0x83, 0x87, 0x38, 0x38, 0x73, 0x87, 0x0E, 0x38, 0xE0, 0xE3, 0x8E, 0x0E,
  0x39, 0xC0, 0xE3, 0x38, 0x0E, 0x73, 0xBE, 0xE7, 0x77, 0xFF, 0xEE, 0xF7,
  0x7C, 0xEE, 0x73, 0x9C, 0xC7, 0x03, 0x9C, 0x70, 0x39, 0xC7, 0x07, 0x1C,
  0x70, 0xE1, 0xCE, 0x0E, 0x1C, 0xE1, 0xC1, 0xDE, 0x38, 0x1F, 0xC7, 0x80,
  0xF8, 0x00, 0xE0, 0x01, 0xFC, 0x01, 0xFE, 0x01, 0xE7, 0x80, 0xE3, 0xC0,
  0x71, 0xE0, 0x38, 0xE0, 0x1C, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xE0,
  0x03, 0xF0, 0xF7, 0xFC, 0x7B, 0xCE, 0x3B, 0xC7, 0xBD, 0xC1, 0xFC, 0xE0,
  0xFC, 0x70, 0x3C, 0x3C, 0x3F, 0x1F, 0xFF, 0x87, 0xFD, 0xE1, 0xF8, 0xF8,
  0x7B, 0x9C, 0xEE, 0x73, 0x80, 0x03, 0xC1, 0xE0, 0x70, 0x38, 0x1E, 0x07,
  0x03, 0xC0, 0xE0, 0x78, 0x1C, 0x07, 0x01, 0xC0, 0xF0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0F, 0x01, 0xC0, 0x70,
  0x0E, 0x00, 0x07, 0x00, 0xE0, 0x38, 0x0E, 0x03, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0xF0, 0x38, 0x0E, 0x03, 0x81,
  0xE0, 0x70, 0x3C, 0x0E, 0x07, 0x81, 0xC0, 0xF0, 0x38, 0x1C, 0x0E, 0x00,
  0x03, 0x00, 0x78, 0x07, 0x0C, 0x70, 0xF7, 0x0F, 0xFF, 0x3F, 0xF0, 0xFF,
  0x3F, 0x07, 0xB8, 0xF3, 0x83, 0x1C, 0x21, 0x80, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x3C, 0xF3, 0x9E,
  0x71, 0xCE, 0x38, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x00, 0x1E,
  0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00,
  0x70, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0,
  0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0x80, 0x0F,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x1F, 0xC0, 0xFF, 0x87, 0xDE, 0x1E,
  0x3C, 0xF0, 0xF3, 0x83, 0xDE, 0x0F, 0x78, 0x3D, 0xC0, 0xF7, 0x03, 0xFC,
  0x0E, 0xF0, 0x7B, 0xC1, 0xEF, 0x07, 0xBC, 0x1C, 0xF0, 0xF3, 0xC3, 0xCF,
  0x1E, 0x1F, 0xF0, 0x7F, 0x80, 0xFC, 0x00, 0x03, 0xC3, 0xF1, 0xFC, 0xFE,
  0xFB, 0x9C, 0xE6, 0x78, 0x1E, 0x07, 0x01, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0x80, 0xE0, 0x78, 0x1E, 0x07, 0x01, 0xC0, 0xF0, 0x3C, 0x00, 0x00, 0xF0,
  0x03, 0xFC, 0x07, 0xFE, 0x0F, 0xBF, 0x06, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x7F, 0xF8, 0x7F, 0xF8, 0xFF, 0xF8, 0x01, 0xE0, 0x0F, 0xF0, 0x7F, 0xF0,
  0x79, 0xF0, 0x81, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x03,
  0xF0, 0x1F, 0x80, 0x7F, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1C,
  0x00, 0x78, 0x00, 0xF2, 0x03, 0xC7, 0xFF, 0x8F, 0xFE, 0x0F, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x07, 0xE0, 0x1D, 0xC0, 0x7F, 0x80,
  0xEE, 0x03, 0x9C, 0x0E, 0x78, 0x3C, 0xF0, 0x71, 0xE1, 0xC3, 0x87, 0x07,
  0x1F, 0xFF, 0xBF, 0xFF, 0x7F, 0xFE, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1C, 0x00, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF0, 0x78, 0x00,
  0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1F, 0xE0, 0x7F, 0xE0, 0x7F,
  0xE0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x79,
  0x81, 0xE3, 0xFF, 0xC7, 0xFF, 0x07, 0xF8, 0x00, 0x00, 0x3C, 0x07, 0xF0,
  0x7F, 0xC3, 0xF1, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x0E, 0x00, 0x39, 0xC1,
  0xFF, 0xC7, 0xFF, 0x1F, 0x3E, 0xF8, 0x7B, 0xC1, 0xEF, 0x07, 0xBC, 0x1E,
  0xF0, 0x73, 0xC3, 0xC7, 0x0F, 0x1F, 0xF8, 0x7F, 0xC0, 0x7E, 0x00, 0x3F,
  0xFE, 0x7F, 0xFC, 0xFF, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1C,
  0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00,
  0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x80, 0x00, 0x01, 0xE0, 0x1F, 0xE0, 0xFF, 0xC7, 0x8F, 0x1C, 0x1C,
  0xF0, 0x73, 0xC3, 0xC7, 0x0F, 0x1E, 0x78, 0x3F, 0xC0, 0x7C, 0x07, 0xF0,
  0x3D, 0xE1, 0xE3, 0xCF, 0x07, 0x38, 0x1E, 0xE0, 0x7B, 0x81, 0xCF, 0x0F,
  0x3F, 0xF8, 0x7F, 0xE0, 0xFE, 0x00, 0x03, 0xC0, 0x3F, 0xC1, 0xFF, 0x8F,
  0x9E, 0x3C, 0x39, 0xE0, 0xF7, 0x83, 0xDE, 0x0F, 0x70, 0x3D, 0xE1, 0xE7,
  0x87, 0x9F, 0xFE, 0x3F, 0xF8, 0x7D, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0,
  0x07, 0x80, 0x3C, 0x3F, 0xE0, 0xFF, 0x03, 0xF8, 0x00, 0x04, 0x3C, 0x78,
  0xF1, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x3E, 0x7C, 0xF0,
  0x01, 0x03, 0xC1, 0xE0, 0xF0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x78, 0x38, 0x3C, 0x1C, 0x1E, 0x0E, 0x0E, 0x00,
  0x00, 0x08, 0x01, 0xC0, 0x3E, 0x07, 0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0x1E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0x80, 0x0C, 0x00,
  0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x07, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x01, 0xF8, 0x7F, 0x0F, 0xC1, 0xF8, 0x0F,
  0x00, 0x60, 0x02, 0x00, 0x00, 0x07, 0x0F, 0xF9, 0xFF, 0xB8, 0xF4, 0x1E,
  0x01, 0xC0, 0x78, 0x0E, 0x03, 0xC0, 0xF0, 0x7C, 0x0F, 0x03, 0xC0, 0x70,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x7C, 0x0F, 0x03, 0xC0, 0x0E, 0x1E,
  0x00, 0x38, 0x70, 0x78, 0x63, 0x87, 0xF9, 0xCC, 0x3F, 0xC7, 0x71, 0xC7,
  0x1D, 0xCE, 0x1C, 0x76, 0x38, 0x61, 0xB8, 0xC3, 0x86, 0xE3, 0x0E, 0x3B,
  0x9C, 0x38, 0xEE, 0x71, 0xE7, 0x38, 0xEF, 0xB8, 0xE3, 0xF7, 0xC1, 0x87,
  0x0E, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x02, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xE0, 0x00, 0x70, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0x70, 0x07, 0xBC, 0x03, 0x9E, 0x03,
  0xCF, 0x01, 0xC3, 0x81, 0xE1, 0xC0, 0xE0, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8,
  0x7F, 0xFC, 0x3C, 0x0E, 0x3C, 0x07, 0x1E, 0x03, 0x9E, 0x01, 0xCF, 0x00,
  0xEF, 0x00, 0x78, 0x0F, 0xFC, 0x0F, 0xFE, 0x1F, 0xFE, 0x1E, 0x1F, 0x1E,
  0x0F, 0x1C, 0x0E, 0x1C, 0x1E, 0x3C, 0x1E, 0x3F, 0xFC, 0x3F, 0xF0, 0x3F,
  0xF0, 0x38, 0x78, 0x78, 0x3C, 0x78, 0x3C, 0x78, 0x3C, 0x70, 0x3C, 0x70,
  0x3C, 0xF0, 0xF8, 0xFF, 0xF8, 0xFF, 0xE0, 0xFF, 0x80, 0x00, 0xF0, 0x03,
  0xFF, 0x0F, 0xFE, 0x1F, 0xDE, 0x1E, 0x04, 0x3C, 0x00, 0x7C, 0x00, 0x78,
  0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x20, 0x7F,
  0xE0, 0x3F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF8, 0x07, 0xFF, 0x07, 0xFF, 0x83,
  0xC3, 0xE1, 0xE0, 0xF0, 0xF0, 0x38, 0x70, 0x1E, 0x78, 0x0F, 0x3C, 0x07,
  0x9E, 0x03, 0x8F, 0x03, 0xC7, 0x01, 0xE7, 0x80, 0xF3, 0xC0, 0xF9, 0xE0,
  0x78, 0xE0, 0x7C, 0x70, 0x7C, 0x78, 0xFC, 0x3F, 0xFC, 0x1F, 0xFC, 0x0F,
  0xF8, 0x00, 0x0F, 0xFE, 0x1F, 0xF8, 0x7F, 0xF0, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x00, 0x1E, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03,
  0xFF, 0x87, 0xFE, 0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x1F, 0xF8, 0x7F, 0xF0,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7F,
  0xE0, 0xFF, 0xC1, 0xFF, 0x87, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00,
  0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x00, 0x00, 0x78,
  0x01, 0xFF, 0xC1, 0xFF, 0xC3, 0xFB, 0xE1, 0xF0, 0x11, 0xE0, 0x01, 0xF0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x3F, 0x9E, 0x1F, 0xCF,
  0x0F, 0xE7, 0x00, 0xF3, 0x80, 0x79, 0xC0, 0x38, 0xF0, 0x3C, 0x78, 0x1E,
  0x3E, 0x0F, 0x0F, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0x80, 0x0F, 0x03, 0xC3,
  0x80, 0xF1, 0xE0, 0x3C, 0x78, 0x0E, 0x1E, 0x07, 0x87, 0x81, 0xE1, 0xC0,
  0x78, 0xF0, 0x1E, 0x3F, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0xE0, 0x3C,
  0x78, 0x0E, 0x1E, 0x03, 0x87, 0x81, 0xE1, 0xC0, 0x78, 0x70, 0x1E, 0x3C,
  0x07, 0x0F, 0x01, 0xC3, 0xC0, 0xF0, 0xE0, 0x3C, 0x00, 0x0F, 0xF8, 0x7F,
  0xC0, 0xF0, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x38, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x1E,
  0x00, 0xF0, 0x0F, 0xC1, 0xFF, 0x0F, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x78,
  0x03, 0xE0, 0x7F, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x0F, 0x07, 0xC3, 0x83,
  0xC1, 0xE1, 0xE0, 0x78, 0xF8, 0x1E, 0x3C, 0x07, 0x1E, 0x01, 0xCF, 0x00,
  0xF7, 0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7D,
  0xE0, 0x1E, 0x78, 0x07, 0x8E, 0x01, 0xC3, 0xC0, 0x70, 0xF0, 0x3C, 0x3C,
  0x0F, 0x07, 0x83, 0x81, 0xE0, 0xE0, 0x78, 0x00, 0x0F, 0x01, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x38, 0x07, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x1C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0x70, 0x1E, 0x03, 0xFF, 0xFF, 0xEF,
  0xFC, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0xFC, 0x7E, 0x01, 0xF8, 0xFC, 0x07,
  0xE1, 0xF8, 0x0F, 0xC3, 0xF0, 0x3B, 0x87, 0xE0, 0x7F, 0x1E, 0xC1, 0xDE,
  0x3D, 0xC3, 0xB8, 0x73, 0x8E, 0x70, 0xE7, 0x1C, 0xE1, 0xCE, 0x73, 0xC7,
  0x9C, 0xE7, 0x8F, 0x3B, 0x8E, 0x1C, 0x77, 0x1C, 0x38, 0xFC, 0x78, 0x71,
  0xF8, 0xF1, 0xE3, 0xE1, 0xE3, 0x87, 0xC3, 0x87, 0x0F, 0x07, 0x0E, 0x1E,
  0x1E, 0x00, 0x0F, 0x00, 0xE1, 0xF0, 0x1C, 0x7E, 0x07, 0x8F, 0xC0, 0xF1,
  0xFC, 0x1C, 0x3F, 0x83, 0x87, 0x70, 0x71, 0xEE, 0x1E, 0x3D, 0xE3, 0xC7,
  0x1C, 0x70, 0xE3, 0x8E, 0x1C, 0x79, 0xC7, 0x8F, 0x78, 0xF0, 0xEE, 0x1C,
  0x1D, 0xC3, 0x83, 0xF8, 0x70, 0x3F, 0x1E, 0x07, 0xE3, 0x80, 0xF8, 0x70,
  0x1F, 0x0E, 0x01, 0xE0, 0x00, 0xF0, 0x01, 0xFE, 0x03, 0xFF, 0x83, 0xFF,
  0xE3, 0xE0, 0xF1, 0xE0, 0x3D, 0xE0, 0x1E, 0xF0, 0x0F, 0x70, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x77, 0x00, 0x7B, 0x80, 0x3D,
  0xC0, 0x3C, 0xF0, 0x1E, 0x78, 0x1E, 0x3E, 0x1F, 0x0F, 0xFF, 0x03, 0xFF,
  0x00, 0xFE, 0x00, 0x0F, 0xF8, 0x0F, 0xFC, 0x1F, 0xFE, 0x1E, 0x1E, 0x1E,
  0x0E, 0x1E, 0x0F, 0x1C, 0x0E, 0x3C, 0x1E, 0x3C, 0x1E, 0x3C, 0x7C, 0x3F,
  0xFC, 0x3F, 0xF0, 0x7F, 0xE0, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x01,
  0xFE, 0x03, 0xFF, 0x83, 0xFF, 0xE3, 0xE0, 0xF1, 0xE0, 0x3D, 0xE0, 0x1E,
  0xF0, 0x0F, 0x78, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0xF7, 0x00, 0x7B, 0x80, 0x3D, 0xC0, 0x3C, 0xF0, 0x1E, 0x78, 0x1E, 0x3E,
  0x1F, 0x0F, 0xFF, 0x03, 0xFF, 0x00, 0xFE, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0xF8, 0x1F, 0xF8, 0x7F,
  0xF8, 0xF0, 0xF1, 0xE1, 0xE3, 0xC3, 0xC7, 0x07, 0x9E, 0x0F, 0x3C, 0x3C,
  0x7B, 0xF8, 0xFF, 0xE1, 0xFF, 0x07, 0x9E, 0x0F, 0x3C, 0x1E, 0x38, 0x38,
  0x78, 0x70, 0xF1, 0xE0, 0xE3, 0xC1, 0xE7, 0x83, 0xCE, 0x07, 0xC0, 0x00,
  0xF0, 0x0F, 0xFC, 0x3F, 0xF8, 0x7F, 0xE1, 0xE0, 0x43, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE3, 0x07, 0xC7, 0xFF,
  0x0F, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0xFD, 0xFF, 0xFF, 0xFF, 0xC1, 0xE0,
  0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0E, 0x00, 0x78, 0x00, 0x1E, 0x07, 0x8E, 0x03, 0xCF, 0x01,
  0xC7, 0x80, 0xE3, 0xC0, 0xF1, 0xC0, 0x79, 0xE0, 0x3C, 0xF0, 0x1C, 0x78,
  0x1E, 0x3C, 0x0F, 0x1C, 0x07, 0x9E, 0x03, 0xCF, 0x01, 0xC7, 0x81, 0xE3,
  0xC0, 0xF1, 0xC0, 0x78, 0xF0, 0x78, 0x78, 0x7C, 0x3F, 0xFC, 0x0F, 0xFC,
  0x03, 0xFC, 0x00, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0xF7, 0x01, 0xEE, 0x07,
  0x9E, 0x0F, 0x3C, 0x3C, 0x78, 0x78, 0xF1, 0xE1, 0xE3, 0xC3, 0xC7, 0x07,
  0x9E, 0x07, 0x38, 0x0E, 0xF0, 0x1D, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xFC,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x00, 0xE0, 0x38, 0x0F, 0xE0, 0x78,
  0x1E, 0xE0, 0x78, 0x1E, 0xE0, 0xF8, 0x1C, 0xE0, 0xF8, 0x3C, 0xE0, 0xFC,
  0x38, 0xE1, 0xDC, 0x78, 0xE1, 0xDC, 0x78, 0xE3, 0x9C, 0x70, 0xE3, 0x9C,
  0xF0, 0xE7, 0x9C, 0xE0, 0xE7, 0x1D, 0xE0, 0xE7, 0x1D, 0xC0, 0xEE, 0x1D,
  0xC0, 0xEE, 0x1F, 0xC0, 0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0xFC, 0x1F,
  0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x1E, 0x00, 0xF0, 0x1E, 0x00, 0x07, 0x81,
  0xF0, 0x38, 0x1C, 0x03, 0xC3, 0xC0, 0x3C, 0x78, 0x01, 0xC7, 0x00, 0x1C,
  0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x7B, 0xC0, 0x07, 0xBC, 0x00,
  0xF3, 0xC0, 0x1E, 0x1C, 0x01, 0xE1, 0xE0, 0x3C, 0x1E, 0x07, 0x81, 0xE0,
  0xF8, 0x0F, 0x00, 0xF0, 0x3F, 0xC1, 0xEF, 0x07, 0x9C, 0x3C, 0x70, 0xE1,
  0xC7, 0x87, 0xBC, 0x1E, 0xE0, 0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0x80,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x70, 0x00, 0x07, 0xFF, 0x87, 0xFF, 0x83, 0xFF, 0xC0, 0x03,
  0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1F, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF,
  0x80, 0x03, 0xF0, 0x7F, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x3C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x78, 0x07, 0x00, 0x70, 0x07,
  0xE0, 0x7E, 0x0F, 0xE0, 0xE3, 0x8F, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xE3,
  0x8E, 0x38, 0xE3, 0x8E, 0x3C, 0x71, 0xC7, 0x1C, 0x70, 0x07, 0xF0, 0x7E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x03, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x07, 0x80, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x0F, 0xE0, 0xFE, 0x0F, 0xC0,
  0x00, 0xC0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3F, 0x00, 0xEE, 0x01,
  0xDC, 0x07, 0x1C, 0x0E, 0x38, 0x38, 0x70, 0xE0, 0x71, 0xC0, 0xE7, 0x01,
  0xDE, 0x01, 0xC0, 0xFF, 0xFF, 0xFE, 0xF1, 0xE3, 0x8E, 0x1C, 0x01, 0x00,
  0x1F, 0x9C, 0x7F, 0xF1, 0xFF, 0xE3, 0xC3, 0xCF, 0x07, 0x9E, 0x0F, 0x38,
  0x1C, 0xF0, 0x39, 0xE0, 0xF3, 0xC1, 0xE7, 0x83, 0x8F, 0x0F, 0x1E, 0x3E,
  0x3F, 0xFC, 0x3F, 0xB8, 0x3E, 0xE0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x84, 0x07, 0x7E, 0x1F, 0xFC, 0x3F,
  0x7C, 0x78, 0x78, 0xF0, 0xF1, 0xC1, 0xE7, 0x83, 0xCF, 0x07, 0x9C, 0x0F,
  0x38, 0x1C, 0x70, 0x79, 0xE0, 0xF3, 0xE3, 0xC7, 0xFF, 0x0F, 0xFE, 0x39,
  0xF0, 0x00, 0x00, 0x80, 0x7F, 0x1F, 0xF3, 0xF6, 0x3C, 0x07, 0x80, 0x78,
  0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x04, 0x7F,
  0xC7, 0xFC, 0x3F, 0x80, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x1E, 0x01, 0x1E, 0x0F, 0xDE, 0x1F, 0xFC, 0x3E, 0xFC,
  0x3C, 0x3C, 0x78, 0x3C, 0x78, 0x3C, 0x70, 0x38, 0xF0, 0x38, 0xF0, 0x78,
  0xF0, 0x78, 0xF0, 0x70, 0xF0, 0xF0, 0xF1, 0xF0, 0xFF, 0xF0, 0x7F, 0x70,
  0x3E, 0x60, 0x01, 0x80, 0x3F, 0x87, 0xFE, 0x7C, 0xF3, 0xC3, 0xBC, 0x3D,
  0xE1, 0xEE, 0x7E, 0xFF, 0xE7, 0xFC, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x11, 0xF7, 0x8F, 0xFC, 0x3F, 0xC0, 0x00, 0x1E, 0x00, 0x7F, 0x00, 0x7E,
  0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x07, 0xFC, 0x07, 0xF8,
  0x0F, 0xF8, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0x00, 0x80, 0x07, 0xE7, 0x0F, 0xFE,
  0x1F, 0xFE, 0x1E, 0x1E, 0x3C, 0x1E, 0x3C, 0x1E, 0x38, 0x1C, 0x78, 0x1C,
  0x78, 0x3C, 0x78, 0x3C, 0x78, 0x38, 0x78, 0x78, 0x78, 0xF8, 0x7F, 0xF8,
  0x3F, 0xF8, 0x1F, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x81, 0xE0,
  0xFF, 0xE0, 0xFF, 0xC0, 0x7F, 0x00, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x8C, 0x07, 0x7E, 0x1F, 0xFC, 0x3F,
  0x7C, 0x7C, 0x78, 0xF0, 0xF1, 0xC1, 0xE7, 0x83, 0x8F, 0x07, 0x1E, 0x1E,
  0x38, 0x3C, 0x70, 0x79, 0xE0, 0xE3, 0xC1, 0xC7, 0x07, 0x8E, 0x0F, 0x3C,
  0x1E, 0x00, 0x02, 0x03, 0xC3, 0xE0, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x1E,
  0x0F, 0x07, 0x83, 0x81, 0xC1, 0xE0, 0xF0, 0x78, 0x38, 0x1C, 0x1E, 0x0F,
  0x07, 0x83, 0x83, 0xC0, 0x00, 0x20, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80,
  0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x81,
  0xFC, 0x0F, 0xC0, 0x7C, 0x00, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x1F, 0x1E, 0x3C, 0x1E,
  0x38, 0x1E, 0x78, 0x1C, 0xF0, 0x1D, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F,
  0xC0, 0x3D, 0xE0, 0x39, 0xE0, 0x78, 0xE0, 0x78, 0xF0, 0x70, 0xF0, 0x70,
  0x70, 0xF0, 0x78, 0x07, 0x83, 0xC1, 0xC1, 0xE0, 0xF0, 0x78, 0x38, 0x1C,
  0x1E, 0x0F, 0x07, 0x83, 0x81, 0xC1, 0xE0, 0xF0, 0x78, 0x38, 0x3C, 0x1E,
  0x0F, 0x07, 0x03, 0x83, 0xC0, 0x00, 0x10, 0x10, 0x1D, 0xF9, 0xF8, 0x77,
  0xF7, 0xF8, 0xFD, 0xFF, 0xF1, 0xF1, 0xF1, 0xE3, 0xC3, 0xC3, 0xC7, 0x07,
  0x87, 0x9E, 0x0E, 0x0E, 0x3C, 0x3C, 0x1C, 0x70, 0x78, 0x78, 0xE0, 0xF0,
  0xF1, 0xC1, 0xC1, 0xE7, 0x83, 0x83, 0x8F, 0x0F, 0x07, 0x1C, 0x1E, 0x1E,
  0x38, 0x3C, 0x3C, 0xF0, 0x70, 0x78, 0x00, 0x10, 0x1D, 0xF8, 0x77, 0xF8,
  0xFF, 0xF1, 0xF1, 0xE3, 0xC3, 0xC7, 0x07, 0x9E, 0x0E, 0x3C, 0x1C, 0x78,
  0x78, 0xE0, 0xF3, 0xC1, 0xE7, 0x83, 0x8F, 0x07, 0x1C, 0x1E, 0x38, 0x3C,
  0xF0, 0x78, 0x00, 0x80, 0x3F, 0xC1, 0xFF, 0x8F, 0xBE, 0x3C, 0x39, 0xE0,
  0xF7, 0x83, 0xDC, 0x0F, 0xF0, 0x3B, 0xC0, 0xEF, 0x07, 0xBC, 0x1E, 0xF0,
  0xF3, 0xC3, 0xC7, 0xFE, 0x1F, 0xF0, 0x1F, 0x80, 0x00, 0x08, 0x07, 0x7E,
  0x0E, 0xFE, 0x0F, 0xDF, 0x0F, 0x0F, 0x0F, 0x0F, 0x0E, 0x0F, 0x1E, 0x0F,
  0x1E, 0x0F, 0x1C, 0x0F, 0x1C, 0x0E, 0x1C, 0x1E, 0x3C, 0x1E, 0x3E, 0x3C,
  0x3F, 0xF8, 0x3B, 0xF8, 0x7B, 0xE0, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00,
  0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x01, 0x00, 0x1F, 0x9C,
  0x7F, 0xF1, 0xF7, 0xE3, 0xC3, 0xCF, 0x07, 0x9E, 0x0F, 0x38, 0x1C, 0xF0,
  0x39, 0xE0, 0xF3, 0xC1, 0xE7, 0x83, 0x8F, 0x0F, 0x1E, 0x3E, 0x3F, 0xFC,
  0x3F, 0xF8, 0x3E, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x38, 0x00, 0x70, 0x01, 0xE0, 0x00, 0x10, 0xEF, 0x1F, 0xF1, 0xFF, 0x1F,
  0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x78,
  0x07, 0x80, 0x70, 0x07, 0x00, 0xF0, 0x00, 0x03, 0x00, 0xFF, 0x1F, 0xF3,
  0xE6, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x03, 0xC0,
  0x1E, 0x01, 0xE8, 0x1C, 0xFF, 0xCF, 0xF8, 0xFF, 0x00, 0x06, 0x03, 0x80,
  0xE0, 0x78, 0x7F, 0xDF, 0xFF, 0xF8, 0xF0, 0x3C, 0x0E, 0x03, 0x81, 0xE0,
  0x78, 0x1C, 0x07, 0x01, 0xC0, 0xF0, 0x3F, 0x87, 0xE1, 0xF8, 0x1C, 0x1E,
  0x78, 0x38, 0xF0, 0x71, 0xC1, 0xE3, 0x83, 0xCF, 0x07, 0x9E, 0x0E, 0x3C,
  0x1C, 0x70, 0x78, 0xE0, 0xF3, 0xC1, 0xC7, 0x87, 0x8F, 0x1F, 0x1F, 0xFE,
  0x1F, 0xDC, 0x3F, 0x30, 0xE0, 0x7F, 0x03, 0xB8, 0x3D, 0xC1, 0xCE, 0x1E,
  0x70, 0xE3, 0x8F, 0x1C, 0x70, 0xF7, 0x87, 0xB8, 0x3F, 0xC0, 0xFC, 0x07,
  0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0xE0, 0xF0, 0xFE, 0x1F, 0x0F, 0xE1,
  0xF0, 0xEE, 0x3F, 0x1E, 0xE3, 0xF1, 0xCE, 0x37, 0x3C, 0xE7, 0x73, 0x8E,
  0x77, 0x38, 0xEE, 0x77, 0x0E, 0xE7, 0x70, 0xEC, 0x7F, 0x0F, 0xC7, 0xE0,
  0xFC, 0x7E, 0x0F, 0x87, 0xC0, 0xF8, 0x7C, 0x0F, 0x07, 0x80, 0x1E, 0x0F,
  0x0F, 0x1E, 0x0F, 0x3C, 0x07, 0x38, 0x07, 0x78, 0x07, 0xF0, 0x03, 0xE0,
  0x03, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x0E, 0xE0, 0x1E, 0xE0, 0x3C, 0xF0,
  0x78, 0xF0, 0x78, 0x70, 0xF0, 0x78, 0x0E, 0x07, 0x87, 0x03, 0x83, 0x83,
  0xC1, 0xC1, 0xC0, 0xE1, 0xE0, 0x78, 0xE0, 0x3C, 0xF0, 0x1E, 0x70, 0x07,
  0x78, 0x03, 0xB8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x03, 0xC0,
  0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xC0, 0x00, 0x0F, 0xFC, 0x3F, 0xE1, 0xFF,
  0x80, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x07, 0x00, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xFF, 0x87, 0xFE, 0x3F, 0xF8, 0x00,
  0xF0, 0x1F, 0x03, 0xE0, 0x38, 0x07, 0x80, 0x78, 0x07, 0x00, 0x70, 0x07,
  0x00, 0xF0, 0x1E, 0x07, 0xC0, 0x70, 0x0F, 0x80, 0x3C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x3C, 0x03, 0xE0, 0x1E,
  0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x07, 0x80, 0x7C, 0x07, 0xC0, 0x1E, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x03, 0xC0, 0x1F, 0x00, 0xF0, 0x3F, 0x07,
  0xC0, 0x70, 0x07, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x3C,
  0x0F, 0xC0, 0xF8, 0x0E, 0x00, 0x78, 0x0F, 0xF8, 0xFF, 0xFF, 0x0F, 0xF8,
  0x0C, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_SemiBoldItalic30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 9, 21, 8, 0, -21 },
  { 25, 10, 7, 12, 3, -21 },
  { 34, 18, 21, 17, 0, -21 },
  { 82, 14, 25, 15, 1, -23 },
  { 126, 20, 22, 23, 2, -22 },
  { 181, 17, 22, 19, 1, -22 },
  { 228, 5, 7, 7, 3, -21 },
  { 233, 10, 26, 9, 1, -21 },
  { 266, 10, 27, 9, -2, -22 },
  { 300, 12, 13, 15, 3, -23 },
  { 320, 13, 15, 16, 2, -18 },
  { 345, 6, 8, 8, -1, -4 },
  { 351, 7, 4, 9, 1, -10 },
  { 355, 5, 4, 8, 0, -4 },
  { 358, 15, 22, 11, -1, -22 },
  { 400, 14, 22, 15, 1, -22 },
  { 439, 10, 21, 15, 3, -21 },
  { 466, 16, 22, 15, -1, -22 },
  { 510, 15, 22, 15, 0, -22 },
  { 552, 15, 21, 15, 0, -21 },
  { 592, 15, 21, 15, 0, -21 },
  { 632, 14, 22, 15, 1, -22 },
  { 671, 15, 21, 15, 1, -21 },
  { 711, 14, 22, 15, 1, -22 },
  { 750, 14, 22, 15, 1, -22 },
  { 789, 7, 17, 8, 0, -17 },
  { 804, 9, 21, 8, -2, -17 },
  { 828, 13, 15, 16, 2, -18 },
  { 853, 13, 9, 16, 2, -15 },
  { 868, 13, 15, 16, 2, -18 },
  { 893, 11, 22, 12, 2, -22 },
  { 924, 22, 24, 23, 1, -21 },
  { 990, 17, 21, 16, -2, -21 },
  { 1035, 16, 21, 17, 1, -21 },
  { 1077, 16, 22, 16, 2, -22 },
  { 1121, 17, 21, 18, 1, -21 },
  { 1166, 15, 21, 14, 1, -21 },
  { 1206, 15, 21, 14, 1, -21 },
  { 1246, 17, 22, 19, 2, -22 },
  { 1293, 18, 21, 19, 1, -21 },
  { 1341, 13, 21, 10, -1, -21 },
  { 1376, 14, 27, 8, -5, -21 },
  { 1424, 18, 21, 16, 1, -21 },
  { 1472, 11, 21, 14, 1, -21 },
  { 1501, 23, 21, 24, 1, -21 },
  { 1562, 19, 21, 20, 1, -21 },
  { 1612, 17, 22, 20, 2, -22 },
  { 1659, 16, 21, 16, 1, -21 },
  { 1701, 17, 27, 20, 2, -22 },
  { 1759, 15, 21, 16, 1, -21 },
  { 1799, 15, 22, 14, 0, -22 },
  { 1841, 14, 21, 14, 2, -21 },
  { 1878, 17, 21, 19, 2, -21 },
  { 1923, 15, 21, 16, 3, -21 },
  { 1963, 24, 21, 24, 3, -21 },
  { 2026, 20, 21, 16, -2, -21 },
  { 2079, 14, 21, 15, 3, -21 },
  { 2116, 17, 21, 14, -1, -21 },
  { 2161, 12, 26, 9, -1, -21 },
  { 2200, 6, 22, 12, 3, -22 },
  { 2217, 12, 26, 9, -2, -21 },
  { 2256, 15, 14, 15, 0, -22 },
  { 2283, 12, 2, 11, -3, 3 },
  { 2286, 6, 5, 9, 4, -23 },
  { 2290, 15, 17, 16, 1, -17 },
  { 2322, 15, 23, 16, 0, -23 },
  { 2366, 12, 17, 13, 1, -17 },
  { 2392, 16, 23, 16, 1, -23 },
  { 2438, 13, 17, 15, 1, -17 },
  { 2466, 16, 30, 10, -3, -23 },
  { 2526, 16, 24, 16, 0, -17 },
  { 2574, 15, 23, 16, 0, -23 },
  { 2618, 9, 23, 8, 0, -23 },
  { 2644, 13, 30, 8, -4, -23 },
  { 2693, 16, 23, 15, 0, -23 },
  { 2739, 9, 23, 8, 0, -23 },
  { 2765, 23, 17, 24, 0, -17 },
  { 2814, 15, 17, 16, 0, -17 },
  { 2846, 14, 17, 16, 1, -17 },
  { 2876, 16, 24, 16, -1, -17 },
  { 2924, 15, 24, 16, 1, -17 },
  { 2969, 12, 17, 11, 0, -17 },
  { 2995, 12, 17, 12, 0, -17 },
  { 3021, 10, 20, 10, 1, -20 },
  { 3046, 15, 16, 16, 1, -16 },
  { 3076, 13, 16, 14, 2, -16 },
  { 3102, 20, 16, 21, 2, -16 },
  { 3142, 16, 16, 14, -1, -16 },
  { 3174, 17, 23, 14, -2, -16 },
  { 3223, 14, 16, 12, -1, -16 },
  { 3251, 12, 26, 10, 0, -21 },
  { 3290, 3, 30, 15, 6, -23 },
  { 3302, 12, 26, 10, -2, -21 },
  { 3341, 13, 5, 16, 2, -13 },
};

const GFXfont NotoSans_SemiCondensed_SemiBoldItalic30pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_SemiBoldItalic30pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_SemiBoldItalic30pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC30PT7B_H_
