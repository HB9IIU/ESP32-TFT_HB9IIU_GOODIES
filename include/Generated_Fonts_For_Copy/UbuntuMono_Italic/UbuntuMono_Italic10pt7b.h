#ifndef _UBUNTUMONO_ITALIC10PT7B_H_
#define _UBUNTUMONO_ITALIC10PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Italic.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Italic10pt7bBitmaps[] PROGMEM = {
  0x00, 0x56, 0x20, 0xB4, 0x14, 0xA7, 0xCC, 0x79, 0x80, 0x27, 0x44, 0x31,
  0xE4, 0x65, 0xA7, 0x0E, 0x5A, 0x60, 0x75, 0x6D, 0xAD, 0xE0, 0x12, 0x44,
  0x88, 0x84, 0x40, 0x44, 0x92, 0x52, 0x80, 0x27, 0x25, 0x22, 0xF4, 0x40,
  0x70, 0xC0, 0x80, 0x08, 0x21, 0x04, 0x20, 0x84, 0x10, 0x80, 0x75, 0xF9,
  0xBE, 0x26, 0x22, 0x4E, 0x75, 0x16, 0x8E, 0x71, 0x61, 0x1E, 0x08, 0xCA,
  0xA7, 0x88, 0x72, 0x18, 0x21, 0x70, 0x32, 0x3D, 0x29, 0x70, 0x78, 0x88,
  0x44, 0x40, 0x75, 0x5B, 0x9E, 0x79, 0x97, 0x2C, 0x42, 0x20, 0x2C, 0x16,
  0x86, 0xF0, 0xF0, 0xC3, 0x68, 0xE5, 0xC1, 0x00, 0x32, 0x6D, 0xAD, 0x5B,
  0x80, 0x11, 0x4A, 0x97, 0xC4, 0x3A, 0x5C, 0x94, 0xB8, 0x3A, 0x21, 0x08,
  0x70, 0x3A, 0x52, 0x95, 0xF8, 0x7A, 0x1D, 0x08, 0x70, 0x7A, 0x11, 0xE8,
  0x40, 0x3A, 0x21, 0x29, 0x70, 0x25, 0x14, 0x9E, 0x4A, 0x20, 0x72, 0x24,
  0x4E, 0x30, 0x84, 0x2A, 0x70, 0x29, 0x46, 0x14, 0x52, 0x20, 0x4A, 0x49,
  0xC0, 0x24, 0xA7, 0x96, 0x8A, 0x20, 0x24, 0x95, 0x96, 0x5A, 0x40, 0x75,
  0x99, 0x9E, 0x75, 0x9E, 0x88, 0x75, 0x99, 0x9E, 0x42, 0x39, 0x52, 0xE5,
  0x48, 0x74, 0x43, 0x1E, 0xF4, 0x48, 0x88, 0x4C, 0xA5, 0x29, 0x70, 0x8C,
  0xA5, 0x4A, 0x20, 0x8C, 0x6D, 0xEB, 0x50, 0x24, 0xA1, 0x0C, 0x52, 0x20,
  0x8A, 0x94, 0xC4, 0x20, 0x3C, 0x21, 0x08, 0x43, 0xC0, 0x32, 0x44, 0x44,
  0x88, 0xC0, 0xAA, 0x95, 0x40, 0x38, 0x44, 0x21, 0x08, 0x84, 0xE0, 0x25,
  0x90, 0xF0, 0xC0, 0x79, 0x9A, 0xE0, 0x44, 0x79, 0x9B, 0xE0, 0x78, 0x88,
  0xE0, 0x08, 0x5D, 0x29, 0x4B, 0xC0, 0x79, 0xE8, 0xE0, 0x0C, 0x43, 0x88,
  0x20, 0x82, 0x08, 0xC0, 0x3A, 0x52, 0x97, 0x0B, 0x80, 0x21, 0x0C, 0x94,
  0xA6, 0x40, 0x23, 0xA4, 0x98, 0x08, 0x0E, 0x11, 0x08, 0x42, 0xE0, 0x44,
  0x5A, 0xCA, 0xA0, 0xD6, 0xAC, 0x7A, 0xDA, 0x98, 0x80, 0x79, 0x99, 0xA0,
  0x79, 0x99, 0xE0, 0x3A, 0x52, 0x97, 0x42, 0x00, 0x79, 0x99, 0xE2, 0x20,
  0x74, 0x88, 0x80, 0x74, 0x61, 0xE0, 0x2F, 0x44, 0x46, 0x99, 0x9A, 0xE0,
  0x99, 0xA6, 0x40, 0x8D, 0xBD, 0x6A, 0x00, 0x29, 0x88, 0x65, 0x00, 0x4A,
  0x4A, 0x62, 0x13, 0x00, 0x72, 0x48, 0xE0, 0x39, 0x08, 0x88, 0x21, 0x10,
  0x60, 0x55, 0xAA, 0x80, 0x30, 0x84, 0x21, 0x90, 0x84, 0xC0, 0xDB,
};

const GFXglyph UbuntuMono_Italic10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 2, 6, 5, 2, -6 },
  { 3, 3, 2, 5, 2, -6 },
  { 4, 6, 6, 5, 0, -6 },
  { 9, 4, 8, 5, 1, -7 },
  { 13, 6, 6, 5, 0, -6 },
  { 18, 4, 6, 5, 1, -6 },
  { 21, 1, 3, 5, 3, -7 },
  { 22, 4, 9, 5, 1, -7 },
  { 27, 3, 9, 5, 1, -7 },
  { 31, 4, 4, 5, 1, -6 },
  { 33, 4, 5, 5, 1, -5 },
  { 36, 2, 2, 5, 1, -1 },
  { 37, 2, 1, 5, 2, -3 },
  { 38, 1, 1, 5, 2, -1 },
  { 39, 6, 9, 5, 0, -7 },
  { 46, 4, 6, 5, 1, -6 },
  { 49, 4, 6, 5, 1, -6 },
  { 52, 4, 6, 5, 1, -6 },
  { 55, 4, 6, 5, 1, -6 },
  { 58, 5, 6, 5, 0, -6 },
  { 62, 5, 6, 5, 1, -6 },
  { 66, 5, 6, 5, 1, -6 },
  { 70, 5, 6, 5, 1, -6 },
  { 74, 4, 6, 5, 1, -6 },
  { 77, 4, 6, 5, 1, -6 },
  { 80, 2, 4, 5, 2, -4 },
  { 81, 3, 5, 5, 1, -4 },
  { 83, 4, 4, 5, 1, -5 },
  { 85, 4, 3, 5, 1, -4 },
  { 87, 4, 4, 5, 1, -5 },
  { 89, 3, 6, 5, 2, -6 },
  { 92, 5, 7, 5, 1, -6 },
  { 97, 5, 6, 5, 0, -6 },
  { 101, 5, 6, 5, 0, -6 },
  { 105, 5, 6, 5, 1, -6 },
  { 109, 5, 6, 5, 0, -6 },
  { 113, 5, 6, 5, 1, -6 },
  { 117, 5, 6, 5, 1, -6 },
  { 121, 5, 6, 5, 1, -6 },
  { 125, 6, 6, 5, 0, -6 },
  { 130, 4, 6, 5, 1, -6 },
  { 133, 5, 6, 5, 1, -6 },
  { 137, 6, 6, 5, 0, -6 },
  { 142, 3, 6, 5, 1, -6 },
  { 145, 6, 6, 5, 0, -6 },
  { 150, 6, 6, 5, 0, -6 },
  { 155, 4, 6, 5, 1, -6 },
  { 158, 4, 6, 5, 1, -6 },
  { 161, 4, 8, 5, 1, -6 },
  { 165, 5, 6, 5, 0, -6 },
  { 169, 4, 6, 5, 1, -6 },
  { 172, 4, 6, 5, 2, -6 },
  { 175, 5, 6, 5, 1, -6 },
  { 179, 5, 6, 5, 1, -6 },
  { 183, 5, 6, 5, 1, -6 },
  { 187, 6, 6, 5, 0, -6 },
  { 192, 5, 6, 5, 1, -6 },
  { 196, 6, 6, 5, 0, -6 },
  { 201, 4, 9, 5, 1, -7 },
  { 206, 2, 9, 5, 2, -7 },
  { 209, 5, 9, 5, 0, -7 },
  { 215, 4, 3, 5, 1, -6 },
  { 217, 4, 1, 5, 0, 1 },
  { 218, 1, 2, 5, 3, -7 },
  { 219, 4, 5, 5, 1, -5 },
  { 222, 4, 7, 5, 1, -7 },
  { 226, 4, 5, 5, 1, -5 },
  { 229, 5, 7, 5, 1, -7 },
  { 234, 4, 5, 5, 1, -5 },
  { 237, 6, 9, 5, 0, -7 },
  { 244, 5, 7, 5, 0, -5 },
  { 249, 5, 7, 5, 0, -7 },
  { 254, 3, 7, 5, 1, -7 },
  { 257, 5, 9, 5, 0, -7 },
  { 263, 4, 7, 5, 1, -7 },
  { 267, 2, 7, 5, 2, -7 },
  { 269, 5, 5, 5, 0, -5 },
  { 273, 4, 5, 5, 1, -5 },
  { 276, 4, 5, 5, 1, -5 },
  { 279, 5, 7, 5, 0, -5 },
  { 284, 4, 7, 5, 1, -5 },
  { 288, 4, 5, 5, 1, -5 },
  { 291, 4, 5, 5, 1, -5 },
  { 294, 4, 6, 5, 1, -6 },
  { 297, 4, 5, 5, 1, -5 },
  { 300, 4, 5, 5, 1, -5 },
  { 303, 5, 5, 5, 1, -5 },
  { 307, 5, 5, 5, 0, -5 },
  { 311, 5, 7, 5, 0, -5 },
  { 316, 4, 5, 5, 1, -5 },
  { 319, 5, 9, 5, 1, -7 },
  { 325, 2, 9, 5, 2, -7 },
  { 328, 5, 9, 5, 0, -7 },
  { 334, 4, 2, 5, 1, -5 },
};

const GFXfont UbuntuMono_Italic10pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Italic10pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Italic10pt7bGlyphs,
  0x20, 0x7E, 10
};

#endif // _UBUNTUMONO_ITALIC10PT7B_H_
