#ifndef _UBUNTUMONO_ITALIC48PT7B_H_
#define _UBUNTUMONO_ITALIC48PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Italic.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Italic48pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x07, 0xC0, 0xFE, 0x0F, 0xE0, 0xFC, 0x07, 0x80, 0x38, 0x7B,
  0xC3, 0xDE, 0x1E, 0xF0, 0xE7, 0x07, 0x78, 0x7B, 0xC3, 0xDC, 0x1C, 0xE0,
  0xE7, 0x07, 0x30, 0x31, 0x81, 0x80, 0x00, 0x07, 0x07, 0x80, 0x07, 0x83,
  0xC0, 0x03, 0x81, 0xC0, 0x03, 0xC1, 0xE0, 0x01, 0xC0, 0xE0, 0x01, 0xE0,
  0xF0, 0x00, 0xF0, 0x78, 0x00, 0x70, 0x78, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xC0, 0x1C, 0x0E, 0x00, 0x1E, 0x0F, 0x00, 0x0F,
  0x07, 0x00, 0x0F, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x03, 0x81, 0xC0, 0x03,
  0xC1, 0xE0, 0x01, 0xC0, 0xE0, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xE0, 0x78, 0x3C, 0x00, 0x38, 0x1C, 0x00, 0x3C, 0x1E, 0x00,
  0x1C, 0x0E, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x07, 0x00, 0x07, 0x07, 0x80,
  0x07, 0x83, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFF,
  0x00, 0x7F, 0xFE, 0x01, 0xF0, 0x1C, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x81, 0x00, 0x1F,
  0x07, 0x80, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x07, 0xFC, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x78, 0x07, 0xF0,
  0x07, 0x80, 0x7F, 0x80, 0x78, 0x07, 0x9E, 0x03, 0x80, 0x38, 0x70, 0x38,
  0x03, 0xC3, 0x83, 0x80, 0x1C, 0x1C, 0x3C, 0x00, 0xE1, 0xC3, 0xC0, 0x07,
  0x0E, 0x3C, 0x00, 0x38, 0x71, 0xC0, 0x01, 0xC7, 0x9C, 0x00, 0x0E, 0x39,
  0xC0, 0x00, 0x7F, 0xDC, 0x00, 0x01, 0xFD, 0xE0, 0x00, 0x07, 0x9E, 0x00,
  0x00, 0x01, 0xE7, 0xC0, 0x00, 0x0E, 0x7F, 0x00, 0x00, 0xE7, 0xF8, 0x00,
  0x0E, 0x79, 0xC0, 0x00, 0xF3, 0x8E, 0x00, 0x0F, 0x38, 0x70, 0x00, 0xF1,
  0xC3, 0x80, 0x07, 0x0E, 0x1C, 0x00, 0x70, 0x70, 0xE0, 0x07, 0x03, 0x87,
  0x00, 0x78, 0x1C, 0x70, 0x07, 0x80, 0xE7, 0x80, 0x78, 0x07, 0xF8, 0x07,
  0x80, 0x3F, 0x80, 0x38, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xFE,
  0x00, 0x3F, 0xF8, 0x03, 0xC3, 0xC0, 0x3C, 0x0E, 0x01, 0xE0, 0x70, 0x1E,
  0x07, 0x80, 0xF0, 0x3C, 0x07, 0x83, 0xC0, 0x3C, 0x1E, 0x01, 0xE1, 0xE0,
  0x07, 0xBE, 0x00, 0x3F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x81, 0xE1, 0xFE,
  0x0E, 0x1F, 0xF0, 0xF1, 0xE3, 0xC7, 0x9E, 0x0F, 0x38, 0xF0, 0x7B, 0xCF,
  0x01, 0xFC, 0x78, 0x0F, 0xE3, 0xC0, 0x3E, 0x1E, 0x00, 0xF0, 0xF0, 0x0F,
  0x87, 0x80, 0xFC, 0x3E, 0x1F, 0xF0, 0xFF, 0xF7, 0x83, 0xFF, 0x3E, 0x0F,
  0xC0, 0xF0, 0x3E, 0x78, 0xF1, 0xE3, 0xCF, 0x1E, 0x3C, 0x70, 0xE1, 0xC3,
  0x0E, 0x00, 0x00, 0x00, 0x80, 0x00, 0xE0, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00,
  0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x10, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x10, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x41, 0xE0, 0xBC,
  0x71, 0xEF, 0xCD, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0x80, 0x78, 0x00, 0x3F,
  0x00, 0x1F, 0xE0, 0x0F, 0x7C, 0x07, 0xCF, 0x01, 0xE3, 0xE0, 0xF8, 0x7C,
  0x1C, 0x1C, 0x01, 0x02, 0x00, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x07, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x81,
  0xF8, 0x7F, 0x0F, 0xE0, 0xFC, 0x0F, 0x80, 0xF0, 0x3C, 0x0F, 0x87, 0xE3,
  0xF8, 0x7C, 0x0E, 0x00, 0x7F, 0xF7, 0xFF, 0x7F, 0xE7, 0xFE, 0x3C, 0xFF,
  0xFF, 0xF7, 0xE7, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xFF,
  0x00, 0x3F, 0xFC, 0x07, 0xE1, 0xE0, 0x3C, 0x0F, 0x83, 0xC0, 0x3C, 0x3C,
  0x01, 0xE1, 0xE0, 0x0F, 0x1E, 0x00, 0x78, 0xF0, 0x03, 0xCF, 0x00, 0x1E,
  0x78, 0x00, 0xF7, 0xC7, 0x87, 0xBC, 0x7C, 0x3D, 0xE3, 0xF3, 0xCF, 0x1F,
  0x9E, 0xF0, 0xF8, 0xF7, 0x83, 0x87, 0xBC, 0x00, 0x79, 0xE0, 0x03, 0xCF,
  0x00, 0x1E, 0x78, 0x01, 0xE3, 0xC0, 0x1F, 0x1E, 0x00, 0xF0, 0xF0, 0x0F,
  0x03, 0xC0, 0xF8, 0x1F, 0x0F, 0x80, 0xFF, 0xF8, 0x03, 0xFF, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x01, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFE, 0x00,
  0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0x3C, 0x06, 0x0F, 0x00, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x01, 0xFF, 0xFE, 0x7F, 0xFF, 0x9F, 0xFF, 0xE0, 0x00, 0x1F,
  0xC0, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0xF8, 0x3E, 0x03, 0x80, 0x7C,
  0x04, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x78, 0x3E, 0x01, 0x00, 0x78, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x01, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xE1, 0x00, 0x1F, 0x07, 0x01, 0xFC, 0x3F,
  0xFF, 0xC0, 0xFF, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01,
  0xFF, 0x00, 0x07, 0xDE, 0x00, 0x1F, 0x3C, 0x00, 0x7C, 0x78, 0x00, 0xF1,
  0xE0, 0x03, 0xC3, 0xC0, 0x0F, 0x07, 0x80, 0x3C, 0x0F, 0x00, 0xF0, 0x3C,
  0x03, 0xC0, 0x78, 0x07, 0x80, 0xF0, 0x1E, 0x01, 0xE0, 0x78, 0x03, 0x80,
  0xE0, 0x0F, 0x03, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x80,
  0x0F, 0x81, 0xC0, 0x7E, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0xC0, 0x07, 0xFE, 0x00, 0xFE,
  0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x79, 0xFC, 0x07, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC1, 0xF8, 0x1F, 0x1E, 0x00, 0x78, 0xF0, 0x01, 0xE7, 0x80,
  0x0F, 0x3C, 0x00, 0x79, 0xE0, 0x03, 0xCF, 0x00, 0x1E, 0x78, 0x01, 0xE3,
  0xC0, 0x0F, 0x1E, 0x00, 0x78, 0xF0, 0x07, 0x87, 0xC0, 0x7C, 0x1F, 0x0F,
  0xC0, 0xFF, 0xFC, 0x03, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0x1F, 0xFF, 0xF9,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0x80, 0x1F, 0xFF,
  0x00, 0xF8, 0x3E, 0x07, 0xC0, 0x7C, 0x1E, 0x00, 0xF0, 0xF0, 0x03, 0xC3,
  0xC0, 0x0F, 0x0F, 0x00, 0x3C, 0x3C, 0x01, 0xE0, 0xF0, 0x07, 0x83, 0xE0,
  0x3C, 0x07, 0xC3, 0xE0, 0x0F, 0xDF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xC0,
  0x1F, 0x1F, 0x80, 0xF8, 0x1F, 0x07, 0xC0, 0x3E, 0x1E, 0x00, 0x78, 0xF0,
  0x01, 0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x1E, 0x3C, 0x00, 0x78, 0xF0, 0x03,
  0xC3, 0xC0, 0x1F, 0x07, 0xC1, 0xF8, 0x1F, 0xFF, 0xC0, 0x3F, 0xFC, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0x01,
  0xF8, 0x3E, 0x0F, 0x80, 0x78, 0x3C, 0x01, 0xE1, 0xF0, 0x03, 0xC7, 0x80,
  0x0F, 0x1E, 0x00, 0x3C, 0x78, 0x00, 0xF1, 0xC0, 0x03, 0xC7, 0x00, 0x1F,
  0x1E, 0x00, 0x78, 0x78, 0x01, 0xE1, 0xF0, 0x1F, 0x83, 0xFF, 0xFE, 0x07,
  0xFF, 0xF0, 0x07, 0xE7, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x03, 0xF0, 0x00, 0x7F, 0x80, 0x3F, 0xF8, 0x00, 0xFF, 0x80, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0xFC, 0x3F, 0x87, 0xF0, 0xFC, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x7E, 0x1F, 0xC3, 0xF8, 0x3F, 0x03, 0xC0, 0x00, 0x78, 0x03, 0xF0, 0x1F,
  0xC0, 0x7F, 0x01, 0xF8, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x0F,
  0xC0, 0x7F, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x78, 0x03,
  0xE0, 0x3F, 0x03, 0xF8, 0x0F, 0x80, 0x38, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x03, 0xC0, 0x00, 0xFE, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x0F, 0xF8, 0x00, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0x40, 0x1F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0x0C, 0x00, 0x00, 0x78, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xC0, 0x01, 0xFC,
  0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x1F, 0xF0,
  0x00, 0xFE, 0x00, 0x07, 0x80, 0x00, 0x20, 0x00, 0x00, 0x03, 0xF8, 0x0F,
  0xFF, 0x07, 0xFF, 0xC3, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xF8,
  0x3E, 0x01, 0xF0, 0x0E, 0x03, 0xE0, 0x0F, 0x07, 0x80, 0x0F, 0x07, 0x80,
  0x0F, 0x0F, 0x00, 0x0F, 0x1E, 0x01, 0xFF, 0x1E, 0x07, 0xFE, 0x1C, 0x1F,
  0xFE, 0x3C, 0x3E, 0x1E, 0x3C, 0x7C, 0x1E, 0x78, 0x78, 0x1C, 0x78, 0xF0,
  0x3C, 0x78, 0xF0, 0x3C, 0x78, 0xF0, 0x3C, 0x70, 0xE0, 0x38, 0xF0, 0xE0,
  0x78, 0xF0, 0xE0, 0x78, 0xF0, 0xE0, 0x78, 0xF0, 0xE0, 0x70, 0xF0, 0xF0,
  0x70, 0xF0, 0xF8, 0xF0, 0xF0, 0x7F, 0xF0, 0x70, 0x3F, 0xF0, 0x78, 0x0F,
  0xC0, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xBC, 0x00, 0x07, 0xBC, 0x00, 0x0F,
  0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x1E, 0x1C, 0x00, 0x1C, 0x1E, 0x00, 0x3C,
  0x1E, 0x00, 0x78, 0x1E, 0x00, 0x78, 0x1E, 0x00, 0xF0, 0x1E, 0x00, 0xF0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x1E, 0x03, 0xC0, 0x1E, 0x03, 0xFF,
  0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0x00, 0x1E, 0x0E, 0x00,
  0x1E, 0x1E, 0x00, 0x1E, 0x1C, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x00,
  0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x01, 0xFF, 0xC0, 0x03, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF0, 0x1E, 0x03, 0xF0, 0x3C, 0x03, 0xE0, 0x78, 0x03,
  0xC0, 0xF0, 0x07, 0x83, 0xC0, 0x0F, 0x07, 0x80, 0x1E, 0x0F, 0x00, 0x38,
  0x1E, 0x00, 0xF0, 0x78, 0x03, 0xC0, 0xF0, 0x1F, 0x01, 0xFF, 0xFC, 0x03,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x1E, 0x01, 0xF0, 0x3C, 0x00, 0xF0, 0x78,
  0x01, 0xE0, 0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x87, 0x80, 0x0F, 0x0F, 0x00,
  0x1E, 0x1C, 0x00, 0x7C, 0x78, 0x00, 0xF0, 0xF0, 0x03, 0xE1, 0xE0, 0x3F,
  0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xFE, 0x01, 0xF8, 0x1E, 0x03, 0xE0,
  0x04, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x7C, 0x00, 0x80, 0x3F, 0x03, 0x80, 0x1F, 0xFF, 0x80, 0x0F, 0xFF,
  0x80, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF,
  0xC0, 0x1E, 0x0F, 0xC0, 0x3C, 0x07, 0xC0, 0xF0, 0x07, 0x81, 0xE0, 0x0F,
  0x83, 0xC0, 0x0F, 0x07, 0x80, 0x1E, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x78,
  0x78, 0x00, 0xF0, 0xF0, 0x01, 0xE1, 0xC0, 0x03, 0xC7, 0x80, 0x07, 0x8F,
  0x00, 0x0F, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0xF0, 0x00, 0xF1, 0xE0,
  0x03, 0xE3, 0xC0, 0x07, 0x87, 0x80, 0x1F, 0x1E, 0x00, 0x3C, 0x3C, 0x00,
  0xF0, 0x78, 0x03, 0xE0, 0xF0, 0x1F, 0x83, 0xC0, 0xFE, 0x07, 0xFF, 0xF0,
  0x0F, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xE0, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0xF8, 0x03, 0xFF, 0xF8, 0x0F, 0xC1, 0xE0, 0x3E, 0x00, 0x80, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x78, 0xF0, 0x00, 0xF1, 0xE0, 0x03, 0xC3, 0xC0,
  0x07, 0x87, 0x80, 0x0F, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x78, 0x3C, 0x00,
  0xF0, 0x7C, 0x01, 0xE0, 0x78, 0x03, 0xC0, 0xF8, 0x07, 0x00, 0xF8, 0x1E,
  0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xE0,
  0x03, 0xC0, 0xF0, 0x01, 0xE0, 0x3C, 0x00, 0x78, 0x0F, 0x00, 0x1E, 0x03,
  0xC0, 0x07, 0x80, 0xF0, 0x03, 0xC0, 0x78, 0x00, 0xF0, 0x1E, 0x00, 0x3C,
  0x07, 0x80, 0x0F, 0x01, 0xE0, 0x03, 0x80, 0xF0, 0x01, 0xE0, 0x3C, 0x00,
  0x78, 0x0F, 0x00, 0x1E, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xF0, 0x1E, 0x00, 0x3C, 0x07, 0x80, 0x0F, 0x03, 0xC0, 0x07, 0x80,
  0xF0, 0x01, 0xE0, 0x3C, 0x00, 0x78, 0x0F, 0x00, 0x1E, 0x07, 0x80, 0x0F,
  0x01, 0xE0, 0x03, 0xC0, 0x78, 0x00, 0xF0, 0x1E, 0x00, 0x3C, 0x07, 0x00,
  0x1E, 0x03, 0xC0, 0x07, 0x80, 0xF0, 0x01, 0xE0, 0x3C, 0x00, 0x78, 0x00,
  0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x20, 0x0F, 0x80, 0x78, 0x1F, 0x00,
  0xFF, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xE0, 0x07,
  0xC0, 0x78, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x03, 0xC0,
  0x7C, 0x00, 0xF0, 0x3E, 0x00, 0x3C, 0x1F, 0x00, 0x1E, 0x0F, 0x80, 0x07,
  0x87, 0xC0, 0x01, 0xE3, 0xE0, 0x00, 0x79, 0xF0, 0x00, 0x1C, 0xF8, 0x00,
  0x0F, 0x7C, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x1E, 0xF8, 0x00, 0x07, 0x9F, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0x78,
  0x78, 0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x03, 0xC0, 0x03, 0xC0, 0x78, 0x00,
  0xF0, 0x1F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF8, 0x07, 0x80, 0x1E,
  0x01, 0xE0, 0x07, 0x80, 0x70, 0x00, 0xF0, 0x3C, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x3E, 0x00, 0xF8, 0x0F, 0x80, 0x7E, 0x07, 0xE0, 0x1F,
  0x81, 0xB8, 0x06, 0xE0, 0xEE, 0x03, 0xB8, 0x33, 0x80, 0xE7, 0x1D, 0xE0,
  0x39, 0xCE, 0x70, 0x1C, 0x73, 0x9C, 0x07, 0x1D, 0xC7, 0x01, 0xC7, 0x71,
  0xC0, 0xF1, 0xF8, 0xF0, 0x38, 0x7E, 0x3C, 0x0E, 0x1F, 0x0E, 0x07, 0x87,
  0xC3, 0x81, 0xE1, 0xE1, 0xE0, 0x70, 0x00, 0x78, 0x3C, 0x00, 0x1E, 0x0F,
  0x00, 0x07, 0x03, 0xC0, 0x01, 0xC0, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x3C,
  0x1E, 0x00, 0x0F, 0x07, 0x80, 0x03, 0x81, 0xC0, 0x01, 0xE0, 0xF0, 0x00,
  0x78, 0x3C, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x78, 0x00, 0xE0,
  0x3F, 0x00, 0x38, 0x0F, 0xC0, 0x1E, 0x03, 0xF0, 0x07, 0x80, 0xFE, 0x01,
  0xC0, 0x3F, 0x80, 0x70, 0x1E, 0xE0, 0x3C, 0x07, 0xB8, 0x0F, 0x01, 0xCF,
  0x03, 0xC0, 0x71, 0xC0, 0xE0, 0x3C, 0x70, 0x78, 0x0F, 0x1C, 0x1E, 0x03,
  0x87, 0x87, 0x80, 0xE0, 0xE1, 0xC0, 0x78, 0x38, 0x70, 0x1E, 0x0E, 0x3C,
  0x07, 0x03, 0xCF, 0x01, 0xC0, 0x73, 0x80, 0xF0, 0x1C, 0xE0, 0x3C, 0x07,
  0x78, 0x0F, 0x01, 0xDE, 0x03, 0x80, 0x77, 0x01, 0xE0, 0x0F, 0xC0, 0x78,
  0x03, 0xF0, 0x1E, 0x00, 0xFC, 0x07, 0x00, 0x3E, 0x01, 0xC0, 0x0F, 0x80,
  0xF0, 0x03, 0xE0, 0x3C, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x80, 0x01, 0xFF,
  0x80, 0x1F, 0xFF, 0x00, 0xF8, 0x3E, 0x07, 0xC0, 0x78, 0x1E, 0x01, 0xF0,
  0xF0, 0x03, 0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x3C, 0xF0, 0x00, 0xF3, 0xC0,
  0x03, 0xCE, 0x00, 0x0F, 0x78, 0x00, 0x3D, 0xE0, 0x00, 0xF7, 0x80, 0x07,
  0xBC, 0x00, 0x1E, 0xF0, 0x00, 0x7B, 0xC0, 0x01, 0xEF, 0x00, 0x0F, 0x3C,
  0x00, 0x3C, 0xF0, 0x00, 0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x1E, 0x3C, 0x00,
  0xF0, 0xF0, 0x07, 0x81, 0xE0, 0x3E, 0x07, 0xC1, 0xF0, 0x0F, 0xFF, 0x80,
  0x1F, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xE0,
  0x0F, 0xFF, 0xE0, 0x1E, 0x07, 0xE0, 0x3C, 0x03, 0xC0, 0xF0, 0x03, 0xC1,
  0xE0, 0x07, 0x83, 0xC0, 0x0F, 0x07, 0x80, 0x1E, 0x1E, 0x00, 0x3C, 0x3C,
  0x00, 0x78, 0x78, 0x01, 0xE0, 0xF0, 0x03, 0xC1, 0xE0, 0x0F, 0x07, 0x80,
  0x3E, 0x0F, 0x01, 0xF8, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0xF0,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x01, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xF8, 0x3E, 0x07, 0xC0, 0x78, 0x1E,
  0x01, 0xF0, 0xF0, 0x03, 0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x3C, 0xF0, 0x00,
  0xF3, 0xC0, 0x03, 0xCE, 0x00, 0x0F, 0x78, 0x00, 0x3D, 0xE0, 0x00, 0xF7,
  0x80, 0x07, 0xBC, 0x00, 0x1E, 0xF0, 0x00, 0x7B, 0xC0, 0x01, 0xEF, 0x00,
  0x0F, 0x3C, 0x00, 0x3C, 0xF0, 0x00, 0xF3, 0xC0, 0x07, 0x8F, 0x00, 0x1E,
  0x3C, 0x00, 0xF0, 0xF0, 0x07, 0x81, 0xE0, 0x3E, 0x07, 0xC1, 0xF0, 0x0F,
  0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0,
  0x00, 0x7E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xF0,
  0x07, 0xFF, 0xF0, 0x1E, 0x03, 0xE0, 0x3C, 0x03, 0xE0, 0x78, 0x03, 0xC0,
  0xF0, 0x07, 0x81, 0xC0, 0x0F, 0x07, 0x80, 0x1E, 0x0F, 0x00, 0x3C, 0x1E,
  0x00, 0x78, 0x38, 0x01, 0xF0, 0xF0, 0x03, 0xC1, 0xE0, 0x0F, 0x03, 0xC0,
  0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x78, 0x3C,
  0x00, 0xF0, 0x78, 0x03, 0xC0, 0x78, 0x07, 0x80, 0xF0, 0x0F, 0x00, 0xF0,
  0x1E, 0x01, 0xE0, 0x78, 0x03, 0xC0, 0xF0, 0x03, 0xC1, 0xE0, 0x07, 0x83,
  0xC0, 0x0F, 0x07, 0x00, 0x1E, 0x1E, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x0F, 0x80, 0xE0, 0x3C, 0x00, 0x40,
  0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x80, 0x07, 0x81,
  0xE0, 0x3F, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x0F, 0x0F, 0x00,
  0x1E, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x0E, 0x00,
  0x3C, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x1E, 0x00,
  0x78, 0x3C, 0x00, 0x78, 0x3C, 0x00, 0x78, 0x3C, 0x00, 0x78, 0x3C, 0x00,
  0xF0, 0x78, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0x78, 0x00,
  0xE0, 0xF0, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0xF0, 0x03,
  0xC0, 0xF0, 0x03, 0xC0, 0xF0, 0x03, 0xC0, 0xF0, 0x07, 0x80, 0xF8, 0x0F,
  0x80, 0x7C, 0x1F, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xBC, 0x00, 0x1E,
  0xF0, 0x00, 0xF3, 0xC0, 0x03, 0xCF, 0x00, 0x1E, 0x3C, 0x00, 0x78, 0xF0,
  0x03, 0xC3, 0xC0, 0x0F, 0x0F, 0x00, 0x78, 0x3C, 0x01, 0xE0, 0xF0, 0x0F,
  0x03, 0xC0, 0x3C, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x00, 0xF0, 0x3C, 0x03,
  0xC0, 0xE0, 0x0F, 0x07, 0x80, 0x3C, 0x3C, 0x00, 0x70, 0xF0, 0x01, 0xC7,
  0x80, 0x07, 0x1E, 0x00, 0x1E, 0xF0, 0x00, 0x7B, 0xC0, 0x01, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0x80, 0x03, 0xC1, 0xC0, 0x00, 0xE0, 0xF0, 0x00, 0x78, 0x3C, 0x00,
  0x1E, 0x0F, 0x00, 0x07, 0x83, 0x80, 0x01, 0xC0, 0xE0, 0x00, 0xF0, 0x78,
  0x00, 0x3C, 0x1E, 0x00, 0x0E, 0x07, 0x80, 0x03, 0x81, 0xC0, 0x01, 0xE0,
  0x70, 0xF0, 0x70, 0x3C, 0x3C, 0x1C, 0x0F, 0x1F, 0x0F, 0x03, 0x87, 0xC3,
  0xC0, 0xE3, 0xB0, 0xE0, 0x38, 0xEE, 0x38, 0x0E, 0x73, 0x9E, 0x07, 0x9C,
  0xE7, 0x01, 0xCE, 0x39, 0xC0, 0x73, 0x8E, 0x70, 0x1D, 0xC3, 0xB8, 0x07,
  0x70, 0xEE, 0x01, 0xB8, 0x3B, 0x80, 0xFC, 0x0F, 0xC0, 0x3F, 0x03, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0xF8, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00,
  0x78, 0x00, 0x78, 0x07, 0xC0, 0x03, 0xC0, 0x7C, 0x00, 0x1F, 0x03, 0xC0,
  0x00, 0x78, 0x3C, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x1F, 0x1E, 0x00, 0x00,
  0x79, 0xE0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00,
  0xF9, 0xE0, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0xF8, 0x78, 0x00, 0x0F, 0x81,
  0xE0, 0x00, 0x78, 0x0F, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x7C, 0x01, 0xE0,
  0x07, 0xC0, 0x0F, 0x00, 0x7C, 0x00, 0x78, 0x03, 0xC0, 0x03, 0xC0, 0x3E,
  0x00, 0x0F, 0x00, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7B, 0xC0, 0x01, 0xE3,
  0x80, 0x07, 0xC7, 0x80, 0x0F, 0x0F, 0x00, 0x3C, 0x1E, 0x00, 0xF8, 0x3C,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0x78, 0x1E, 0x00, 0xF0, 0x3C, 0x00, 0xE0,
  0xF0, 0x01, 0xE3, 0xC0, 0x03, 0xCF, 0x00, 0x07, 0x9E, 0x00, 0x07, 0x78,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE,
  0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1F, 0xFE,
  0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x00, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E,
  0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x0F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3,
  0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C,
  0x78, 0xF1, 0xE3, 0xC7, 0x87, 0x8F, 0x1E, 0x3C, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x1F, 0xFC, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x07, 0xF0, 0x00, 0xF7, 0x80, 0x1F, 0x78, 0x03, 0xE7, 0x80, 0x3C, 0x3C,
  0x07, 0x83, 0xC0, 0xF0, 0x3C, 0x1F, 0x01, 0xC3, 0xE0, 0x1E, 0x3C, 0x01,
  0xE7, 0x80, 0x0E, 0x70, 0x00, 0xF3, 0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x20, 0x70, 0xF0, 0x78, 0x7C, 0x3E, 0x1E,
  0x0E, 0x04, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFC,
  0x1E, 0x07, 0xC0, 0x78, 0x3E, 0x01, 0xE1, 0xF0, 0x0F, 0x0F, 0x80, 0x3C,
  0x3C, 0x00, 0xF0, 0xF0, 0x03, 0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x78, 0x78,
  0x01, 0xE1, 0xE0, 0x07, 0x8F, 0x00, 0x1E, 0x3C, 0x00, 0xF0, 0xF0, 0x03,
  0xC1, 0xE0, 0x0F, 0x07, 0x80, 0x3C, 0x1E, 0x01, 0xF0, 0x7C, 0x1F, 0xC0,
  0xFF, 0xFF, 0x01, 0xFF, 0xBC, 0x01, 0xF8, 0x78, 0x00, 0x70, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE7,
  0xE0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0x03, 0xE0, 0xF8, 0x3C, 0x03, 0xE1,
  0xE0, 0x0F, 0x0F, 0x00, 0x78, 0x70, 0x03, 0xC7, 0x80, 0x1E, 0x3C, 0x00,
  0xF1, 0xE0, 0x07, 0x8E, 0x00, 0x3C, 0xF0, 0x01, 0xE7, 0x80, 0x1E, 0x3C,
  0x00, 0xF1, 0xE0, 0x0F, 0x8E, 0x00, 0x78, 0xF0, 0x07, 0xC7, 0x80, 0x7C,
  0x3C, 0x07, 0xC1, 0xE0, 0xFC, 0x1F, 0xFF, 0xC0, 0xFF, 0xF8, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x81, 0xFC,
  0x04, 0x0F, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x10, 0x3F, 0x03, 0xC0,
  0x7F, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x07,
  0xE0, 0x78, 0x0F, 0x80, 0xF0, 0x1F, 0x00, 0xF0, 0x3E, 0x00, 0xF0, 0x3C,
  0x00, 0xF0, 0x7C, 0x01, 0xE0, 0x78, 0x01, 0xE0, 0x78, 0x01, 0xE0, 0xF0,
  0x01, 0xE0, 0xF0, 0x01, 0xC0, 0xF0, 0x03, 0xC0, 0xF0, 0x03, 0xC0, 0xF0,
  0x03, 0xC0, 0xF0, 0x03, 0x80, 0xF0, 0x03, 0x80, 0xF0, 0x07, 0x80, 0xF8,
  0x0F, 0x80, 0x7C, 0x1F, 0x80, 0x7F, 0xFF, 0x80, 0x3F, 0xF3, 0xC0, 0x0F,
  0xC3, 0xC0, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0xC1,
  0xF0, 0xF8, 0x07, 0x8F, 0x80, 0x3C, 0x78, 0x01, 0xE7, 0xC0, 0x0F, 0x3C,
  0x00, 0x7B, 0xE0, 0x07, 0x9E, 0x00, 0xFC, 0xF0, 0x3F, 0xC7, 0xFF, 0xFC,
  0x7F, 0xFF, 0x83, 0xFF, 0xC0, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x83, 0xF0, 0x3C, 0x0F, 0xFF, 0xE0,
  0x3F, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x21, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0xFE, 0x0F, 0x01, 0xF8,
  0x0F, 0x03, 0xE0, 0x1E, 0x03, 0xC0, 0x1E, 0x07, 0x80, 0x1E, 0x07, 0x80,
  0x1E, 0x0F, 0x00, 0x3C, 0x0F, 0x00, 0x3C, 0x0E, 0x00, 0x3C, 0x1E, 0x00,
  0x3C, 0x1E, 0x00, 0x38, 0x1E, 0x00, 0x78, 0x1E, 0x00, 0x78, 0x1E, 0x00,
  0x78, 0x1F, 0x00, 0xF0, 0x0F, 0x83, 0xF0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF,
  0xF0, 0x01, 0xFC, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0xC0, 0x40, 0x07, 0x80, 0x70, 0x1F, 0x80, 0xFF, 0xFF,
  0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xEF, 0xE0,
  0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0x03, 0xC0, 0xF8, 0x1C, 0x03, 0xE1, 0xE0,
  0x0F, 0x0F, 0x00, 0x78, 0x78, 0x03, 0xC3, 0x80, 0x1E, 0x3C, 0x00, 0xF1,
  0xE0, 0x0F, 0x0F, 0x00, 0x78, 0x78, 0x03, 0xC7, 0x80, 0x1E, 0x3C, 0x01,
  0xE1, 0xE0, 0x0F, 0x0F, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80, 0x3C, 0x3C,
  0x01, 0xE1, 0xE0, 0x0F, 0x0E, 0x00, 0x78, 0xF0, 0x03, 0xC0, 0x00, 0x70,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x01, 0xE0, 0x0F, 0x80, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xE0, 0x07,
  0xFC, 0x0F, 0xF0, 0x1F, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x01, 0xFF,
  0xF0, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x01, 0x00, 0x78, 0x03, 0x81, 0xF0,
  0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x01, 0xF0, 0x78, 0x07, 0xC0,
  0xF0, 0x3F, 0x03, 0xC0, 0xF8, 0x07, 0x83, 0xE0, 0x0F, 0x0F, 0x80, 0x1E,
  0x7E, 0x00, 0x39, 0xF8, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x1E, 0x7C, 0x00, 0x3C, 0x7C, 0x00, 0x78, 0x7C,
  0x00, 0xF0, 0x78, 0x03, 0xC0, 0xF8, 0x07, 0x80, 0xF8, 0x0F, 0x00, 0xF0,
  0x1E, 0x01, 0xF0, 0x78, 0x01, 0xE0, 0xF0, 0x03, 0xE0, 0xFF, 0xEF, 0xFC,
  0xFF, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x07, 0x80,
  0x78, 0x07, 0x80, 0x70, 0x07, 0x80, 0x78, 0x17, 0xFF, 0x3F, 0xF1, 0xFE,
  0x00, 0xFC, 0x7C, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x07, 0x8F, 0x8F,
  0x07, 0x0F, 0x0F, 0x07, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0E,
  0x0E, 0x0E, 0x0E, 0x0E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E,
  0x1E, 0x1C, 0x1C, 0x1C, 0x1C, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C,
  0x3C, 0x00, 0x38, 0x38, 0x00, 0x38, 0x38, 0x00, 0x78, 0x78, 0x00, 0x78,
  0x78, 0x00, 0x78, 0x70, 0x00, 0x70, 0x70, 0x00, 0xF0, 0x00, 0x7F, 0x80,
  0x3F, 0xFF, 0x01, 0xFF, 0xFC, 0x0E, 0x03, 0xE0, 0xF0, 0x0F, 0x07, 0x80,
  0x3C, 0x3C, 0x01, 0xE1, 0xE0, 0x0F, 0x1E, 0x00, 0x78, 0xF0, 0x07, 0x87,
  0x80, 0x3C, 0x3C, 0x01, 0xE1, 0xC0, 0x0F, 0x1E, 0x00, 0xF0, 0xF0, 0x07,
  0x87, 0x80, 0x3C, 0x38, 0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0xF0, 0xF0,
  0x07, 0x87, 0x80, 0x3C, 0x78, 0x01, 0xE3, 0xC0, 0x1E, 0x00, 0x00, 0x7F,
  0x00, 0x1F, 0xFC, 0x07, 0xFF, 0xE0, 0xFC, 0x3E, 0x1F, 0x01, 0xF1, 0xE0,
  0x0F, 0x3C, 0x00, 0xF3, 0xC0, 0x0F, 0x78, 0x00, 0xF7, 0x80, 0x0F, 0x78,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xEF,
  0x00, 0x1E, 0xF0, 0x03, 0xCF, 0x00, 0x3C, 0xF0, 0x07, 0x8F, 0x80, 0xF8,
  0x7C, 0x3F, 0x07, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1E, 0x03, 0xE0, 0x3C, 0x03,
  0xE0, 0x78, 0x03, 0xC0, 0xF0, 0x07, 0x83, 0xC0, 0x0F, 0x07, 0x80, 0x1E,
  0x0F, 0x00, 0x3C, 0x1E, 0x00, 0x78, 0x7C, 0x00, 0xF0, 0xF0, 0x01, 0xE1,
  0xE0, 0x07, 0x83, 0xC0, 0x0F, 0x07, 0x80, 0x1E, 0x1E, 0x00, 0x78, 0x3C,
  0x01, 0xF0, 0x78, 0x07, 0xC0, 0xF0, 0x1F, 0x03, 0xE0, 0xFC, 0x07, 0xFF,
  0xF0, 0x0F, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x07, 0xFF, 0xC0, 0x7F, 0xFE,
  0x0F, 0xC0, 0xF0, 0xF8, 0x0F, 0x0F, 0x80, 0x78, 0xF8, 0x03, 0xC7, 0x80,
  0x1E, 0x7C, 0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0x79, 0xE0, 0x03, 0xCF,
  0x00, 0x1C, 0x78, 0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0x78, 0xF0, 0x03,
  0x87, 0x80, 0x3C, 0x3C, 0x01, 0xE1, 0xF0, 0x0F, 0x07, 0xC1, 0xF8, 0x3F,
  0xFF, 0x80, 0xFF, 0xFC, 0x01, 0xF9, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x1F, 0xFF, 0xC1, 0xFF, 0xFC, 0x0F, 0x80,
  0x20, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7C,
  0x06, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x84, 0x00, 0xF8, 0x70, 0x1F, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC,
  0x01, 0xFF, 0x00, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xE0, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0xC0, 0xFF, 0xF0, 0x1F, 0xFC, 0x01, 0xFC, 0x00, 0x1E,
  0x00, 0x78, 0xF0, 0x07, 0x87, 0x80, 0x3C, 0x3C, 0x01, 0xE3, 0xC0, 0x0F,
  0x1E, 0x00, 0xF0, 0xF0, 0x07, 0x87, 0x80, 0x3C, 0x78, 0x01, 0xE3, 0xC0,
  0x0F, 0x1E, 0x00, 0xF0, 0xF0, 0x07, 0x87, 0x00, 0x3C, 0x78, 0x01, 0xE3,
  0xC0, 0x1E, 0x1E, 0x00, 0xF0, 0xF0, 0x07, 0x87, 0x80, 0x3C, 0x3C, 0x03,
  0xE0, 0xF0, 0x7F, 0x07, 0xFF, 0xF8, 0x1F, 0xFB, 0xC0, 0x3F, 0x0F, 0x00,
  0xF0, 0x01, 0xEF, 0x00, 0x1E, 0x78, 0x01, 0xE7, 0x80, 0x3C, 0x78, 0x03,
  0xC7, 0x80, 0x78, 0x78, 0x07, 0x87, 0x80, 0xF0, 0x78, 0x0F, 0x07, 0x81,
  0xE0, 0x78, 0x1E, 0x07, 0x83, 0xC0, 0x78, 0x3C, 0x03, 0xC7, 0x80, 0x3C,
  0xF0, 0x03, 0xCF, 0x00, 0x3D, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01,
  0xF8, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x78, 0x00,
  0x0E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1C, 0x70, 0x38,
  0x3C, 0x70, 0x78, 0x38, 0x70, 0x78, 0x38, 0x70, 0xF8, 0x78, 0xF0, 0xF8,
  0x70, 0xF1, 0xF8, 0xF0, 0xF1, 0xF8, 0xF0, 0xF3, 0xB8, 0xE0, 0xF7, 0x1D,
  0xE0, 0xE7, 0x1D, 0xC0, 0xEE, 0x1F, 0xC0, 0xEE, 0x1F, 0x80, 0xFC, 0x1F,
  0x80, 0xF8, 0x1F, 0x80, 0xF8, 0x1F, 0x00, 0xF0, 0x1F, 0x00, 0xE0, 0x0E,
  0x00, 0x03, 0xC0, 0x0F, 0x81, 0xF0, 0x0F, 0x80, 0x78, 0x0F, 0x80, 0x3E,
  0x07, 0x80, 0x0F, 0x07, 0x80, 0x07, 0xC7, 0x80, 0x01, 0xE7, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xDE, 0x00,
  0x07, 0xC7, 0x80, 0x07, 0xC3, 0xC0, 0x07, 0xC0, 0xF0, 0x07, 0xC0, 0x78,
  0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x0F, 0x07, 0xC0, 0x07, 0x80, 0x00, 0xF0,
  0x03, 0xE0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x03, 0xC0, 0x07, 0x80,
  0x78, 0x00, 0xF0, 0x0F, 0x00, 0x0F, 0x03, 0xC0, 0x01, 0xE0, 0x78, 0x00,
  0x3C, 0x1E, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x1E,
  0x00, 0x01, 0xE7, 0x80, 0x00, 0x3C, 0xF0, 0x00, 0x07, 0xBC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x01, 0x07, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x00,
  0xF8, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x70, 0x03, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x80,
  0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x3F, 0xF8, 0x00,
  0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x30, 0xFE, 0x03, 0xCF,
  0xF8, 0x1C, 0xFF, 0xF1, 0xE7, 0x8F, 0xFE, 0x78, 0x3F, 0xF3, 0x80, 0xFF,
  0x0C, 0x01, 0xE0,
};

const GFXglyph UbuntuMono_Italic48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 24, 0, -1 },
  { 1, 12, 30, 24, 8, -30 },
  { 46, 13, 12, 24, 11, -33 },
  { 66, 25, 30, 24, 2, -30 },
  { 160, 23, 38, 24, 3, -33 },
  { 270, 29, 30, 24, 0, -30 },
  { 379, 21, 30, 24, 3, -30 },
  { 458, 7, 13, 24, 14, -33 },
  { 470, 18, 42, 24, 7, -34 },
  { 565, 18, 42, 24, 3, -34 },
  { 660, 18, 18, 24, 7, -30 },
  { 701, 20, 21, 24, 4, -23 },
  { 754, 11, 13, 24, 5, -6 },
  { 772, 12, 4, 24, 8, -14 },
  { 778, 7, 6, 24, 8, -6 },
  { 784, 28, 42, 24, -1, -34 },
  { 931, 21, 30, 24, 4, -30 },
  { 1010, 18, 30, 24, 4, -30 },
  { 1078, 22, 30, 24, 3, -30 },
  { 1161, 22, 30, 24, 3, -30 },
  { 1244, 23, 30, 24, 2, -30 },
  { 1331, 23, 30, 24, 3, -30 },
  { 1418, 21, 30, 24, 5, -30 },
  { 1497, 21, 30, 24, 7, -30 },
  { 1576, 22, 30, 24, 4, -30 },
  { 1659, 22, 30, 24, 4, -30 },
  { 1742, 11, 21, 24, 8, -21 },
  { 1771, 14, 28, 24, 5, -21 },
  { 1820, 21, 19, 24, 4, -22 },
  { 1870, 22, 12, 24, 3, -19 },
  { 1903, 21, 19, 24, 3, -22 },
  { 1953, 17, 30, 24, 8, -30 },
  { 2017, 24, 36, 24, 3, -30 },
  { 2125, 24, 30, 24, -1, -30 },
  { 2215, 23, 30, 24, 2, -30 },
  { 2302, 24, 30, 24, 4, -30 },
  { 2392, 23, 30, 24, 2, -30 },
  { 2479, 24, 30, 24, 3, -30 },
  { 2569, 24, 30, 24, 3, -30 },
  { 2659, 23, 30, 24, 4, -30 },
  { 2746, 26, 30, 24, 2, -30 },
  { 2844, 23, 30, 24, 3, -30 },
  { 2931, 24, 30, 24, 3, -30 },
  { 3021, 26, 30, 24, 2, -30 },
  { 3119, 17, 30, 24, 3, -30 },
  { 3183, 26, 30, 24, 1, -30 },
  { 3281, 26, 30, 24, 2, -30 },
  { 3379, 22, 30, 24, 4, -30 },
  { 3462, 23, 30, 24, 3, -30 },
  { 3549, 22, 38, 24, 4, -30 },
  { 3654, 23, 30, 24, 2, -30 },
  { 3741, 23, 30, 24, 3, -30 },
  { 3828, 21, 30, 24, 7, -30 },
  { 3907, 24, 30, 24, 4, -30 },
  { 3997, 22, 30, 24, 7, -30 },
  { 4080, 26, 30, 24, 3, -30 },
  { 4178, 29, 30, 24, 0, -30 },
  { 4287, 23, 30, 24, 7, -30 },
  { 4374, 25, 30, 24, 2, -30 },
  { 4468, 21, 42, 24, 5, -34 },
  { 4579, 7, 42, 24, 11, -34 },
  { 4616, 22, 42, 24, 1, -34 },
  { 4732, 20, 16, 24, 5, -30 },
  { 4772, 22, 3, 24, -1, 5 },
  { 4781, 8, 9, 24, 13, -33 },
  { 4790, 22, 24, 24, 3, -23 },
  { 4856, 21, 34, 24, 3, -33 },
  { 4946, 22, 24, 24, 3, -23 },
  { 5012, 24, 34, 24, 4, -33 },
  { 5114, 21, 24, 24, 3, -23 },
  { 5177, 29, 41, 24, 0, -33 },
  { 5326, 24, 31, 24, 1, -23 },
  { 5419, 21, 33, 24, 2, -33 },
  { 5506, 14, 31, 24, 6, -31 },
  { 5561, 23, 39, 24, 1, -31 },
  { 5674, 23, 33, 24, 3, -33 },
  { 5769, 12, 34, 24, 9, -33 },
  { 5820, 24, 23, 24, 1, -23 },
  { 5889, 21, 23, 24, 3, -23 },
  { 5950, 20, 24, 24, 4, -23 },
  { 6010, 23, 31, 24, 1, -23 },
  { 6100, 21, 31, 24, 4, -23 },
  { 6182, 21, 23, 24, 4, -23 },
  { 6243, 20, 24, 24, 4, -23 },
  { 6303, 18, 30, 24, 7, -29 },
  { 6371, 21, 23, 24, 4, -22 },
  { 6432, 20, 22, 24, 6, -22 },
  { 6487, 24, 22, 24, 4, -22 },
  { 6553, 25, 22, 24, 1, -22 },
  { 6622, 27, 30, 24, -1, -22 },
  { 6724, 21, 22, 24, 3, -22 },
  { 6782, 23, 42, 24, 4, -34 },
  { 6903, 14, 42, 24, 7, -34 },
  { 6977, 23, 42, 24, 0, -34 },
  { 7098, 21, 8, 24, 4, -17 },
};

const GFXfont UbuntuMono_Italic48pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Italic48pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Italic48pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _UBUNTUMONO_ITALIC48PT7B_H_
