#ifndef _UBUNTUMONO_ITALIC53PT7B_H_
#define _UBUNTUMONO_ITALIC53PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Italic.ttf
// Size: 53pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Italic53pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0x80, 0x78, 0x00, 0x3C, 0x1E, 0x78, 0x79, 0xE0,
  0xF3, 0xC1, 0xE7, 0x83, 0xCF, 0x0F, 0x1C, 0x1E, 0x78, 0x3C, 0xF0, 0x71,
  0xC0, 0xE3, 0x81, 0xC7, 0x03, 0x0C, 0x06, 0x00, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x3C, 0x1F, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xE0, 0x78,
  0x00, 0x1E, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0x81, 0xE0, 0x00, 0xF0, 0x3C,
  0x00, 0x0F, 0x03, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x03,
  0xC0, 0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x07, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x00,
  0xF0, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x0F,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x78, 0x1E, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0xF0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xFE, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xF8, 0x0E, 0x03, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x20, 0x01,
  0xF0, 0x78, 0x07, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x0F, 0x00, 0x7F, 0x00, 0x1E, 0x00, 0xFF, 0x80, 0x3C, 0x01, 0xFF,
  0x80, 0x78, 0x01, 0xE7, 0x80, 0xF0, 0x03, 0xC3, 0x80, 0xE0, 0x03, 0x83,
  0x81, 0xE0, 0x03, 0x83, 0x83, 0xC0, 0x07, 0x83, 0x87, 0x80, 0x07, 0x87,
  0x8F, 0x00, 0x07, 0x87, 0x1E, 0x00, 0x07, 0x8F, 0x3C, 0x00, 0x07, 0xFF,
  0x38, 0x00, 0x03, 0xFE, 0x78, 0x00, 0x03, 0xFC, 0xF0, 0x00, 0x00, 0xF1,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x8F, 0x80, 0x00, 0x07,
  0x1F, 0xC0, 0x00, 0x0F, 0x3F, 0xE0, 0x00, 0x1E, 0x7F, 0xE0, 0x00, 0x3C,
  0xF9, 0xE0, 0x00, 0x78, 0xF0, 0xE0, 0x00, 0xF0, 0xE0, 0xE0, 0x01, 0xE1,
  0xE0, 0xE0, 0x01, 0xC1, 0xC1, 0xE0, 0x03, 0xC1, 0xC1, 0xE0, 0x07, 0x81,
  0xC3, 0xC0, 0x0F, 0x01, 0xE3, 0xC0, 0x1E, 0x01, 0xFF, 0x80, 0x3C, 0x01,
  0xFF, 0x80, 0x38, 0x00, 0xFF, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x1F, 0x87,
  0xC0, 0x3E, 0x0F, 0x80, 0xF8, 0x0E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x78,
  0x07, 0x81, 0xE0, 0x0F, 0x07, 0xC0, 0x1F, 0x1F, 0x00, 0x1E, 0xFC, 0x00,
  0x3F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x0F, 0x07, 0xF8, 0x1E, 0x1F,
  0xF8, 0x78, 0x7C, 0xF8, 0xF1, 0xF0, 0xF1, 0xE3, 0xC1, 0xF7, 0x8F, 0x01,
  0xFF, 0x1E, 0x01, 0xFC, 0x7C, 0x03, 0xF8, 0xF8, 0x03, 0xE1, 0xF0, 0x07,
  0xC3, 0xE0, 0x1F, 0x87, 0xC0, 0x7F, 0x8F, 0xC1, 0xFF, 0x0F, 0xFF, 0xDE,
  0x1F, 0xFF, 0x3E, 0x1F, 0xF8, 0x7C, 0x0F, 0xC0, 0x78, 0x3E, 0x7C, 0xF1,
  0xE7, 0xCF, 0x1E, 0x3C, 0x79, 0xE3, 0xC7, 0x8E, 0x1C, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x0E, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0x80, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x01, 0xC0, 0x00, 0x3E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0x70, 0x00, 0x04, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0x80, 0x10, 0x38, 0x19, 0xE1, 0xC3, 0xCF, 0xCE, 0x7E, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0x00, 0x7F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xC0, 0x01, 0xEF,
  0x00, 0x1F, 0x7C, 0x01, 0xF1, 0xF0, 0x1F, 0x8F, 0xC0, 0xF8, 0x3E, 0x01,
  0xC1, 0xC0, 0x04, 0x04, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xE0, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x81, 0xF8, 0x7F, 0x8F, 0xF1, 0xFE, 0x1F, 0xC1, 0xF8, 0x1E, 0x07, 0xC1,
  0xF0, 0xFC, 0x7F, 0x0F, 0x81, 0xC0, 0x00, 0x7F, 0xFB, 0xFF, 0xDF, 0xFD,
  0xFF, 0xE0, 0x3C, 0x7F, 0xFF, 0xFF, 0xFF, 0x7E, 0x3C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFC, 0x00,
  0xFF, 0xFE, 0x01, 0xF8, 0x7E, 0x03, 0xF0, 0x1E, 0x07, 0xE0, 0x1F, 0x07,
  0xC0, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x1E,
  0x00, 0x1F, 0x3E, 0x1C, 0x1F, 0x3E, 0x3E, 0x1E, 0x3C, 0x7E, 0x1E, 0x3C,
  0x7E, 0x1E, 0x7C, 0x7E, 0x3E, 0x78, 0x7E, 0x3E, 0x78, 0x3C, 0x3C, 0x78,
  0x00, 0x3C, 0x78, 0x00, 0x7C, 0x78, 0x00, 0x78, 0xF8, 0x00, 0xF8, 0xF8,
  0x00, 0xF8, 0xF8, 0x01, 0xF0, 0x78, 0x03, 0xE0, 0x78, 0x03, 0xE0, 0x7C,
  0x07, 0xC0, 0x7E, 0x1F, 0x80, 0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x1F,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x7C, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x03, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xBC,
  0x07, 0xE7, 0x80, 0xF0, 0xF0, 0x18, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x00, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE,
  0x03, 0xF0, 0x7E, 0x01, 0x80, 0x3F, 0x01, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFE, 0x00, 0xF0, 0x3F, 0x00, 0xC0, 0x1F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x20, 0x01, 0xF8, 0x78, 0x07, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFE,
  0x00, 0x0F, 0xBE, 0x00, 0x1F, 0x3C, 0x00, 0x3E, 0x3C, 0x00, 0x3C, 0x3C,
  0x00, 0x78, 0x7C, 0x00, 0xF0, 0x78, 0x01, 0xE0, 0x78, 0x03, 0xE0, 0x78,
  0x07, 0xC0, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x1E, 0x00, 0xF0,
  0x3E, 0x01, 0xF0, 0x3C, 0x01, 0xE0, 0x78, 0x01, 0xE0, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x81, 0x00, 0x0F, 0xC0, 0x78, 0x0F, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xE0,
  0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x7F, 0x00,
  0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0x01, 0xF8,
  0x78, 0x00, 0xF8, 0x78, 0x00, 0x78, 0xF8, 0x00, 0x78, 0xF8, 0x00, 0x78,
  0xF8, 0x00, 0x78, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0xF8,
  0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0x7E, 0x0F, 0xE0,
  0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x3F, 0xFF, 0xE0, 0x1F, 0x83, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0x00,
  0x3C, 0x0F, 0x80, 0x1F, 0x07, 0x80, 0x0F, 0x03, 0xC0, 0x07, 0x81, 0xE0,
  0x07, 0xC0, 0xF0, 0x03, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x07, 0xE0, 0x0F,
  0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x03,
  0xE1, 0xFC, 0x03, 0xE0, 0x3F, 0x03, 0xE0, 0x0F, 0x83, 0xE0, 0x03, 0xC1,
  0xE0, 0x01, 0xE1, 0xF0, 0x00, 0xF0, 0xF8, 0x00, 0x78, 0x7C, 0x00, 0x7C,
  0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x07, 0xE0, 0x7F, 0x03, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x03,
  0xF0, 0x3E, 0x07, 0xE0, 0x1F, 0x07, 0xC0, 0x1F, 0x0F, 0x80, 0x0F, 0x0F,
  0x00, 0x0F, 0x1F, 0x00, 0x0F, 0x1F, 0x00, 0x0F, 0x1F, 0x00, 0x0F, 0x1F,
  0x00, 0x0F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x0F, 0xC0, 0x7F, 0x0F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x00, 0xFE, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x03,
  0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xE0, 0x7F, 0x07, 0xF0, 0xFF, 0x0F, 0xF0, 0x7E, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x7F, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0x7E,
  0x03, 0xC0, 0x00, 0x7C, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x1F, 0x80, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x3F, 0x00, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xF8, 0x03, 0xF0, 0x03,
  0xC0, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x0F, 0xE0, 0x1F, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF8, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00,
  0x7F, 0xE0, 0x00, 0xFE, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x04, 0x00, 0x0F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE0, 0x06, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xFE, 0x00, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0xFC, 0x03, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x0C, 0x07,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x03,
  0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x01, 0xFC, 0x1F, 0x80, 0xFC, 0x01, 0xE0,
  0x3E, 0x00, 0x78, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xC3, 0xC0, 0x00,
  0xF1, 0xF0, 0x00, 0x78, 0x78, 0x03, 0xFE, 0x3E, 0x07, 0xFF, 0x8F, 0x03,
  0xFF, 0xE7, 0xC1, 0xFF, 0xF9, 0xE0, 0xFC, 0x3C, 0x78, 0x7C, 0x0F, 0x1E,
  0x1E, 0x03, 0xCF, 0x8F, 0x81, 0xF3, 0xC3, 0xC0, 0x78, 0xF0, 0xF0, 0x1E,
  0x3C, 0x3C, 0x07, 0x8F, 0x0F, 0x03, 0xE3, 0xC3, 0xC0, 0xF0, 0xF0, 0xF0,
  0x3C, 0x3C, 0x3C, 0x0F, 0x0F, 0x0F, 0x87, 0xC3, 0xC1, 0xFF, 0xE0, 0xF0,
  0x7F, 0xF8, 0x3C, 0x0F, 0xFE, 0x0F, 0x80, 0xFE, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFE, 0x04,
  0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x3C,
  0xF0, 0x00, 0x0F, 0x3C, 0x00, 0x07, 0x8F, 0x80, 0x01, 0xE1, 0xE0, 0x00,
  0xF0, 0x78, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x07, 0x80, 0x0F, 0x81, 0xE0,
  0x03, 0xC0, 0x78, 0x01, 0xE0, 0x1E, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x1E, 0x01, 0xE0, 0x07, 0x80, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC3,
  0xC0, 0x01, 0xF0, 0xF0, 0x00, 0x7C, 0x78, 0x00, 0x1F, 0x1E, 0x00, 0x07,
  0xCF, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x7D, 0xE0, 0x00, 0x1F, 0x78, 0x00,
  0x07, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFE, 0x01, 0xE0, 0x1F, 0x80, 0x78, 0x03, 0xF0, 0x3E, 0x00,
  0x7C, 0x0F, 0x80, 0x1F, 0x03, 0xC0, 0x07, 0xC0, 0xF0, 0x01, 0xE0, 0x3C,
  0x00, 0x78, 0x1F, 0x00, 0x3E, 0x07, 0x80, 0x1F, 0x01, 0xE0, 0x1F, 0x80,
  0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0x00, 0xF0, 0x0F, 0xE0, 0x7C, 0x00, 0xF8, 0x1F, 0x00, 0x1F, 0x07, 0x80,
  0x07, 0xC1, 0xE0, 0x01, 0xF0, 0x78, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x0F,
  0x00, 0x0F, 0x83, 0xC0, 0x03, 0xE0, 0xF0, 0x03, 0xF0, 0x78, 0x03, 0xFC,
  0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF0, 0x1F, 0xC0, 0xF0, 0x1F, 0x80, 0x08, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x08, 0x07, 0xF0, 0x1C, 0x01, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x01,
  0xE0, 0x7F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x00, 0xF8, 0x0F, 0x00, 0x3E,
  0x03, 0xC0, 0x07, 0x81, 0xF0, 0x01, 0xF0, 0x78, 0x00, 0x7C, 0x1E, 0x00,
  0x1F, 0x07, 0x80, 0x07, 0xC3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x3C,
  0x00, 0x1E, 0x0F, 0x00, 0x07, 0x87, 0xC0, 0x01, 0xE1, 0xF0, 0x00, 0xF8,
  0x78, 0x00, 0x3E, 0x1E, 0x00, 0x0F, 0x0F, 0x80, 0x07, 0xC3, 0xE0, 0x01,
  0xF0, 0xF0, 0x00, 0xF8, 0x3C, 0x00, 0x7C, 0x0F, 0x00, 0x3F, 0x07, 0xC0,
  0x1F, 0x81, 0xE0, 0x0F, 0xC0, 0x78, 0x1F, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x01, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x01,
  0xFC, 0x07, 0x00, 0xFC, 0x00, 0x40, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x0F, 0x0F, 0x80, 0x03, 0xC3,
  0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x1E, 0x0F, 0x80, 0x07,
  0x83, 0xE0, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x1E, 0x00, 0x3C, 0x07, 0xC0,
  0x0F, 0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x81, 0xF0, 0x0F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0xF0, 0x0F, 0x80, 0x07, 0x80, 0x7C, 0x00, 0x3C, 0x03, 0xC0, 0x03,
  0xE0, 0x1E, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0xF0, 0x0F, 0x80, 0x07, 0x80,
  0x78, 0x00, 0x7C, 0x03, 0xC0, 0x03, 0xE0, 0x3E, 0x00, 0x1E, 0x01, 0xF0,
  0x00, 0xF0, 0x0F, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x7C, 0x03, 0xC0, 0x03,
  0xC0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xF8, 0x07, 0xC0, 0x03, 0xC0, 0x3E, 0x00, 0x1E, 0x01, 0xE0,
  0x01, 0xF0, 0x0F, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x78, 0x07, 0xC0, 0x03,
  0xC0, 0x3C, 0x00, 0x3E, 0x01, 0xE0, 0x01, 0xE0, 0x1F, 0x00, 0x0F, 0x00,
  0xF8, 0x00, 0x78, 0x07, 0x80, 0x07, 0xC0, 0x3C, 0x00, 0x3E, 0x03, 0xE0,
  0x01, 0xE0, 0x1F, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1E, 0x00, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xF0, 0x10, 0x01, 0xF8, 0x0E, 0x00, 0xF8, 0x0F, 0x81, 0xF8,
  0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x01, 0xF8, 0x07, 0x80, 0x1F, 0x80, 0x3C, 0x01,
  0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x1E, 0x01, 0xF8, 0x00, 0xF0, 0x1F, 0x80,
  0x07, 0x81, 0xF8, 0x00, 0x7C, 0x1F, 0x80, 0x03, 0xC1, 0xF8, 0x00, 0x1E,
  0x1F, 0x80, 0x00, 0xF1, 0xF0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x7D, 0xF0,
  0x00, 0x03, 0xDF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7B, 0xF0, 0x00, 0x03, 0xCF, 0x80, 0x00, 0x1E,
  0x3E, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x78, 0x1F,
  0x00, 0x03, 0xC0, 0x78, 0x00, 0x3E, 0x03, 0xE0, 0x01, 0xE0, 0x0F, 0x80,
  0x0F, 0x00, 0x7C, 0x00, 0x78, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3E,
  0x00, 0x3C, 0x01, 0xE0, 0x01, 0xF0, 0x0F, 0x00, 0x0F, 0x80, 0x78, 0x00,
  0x3E, 0x00, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03,
  0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3C, 0x00,
  0xF8, 0x01, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xFC, 0x03, 0xE0,
  0x07, 0xE0, 0x3F, 0x00, 0x7F, 0x03, 0xF8, 0x03, 0xF8, 0x1D, 0xC0, 0x1D,
  0xC1, 0xFE, 0x01, 0xEE, 0x0E, 0xE0, 0x0E, 0x70, 0xE7, 0x00, 0x73, 0x87,
  0x38, 0x07, 0x9C, 0x71, 0xC0, 0x3C, 0xE7, 0x9E, 0x01, 0xC7, 0x38, 0xF0,
  0x1E, 0x3B, 0xC7, 0x80, 0xF1, 0xDC, 0x38, 0x07, 0x0F, 0xC3, 0xC0, 0x78,
  0x7E, 0x1E, 0x03, 0xC3, 0xE0, 0xF0, 0x1E, 0x0F, 0x07, 0x81, 0xE0, 0x00,
  0x38, 0x0F, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0xF0,
  0x3C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x7C, 0x0F, 0x00, 0x03, 0xC0, 0xF8,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0x7C, 0x1F, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x78, 0x07, 0xC0, 0x07, 0x80, 0x7E, 0x00, 0x3C, 0x03, 0xF0, 0x01, 0xE0,
  0x1F, 0xC0, 0x0F, 0x00, 0xFE, 0x00, 0xF0, 0x0F, 0xF0, 0x07, 0x80, 0x7B,
  0xC0, 0x3C, 0x03, 0xDE, 0x01, 0xE0, 0x1E, 0xF0, 0x1E, 0x01, 0xE3, 0x80,
  0xF0, 0x0F, 0x1E, 0x07, 0x80, 0x78, 0xF0, 0x3C, 0x03, 0xC7, 0x81, 0xC0,
  0x1C, 0x1C, 0x1E, 0x01, 0xE0, 0xF0, 0xF0, 0x0F, 0x07, 0x87, 0x80, 0x78,
  0x3C, 0x3C, 0x03, 0xC0, 0xE3, 0xC0, 0x3C, 0x07, 0x1E, 0x01, 0xE0, 0x3C,
  0xF0, 0x0F, 0x01, 0xE7, 0x80, 0x78, 0x07, 0x78, 0x07, 0x80, 0x3B, 0xC0,
  0x3C, 0x01, 0xDE, 0x01, 0xE0, 0x0F, 0xF0, 0x0F, 0x00, 0x7F, 0x00, 0xF0,
  0x01, 0xF8, 0x07, 0x80, 0x0F, 0xC0, 0x3C, 0x00, 0x7E, 0x01, 0xE0, 0x03,
  0xE0, 0x1E, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0x83,
  0xF0, 0x1F, 0x00, 0xF8, 0x1F, 0x00, 0x3C, 0x1F, 0x00, 0x1E, 0x0F, 0x80,
  0x0F, 0x8F, 0x80, 0x07, 0xC7, 0x80, 0x03, 0xE7, 0xC0, 0x01, 0xF3, 0xE0,
  0x00, 0xF9, 0xE0, 0x00, 0x79, 0xF0, 0x00, 0x3C, 0xF8, 0x00, 0x1E, 0x78,
  0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x9E, 0x00, 0x07, 0x9F, 0x00, 0x03, 0xCF,
  0x80, 0x03, 0xE7, 0xC0, 0x01, 0xE3, 0xE0, 0x00, 0xF1, 0xF0, 0x00, 0xF8,
  0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x78, 0x1E, 0x00, 0x7C, 0x0F, 0x80, 0x7C,
  0x07, 0xE0, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xFF, 0x00,
  0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x01, 0xE0, 0x3F, 0x80, 0xF8, 0x03,
  0xE0, 0x3E, 0x00, 0x7C, 0x0F, 0x00, 0x1F, 0x03, 0xC0, 0x07, 0xC1, 0xF0,
  0x01, 0xF0, 0x7C, 0x00, 0x78, 0x1E, 0x00, 0x1E, 0x07, 0x80, 0x07, 0x81,
  0xE0, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x3C, 0x00, 0xF8, 0x0F, 0x01, 0xFE,
  0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0x83, 0xF0, 0x1F, 0x00, 0xF8,
  0x1F, 0x00, 0x3C, 0x1F, 0x00, 0x1E, 0x0F, 0x80, 0x0F, 0x8F, 0x80, 0x07,
  0xC7, 0x80, 0x03, 0xE3, 0xC0, 0x01, 0xF3, 0xE0, 0x00, 0xF9, 0xE0, 0x00,
  0x79, 0xF0, 0x00, 0x3C, 0xF8, 0x00, 0x1E, 0x78, 0x00, 0x0F, 0x3C, 0x00,
  0x0F, 0x9E, 0x00, 0x07, 0x9F, 0x00, 0x03, 0xCF, 0x80, 0x03, 0xE7, 0xC0,
  0x01, 0xE3, 0xE0, 0x00, 0xF1, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0x7C,
  0x00, 0x7C, 0x1E, 0x00, 0x7C, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0xFC, 0x01,
  0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFF, 0x80,
  0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x01, 0xF0, 0x1F, 0x80, 0x78, 0x03,
  0xF0, 0x1E, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x03, 0xC0, 0xF0,
  0x00, 0xF0, 0x3C, 0x00, 0x3C, 0x0F, 0x00, 0x1F, 0x07, 0xC0, 0x07, 0x81,
  0xF0, 0x03, 0xE0, 0x78, 0x00, 0xF8, 0x1E, 0x00, 0xFC, 0x0F, 0x80, 0xFE,
  0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x1F, 0x3F,
  0x80, 0x07, 0xC1, 0xF0, 0x01, 0xE0, 0x3C, 0x00, 0x78, 0x0F, 0x80, 0x3E,
  0x01, 0xE0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x0F, 0x00, 0xF0, 0x03, 0xC0,
  0x7C, 0x00, 0xF8, 0x1F, 0x00, 0x1E, 0x07, 0x80, 0x07, 0x81, 0xE0, 0x01,
  0xF0, 0x78, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0xE0,
  0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xFC, 0x07, 0x80, 0x7C, 0x00,
  0x40, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x80, 0x07, 0xE0,
  0x78, 0x07, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0xF8, 0x00, 0x78, 0x1E,
  0x00, 0x0F, 0x03, 0xC0, 0x03, 0xE0, 0x78, 0x00, 0x78, 0x1F, 0x00, 0x0F,
  0x03, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x7C, 0x0F, 0x00, 0x0F, 0x03, 0xE0,
  0x01, 0xE0, 0x7C, 0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x81, 0xE0, 0x01, 0xE0,
  0x7C, 0x00, 0x3C, 0x0F, 0x80, 0x07, 0x81, 0xE0, 0x01, 0xF0, 0x3C, 0x00,
  0x3C, 0x0F, 0x80, 0x07, 0x81, 0xF0, 0x00, 0xF0, 0x3C, 0x00, 0x3E, 0x07,
  0x80, 0x07, 0x81, 0xF0, 0x00, 0xF0, 0x3E, 0x00, 0x3E, 0x07, 0xC0, 0x07,
  0xC0, 0xF8, 0x00, 0xF0, 0x1F, 0x00, 0x3E, 0x01, 0xE0, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x07, 0xE0, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0,
  0x00, 0x7F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xDF, 0x00, 0x03, 0xEF, 0x80, 0x01, 0xE7,
  0xC0, 0x01, 0xF3, 0xE0, 0x00, 0xF1, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x78,
  0x3C, 0x00, 0x7C, 0x1E, 0x00, 0x3C, 0x0F, 0x00, 0x3E, 0x07, 0x80, 0x1E,
  0x03, 0xC0, 0x1F, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x07,
  0x80, 0x3C, 0x07, 0x80, 0x1E, 0x03, 0xC0, 0x0F, 0x03, 0xC0, 0x07, 0x81,
  0xE0, 0x03, 0xC1, 0xE0, 0x01, 0xF1, 0xF0, 0x00, 0xF8, 0xF0, 0x00, 0x7C,
  0xF8, 0x00, 0x1E, 0x78, 0x00, 0x0F, 0x7C, 0x00, 0x07, 0xBC, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x1F, 0x03, 0xC0,
  0x00, 0xF0, 0x3C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x03,
  0xC0, 0x78, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0x78, 0x0F, 0x07, 0x83, 0xC0, 0x78, 0x7C, 0x1E, 0x03, 0x83,
  0xE0, 0xE0, 0x1C, 0x3F, 0x0F, 0x01, 0xE1, 0xF8, 0x78, 0x0F, 0x1D, 0xC3,
  0x80, 0x79, 0xEE, 0x3C, 0x03, 0x8E, 0x79, 0xE0, 0x1C, 0xF1, 0xCE, 0x01,
  0xE7, 0x0E, 0x70, 0x0F, 0x78, 0x77, 0x80, 0x73, 0x83, 0xB8, 0x03, 0xB8,
  0x1D, 0xC0, 0x1F, 0xC0, 0xFE, 0x00, 0xFC, 0x07, 0xE0, 0x07, 0xE0, 0x3F,
  0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00,
  0xF0, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0xF8,
  0x00, 0x1F, 0x01, 0xF0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0F, 0x83, 0xE0,
  0x00, 0x0F, 0x87, 0xC0, 0x00, 0x07, 0x8F, 0x80, 0x00, 0x07, 0xCF, 0x00,
  0x00, 0x07, 0xDE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x1F, 0x78, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x7C, 0x3C, 0x00,
  0x00, 0xF8, 0x3C, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x01, 0xF0, 0x1E, 0x00,
  0x03, 0xE0, 0x1E, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x00,
  0x1F, 0x80, 0x0F, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x0F, 0x80,
  0x7C, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xBC, 0x00,
  0x07, 0x9F, 0x00, 0x07, 0xC7, 0x80, 0x07, 0xC3, 0xC0, 0x03, 0xC1, 0xE0,
  0x03, 0xE0, 0xF0, 0x03, 0xE0, 0x7C, 0x01, 0xE0, 0x1E, 0x01, 0xF0, 0x0F,
  0x01, 0xF0, 0x07, 0x80, 0xF0, 0x03, 0xE0, 0xF0, 0x00, 0xF0, 0xF8, 0x00,
  0x78, 0x78, 0x00, 0x3E, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xF8, 0x00, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x7C, 0x7C, 0x7C,
  0x7C, 0x7C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3E, 0x3E, 0x3E,
  0x3E, 0x3E, 0x3E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1F, 0x1F,
  0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xFC, 0x00, 0x7D, 0xE0, 0x07, 0xCF,
  0x00, 0x7C, 0x7C, 0x03, 0xC1, 0xE0, 0x3E, 0x0F, 0x03, 0xE0, 0x78, 0x3E,
  0x01, 0xE1, 0xE0, 0x0F, 0x1F, 0x00, 0x79, 0xF0, 0x01, 0xFF, 0x00, 0x0F,
  0x70, 0x00, 0x79, 0x00, 0x01, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x20, 0x38, 0x3E, 0x0F, 0x83, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0x01, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xFC,
  0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x7F, 0x83, 0xC1, 0xF8, 0x07, 0x87,
  0xE0, 0x0F, 0x0F, 0x80, 0x1E, 0x3E, 0x00, 0x7C, 0x78, 0x00, 0xF1, 0xF0,
  0x01, 0xE3, 0xC0, 0x03, 0xCF, 0x80, 0x0F, 0x9F, 0x00, 0x1E, 0x3C, 0x00,
  0x3C, 0x78, 0x00, 0x78, 0xF0, 0x01, 0xF1, 0xE0, 0x03, 0xC3, 0xC0, 0x07,
  0x87, 0x80, 0x0F, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0xFC, 0x1F, 0x07, 0xF8,
  0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFB, 0xE0, 0x3F, 0xC3, 0x80,
  0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xCF, 0xE0,
  0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x07, 0xF0, 0x7E,
  0x07, 0xC0, 0x3E, 0x07, 0x80, 0x1F, 0x07, 0x80, 0x1F, 0x0F, 0x00, 0x1F,
  0x0F, 0x00, 0x1F, 0x0F, 0x00, 0x1F, 0x0F, 0x00, 0x1F, 0x1F, 0x00, 0x1F,
  0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x3E, 0x1E, 0x00, 0x3C,
  0x3C, 0x00, 0x7C, 0x3C, 0x00, 0x7C, 0x3C, 0x00, 0xF8, 0x3C, 0x01, 0xF0,
  0x7C, 0x07, 0xF0, 0x78, 0x1F, 0xE0, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x00,
  0xFF, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xFC,
  0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0x00, 0xC1, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x04, 0x1F, 0xC0, 0x78,
  0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0x80, 0x3F, 0xC0, 0xF0, 0x0F, 0xE0, 0x3E, 0x01, 0xF0, 0x07,
  0xC0, 0x7C, 0x00, 0xF0, 0x1F, 0x80, 0x1E, 0x03, 0xE0, 0x03, 0xC0, 0x78,
  0x00, 0xF8, 0x1F, 0x00, 0x1E, 0x03, 0xC0, 0x03, 0xC0, 0x78, 0x00, 0x78,
  0x1F, 0x00, 0x1F, 0x03, 0xE0, 0x03, 0xC0, 0x7C, 0x00, 0x78, 0x0F, 0x80,
  0x0F, 0x01, 0xF0, 0x03, 0xE0, 0x3E, 0x00, 0x7C, 0x07, 0xC0, 0x0F, 0x00,
  0x7C, 0x03, 0xE0, 0x0F, 0xC1, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0x78, 0x01, 0xFF, 0xCF, 0x00, 0x0F, 0xE1, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0xFF, 0x07, 0xC1,
  0xF8, 0x07, 0xC7, 0xC0, 0x0F, 0x9F, 0x00, 0x1F, 0x3E, 0x00, 0x3E, 0xF8,
  0x00, 0x79, 0xE0, 0x01, 0xF3, 0xC0, 0x0F, 0xCF, 0x80, 0xFF, 0x9F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0x80, 0xFF, 0xE0, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x04,
  0x1F, 0xC0, 0x78, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7E, 0x04, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x41,
  0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x07, 0xF0, 0x3C,
  0x01, 0xF8, 0x07, 0x80, 0x7E, 0x01, 0xF0, 0x1F, 0x80, 0x3E, 0x03, 0xE0,
  0x07, 0x80, 0xF8, 0x00, 0xF0, 0x1E, 0x00, 0x1E, 0x07, 0xC0, 0x07, 0xC0,
  0xF8, 0x00, 0xF0, 0x1E, 0x00, 0x1E, 0x03, 0xC0, 0x03, 0xC0, 0x78, 0x00,
  0xF8, 0x0F, 0x00, 0x1E, 0x01, 0xE0, 0x03, 0xC0, 0x3C, 0x00, 0x78, 0x07,
  0xC0, 0x1F, 0x00, 0xFC, 0x0F, 0xE0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFE, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0,
  0x1E, 0x03, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x1F, 0x7E, 0x00, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0xFF,
  0xFF, 0x03, 0xE0, 0x3F, 0x07, 0xC0, 0x3E, 0x0F, 0x00, 0x3C, 0x1E, 0x00,
  0x78, 0x3C, 0x00, 0xF0, 0xF8, 0x01, 0xE1, 0xE0, 0x03, 0xC3, 0xC0, 0x0F,
  0x87, 0x80, 0x1F, 0x1F, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x78, 0x00, 0xF0,
  0xF0, 0x03, 0xE3, 0xE0, 0x07, 0x87, 0x80, 0x0F, 0x0F, 0x00, 0x1E, 0x1E,
  0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x01, 0xE1, 0xE0, 0x03, 0xC3, 0xC0,
  0x0F, 0x87, 0x80, 0x1F, 0x00, 0x00, 0x78, 0x00, 0xFC, 0x00, 0xFC, 0x01,
  0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xFF, 0x07,
  0xFE, 0x03, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00,
  0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x78, 0x1F, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0,
  0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x0F, 0x80, 0xF0, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x1F, 0x01, 0xF0,
  0x07, 0xC1, 0xF8, 0x01, 0xE0, 0xFC, 0x00, 0x78, 0x7E, 0x00, 0x1E, 0x7E,
  0x00, 0x0F, 0xBF, 0x00, 0x03, 0xDF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0x9F, 0x00, 0x01, 0xE3, 0xE0, 0x00,
  0x78, 0x7C, 0x00, 0x3E, 0x1F, 0x80, 0x0F, 0x03, 0xE0, 0x03, 0xC0, 0x7C,
  0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x07, 0x80,
  0x1F, 0x01, 0xE0, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x00, 0x7F, 0xF9, 0xFF,
  0xC7, 0xFF, 0x1F, 0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF8, 0x13, 0xFF, 0xCF, 0xFF,
  0x1F, 0xFC, 0x1F, 0xC0, 0x00, 0xFC, 0x3E, 0x01, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0x8F, 0xC7, 0xC3, 0xC1, 0xE1, 0xF0,
  0xF0, 0x78, 0x3C, 0x3C, 0x1E, 0x1E, 0x0F, 0x0F, 0x07, 0x87, 0x83, 0xC1,
  0xE1, 0xE0, 0xF0, 0x78, 0x78, 0x3C, 0x3C, 0x1E, 0x1E, 0x0F, 0x07, 0x87,
  0x83, 0xC3, 0xC1, 0xE0, 0xF0, 0xF0, 0x78, 0x3C, 0x3C, 0x00, 0x1E, 0x0F,
  0x00, 0x07, 0x87, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x3C,
  0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF0, 0xF0, 0x00,
  0x78, 0x3C, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0xC0, 0x07, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x7C, 0x07, 0xE0, 0xF0, 0x07, 0xC1, 0xE0,
  0x0F, 0x83, 0xC0, 0x0F, 0x0F, 0x80, 0x1E, 0x1F, 0x00, 0x3C, 0x3C, 0x00,
  0x78, 0x78, 0x01, 0xF1, 0xF0, 0x03, 0xC3, 0xE0, 0x07, 0x87, 0x80, 0x0F,
  0x0F, 0x00, 0x3E, 0x1E, 0x00, 0x7C, 0x7C, 0x00, 0xF0, 0xF0, 0x01, 0xE1,
  0xE0, 0x03, 0xC3, 0xC0, 0x0F, 0x8F, 0x80, 0x1E, 0x1F, 0x00, 0x3C, 0x3C,
  0x00, 0x78, 0x78, 0x01, 0xF1, 0xF0, 0x03, 0xE0, 0x00, 0x1F, 0xC0, 0x01,
  0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x0F, 0x87, 0xE0, 0x0F, 0x8F, 0x80, 0x1F, 0x3E, 0x00, 0x3E, 0x78, 0x00,
  0x7D, 0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xF7, 0x80, 0x03, 0xCF, 0x00, 0x07,
  0xBE, 0x00, 0x0F, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x7D, 0xF0, 0x00, 0xF3,
  0xE0, 0x03, 0xE7, 0xC0, 0x0F, 0x8F, 0x80, 0x3F, 0x0F, 0x80, 0xFC, 0x1F,
  0x83, 0xF0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFC, 0x01, 0xF0, 0x1F, 0x80, 0x78, 0x03, 0xE0, 0x1E, 0x00,
  0x78, 0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x07, 0xC0, 0xF0, 0x01, 0xF0, 0x3C,
  0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x07, 0xC0, 0x07, 0xC1, 0xE0, 0x01, 0xE0,
  0x78, 0x00, 0x78, 0x3E, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x83, 0xC0, 0x07,
  0xC0, 0xF0, 0x01, 0xF0, 0x3C, 0x00, 0xF8, 0x1F, 0x00, 0x7C, 0x07, 0xC0,
  0x7F, 0x01, 0xE0, 0x7F, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xF8, 0x1E, 0x07,
  0xE0, 0x3E, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x3C, 0x3E, 0x00, 0x3C, 0x3E,
  0x00, 0x7C, 0x3C, 0x00, 0x7C, 0x7C, 0x00, 0x78, 0x78, 0x00, 0x78, 0x78,
  0x00, 0x78, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF0, 0xF8, 0x00, 0xF0, 0xF8,
  0x00, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xE0, 0x7C,
  0x03, 0xE0, 0x7E, 0x0F, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xC0, 0x07, 0xF7, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7E, 0x00, 0x81, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0x01, 0x80, 0xF8,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x04, 0x00, 0x7C, 0x1E,
  0x03, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x7F, 0xFF,
  0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xF0, 0x30, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x0F, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0xF8,
  0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xC3, 0xC0, 0x07, 0x87, 0x80, 0x1F, 0x1F,
  0x00, 0x3E, 0x3E, 0x00, 0x78, 0x78, 0x00, 0xF0, 0xF0, 0x01, 0xE1, 0xE0,
  0x07, 0xC7, 0xC0, 0x0F, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x3C, 0x00,
  0xF8, 0x78, 0x01, 0xE1, 0xF0, 0x03, 0xC3, 0xE0, 0x07, 0x83, 0xC0, 0x1F,
  0x07, 0x80, 0x7E, 0x0F, 0x83, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0,
  0x1F, 0xFD, 0xF0, 0x0F, 0xC1, 0xE0, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFE,
  0x00, 0x3D, 0xF0, 0x01, 0xEF, 0x80, 0x1F, 0x7C, 0x00, 0xF3, 0xE0, 0x0F,
  0x9F, 0x00, 0x78, 0x78, 0x07, 0xC3, 0xC0, 0x3C, 0x1E, 0x03, 0xE0, 0xF0,
  0x1E, 0x07, 0x81, 0xF0, 0x3E, 0x0F, 0x01, 0xF0, 0xF0, 0x0F, 0x87, 0x80,
  0x3C, 0x78, 0x01, 0xE7, 0xC0, 0x0F, 0x3C, 0x00, 0x7B, 0xC0, 0x03, 0xFE,
  0x00, 0x1F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0x3C, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x78, 0xF0, 0x00, 0x0F, 0x1E, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0x78, 0xF0, 0x00, 0x0F, 0x1E, 0x07, 0x83, 0xC3,
  0xC0, 0xF0, 0x78, 0x78, 0x3E, 0x0F, 0x0F, 0x07, 0xC3, 0xC1, 0xE1, 0xF8,
  0x78, 0x3C, 0x3F, 0x0F, 0x07, 0x8E, 0xE3, 0xC0, 0xF3, 0xDC, 0x78, 0x1C,
  0x73, 0x8E, 0x03, 0x9E, 0x73, 0xC0, 0x73, 0x8E, 0x78, 0x1E, 0xF1, 0xFE,
  0x03, 0xDC, 0x3F, 0xC0, 0x7F, 0x03, 0xF0, 0x0F, 0xE0, 0x7E, 0x01, 0xF8,
  0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF0, 0x07, 0x80,
  0x00, 0x03, 0xE0, 0x01, 0xE0, 0x1F, 0x00, 0x3E, 0x01, 0xF0, 0x07, 0xC0,
  0x0F, 0x80, 0xF8, 0x00, 0xF8, 0x1F, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C,
  0x3C, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xF9, 0xE0,
  0x00, 0x1F, 0x1F, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x7E, 0x0F, 0x80, 0x0F,
  0xC0, 0xF8, 0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x00, 0x7C, 0x07, 0xE0, 0x03,
  0xC0, 0xFC, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x78, 0x07, 0xC0, 0x07,
  0xC0, 0x3E, 0x00, 0x3E, 0x01, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x1F, 0x00,
  0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x7C, 0x00, 0x7C,
  0x03, 0xC0, 0x03, 0xE0, 0x1E, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x78, 0x0F,
  0x00, 0x03, 0xC0, 0xF8, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xF8, 0x7C, 0x00,
  0x07, 0xC3, 0xC0, 0x00, 0x1E, 0x3E, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x07,
  0x9F, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x20, 0x7E, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x01, 0xFF,
  0xF0, 0x01, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80,
  0x1E, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF,
  0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x0C,
  0x1F, 0xE0, 0x1C, 0xFF, 0xE0, 0x79, 0xFF, 0xF1, 0xE7, 0x87, 0xFF, 0xCE,
  0x07, 0xFF, 0x3C, 0x03, 0xFC, 0x30, 0x03, 0xE0,
};

const GFXglyph UbuntuMono_Italic53pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 27, 0, -1 },
  { 1, 13, 33, 27, 9, -33 },
  { 55, 15, 13, 27, 12, -36 },
  { 80, 28, 33, 27, 2, -33 },
  { 196, 24, 42, 27, 4, -37 },
  { 322, 32, 33, 27, 0, -33 },
  { 454, 23, 33, 27, 3, -33 },
  { 549, 7, 14, 27, 16, -36 },
  { 562, 20, 46, 27, 8, -37 },
  { 677, 20, 46, 27, 3, -37 },
  { 792, 21, 20, 27, 7, -33 },
  { 845, 22, 24, 27, 5, -26 },
  { 911, 11, 14, 27, 6, -7 },
  { 931, 13, 4, 27, 9, -15 },
  { 938, 8, 7, 27, 9, -7 },
  { 945, 30, 46, 27, -1, -37 },
  { 1118, 24, 33, 27, 4, -33 },
  { 1217, 19, 33, 27, 5, -33 },
  { 1296, 24, 33, 27, 4, -33 },
  { 1395, 24, 33, 27, 3, -33 },
  { 1494, 24, 33, 27, 3, -33 },
  { 1593, 26, 33, 27, 3, -33 },
  { 1701, 24, 33, 27, 5, -33 },
  { 1800, 24, 33, 27, 7, -33 },
  { 1899, 25, 33, 27, 4, -33 },
  { 2003, 24, 33, 27, 4, -33 },
  { 2102, 12, 24, 27, 9, -24 },
  { 2138, 15, 31, 27, 6, -24 },
  { 2197, 23, 21, 27, 4, -24 },
  { 2258, 25, 14, 27, 3, -21 },
  { 2302, 24, 21, 27, 3, -24 },
  { 2365, 18, 33, 27, 9, -33 },
  { 2440, 26, 40, 27, 4, -33 },
  { 2570, 26, 33, 27, -1, -33 },
  { 2678, 26, 33, 27, 2, -33 },
  { 2786, 25, 33, 27, 5, -33 },
  { 2890, 26, 33, 27, 2, -33 },
  { 2998, 26, 33, 27, 4, -33 },
  { 3106, 26, 33, 27, 4, -33 },
  { 3214, 26, 33, 27, 4, -33 },
  { 3322, 29, 33, 27, 2, -33 },
  { 3442, 25, 33, 27, 4, -33 },
  { 3546, 25, 33, 27, 4, -33 },
  { 3650, 29, 33, 27, 2, -33 },
  { 3770, 19, 33, 27, 3, -33 },
  { 3849, 29, 33, 27, 1, -33 },
  { 3969, 29, 33, 27, 2, -33 },
  { 4089, 25, 33, 27, 4, -33 },
  { 4193, 26, 33, 27, 3, -33 },
  { 4301, 25, 42, 27, 4, -33 },
  { 4433, 26, 33, 27, 2, -33 },
  { 4541, 26, 33, 27, 3, -33 },
  { 4649, 23, 33, 27, 8, -33 },
  { 4744, 27, 33, 27, 4, -33 },
  { 4856, 25, 33, 27, 7, -33 },
  { 4960, 29, 33, 27, 3, -33 },
  { 5080, 32, 33, 27, 0, -33 },
  { 5212, 25, 33, 27, 8, -33 },
  { 5316, 28, 33, 27, 2, -33 },
  { 5432, 24, 46, 27, 5, -37 },
  { 5570, 8, 46, 27, 12, -37 },
  { 5616, 24, 46, 27, 1, -37 },
  { 5754, 21, 18, 27, 6, -33 },
  { 5802, 24, 4, 27, -1, 5 },
  { 5814, 9, 10, 27, 14, -37 },
  { 5826, 23, 27, 27, 4, -26 },
  { 5904, 24, 38, 27, 3, -37 },
  { 6018, 23, 27, 27, 4, -26 },
  { 6096, 27, 38, 27, 4, -37 },
  { 6225, 23, 27, 27, 4, -26 },
  { 6303, 32, 46, 27, 0, -37 },
  { 6487, 27, 35, 27, 1, -26 },
  { 6606, 23, 37, 27, 2, -37 },
  { 6713, 16, 36, 27, 7, -36 },
  { 6785, 26, 45, 27, 1, -36 },
  { 6932, 26, 37, 27, 3, -37 },
  { 7053, 14, 38, 27, 9, -37 },
  { 7120, 26, 26, 27, 2, -26 },
  { 7205, 23, 26, 27, 3, -26 },
  { 7280, 23, 27, 27, 4, -26 },
  { 7358, 26, 35, 27, 1, -26 },
  { 7472, 24, 35, 27, 4, -26 },
  { 7577, 23, 26, 27, 5, -26 },
  { 7652, 23, 27, 27, 4, -26 },
  { 7730, 20, 34, 27, 7, -33 },
  { 7815, 23, 26, 27, 4, -25 },
  { 7890, 21, 25, 27, 7, -25 },
  { 7956, 27, 25, 27, 4, -25 },
  { 8041, 28, 25, 27, 1, -25 },
  { 8129, 29, 34, 27, -1, -25 },
  { 8253, 24, 25, 27, 3, -25 },
  { 8328, 25, 46, 27, 5, -37 },
  { 8472, 15, 46, 27, 8, -37 },
  { 8559, 26, 46, 27, 0, -37 },
  { 8709, 23, 8, 27, 4, -18 },
};

const GFXfont UbuntuMono_Italic53pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Italic53pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Italic53pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _UBUNTUMONO_ITALIC53PT7B_H_
