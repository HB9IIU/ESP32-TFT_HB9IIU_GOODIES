#ifndef _UBUNTUMONO_ITALIC23PT7B_H_
#define _UBUNTUMONO_ITALIC23PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Italic.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Italic23pt7bBitmaps[] PROGMEM = {
  0x00, 0x18, 0x61, 0x86, 0x30, 0xC3, 0x08, 0x20, 0x00, 0x38, 0xE3, 0x80,
  0x66, 0x89, 0x36, 0x6C, 0x91, 0x00, 0x03, 0x30, 0x62, 0x06, 0x60, 0x46,
  0x3F, 0xF7, 0xFF, 0x18, 0xC1, 0x98, 0x31, 0x0F, 0xFE, 0xFF, 0xC6, 0x20,
  0x46, 0x0C, 0xC0, 0x03, 0x00, 0xC0, 0xF8, 0x7F, 0x38, 0x4C, 0x03, 0x00,
  0xF0, 0x1F, 0x01, 0xC0, 0x18, 0x06, 0x83, 0x3F, 0xC7, 0xC0, 0x40, 0x10,
  0x0C, 0x00, 0x0E, 0x08, 0x78, 0x61, 0x23, 0x0C, 0x98, 0x36, 0xC0, 0xFE,
  0x01, 0xD0, 0x00, 0xB8, 0x07, 0xF0, 0x36, 0xC1, 0x93, 0x0C, 0x48, 0x61,
  0xE1, 0x07, 0x00, 0x07, 0x83, 0xF1, 0x8C, 0x62, 0x19, 0x87, 0x81, 0xC4,
  0xDB, 0x66, 0x90, 0xEC, 0x13, 0x9E, 0x7F, 0x8E, 0x60, 0x6F, 0x6D, 0x00,
  0x01, 0x81, 0xC1, 0xC1, 0x81, 0x80, 0xC0, 0xC0, 0xC0, 0x60, 0x30, 0x10,
  0x18, 0x0C, 0x06, 0x01, 0x00, 0xC0, 0x60, 0x18, 0x0E, 0x02, 0x00, 0x04,
  0x03, 0x00, 0xC0, 0x60, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x60, 0x30, 0x30, 0x18, 0x18, 0x18, 0x18, 0x38, 0x08, 0x00, 0x0C, 0x06,
  0x12, 0x7F, 0xF1, 0xC0, 0xB0, 0xDC, 0x44, 0x06, 0x01, 0x80, 0x40, 0x30,
  0xFF, 0xBF, 0xE0, 0x80, 0x60, 0x18, 0x06, 0x00, 0x39, 0xCE, 0x3F, 0x30,
  0xFB, 0xE0, 0xFF, 0x80, 0x00, 0x10, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x0C,
  0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00,
  0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0x00, 0x30, 0x01, 0x80,
  0x00, 0x07, 0x87, 0xF3, 0x8C, 0xC3, 0x60, 0xDB, 0x3C, 0xCF, 0x33, 0xC1,
  0xB0, 0x6C, 0x33, 0x1C, 0xFE, 0x1E, 0x00, 0x01, 0x03, 0x87, 0xC7, 0x63,
  0x20, 0x30, 0x18, 0x0C, 0x0C, 0x06, 0x03, 0x01, 0x8F, 0xF7, 0xF8, 0x0F,
  0x8F, 0xF1, 0x0C, 0x03, 0x00, 0xC0, 0x60, 0x38, 0x3C, 0x1C, 0x0E, 0x06,
  0x03, 0x00, 0xFF, 0x3F, 0xC0, 0x07, 0x81, 0xF8, 0x23, 0x80, 0x30, 0x06,
  0x03, 0x81, 0xE0, 0x7C, 0x01, 0xC0, 0x18, 0x03, 0x20, 0xC7, 0xF8, 0xFC,
  0x00, 0x00, 0xE0, 0x38, 0x0F, 0x03, 0x60, 0xCC, 0x31, 0x0C, 0x61, 0x0C,
  0x61, 0x9F, 0xFB, 0xFF, 0x01, 0x80, 0x30, 0x04, 0x00, 0x07, 0xF0, 0x7E,
  0x0C, 0x00, 0xC0, 0x08, 0x01, 0xE0, 0x1F, 0x80, 0x3C, 0x00, 0xC0, 0x0C,
  0x00, 0xC4, 0x38, 0xFF, 0x07, 0xE0, 0x01, 0xE0, 0xF8, 0x78, 0x0C, 0x03,
  0x00, 0xFE, 0x1F, 0xE3, 0x0C, 0xC1, 0x98, 0x33, 0x06, 0x71, 0xC7, 0xF0,
  0x78, 0x00, 0x3F, 0xCF, 0xF8, 0x07, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x18, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x00, 0x0F, 0x87,
  0xF3, 0x8C, 0xC3, 0x30, 0xCC, 0x61, 0xF0, 0xFC, 0x63, 0xB0, 0x6C, 0x1B,
  0x0E, 0xFF, 0x1F, 0x00, 0x0F, 0x87, 0xF3, 0x8D, 0xC3, 0x60, 0xD8, 0x36,
  0x0C, 0xFF, 0x1F, 0x80, 0x60, 0x30, 0x38, 0xFC, 0x3C, 0x00, 0x39, 0xCE,
  0x00, 0x00, 0x1C, 0xE7, 0x00, 0x0E, 0x1C, 0x38, 0x00, 0x00, 0x00, 0x1C,
  0x38, 0x70, 0x67, 0x86, 0x00, 0x00, 0xC0, 0xF1, 0xF3, 0xE0, 0xC0, 0x3E,
  0x03, 0xE0, 0x1C, 0x01, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x9F, 0xF0, 0x30, 0x07, 0x80, 0x7C, 0x01, 0xE0, 0x0C, 0x0F, 0x8F,
  0x87, 0xC0, 0xC0, 0x00, 0x3E, 0x7F, 0x43, 0x03, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0x00, 0x00, 0xE0, 0xE0, 0xC0, 0x07, 0x83, 0xF8, 0xE1, 0x98, 0x36,
  0x06, 0xC7, 0xF3, 0xF6, 0x66, 0xD8, 0xD3, 0x1A, 0x66, 0x4F, 0xCC, 0xF9,
  0x80, 0x38, 0x03, 0xF0, 0x3C, 0x00, 0x01, 0xC0, 0x38, 0x0F, 0x03, 0x60,
  0x64, 0x18, 0x82, 0x10, 0xC3, 0x10, 0x67, 0xFC, 0xFF, 0xB0, 0x3C, 0x07,
  0x80, 0xC0, 0x1F, 0xC3, 0xFC, 0x61, 0x88, 0x33, 0x06, 0x61, 0x8F, 0xE1,
  0xFC, 0x60, 0xCC, 0x19, 0x83, 0x20, 0xEF, 0xF9, 0xFC, 0x00, 0x07, 0xC1,
  0xFC, 0xE0, 0x98, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x70, 0x87, 0xF0, 0x7C, 0x00, 0x1F, 0x83, 0xF8, 0x63, 0x98, 0x33,
  0x06, 0x60, 0xC8, 0x1B, 0x03, 0x60, 0xCC, 0x19, 0x07, 0x61, 0xCF, 0xF1,
  0xF8, 0x00, 0x1F, 0xE3, 0xFC, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x1F, 0xE3,
  0xFC, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x0F, 0xF1, 0xFE, 0x00, 0x1F, 0xE3,
  0xFC, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x1F, 0xE3, 0xFC, 0x60, 0x0C, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x00, 0x07, 0xC3, 0xFC, 0xE1, 0x18, 0x06,
  0x00, 0x80, 0x30, 0x06, 0x0C, 0xC1, 0x98, 0x33, 0x06, 0x71, 0x87, 0xF0,
  0x7C, 0x00, 0x18, 0x31, 0x83, 0x18, 0x33, 0x02, 0x30, 0x63, 0x06, 0x3F,
  0xE7, 0xFC, 0x60, 0xC6, 0x0C, 0x60, 0xCC, 0x08, 0xC1, 0x8C, 0x18, 0x1F,
  0xC7, 0xF0, 0x60, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x06, 0x01,
  0x80, 0x60, 0xFE, 0x3F, 0x80, 0x0F, 0xE1, 0xF8, 0x03, 0x00, 0x60, 0x0C,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x43, 0x8F, 0xE0, 0xF8,
  0x00, 0x18, 0x30, 0xC3, 0x06, 0x30, 0x23, 0x03, 0x70, 0x1F, 0x00, 0xF0,
  0x05, 0x80, 0x66, 0x03, 0x18, 0x18, 0xC0, 0xC3, 0x0C, 0x18, 0x60, 0x60,
  0x08, 0x0C, 0x06, 0x03, 0x01, 0x01, 0x80, 0xC0, 0x60, 0x20, 0x30, 0x18,
  0x0C, 0x07, 0xFF, 0xF8, 0x06, 0x18, 0x71, 0xC3, 0x8E, 0x1C, 0xE1, 0xA5,
  0x0D, 0x48, 0x4A, 0xC6, 0x66, 0x33, 0x31, 0x01, 0x18, 0x18, 0xC0, 0xC6,
  0x06, 0x20, 0x30, 0x18, 0x31, 0xC3, 0x1C, 0x33, 0x42, 0x36, 0x23, 0x66,
  0x26, 0x62, 0x24, 0x63, 0x46, 0x3C, 0x43, 0xC4, 0x1C, 0xC1, 0x8C, 0x18,
  0x0F, 0x87, 0xF3, 0x8D, 0xC3, 0x60, 0x58, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x6C, 0x1B, 0x0C, 0x7E, 0x0F, 0x00, 0x0F, 0xC3, 0xFC, 0x61, 0x8C, 0x11,
  0x06, 0x60, 0xCC, 0x39, 0xFE, 0x3F, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x01,
  0x80, 0x00, 0x0F, 0x87, 0xF3, 0x8D, 0xC3, 0x60, 0x58, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x6C, 0x1B, 0x0C, 0xFE, 0x1F, 0x03, 0x00, 0x70, 0x1E, 0x01,
  0x80, 0x1F, 0x83, 0xFC, 0x61, 0x8C, 0x33, 0x06, 0x60, 0xCC, 0x31, 0xFC,
  0x7F, 0x0C, 0x61, 0x8C, 0x30, 0xCC, 0x19, 0x83, 0x00, 0x07, 0xC0, 0xFE,
  0x1C, 0x21, 0x80, 0x18, 0x01, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xC0, 0x0C,
  0x00, 0xC4, 0x18, 0xFF, 0x87, 0xE0, 0x7F, 0xCF, 0xF8, 0x30, 0x06, 0x00,
  0xC0, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0xC0, 0x00, 0x30, 0x66, 0x0C, 0x81, 0xB0, 0x66, 0x0C, 0xC1, 0x90, 0x36,
  0x0C, 0xC1, 0x98, 0x33, 0x0C, 0x61, 0x87, 0xE0, 0x78, 0x00, 0xC0, 0x78,
  0x1B, 0x03, 0x60, 0xCC, 0x19, 0x86, 0x30, 0xC6, 0x30, 0x46, 0x09, 0x81,
  0x20, 0x3C, 0x07, 0x00, 0xE0, 0x00, 0x10, 0x19, 0x80, 0x8C, 0x0C, 0x60,
  0x63, 0x02, 0x13, 0x11, 0x99, 0x8D, 0xCC, 0x6A, 0x42, 0xDE, 0x14, 0xF0,
  0xC7, 0x06, 0x38, 0x60, 0x80, 0x0C, 0x1C, 0x18, 0x60, 0x63, 0x01, 0x98,
  0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x33, 0x01, 0x8C,
  0x0E, 0x30, 0x70, 0x61, 0x81, 0x80, 0xC0, 0x68, 0x19, 0x83, 0x30, 0xC6,
  0x30, 0x44, 0x0D, 0x81, 0xE0, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x30, 0x06, 0x00, 0xFF, 0x8F, 0xF8, 0x07,
  0xC0, 0xF8, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x40, 0x18, 0x03, 0x00, 0x60, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0xF0, 0x7E, 0x00, 0xCC, 0xCC, 0xCC, 0x46, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x62, 0x0F, 0xC3, 0xF0, 0x08, 0x06, 0x01, 0x80, 0x60, 0x10, 0x0C, 0x03,
  0x00, 0xC0, 0x20, 0x18, 0x06, 0x01, 0x80, 0x40, 0x30, 0x0C, 0x03, 0x0F,
  0x83, 0xE0, 0x03, 0x01, 0xC0, 0xD0, 0x66, 0x19, 0x8C, 0x26, 0x0D, 0x02,
  0x7F, 0xFF, 0xFC, 0x4E, 0x63, 0x0F, 0x8F, 0xF7, 0x09, 0x86, 0xC1, 0xB0,
  0x4C, 0x33, 0x0C, 0xC7, 0x3F, 0xC7, 0xB0, 0x0C, 0x01, 0x80, 0x20, 0x0C,
  0x01, 0x80, 0x3F, 0x07, 0xF1, 0xC6, 0x30, 0x66, 0x0C, 0x81, 0x30, 0x66,
  0x1C, 0xC7, 0x1F, 0xC3, 0xE0, 0x0F, 0x8F, 0xF7, 0x0B, 0x80, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC1, 0x3F, 0xC3, 0xE0, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x0E, 0x1F, 0x87, 0xF3, 0xC6, 0x61, 0xD8, 0x3B, 0x06, 0x60, 0xCC,
  0x39, 0x8F, 0x3F, 0xE3, 0xCC, 0x0F, 0x0F, 0xE7, 0x0F, 0x83, 0xC3, 0xBF,
  0xCF, 0xC2, 0x00, 0xC1, 0x3F, 0xC3, 0xE0, 0x00, 0x7C, 0x03, 0xE0, 0x18,
  0x00, 0x60, 0x03, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0xC0, 0x03, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x60, 0x0F, 0x80, 0x3C, 0x00, 0x03, 0xF0, 0x7F, 0x0E, 0x31, 0x82,
  0x18, 0x63, 0x06, 0x30, 0x63, 0x04, 0x30, 0xC3, 0xFC, 0x1E, 0xC0, 0x18,
  0x43, 0x87, 0xF0, 0x7E, 0x00, 0x0C, 0x06, 0x01, 0x80, 0x60, 0x18, 0x07,
  0xE3, 0xF8, 0xC3, 0x30, 0xCC, 0x36, 0x0D, 0x82, 0x61, 0x98, 0x6C, 0x1B,
  0x04, 0x0C, 0x38, 0x70, 0x00, 0x1F, 0x3E, 0x0C, 0x18, 0x60, 0xC1, 0x83,
  0x06, 0x0F, 0x8F, 0x00, 0x60, 0x0E, 0x00, 0x60, 0x00, 0x00, 0x00, 0x7E,
  0x0F, 0xE0, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x10, 0x03, 0x04, 0x30, 0x7E, 0x07, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x01, 0x80, 0x18, 0x01, 0x86, 0x18, 0xC3, 0x18, 0x33, 0x03, 0x60,
  0x3C, 0x02, 0xE0, 0x66, 0x06, 0x30, 0x61, 0x84, 0x18, 0xFB, 0xE1, 0x86,
  0x10, 0xC3, 0x0C, 0x61, 0x86, 0x18, 0x41, 0x97, 0xDF, 0x3F, 0xC7, 0xFC,
  0xD9, 0xB3, 0x36, 0x66, 0xCC, 0x99, 0x32, 0x06, 0xC0, 0xD8, 0x13, 0x06,
  0x00, 0x1F, 0x87, 0xF3, 0x0C, 0xC3, 0x30, 0xCC, 0x32, 0x0D, 0x83, 0x61,
  0x98, 0x64, 0x18, 0x0F, 0x0F, 0xE7, 0x19, 0x83, 0xC0, 0xF0, 0x2C, 0x1B,
  0x06, 0xC7, 0x3F, 0x87, 0xC0, 0x0F, 0xC0, 0xFE, 0x18, 0x61, 0x83, 0x18,
  0x31, 0x82, 0x30, 0x63, 0x0E, 0x31, 0xC3, 0xF8, 0x7E, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x40, 0x00, 0x0F, 0xC7, 0xF7, 0x8D, 0x86, 0xC1, 0xB0, 0x6C,
  0x1B, 0x0C, 0xC3, 0x3F, 0xC7, 0xB0, 0x18, 0x06, 0x01, 0x80, 0x60, 0x1F,
  0xCF, 0xF3, 0x00, 0xC0, 0x30, 0x18, 0x06, 0x01, 0x80, 0x60, 0x30, 0x0C,
  0x00, 0x0F, 0x8F, 0xE3, 0x08, 0xC0, 0x38, 0x07, 0x80, 0x70, 0x0C, 0x83,
  0x3F, 0xC7, 0xC0, 0x18, 0x0C, 0x06, 0x1F, 0xFF, 0xF9, 0x80, 0xC0, 0x60,
  0x60, 0x30, 0x18, 0x0C, 0x47, 0xE1, 0xE0, 0x60, 0xD8, 0x26, 0x19, 0x86,
  0xC1, 0xB0, 0x4C, 0x33, 0x0C, 0xC7, 0x3F, 0xC7, 0xB0, 0xC1, 0xE0, 0xF0,
  0xD8, 0x6C, 0x66, 0x31, 0x30, 0xD8, 0x78, 0x38, 0x1C, 0x00, 0x40, 0x78,
  0x0F, 0x01, 0x66, 0x6C, 0xCD, 0xB9, 0x35, 0x67, 0xAC, 0xA7, 0x18, 0xE3,
  0x18, 0x00, 0x18, 0x30, 0xC6, 0x0C, 0xC0, 0x6C, 0x07, 0x80, 0x30, 0x07,
  0x00, 0xD8, 0x19, 0x83, 0x0C, 0x60, 0xC0, 0x18, 0x31, 0x83, 0x18, 0x21,
  0x86, 0x0C, 0x60, 0xCC, 0x0C, 0xC0, 0xD8, 0x05, 0x80, 0x70, 0x06, 0x00,
  0x60, 0x0C, 0x0F, 0x80, 0xF0, 0x00, 0x1F, 0xE3, 0xF8, 0x07, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x0F, 0xF3, 0xFC, 0x00, 0x01, 0xE0,
  0xFC, 0x18, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x18, 0x1E, 0x03,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x60, 0x0C, 0x01, 0xF8,
  0x1E, 0x00, 0x0C, 0x30, 0x86, 0x18, 0x61, 0x84, 0x30, 0xC3, 0x08, 0x61,
  0x86, 0x10, 0xC3, 0x0C, 0x20, 0x07, 0x81, 0xF8, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x3C, 0x07, 0x81, 0x80, 0x30, 0x04,
  0x01, 0x80, 0x30, 0x06, 0x01, 0x83, 0xF0, 0x7C, 0x00, 0x30, 0xDF, 0x3C,
  0xFA, 0x1C,
};

const GFXglyph UbuntuMono_Italic23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 6, 14, 12, 4, -14 },
  { 12, 7, 6, 12, 5, -14 },
  { 18, 12, 14, 12, 1, -14 },
  { 39, 10, 18, 12, 2, -16 },
  { 62, 14, 14, 12, 0, -14 },
  { 87, 10, 14, 12, 1, -14 },
  { 105, 3, 6, 12, 7, -16 },
  { 108, 9, 20, 12, 3, -16 },
  { 131, 9, 20, 12, 1, -16 },
  { 154, 9, 8, 12, 3, -14 },
  { 163, 10, 10, 12, 2, -11 },
  { 176, 5, 6, 12, 2, -3 },
  { 180, 6, 2, 12, 4, -7 },
  { 182, 3, 3, 12, 4, -3 },
  { 184, 13, 20, 12, 0, -16 },
  { 217, 10, 14, 12, 2, -14 },
  { 235, 9, 14, 12, 2, -14 },
  { 251, 10, 14, 12, 2, -14 },
  { 269, 11, 14, 12, 1, -14 },
  { 289, 11, 14, 12, 1, -14 },
  { 309, 12, 14, 12, 1, -14 },
  { 330, 11, 14, 12, 2, -14 },
  { 350, 11, 14, 12, 3, -14 },
  { 370, 10, 14, 12, 2, -14 },
  { 388, 10, 14, 12, 2, -14 },
  { 406, 5, 10, 12, 4, -10 },
  { 413, 7, 13, 12, 2, -10 },
  { 425, 10, 9, 12, 2, -10 },
  { 437, 11, 7, 12, 1, -10 },
  { 447, 11, 9, 12, 1, -11 },
  { 460, 8, 14, 12, 4, -14 },
  { 474, 11, 17, 12, 2, -14 },
  { 498, 11, 14, 12, 0, -14 },
  { 518, 11, 14, 12, 1, -14 },
  { 538, 11, 14, 12, 2, -14 },
  { 558, 11, 14, 12, 1, -14 },
  { 578, 11, 14, 12, 2, -14 },
  { 598, 11, 14, 12, 2, -14 },
  { 618, 11, 14, 12, 2, -14 },
  { 638, 12, 14, 12, 1, -14 },
  { 659, 10, 14, 12, 2, -14 },
  { 677, 11, 14, 12, 2, -14 },
  { 697, 13, 14, 12, 1, -14 },
  { 720, 9, 14, 12, 1, -14 },
  { 736, 13, 14, 12, 0, -14 },
  { 759, 12, 14, 12, 1, -14 },
  { 780, 10, 14, 12, 2, -14 },
  { 798, 11, 14, 12, 1, -14 },
  { 818, 10, 18, 12, 2, -14 },
  { 841, 11, 14, 12, 1, -14 },
  { 861, 12, 14, 12, 1, -14 },
  { 882, 11, 14, 12, 3, -14 },
  { 902, 11, 14, 12, 2, -14 },
  { 922, 11, 14, 12, 3, -14 },
  { 942, 13, 14, 12, 1, -14 },
  { 965, 14, 14, 12, 0, -14 },
  { 990, 11, 14, 12, 3, -14 },
  { 1010, 12, 14, 12, 1, -14 },
  { 1031, 11, 20, 12, 2, -16 },
  { 1059, 4, 20, 12, 5, -16 },
  { 1069, 10, 20, 12, 1, -16 },
  { 1094, 10, 8, 12, 2, -14 },
  { 1104, 11, 2, 12, -1, 2 },
  { 1107, 4, 4, 12, 6, -16 },
  { 1109, 10, 11, 12, 2, -11 },
  { 1123, 11, 16, 12, 1, -16 },
  { 1145, 10, 11, 12, 2, -11 },
  { 1159, 11, 16, 12, 2, -16 },
  { 1181, 10, 11, 12, 2, -11 },
  { 1195, 14, 20, 12, 0, -16 },
  { 1230, 12, 15, 12, 0, -11 },
  { 1253, 10, 16, 12, 1, -16 },
  { 1273, 7, 16, 12, 3, -16 },
  { 1287, 12, 20, 12, 0, -16 },
  { 1317, 12, 16, 12, 1, -16 },
  { 1341, 6, 16, 12, 4, -16 },
  { 1353, 11, 11, 12, 1, -11 },
  { 1369, 10, 11, 12, 1, -11 },
  { 1383, 10, 11, 12, 2, -11 },
  { 1397, 12, 15, 12, 0, -11 },
  { 1420, 10, 15, 12, 2, -11 },
  { 1439, 10, 11, 12, 2, -11 },
  { 1453, 10, 11, 12, 2, -11 },
  { 1467, 9, 14, 12, 3, -14 },
  { 1483, 10, 11, 12, 2, -11 },
  { 1497, 9, 11, 12, 3, -11 },
  { 1510, 11, 11, 12, 2, -11 },
  { 1526, 12, 11, 12, 0, -11 },
  { 1543, 12, 15, 12, 0, -11 },
  { 1566, 11, 11, 12, 1, -11 },
  { 1582, 11, 20, 12, 2, -16 },
  { 1610, 6, 20, 12, 4, -16 },
  { 1625, 11, 20, 12, 0, -16 },
  { 1653, 10, 4, 12, 2, -10 },
};

const GFXfont UbuntuMono_Italic23pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Italic23pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Italic23pt7bGlyphs,
  0x20, 0x7E, 23
};

#endif // _UBUNTUMONO_ITALIC23PT7B_H_
