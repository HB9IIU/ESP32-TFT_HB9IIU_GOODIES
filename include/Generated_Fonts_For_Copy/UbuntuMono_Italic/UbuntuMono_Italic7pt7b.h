#ifndef _UBUNTUMONO_ITALIC7PT7B_H_
#define _UBUNTUMONO_ITALIC7PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Italic.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Italic7pt7bBitmaps[] PROGMEM = {
  0x00, 0x52, 0x00, 0x36, 0xFA, 0x25, 0x42, 0x64, 0xF6, 0x7A, 0x6E, 0xF0,
  0xC0, 0x2A, 0x49, 0x00, 0x04, 0x92, 0x80, 0xE8, 0x52, 0x00, 0xC0, 0xC0,
  0x80, 0x12, 0x24, 0x48, 0xFE, 0xE0, 0xD6, 0x32, 0x4C, 0x32, 0x26, 0x26,
  0xE2, 0x66, 0x26, 0x5A, 0xE0, 0x6A, 0x40, 0xFA, 0xE0, 0xF5, 0xE0, 0x48,
  0x4A, 0x51, 0x00, 0x76, 0x66, 0x80, 0x28, 0x40, 0x7B, 0xDA, 0x60, 0x2D,
  0xD0, 0x76, 0x9E, 0xF2, 0x40, 0x75, 0x9E, 0x66, 0x4C, 0x64, 0x48, 0xD2,
  0xE0, 0x57, 0x9A, 0x22, 0x44, 0x11, 0x26, 0x74, 0xAA, 0x49, 0x60, 0x57,
  0x9A, 0x55, 0xAA, 0xF6, 0xE0, 0x75, 0x68, 0xF6, 0xE8, 0x75, 0xAA, 0x64,
  0x26, 0x4A, 0x40, 0xB6, 0xE0, 0xB7, 0x40, 0x57, 0x6A, 0x52, 0x6A, 0xB9,
  0x40, 0x32, 0x4C, 0x6A, 0x49, 0x00, 0x7C, 0x24, 0x94, 0x80, 0x54, 0xC0,
  0x80, 0x7A, 0xE0, 0x46, 0x55, 0xE0, 0x68, 0x60, 0x2E, 0xEC, 0x76, 0x60,
  0x32, 0x24, 0x44, 0x79, 0x66, 0x49, 0xDA, 0x46, 0x80, 0x02, 0x02, 0x26,
  0x04, 0x64, 0xA0, 0xD6, 0x80, 0x79, 0xA0, 0x6E, 0x80, 0xF7, 0x00, 0x75,
  0xE8, 0xFB, 0x20, 0xD2, 0x00, 0xC9, 0x00, 0x52, 0x60, 0xBB, 0x00, 0xBA,
  0x00, 0xBB, 0x00, 0x66, 0xA0, 0x56, 0x64, 0x24, 0xC0, 0x6A, 0x49, 0x00,
  0x56, 0xA0, 0x64, 0x94, 0x80, 0xC0,
};

const GFXglyph UbuntuMono_Italic7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 2, 4, 4, 1, -4 },
  { 2, 2, 2, 4, 2, -5 },
  { 3, 4, 4, 4, 0, -4 },
  { 5, 4, 6, 4, 0, -5 },
  { 8, 4, 4, 4, 0, -4 },
  { 10, 3, 4, 4, 0, -4 },
  { 12, 1, 2, 4, 2, -5 },
  { 13, 3, 6, 4, 1, -5 },
  { 16, 3, 6, 4, 0, -5 },
  { 19, 3, 2, 4, 1, -4 },
  { 20, 3, 3, 4, 1, -3 },
  { 22, 1, 2, 4, 1, -1 },
  { 23, 2, 1, 4, 1, -2 },
  { 24, 1, 1, 4, 1, -1 },
  { 25, 4, 6, 4, 0, -5 },
  { 28, 3, 4, 4, 1, -4 },
  { 30, 2, 4, 4, 1, -4 },
  { 31, 4, 4, 4, 0, -4 },
  { 33, 4, 4, 4, 0, -4 },
  { 35, 4, 4, 4, 0, -4 },
  { 37, 4, 4, 4, 0, -4 },
  { 39, 3, 4, 4, 1, -4 },
  { 41, 3, 4, 4, 1, -4 },
  { 43, 3, 4, 4, 1, -4 },
  { 45, 3, 4, 4, 1, -4 },
  { 47, 2, 3, 4, 1, -3 },
  { 48, 2, 4, 4, 1, -3 },
  { 49, 3, 3, 4, 1, -3 },
  { 51, 4, 2, 4, 0, -3 },
  { 52, 4, 3, 4, 0, -3 },
  { 54, 3, 4, 4, 1, -4 },
  { 56, 4, 5, 4, 0, -4 },
  { 59, 3, 4, 4, 0, -4 },
  { 61, 4, 4, 4, 0, -4 },
  { 63, 3, 4, 4, 1, -4 },
  { 65, 4, 4, 4, 0, -4 },
  { 67, 4, 4, 4, 0, -4 },
  { 69, 4, 4, 4, 0, -4 },
  { 71, 3, 4, 4, 1, -4 },
  { 73, 4, 4, 4, 0, -4 },
  { 75, 4, 4, 4, 0, -4 },
  { 77, 4, 4, 4, 0, -4 },
  { 79, 4, 4, 4, 0, -4 },
  { 81, 3, 4, 4, 0, -4 },
  { 83, 4, 4, 4, 0, -4 },
  { 85, 4, 4, 4, 0, -4 },
  { 87, 3, 4, 4, 1, -4 },
  { 89, 4, 4, 4, 0, -4 },
  { 91, 3, 5, 4, 1, -4 },
  { 93, 4, 4, 4, 0, -4 },
  { 95, 4, 4, 4, 0, -4 },
  { 97, 3, 4, 4, 1, -4 },
  { 99, 3, 4, 4, 1, -4 },
  { 101, 3, 4, 4, 1, -4 },
  { 103, 4, 4, 4, 0, -4 },
  { 105, 4, 4, 4, 0, -4 },
  { 107, 3, 4, 4, 1, -4 },
  { 109, 4, 4, 4, 0, -4 },
  { 111, 3, 6, 4, 1, -5 },
  { 114, 1, 6, 4, 2, -5 },
  { 115, 3, 6, 4, 0, -5 },
  { 118, 3, 2, 4, 1, -4 },
  { 119, 3, 1, 4, 0, 0 },
  { 120, 1, 1, 4, 2, -5 },
  { 121, 4, 3, 4, 0, -3 },
  { 123, 4, 5, 4, 0, -5 },
  { 126, 4, 3, 4, 0, -3 },
  { 128, 3, 5, 4, 1, -5 },
  { 130, 4, 3, 4, 0, -3 },
  { 132, 4, 6, 4, 0, -5 },
  { 135, 4, 4, 4, 0, -3 },
  { 137, 3, 5, 4, 0, -5 },
  { 139, 2, 5, 4, 1, -5 },
  { 141, 4, 6, 4, 0, -5 },
  { 144, 4, 5, 4, 0, -5 },
  { 147, 2, 5, 4, 1, -5 },
  { 149, 4, 3, 4, 0, -3 },
  { 151, 3, 3, 4, 0, -3 },
  { 153, 3, 3, 4, 1, -3 },
  { 155, 4, 4, 4, 0, -3 },
  { 157, 3, 4, 4, 1, -3 },
  { 159, 3, 3, 4, 1, -3 },
  { 161, 3, 3, 4, 1, -3 },
  { 163, 3, 4, 4, 1, -4 },
  { 165, 3, 3, 4, 1, -3 },
  { 167, 3, 3, 4, 1, -3 },
  { 169, 3, 3, 4, 1, -3 },
  { 171, 4, 3, 4, 0, -3 },
  { 173, 4, 4, 4, 0, -3 },
  { 175, 4, 3, 4, 0, -3 },
  { 177, 3, 6, 4, 1, -5 },
  { 180, 2, 6, 4, 1, -5 },
  { 182, 3, 6, 4, 0, -5 },
  { 185, 3, 1, 4, 1, -2 },
};

const GFXfont UbuntuMono_Italic7pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Italic7pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Italic7pt7bGlyphs,
  0x20, 0x7E, 7
};

#endif // _UBUNTUMONO_ITALIC7PT7B_H_
