#ifndef _UBUNTUMONO_ITALIC62PT7B_H_
#define _UBUNTUMONO_ITALIC62PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Italic.ttf
// Size: 62pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Italic62pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x3F,
  0x00, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0x00,
  0x00, 0x3E, 0x0F, 0x9F, 0x07, 0xCF, 0x83, 0xE7, 0x81, 0xE7, 0xC1, 0xF3,
  0xE0, 0xF9, 0xE0, 0x7C, 0xF0, 0x3C, 0x78, 0x1E, 0x78, 0x0F, 0x3C, 0x0F,
  0x1E, 0x07, 0x8E, 0x03, 0xC7, 0x01, 0xC3, 0x80, 0xE0, 0x00, 0x00, 0x78,
  0x0F, 0x80, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x1E,
  0x03, 0xE0, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0xF0, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x03,
  0xE0, 0x7C, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x78, 0x0F, 0x80, 0x00,
  0x7C, 0x07, 0x80, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0x3E, 0x03, 0xE0, 0x00,
  0x1F, 0x03, 0xE0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0xF0, 0x00,
  0x07, 0x80, 0xF8, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x03, 0xC0, 0x7C, 0x00,
  0x3F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x0F, 0x80, 0x00, 0x7C, 0x07, 0x80,
  0x00, 0x3C, 0x07, 0xC0, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x1F, 0x03, 0xE0,
  0x00, 0x1F, 0x01, 0xF0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x07, 0x80, 0xF8,
  0x00, 0x07, 0xC0, 0x78, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x1F,
  0xC0, 0x3C, 0x01, 0xF8, 0x00, 0x40, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x03, 0x00, 0x07, 0xF0,
  0x1F, 0x00, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x78, 0x00, 0xFF, 0x00, 0x07, 0x80, 0x1F, 0xF8, 0x00, 0x78, 0x00, 0xFF,
  0xE0, 0x07, 0x80, 0x0F, 0x8F, 0x00, 0x7C, 0x00, 0x78, 0x78, 0x07, 0xC0,
  0x07, 0x83, 0xC0, 0x7C, 0x00, 0x3C, 0x1E, 0x03, 0xC0, 0x01, 0xC0, 0xF0,
  0x3C, 0x00, 0x1E, 0x07, 0x83, 0xC0, 0x00, 0xF0, 0x3C, 0x3C, 0x00, 0x07,
  0x81, 0xE3, 0xE0, 0x00, 0x3C, 0x1E, 0x3E, 0x00, 0x01, 0xE1, 0xF3, 0xE0,
  0x00, 0x0F, 0x8F, 0x1E, 0x00, 0x00, 0x3F, 0xF9, 0xE0, 0x00, 0x01, 0xFF,
  0x9E, 0x00, 0x00, 0x07, 0xF9, 0xE0, 0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00,
  0x00, 0x01, 0xF1, 0xF0, 0x00, 0x00, 0x1F, 0x3F, 0xC0, 0x00, 0x01, 0xF3,
  0xFF, 0x00, 0x00, 0x0F, 0x3F, 0xF8, 0x00, 0x00, 0xF3, 0xE3, 0xC0, 0x00,
  0x0F, 0x1E, 0x0F, 0x00, 0x00, 0xF8, 0xF0, 0x78, 0x00, 0x0F, 0x8F, 0x03,
  0xC0, 0x00, 0xF8, 0x78, 0x1E, 0x00, 0x0F, 0x83, 0xC0, 0xE0, 0x00, 0x78,
  0x1C, 0x0F, 0x00, 0x07, 0x80, 0xE0, 0x78, 0x00, 0x78, 0x07, 0x03, 0xC0,
  0x07, 0xC0, 0x3C, 0x3C, 0x00, 0x7C, 0x01, 0xE3, 0xE0, 0x07, 0xC0, 0x0F,
  0xFE, 0x00, 0x7C, 0x00, 0x7F, 0xE0, 0x03, 0xC0, 0x01, 0xFE, 0x00, 0x3C,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x01,
  0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x3E, 0x03, 0xE0,
  0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x7C, 0x07,
  0xC0, 0x1E, 0x01, 0xF0, 0x07, 0x80, 0xF8, 0x01, 0xF0, 0x7E, 0x00, 0x7C,
  0x3F, 0x00, 0x1F, 0x1F, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x3C, 0x0F, 0xF8, 0x0F, 0x0F, 0xFF, 0x07,
  0xC7, 0xE7, 0xC1, 0xE3, 0xF0, 0xF8, 0xF8, 0xF8, 0x3F, 0x3E, 0x7C, 0x07,
  0xCF, 0x1F, 0x00, 0xFF, 0xCF, 0x80, 0x3F, 0xE3, 0xE0, 0x07, 0xF8, 0xF8,
  0x01, 0xFC, 0x3E, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0xC3, 0xE0, 0x07, 0xF0,
  0xFC, 0x03, 0xFE, 0x3F, 0x83, 0xFF, 0x87, 0xFF, 0xFB, 0xE1, 0xFF, 0xFC,
  0xFC, 0x1F, 0xFC, 0x1F, 0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x3E, 0x3E, 0x3E,
  0x7E, 0x7C, 0x7C, 0x7C, 0x7C, 0x78, 0xF8, 0xF8, 0xF0, 0xF0, 0xF0, 0xE0,
  0xE0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x10, 0x1F, 0x01, 0x3C, 0x1C, 0x1E,
  0xFE, 0x38, 0xFF, 0xFF, 0x77, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xE0,
  0x1F, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7B, 0xC0, 0x01, 0xF7, 0xC0, 0x07,
  0xEF, 0xC0, 0x1F, 0x8F, 0xC0, 0x3F, 0x1F, 0x80, 0xFC, 0x1F, 0x81, 0xF8,
  0x3F, 0x00, 0xE0, 0x38, 0x00, 0x80, 0x20, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x3F,
  0x83, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE0, 0x7F, 0x01, 0xF0,
  0x1F, 0x81, 0xF8, 0x7F, 0x8F, 0xF8, 0x7F, 0x03, 0xF0, 0x1C, 0x00, 0x7F,
  0xFE, 0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF, 0xC0, 0x3E, 0x3F, 0xBF,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFC, 0x78, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0xE0,
  0x0F, 0xE0, 0xFC, 0x03, 0xF8, 0x0F, 0xC0, 0x7E, 0x00, 0xF8, 0x1F, 0x80,
  0x1F, 0x07, 0xE0, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x3F, 0x00, 0x0F, 0x87,
  0xC0, 0x01, 0xF1, 0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x07, 0xCF, 0xC0, 0x00,
  0xF9, 0xF0, 0x78, 0x1F, 0x3E, 0x1F, 0x83, 0xE7, 0xC3, 0xF8, 0x7D, 0xF0,
  0xFF, 0x1F, 0xBE, 0x1F, 0xE3, 0xE7, 0xC3, 0xF8, 0x7C, 0xF8, 0x3F, 0x0F,
  0x9F, 0x03, 0x83, 0xF7, 0xE0, 0x00, 0x7C, 0xFC, 0x00, 0x0F, 0x9F, 0x00,
  0x03, 0xE3, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE1,
  0xF8, 0x00, 0xF8, 0x3F, 0x00, 0x3F, 0x03, 0xE0, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x0F, 0xE1, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xE0,
  0x07, 0xFF, 0x80, 0x7F, 0xFE, 0x07, 0xFD, 0xF0, 0x0F, 0xC7, 0xC0, 0x3C,
  0x1F, 0x00, 0xC0, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF0, 0x07, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x0F, 0x00,
  0x3F, 0x00, 0xE0, 0x01, 0xF0, 0x04, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x7C, 0x0F, 0xE0, 0x06,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x60, 0x00, 0xFE,
  0x07, 0x80, 0x3F, 0xC0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0x7C, 0x00,
  0x03, 0xF3, 0xE0, 0x00, 0x3F, 0x3E, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x3F,
  0x0F, 0x80, 0x03, 0xF0, 0x7C, 0x00, 0x3F, 0x07, 0xC0, 0x03, 0xF0, 0x3E,
  0x00, 0x1F, 0x01, 0xF0, 0x01, 0xF0, 0x0F, 0x80, 0x1F, 0x00, 0xF8, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x0F, 0x80,
  0x1F, 0x00, 0xF8, 0x00, 0xF8, 0x07, 0xC0, 0x07, 0xC0, 0x7F, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x20, 0x00, 0x7F, 0x00, 0x78, 0x07, 0xFC, 0x01,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x1F, 0xE0, 0x03, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0x80, 0x7F, 0x07, 0xE0,
  0x03, 0xF0, 0x7C, 0x00, 0x1F, 0x0F, 0xC0, 0x01, 0xF8, 0xF8, 0x00, 0x0F,
  0x8F, 0x80, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF8, 0xF8,
  0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x03,
  0xE0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xC0, 0x7E, 0x01, 0xFC, 0x07,
  0xF0, 0x3F, 0x80, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0xFE, 0x07, 0xF0,
  0x1F, 0x80, 0x3F, 0x01, 0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x03, 0xE0,
  0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x1F,
  0x07, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0x7E, 0x03, 0xE0, 0x0F, 0xC0, 0x3F,
  0x81, 0xF8, 0x01, 0xFC, 0x3F, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0x80, 0x07, 0xF3, 0xFC, 0x00, 0xFC, 0x0F, 0xE0, 0x1F,
  0x00, 0x7F, 0x03, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x87, 0xC0, 0x01,
  0xF8, 0xFC, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0xF8, 0xF8, 0x00, 0x1F, 0x8F,
  0x80, 0x01, 0xF0, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00,
  0xFE, 0x07, 0xF0, 0x3F, 0xC0, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x01, 0xFC, 0x0F,
  0xE0, 0x3F, 0x80, 0x7E, 0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x07,
  0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00,
  0x1F, 0x0F, 0x80, 0x01, 0xF1, 0xF8, 0x00, 0x1F, 0x1F, 0x80, 0x01, 0xF1,
  0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x3E, 0x0F, 0xE0,
  0x1F, 0xE0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0x7C,
  0x00, 0x7F, 0x8F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x0F, 0xE0,
  0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xE0, 0x7F, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x01, 0xFC, 0x0F, 0xF8,
  0x3F, 0xE0, 0xFF, 0x83, 0xFC, 0x0F, 0xF0, 0x0F, 0x00, 0x00, 0x1F, 0x00,
  0x0F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x07,
  0xF0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x01, 0xFC, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xE0,
  0x01, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x3F,
  0x80, 0x0F, 0xC0, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFE, 0x00,
  0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0x80,
  0x07, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x08, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xFE, 0x00, 0x02, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x1F, 0xFF, 0x80, 0xFF, 0xFF, 0x01,
  0xFF, 0xFE, 0x07, 0x01, 0xFC, 0x10, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0x80,
  0x3F, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x3E, 0x07,
  0xC0, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x01, 0xE0, 0xF8,
  0x01, 0xFF, 0xC1, 0xF0, 0x0F, 0xFF, 0x87, 0xC0, 0x7F, 0xFF, 0x0F, 0x81,
  0xFF, 0xFE, 0x1F, 0x07, 0xF0, 0xF8, 0x7C, 0x1F, 0x81, 0xF0, 0xF8, 0x3E,
  0x03, 0xE1, 0xF0, 0xF8, 0x07, 0xC7, 0xC1, 0xF0, 0x0F, 0x0F, 0x87, 0xC0,
  0x3E, 0x1F, 0x0F, 0x80, 0x7C, 0x3E, 0x1F, 0x00, 0xF8, 0x78, 0x3C, 0x01,
  0xE1, 0xF0, 0x78, 0x07, 0xC3, 0xE0, 0xF0, 0x0F, 0x87, 0xC1, 0xE0, 0x1F,
  0x0F, 0x83, 0xE0, 0x3C, 0x1F, 0x07, 0xC0, 0xF8, 0x3E, 0x0F, 0x81, 0xF0,
  0x7C, 0x0F, 0xC3, 0xE0, 0xF8, 0x1F, 0xFF, 0xC0, 0xF0, 0x1F, 0xFF, 0x01,
  0xF0, 0x1F, 0xFE, 0x03, 0xE0, 0x0F, 0xF0, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xF7, 0xC0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00, 0xF8,
  0xF0, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0xF8, 0x3E,
  0x00, 0x03, 0xC0, 0xF8, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x78, 0x0F, 0x80,
  0x03, 0xE0, 0x3E, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x7C, 0x03, 0xE0, 0x03,
  0xE0, 0x0F, 0x80, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x01, 0xE0, 0x0F, 0x80, 0x07, 0x80, 0x3C, 0x00, 0x1E, 0x01, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0x07, 0xC0, 0x00, 0x7C, 0x1E, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x07, 0xC3,
  0xC0, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x01, 0xF3, 0xE0,
  0x00, 0x07, 0xDF, 0x80, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0x80, 0x7F, 0x80, 0xFC, 0x00, 0xFC,
  0x07, 0xC0, 0x03, 0xE0, 0x3E, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0xF8, 0x1F,
  0x80, 0x07, 0xC0, 0xF8, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF0, 0x3E, 0x00,
  0x1F, 0x03, 0xF0, 0x01, 0xF8, 0x1F, 0x00, 0x1F, 0x80, 0xF8, 0x07, 0xF8,
  0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0x00, 0xF8, 0x03, 0xFC, 0x07, 0xC0, 0x07, 0xE0, 0x7C, 0x00,
  0x1F, 0x83, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1F,
  0x0F, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7E, 0x1F,
  0x00, 0x03, 0xE0, 0xF0, 0x00, 0x3F, 0x0F, 0x80, 0x03, 0xF0, 0x7C, 0x00,
  0x3F, 0x83, 0xE0, 0x0F, 0xF8, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00,
  0xFF, 0x00, 0xF0, 0x07, 0xF0, 0x00, 0xC0, 0x3F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x08, 0x00,
  0xFE, 0x01, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xF8,
  0x0F, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x7C, 0x00,
  0x3E, 0x01, 0xF0, 0x00, 0xFC, 0x07, 0xC0, 0x01, 0xF0, 0x1F, 0x00, 0x07,
  0xC0, 0xFC, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x01, 0xF0,
  0x3E, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x1F,
  0x00, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x0F, 0x80,
  0x00, 0xFC, 0x3E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x00,
  0x7E, 0x1F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3F,
  0x07, 0xC0, 0x01, 0xF8, 0x3E, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x3F, 0x03,
  0xE0, 0x01, 0xF8, 0x0F, 0x80, 0x1F, 0xC0, 0x7C, 0x00, 0xFE, 0x01, 0xF0,
  0x1F, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xF0, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0x80, 0xF0, 0x03, 0xF0, 0x00,
  0xC0, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x3E,
  0x0F, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x83,
  0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0xFC,
  0x00, 0x1F, 0x03, 0xF0, 0x00, 0xF8, 0x07, 0xC0, 0x03, 0xE0, 0x1F, 0x80,
  0x0F, 0x80, 0x3F, 0x00, 0x3E, 0x00, 0xFF, 0x01, 0xF0, 0x01, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x03, 0xE0, 0x07, 0xC0,
  0x00, 0xF8, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x3E,
  0x00, 0x07, 0xC0, 0x0F, 0x80, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x7C, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x03, 0xE0,
  0x07, 0xC0, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x1F,
  0x80, 0x3E, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x01, 0xF0, 0x07, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xE0, 0x0F, 0x80, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x1F, 0x80, 0x01, 0xF0, 0x07,
  0xC0, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x1F, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x01,
  0xF0, 0x07, 0xC0, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x08, 0x00, 0x3F, 0x00, 0x38, 0x01, 0xF8, 0x01, 0xF8, 0x1F,
  0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x3E, 0x00,
  0x1F, 0x80, 0x3E, 0x00, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x80,
  0x1F, 0x80, 0x07, 0xC0, 0x1F, 0x80, 0x07, 0xE0, 0x1F, 0x80, 0x03, 0xE0,
  0x1F, 0x80, 0x01, 0xF0, 0x1F, 0x80, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0xFC,
  0x1F, 0x80, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x1F,
  0x1F, 0x80, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x07,
  0xDF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x00,
  0x3E, 0x3F, 0x00, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x1F, 0x07, 0xE0, 0x00,
  0x0F, 0x81, 0xF8, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x07, 0xC0, 0x3F, 0x00,
  0x03, 0xE0, 0x0F, 0xC0, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0xF8, 0x01, 0xF8,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x1F, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x03, 0xF0, 0x0F, 0x80, 0x00,
  0xF8, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x0F, 0xE0, 0x0F, 0xE0, 0x03, 0xF8,
  0x07, 0xF8, 0x01, 0xEE, 0x01, 0xDE, 0x00, 0x7B, 0x80, 0xF7, 0x80, 0x1E,
  0xF0, 0x3B, 0xC0, 0x0F, 0x3C, 0x1E, 0xF0, 0x03, 0xCF, 0x07, 0x3C, 0x00,
  0xF3, 0xC3, 0xCF, 0x00, 0x7C, 0xF1, 0xE3, 0xC0, 0x1E, 0x3C, 0x79, 0xF0,
  0x07, 0x8F, 0x3C, 0x78, 0x03, 0xE3, 0xCF, 0x1E, 0x00, 0xF0, 0xF7, 0x87,
  0x80, 0x3C, 0x1D, 0xC1, 0xE0, 0x1F, 0x07, 0xF0, 0xF8, 0x07, 0xC1, 0xF8,
  0x3E, 0x01, 0xE0, 0x7E, 0x0F, 0x00, 0x78, 0x1F, 0x03, 0xC0, 0x3E, 0x07,
  0xC1, 0xF0, 0x0F, 0x80, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x1F, 0x01, 0xF0,
  0x00, 0x07, 0x80, 0x7C, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0xF8, 0x0F,
  0x80, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x03, 0xC0,
  0x3C, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x1F,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x1F, 0x80, 0x01, 0xF0, 0x07,
  0xE0, 0x00, 0x78, 0x01, 0xFC, 0x00, 0x3E, 0x00, 0x7F, 0x00, 0x0F, 0x80,
  0x3F, 0xC0, 0x03, 0xE0, 0x0F, 0xF8, 0x00, 0xF0, 0x03, 0xDE, 0x00, 0x7C,
  0x00, 0xF7, 0x80, 0x1F, 0x00, 0x7D, 0xF0, 0x07, 0xC0, 0x1F, 0x7C, 0x01,
  0xE0, 0x07, 0x8F, 0x00, 0xF8, 0x01, 0xE3, 0xC0, 0x3E, 0x00, 0xF8, 0xF8,
  0x0F, 0x80, 0x3E, 0x1E, 0x03, 0xC0, 0x0F, 0x87, 0x80, 0xF0, 0x03, 0xC1,
  0xE0, 0x7C, 0x01, 0xF0, 0x7C, 0x1F, 0x00, 0x7C, 0x0F, 0x07, 0x80, 0x1F,
  0x03, 0xC1, 0xE0, 0x07, 0x80, 0xF0, 0xF8, 0x03, 0xE0, 0x3E, 0x3E, 0x00,
  0xF8, 0x07, 0x8F, 0x00, 0x3E, 0x01, 0xE3, 0xC0, 0x0F, 0x00, 0x79, 0xF0,
  0x03, 0xC0, 0x1E, 0x7C, 0x01, 0xF0, 0x07, 0xDE, 0x00, 0x7C, 0x00, 0xF7,
  0x80, 0x1E, 0x00, 0x3F, 0xE0, 0x07, 0x80, 0x0F, 0xF8, 0x03, 0xE0, 0x03,
  0xFC, 0x00, 0xF8, 0x00, 0xFF, 0x00, 0x3C, 0x00, 0x1F, 0xC0, 0x0F, 0x00,
  0x07, 0xF0, 0x07, 0xC0, 0x01, 0xFC, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x78,
  0x00, 0x1F, 0x80, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x0F,
  0xE0, 0xFE, 0x00, 0xFC, 0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0x7C, 0x00,
  0x3E, 0x07, 0xC0, 0x01, 0xF0, 0x7E, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7E,
  0x3F, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0xF8, 0xF8,
  0x00, 0x07, 0xC7, 0xC0, 0x00, 0x3E, 0x7E, 0x00, 0x01, 0xF3, 0xE0, 0x00,
  0x0F, 0x9F, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x3E,
  0x7C, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0xF8, 0xF8,
  0x00, 0x07, 0xC7, 0xC0, 0x00, 0x7E, 0x3E, 0x00, 0x03, 0xE1, 0xF0, 0x00,
  0x3F, 0x0F, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x83, 0xF0, 0x01, 0xF8,
  0x0F, 0x80, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x03, 0xF8, 0x3F, 0x80, 0x0F,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xC0, 0x3F, 0x80, 0x1F, 0x00,
  0x3F, 0x80, 0x3E, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x3E, 0x01, 0xF8, 0x00,
  0x7E, 0x03, 0xE0, 0x00, 0xFC, 0x07, 0xC0, 0x01, 0xF0, 0x0F, 0x80, 0x03,
  0xE0, 0x1F, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x3F,
  0x01, 0xF0, 0x00, 0x7C, 0x03, 0xE0, 0x01, 0xF8, 0x0F, 0x80, 0x07, 0xE0,
  0x1F, 0x00, 0x1F, 0x80, 0x3E, 0x01, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xE0, 0xFE,
  0x00, 0xFC, 0x01, 0xF0, 0x0F, 0xC0, 0x0F, 0xC0, 0x7C, 0x00, 0x3E, 0x07,
  0xC0, 0x01, 0xF0, 0x7E, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7E, 0x3F, 0x00,
  0x03, 0xF1, 0xF0, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0xF8, 0xF8, 0x00, 0x07,
  0xC7, 0xC0, 0x00, 0x3E, 0x7E, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x0F, 0x9F,
  0x00, 0x00, 0x7C, 0xF8, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x3E, 0x7C, 0x00,
  0x01, 0xF3, 0xE0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x07,
  0xC7, 0xC0, 0x00, 0x7E, 0x3E, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x3F, 0x0F,
  0x80, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x83, 0xF0, 0x01, 0xF8, 0x0F, 0x80,
  0x1F, 0x80, 0x7E, 0x01, 0xFC, 0x03, 0xF8, 0x3F, 0xC0, 0x0F, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0xF8, 0x07, 0xF8, 0x03, 0xE0, 0x07, 0xE0, 0x1F,
  0x00, 0x0F, 0x80, 0x7C, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x7C, 0x07, 0xC0,
  0x01, 0xF0, 0x3F, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x03, 0xE0, 0x00,
  0xF8, 0x0F, 0x80, 0x03, 0xE0, 0x7E, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x7C,
  0x07, 0xC0, 0x03, 0xF0, 0x1F, 0x00, 0x3F, 0x80, 0x7C, 0x03, 0xFC, 0x03,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x7C, 0x03,
  0xE0, 0x01, 0xF0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x00, 0xF8, 0x03, 0xE0, 0x03, 0xE0, 0x1F, 0x00, 0x0F, 0x80,
  0x7C, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x7C, 0x07, 0xC0, 0x01, 0xF0, 0x3E,
  0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xE0, 0x07, 0xF8, 0x07, 0x80, 0x0F, 0xC0, 0x01, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x30, 0x00, 0x3F, 0x00, 0x7C, 0x01, 0xFE, 0x01, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0xF8,
  0x0F, 0x80, 0x01, 0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0xC0,
  0xF8, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x7C, 0x0F,
  0x80, 0x01, 0xF8, 0x1F, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x07, 0xC0, 0x7C,
  0x00, 0x0F, 0x81, 0xF0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x7C, 0x07, 0xC0,
  0x00, 0xF8, 0x0F, 0x80, 0x01, 0xF0, 0x3E, 0x00, 0x03, 0xE0, 0x7C, 0x00,
  0x0F, 0x80, 0xF8, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x00,
  0x7C, 0x0F, 0x80, 0x01, 0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x07,
  0xC0, 0xF8, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x7C,
  0x07, 0xC0, 0x00, 0xF8, 0x0F, 0x80, 0x03, 0xE0, 0x1F, 0x00, 0x07, 0xC0,
  0x3E, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFC, 0x00,
  0xFE, 0x07, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x7C, 0x7C,
  0x00, 0x03, 0xF1, 0xF0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x7E, 0x1F, 0x00,
  0x01, 0xF0, 0x7C, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x01,
  0xF8, 0x1F, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0xF8,
  0x07, 0xC0, 0x07, 0xE0, 0x1F, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x7C,
  0x03, 0xE0, 0x01, 0xF0, 0x0F, 0x80, 0x07, 0xC0, 0x7C, 0x00, 0x0F, 0x01,
  0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x03, 0xE1, 0xF0,
  0x00, 0x0F, 0x8F, 0x80, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0xF9, 0xF0, 0x00,
  0x03, 0xE7, 0xC0, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x81,
  0xF0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x03, 0xE0,
  0x7C, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x78,
  0x0F, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x1E,
  0x03, 0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x07,
  0xC0, 0xF8, 0x00, 0x03, 0xC0, 0x7C, 0x1F, 0x03, 0xE0, 0x3E, 0x0F, 0x81,
  0xF0, 0x1E, 0x0F, 0xC0, 0xF0, 0x0F, 0x07, 0xE0, 0x78, 0x07, 0x87, 0xF0,
  0x7C, 0x07, 0xC3, 0xFC, 0x3C, 0x03, 0xC3, 0xDE, 0x1E, 0x01, 0xE1, 0xCF,
  0x1F, 0x00, 0xF1, 0xE7, 0x8F, 0x00, 0x79, 0xE3, 0xC7, 0x80, 0x7C, 0xF1,
  0xE3, 0xC0, 0x3C, 0xF0, 0xF3, 0xC0, 0x1E, 0x78, 0x39, 0xE0, 0x0F, 0x78,
  0x1C, 0xF0, 0x07, 0xBC, 0x0E, 0x70, 0x03, 0xBC, 0x07, 0x78, 0x01, 0xDE,
  0x03, 0xFC, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F,
  0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x0F, 0x80,
  0x00, 0x3F, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00,
  0x07, 0xE7, 0xC0, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0x78, 0x00, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x00,
  0x1F, 0x9F, 0x00, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x00, 0x1F, 0x83, 0xE0,
  0x00, 0x01, 0xF8, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x00, 0xFC,
  0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x0F, 0xE0, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x7E,
  0x00, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0x3F, 0x1F, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x07, 0xE1, 0xF0,
  0x00, 0x3F, 0x07, 0xC0, 0x00, 0xF8, 0x1F, 0x00, 0x07, 0xE0, 0x3E, 0x00,
  0x3F, 0x00, 0xF8, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3F,
  0x00, 0x1F, 0x00, 0xF8, 0x00, 0x7C, 0x07, 0xC0, 0x01, 0xF0, 0x3E, 0x00,
  0x03, 0xE1, 0xF8, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x3E, 0x3E, 0x00, 0x00,
  0x79, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xF8, 0x7C,
  0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3F, 0x1F, 0x87,
  0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF8,
  0xFC, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x0F, 0xC7, 0xE3, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1,
  0xF0, 0xF8, 0x7C, 0x3F, 0x1F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x00, 0x0F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0xC0, 0x01, 0xFB, 0xE0, 0x00, 0xF8, 0xF0, 0x00, 0xF8,
  0x7C, 0x00, 0xFC, 0x3E, 0x00, 0xFC, 0x1F, 0x00, 0xFC, 0x07, 0xC0, 0x7C,
  0x03, 0xE0, 0x7C, 0x01, 0xF0, 0x7E, 0x00, 0x7C, 0x7E, 0x00, 0x3E, 0x7E,
  0x00, 0x1F, 0x3E, 0x00, 0x07, 0xBF, 0x00, 0x03, 0xEF, 0x00, 0x01, 0xE1,
  0x00, 0x00, 0x40, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xE0, 0x10, 0x07, 0x01, 0xF0, 0x3F, 0x03,
  0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x38, 0x02, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE,
  0x01, 0xFF, 0x03, 0xE0, 0x3F, 0xC0, 0x3E, 0x07, 0xF0, 0x03, 0xE0, 0xFE,
  0x00, 0x7C, 0x0F, 0xC0, 0x07, 0xC1, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x07,
  0xC3, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0xF8, 0x7C,
  0x00, 0x0F, 0x87, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x01,
  0xF0, 0xFC, 0x00, 0x1F, 0x0F, 0xC0, 0x01, 0xF0, 0xFC, 0x00, 0x3E, 0x0F,
  0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00,
  0x7E, 0x07, 0xE0, 0x0F, 0xE0, 0x3F, 0x03, 0xFE, 0x03, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xF1, 0xF0, 0x03, 0xFC, 0x1E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE7, 0xF0, 0x00, 0x7B,
  0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0x03, 0xF8,
  0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x03, 0xF0, 0x7C, 0x00, 0x3E, 0x0F, 0x80,
  0x07, 0xC1, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE1,
  0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF1, 0xF0, 0x00,
  0x3E, 0x3E, 0x00, 0x0F, 0xC7, 0xC0, 0x01, 0xF0, 0xF0, 0x00, 0x3E, 0x3E,
  0x00, 0x0F, 0xC7, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x7E, 0x1F, 0x00, 0x1F,
  0x87, 0xC0, 0x07, 0xE0, 0xF8, 0x01, 0xFC, 0x1F, 0x00, 0xFF, 0x03, 0xE0,
  0x7F, 0xC0, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0x00, 0xC0, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x20, 0x3F,
  0xC0, 0x1E, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x03,
  0xFE, 0x17, 0xC0, 0x0F, 0xE0, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0xFC,
  0x00, 0x7C, 0x03, 0xF0, 0x00, 0xF8, 0x07, 0xC0, 0x03, 0xE0, 0x1F, 0x80,
  0x07, 0xC0, 0x3E, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x1F, 0x01, 0xF0, 0x00,
  0x3C, 0x03, 0xE0, 0x00, 0xF8, 0x0F, 0xC0, 0x01, 0xF0, 0x1F, 0x00, 0x03,
  0xE0, 0x3E, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x3E,
  0x01, 0xF0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0xF8, 0x07, 0xC0, 0x01, 0xE0,
  0x0F, 0xC0, 0x03, 0xC0, 0x1F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x7F, 0x00,
  0x3F, 0x83, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x7C, 0x00,
  0x3F, 0xF8, 0xF8, 0x00, 0x1F, 0xC0, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x3F, 0xC0,
  0xFE, 0x07, 0xE0, 0x0F, 0xC1, 0xF8, 0x00, 0xF8, 0x7E, 0x00, 0x1F, 0x1F,
  0x80, 0x03, 0xE3, 0xE0, 0x00, 0x7C, 0xFC, 0x00, 0x1F, 0x9F, 0x00, 0x03,
  0xF3, 0xE0, 0x00, 0xFC, 0xF8, 0x00, 0x7F, 0x1F, 0x00, 0xFF, 0xC3, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x40,
  0xFF, 0x00, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x40, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xF0, 0x7E,
  0x00, 0x3F, 0x80, 0x3E, 0x00, 0x7F, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x7C,
  0x00, 0xFC, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x7C,
  0x03, 0xE0, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0xF8,
  0x07, 0xC0, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0xF8, 0x07, 0xC0, 0x01, 0xF0,
  0x0F, 0xC0, 0x01, 0xF0, 0x0F, 0xC0, 0x01, 0xF0, 0x0F, 0x80, 0x01, 0xF0,
  0x0F, 0x80, 0x03, 0xE0, 0x0F, 0xC0, 0x03, 0xE0, 0x07, 0xC0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0xC0, 0x03, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xCF, 0x80,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x20, 0x00, 0x7E, 0x00,
  0x7C, 0x03, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xEF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x1F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x7E, 0x03, 0xF8, 0x0F, 0x80, 0x3F,
  0x03, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x81, 0xF0,
  0x01, 0xF8, 0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x00, 0xF8,
  0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0xFC, 0x3E, 0x00,
  0x1F, 0x07, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x87,
  0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x01,
  0xF0, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x01, 0xF0, 0xF8,
  0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x01, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x0F, 0xC0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0,
  0x07, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFE, 0x1F, 0xFF, 0x07, 0xFF, 0xC3, 0xFF, 0xF0, 0x00, 0xFC,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFF, 0xF0,
  0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x80, 0x0F, 0xC0, 0x07,
  0xC0, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0xFC, 0x03, 0xE0, 0x07, 0xE0, 0x0F,
  0x80, 0x7F, 0x00, 0x3E, 0x03, 0xF8, 0x00, 0xF8, 0x1F, 0xC0, 0x07, 0xC0,
  0xFE, 0x00, 0x1F, 0x0F, 0xF0, 0x00, 0x7C, 0x7F, 0x00, 0x01, 0xF7, 0xF8,
  0x00, 0x0F, 0xBF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7D, 0xFC, 0x00, 0x01,
  0xF3, 0xF8, 0x00, 0x07, 0xC7, 0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xF8,
  0x1F, 0x80, 0x03, 0xE0, 0x3F, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x7E, 0x01,
  0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0xC0, 0x1F, 0x00, 0x1F,
  0x80, 0xFC, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0xFC, 0x0F, 0x80, 0x03, 0xF0,
  0x00, 0x7F, 0xFC, 0x7F, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0x00, 0xFC, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01,
  0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7E, 0x01, 0x3F, 0x07, 0x3F, 0xFF, 0x3F,
  0xFF, 0x1F, 0xFF, 0x07, 0xF8, 0x00, 0x3F, 0x83, 0xE0, 0x07, 0xFF, 0x3F,
  0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x03, 0xE1, 0xF8, 0x7C,
  0x0F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x03, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0x1E, 0x07, 0x81, 0xF0, 0xF8, 0x1E, 0x07, 0x83, 0xE0,
  0xF8, 0x1E, 0x0F, 0x83, 0xE0, 0xF8, 0x3C, 0x0F, 0x83, 0xE0, 0xF0, 0x3C,
  0x0F, 0x87, 0xC0, 0xF0, 0x3C, 0x1F, 0x07, 0xC1, 0xF0, 0x78, 0x1F, 0x07,
  0xC1, 0xE0, 0x7C, 0x1F, 0x0F, 0x80, 0x00, 0x78, 0x3E, 0x00, 0x01, 0xE0,
  0xF8, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0xF8, 0x7C,
  0x00, 0x03, 0xC1, 0xF0, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x7C, 0x1E, 0x00,
  0x01, 0xF0, 0xF8, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0,
  0x3E, 0x01, 0xFC, 0x07, 0xC0, 0x1F, 0x81, 0xF0, 0x01, 0xF0, 0x3E, 0x00,
  0x3F, 0x07, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x87,
  0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x01,
  0xF0, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x01, 0xF0, 0x7C,
  0x00, 0x3E, 0x1F, 0x00, 0x0F, 0xC3, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x3E,
  0x0F, 0x80, 0x07, 0xC3, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x0F, 0x80,
  0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x7E, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xE1,
  0xF0, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x0F,
  0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xF8, 0x3F, 0x81, 0xF8, 0x03, 0xE0,
  0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x1F, 0x00, 0x07, 0xCF, 0xC0, 0x01,
  0xF3, 0xE0, 0x00, 0x7D, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x07, 0xDF, 0x00,
  0x01, 0xF7, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFE,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x7E, 0xF8, 0x00, 0x1F,
  0x3E, 0x00, 0x0F, 0xCF, 0x80, 0x03, 0xE3, 0xE0, 0x01, 0xF8, 0xFC, 0x00,
  0xFC, 0x1F, 0x80, 0x7E, 0x07, 0xF0, 0x7F, 0x00, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x7E, 0x03, 0xF8, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0x80, 0x0F, 0xC0,
  0x3E, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x7C, 0x07, 0xE0, 0x01, 0xF0, 0x1F,
  0x00, 0x07, 0xC0, 0x7C, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x7C, 0x0F, 0xC0,
  0x01, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x03, 0xE0, 0x00,
  0xFC, 0x1F, 0x80, 0x03, 0xE0, 0x7E, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x7E,
  0x07, 0xC0, 0x01, 0xF0, 0x3F, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x7E, 0x03,
  0xE0, 0x03, 0xF0, 0x0F, 0x80, 0x1F, 0xC0, 0x3E, 0x00, 0xFE, 0x01, 0xF8,
  0x1F, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0x80, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x01, 0xFE, 0x03, 0xE0, 0x3F, 0x80, 0x7E,
  0x07, 0xE0, 0x07, 0xC0, 0xFC, 0x00, 0x7C, 0x1F, 0x80, 0x07, 0xC1, 0xF0,
  0x00, 0xFC, 0x3F, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0xF8, 0x7E, 0x00, 0x0F,
  0x87, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x0F, 0xC0, 0x01, 0xF0, 0xF8,
  0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x03,
  0xE0, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x0F,
  0xC0, 0x07, 0xC0, 0xFC, 0x00, 0x7C, 0x07, 0xE0, 0x0F, 0xC0, 0x7F, 0x03,
  0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xEF, 0x80,
  0x03, 0xF9, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE,
  0x03, 0xF8, 0x01, 0x81, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x03,
  0xFF, 0xFE, 0x01, 0xFC, 0x07, 0x80, 0xFC, 0x00, 0x40, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x08, 0x00,
  0x3F, 0x07, 0xC0, 0x3F, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xC0, 0xFC, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFE, 0x03, 0x00, 0xFF,
  0xFE, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xC0, 0x03, 0xE1, 0xF0, 0x00, 0xFC, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x03,
  0xE0, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xE0, 0xF8,
  0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x87, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x7E,
  0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x01, 0xF0, 0xFC, 0x00, 0x3E, 0x1F, 0x00,
  0x07, 0xC3, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xC3,
  0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x3F, 0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x00,
  0xF8, 0x3E, 0x00, 0x1F, 0x07, 0xE0, 0x07, 0xE0, 0x7C, 0x01, 0xFC, 0x0F,
  0xC0, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xE3,
  0xE0, 0x0F, 0xF0, 0x78, 0x00, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF,
  0x00, 0x07, 0xDF, 0x80, 0x03, 0xEF, 0xC0, 0x03, 0xE3, 0xE0, 0x01, 0xF1,
  0xF0, 0x01, 0xF8, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0xFC, 0x3E, 0x00, 0x7C,
  0x1F, 0x00, 0x7E, 0x0F, 0x80, 0x3E, 0x07, 0xC0, 0x3F, 0x03, 0xE0, 0x1F,
  0x01, 0xF8, 0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x1F, 0x07,
  0xC0, 0x0F, 0x87, 0xC0, 0x07, 0xC7, 0xE0, 0x03, 0xE3, 0xE0, 0x01, 0xF3,
  0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x78, 0xF8, 0x00, 0x01, 0xF1,
  0xE0, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x07, 0x8F, 0x80, 0x00, 0x1F, 0x1F,
  0x00, 0x00, 0x3E, 0x3E, 0x03, 0xC0, 0x78, 0x7C, 0x0F, 0x81, 0xF0, 0xF8,
  0x1F, 0x03, 0xE1, 0xF0, 0x7E, 0x07, 0x83, 0xC0, 0xFC, 0x1F, 0x07, 0x83,
  0xF8, 0x3C, 0x0F, 0x07, 0xF0, 0x78, 0x1E, 0x1E, 0xE1, 0xF0, 0x3C, 0x39,
  0xC3, 0xC0, 0xF8, 0xF3, 0xCF, 0x81, 0xF3, 0xC7, 0x9E, 0x03, 0xE7, 0x8F,
  0x3C, 0x07, 0xDE, 0x1E, 0xF8, 0x0F, 0xBC, 0x3D, 0xE0, 0x1E, 0xF0, 0x7F,
  0xC0, 0x3F, 0xC0, 0xFF, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0xFE, 0x01, 0xF8,
  0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x0F, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x7E, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x1F, 0x80, 0x03, 0xE0,
  0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x3F,
  0x0F, 0x80, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xDF, 0x00, 0x00,
  0x0F, 0xC7, 0xC0, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x0F, 0xC1, 0xF8, 0x00,
  0x0F, 0xC0, 0x7C, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x07, 0xE0, 0x0F, 0x80,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x01, 0xF0, 0x07, 0xE0, 0x00, 0xF8,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x0F, 0x80,
  0x03, 0xF0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x0F, 0x80,
  0x01, 0xF0, 0x07, 0xC0, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0xFC,
  0x00, 0x07, 0xC0, 0x3E, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x7E, 0x07,
  0xC0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x00, 0xF8,
  0x3E, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x01,
  0xF3, 0xE0, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x06, 0x07, 0xF0, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x01, 0x81, 0xFF, 0x00, 0x3C,
  0x7F, 0xF0, 0x0F, 0x9F, 0xFF, 0x01, 0xE3, 0xFF, 0xF8, 0xFC, 0xF8, 0x7F,
  0xFF, 0x1E, 0x07, 0xFF, 0xC7, 0x80, 0x3F, 0xF8, 0xF0, 0x03, 0xFC, 0x04,
  0x00, 0x3F, 0x00,
};

const GFXglyph UbuntuMono_Italic62pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 31, 0, -1 },
  { 1, 15, 38, 31, 11, -38 },
  { 73, 17, 15, 31, 14, -42 },
  { 105, 33, 38, 31, 2, -38 },
  { 262, 29, 49, 31, 4, -43 },
  { 440, 37, 38, 31, 0, -38 },
  { 616, 26, 38, 31, 4, -38 },
  { 740, 8, 17, 31, 19, -42 },
  { 757, 23, 53, 31, 9, -43 },
  { 910, 24, 53, 31, 3, -43 },
  { 1069, 23, 23, 31, 9, -38 },
  { 1136, 26, 26, 31, 5, -29 },
  { 1221, 13, 16, 31, 7, -8 },
  { 1247, 15, 5, 31, 11, -18 },
  { 1257, 9, 8, 31, 11, -8 },
  { 1266, 35, 53, 31, -1, -43 },
  { 1498, 27, 38, 31, 5, -38 },
  { 1627, 22, 38, 31, 6, -38 },
  { 1732, 28, 38, 31, 4, -38 },
  { 1865, 28, 38, 31, 4, -38 },
  { 1998, 29, 38, 31, 3, -38 },
  { 2136, 31, 38, 31, 3, -38 },
  { 2284, 28, 38, 31, 6, -38 },
  { 2417, 28, 38, 31, 9, -38 },
  { 2550, 28, 38, 31, 5, -38 },
  { 2683, 28, 38, 31, 5, -38 },
  { 2816, 14, 28, 31, 11, -28 },
  { 2865, 18, 36, 31, 7, -28 },
  { 2946, 27, 25, 31, 5, -28 },
  { 3031, 29, 15, 31, 4, -24 },
  { 3086, 27, 25, 31, 4, -29 },
  { 3171, 22, 38, 31, 10, -38 },
  { 3276, 31, 47, 31, 4, -39 },
  { 3459, 30, 38, 31, -1, -38 },
  { 3602, 29, 38, 31, 3, -38 },
  { 3740, 30, 38, 31, 6, -38 },
  { 3883, 30, 38, 31, 2, -38 },
  { 4026, 31, 38, 31, 4, -38 },
  { 4174, 31, 38, 31, 4, -38 },
  { 4322, 30, 38, 31, 5, -38 },
  { 4465, 34, 38, 31, 2, -38 },
  { 4627, 30, 38, 31, 4, -38 },
  { 4770, 30, 38, 31, 4, -38 },
  { 4913, 33, 38, 31, 3, -38 },
  { 5070, 23, 38, 31, 3, -38 },
  { 5180, 34, 38, 31, 1, -38 },
  { 5342, 34, 38, 31, 2, -38 },
  { 5504, 29, 38, 31, 5, -38 },
  { 5642, 31, 38, 31, 3, -38 },
  { 5790, 29, 48, 31, 5, -38 },
  { 5964, 30, 38, 31, 3, -38 },
  { 6107, 31, 38, 31, 3, -38 },
  { 6255, 28, 38, 31, 9, -38 },
  { 6388, 31, 38, 31, 5, -38 },
  { 6536, 30, 38, 31, 8, -38 },
  { 6679, 33, 38, 31, 4, -38 },
  { 6836, 37, 38, 31, 1, -38 },
  { 7012, 30, 38, 31, 9, -38 },
  { 7155, 33, 38, 31, 2, -38 },
  { 7312, 28, 53, 31, 6, -43 },
  { 7498, 9, 53, 31, 14, -43 },
  { 7558, 27, 53, 31, 2, -43 },
  { 7737, 25, 21, 31, 7, -38 },
  { 7803, 29, 4, 31, -2, 6 },
  { 7818, 11, 11, 31, 16, -43 },
  { 7834, 28, 31, 31, 4, -30 },
  { 7943, 27, 44, 31, 4, -43 },
  { 8092, 28, 31, 31, 4, -30 },
  { 8201, 31, 44, 31, 5, -43 },
  { 8372, 27, 31, 31, 4, -30 },
  { 8477, 36, 53, 31, 1, -43 },
  { 8716, 32, 40, 31, 1, -30 },
  { 8876, 27, 43, 31, 3, -43 },
  { 9022, 18, 41, 31, 8, -41 },
  { 9115, 30, 51, 31, 1, -41 },
  { 9307, 30, 43, 31, 4, -43 },
  { 9469, 16, 44, 31, 11, -43 },
  { 9557, 30, 30, 31, 2, -30 },
  { 9670, 27, 30, 31, 4, -30 },
  { 9772, 26, 31, 31, 5, -30 },
  { 9873, 30, 40, 31, 1, -30 },
  { 10023, 28, 40, 31, 5, -30 },
  { 10163, 26, 30, 31, 6, -30 },
  { 10261, 26, 31, 31, 5, -30 },
  { 10362, 23, 39, 31, 9, -38 },
  { 10475, 27, 30, 31, 5, -29 },
  { 10577, 25, 29, 31, 8, -29 },
  { 10668, 31, 29, 31, 5, -29 },
  { 10781, 33, 29, 31, 1, -29 },
  { 10901, 34, 39, 31, -1, -29 },
  { 11067, 28, 29, 31, 4, -29 },
  { 11169, 29, 53, 31, 6, -43 },
  { 11362, 18, 53, 31, 9, -43 },
  { 11482, 30, 53, 31, 0, -43 },
  { 11681, 27, 10, 31, 5, -22 },
};

const GFXfont UbuntuMono_Italic62pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Italic62pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Italic62pt7bGlyphs,
  0x20, 0x7E, 62
};

#endif // _UBUNTUMONO_ITALIC62PT7B_H_
