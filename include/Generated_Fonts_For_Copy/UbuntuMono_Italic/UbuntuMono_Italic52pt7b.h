#ifndef _UBUNTUMONO_ITALIC52PT7B_H_
#define _UBUNTUMONO_ITALIC52PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Italic.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Italic52pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0,
  0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x1F, 0x01, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xF0, 0x0F, 0x00, 0x1E, 0x1E, 0x78, 0x3C, 0xF0, 0x79, 0xE1,
  0xE3, 0xC3, 0xC7, 0x07, 0x9E, 0x0F, 0x3C, 0x1C, 0x70, 0x38, 0xE0, 0xF1,
  0xC1, 0xC3, 0x03, 0x86, 0x07, 0x00, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x78,
  0x1E, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x0F, 0x03, 0x80,
  0x01, 0xE0, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0xF0, 0x0F, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE,
  0x00, 0x78, 0x3C, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x1E,
  0x07, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x78, 0x1E, 0x00, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0x78,
  0x00, 0x1C, 0x0F, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFF, 0x01, 0xFF,
  0xFE, 0x03, 0xF0, 0x0E, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xF0, 0x60, 0x03, 0xF0, 0x78, 0x07, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0xFE, 0x00, 0x78, 0x03, 0xFE, 0x01,
  0xE0, 0x0F, 0xFC, 0x03, 0x80, 0x3E, 0x78, 0x0F, 0x00, 0x78, 0x70, 0x3C,
  0x00, 0xE0, 0xE0, 0xF0, 0x03, 0xC1, 0xC3, 0xC0, 0x07, 0x07, 0x8F, 0x00,
  0x0E, 0x0E, 0x1C, 0x00, 0x1C, 0x3C, 0x70, 0x00, 0x3C, 0x79, 0xE0, 0x00,
  0x7F, 0xE7, 0x80, 0x00, 0x7F, 0x9E, 0x00, 0x00, 0xFF, 0x78, 0x00, 0x00,
  0xF9, 0xE0, 0x00, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x0E, 0x7F, 0x80, 0x00,
  0x3D, 0xFF, 0x00, 0x00, 0xF3, 0xFE, 0x00, 0x03, 0xCF, 0x1C, 0x00, 0x0F,
  0x1C, 0x3C, 0x00, 0x3C, 0x78, 0x70, 0x00, 0x70, 0xE0, 0xE0, 0x01, 0xC1,
  0xC1, 0xC0, 0x07, 0x83, 0x83, 0x80, 0x1E, 0x07, 0x0F, 0x00, 0x78, 0x0F,
  0x3C, 0x01, 0xE0, 0x1F, 0xF8, 0x07, 0x80, 0x3F, 0xE0, 0x0E, 0x00, 0x3F,
  0x80, 0x38, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x1F, 0x8F, 0x80, 0x3C, 0x0F, 0x00, 0xF8,
  0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0xF0, 0x07, 0x81, 0xE0, 0x0F, 0x07,
  0x80, 0x1E, 0x1E, 0x00, 0x1E, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80,
  0x01, 0xFC, 0x0F, 0x07, 0xF8, 0x3C, 0x1F, 0xF8, 0x78, 0x78, 0xF8, 0xE1,
  0xE0, 0xF3, 0xC7, 0x81, 0xF7, 0x8F, 0x01, 0xFE, 0x3E, 0x01, 0xFC, 0x78,
  0x03, 0xF0, 0xF0, 0x03, 0xC1, 0xE0, 0x0F, 0xC3, 0xE0, 0x3F, 0x87, 0xE1,
  0xFF, 0x07, 0xFF, 0xEF, 0x0F, 0xFF, 0x9E, 0x0F, 0xFC, 0x3C, 0x07, 0xE0,
  0x7C, 0x3C, 0xF7, 0xDF, 0x79, 0xE7, 0xBC, 0xF3, 0xCE, 0x38, 0xE3, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x38, 0x00, 0x0F, 0x80, 0x07, 0xF0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0x80, 0x00, 0x20, 0x00, 0x00,
  0x08, 0x00, 0x01, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80,
  0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x00, 0xF8, 0x00, 0x07, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x06, 0x0F, 0x02, 0x78, 0x71, 0xE7, 0xE7, 0x7F,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFE, 0x00, 0xF0, 0x00, 0x1F, 0x80, 0x03, 0xDC,
  0x00, 0x79, 0xE0, 0x0F, 0x9F, 0x01, 0xF0, 0xF8, 0x1F, 0x0F, 0xC0, 0xE0,
  0x70, 0x02, 0x02, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x07, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xE0, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x7E, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x07, 0xE0, 0x1E, 0x03, 0xC0,
  0x7C, 0x1F, 0x87, 0xF0, 0x7C, 0x06, 0x00, 0x7F, 0xF3, 0xFF, 0x9F, 0xFD,
  0xFF, 0xE0, 0x3C, 0x7E, 0xFF, 0xFF, 0xFE, 0xFE, 0x78, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x1F, 0x87,
  0xE0, 0x7C, 0x07, 0xC1, 0xF0, 0x0F, 0x87, 0xC0, 0x0F, 0x0F, 0x80, 0x1E,
  0x3E, 0x00, 0x3C, 0x7C, 0x00, 0x78, 0xF0, 0x00, 0xF3, 0xE3, 0xC1, 0xE7,
  0x8F, 0xC3, 0xCF, 0x1F, 0x8F, 0xBE, 0x3F, 0x1F, 0x78, 0x7E, 0x3C, 0xF0,
  0xF8, 0x79, 0xE0, 0xE1, 0xF3, 0xC0, 0x03, 0xCF, 0x80, 0x07, 0x9F, 0x00,
  0x1F, 0x3E, 0x00, 0x3C, 0x7C, 0x00, 0xF8, 0xF8, 0x03, 0xE0, 0xF0, 0x0F,
  0xC1, 0xF0, 0x3F, 0x03, 0xF0, 0xFC, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1F, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0xE0, 0x7F,
  0xBC, 0x07, 0xCF, 0x80, 0xE1, 0xE0, 0x10, 0x3C, 0x00, 0x07, 0x80, 0x01,
  0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x07, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xE7, 0xFF, 0xFC, 0x00, 0x1F,
  0xC0, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3E, 0x07,
  0xE0, 0x70, 0x07, 0xC0, 0x40, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xF8,
  0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0xF0, 0x7E, 0x00, 0x80, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x20, 0x01, 0xF0, 0x78, 0x0F, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0x3C, 0x00, 0x1F, 0x3C, 0x00, 0x1F,
  0x1E, 0x00, 0x1F, 0x0F, 0x00, 0x1F, 0x07, 0x80, 0x1F, 0x07, 0x80, 0x1F,
  0x03, 0xC0, 0x0F, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF8, 0x0F,
  0x00, 0x78, 0x07, 0x80, 0x3C, 0x07, 0x80, 0x1E, 0x07, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x04, 0x00,
  0x3F, 0x01, 0xC0, 0x3F, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x07,
  0xFF, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x03, 0xFE,
  0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0xFE, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x7F, 0x00, 0x3F, 0xFF, 0xC0,
  0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7E, 0x03, 0xF0, 0x78, 0x00, 0xF0,
  0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF0, 0x00, 0xF8, 0xF0, 0x00, 0xF8,
  0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0xF0, 0x01, 0xF0, 0xF8, 0x01, 0xE0,
  0xF8, 0x07, 0xE0, 0x7C, 0x0F, 0xC0, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xF8,
  0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x03, 0xF8, 0x3F, 0x03, 0xE0, 0x1F,
  0x07, 0xC0, 0x0F, 0x07, 0x80, 0x0F, 0x07, 0x80, 0x0F, 0x07, 0x80, 0x1F,
  0x07, 0x80, 0x1E, 0x07, 0x80, 0x3C, 0x07, 0xC0, 0x7C, 0x03, 0xF1, 0xF8,
  0x03, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x0F, 0xDF, 0xE0,
  0x1F, 0x03, 0xF0, 0x3E, 0x01, 0xF8, 0x7C, 0x00, 0xF8, 0x78, 0x00, 0x78,
  0xF8, 0x00, 0x78, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0xF0,
  0xF8, 0x03, 0xF0, 0x7C, 0x0F, 0xE0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80,
  0x1F, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xF8,
  0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x03, 0xF0, 0x7E, 0x07, 0xC0, 0x3E,
  0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x00, 0x0F, 0x1F, 0x00, 0x0F,
  0x1E, 0x00, 0x1F, 0x1E, 0x00, 0x1F, 0x1E, 0x00, 0x1F, 0x1F, 0x00, 0x1E,
  0x1F, 0x00, 0x1E, 0x0F, 0x80, 0xFE, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFC,
  0x03, 0xFF, 0xFC, 0x00, 0xFE, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x80, 0x03, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00,
  0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xC0, 0x7E, 0x0F, 0xF0, 0xFF,
  0x0F, 0xE0, 0xFE, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x7E, 0x0F, 0xF0,
  0xFF, 0x0F, 0xE0, 0xFE, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x7E, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x07, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0xC0,
  0x1F, 0x80, 0x7F, 0x00, 0x7C, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x3C, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xC0, 0x1F,
  0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0xFE, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x04, 0x00, 0x1F, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF8, 0x04, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFF,
  0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x07, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x07,
  0xFF, 0xF0, 0xC0, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x1F, 0xC1, 0xF0,
  0x1F, 0x80, 0x7C, 0x1F, 0x80, 0x1E, 0x0F, 0x80, 0x0F, 0x0F, 0x80, 0x07,
  0x8F, 0x80, 0x03, 0xC7, 0x80, 0x01, 0xE7, 0xC0, 0x3F, 0xF3, 0xC0, 0x7F,
  0xF9, 0xE0, 0xFF, 0xF9, 0xE0, 0xFF, 0xFC, 0xF0, 0xFE, 0x1E, 0x78, 0x7C,
  0x0E, 0x78, 0x7C, 0x0F, 0x3C, 0x3C, 0x07, 0x9E, 0x1E, 0x03, 0xCF, 0x0F,
  0x03, 0xC7, 0x8F, 0x01, 0xE3, 0xC7, 0x80, 0xF1, 0xE3, 0xE0, 0xF8, 0xF0,
  0xF0, 0x78, 0x78, 0x7C, 0x3C, 0x3C, 0x3F, 0xFE, 0x1E, 0x0F, 0xFF, 0x0F,
  0x03, 0xFF, 0x07, 0x80, 0x7F, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x40, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x1E, 0xF0, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x1E, 0x00,
  0x07, 0x8F, 0x00, 0x07, 0x87, 0x80, 0x03, 0xC3, 0xC0, 0x03, 0xC1, 0xE0,
  0x01, 0xC0, 0xF0, 0x01, 0xE0, 0x38, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x78, 0x01, 0xE0, 0x3C, 0x00,
  0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x03, 0xC7, 0x80, 0x01, 0xE3, 0xC0,
  0x00, 0xF3, 0xC0, 0x00, 0x79, 0xE0, 0x00, 0x3D, 0xE0, 0x00, 0x1E, 0xF0,
  0x00, 0x0F, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0,
  0x3F, 0xFF, 0xF0, 0x1E, 0x01, 0xF8, 0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x1E,
  0x07, 0x80, 0x0F, 0x03, 0xC0, 0x07, 0x81, 0xE0, 0x03, 0xC1, 0xF0, 0x03,
  0xC0, 0xF0, 0x03, 0xE0, 0x78, 0x0F, 0xE0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0x80, 0x7E, 0x07, 0xC0,
  0x0F, 0x83, 0xC0, 0x03, 0xC1, 0xE0, 0x01, 0xE0, 0xF0, 0x00, 0xF0, 0x78,
  0x00, 0x78, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x3E, 0x1E, 0x00, 0x3E, 0x0F,
  0x00, 0x3F, 0x0F, 0x00, 0xFF, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x01,
  0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xFF,
  0x00, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0x80, 0xF0, 0x3F, 0x00,
  0x10, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x10, 0x0F, 0xE0, 0x78, 0x03, 0xFF, 0xFC,
  0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x3E,
  0x07, 0xF0, 0x1E, 0x01, 0xF8, 0x0F, 0x00, 0x7C, 0x07, 0x80, 0x1F, 0x07,
  0xC0, 0x0F, 0x83, 0xC0, 0x03, 0xC1, 0xE0, 0x01, 0xE0, 0xF0, 0x00, 0xF0,
  0xF8, 0x00, 0x78, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x0F,
  0x1F, 0x00, 0x0F, 0x8F, 0x00, 0x07, 0x87, 0x80, 0x03, 0xC3, 0xC0, 0x03,
  0xE3, 0xE0, 0x01, 0xF1, 0xE0, 0x01, 0xF0, 0xF0, 0x00, 0xF8, 0x78, 0x00,
  0xF8, 0x3C, 0x00, 0xFC, 0x3C, 0x00, 0xFC, 0x1E, 0x01, 0xFC, 0x0F, 0x03,
  0xFC, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x00, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF0, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xE0, 0x1F, 0xC0, 0xF0, 0x1F, 0x80, 0x10, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x3C, 0x7C, 0x00, 0x3E, 0x3E, 0x00,
  0x1E, 0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x07, 0xC3, 0xE0,
  0x03, 0xC1, 0xF0, 0x01, 0xE0, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0xF8, 0x1F,
  0x80, 0x78, 0x07, 0xE0, 0x7C, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0xF0, 0x1E, 0x00,
  0x1F, 0x01, 0xE0, 0x01, 0xE0, 0x1E, 0x00, 0x1E, 0x03, 0xE0, 0x01, 0xE0,
  0x3C, 0x00, 0x3E, 0x03, 0xC0, 0x03, 0xC0, 0x3C, 0x00, 0x3C, 0x03, 0xC0,
  0x03, 0xC0, 0x78, 0x00, 0x7C, 0x07, 0x80, 0x07, 0x80, 0x78, 0x00, 0x78,
  0x07, 0x80, 0x07, 0x80, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x01, 0xF0, 0x01, 0xF0, 0x1E, 0x00, 0x1F,
  0x01, 0xE0, 0x01, 0xE0, 0x1E, 0x00, 0x1E, 0x03, 0xE0, 0x03, 0xE0, 0x3C,
  0x00, 0x3E, 0x03, 0xC0, 0x03, 0xC0, 0x3C, 0x00, 0x3C, 0x07, 0xC0, 0x03,
  0xC0, 0x78, 0x00, 0x7C, 0x07, 0x80, 0x07, 0x80, 0x78, 0x00, 0x78, 0x0F,
  0x80, 0x07, 0x80, 0xF0, 0x00, 0xF8, 0x0F, 0x00, 0x0F, 0x00, 0x01, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x08, 0x00, 0xF8, 0x03, 0x00,
  0x7E, 0x01, 0xF0, 0x3F, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x01,
  0xFF, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xF0, 0x01, 0xF0, 0x07, 0x80,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x1E, 0x01, 0xF0,
  0x00, 0xF0, 0x1F, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x03,
  0xC1, 0xF0, 0x00, 0x1E, 0x1F, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x0F, 0x9F,
  0x00, 0x00, 0x79, 0xF0, 0x00, 0x03, 0xDF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x03,
  0xCF, 0x80, 0x00, 0x3E, 0x3E, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x0F, 0x07,
  0xC0, 0x00, 0x78, 0x1F, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x3C, 0x03, 0xE0,
  0x01, 0xE0, 0x0F, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x07,
  0x80, 0x0F, 0x80, 0x3C, 0x00, 0x3C, 0x01, 0xE0, 0x01, 0xF0, 0x1F, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFE, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0,
  0x0F, 0xC0, 0x7E, 0x00, 0xFC, 0x0F, 0xE0, 0x1D, 0xE0, 0xEE, 0x01, 0xDE,
  0x1C, 0xE0, 0x1C, 0xE1, 0xDE, 0x03, 0xCE, 0x39, 0xE0, 0x38, 0xE3, 0x9C,
  0x03, 0x8E, 0x71, 0xC0, 0x78, 0xE7, 0x1C, 0x07, 0x8E, 0xE3, 0xC0, 0x70,
  0xFE, 0x3C, 0x0F, 0x0F, 0xC3, 0xC0, 0xF0, 0xF8, 0x38, 0x0F, 0x0F, 0x87,
  0x81, 0xE0, 0xF0, 0x78, 0x1E, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x78, 0x1E,
  0x00, 0x07, 0x03, 0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0xF0, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x07,
  0x80, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0xF0,
  0x00, 0xF0, 0x1F, 0x00, 0x0F, 0x01, 0xF8, 0x00, 0xF0, 0x1F, 0x80, 0x1E,
  0x01, 0xF8, 0x01, 0xE0, 0x3F, 0xC0, 0x1E, 0x03, 0xFC, 0x01, 0xE0, 0x3D,
  0xC0, 0x3C, 0x03, 0xDE, 0x03, 0xC0, 0x39, 0xE0, 0x3C, 0x07, 0x9E, 0x03,
  0xC0, 0x78, 0xE0, 0x78, 0x07, 0x8F, 0x07, 0x80, 0x70, 0xF0, 0x78, 0x0F,
  0x07, 0x07, 0x80, 0xF0, 0x70, 0xF0, 0x0F, 0x07, 0x8F, 0x00, 0xE0, 0x78,
  0xF0, 0x1E, 0x03, 0x8F, 0x01, 0xE0, 0x38, 0xE0, 0x1E, 0x03, 0x9E, 0x01,
  0xE0, 0x3D, 0xE0, 0x3C, 0x03, 0xDE, 0x03, 0xC0, 0x1D, 0xC0, 0x3C, 0x01,
  0xFC, 0x03, 0xC0, 0x1F, 0xC0, 0x78, 0x01, 0xFC, 0x07, 0x80, 0x1F, 0x80,
  0x78, 0x00, 0xF8, 0x07, 0x80, 0x0F, 0x80, 0xF0, 0x00, 0xF8, 0x0F, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xFC, 0x01,
  0xFF, 0xFE, 0x03, 0xF8, 0x7E, 0x03, 0xE0, 0x1F, 0x07, 0xC0, 0x1F, 0x0F,
  0x80, 0x0F, 0x0F, 0x00, 0x0F, 0x1F, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x3E,
  0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x7C, 0x00, 0x1F, 0x78,
  0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0xF8, 0x00, 0x3E, 0xF8,
  0x00, 0x3C, 0xF8, 0x00, 0x3C, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x78, 0xF8,
  0x00, 0xF8, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0x7C, 0x07, 0xE0, 0x7E,
  0x0F, 0xC0, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80,
  0x3F, 0xFF, 0xE0, 0x3E, 0x03, 0xF0, 0x1F, 0x00, 0x7C, 0x0F, 0x00, 0x3E,
  0x07, 0x80, 0x0F, 0x07, 0xC0, 0x07, 0x83, 0xE0, 0x03, 0xC1, 0xE0, 0x01,
  0xE0, 0xF0, 0x01, 0xF0, 0x78, 0x00, 0xF0, 0x7C, 0x00, 0x78, 0x3C, 0x00,
  0x7C, 0x1E, 0x00, 0xFC, 0x0F, 0x01, 0xFC, 0x0F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFC, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xF8,
  0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x03, 0xF8, 0x7E, 0x03, 0xE0, 0x1F,
  0x07, 0xC0, 0x1F, 0x0F, 0x80, 0x0F, 0x0F, 0x00, 0x0F, 0x1F, 0x00, 0x0F,
  0x1E, 0x00, 0x0F, 0x3E, 0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x3C, 0x00, 0x0F,
  0x7C, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E,
  0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3C, 0xF8, 0x00, 0x3C, 0xF0, 0x00, 0x7C,
  0xF0, 0x00, 0x78, 0xF8, 0x00, 0xF8, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF0,
  0x7C, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x03, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x1E, 0x03,
  0xF8, 0x0F, 0x00, 0x7C, 0x0F, 0x80, 0x1E, 0x07, 0xC0, 0x0F, 0x03, 0xC0,
  0x07, 0x81, 0xE0, 0x03, 0xC0, 0xF0, 0x01, 0xE0, 0xF8, 0x00, 0xF0, 0x78,
  0x00, 0xF8, 0x3C, 0x00, 0xF8, 0x1E, 0x00, 0xFC, 0x1F, 0x01, 0xFC, 0x0F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x01,
  0xE0, 0x7C, 0x00, 0xF0, 0x1E, 0x00, 0x78, 0x0F, 0x80, 0x7C, 0x03, 0xC0,
  0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF8, 0x0F, 0x00, 0x3C, 0x0F, 0x80, 0x1E,
  0x07, 0x80, 0x0F, 0x83, 0xC0, 0x07, 0xC1, 0xE0, 0x01, 0xE1, 0xF0, 0x00,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF0, 0x1F, 0x80, 0xF0, 0x1F, 0x00, 0x08, 0x0F, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x18, 0x00,
  0x7C, 0x0F, 0x00, 0xFE, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x01, 0xFF,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xE0, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0xC0, 0x03, 0xC1, 0xE0, 0x01, 0xF0, 0x78, 0x00, 0x78, 0x1E,
  0x00, 0x1E, 0x0F, 0x80, 0x07, 0x83, 0xC0, 0x03, 0xE0, 0xF0, 0x00, 0xF0,
  0x3C, 0x00, 0x3C, 0x1F, 0x00, 0x0F, 0x07, 0x80, 0x07, 0xC1, 0xE0, 0x01,
  0xE0, 0x78, 0x00, 0x78, 0x3E, 0x00, 0x3E, 0x0F, 0x00, 0x0F, 0x83, 0xC0,
  0x03, 0xC0, 0xF0, 0x00, 0xF0, 0x7C, 0x00, 0x7C, 0x1E, 0x00, 0x1F, 0x07,
  0x80, 0x07, 0x81, 0xE0, 0x01, 0xE0, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x3C,
  0x0F, 0x00, 0x0F, 0x03, 0xC0, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x3E, 0x00,
  0xF8, 0x07, 0xC0, 0x7E, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0xFF, 0x80, 0x0F,
  0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xBE, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xCF, 0x80, 0x03,
  0xE7, 0xC0, 0x01, 0xE3, 0xE0, 0x01, 0xF1, 0xF0, 0x00, 0xF0, 0xF8, 0x00,
  0xF8, 0x7C, 0x00, 0x78, 0x3E, 0x00, 0x7C, 0x0F, 0x00, 0x3C, 0x07, 0x80,
  0x3C, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x78,
  0x0F, 0x00, 0x3C, 0x0F, 0x80, 0x1E, 0x07, 0x80, 0x0F, 0x07, 0xC0, 0x07,
  0x83, 0xC0, 0x03, 0xC3, 0xE0, 0x01, 0xE1, 0xE0, 0x00, 0xF1, 0xE0, 0x00,
  0x78, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x0F, 0x78, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xE0,
  0x78, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x0F, 0x00,
  0x03, 0xC0, 0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x38,
  0x1E, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x78, 0x1E, 0x0F, 0x07, 0x81, 0xE1,
  0xF0, 0x70, 0x1C, 0x3F, 0x0F, 0x03, 0xC3, 0xF0, 0xF0, 0x3C, 0x7F, 0x0E,
  0x03, 0xC7, 0x71, 0xE0, 0x38, 0xE7, 0x1E, 0x03, 0x8E, 0x71, 0xC0, 0x39,
  0xC7, 0x1C, 0x07, 0x9C, 0x73, 0xC0, 0x7B, 0x87, 0x38, 0x07, 0x78, 0x73,
  0x80, 0x77, 0x03, 0xF8, 0x07, 0xF0, 0x3F, 0x00, 0x7E, 0x03, 0xF0, 0x07,
  0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x1E, 0x01,
  0xF0, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x0F, 0x07,
  0xC0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0x07, 0xDE,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0x78,
  0x00, 0x00, 0x3E, 0x78, 0x00, 0x00, 0x7C, 0x78, 0x00, 0x00, 0xF8, 0x3C,
  0x00, 0x01, 0xF0, 0x3C, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x03, 0xE0, 0x1E,
  0x00, 0x07, 0xC0, 0x1E, 0x00, 0x0F, 0x80, 0x1E, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x0F, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x3E, 0xF0, 0x00,
  0x7C, 0xF8, 0x00, 0x78, 0x78, 0x00, 0xF8, 0x78, 0x01, 0xF0, 0x78, 0x01,
  0xE0, 0x78, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0x3C, 0x07, 0x80, 0x3C, 0x0F,
  0x00, 0x3E, 0x1E, 0x00, 0x1E, 0x3E, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x78,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F,
  0xFF, 0x80, 0x00, 0xF8, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78,
  0x78, 0x7C, 0x7C, 0x7C, 0x7C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E,
  0x1E, 0x1E, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x79, 0xE0, 0x07, 0xCF, 0x00, 0x7C, 0x78,
  0x07, 0xC1, 0xE0, 0x7C, 0x0F, 0x07, 0xC0, 0x78, 0x3C, 0x01, 0xE3, 0xE0,
  0x0F, 0x3E, 0x00, 0x7B, 0xE0, 0x03, 0xFE, 0x00, 0x0F, 0x20, 0x00, 0x40,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE,
  0x20, 0x38, 0x3E, 0x1F, 0x83, 0xE0, 0xF0, 0x3C, 0x0E, 0x02, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x7F,
  0x03, 0xC1, 0xF8, 0x07, 0x87, 0xE0, 0x1E, 0x1F, 0x80, 0x3C, 0x3E, 0x00,
  0x78, 0xF8, 0x00, 0xF1, 0xE0, 0x03, 0xC7, 0xC0, 0x07, 0x8F, 0x80, 0x0F,
  0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x7C, 0x78, 0x00, 0xF0, 0xF0, 0x01, 0xE1,
  0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x87, 0x80, 0x1F, 0x0F, 0x80, 0x7E, 0x1F,
  0x83, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x1F, 0xF9, 0xE0, 0x1F,
  0xC3, 0xC0, 0x00, 0x38, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x7E,
  0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xF0, 0x3E,
  0x07, 0x80, 0x3E, 0x0F, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x78, 0x00, 0xF0,
  0xF0, 0x01, 0xE1, 0xE0, 0x03, 0xC7, 0xC0, 0x07, 0x8F, 0x00, 0x0F, 0x1E,
  0x00, 0x3E, 0x3C, 0x00, 0x78, 0xF8, 0x00, 0xF1, 0xE0, 0x03, 0xE3, 0xC0,
  0x0F, 0x87, 0x80, 0x3F, 0x0F, 0x00, 0xFC, 0x3C, 0x03, 0xF0, 0x78, 0x1F,
  0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x3F, 0xFF,
  0xE0, 0xFF, 0x01, 0x83, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0,
  0x04, 0x0F, 0xE0, 0x38, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xC0, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x3F,
  0xFF, 0x80, 0x3F, 0x87, 0xE0, 0x1F, 0x80, 0xF0, 0x0F, 0x80, 0x3C, 0x07,
  0xC0, 0x0F, 0x01, 0xE0, 0x07, 0xC0, 0xF8, 0x01, 0xE0, 0x3C, 0x00, 0x78,
  0x1F, 0x00, 0x1E, 0x07, 0x80, 0x07, 0x81, 0xE0, 0x03, 0xC0, 0xF8, 0x00,
  0xF0, 0x3E, 0x00, 0x3C, 0x0F, 0x80, 0x0F, 0x03, 0xC0, 0x03, 0xC0, 0xF0,
  0x01, 0xE0, 0x3E, 0x00, 0x78, 0x0F, 0x80, 0x1E, 0x01, 0xE0, 0x07, 0x80,
  0x7C, 0x07, 0xE0, 0x1F, 0x83, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xE7,
  0xC0, 0x07, 0xE0, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0xC0, 0x3F,
  0xFF, 0x81, 0xFF, 0xFF, 0x0F, 0xE0, 0xFC, 0x7E, 0x00, 0xF3, 0xF0, 0x03,
  0xCF, 0x80, 0x0F, 0x7C, 0x00, 0x7D, 0xE0, 0x01, 0xF7, 0x80, 0x1F, 0xBE,
  0x03, 0xFE, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x3F, 0xFC,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0xFC, 0x00, 0x41, 0xFC, 0x07, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xE0,
  0x40, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x43, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x3F,
  0x83, 0xE0, 0x0F, 0xC0, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x78, 0x01, 0xE0,
  0x1F, 0x00, 0x3C, 0x07, 0xC0, 0x07, 0x80, 0xF0, 0x01, 0xF0, 0x1E, 0x00,
  0x3C, 0x07, 0xC0, 0x07, 0x80, 0xF0, 0x00, 0xF0, 0x1E, 0x00, 0x3E, 0x03,
  0xC0, 0x07, 0x80, 0xF8, 0x00, 0xF0, 0x1F, 0x00, 0x1E, 0x03, 0xE0, 0x07,
  0xC0, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xFC, 0x1F, 0xC0, 0x0F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xF3, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0xF0, 0x1F, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00,
  0x7F, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1E, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0x01,
  0xFF, 0xFF, 0x03, 0xE0, 0x7E, 0x07, 0x80, 0x3C, 0x0F, 0x00, 0x7C, 0x1E,
  0x00, 0xF8, 0x7C, 0x01, 0xF0, 0xF0, 0x03, 0xE1, 0xE0, 0x07, 0xC3, 0xC0,
  0x0F, 0x0F, 0x80, 0x1E, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0xF8, 0x78, 0x01,
  0xE1, 0xF0, 0x03, 0xC3, 0xC0, 0x07, 0x87, 0x80, 0x1F, 0x0F, 0x00, 0x3C,
  0x3E, 0x00, 0x78, 0x78, 0x00, 0xF0, 0xF0, 0x03, 0xE1, 0xE0, 0x07, 0x87,
  0xC0, 0x0F, 0x00, 0x00, 0x78, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x8F, 0xFF, 0x1F, 0xFC, 0x3F, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xF0, 0x03,
  0xF0, 0x07, 0xFF, 0x07, 0xFE, 0x07, 0xFC, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x07,
  0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0xF0,
  0x7E, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0xF8, 0x1E, 0x01, 0xF8, 0x1F,
  0x01, 0xF8, 0x0F, 0x01, 0xF0, 0x07, 0x83, 0xF0, 0x03, 0xC3, 0xF0, 0x03,
  0xE7, 0xF0, 0x01, 0xE7, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x1E, 0xFC, 0x00, 0x0F, 0x3F, 0x00,
  0x07, 0x8F, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xC0, 0xF8, 0x01, 0xE0, 0x3E,
  0x00, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x78, 0x03, 0xE0, 0x3C, 0x00,
  0xF8, 0x1E, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x00, 0x7F, 0xF1, 0xFF, 0xC7,
  0xFF, 0x3F, 0xFC, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7E, 0x0C, 0xFF, 0xF3, 0xFF, 0xC7, 0xFF, 0x0F,
  0xF0, 0x01, 0xFC, 0x3E, 0x03, 0xFF, 0x7F, 0x81, 0xFF, 0xFF, 0xE0, 0xE1,
  0xF9, 0xF0, 0xF0, 0x70, 0x78, 0x78, 0x38, 0x3C, 0x3C, 0x3C, 0x1E, 0x1E,
  0x1E, 0x0F, 0x1E, 0x0F, 0x0F, 0x0F, 0x07, 0x87, 0x87, 0x87, 0x83, 0xC3,
  0xC3, 0xC1, 0xE1, 0xC1, 0xE0, 0xE1, 0xE0, 0xF0, 0xF0, 0xF0, 0xF0, 0x78,
  0x78, 0x00, 0x3C, 0x38, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x0F,
  0x0F, 0x00, 0x07, 0x87, 0x80, 0x03, 0xC7, 0x80, 0x01, 0xC3, 0xC0, 0x01,
  0xE1, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x3F, 0xC0, 0x07,
  0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x7C, 0x0F, 0xC0, 0xF0,
  0x07, 0x81, 0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0x00, 0x3E, 0x1E, 0x00,
  0x7C, 0x3C, 0x00, 0xF0, 0xF8, 0x01, 0xE1, 0xF0, 0x03, 0xC3, 0xC0, 0x0F,
  0x87, 0x80, 0x1E, 0x0F, 0x00, 0x3C, 0x3E, 0x00, 0x78, 0x78, 0x00, 0xF0,
  0xF0, 0x03, 0xE1, 0xE0, 0x07, 0x87, 0xC0, 0x0F, 0x0F, 0x00, 0x1E, 0x1E,
  0x00, 0x7C, 0x3C, 0x00, 0xF0, 0xF8, 0x01, 0xE0, 0x00, 0x3F, 0x80, 0x03,
  0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xE0, 0xFC, 0x3E, 0x01,
  0xF1, 0xF0, 0x03, 0xCF, 0x80, 0x0F, 0x3E, 0x00, 0x3D, 0xF0, 0x00, 0xF7,
  0xC0, 0x03, 0xDE, 0x00, 0x0F, 0x78, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x1E, 0xF8, 0x00, 0xFB, 0xC0, 0x03, 0xCF, 0x80, 0x1F,
  0x3E, 0x00, 0xF8, 0x78, 0x07, 0xE1, 0xF8, 0x3F, 0x07, 0xFF, 0xF8, 0x0F,
  0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x1F, 0x03, 0xF0,
  0x0F, 0x00, 0x7C, 0x0F, 0x80, 0x3E, 0x07, 0xC0, 0x0F, 0x03, 0xC0, 0x07,
  0x81, 0xE0, 0x03, 0xC1, 0xF0, 0x01, 0xE0, 0xF8, 0x00, 0xF0, 0x78, 0x00,
  0x78, 0x3C, 0x00, 0x7C, 0x3E, 0x00, 0x3C, 0x1F, 0x00, 0x1E, 0x0F, 0x00,
  0x1F, 0x07, 0x80, 0x1F, 0x03, 0xC0, 0x0F, 0x83, 0xE0, 0x0F, 0x81, 0xE0,
  0x1F, 0x80, 0xF0, 0x3F, 0xC0, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x3F,
  0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x7F,
  0xFC, 0x03, 0xFF, 0xF8, 0x1F, 0xC1, 0xF0, 0x7E, 0x03, 0xE1, 0xF0, 0x07,
  0x87, 0xC0, 0x0F, 0x0F, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x78, 0x00, 0xF1,
  0xF0, 0x01, 0xE3, 0xC0, 0x03, 0xC7, 0x80, 0x0F, 0x9F, 0x00, 0x1E, 0x3E,
  0x00, 0x3C, 0x7C, 0x00, 0x78, 0xF0, 0x01, 0xF1, 0xE0, 0x03, 0xC3, 0xE0,
  0x07, 0x87, 0xC0, 0x0F, 0x07, 0x80, 0x1E, 0x0F, 0x80, 0x78, 0x1F, 0x83,
  0xF0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x0F, 0xCF, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0xF8,
  0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x0F, 0xC0, 0x08, 0x3E,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xF0,
  0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xE0, 0x18, 0x1F, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x20, 0x03, 0xE1, 0xE0, 0x3F, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0,
  0x7F, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x01,
  0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x07,
  0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3E,
  0x00, 0x03, 0xF0, 0x30, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x00,
  0x3F, 0x80, 0x0F, 0x00, 0x3E, 0x1E, 0x00, 0x78, 0x7C, 0x00, 0xF0, 0xF0,
  0x01, 0xE1, 0xE0, 0x07, 0xC3, 0xC0, 0x0F, 0x0F, 0x80, 0x1E, 0x1F, 0x00,
  0x3C, 0x3C, 0x00, 0xF8, 0x78, 0x01, 0xF1, 0xF0, 0x03, 0xC3, 0xE0, 0x07,
  0x87, 0x80, 0x1F, 0x0F, 0x00, 0x3E, 0x1E, 0x00, 0x78, 0x7C, 0x00, 0xF0,
  0xF8, 0x01, 0xE1, 0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0x83, 0xC0, 0x3F, 0x07,
  0xC1, 0xFE, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x0F, 0xFC, 0xF0, 0x07,
  0xE1, 0xE0, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xBC, 0x00, 0x7D, 0xE0, 0x03,
  0xCF, 0x80, 0x1E, 0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0x1F, 0x00, 0xF8, 0xF8,
  0x07, 0x83, 0xC0, 0x7C, 0x1E, 0x03, 0xC0, 0xF0, 0x3C, 0x07, 0x81, 0xE0,
  0x3C, 0x1E, 0x01, 0xE1, 0xF0, 0x0F, 0x8F, 0x00, 0x3C, 0xF0, 0x01, 0xEF,
  0x80, 0x0F, 0x78, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00,
  0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xCF, 0x00, 0x00, 0xF3,
  0xC0, 0x00, 0x78, 0xF0, 0x00, 0x1E, 0x78, 0x00, 0x07, 0x1E, 0x00, 0x03,
  0xC7, 0x81, 0xC0, 0xF1, 0xE0, 0xF0, 0x38, 0x78, 0x3C, 0x1E, 0x1E, 0x1F,
  0x07, 0x87, 0x87, 0xE1, 0xC1, 0xE3, 0xF8, 0xF0, 0x70, 0xEE, 0x38, 0x1C,
  0x73, 0x9E, 0x07, 0x3C, 0xE7, 0x83, 0xCE, 0x39, 0xC0, 0xF7, 0x8E, 0xF0,
  0x3D, 0xC3, 0xB8, 0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x3F, 0x80, 0xFC, 0x0F,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0x03,
  0xE0, 0x03, 0xE0, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0x7C, 0x0F,
  0x80, 0x0F, 0x81, 0xE0, 0x00, 0xF8, 0x78, 0x00, 0x1F, 0x1E, 0x00, 0x01,
  0xF7, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xDF, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x7C, 0x3E, 0x00,
  0x1F, 0x03, 0xC0, 0x07, 0xC0, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x7C, 0x00,
  0xF0, 0x1F, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8,
  0x07, 0xC0, 0x07, 0x80, 0x3E, 0x00, 0x3C, 0x01, 0xF0, 0x03, 0xE0, 0x0F,
  0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x0F, 0x80, 0x0F, 0x00,
  0x78, 0x00, 0x78, 0x07, 0xC0, 0x03, 0xC0, 0x3C, 0x00, 0x1F, 0x01, 0xE0,
  0x00, 0xF8, 0x1E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1E, 0x0F, 0x80, 0x00,
  0xF0, 0x78, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0xF3,
  0xC0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x04, 0x0F, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x07,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80,
  0x0F, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x0C, 0x3F, 0xC0, 0x3C, 0xFF, 0xE0, 0x71, 0xFF, 0xE1, 0xE7,
  0x87, 0xFF, 0x9E, 0x07, 0xFE, 0x3C, 0x07, 0xF8, 0x30, 0x03, 0xE0,
};

const GFXglyph UbuntuMono_Italic52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 26, 0, -1 },
  { 1, 13, 32, 26, 9, -32 },
  { 53, 15, 13, 26, 11, -35 },
  { 78, 28, 32, 26, 2, -32 },
  { 190, 24, 41, 26, 4, -36 },
  { 313, 31, 32, 26, 0, -32 },
  { 437, 23, 32, 26, 3, -32 },
  { 529, 6, 14, 26, 16, -35 },
  { 540, 19, 45, 26, 8, -36 },
  { 647, 20, 45, 26, 3, -36 },
  { 760, 20, 19, 26, 7, -32 },
  { 808, 22, 24, 26, 4, -26 },
  { 874, 12, 14, 26, 5, -7 },
  { 895, 13, 4, 26, 9, -15 },
  { 902, 8, 7, 26, 9, -7 },
  { 909, 30, 45, 26, -1, -36 },
  { 1078, 23, 32, 26, 4, -32 },
  { 1170, 19, 32, 26, 5, -32 },
  { 1246, 23, 32, 26, 4, -32 },
  { 1338, 24, 32, 26, 3, -32 },
  { 1434, 25, 32, 26, 2, -32 },
  { 1534, 26, 32, 26, 3, -32 },
  { 1638, 24, 32, 26, 5, -32 },
  { 1734, 24, 32, 26, 7, -32 },
  { 1830, 24, 32, 26, 4, -32 },
  { 1926, 24, 32, 26, 4, -32 },
  { 2022, 12, 24, 26, 9, -24 },
  { 2058, 16, 31, 26, 5, -24 },
  { 2120, 23, 21, 26, 4, -24 },
  { 2181, 24, 14, 26, 3, -21 },
  { 2223, 23, 21, 26, 3, -24 },
  { 2284, 19, 32, 26, 8, -32 },
  { 2360, 25, 39, 26, 4, -32 },
  { 2482, 25, 32, 26, -1, -32 },
  { 2582, 25, 32, 26, 2, -32 },
  { 2682, 25, 32, 26, 5, -32 },
  { 2782, 25, 32, 26, 2, -32 },
  { 2882, 25, 32, 26, 4, -32 },
  { 2982, 26, 32, 26, 4, -32 },
  { 3086, 25, 32, 26, 4, -32 },
  { 3186, 28, 32, 26, 2, -32 },
  { 3298, 24, 32, 26, 4, -32 },
  { 3394, 26, 32, 26, 3, -32 },
  { 3498, 29, 32, 26, 2, -32 },
  { 3614, 19, 32, 26, 3, -32 },
  { 3690, 28, 32, 26, 1, -32 },
  { 3802, 28, 32, 26, 2, -32 },
  { 3914, 24, 32, 26, 4, -32 },
  { 4010, 25, 32, 26, 3, -32 },
  { 4110, 24, 41, 26, 4, -32 },
  { 4233, 25, 32, 26, 2, -32 },
  { 4333, 25, 32, 26, 3, -32 },
  { 4433, 23, 32, 26, 8, -32 },
  { 4525, 26, 32, 26, 4, -32 },
  { 4629, 25, 32, 26, 7, -32 },
  { 4729, 28, 32, 26, 3, -32 },
  { 4841, 32, 32, 26, 0, -32 },
  { 4969, 24, 32, 26, 8, -32 },
  { 5065, 28, 32, 26, 2, -32 },
  { 5177, 23, 45, 26, 5, -36 },
  { 5307, 8, 45, 26, 11, -36 },
  { 5352, 24, 45, 26, 1, -36 },
  { 5487, 21, 17, 26, 6, -32 },
  { 5532, 24, 4, 26, -1, 5 },
  { 5544, 9, 9, 26, 14, -35 },
  { 5555, 23, 26, 26, 4, -25 },
  { 5630, 23, 37, 26, 3, -36 },
  { 5737, 23, 26, 26, 4, -25 },
  { 5812, 26, 37, 26, 4, -36 },
  { 5933, 22, 26, 26, 4, -25 },
  { 6005, 31, 45, 26, 0, -36 },
  { 6180, 27, 34, 26, 1, -25 },
  { 6295, 23, 36, 26, 2, -36 },
  { 6399, 15, 35, 26, 7, -35 },
  { 6465, 25, 44, 26, 1, -35 },
  { 6603, 25, 36, 26, 3, -36 },
  { 6716, 14, 37, 26, 9, -36 },
  { 6781, 25, 25, 26, 2, -25 },
  { 6860, 23, 25, 26, 3, -25 },
  { 6932, 22, 26, 26, 4, -25 },
  { 7004, 25, 34, 26, 1, -25 },
  { 7111, 23, 34, 26, 4, -25 },
  { 7209, 22, 25, 26, 5, -25 },
  { 7278, 22, 26, 26, 4, -25 },
  { 7350, 20, 32, 26, 7, -31 },
  { 7430, 23, 25, 26, 4, -24 },
  { 7502, 21, 24, 26, 7, -24 },
  { 7565, 26, 24, 26, 4, -24 },
  { 7643, 27, 24, 26, 1, -24 },
  { 7724, 29, 33, 26, -1, -24 },
  { 7844, 23, 24, 26, 3, -24 },
  { 7913, 25, 45, 26, 5, -36 },
  { 8054, 15, 45, 26, 8, -36 },
  { 8139, 25, 45, 26, 0, -36 },
  { 8280, 23, 8, 26, 4, -18 },
};

const GFXfont UbuntuMono_Italic52pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Italic52pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Italic52pt7bGlyphs,
  0x20, 0x7E, 52
};

#endif // _UBUNTUMONO_ITALIC52PT7B_H_
