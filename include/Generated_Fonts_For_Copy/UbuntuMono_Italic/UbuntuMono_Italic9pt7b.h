#ifndef _UBUNTUMONO_ITALIC9PT7B_H_
#define _UBUNTUMONO_ITALIC9PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Italic.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Italic9pt7bBitmaps[] PROGMEM = {
  0x00, 0x6A, 0x20, 0xB8, 0x29, 0x5E, 0xAF, 0xB0, 0x27, 0x86, 0x2E, 0x40,
  0x6B, 0x98, 0x76, 0xC8, 0x76, 0xFB, 0xC0, 0xC0, 0x12, 0x48, 0x88, 0x84,
  0x21, 0x11, 0x12, 0x24, 0x4F, 0x60, 0x24, 0xE4, 0x40, 0x60, 0xC0, 0x80,
  0x08, 0x84, 0x44, 0x22, 0x00, 0x69, 0xD9, 0xAC, 0x2C, 0xA5, 0xC0, 0x61,
  0x26, 0x8E, 0x61, 0x62, 0x2E, 0x11, 0x94, 0xA7, 0x08, 0x39, 0x0C, 0x21,
  0x30, 0x34, 0xE9, 0xAE, 0x71, 0x24, 0x48, 0x79, 0x6A, 0xAE, 0x69, 0x9F,
  0x2C, 0xC2, 0x60, 0x28, 0x3C, 0x60, 0xF0, 0xE0, 0xC3, 0xC0, 0x61, 0x24,
  0x0C, 0x79, 0xBD, 0xDE, 0xC0, 0x13, 0x55, 0x79, 0x3A, 0x5C, 0xA5, 0x38,
  0x78, 0x88, 0x8E, 0x32, 0x52, 0x99, 0x70, 0x74, 0xE8, 0x8E, 0x74, 0x8E,
  0x88, 0x78, 0x8A, 0xAE, 0x4A, 0x52, 0xE5, 0x48, 0x72, 0x44, 0x4E, 0x71,
  0x12, 0x2C, 0x4A, 0x98, 0xC5, 0x48, 0x24, 0x44, 0x47, 0x2B, 0x5E, 0xD8,
  0xC8, 0x2B, 0x5A, 0xD5, 0x48, 0x79, 0x99, 0xAC, 0x3A, 0x52, 0xE4, 0x40,
  0x79, 0x99, 0xAE, 0x60, 0x32, 0x52, 0xE5, 0x48, 0x3A, 0x08, 0x21, 0x38,
  0xF2, 0x44, 0x44, 0x99, 0x9A, 0xAE, 0x94, 0xA9, 0x4C, 0x20, 0x99, 0xDA,
  0xAA, 0x29, 0x4C, 0x65, 0x48, 0x94, 0x98, 0x84, 0x20, 0x38, 0x44, 0x44,
  0x78, 0x34, 0x44, 0x88, 0xC0, 0xFE, 0x31, 0x12, 0x22, 0xE0, 0x26, 0x90,
  0xF0, 0x90, 0x6A, 0xAE, 0x44, 0xE9, 0xAC, 0x68, 0x8E, 0x11, 0x79, 0xAE,
  0x6E, 0x8E, 0x18, 0x8E, 0x42, 0x23, 0x00, 0x3A, 0x54, 0xEF, 0x00, 0x24,
  0x75, 0x59, 0x63, 0x24, 0xC0, 0x10, 0x0C, 0x21, 0x13, 0x80, 0x44, 0xAC,
  0xCA, 0xEA, 0xB0, 0x7B, 0x5B, 0x20, 0xF6, 0xD0, 0x69, 0xAE, 0x72, 0x54,
  0xC8, 0x00, 0x79, 0xAE, 0x20, 0x78, 0x88, 0x64, 0x2E, 0x4F, 0x48, 0x60,
  0x9A, 0xAE, 0x9A, 0xA4, 0x9D, 0xAA, 0x51, 0x08, 0xA0, 0x4A, 0x88, 0x4C,
  0x00, 0x76, 0x8E, 0x34, 0x48, 0x48, 0xC0, 0x25, 0x24, 0xA0, 0x31, 0x11,
  0x22, 0xC0, 0xDA,
};

const GFXglyph UbuntuMono_Italic9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 2, 6, 5, 2, -6 },
  { 3, 3, 2, 5, 2, -6 },
  { 4, 5, 6, 5, 0, -6 },
  { 8, 4, 7, 5, 1, -6 },
  { 12, 5, 6, 5, 0, -6 },
  { 16, 3, 6, 5, 1, -6 },
  { 19, 1, 2, 5, 3, -6 },
  { 20, 4, 8, 5, 1, -6 },
  { 24, 4, 8, 5, 0, -6 },
  { 28, 4, 3, 5, 1, -6 },
  { 30, 4, 5, 5, 1, -5 },
  { 33, 2, 2, 5, 1, -1 },
  { 34, 2, 1, 5, 2, -3 },
  { 35, 1, 1, 5, 2, -1 },
  { 36, 5, 7, 5, 0, -6 },
  { 41, 4, 6, 5, 1, -6 },
  { 44, 3, 6, 5, 1, -6 },
  { 47, 4, 6, 5, 1, -6 },
  { 50, 4, 6, 5, 1, -6 },
  { 53, 5, 6, 5, 0, -6 },
  { 57, 5, 6, 5, 0, -6 },
  { 61, 4, 6, 5, 1, -6 },
  { 64, 4, 6, 5, 1, -6 },
  { 67, 4, 6, 5, 1, -6 },
  { 70, 4, 6, 5, 1, -6 },
  { 73, 2, 4, 5, 2, -4 },
  { 74, 3, 5, 5, 1, -4 },
  { 76, 4, 3, 5, 1, -5 },
  { 78, 4, 3, 5, 1, -4 },
  { 80, 4, 3, 5, 1, -5 },
  { 82, 4, 6, 5, 1, -6 },
  { 85, 4, 7, 5, 1, -6 },
  { 89, 4, 6, 5, 0, -6 },
  { 92, 5, 6, 5, 0, -6 },
  { 96, 4, 6, 5, 1, -6 },
  { 99, 5, 6, 5, 0, -6 },
  { 103, 4, 6, 5, 1, -6 },
  { 106, 4, 6, 5, 1, -6 },
  { 109, 4, 6, 5, 1, -6 },
  { 112, 5, 6, 5, 0, -6 },
  { 116, 4, 6, 5, 1, -6 },
  { 119, 4, 6, 5, 1, -6 },
  { 122, 5, 6, 5, 0, -6 },
  { 126, 4, 6, 5, 0, -6 },
  { 129, 5, 6, 5, 0, -6 },
  { 133, 5, 6, 5, 0, -6 },
  { 137, 4, 6, 5, 1, -6 },
  { 140, 5, 6, 5, 0, -6 },
  { 144, 4, 7, 5, 1, -6 },
  { 148, 5, 6, 5, 0, -6 },
  { 152, 5, 6, 5, 0, -6 },
  { 156, 4, 6, 5, 1, -6 },
  { 159, 4, 6, 5, 1, -6 },
  { 162, 5, 6, 5, 1, -6 },
  { 166, 4, 6, 5, 1, -6 },
  { 169, 5, 6, 5, 0, -6 },
  { 173, 5, 6, 5, 1, -6 },
  { 177, 5, 6, 5, 0, -6 },
  { 181, 4, 7, 5, 1, -6 },
  { 185, 1, 7, 5, 2, -6 },
  { 186, 4, 7, 5, 0, -6 },
  { 190, 4, 3, 5, 1, -6 },
  { 192, 4, 1, 5, 0, 1 },
  { 193, 2, 2, 5, 2, -7 },
  { 194, 4, 4, 5, 1, -4 },
  { 196, 4, 6, 5, 1, -6 },
  { 199, 4, 4, 5, 1, -4 },
  { 201, 4, 6, 5, 1, -6 },
  { 204, 4, 4, 5, 1, -4 },
  { 206, 5, 7, 5, 0, -6 },
  { 211, 5, 5, 5, 0, -4 },
  { 215, 4, 6, 5, 0, -6 },
  { 218, 3, 6, 5, 1, -6 },
  { 221, 5, 7, 5, 0, -6 },
  { 226, 4, 6, 5, 1, -6 },
  { 229, 2, 6, 5, 2, -6 },
  { 231, 5, 4, 5, 0, -4 },
  { 234, 3, 4, 5, 1, -4 },
  { 236, 4, 4, 5, 1, -4 },
  { 238, 5, 5, 5, 0, -4 },
  { 242, 4, 5, 5, 1, -4 },
  { 245, 4, 4, 5, 1, -4 },
  { 247, 4, 4, 5, 1, -4 },
  { 249, 4, 5, 5, 1, -5 },
  { 252, 4, 4, 5, 1, -4 },
  { 254, 4, 4, 5, 1, -4 },
  { 256, 4, 4, 5, 1, -4 },
  { 258, 5, 4, 5, 0, -4 },
  { 261, 5, 5, 5, 0, -4 },
  { 265, 4, 4, 5, 1, -4 },
  { 267, 4, 7, 5, 1, -6 },
  { 271, 3, 7, 5, 1, -6 },
  { 274, 4, 7, 5, 0, -6 },
  { 278, 4, 2, 5, 1, -5 },
};

const GFXfont UbuntuMono_Italic9pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Italic9pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Italic9pt7bGlyphs,
  0x20, 0x7E, 9
};

#endif // _UBUNTUMONO_ITALIC9PT7B_H_
