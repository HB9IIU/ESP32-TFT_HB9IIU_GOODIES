#ifndef _UBUNTUMONO_ITALIC8PT7B_H_
#define _UBUNTUMONO_ITALIC8PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Italic.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Italic8pt7bBitmaps[] PROGMEM = {
  0x00, 0x54, 0x80, 0xD0, 0x33, 0x95, 0xEA, 0x00, 0x2E, 0x23, 0xA0, 0x6A,
  0x88, 0xAB, 0x00, 0x35, 0x7A, 0x50, 0xC0, 0x2A, 0x49, 0x10, 0x24, 0x92,
  0x70, 0x5D, 0x80, 0x5D, 0x00, 0xE0, 0xC0, 0xC0, 0x11, 0x22, 0x44, 0x80,
  0x77, 0xDC, 0x39, 0x2C, 0xE5, 0xCE, 0x31, 0x21, 0x60, 0x13, 0x5F, 0x20,
  0x32, 0x61, 0x60, 0x73, 0xDC, 0x72, 0x44, 0x80, 0x75, 0xDC, 0x77, 0x9C,
  0x43, 0x43, 0x80, 0x71, 0x00, 0x70, 0x70, 0x43, 0x40, 0x65, 0x08, 0x77,
  0xDF, 0x80, 0x23, 0x57, 0x90, 0x75, 0x65, 0xE0, 0x78, 0x88, 0xE0, 0x75,
  0x59, 0xE0, 0x68, 0xE8, 0xE0, 0x78, 0xE8, 0x80, 0x72, 0x5E, 0x4A, 0x9D,
  0x29, 0x00, 0x69, 0x2C, 0x64, 0x9C, 0x53, 0x10, 0xC9, 0x00, 0x49, 0x26,
  0x55, 0x79, 0x90, 0x4B, 0x9D, 0x29, 0x00, 0x76, 0xDC, 0x35, 0x57, 0x80,
  0x76, 0xDC, 0x80, 0x75, 0x76, 0x90, 0x34, 0x21, 0xE0, 0xF4, 0x44, 0x80,
  0x9A, 0xAA, 0xC0, 0x9A, 0xAC, 0xC0, 0x4A, 0x5C, 0xAA, 0x00, 0x49, 0x88,
  0xA9, 0x00, 0x9A, 0x44, 0x80, 0x38, 0x88, 0x8F, 0x00, 0x69, 0x49, 0x30,
  0xFE, 0x31, 0x22, 0x22, 0xC0, 0x4E, 0x80, 0xE0, 0xC0, 0x76, 0xF0, 0x24,
  0x75, 0x56, 0x72, 0x60, 0x11, 0x6A, 0xAE, 0xFE, 0x60, 0x19, 0x1C, 0x44,
  0x23, 0x00, 0x35, 0x57, 0xE0, 0x44, 0x75, 0x59, 0x4D, 0x50, 0x10, 0x31,
  0x22, 0xC0, 0x24, 0x74, 0x69, 0x49, 0x28, 0xC0, 0x77, 0xB9, 0x75, 0x59,
  0xF6, 0xE0, 0x75, 0x56, 0x80, 0x76, 0xE4, 0x72, 0x40, 0x78, 0xE0, 0x5D,
  0x46, 0xB6, 0xF0, 0xB7, 0x60, 0x9E, 0xEC, 0x52, 0x25, 0x55, 0x22, 0xC0,
  0x72, 0x46, 0x34, 0x48, 0x88, 0xC0, 0x29, 0x25, 0x20, 0x21, 0x23, 0x24,
  0xC0, 0xBC,
};

const GFXglyph UbuntuMono_Italic8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 2, 5, 4, 1, -5 },
  { 3, 2, 2, 4, 2, -5 },
  { 4, 5, 5, 4, 0, -5 },
  { 8, 3, 7, 4, 1, -6 },
  { 11, 5, 5, 4, 0, -5 },
  { 15, 4, 5, 4, 0, -5 },
  { 18, 1, 2, 4, 2, -5 },
  { 19, 3, 7, 4, 1, -6 },
  { 22, 3, 7, 4, 0, -6 },
  { 25, 3, 3, 4, 1, -5 },
  { 27, 3, 3, 4, 1, -3 },
  { 29, 2, 2, 4, 1, -1 },
  { 30, 2, 1, 4, 1, -3 },
  { 31, 2, 1, 4, 1, -1 },
  { 32, 4, 7, 4, 0, -6 },
  { 36, 3, 5, 4, 1, -5 },
  { 38, 3, 5, 4, 1, -5 },
  { 40, 3, 5, 4, 1, -5 },
  { 42, 4, 5, 4, 0, -5 },
  { 45, 4, 5, 4, 0, -5 },
  { 48, 4, 5, 4, 0, -5 },
  { 51, 3, 5, 4, 1, -5 },
  { 53, 4, 5, 4, 1, -5 },
  { 56, 3, 5, 4, 1, -5 },
  { 58, 3, 5, 4, 1, -5 },
  { 60, 2, 4, 4, 1, -4 },
  { 61, 2, 5, 4, 1, -4 },
  { 63, 3, 3, 4, 1, -4 },
  { 65, 4, 3, 4, 0, -4 },
  { 67, 4, 3, 4, 0, -4 },
  { 69, 3, 5, 4, 1, -5 },
  { 71, 3, 6, 4, 1, -5 },
  { 74, 4, 5, 4, 0, -5 },
  { 77, 4, 5, 4, 0, -5 },
  { 80, 4, 5, 4, 1, -5 },
  { 83, 4, 5, 4, 0, -5 },
  { 86, 4, 5, 4, 1, -5 },
  { 89, 4, 5, 4, 1, -5 },
  { 92, 3, 5, 4, 1, -5 },
  { 94, 5, 5, 4, 0, -5 },
  { 98, 3, 5, 4, 1, -5 },
  { 100, 3, 5, 4, 1, -5 },
  { 102, 5, 5, 4, 0, -5 },
  { 106, 3, 5, 4, 0, -5 },
  { 108, 4, 5, 4, 0, -5 },
  { 111, 5, 5, 4, 0, -5 },
  { 115, 3, 5, 4, 1, -5 },
  { 117, 4, 5, 4, 0, -5 },
  { 120, 3, 6, 4, 1, -5 },
  { 123, 4, 5, 4, 0, -5 },
  { 126, 4, 5, 4, 0, -5 },
  { 129, 4, 5, 4, 1, -5 },
  { 132, 4, 5, 4, 1, -5 },
  { 135, 4, 5, 4, 1, -5 },
  { 138, 5, 5, 4, 0, -5 },
  { 142, 5, 5, 4, 0, -5 },
  { 146, 4, 5, 4, 1, -5 },
  { 149, 5, 5, 4, 0, -5 },
  { 153, 3, 7, 4, 1, -6 },
  { 156, 1, 7, 4, 2, -6 },
  { 157, 4, 7, 4, 0, -6 },
  { 161, 3, 3, 4, 1, -5 },
  { 163, 4, 1, 4, 0, 1 },
  { 164, 1, 2, 4, 2, -6 },
  { 165, 3, 4, 4, 1, -4 },
  { 167, 4, 6, 4, 0, -6 },
  { 170, 3, 4, 4, 1, -4 },
  { 172, 4, 6, 4, 1, -6 },
  { 175, 3, 4, 4, 1, -4 },
  { 177, 5, 7, 4, 0, -6 },
  { 182, 4, 5, 4, 0, -4 },
  { 185, 4, 6, 4, 0, -6 },
  { 188, 2, 6, 4, 1, -6 },
  { 190, 4, 7, 4, 0, -6 },
  { 194, 4, 6, 4, 0, -6 },
  { 197, 3, 6, 4, 1, -6 },
  { 200, 4, 4, 4, 0, -4 },
  { 202, 4, 4, 4, 0, -4 },
  { 204, 3, 4, 4, 1, -4 },
  { 206, 4, 5, 4, 0, -4 },
  { 209, 3, 5, 4, 1, -4 },
  { 211, 3, 4, 4, 1, -4 },
  { 213, 3, 4, 4, 1, -4 },
  { 215, 3, 5, 4, 1, -5 },
  { 217, 3, 4, 4, 1, -4 },
  { 219, 3, 4, 4, 1, -4 },
  { 221, 4, 4, 4, 1, -4 },
  { 223, 4, 4, 4, 0, -4 },
  { 225, 4, 5, 4, 0, -4 },
  { 228, 4, 4, 4, 0, -4 },
  { 230, 4, 7, 4, 1, -6 },
  { 234, 3, 7, 4, 1, -6 },
  { 237, 4, 7, 4, 0, -6 },
  { 241, 3, 2, 4, 1, -4 },
};

const GFXfont UbuntuMono_Italic8pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Italic8pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Italic8pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _UBUNTUMONO_ITALIC8PT7B_H_
