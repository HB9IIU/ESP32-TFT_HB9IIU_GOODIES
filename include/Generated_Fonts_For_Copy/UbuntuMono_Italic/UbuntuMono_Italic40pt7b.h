#ifndef _UBUNTUMONO_ITALIC40PT7B_H_
#define _UBUNTUMONO_ITALIC40PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Italic.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Italic40pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0x80, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xC0, 0x70, 0x3C, 0x0F,
  0x03, 0x80, 0xE0, 0x78, 0x1E, 0x07, 0x01, 0xC0, 0x70, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x3E, 0x0F, 0x83, 0xE0, 0x70, 0x00, 0x78, 0xEE, 0x1D,
  0xC3, 0xB8, 0xE6, 0x1D, 0xC3, 0xB8, 0x66, 0x0C, 0xC1, 0x98, 0x20, 0x00,
  0x38, 0x38, 0x01, 0xC3, 0x80, 0x1C, 0x1C, 0x00, 0xE1, 0xC0, 0x0F, 0x0E,
  0x00, 0x70, 0x70, 0x03, 0x87, 0x03, 0xFF, 0xFE, 0x3F, 0xFF, 0xF1, 0xFF,
  0xFF, 0x80, 0xE1, 0xE0, 0x07, 0x0E, 0x00, 0x70, 0x70, 0x03, 0x87, 0x00,
  0x38, 0x38, 0x01, 0xC3, 0x80, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF,
  0xF0, 0x70, 0x70, 0x03, 0x87, 0x00, 0x38, 0x38, 0x01, 0xC3, 0x80, 0x1C,
  0x1C, 0x00, 0xE1, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x7F, 0x00, 0x7F, 0xF0, 0x7F, 0xFC, 0x1E, 0x06, 0x0F,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC4, 0x00, 0xE1, 0xC0, 0xF8, 0xFF,
  0xFC, 0x3F, 0xFE, 0x01, 0xFE, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x01, 0xF0, 0x07, 0x03, 0xF8, 0x0E, 0x07,
  0xF8, 0x1C, 0x07, 0x38, 0x38, 0x0E, 0x18, 0x70, 0x0E, 0x38, 0x70, 0x0C,
  0x38, 0xE0, 0x0C, 0x39, 0xC0, 0x0E, 0x73, 0x80, 0x0F, 0xF7, 0x00, 0x07,
  0xEE, 0x00, 0x07, 0xCC, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x39, 0xE0, 0x00,
  0x73, 0xF0, 0x00, 0xE7, 0xF0, 0x01, 0xCE, 0x30, 0x01, 0x8E, 0x30, 0x03,
  0x8C, 0x30, 0x07, 0x1C, 0x30, 0x0E, 0x1C, 0x70, 0x1C, 0x1C, 0xF0, 0x38,
  0x1F, 0xE0, 0x70, 0x0F, 0xC0, 0x70, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x3F,
  0xC0, 0x1F, 0xF0, 0x0F, 0x1E, 0x07, 0x87, 0x81, 0xC1, 0xC0, 0x70, 0x70,
  0x1C, 0x1C, 0x07, 0x0E, 0x01, 0xCF, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07,
  0xC1, 0xC3, 0xF8, 0xE1, 0xCE, 0x38, 0xE1, 0xDC, 0x70, 0x7F, 0x1C, 0x0F,
  0x8F, 0x03, 0xE3, 0xC0, 0x70, 0xF0, 0x3E, 0x3E, 0x3F, 0x87, 0xFF, 0xF0,
  0xFF, 0x1C, 0x1F, 0x07, 0x00, 0x3B, 0xDE, 0xE7, 0x39, 0xDC, 0xE7, 0x30,
  0x00, 0x04, 0x00, 0x38, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0,
  0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00,
  0x1E, 0x00, 0x1C, 0x00, 0x10, 0x00, 0x00, 0x40, 0x01, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80,
  0x0E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x00, 0xE0, 0x01, 0x00, 0x00,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x0C, 0x38, 0x5E, 0x67, 0xBF,
  0xDF, 0xBF, 0xFC, 0x07, 0x80, 0x1F, 0x80, 0x7B, 0x80, 0xE7, 0x83, 0xC7,
  0x87, 0x0E, 0x06, 0x08, 0x00, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0xFF, 0xFF, 0x7F, 0xFF,
  0xBF, 0xFF, 0xC0, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x0F, 0xC7, 0xE3, 0xF0, 0xF8,
  0x38, 0x7D, 0xFC, 0xF8, 0x70, 0x00, 0x7F, 0xBF, 0xEF, 0xF8, 0x7B, 0xFF,
  0xFF, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0xC0,
  0x3F, 0xF8, 0x1F, 0x1E, 0x0F, 0x03, 0xC3, 0x80, 0xF1, 0xE0, 0x1C, 0x70,
  0x07, 0x3C, 0x01, 0xCE, 0x38, 0xF3, 0x9F, 0x3D, 0xE7, 0xCF, 0x71, 0xE3,
  0x9C, 0x38, 0xE7, 0x00, 0x7B, 0xC0, 0x1C, 0xF0, 0x07, 0x3C, 0x03, 0xCF,
  0x00, 0xE3, 0xC0, 0x78, 0x70, 0x3C, 0x1E, 0x1E, 0x07, 0xFF, 0x00, 0xFF,
  0x80, 0x1F, 0x80, 0x00, 0x00, 0x1C, 0x00, 0xF0, 0x07, 0xC0, 0x7E, 0x07,
  0xF8, 0x7E, 0xE0, 0xE7, 0x82, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x0F, 0xFF, 0xFF, 0xFE, 0xFF, 0xF8,
  0x00, 0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0xF8, 0x1C, 0x1F, 0x04, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1C,
  0x00, 0x0F, 0xFF, 0xE3, 0xFF, 0xF8, 0xFF, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x3F, 0xF0, 0x0F, 0xFF, 0x01, 0xC1, 0xE0, 0x10, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x03, 0xFC, 0x00,
  0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0xC0,
  0x7C, 0x1F, 0xFF, 0x87, 0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0x01, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1E, 0xE0, 0x0F,
  0x38, 0x07, 0x9E, 0x03, 0xC7, 0x01, 0xE1, 0xC0, 0x70, 0x70, 0x38, 0x1C,
  0x1C, 0x0E, 0x0F, 0x03, 0x83, 0x80, 0xE1, 0xC0, 0x38, 0xFF, 0xFF, 0xBF,
  0xFF, 0xEF, 0xFF, 0xF8, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00,
  0xFF, 0xF0, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x7E, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xE0,
  0x00, 0x7F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x06, 0x03,
  0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x80, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xC0,
  0x0F, 0xF0, 0x0F, 0xFC, 0x07, 0xE0, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0xFC, 0x07, 0xFF, 0xC1, 0xFF, 0xF8,
  0x78, 0x1E, 0x3C, 0x03, 0xCE, 0x00, 0xF3, 0x80, 0x3C, 0xE0, 0x0F, 0x38,
  0x03, 0xCE, 0x00, 0xE3, 0x80, 0x78, 0xF0, 0x3C, 0x3E, 0x1F, 0x07, 0xFF,
  0x80, 0xFF, 0xC0, 0x1F, 0xC0, 0x00, 0x3F, 0xFF, 0x8F, 0xFF, 0xE3, 0xFF,
  0xF8, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0,
  0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x03, 0xE1,
  0xE0, 0xF0, 0x1C, 0x1C, 0x03, 0xC3, 0x80, 0x70, 0x70, 0x0E, 0x0E, 0x03,
  0xC1, 0xE0, 0xF0, 0x3E, 0x3C, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x1E, 0xFC,
  0x0F, 0x07, 0xC3, 0xC0, 0x78, 0x70, 0x07, 0x1E, 0x00, 0xE3, 0x80, 0x1C,
  0x70, 0x07, 0x8F, 0x00, 0xE1, 0xF0, 0x7C, 0x1F, 0xFF, 0x01, 0xFF, 0xC0,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x3E, 0x0F,
  0x0F, 0x01, 0xC7, 0x80, 0x71, 0xC0, 0x1C, 0x70, 0x07, 0x3C, 0x01, 0xCF,
  0x00, 0x71, 0xC0, 0x1C, 0x78, 0x1F, 0x1F, 0xFF, 0xC3, 0xFF, 0xE0, 0x3F,
  0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x01, 0xFC, 0x0F, 0xFC, 0x03, 0xFC, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x0F, 0xC7, 0xE3, 0xF0, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xC3, 0xF1, 0xF8, 0xFC, 0x38, 0x00, 0x01, 0xE0, 0x3F,
  0x03, 0xF0, 0x3F, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x1F, 0x81, 0xF8, 0x1F, 0x80, 0xF8,
  0x07, 0x01, 0xF0, 0xFE, 0x0F, 0x80, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0xF0, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xFC, 0x03, 0xF8, 0x01,
  0xF8, 0x00, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x03,
  0xFC, 0x00, 0x3F, 0x80, 0x03, 0xC0, 0x00, 0x10, 0x3F, 0xFF, 0xCF, 0xFF,
  0xF7, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xF0, 0x0C, 0x00, 0x03,
  0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0xC0,
  0x3F, 0x80, 0x3F, 0x80, 0x07, 0x00, 0x01, 0x00, 0x00, 0x0F, 0xE0, 0xFF,
  0xC3, 0xFF, 0x84, 0x1F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x03, 0xE0, 0x0F,
  0x80, 0x3C, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0xF8, 0x07, 0xFF,
  0x03, 0xE0, 0xF0, 0x78, 0x0E, 0x1E, 0x01, 0xC7, 0x80, 0x38, 0xE0, 0x07,
  0x3C, 0x1F, 0xE7, 0x0F, 0xFD, 0xE3, 0xFF, 0xB8, 0xF8, 0xE7, 0x1C, 0x1D,
  0xE7, 0x83, 0xB8, 0xE0, 0xF7, 0x1C, 0x1C, 0xE3, 0x83, 0x9C, 0x70, 0x73,
  0x8E, 0x1E, 0x71, 0xE3, 0x8E, 0x1F, 0xF1, 0xC3, 0xFE, 0x38, 0x1F, 0x87,
  0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0xF8, 0x01,
  0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0xFC, 0x00, 0x1D, 0xE0, 0x01, 0xCE, 0x00, 0x38, 0xE0, 0x03,
  0x8E, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0xE0, 0xE0, 0x1E, 0x0E, 0x01,
  0xC0, 0xE0, 0x3C, 0x0E, 0x03, 0x80, 0xE0, 0x78, 0x0E, 0x07, 0xFF, 0xE0,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF1, 0xE0, 0x0F, 0x1C, 0x00, 0xF3, 0xC0, 0x0F,
  0x38, 0x00, 0xF7, 0x80, 0x0F, 0x70, 0x00, 0xF0, 0x07, 0xFE, 0x00, 0xFF,
  0xF0, 0x1F, 0xFF, 0x03, 0x81, 0xF0, 0xF0, 0x1E, 0x1E, 0x01, 0xC3, 0x80,
  0x38, 0x70, 0x0F, 0x0E, 0x01, 0xC3, 0xC0, 0x78, 0x70, 0x3E, 0x0F, 0xFF,
  0x81, 0xFF, 0xC0, 0x7F, 0xFE, 0x0F, 0x03, 0xE1, 0xC0, 0x1C, 0x38, 0x03,
  0x8F, 0x00, 0x71, 0xC0, 0x0E, 0x38, 0x03, 0xC7, 0x00, 0xF8, 0xE0, 0x7E,
  0x3F, 0xFF, 0x87, 0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x3F,
  0xF8, 0x0F, 0xFF, 0x83, 0xE0, 0xE0, 0xF0, 0x04, 0x3C, 0x00, 0x0F, 0x00,
  0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x18,
  0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x3F,
  0xF8, 0x03, 0xFF, 0xC0, 0x78, 0x3E, 0x07, 0x81, 0xE0, 0x70, 0x0E, 0x07,
  0x00, 0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0x70,
  0xE0, 0x0F, 0x1E, 0x00, 0xF1, 0xC0, 0x0E, 0x1C, 0x00, 0xE1, 0xC0, 0x1E,
  0x3C, 0x01, 0xE3, 0x80, 0x3C, 0x38, 0x03, 0x83, 0x80, 0x78, 0x78, 0x1F,
  0x07, 0x07, 0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFE, 0x01, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF,
  0xE0, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x1F, 0xFC, 0x0F, 0xFF,
  0x83, 0xF0, 0x70, 0xF8, 0x04, 0x1C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01,
  0xE0, 0x07, 0x3C, 0x01, 0xE7, 0x80, 0x38, 0xF0, 0x07, 0x1E, 0x01, 0xE3,
  0xC0, 0x3C, 0x38, 0x07, 0x07, 0x80, 0xE0, 0xF8, 0x3C, 0x0F, 0xFF, 0x80,
  0xFF, 0xE0, 0x07, 0xF0, 0x00, 0x03, 0xC0, 0x1C, 0x0E, 0x00, 0xF0, 0x38,
  0x03, 0x80, 0xE0, 0x0E, 0x07, 0x80, 0x38, 0x1C, 0x00, 0xE0, 0x70, 0x07,
  0x81, 0xC0, 0x1C, 0x0F, 0x00, 0x70, 0x3C, 0x01, 0xC0, 0xE0, 0x0F, 0x03,
  0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x81, 0xC0, 0x1E, 0x07, 0x00,
  0x70, 0x3C, 0x01, 0xC0, 0xF0, 0x07, 0x03, 0x80, 0x3C, 0x0E, 0x00, 0xE0,
  0x78, 0x03, 0x81, 0xE0, 0x0E, 0x07, 0x00, 0x78, 0x1C, 0x01, 0xC0, 0x70,
  0x07, 0x00, 0x03, 0xFF, 0xE0, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0E, 0x04, 0x03, 0xC1, 0xE1, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0x80, 0x78, 0x1E, 0x03, 0xC0, 0x70, 0x1E, 0x01, 0xC0,
  0xF0, 0x07, 0x07, 0x80, 0x3C, 0x3C, 0x00, 0xE1, 0xE0, 0x03, 0x8F, 0x00,
  0x0E, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x77, 0x80, 0x03, 0x8F, 0x00, 0x0E, 0x3C, 0x00, 0x38, 0x78,
  0x00, 0xE0, 0xE0, 0x07, 0x83, 0xC0, 0x1C, 0x07, 0x00, 0x70, 0x1E, 0x01,
  0xC0, 0x38, 0x0F, 0x00, 0xF0, 0x38, 0x01, 0xC0, 0xE0, 0x07, 0x80, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0,
  0x07, 0x00, 0x0E, 0x00, 0x1F, 0xFF, 0xBF, 0xFF, 0xFF, 0xFC, 0x01, 0xE0,
  0x38, 0x0F, 0x03, 0xC0, 0x78, 0x1E, 0x07, 0xC1, 0xF0, 0x3E, 0x0F, 0x81,
  0xF0, 0xFC, 0x1D, 0x86, 0xC0, 0xCC, 0x76, 0x06, 0x63, 0x30, 0x73, 0x3B,
  0x83, 0x99, 0x9C, 0x18, 0xDC, 0xE1, 0xC6, 0xC7, 0x0E, 0x3C, 0x70, 0x71,
  0xE3, 0x87, 0x0E, 0x1C, 0x38, 0x00, 0xE1, 0xC0, 0x07, 0x1E, 0x00, 0x70,
  0xE0, 0x03, 0x87, 0x00, 0x1C, 0x38, 0x00, 0xE3, 0xC0, 0x0F, 0x1C, 0x00,
  0x70, 0xE0, 0x03, 0x80, 0x07, 0x80, 0x38, 0x3C, 0x01, 0xC1, 0xF0, 0x0E,
  0x0F, 0x80, 0xE0, 0xFC, 0x07, 0x07, 0x60, 0x38, 0x3B, 0x81, 0xC1, 0xDC,
  0x1C, 0x0C, 0xE0, 0xE0, 0xE3, 0x07, 0x07, 0x1C, 0x38, 0x38, 0xE3, 0x81,
  0xC7, 0x1C, 0x1C, 0x18, 0xE0, 0xE0, 0xE7, 0x07, 0x07, 0x30, 0x38, 0x3B,
  0x83, 0x80, 0xDC, 0x1C, 0x06, 0xE0, 0xE0, 0x3F, 0x07, 0x01, 0xF0, 0x70,
  0x0F, 0x83, 0x80, 0x3C, 0x1C, 0x01, 0xE0, 0xE0, 0x0E, 0x00, 0x00, 0x7E,
  0x00, 0x3F, 0xE0, 0x0F, 0xFE, 0x03, 0xE1, 0xE0, 0xF0, 0x1C, 0x3C, 0x03,
  0x87, 0x00, 0x79, 0xE0, 0x0F, 0x38, 0x01, 0xE7, 0x00, 0x3D, 0xE0, 0x07,
  0x38, 0x00, 0xE7, 0x00, 0x1C, 0xE0, 0x03, 0xBC, 0x00, 0xF7, 0x80, 0x1C,
  0xF0, 0x07, 0x9E, 0x00, 0xE3, 0xC0, 0x3C, 0x78, 0x07, 0x07, 0x01, 0xE0,
  0xF0, 0xF8, 0x1F, 0xFE, 0x01, 0xFF, 0x80, 0x0F, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xE0, 0x78, 0x3E, 0x07, 0x00, 0xE0, 0x70,
  0x0F, 0x07, 0x00, 0xF0, 0xF0, 0x0F, 0x0E, 0x00, 0xE0, 0xE0, 0x0E, 0x0E,
  0x01, 0xE1, 0xE0, 0x3C, 0x1C, 0x0F, 0x81, 0xFF, 0xF0, 0x1F, 0xFE, 0x03,
  0xFF, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x3F, 0xE0, 0x0F, 0xFE, 0x03, 0xE1, 0xE0, 0xF0,
  0x1C, 0x3C, 0x03, 0x87, 0x00, 0x79, 0xE0, 0x0F, 0x38, 0x01, 0xE7, 0x00,
  0x3D, 0xE0, 0x07, 0x38, 0x00, 0xE7, 0x00, 0x1C, 0xE0, 0x03, 0xBC, 0x00,
  0xF7, 0x80, 0x1C, 0xF0, 0x07, 0x9E, 0x00, 0xE3, 0xC0, 0x3C, 0x78, 0x07,
  0x07, 0x01, 0xE0, 0xF0, 0xF8, 0x1F, 0xFE, 0x01, 0xFF, 0x80, 0x0F, 0xC0,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0,
  0x00, 0x7E, 0x00, 0x01, 0x80, 0x03, 0xFE, 0x00, 0xFF, 0xF0, 0x1F, 0xFF,
  0x03, 0x81, 0xF0, 0x70, 0x1E, 0x1E, 0x01, 0xC3, 0xC0, 0x38, 0x70, 0x07,
  0x0E, 0x00, 0xE3, 0xC0, 0x3C, 0x78, 0x07, 0x0E, 0x01, 0xE1, 0xC0, 0xF8,
  0x3F, 0xFE, 0x0F, 0xFF, 0x81, 0xDF, 0xC0, 0x38, 0x38, 0x07, 0x07, 0x81,
  0xE0, 0x70, 0x38, 0x0E, 0x07, 0x01, 0xE0, 0xE0, 0x1C, 0x3C, 0x03, 0x87,
  0x00, 0x78, 0xE0, 0x07, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0xFF, 0x03, 0xFF,
  0xE0, 0x3C, 0x06, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x40, 0x0F, 0x07, 0x01, 0xF0,
  0xFF, 0xFE, 0x07, 0xFF, 0x80, 0x1F, 0xE0, 0x00, 0x7F, 0xFF, 0xBF, 0xFF,
  0xEF, 0xFF, 0xF8, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x70, 0xE0, 0x0F, 0x0E, 0x00,
  0xE1, 0xE0, 0x0E, 0x1E, 0x00, 0xE1, 0xC0, 0x1E, 0x1C, 0x01, 0xC1, 0xC0,
  0x1C, 0x3C, 0x01, 0xC3, 0x80, 0x3C, 0x38, 0x03, 0x83, 0x80, 0x38, 0x78,
  0x03, 0x87, 0x00, 0x78, 0x70, 0x07, 0x07, 0x00, 0x70, 0xF0, 0x07, 0x0F,
  0x00, 0xF0, 0xF0, 0x0E, 0x0F, 0x01, 0xE0, 0x70, 0x1E, 0x07, 0x87, 0xC0,
  0x7F, 0xF8, 0x03, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0xF0, 0x00, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0x38, 0x01, 0xE7, 0x00, 0x38, 0xE0, 0x0F, 0x1C, 0x01,
  0xC3, 0x80, 0x78, 0x70, 0x0E, 0x0E, 0x03, 0xC1, 0xC0, 0x70, 0x38, 0x1E,
  0x07, 0x03, 0x80, 0xE0, 0xF0, 0x1C, 0x1C, 0x03, 0x87, 0x80, 0x70, 0xE0,
  0x0E, 0x38, 0x01, 0xE7, 0x00, 0x3D, 0xC0, 0x03, 0xB8, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x1C, 0x38,
  0x00, 0xF0, 0xE0, 0x03, 0x83, 0x80, 0x0E, 0x0E, 0x00, 0x38, 0x78, 0x01,
  0xC1, 0xC0, 0x07, 0x07, 0x00, 0x1C, 0x1C, 0x00, 0x70, 0x71, 0xC3, 0x81,
  0x87, 0x0E, 0x0E, 0x3C, 0x38, 0x38, 0xF8, 0xC0, 0xE6, 0xE7, 0x03, 0x9B,
  0x9C, 0x0C, 0xCE, 0x60, 0x77, 0x1B, 0x81, 0xD8, 0x6E, 0x07, 0xE1, 0xB0,
  0x1B, 0x06, 0xC0, 0x7C, 0x1F, 0x01, 0xE0, 0x78, 0x07, 0x81, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1C, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x1E, 0x00, 0xF0, 0x3C, 0x00, 0x70, 0x78, 0x00, 0x78, 0x70, 0x00,
  0x78, 0xE0, 0x00, 0x39, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0xF7, 0x00, 0x01, 0xE7, 0x00, 0x03, 0xC3, 0x80, 0x03,
  0xC3, 0x80, 0x07, 0x83, 0x80, 0x0F, 0x03, 0xC0, 0x1E, 0x01, 0xC0, 0x3C,
  0x01, 0xC0, 0x38, 0x01, 0xE0, 0x78, 0x01, 0xE0, 0xE0, 0x01, 0xFC, 0x00,
  0x7B, 0x80, 0x0E, 0x78, 0x03, 0xC7, 0x00, 0xF0, 0xE0, 0x1C, 0x1C, 0x07,
  0x83, 0xC1, 0xE0, 0x38, 0x38, 0x07, 0x0E, 0x00, 0xE3, 0xC0, 0x0E, 0x70,
  0x01, 0xDC, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x1F,
  0xFF, 0xE0, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8,
  0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x00,
  0xE3, 0x8E, 0x38, 0xE3, 0xCF, 0x3C, 0xF1, 0xC7, 0x1C, 0x71, 0xC7, 0x1C,
  0x71, 0xC7, 0x9E, 0x79, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8F,
  0x3C, 0xF3, 0xC0, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E,
  0x00, 0x07, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x3D, 0xC0, 0x3C, 0xF0, 0x1C,
  0x38, 0x1C, 0x1C, 0x1E, 0x0F, 0x1E, 0x03, 0x9E, 0x01, 0xDE, 0x00, 0xF2,
  0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x20, 0xE1, 0xE1,
  0xE1, 0xE1, 0xC1, 0x00, 0x00, 0x7F, 0x00, 0xFF, 0xE0, 0x7F, 0xF8, 0x7E,
  0x0E, 0x1E, 0x07, 0x8F, 0x01, 0xC7, 0x80, 0x71, 0xC0, 0x1C, 0xF0, 0x0E,
  0x38, 0x03, 0x8E, 0x00, 0xE3, 0x80, 0x38, 0xE0, 0x1E, 0x38, 0x07, 0x0F,
  0x01, 0xC3, 0xE1, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xF8, 0xE0, 0x03,
  0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x7E, 0x03, 0xFF, 0x83, 0xFF,
  0xE1, 0xF0, 0xF8, 0xE0, 0x3C, 0x70, 0x0E, 0x78, 0x07, 0x38, 0x03, 0x9C,
  0x01, 0xCE, 0x00, 0xEF, 0x00, 0xF7, 0x00, 0x73, 0x80, 0x79, 0xC0, 0x78,
  0xE0, 0x7C, 0xE0, 0xFC, 0x7F, 0xF8, 0x3F, 0xF8, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0x01, 0xFF, 0xC3, 0xFF, 0xE3, 0xF0, 0x23, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x08, 0x7F, 0xFC, 0x1F,
  0xFE, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x07, 0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0x83,
  0x81, 0xE0, 0x38, 0x3C, 0x03, 0x83, 0x80, 0x70, 0x78, 0x07, 0x07, 0x00,
  0x70, 0x70, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x0E, 0x0F, 0x00, 0xE0, 0xF0,
  0x0E, 0x0F, 0x01, 0xE0, 0x78, 0x7E, 0x07, 0xFF, 0xE0, 0x3F, 0xEE, 0x01,
  0xF8, 0xE0, 0x00, 0xFC, 0x01, 0xFF, 0x83, 0xFF, 0xE3, 0xE0, 0xF3, 0xE0,
  0x39, 0xC0, 0x1D, 0xE0, 0x1E, 0xE0, 0x1F, 0xF0, 0x3F, 0x7F, 0xFF, 0x3F,
  0xFE, 0x1F, 0xF8, 0x0E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x08,
  0x7F, 0xFC, 0x1F, 0xFE, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x07, 0x82, 0x00, 0x0F, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x01, 0xFF,
  0xFC, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x00, 0x3C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x07, 0xFF, 0x01, 0xFF, 0xF0,
  0x3F, 0x0F, 0x07, 0xC0, 0xE0, 0xF0, 0x0E, 0x0F, 0x00, 0xE1, 0xE0, 0x1E,
  0x1C, 0x01, 0xC1, 0xC0, 0x1C, 0x1C, 0x01, 0xC3, 0xC0, 0x3C, 0x3C, 0x03,
  0x83, 0xC0, 0x38, 0x1E, 0x0F, 0x81, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x7E,
  0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x60,
  0x7C, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x03, 0xFC, 0x00, 0x01, 0xC0, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x0F, 0x00, 0x07, 0x7E, 0x03, 0xFF, 0x81, 0xFF, 0xE1, 0xE0,
  0xF8, 0xF0, 0x3C, 0x70, 0x0E, 0x38, 0x07, 0x1C, 0x03, 0x9E, 0x03, 0xCE,
  0x01, 0xE7, 0x00, 0xE3, 0x80, 0x73, 0xC0, 0x39, 0xC0, 0x3C, 0xE0, 0x1C,
  0x70, 0x0E, 0x78, 0x07, 0x38, 0x07, 0x9C, 0x03, 0x80, 0x01, 0xC0, 0x3E,
  0x03, 0xE0, 0x3E, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC7, 0xF8,
  0xFF, 0x80, 0x38, 0x07, 0x80, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0xF0, 0x7F,
  0x03, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00,
  0xF0, 0x18, 0x3C, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x07, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x78, 0x38,
  0x1E, 0x0F, 0x07, 0x81, 0xC1, 0xE0, 0x38, 0xF8, 0x07, 0x3C, 0x01, 0xEF,
  0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x1D, 0xE0, 0x07, 0x9E,
  0x00, 0xE1, 0xE0, 0x1C, 0x1C, 0x03, 0x83, 0xC0, 0xF0, 0x3C, 0x1C, 0x07,
  0x83, 0x80, 0x78, 0x70, 0x0F, 0x00, 0x7F, 0x9F, 0xF3, 0xFE, 0x03, 0xC0,
  0x70, 0x0E, 0x01, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xC0,
  0x38, 0x07, 0x01, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0xE0,
  0x1C, 0x03, 0x80, 0x78, 0x6F, 0xFC, 0xFF, 0x8F, 0xC0, 0x03, 0xE3, 0xC0,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xE3, 0xCF, 0x0E, 0x38, 0x71, 0xE3, 0x87,
  0x1C, 0x38, 0xE1, 0xC3, 0x8E, 0x1C, 0x70, 0xE3, 0xC7, 0x0E, 0x38, 0x71,
  0xE3, 0x87, 0x1C, 0x38, 0x01, 0xC3, 0x80, 0x1C, 0x70, 0x01, 0xC7, 0x00,
  0x38, 0x70, 0x03, 0x87, 0x00, 0x38, 0xE0, 0x03, 0x80, 0x03, 0xFC, 0x07,
  0xFF, 0x07, 0xFF, 0xC3, 0xC1, 0xE1, 0xC0, 0x78, 0xE0, 0x3C, 0xF0, 0x1E,
  0x78, 0x0F, 0x38, 0x07, 0x1C, 0x03, 0x8E, 0x01, 0xCF, 0x01, 0xE7, 0x00,
  0xF3, 0x80, 0x71, 0xC0, 0x39, 0xE0, 0x3C, 0xE0, 0x1E, 0x70, 0x0E, 0x38,
  0x07, 0x00, 0x00, 0xFC, 0x01, 0xFF, 0x03, 0xFF, 0xC3, 0xE1, 0xF1, 0xE0,
  0x79, 0xE0, 0x1D, 0xE0, 0x0E, 0xF0, 0x07, 0x70, 0x03, 0xB8, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0xEF, 0x00, 0xF7, 0x80, 0x7B, 0xC0, 0x78, 0xF0, 0xF8,
  0x7F, 0xF8, 0x1F, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0xF0,
  0x1F, 0xFF, 0x03, 0x81, 0xF0, 0x70, 0x1E, 0x0E, 0x01, 0xC3, 0xC0, 0x38,
  0x70, 0x07, 0x0E, 0x00, 0xE1, 0xC0, 0x1C, 0x78, 0x07, 0x8E, 0x00, 0xE1,
  0xC0, 0x3C, 0x38, 0x0F, 0x0F, 0x03, 0xE1, 0xC1, 0xF8, 0x3F, 0xFE, 0x07,
  0xFF, 0x01, 0xFF, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x7F, 0xF0, 0x7F, 0xFC, 0x3E, 0x0E, 0x1E, 0x03, 0x8F, 0x00, 0xE3, 0x80,
  0x79, 0xE0, 0x1C, 0x70, 0x07, 0x1C, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x38,
  0xF0, 0x0E, 0x3C, 0x07, 0x8F, 0x01, 0xE1, 0xE1, 0xF8, 0x7F, 0xFC, 0x0F,
  0xFF, 0x01, 0xFB, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x01, 0xFF, 0x87, 0xFF,
  0x83, 0xFF, 0xC3, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xC1, 0xE0, 0x60, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0xC0, 0x78, 0x7F,
  0xFC, 0x7F, 0xF8, 0x0F, 0xF0, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0xF0, 0x01, 0xE0, 0x3F, 0xFF, 0x7F, 0xFE, 0xFF, 0xFC, 0x3C,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0F, 0x06, 0x1F,
  0xFC, 0x1F, 0xF8, 0x0F, 0xC0, 0x1C, 0x03, 0x87, 0x00, 0xE1, 0xC0, 0x38,
  0xF0, 0x1E, 0x38, 0x07, 0x8E, 0x01, 0xC3, 0x80, 0x71, 0xE0, 0x3C, 0x70,
  0x0F, 0x1C, 0x03, 0x87, 0x00, 0xE3, 0xC0, 0x78, 0xF0, 0x1E, 0x3C, 0x07,
  0x0F, 0x03, 0xC1, 0xE1, 0xF0, 0x7F, 0xFC, 0x0F, 0xFB, 0x81, 0xF8, 0xE0,
  0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x0E, 0xF0, 0x0E, 0x70, 0x1E, 0x70, 0x1C,
  0x70, 0x3C, 0x70, 0x38, 0x70, 0x78, 0x70, 0x70, 0x70, 0xF0, 0x78, 0xE0,
  0x79, 0xC0, 0x3B, 0xC0, 0x3B, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x77, 0x80, 0x07, 0x70, 0x00, 0xE7, 0x00, 0x0E,
  0x70, 0x00, 0xE7, 0x0E, 0x1C, 0x70, 0xE1, 0xC7, 0x1E, 0x1C, 0x71, 0xE3,
  0x87, 0x3E, 0x38, 0x63, 0x63, 0x0E, 0x77, 0x70, 0xEE, 0x77, 0x0E, 0xC7,
  0xE0, 0xFC, 0x7E, 0x0F, 0x83, 0xC0, 0xF8, 0x3C, 0x0F, 0x03, 0x80, 0xE0,
  0x38, 0x00, 0x07, 0x00, 0x70, 0x3C, 0x07, 0x80, 0xE0, 0x78, 0x07, 0x87,
  0x80, 0x1C, 0x78, 0x00, 0xF3, 0x80, 0x03, 0xB8, 0x00, 0x1F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF8, 0x00, 0x3D, 0xC0,
  0x03, 0xCF, 0x00, 0x3C, 0x38, 0x03, 0xC1, 0xE0, 0x3C, 0x07, 0x03, 0xC0,
  0x38, 0x3C, 0x01, 0xE0, 0x03, 0xC0, 0x1C, 0x07, 0x00, 0x70, 0x1C, 0x03,
  0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xE0, 0x1C, 0x07, 0x00,
  0x78, 0x3C, 0x01, 0xE0, 0xE0, 0x03, 0x83, 0x80, 0x0E, 0x1C, 0x00, 0x38,
  0x70, 0x00, 0xF3, 0x80, 0x03, 0xCE, 0x00, 0x07, 0x70, 0x00, 0x1D, 0xC0,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x04, 0x1E, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x00, 0xE0, 0x00, 0x7F, 0xFE, 0x1F, 0xFF, 0x8F, 0xFF, 0xC0, 0x00,
  0x0F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78,
  0x00, 0xFE, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x03,
  0xC0, 0x38, 0x03, 0x80, 0x38, 0x07, 0x80, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x03, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x07, 0x80, 0x70, 0x07, 0x00, 0x70,
  0x0F, 0x00, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00,
  0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x3F, 0x80, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x7F, 0xC0, 0x1F, 0xF0,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0x01, 0x8F, 0xE0, 0x67, 0xFE, 0x39, 0xC7,
  0xFC, 0xE0, 0xFE, 0x18, 0x0F, 0x00,
};

const GFXglyph UbuntuMono_Italic40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 20, 0, -1 },
  { 1, 10, 25, 20, 7, -25 },
  { 33, 11, 10, 20, 9, -25 },
  { 47, 21, 25, 20, 2, -25 },
  { 113, 18, 32, 20, 3, -28 },
  { 185, 24, 25, 20, 0, -25 },
  { 260, 18, 25, 20, 2, -25 },
  { 317, 5, 11, 20, 12, -27 },
  { 324, 15, 35, 20, 6, -28 },
  { 390, 15, 35, 20, 2, -28 },
  { 456, 15, 15, 20, 6, -25 },
  { 485, 17, 17, 20, 3, -19 },
  { 522, 9, 10, 20, 4, -5 },
  { 534, 10, 3, 20, 7, -12 },
  { 538, 6, 5, 20, 7, -5 },
  { 542, 23, 35, 20, -1, -28 },
  { 643, 18, 25, 20, 3, -25 },
  { 700, 14, 25, 20, 4, -25 },
  { 744, 18, 25, 20, 3, -25 },
  { 801, 19, 25, 20, 2, -25 },
  { 861, 18, 25, 20, 2, -25 },
  { 918, 20, 25, 20, 2, -25 },
  { 981, 18, 25, 20, 4, -25 },
  { 1038, 18, 25, 20, 6, -25 },
  { 1095, 19, 25, 20, 3, -25 },
  { 1155, 18, 25, 20, 3, -25 },
  { 1212, 9, 18, 20, 7, -18 },
  { 1233, 12, 23, 20, 4, -18 },
  { 1268, 18, 16, 20, 3, -19 },
  { 1304, 18, 11, 20, 3, -16 },
  { 1329, 18, 16, 20, 2, -18 },
  { 1365, 14, 25, 20, 7, -25 },
  { 1409, 19, 30, 20, 3, -25 },
  { 1481, 20, 25, 20, -1, -25 },
  { 1544, 19, 25, 20, 2, -25 },
  { 1604, 19, 25, 20, 4, -25 },
  { 1664, 20, 25, 20, 1, -25 },
  { 1727, 20, 25, 20, 3, -25 },
  { 1790, 20, 25, 20, 3, -25 },
  { 1853, 19, 25, 20, 3, -25 },
  { 1913, 22, 25, 20, 1, -25 },
  { 1982, 19, 25, 20, 3, -25 },
  { 2042, 19, 25, 20, 3, -25 },
  { 2102, 22, 25, 20, 2, -25 },
  { 2171, 15, 25, 20, 2, -25 },
  { 2218, 21, 25, 20, 1, -25 },
  { 2284, 21, 25, 20, 2, -25 },
  { 2350, 19, 25, 20, 3, -25 },
  { 2410, 20, 25, 20, 2, -25 },
  { 2473, 19, 32, 20, 3, -25 },
  { 2549, 19, 25, 20, 2, -25 },
  { 2609, 20, 25, 20, 2, -25 },
  { 2672, 18, 25, 20, 6, -25 },
  { 2729, 20, 25, 20, 3, -25 },
  { 2792, 19, 25, 20, 5, -25 },
  { 2852, 22, 25, 20, 2, -25 },
  { 2921, 24, 25, 20, 0, -25 },
  { 2996, 19, 25, 20, 6, -25 },
  { 3056, 22, 25, 20, 1, -25 },
  { 3125, 18, 35, 20, 4, -28 },
  { 3204, 6, 35, 20, 9, -28 },
  { 3231, 18, 35, 20, 1, -28 },
  { 3310, 17, 13, 20, 4, -25 },
  { 3338, 18, 3, 20, -1, 4 },
  { 3345, 7, 7, 20, 10, -27 },
  { 3352, 18, 19, 20, 3, -19 },
  { 3395, 17, 28, 20, 3, -28 },
  { 3455, 17, 19, 20, 3, -19 },
  { 3496, 20, 28, 20, 3, -28 },
  { 3566, 17, 19, 20, 3, -19 },
  { 3607, 24, 35, 20, 0, -28 },
  { 3712, 20, 26, 20, 1, -19 },
  { 3777, 17, 28, 20, 2, -28 },
  { 3837, 12, 27, 20, 5, -27 },
  { 3878, 19, 34, 20, 1, -27 },
  { 3959, 19, 28, 20, 3, -28 },
  { 4026, 11, 28, 20, 7, -28 },
  { 4065, 20, 19, 20, 1, -19 },
  { 4113, 17, 19, 20, 3, -19 },
  { 4154, 17, 19, 20, 3, -19 },
  { 4195, 19, 26, 20, 1, -19 },
  { 4257, 18, 26, 20, 3, -19 },
  { 4316, 17, 19, 20, 4, -19 },
  { 4357, 17, 19, 20, 3, -19 },
  { 4398, 15, 25, 20, 6, -25 },
  { 4445, 18, 19, 20, 3, -19 },
  { 4488, 16, 19, 20, 5, -19 },
  { 4526, 20, 19, 20, 3, -19 },
  { 4574, 21, 19, 20, 1, -19 },
  { 4624, 22, 26, 20, -1, -19 },
  { 4696, 18, 19, 20, 2, -19 },
  { 4739, 19, 35, 20, 4, -28 },
  { 4823, 12, 35, 20, 6, -28 },
  { 4876, 19, 35, 20, 0, -28 },
  { 4960, 18, 6, 20, 3, -16 },
};

const GFXfont UbuntuMono_Italic40pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Italic40pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Italic40pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _UBUNTUMONO_ITALIC40PT7B_H_
