#ifndef _UBUNTUMONO_ITALIC26PT7B_H_
#define _UBUNTUMONO_ITALIC26PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Italic.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Italic26pt7bBitmaps[] PROGMEM = {
  0x00, 0x0E, 0x18, 0x30, 0x61, 0xC3, 0x06, 0x0C, 0x10, 0x60, 0x00, 0x06,
  0x0E, 0x1C, 0x30, 0x67, 0x8F, 0x16, 0x68, 0xD1, 0x00, 0x01, 0x8C, 0x0C,
  0x60, 0x31, 0x81, 0x8C, 0x3F, 0xFC, 0xFF, 0xE0, 0xC6, 0x03, 0x18, 0x18,
  0xC0, 0x63, 0x07, 0xFF, 0x3F, 0xFC, 0x33, 0x01, 0x8C, 0x06, 0x20, 0x31,
  0x80, 0x00, 0x80, 0x18, 0x01, 0x80, 0x7E, 0x0F, 0xF1, 0xC2, 0x18, 0x01,
  0x80, 0x18, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xC0, 0x0C, 0x00, 0xC4,
  0x1C, 0xFF, 0x87, 0xE0, 0x18, 0x01, 0x80, 0x18, 0x00, 0x07, 0x06, 0x0F,
  0x04, 0x19, 0x0C, 0x11, 0x18, 0x11, 0x30, 0x13, 0x60, 0x1E, 0xC0, 0x1D,
  0x80, 0x01, 0x78, 0x03, 0xF8, 0x06, 0xD8, 0x0C, 0x88, 0x19, 0x98, 0x31,
  0x98, 0x60, 0xF0, 0x40, 0xE0, 0x03, 0xC0, 0x7E, 0x0C, 0x60, 0xC6, 0x18,
  0xC0, 0xDC, 0x0F, 0x01, 0xE3, 0x3E, 0x67, 0x36, 0x61, 0xE6, 0x1C, 0xE1,
  0xC6, 0x3C, 0x7F, 0xC3, 0xC6, 0x6F, 0xED, 0xA0, 0x00, 0x80, 0x70, 0x70,
  0x38, 0x1C, 0x06, 0x03, 0x01, 0xC0, 0x60, 0x18, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0x38, 0x04, 0x00,
  0x02, 0x01, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x01, 0xC0, 0x60, 0x38, 0x0C, 0x06, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x10, 0x00, 0x1C, 0x03, 0x08, 0x8B, 0xAE, 0x7F, 0x07, 0x03,
  0xE1, 0xDC, 0x73, 0x08, 0x80, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x00, 0x60,
  0xFF, 0xFF, 0xF8, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0C, 0x00, 0x39, 0xCE,
  0x71, 0x9B, 0x98, 0xFF, 0xE0, 0xFF, 0xF0, 0x00, 0x0C, 0x00, 0x70, 0x01,
  0x80, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x06,
  0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x06, 0x00, 0x18,
  0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x00, 0x03, 0xC0,
  0xFE, 0x1C, 0x63, 0x87, 0x30, 0x77, 0x07, 0x66, 0x66, 0xF6, 0xE6, 0x6C,
  0x06, 0xC0, 0xCC, 0x0C, 0xC1, 0x8E, 0x38, 0x7F, 0x03, 0xC0, 0x00, 0xC0,
  0xF0, 0xF8, 0x7E, 0x19, 0x80, 0xE0, 0x30, 0x0C, 0x03, 0x01, 0xC0, 0x60,
  0x18, 0x06, 0x03, 0x87, 0xFB, 0xFE, 0x07, 0xC1, 0xFE, 0x18, 0x61, 0x07,
  0x00, 0x70, 0x06, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xF0, 0x1C, 0x03, 0x80,
  0x70, 0x06, 0x00, 0xFF, 0xCF, 0xF8, 0x07, 0xC3, 0xFC, 0x21, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x70, 0x7C, 0x0F, 0x80, 0x38, 0x03, 0x00, 0x60, 0x0D,
  0x07, 0xBF, 0xE3, 0xF0, 0x00, 0x30, 0x0F, 0x01, 0xF0, 0x3E, 0x07, 0x60,
  0xE6, 0x1C, 0x61, 0x8C, 0x30, 0xC6, 0x0C, 0x7F, 0xFF, 0xFE, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x38, 0x03, 0xF8, 0x3F, 0xC1, 0x80, 0x0C, 0x00, 0xC0,
  0x06, 0x00, 0x3C, 0x03, 0xF8, 0x01, 0xE0, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x0E, 0x20, 0xE1, 0xFE, 0x07, 0xE0, 0x00, 0xF0, 0x3F, 0x07, 0x80, 0xC0,
  0x18, 0x03, 0x00, 0x3F, 0x87, 0xFC, 0x60, 0xE6, 0x06, 0x60, 0x6E, 0x0E,
  0x60, 0xC6, 0x1C, 0x7F, 0x83, 0xE0, 0x7F, 0xEF, 0xFC, 0x03, 0x00, 0xC0,
  0x38, 0x0E, 0x01, 0x80, 0x60, 0x1C, 0x03, 0x00, 0xC0, 0x38, 0x06, 0x01,
  0xC0, 0x30, 0x06, 0x00, 0x07, 0xC0, 0xFE, 0x1C, 0x71, 0x83, 0x30, 0x33,
  0x86, 0x1C, 0xE1, 0xF8, 0x3F, 0x87, 0x1C, 0x60, 0xCC, 0x0C, 0xC0, 0xCE,
  0x1C, 0x7F, 0x83, 0xE0, 0x07, 0xC1, 0xFE, 0x1C, 0x73, 0x03, 0x30, 0x33,
  0x03, 0x30, 0x33, 0x07, 0x3F, 0xE1, 0xF6, 0x00, 0xC0, 0x1C, 0x03, 0x80,
  0xF0, 0xFC, 0x0F, 0x00, 0x39, 0xCE, 0x70, 0x00, 0x00, 0xE7, 0x39, 0xC0,
  0x0E, 0x1C, 0x38, 0x70, 0x00, 0x00, 0x00, 0x38, 0x70, 0xE1, 0xC1, 0x86,
  0x38, 0x60, 0x00, 0x20, 0x1C, 0x1F, 0x0F, 0x8F, 0x81, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x78, 0x02, 0x00, 0x7F, 0xF7, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x20, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xC0, 0xF8, 0xF8, 0x7C, 0x1C, 0x02, 0x00, 0x00, 0x1F, 0x1F, 0xC8,
  0x60, 0x30, 0x18, 0x18, 0x18, 0x38, 0x38, 0x18, 0x00, 0x00, 0x06, 0x07,
  0x83, 0xC0, 0xC0, 0x03, 0xE0, 0x7F, 0x87, 0x0C, 0x70, 0x73, 0x01, 0xB8,
  0xF9, 0x9F, 0xDC, 0xC6, 0xCC, 0x36, 0x63, 0x33, 0x19, 0x98, 0xCC, 0xC6,
  0x67, 0xE3, 0x1F, 0x1C, 0x00, 0x70, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0xE0,
  0x0E, 0x01, 0xE0, 0x36, 0x03, 0x30, 0x63, 0x06, 0x30, 0xC3, 0x0C, 0x31,
  0x83, 0x3F, 0xF3, 0xFF, 0x70, 0x36, 0x03, 0xE0, 0x3C, 0x03, 0x0F, 0xE0,
  0x7F, 0x87, 0x0E, 0x30, 0x71, 0x83, 0x0C, 0x18, 0xE1, 0xC7, 0xF8, 0x3F,
  0xE1, 0x83, 0x1C, 0x1C, 0xC0, 0xE6, 0x06, 0x30, 0x73, 0xFF, 0x1F, 0xE0,
  0x03, 0xF0, 0x3F, 0xC7, 0x84, 0x30, 0x03, 0x00, 0x38, 0x01, 0x80, 0x0C,
  0x00, 0xE0, 0x07, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x40, 0xFF,
  0x03, 0xE0, 0x0F, 0xC0, 0xFF, 0x06, 0x1C, 0x30, 0x61, 0x83, 0x9C, 0x1C,
  0xC0, 0xE6, 0x06, 0x30, 0x33, 0x81, 0x98, 0x1C, 0xC0, 0xC6, 0x0E, 0x71,
  0xE3, 0xFE, 0x1F, 0xC0, 0x0F, 0xF8, 0xFF, 0x86, 0x00, 0x30, 0x01, 0x80,
  0x1C, 0x00, 0xC0, 0x07, 0xF8, 0x3F, 0xC3, 0x80, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x70, 0x03, 0xFF, 0x1F, 0xF8, 0x0F, 0xF8, 0xFF, 0xC6, 0x00, 0x30,
  0x01, 0x80, 0x1C, 0x00, 0xC0, 0x07, 0xF8, 0x3F, 0xC3, 0x80, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x18, 0x00, 0x03, 0xE0, 0x7F, 0x87,
  0x04, 0x70, 0x03, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x66, 0x07,
  0x30, 0x31, 0x81, 0x8E, 0x0C, 0x38, 0xE1, 0xFE, 0x03, 0xF0, 0x0C, 0x0C,
  0x70, 0x31, 0x81, 0x86, 0x06, 0x18, 0x18, 0xE0, 0x63, 0x03, 0x0F, 0xFC,
  0x3F, 0xF1, 0xC0, 0xC6, 0x06, 0x18, 0x18, 0x60, 0x61, 0x81, 0x8C, 0x0C,
  0x30, 0x30, 0x0F, 0xF1, 0xFF, 0x03, 0x00, 0x30, 0x03, 0x00, 0x70, 0x06,
  0x00, 0x60, 0x06, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0xFF,
  0x8F, 0xF0, 0x07, 0xF0, 0xFF, 0x00, 0x30, 0x07, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x8C, 0x38, 0xFF,
  0x07, 0xE0, 0x0C, 0x1C, 0x30, 0xE1, 0xC7, 0x06, 0x38, 0x19, 0xC0, 0x6E,
  0x03, 0xF0, 0x0F, 0x00, 0x36, 0x00, 0xDC, 0x07, 0x38, 0x18, 0x60, 0x61,
  0xC1, 0x83, 0x06, 0x0E, 0x30, 0x18, 0x0C, 0x03, 0x00, 0xC0, 0x70, 0x18,
  0x06, 0x01, 0x80, 0xE0, 0x30, 0x0C, 0x03, 0x01, 0xC0, 0x60, 0x18, 0x07,
  0xFD, 0xFF, 0x07, 0x0C, 0x0E, 0x18, 0x1C, 0x70, 0x78, 0xE0, 0xF3, 0xC1,
  0x6D, 0x86, 0xDB, 0x0D, 0xE4, 0x19, 0x98, 0x63, 0x30, 0xC0, 0x61, 0x80,
  0xC6, 0x03, 0x0C, 0x06, 0x18, 0x0C, 0x30, 0x18, 0x0C, 0x0C, 0x30, 0x31,
  0xE1, 0x87, 0x86, 0x1E, 0x18, 0x6C, 0x63, 0x31, 0x0C, 0xCC, 0x31, 0x30,
  0xC6, 0xC6, 0x1B, 0x18, 0x78, 0x61, 0xE1, 0x83, 0x8C, 0x0E, 0x30, 0x30,
  0x07, 0xC0, 0xFE, 0x1C, 0x73, 0x83, 0x30, 0x36, 0x03, 0x60, 0x36, 0x03,
  0xC0, 0x7C, 0x06, 0xC0, 0x6C, 0x0C, 0xC1, 0xCE, 0x38, 0x7F, 0x03, 0xE0,
  0x0F, 0xE0, 0x7F, 0x83, 0x0E, 0x38, 0x31, 0x81, 0x8C, 0x0C, 0x60, 0xC7,
  0x0E, 0x3F, 0xE1, 0xFC, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x07, 0xC0, 0xFE, 0x1C, 0x73, 0x83, 0x30, 0x36, 0x03, 0x60,
  0x36, 0x03, 0xC0, 0x7C, 0x06, 0xC0, 0x6C, 0x0E, 0xC1, 0xCE, 0x38, 0x7F,
  0x03, 0xE0, 0x18, 0x01, 0xE0, 0x0F, 0x80, 0x30, 0x0F, 0xE0, 0x7F, 0x87,
  0x0E, 0x30, 0x71, 0x81, 0x8C, 0x1C, 0xE0, 0xC6, 0x0E, 0x3F, 0xE1, 0xFC,
  0x1C, 0x60, 0xC3, 0x06, 0x0C, 0x30, 0x61, 0x83, 0x18, 0x1C, 0x03, 0xF0,
  0x3F, 0xC3, 0x84, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xF0, 0x03,
  0xC0, 0x07, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x20, 0x71, 0xFF, 0x07, 0xE0,
  0xFF, 0xFF, 0xFC, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x18,
  0x07, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x18, 0x19,
  0xC1, 0xCC, 0x0C, 0x60, 0x63, 0x03, 0x38, 0x39, 0x81, 0x8C, 0x0C, 0x60,
  0x67, 0x07, 0x30, 0x31, 0x81, 0x8C, 0x1C, 0x71, 0xC1, 0xFC, 0x07, 0xC0,
  0xC0, 0x7C, 0x06, 0xC0, 0xEC, 0x0C, 0xC1, 0xCC, 0x18, 0xC3, 0x8C, 0x30,
  0xC7, 0x0C, 0x60, 0xCC, 0x0C, 0xC0, 0xD8, 0x0D, 0x80, 0xF0, 0x07, 0x00,
  0x30, 0x18, 0xC0, 0x63, 0x01, 0x8C, 0x06, 0x60, 0x31, 0x80, 0xC6, 0x63,
  0x19, 0x88, 0x4E, 0x63, 0x6D, 0x8D, 0xB4, 0x3C, 0xF0, 0xE3, 0xC3, 0x8E,
  0x0C, 0x38, 0x30, 0x60, 0x06, 0x06, 0x06, 0x0E, 0x07, 0x1C, 0x03, 0x18,
  0x03, 0x30, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x06, 0x60, 0x0C, 0x60, 0x1C, 0x60, 0x38, 0x70, 0x70, 0x30, 0x60, 0x30,
  0xC0, 0x3C, 0x06, 0xC0, 0xEE, 0x0C, 0x61, 0x86, 0x30, 0x67, 0x03, 0x60,
  0x3C, 0x03, 0x80, 0x38, 0x03, 0x00, 0x30, 0x03, 0x00, 0x70, 0x06, 0x00,
  0x0F, 0xFC, 0x3F, 0xF0, 0x03, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x30, 0x01, 0x80,
  0x0F, 0xFE, 0x3F, 0xF0, 0x07, 0xE0, 0xFC, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x0F, 0xC1, 0xF8, 0x00, 0xCC,
  0xCC, 0xCC, 0xCC, 0xEE, 0x66, 0x66, 0x66, 0x66, 0x66, 0x77, 0x07, 0xE0,
  0xFC, 0x01, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x18,
  0x07, 0x0F, 0xC1, 0xF8, 0x00, 0x03, 0x01, 0xC0, 0xD8, 0x76, 0x19, 0x8C,
  0x36, 0x0F, 0x83, 0x40, 0xC0, 0x7F, 0xFF, 0xFF, 0x4C, 0x63, 0x10, 0x07,
  0xE3, 0xFC, 0xE1, 0xB8, 0x36, 0x0D, 0x81, 0xB0, 0x36, 0x0C, 0xC1, 0x9C,
  0x71, 0xFE, 0x1E, 0x60, 0x0C, 0x03, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x0F, 0xE1, 0xFE, 0x38, 0xE6, 0x0D, 0xC1, 0xB0, 0x36, 0x06, 0xC1, 0xB0,
  0x76, 0x1C, 0xFF, 0x1F, 0x80, 0x07, 0xE3, 0xFC, 0xE0, 0xB8, 0x0E, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x1C, 0x11, 0xFE, 0x1F, 0x80, 0x00, 0x18,
  0x00, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x1F, 0xC3, 0xFC, 0x3C,
  0x63, 0x83, 0x18, 0x39, 0xC1, 0x8C, 0x0C, 0x60, 0x63, 0x07, 0x1C, 0x78,
  0x7F, 0xC1, 0xE6, 0x00, 0x07, 0xC3, 0xFC, 0xE1, 0xB8, 0x3E, 0x07, 0x83,
  0xBF, 0xE7, 0xF0, 0xC0, 0x1C, 0x11, 0xFE, 0x1F, 0x80, 0x00, 0x3E, 0x00,
  0x7E, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x07, 0xFC, 0x0F,
  0xFC, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0xFC, 0x00, 0xF0, 0x00, 0x03, 0xF8, 0x7F, 0xC7, 0x8C, 0x70, 0x63,
  0x03, 0x18, 0x31, 0x81, 0x8C, 0x0C, 0x70, 0xE1, 0xFE, 0x07, 0xB0, 0x01,
  0x80, 0x18, 0x41, 0xC3, 0xFC, 0x0F, 0x80, 0x0E, 0x01, 0x80, 0x30, 0x06,
  0x01, 0xC0, 0x30, 0x07, 0xF0, 0xFF, 0x38, 0x66, 0x0C, 0xC1, 0x98, 0x37,
  0x06, 0xC1, 0xD8, 0x33, 0x06, 0x60, 0xD8, 0x18, 0x06, 0x0E, 0x0E, 0x00,
  0x00, 0x7C, 0x7C, 0x0C, 0x0C, 0x18, 0x18, 0x18, 0x18, 0x38, 0x18, 0x1F,
  0x0F, 0x00, 0x70, 0x07, 0x00, 0x60, 0x00, 0x00, 0x00, 0xFE, 0x0F, 0xE0,
  0x06, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x18, 0x01, 0x80,
  0x18, 0x03, 0x80, 0x30, 0x87, 0x0F, 0xE0, 0xFC, 0x00, 0x0C, 0x00, 0xC0,
  0x1C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x38, 0x73, 0x0E, 0x31, 0x83, 0x70,
  0x7E, 0x07, 0xC0, 0x6C, 0x06, 0x60, 0xE3, 0x0C, 0x38, 0xC1, 0x8C, 0x1C,
  0xFD, 0xF0, 0x60, 0xC3, 0x86, 0x0C, 0x18, 0x70, 0xC1, 0x83, 0x0E, 0x18,
  0x30, 0x72, 0xFC, 0xF8, 0x1E, 0xF1, 0xFF, 0x8C, 0xCE, 0x66, 0x23, 0x33,
  0x31, 0x99, 0x8C, 0xCC, 0xC4, 0x60, 0x66, 0x03, 0x30, 0x19, 0x80, 0x80,
  0x1F, 0x87, 0xF8, 0xC3, 0x98, 0x37, 0x06, 0xC0, 0xD8, 0x33, 0x06, 0xE0,
  0xD8, 0x3B, 0x06, 0x60, 0xC0, 0x0F, 0x83, 0xF8, 0xE3, 0xB8, 0x36, 0x07,
  0xC0, 0xF0, 0x1E, 0x06, 0xC1, 0xDC, 0x71, 0xFC, 0x1F, 0x00, 0x07, 0xE0,
  0x7F, 0x83, 0x0E, 0x18, 0x31, 0xC1, 0x8C, 0x0C, 0x60, 0x63, 0x06, 0x30,
  0x71, 0x87, 0x0F, 0xF0, 0x7E, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x07, 0xE1, 0xFE, 0x3C, 0x67, 0x06, 0x60, 0xEE, 0x0C, 0xC0, 0xCC, 0x0C,
  0xC1, 0xCE, 0x38, 0x7F, 0x83, 0xD8, 0x03, 0x80, 0x30, 0x03, 0x00, 0x30,
  0x0F, 0xF1, 0xFE, 0x18, 0x03, 0x80, 0x30, 0x03, 0x00, 0x30, 0x07, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0x07, 0xC3, 0xFC, 0x61, 0x18, 0x03,
  0x80, 0x3E, 0x01, 0xE0, 0x0C, 0x01, 0x88, 0x33, 0xFE, 0x3F, 0x00, 0x1C,
  0x0C, 0x06, 0x03, 0x0F, 0xFF, 0xFC, 0xC0, 0x60, 0x70, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x11, 0xF8, 0x7C, 0x30, 0x66, 0x0D, 0xC1, 0xB0, 0x76, 0x0C,
  0xC1, 0xB0, 0x36, 0x0C, 0xC1, 0x9C, 0x71, 0xFE, 0x1E, 0x60, 0xE0, 0x6C,
  0x19, 0x83, 0x30, 0xC6, 0x18, 0xC6, 0x18, 0xC3, 0x30, 0x6E, 0x0F, 0x80,
  0xE0, 0x18, 0x00, 0x60, 0x1B, 0x00, 0xD8, 0x0C, 0xCC, 0x6C, 0x62, 0x67,
  0x33, 0x29, 0x9B, 0x78, 0xF3, 0xC7, 0x9C, 0x38, 0xE1, 0x86, 0x00, 0x0C,
  0x1C, 0x38, 0xE0, 0x63, 0x01, 0xD8, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x01,
  0xB0, 0x0C, 0xC0, 0x63, 0x83, 0x06, 0x18, 0x1C, 0x0C, 0x0C, 0x30, 0x60,
  0xC1, 0x83, 0x0E, 0x0C, 0x30, 0x30, 0xC0, 0xE6, 0x01, 0x98, 0x06, 0xC0,
  0x1F, 0x00, 0x78, 0x00, 0xC0, 0x07, 0x00, 0x38, 0x0F, 0xC0, 0x3C, 0x00,
  0x1F, 0xE7, 0xFC, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x0C, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0xF8, 0x0F, 0xC0, 0xC0, 0x06, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0xE0, 0x1E, 0x01, 0xE0,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0xF0, 0x0F, 0x80, 0x06, 0x0C, 0x18, 0x30, 0xC1, 0x83, 0x06,
  0x18, 0x30, 0x60, 0xC3, 0x06, 0x0C, 0x18, 0x60, 0xC1, 0x83, 0x0C, 0x18,
  0x00, 0x07, 0xC0, 0x3F, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x3C, 0x01, 0xE0, 0x1C, 0x00, 0xC0,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x0F, 0xC0, 0x7C,
  0x00, 0x38, 0x2F, 0xCF, 0x1F, 0x61, 0xC0,
};

const GFXglyph UbuntuMono_Italic26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 7, 16, 13, 4, -16 },
  { 15, 7, 6, 13, 6, -16 },
  { 21, 14, 16, 13, 1, -16 },
  { 49, 12, 21, 13, 2, -18 },
  { 81, 16, 16, 13, 0, -16 },
  { 113, 12, 16, 13, 1, -16 },
  { 137, 3, 7, 13, 8, -18 },
  { 140, 10, 22, 13, 4, -18 },
  { 168, 10, 22, 13, 1, -18 },
  { 196, 10, 10, 13, 4, -16 },
  { 209, 11, 12, 13, 2, -13 },
  { 226, 5, 8, 13, 3, -4 },
  { 231, 6, 2, 13, 5, -8 },
  { 233, 3, 4, 13, 5, -4 },
  { 235, 14, 22, 13, 0, -18 },
  { 274, 12, 16, 13, 2, -16 },
  { 298, 10, 16, 13, 2, -16 },
  { 318, 12, 16, 13, 2, -16 },
  { 342, 11, 16, 13, 2, -16 },
  { 364, 12, 16, 13, 1, -16 },
  { 388, 13, 16, 13, 1, -16 },
  { 414, 12, 16, 13, 2, -16 },
  { 438, 11, 16, 13, 4, -16 },
  { 460, 12, 16, 13, 2, -16 },
  { 484, 12, 16, 13, 2, -16 },
  { 508, 5, 12, 13, 5, -12 },
  { 516, 7, 16, 13, 3, -12 },
  { 530, 11, 11, 13, 2, -12 },
  { 546, 12, 7, 13, 2, -10 },
  { 557, 11, 11, 13, 2, -13 },
  { 573, 9, 16, 13, 4, -16 },
  { 591, 13, 19, 13, 2, -16 },
  { 622, 12, 16, 13, 0, -16 },
  { 646, 13, 16, 13, 1, -16 },
  { 672, 13, 16, 13, 2, -16 },
  { 698, 13, 16, 13, 1, -16 },
  { 724, 13, 16, 13, 2, -16 },
  { 750, 13, 16, 13, 2, -16 },
  { 776, 13, 16, 13, 2, -16 },
  { 802, 14, 16, 13, 1, -16 },
  { 830, 12, 16, 13, 2, -16 },
  { 854, 12, 16, 13, 2, -16 },
  { 878, 14, 16, 13, 1, -16 },
  { 906, 10, 16, 13, 1, -16 },
  { 926, 15, 16, 13, 0, -16 },
  { 956, 14, 16, 13, 1, -16 },
  { 984, 12, 16, 13, 2, -16 },
  { 1008, 13, 16, 13, 1, -16 },
  { 1034, 12, 20, 13, 2, -16 },
  { 1064, 13, 16, 13, 1, -16 },
  { 1090, 13, 16, 13, 1, -16 },
  { 1116, 11, 16, 13, 4, -16 },
  { 1138, 13, 16, 13, 2, -16 },
  { 1164, 12, 16, 13, 4, -16 },
  { 1188, 14, 16, 13, 2, -16 },
  { 1216, 16, 16, 13, 0, -16 },
  { 1248, 12, 16, 13, 4, -16 },
  { 1272, 14, 16, 13, 1, -16 },
  { 1300, 11, 22, 13, 3, -18 },
  { 1331, 4, 22, 13, 6, -18 },
  { 1342, 11, 22, 13, 1, -18 },
  { 1373, 10, 9, 13, 3, -16 },
  { 1385, 12, 2, 13, -1, 2 },
  { 1388, 4, 5, 13, 7, -18 },
  { 1391, 11, 12, 13, 2, -12 },
  { 1408, 11, 18, 13, 2, -18 },
  { 1433, 11, 12, 13, 2, -12 },
  { 1450, 13, 18, 13, 2, -18 },
  { 1480, 11, 12, 13, 2, -12 },
  { 1497, 16, 22, 13, 0, -18 },
  { 1541, 13, 16, 13, 1, -12 },
  { 1567, 11, 18, 13, 1, -18 },
  { 1592, 8, 17, 13, 3, -17 },
  { 1609, 12, 21, 13, 1, -17 },
  { 1641, 12, 18, 13, 2, -18 },
  { 1668, 7, 18, 13, 5, -18 },
  { 1684, 13, 12, 13, 1, -12 },
  { 1704, 11, 12, 13, 2, -12 },
  { 1721, 11, 12, 13, 2, -12 },
  { 1738, 13, 16, 13, 0, -12 },
  { 1764, 12, 16, 13, 2, -12 },
  { 1788, 12, 12, 13, 2, -12 },
  { 1806, 11, 12, 13, 2, -12 },
  { 1823, 9, 16, 13, 4, -16 },
  { 1841, 11, 12, 13, 2, -12 },
  { 1858, 11, 12, 13, 3, -12 },
  { 1875, 13, 12, 13, 2, -12 },
  { 1895, 14, 12, 13, 0, -12 },
  { 1916, 14, 16, 13, 0, -12 },
  { 1944, 11, 12, 13, 2, -12 },
  { 1961, 13, 22, 13, 2, -18 },
  { 1997, 7, 22, 13, 4, -18 },
  { 2017, 13, 22, 13, 0, -18 },
  { 2053, 11, 4, 13, 2, -11 },
};

const GFXfont UbuntuMono_Italic26pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Italic26pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Italic26pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _UBUNTUMONO_ITALIC26PT7B_H_
