#ifndef _UBUNTUMONO_ITALIC11PT7B_H_
#define _UBUNTUMONO_ITALIC11PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Italic.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Italic11pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x24, 0x20, 0x5A, 0xA0, 0x14, 0x57, 0xCA, 0x7D, 0x45, 0x00,
  0x11, 0xD0, 0x83, 0x08, 0x5C, 0x40, 0x34, 0xA9, 0xA0, 0x82, 0xCA, 0xA6,
  0x00, 0x35, 0x56, 0xF9, 0xF0, 0x68, 0x12, 0x48, 0x88, 0x88, 0x84, 0x22,
  0x11, 0x11, 0x22, 0x48, 0x4F, 0x4A, 0x21, 0x3C, 0x44, 0x00, 0x4B, 0x00,
  0xC0, 0xC0, 0x04, 0x20, 0x84, 0x10, 0x82, 0x10, 0x42, 0x00, 0x32, 0x63,
  0x59, 0x4B, 0x80, 0x37, 0x22, 0x22, 0xF0, 0x32, 0x42, 0x66, 0x43, 0xC0,
  0x70, 0x44, 0x41, 0x0B, 0x80, 0x11, 0x95, 0x2F, 0x10, 0x80, 0x3A, 0x10,
  0xE1, 0x0B, 0x80, 0x1B, 0x11, 0xE9, 0x49, 0x80, 0xF1, 0x24, 0x48, 0x80,
  0x3A, 0x52, 0xE9, 0x4B, 0x80, 0x72, 0x62, 0xF1, 0x1B, 0x00, 0x40, 0xC0,
  0x20, 0x04, 0xB0, 0x0B, 0xA0, 0xC1, 0x00, 0xF8, 0x3C, 0x43, 0x04, 0xC8,
  0x00, 0x61, 0x24, 0x40, 0x80, 0x3A, 0x6F, 0x5C, 0xEA, 0xCC, 0x18, 0xCA,
  0x97, 0xC6, 0x20, 0x38, 0x94, 0x5E, 0x49, 0x27, 0x00, 0x3A, 0x21, 0x08,
  0x41, 0xC0, 0x38, 0x94, 0x51, 0x49, 0x2F, 0x00, 0x7A, 0x10, 0xE8, 0x43,
  0xC0, 0x7A, 0x10, 0xE8, 0x42, 0x00, 0x3A, 0x21, 0x09, 0x49, 0xC0, 0x24,
  0x94, 0x5F, 0x49, 0x28, 0x80, 0x79, 0x08, 0x42, 0x23, 0x80, 0x38, 0x42,
  0x21, 0x4B, 0x80, 0x24, 0xA5, 0x18, 0x51, 0x44, 0x80, 0x44, 0x48, 0x88,
  0xF0, 0x24, 0xB5, 0xD5, 0x45, 0x28, 0x80, 0x24, 0x95, 0x55, 0x59, 0x28,
  0x80, 0x32, 0x63, 0x18, 0xCB, 0x80, 0x72, 0x53, 0x1F, 0x42, 0x00, 0x32,
  0x63, 0x18, 0xCB, 0x88, 0x20, 0x38, 0x94, 0x5E, 0x51, 0x24, 0x80, 0x3A,
  0x10, 0x61, 0x0B, 0x80, 0xF4, 0x44, 0x48, 0x80, 0x4A, 0x63, 0x19, 0x4B,
  0x80, 0x86, 0x24, 0x94, 0x51, 0x84, 0x00, 0x46, 0x28, 0xAA, 0xF2, 0xC9,
  0x00, 0x24, 0x48, 0x60, 0x82, 0x89, 0x32, 0x00, 0x8C, 0xA8, 0x84, 0x42,
  0x00, 0x3C, 0x10, 0x84, 0x21, 0x0F, 0x80, 0x39, 0x08, 0x84, 0x21, 0x08,
  0x87, 0x00, 0xA5, 0x55, 0x50, 0x38, 0x42, 0x21, 0x08, 0x42, 0x27, 0x00,
  0x31, 0x95, 0x10, 0xF8, 0x90, 0x7E, 0xA5, 0x2F, 0x00, 0x42, 0x10, 0xE8,
  0xC6, 0x5C, 0x7C, 0x21, 0x0F, 0x00, 0x08, 0x42, 0xFC, 0xCA, 0x5E, 0x74,
  0x7D, 0x0F, 0x00, 0x0C, 0x20, 0x41, 0xE1, 0x04, 0x08, 0x10, 0x21, 0x80,
  0x1C, 0x94, 0x92, 0x78, 0x2F, 0x00, 0x21, 0x08, 0x74, 0xA5, 0x29, 0x20,
  0x62, 0x44, 0x30, 0x08, 0x03, 0x82, 0x08, 0x41, 0x04, 0xE0, 0x42, 0x10,
  0xBE, 0x62, 0x92, 0xC9, 0x25, 0x27, 0x7D, 0x55, 0x52, 0x88, 0x75, 0x99,
  0x90, 0x74, 0x63, 0x2E, 0x00, 0x39, 0x14, 0x52, 0x72, 0x08, 0x00, 0x7E,
  0x65, 0x2F, 0x10, 0x80, 0x7A, 0x11, 0x08, 0x00, 0x72, 0x1C, 0x2E, 0x00,
  0x44, 0xF8, 0x88, 0xE0, 0x8C, 0xA5, 0x2F, 0x00, 0x8A, 0x94, 0xC4, 0x00,
  0x8D, 0x7B, 0xE9, 0x00, 0x28, 0xA1, 0x0C, 0x48, 0x44, 0xA2, 0x8C, 0x30,
  0x8C, 0x00, 0x78, 0x99, 0x0F, 0x00, 0x19, 0x08, 0x4C, 0x21, 0x08, 0x43,
  0x00, 0x25, 0x24, 0xA4, 0x90, 0x38, 0x42, 0x21, 0x88, 0x44, 0x27, 0x00,
  0xCD, 0x80,
};

const GFXglyph UbuntuMono_Italic11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 3, 7, 6, 2, -7 },
  { 4, 4, 3, 6, 2, -7 },
  { 6, 6, 7, 6, 0, -7 },
  { 12, 5, 9, 6, 1, -8 },
  { 18, 7, 7, 6, 0, -7 },
  { 25, 4, 7, 6, 1, -7 },
  { 29, 2, 3, 6, 3, -7 },
  { 30, 4, 10, 6, 2, -8 },
  { 35, 4, 10, 6, 1, -8 },
  { 40, 4, 4, 6, 2, -7 },
  { 42, 5, 5, 6, 1, -5 },
  { 46, 3, 3, 6, 1, -1 },
  { 48, 3, 1, 6, 2, -3 },
  { 49, 2, 1, 6, 2, -1 },
  { 50, 6, 10, 6, 0, -8 },
  { 58, 5, 7, 6, 1, -7 },
  { 63, 4, 7, 6, 1, -7 },
  { 67, 5, 7, 6, 1, -7 },
  { 72, 5, 7, 6, 1, -7 },
  { 77, 5, 7, 6, 1, -7 },
  { 82, 5, 7, 6, 1, -7 },
  { 87, 5, 7, 6, 1, -7 },
  { 92, 4, 7, 6, 2, -7 },
  { 96, 5, 7, 6, 1, -7 },
  { 101, 5, 7, 6, 1, -7 },
  { 106, 2, 5, 6, 2, -5 },
  { 108, 3, 7, 6, 1, -5 },
  { 111, 5, 5, 6, 1, -5 },
  { 115, 5, 3, 6, 1, -4 },
  { 117, 5, 5, 6, 1, -6 },
  { 121, 4, 7, 6, 2, -7 },
  { 125, 5, 8, 6, 1, -7 },
  { 130, 5, 7, 6, 0, -7 },
  { 135, 6, 7, 6, 0, -7 },
  { 141, 5, 7, 6, 1, -7 },
  { 146, 6, 7, 6, 0, -7 },
  { 152, 5, 7, 6, 1, -7 },
  { 157, 5, 7, 6, 1, -7 },
  { 162, 5, 7, 6, 1, -7 },
  { 167, 6, 7, 6, 0, -7 },
  { 173, 5, 7, 6, 1, -7 },
  { 178, 5, 7, 6, 1, -7 },
  { 183, 6, 7, 6, 0, -7 },
  { 189, 4, 7, 6, 1, -7 },
  { 193, 6, 7, 6, 0, -7 },
  { 199, 6, 7, 6, 0, -7 },
  { 205, 5, 7, 6, 1, -7 },
  { 210, 5, 7, 6, 1, -7 },
  { 215, 5, 9, 6, 1, -7 },
  { 221, 6, 7, 6, 0, -7 },
  { 227, 5, 7, 6, 1, -7 },
  { 232, 4, 7, 6, 2, -7 },
  { 236, 5, 7, 6, 1, -7 },
  { 241, 6, 7, 6, 1, -7 },
  { 247, 6, 7, 6, 1, -7 },
  { 253, 7, 7, 6, 0, -7 },
  { 260, 5, 7, 6, 2, -7 },
  { 265, 6, 7, 6, 0, -7 },
  { 271, 5, 10, 6, 1, -8 },
  { 278, 2, 10, 6, 2, -8 },
  { 281, 5, 10, 6, 0, -8 },
  { 288, 5, 4, 6, 1, -7 },
  { 291, 5, 1, 6, 0, 1 },
  { 292, 2, 2, 6, 3, -8 },
  { 293, 5, 5, 6, 1, -5 },
  { 297, 5, 8, 6, 1, -8 },
  { 302, 5, 5, 6, 1, -5 },
  { 306, 5, 8, 6, 1, -8 },
  { 311, 5, 5, 6, 1, -5 },
  { 315, 7, 10, 6, 0, -8 },
  { 324, 6, 7, 6, 0, -5 },
  { 330, 5, 8, 6, 0, -8 },
  { 335, 4, 7, 6, 1, -7 },
  { 339, 6, 9, 6, 0, -7 },
  { 346, 5, 8, 6, 1, -8 },
  { 351, 3, 8, 6, 2, -8 },
  { 354, 6, 5, 6, 0, -5 },
  { 358, 4, 5, 6, 1, -5 },
  { 361, 5, 5, 6, 1, -5 },
  { 365, 6, 7, 6, 0, -5 },
  { 371, 5, 7, 6, 1, -5 },
  { 376, 5, 5, 6, 1, -5 },
  { 380, 5, 5, 6, 1, -5 },
  { 384, 4, 7, 6, 2, -7 },
  { 388, 5, 5, 6, 1, -5 },
  { 392, 5, 5, 6, 1, -5 },
  { 396, 5, 5, 6, 1, -5 },
  { 400, 6, 5, 6, 0, -5 },
  { 404, 6, 7, 6, 0, -5 },
  { 410, 5, 5, 6, 1, -5 },
  { 414, 5, 10, 6, 1, -8 },
  { 421, 3, 10, 6, 2, -8 },
  { 425, 5, 10, 6, 0, -8 },
  { 432, 5, 2, 6, 1, -5 },
};

const GFXfont UbuntuMono_Italic11pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Italic11pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Italic11pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _UBUNTUMONO_ITALIC11PT7B_H_
