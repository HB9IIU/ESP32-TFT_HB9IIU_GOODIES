#ifndef _UBUNTUMONO_ITALIC31PT7B_H_
#define _UBUNTUMONO_ITALIC31PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Italic.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Italic31pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x06, 0x0E, 0x0E, 0x0E, 0x0C, 0x1C, 0x1C, 0x1C, 0x18, 0x18,
  0x18, 0x00, 0x00, 0x00, 0x70, 0xF0, 0xF0, 0x70, 0x63, 0xB1, 0x98, 0xDC,
  0x6C, 0x76, 0x33, 0x19, 0x08, 0x00, 0xE3, 0x00, 0x61, 0x80, 0x71, 0xC0,
  0x30, 0xC0, 0x18, 0xE1, 0xFF, 0xF8, 0xFF, 0xFC, 0x7F, 0xFE, 0x07, 0x18,
  0x03, 0x1C, 0x03, 0x0C, 0x01, 0x8E, 0x07, 0xFF, 0xE3, 0xFF, 0xF3, 0xFF,
  0xF0, 0x61, 0x80, 0x31, 0xC0, 0x30, 0xC0, 0x38, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0xC0, 0x01, 0x80, 0x0F, 0xC0, 0x7F, 0xE1, 0xFF, 0x83, 0x81, 0x0E,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x18, 0x60, 0x70, 0xFF, 0xE3, 0xFF, 0x81, 0xFC, 0x00,
  0xE0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x03, 0x80, 0xC0, 0xF8, 0x30,
  0x3F, 0x0E, 0x06, 0x63, 0x81, 0x8C, 0x60, 0x31, 0x98, 0x06, 0x76, 0x00,
  0xFD, 0x80, 0x1F, 0xE0, 0x01, 0xDF, 0xC0, 0x07, 0xFC, 0x00, 0xDF, 0x80,
  0x37, 0x30, 0x0C, 0xC6, 0x03, 0x18, 0xC0, 0xC3, 0x30, 0x38, 0x7E, 0x0E,
  0x0F, 0x81, 0x80, 0xE0, 0x00, 0x03, 0xE0, 0x3F, 0x83, 0xFC, 0x3C, 0x61,
  0xC3, 0x0E, 0x30, 0x37, 0x01, 0xF0, 0x1E, 0x19, 0xF8, 0xDC, 0xEC, 0xC3,
  0x6E, 0x1E, 0x60, 0x73, 0x03, 0x9C, 0x7C, 0xFF, 0xF3, 0xFB, 0x8F, 0x1C,
  0x37, 0x76, 0x66, 0xCC, 0x00, 0x40, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0E, 0x01, 0xC0, 0x18, 0x03,
  0x80, 0x38, 0x07, 0x00, 0x40, 0x00, 0x01, 0x00, 0x60, 0x0E, 0x00, 0xE0,
  0x0C, 0x01, 0xC0, 0x38, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0xF0, 0x1C, 0x03, 0x00, 0x00, 0x07, 0x00, 0x70, 0x06,
  0x04, 0x63, 0x76, 0xFF, 0xFF, 0x1F, 0xC0, 0xD0, 0x19, 0xC3, 0x8E, 0x10,
  0x80, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x83, 0xFF,
  0xDF, 0xFE, 0x06, 0x00, 0x70, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x0E, 0x00,
  0x1C, 0x7C, 0xF8, 0xF0, 0xC7, 0xBE, 0x70, 0x7F, 0x7E, 0x77, 0xFE, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03,
  0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03,
  0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00,
  0x00, 0x03, 0xE0, 0x3F, 0x87, 0xFE, 0x3C, 0x73, 0x83, 0xBC, 0x0D, 0xC0,
  0x6C, 0xE3, 0xE7, 0x3F, 0x39, 0xF1, 0xCF, 0x80, 0xEC, 0x07, 0x60, 0x73,
  0x07, 0x9C, 0x78, 0xFF, 0x83, 0xF8, 0x0F, 0x80, 0x00, 0x60, 0x3C, 0x0F,
  0x87, 0xE1, 0xFC, 0x3B, 0x84, 0x70, 0x0C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0x80, 0x70, 0x0E, 0x01, 0x80, 0x30, 0xFF, 0xFF, 0xFB, 0xFF, 0x00, 0x01,
  0xF0, 0x1F, 0xE0, 0xFF, 0xC3, 0x87, 0x08, 0x0C, 0x00, 0x30, 0x01, 0xC0,
  0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0x7F, 0xF3, 0xFF, 0xCF, 0xFE, 0x00, 0x03, 0xF0, 0x3F,
  0xE0, 0xFF, 0xC1, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x1E, 0x07,
  0xF0, 0x1F, 0x00, 0x7F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x10,
  0x3C, 0xFF, 0xF3, 0xFF, 0x83, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x78, 0x01,
  0xF0, 0x07, 0x60, 0x1D, 0xC0, 0x73, 0x81, 0xC6, 0x07, 0x0C, 0x0C, 0x38,
  0x30, 0x70, 0xE0, 0xC3, 0x81, 0x87, 0xFF, 0xCF, 0xFF, 0x9F, 0xFF, 0x00,
  0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x1F,
  0xF8, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x07, 0xC0, 0x0F, 0xE0,
  0x3F, 0xE0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x20,
  0x78, 0xFF, 0xE1, 0xFF, 0x80, 0xFC, 0x00, 0x00, 0x3C, 0x07, 0xF0, 0x3F,
  0xC3, 0xF0, 0x1E, 0x00, 0xF0, 0x03, 0x80, 0x1D, 0xF0, 0x7F, 0xE1, 0xFF,
  0xCE, 0x07, 0x38, 0x0C, 0xE0, 0x33, 0x81, 0xCE, 0x07, 0x38, 0x38, 0x7F,
  0xE1, 0xFF, 0x01, 0xF0, 0x00, 0x3F, 0xFC, 0xFF, 0xF3, 0xFF, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x60,
  0x03, 0x80, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01, 0xC0,
  0x0E, 0x00, 0x00, 0x01, 0xF0, 0x0F, 0xF8, 0x3F, 0xF0, 0x70, 0xF1, 0xC0,
  0xE3, 0x81, 0x87, 0x07, 0x0F, 0x1C, 0x0F, 0xF0, 0x0F, 0xC0, 0x7F, 0xC1,
  0xC3, 0xC7, 0x03, 0x8C, 0x07, 0x38, 0x0E, 0x78, 0x78, 0x7F, 0xF0, 0xFF,
  0xC0, 0x7E, 0x00, 0x01, 0xF0, 0x0F, 0xF0, 0x3F, 0xF0, 0xF0, 0xE1, 0xC0,
  0xE7, 0x01, 0xCE, 0x03, 0x9C, 0x06, 0x38, 0x1C, 0x3F, 0xF8, 0x7F, 0xF0,
  0x3E, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x03, 0xF0, 0x7F, 0x80, 0xFE,
  0x03, 0xE0, 0x00, 0x0E, 0x3C, 0x78, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xC7, 0xCF, 0x8E, 0x00, 0x03, 0x83, 0xC1, 0xE0, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x07, 0xC3, 0xE0, 0xF0, 0x30, 0x78, 0xF8, 0x70,
  0x00, 0x00, 0x04, 0x00, 0xF0, 0x0F, 0x81, 0xF8, 0x1F, 0x01, 0xF0, 0x06,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x20,
  0x3F, 0xFC, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xBF, 0xFE, 0x10, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03,
  0xE0, 0x03, 0x80, 0x3E, 0x03, 0xE0, 0x7E, 0x07, 0xC0, 0x3C, 0x00, 0x80,
  0x00, 0x0F, 0x87, 0xF8, 0xFF, 0x98, 0x70, 0x0E, 0x01, 0xC0, 0x70, 0x1C,
  0x06, 0x03, 0x80, 0x60, 0x18, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0xF0,
  0x1E, 0x03, 0x80, 0x00, 0x00, 0xF8, 0x07, 0xF8, 0x1F, 0xF8, 0x78, 0x71,
  0xE0, 0x67, 0x80, 0xCE, 0x01, 0xB8, 0x3F, 0x71, 0xFE, 0xE7, 0xFD, 0x9E,
  0x37, 0x38, 0x6E, 0x61, 0xDC, 0xC3, 0xB9, 0xC6, 0x73, 0xFC, 0xE3, 0xF9,
  0xC3, 0xE1, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0xF8, 0x03, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0xF0, 0x01, 0xF0, 0x06, 0xE0, 0x1D, 0xC0, 0x33, 0x80,
  0xE3, 0x01, 0x86, 0x06, 0x0C, 0x0C, 0x18, 0x30, 0x30, 0xE0, 0x61, 0xFF,
  0xC7, 0xFF, 0x8F, 0xFF, 0x38, 0x06, 0x70, 0x0D, 0xC0, 0x1B, 0x00, 0x38,
  0x07, 0xF8, 0x1F, 0xF8, 0x3F, 0xF8, 0x70, 0x70, 0xE0, 0x61, 0x80, 0xC7,
  0x03, 0x8E, 0x0E, 0x1F, 0xF8, 0x3F, 0xE0, 0xFF, 0xE1, 0xC0, 0xE3, 0x01,
  0xC6, 0x03, 0x9C, 0x07, 0x30, 0x3C, 0x7F, 0xF8, 0xFF, 0xC3, 0xFE, 0x00,
  0x01, 0xF8, 0x0F, 0xFC, 0x3F, 0xF0, 0xF0, 0x23, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x78, 0x30, 0x7F, 0xE0, 0x7F, 0xC0, 0x7E, 0x00,
  0x07, 0xE0, 0x1F, 0xF0, 0x3F, 0xF0, 0x70, 0xF0, 0xC0, 0xE3, 0x81, 0xC7,
  0x01, 0x8C, 0x03, 0x18, 0x06, 0x70, 0x1C, 0xE0, 0x39, 0x80, 0x63, 0x01,
  0xCE, 0x07, 0x98, 0x1E, 0x30, 0xF8, 0x7F, 0xE1, 0xFF, 0x83, 0xFC, 0x00,
  0x07, 0xFE, 0x0F, 0xFE, 0x0F, 0xFE, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x1F, 0xF8, 0x1F, 0xF0, 0x3F, 0xF0, 0x38, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0x7F, 0xF0, 0x7F, 0xF0,
  0xFF, 0xF0, 0x07, 0xFF, 0x0F, 0xFE, 0x0F, 0xFE, 0x0E, 0x00, 0x0C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1F, 0xF8, 0x1F, 0xF0, 0x3F, 0xF0,
  0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00,
  0x60, 0x00, 0xE0, 0x00, 0x00, 0xFC, 0x07, 0xFC, 0x1F, 0xF8, 0x78, 0x21,
  0xC0, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80,
  0x63, 0x01, 0xCE, 0x03, 0x8C, 0x07, 0x1C, 0x0C, 0x3C, 0x38, 0x7F, 0xF0,
  0x7F, 0xE0, 0x3F, 0x00, 0x06, 0x03, 0x87, 0x01, 0xC3, 0x80, 0xC1, 0x80,
  0xE0, 0xC0, 0x70, 0xE0, 0x38, 0x70, 0x18, 0x30, 0x0C, 0x1F, 0xFE, 0x1F,
  0xFF, 0x0F, 0xFF, 0x07, 0x01, 0x83, 0x01, 0xC3, 0x80, 0xE1, 0xC0, 0x60,
  0xE0, 0x30, 0x60, 0x38, 0x70, 0x1C, 0x38, 0x0C, 0x00, 0x07, 0xFE, 0x0F,
  0xFC, 0x3F, 0xF0, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0x80, 0x03, 0x00, 0x7F, 0xE1, 0xFF, 0x83, 0xFF, 0x00, 0x03, 0xFE, 0x07,
  0xFC, 0x0F, 0xF8, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x10,
  0x38, 0x30, 0xF0, 0xFF, 0xC0, 0xFF, 0x00, 0xFC, 0x00, 0x06, 0x03, 0x83,
  0x03, 0x83, 0x83, 0x81, 0xC3, 0x80, 0xE3, 0x80, 0x63, 0x80, 0x73, 0x80,
  0x3B, 0x80, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xE0, 0x07, 0x70, 0x03, 0x9C,
  0x01, 0x87, 0x01, 0xC1, 0x80, 0xE0, 0xE0, 0x70, 0x30, 0x30, 0x1C, 0x18,
  0x06, 0x00, 0x0E, 0x01, 0x80, 0x30, 0x0E, 0x01, 0xC0, 0x30, 0x06, 0x01,
  0xC0, 0x38, 0x06, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0x03, 0x07, 0x07, 0x07, 0x07, 0x0F,
  0x0F, 0x0F, 0x1B, 0x0F, 0x1B, 0x19, 0x36, 0x19, 0x36, 0x19, 0xE6, 0x39,
  0xE6, 0x31, 0xCE, 0x31, 0x8E, 0x70, 0x0C, 0x60, 0x0C, 0x60, 0x0C, 0x60,
  0x1C, 0xE0, 0x1C, 0xC0, 0x18, 0xC0, 0x18, 0x07, 0x03, 0x87, 0x81, 0xC3,
  0xC0, 0xC1, 0xE0, 0x60, 0xF8, 0x30, 0x6C, 0x38, 0x76, 0x18, 0x33, 0x8C,
  0x18, 0xC6, 0x0C, 0x67, 0x0E, 0x33, 0x06, 0x19, 0x83, 0x06, 0xC1, 0x83,
  0xE1, 0xC1, 0xE0, 0xC0, 0xF0, 0x60, 0x78, 0x30, 0x1C, 0x38, 0x0C, 0x00,
  0x01, 0xF0, 0x0F, 0xF0, 0x3F, 0xF0, 0xF0, 0xE1, 0xC0, 0xE7, 0x01, 0xCE,
  0x03, 0xB8, 0x07, 0x70, 0x0E, 0xC0, 0x19, 0x80, 0x73, 0x00, 0xEE, 0x01,
  0x9C, 0x07, 0x18, 0x1C, 0x38, 0x78, 0x7F, 0xE0, 0x7F, 0x80, 0x7C, 0x00,
  0x0F, 0xF0, 0x1F, 0xF0, 0x3F, 0xF0, 0xE0, 0xF1, 0xC0, 0xE3, 0x81, 0xC6,
  0x03, 0x9C, 0x06, 0x38, 0x1C, 0x70, 0xF8, 0xFF, 0xE3, 0xFF, 0x87, 0xF8,
  0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x00,
  0x01, 0xF0, 0x0F, 0xF0, 0x3F, 0xF0, 0xF0, 0xE1, 0xC0, 0xE7, 0x01, 0xCE,
  0x03, 0xB8, 0x07, 0x70, 0x0E, 0xC0, 0x19, 0x80, 0x73, 0x00, 0xEE, 0x01,
  0x9C, 0x07, 0x18, 0x1C, 0x38, 0x78, 0x7F, 0xE0, 0x7F, 0x80, 0x7C, 0x00,
  0x70, 0x00, 0xF0, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x60, 0x07, 0xF8, 0x0F,
  0xF8, 0x3F, 0xF8, 0x70, 0x70, 0xE0, 0x61, 0x80, 0xC7, 0x01, 0x8E, 0x07,
  0x1C, 0x0E, 0x30, 0x78, 0xFF, 0xE1, 0xFF, 0x83, 0xBC, 0x06, 0x1C, 0x1C,
  0x18, 0x38, 0x38, 0x70, 0x30, 0xC0, 0x71, 0x80, 0xE0, 0x01, 0xF8, 0x0F,
  0xFC, 0x3F, 0xF0, 0x70, 0x21, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0F, 0x80,
  0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00,
  0x0C, 0x20, 0x78, 0xFF, 0xE1, 0xFF, 0x80, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00,
  0xE0, 0x07, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0x18, 0x0E, 0x70, 0x18, 0xE0, 0x31, 0x80, 0xE7,
  0x01, 0xCE, 0x03, 0x18, 0x06, 0x30, 0x1C, 0xE0, 0x39, 0xC0, 0x63, 0x01,
  0xC6, 0x03, 0x8C, 0x07, 0x18, 0x1C, 0x30, 0x38, 0x70, 0xE0, 0xFF, 0xC0,
  0xFF, 0x00, 0xF8, 0x00, 0xE0, 0x0F, 0xC0, 0x1B, 0x80, 0x77, 0x00, 0xCE,
  0x03, 0x9C, 0x06, 0x38, 0x1C, 0x30, 0x30, 0x60, 0xE0, 0xC3, 0x81, 0x87,
  0x03, 0x1C, 0x06, 0x30, 0x0C, 0xE0, 0x19, 0x80, 0x37, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xE0, 0x00, 0x18, 0x03, 0x0C, 0x01, 0x86, 0x01, 0xC7, 0x00,
  0xE3, 0x80, 0x61, 0x80, 0x30, 0xC0, 0x38, 0x63, 0x18, 0x73, 0x8C, 0x33,
  0x46, 0x19, 0xA6, 0x0D, 0x93, 0x06, 0xC9, 0x82, 0xC7, 0x83, 0x63, 0xC1,
  0xE1, 0xE0, 0xF0, 0xE0, 0x70, 0x70, 0x38, 0x38, 0x00, 0x03, 0x00, 0xC0,
  0x70, 0x38, 0x0E, 0x0E, 0x00, 0xC3, 0x80, 0x1C, 0xE0, 0x03, 0x98, 0x00,
  0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x01,
  0xD8, 0x00, 0x3B, 0x80, 0x0E, 0x30, 0x03, 0x86, 0x00, 0xE0, 0xE0, 0x38,
  0x1C, 0x0F, 0x01, 0x81, 0xC0, 0x38, 0x00, 0xC0, 0x1F, 0x00, 0x6C, 0x03,
  0xB8, 0x1C, 0xE0, 0x61, 0x83, 0x86, 0x1C, 0x1C, 0xE0, 0x33, 0x00, 0xD8,
  0x03, 0xE0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x30,
  0x01, 0xC0, 0x07, 0x00, 0x00, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xC0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0x7F, 0xF8, 0x7F, 0xFC, 0x3F, 0xFE, 0x00, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0xC0,
  0x06, 0x00, 0x18, 0x00, 0x7F, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0xC6, 0x39,
  0xCE, 0x73, 0x9C, 0xE3, 0x18, 0xC6, 0x31, 0xCE, 0x73, 0x9C, 0xE7, 0x38,
  0xC6, 0x31, 0x8C, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0x06, 0x00, 0x38,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x18,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xE0, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0xF8, 0x0E, 0xC0, 0xE6, 0x0E,
  0x38, 0xE0, 0xC6, 0x06, 0x70, 0x3B, 0x00, 0x80, 0x7F, 0xFD, 0xFF, 0xF8,
  0x47, 0x1C, 0x71, 0x84, 0x01, 0xF8, 0x3F, 0xF1, 0xFF, 0x8F, 0x86, 0x78,
  0x39, 0xC0, 0xC6, 0x03, 0x38, 0x1C, 0xE0, 0x73, 0x81, 0x8F, 0x0E, 0x1F,
  0xFC, 0x7F, 0xF0, 0xFD, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80,
  0x0C, 0x00, 0x30, 0x01, 0xC0, 0x07, 0xF8, 0x1F, 0xF8, 0x7F, 0xE3, 0xC3,
  0xCE, 0x07, 0x38, 0x1C, 0xC0, 0x77, 0x01, 0x9C, 0x0E, 0x60, 0x71, 0x87,
  0xC7, 0xFE, 0x3F, 0xE0, 0xFE, 0x00, 0x03, 0xF8, 0x3F, 0xF1, 0xFF, 0x8F,
  0x82, 0x78, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0F,
  0x02, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0x00, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x01, 0xFC, 0x07,
  0xFC, 0x1E, 0x1C, 0x3C, 0x18, 0x38, 0x18, 0x70, 0x38, 0x60, 0x38, 0x60,
  0x30, 0xE0, 0x30, 0xE0, 0x70, 0x60, 0x70, 0x70, 0xF0, 0x7F, 0xF0, 0x1F,
  0x30, 0x03, 0xF0, 0x3F, 0xE1, 0xFF, 0x8F, 0x07, 0x70, 0x1D, 0x81, 0xEF,
  0xFF, 0xBF, 0xF8, 0xFF, 0x83, 0x80, 0x0F, 0x02, 0x1F, 0xF8, 0x3F, 0xF0,
  0x7F, 0x00, 0x00, 0x07, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0x80,
  0xFF, 0xE0, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xFE, 0x07, 0xFC, 0x3C, 0x38, 0x70, 0x71,
  0xC0, 0xC7, 0x01, 0x8E, 0x07, 0x18, 0x0E, 0x30, 0x18, 0x60, 0x70, 0xE1,
  0xE1, 0xFF, 0x80, 0xFB, 0x00, 0x0E, 0x00, 0x1C, 0x60, 0xF0, 0xFF, 0xC1,
  0xFF, 0x81, 0xFC, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0xFC, 0x1F, 0xF8, 0x7F, 0xE1, 0xC3, 0xC7,
  0x07, 0x38, 0x1C, 0xE0, 0x73, 0x81, 0x8C, 0x06, 0x70, 0x39, 0xC0, 0xE7,
  0x03, 0x18, 0x1C, 0x60, 0x70, 0x07, 0x07, 0x83, 0xC0, 0xE0, 0x00, 0x01,
  0xF9, 0xFC, 0xFE, 0x06, 0x03, 0x03, 0x81, 0xC0, 0xC0, 0x60, 0x30, 0x1C,
  0x0F, 0xC7, 0xE1, 0xF0, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x30, 0x00,
  0xE0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x18, 0x78, 0x3F, 0xE0, 0x7F,
  0x80, 0x7C, 0x00, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0x80, 0x07, 0x00, 0x0E, 0x0E, 0x1C, 0x38, 0x30, 0xE0, 0x67, 0x81,
  0xDE, 0x03, 0xF0, 0x07, 0xC0, 0x0D, 0xC0, 0x39, 0xC0, 0x71, 0xC0, 0xC3,
  0x81, 0x83, 0x87, 0x03, 0x0E, 0x07, 0x00, 0xFE, 0xFC, 0xFC, 0x0C, 0x1C,
  0x18, 0x18, 0x38, 0x38, 0x30, 0x30, 0x70, 0x60, 0x60, 0xE0, 0xE0, 0xE0,
  0xE1, 0xFF, 0x7F, 0x3E, 0x0F, 0xBC, 0x3F, 0xFC, 0x63, 0x18, 0xC6, 0x33,
  0x9C, 0x66, 0x39, 0xCC, 0x63, 0x18, 0xC6, 0x73, 0x8C, 0xC0, 0x39, 0x80,
  0x63, 0x00, 0xCE, 0x01, 0x98, 0x07, 0x00, 0x07, 0xE0, 0xFF, 0x87, 0xFE,
  0x30, 0x73, 0x81, 0x9C, 0x0C, 0xE0, 0x66, 0x07, 0x70, 0x3B, 0x81, 0x98,
  0x0C, 0xC0, 0xEE, 0x07, 0x70, 0x30, 0x03, 0xE0, 0x3F, 0xE1, 0xFF, 0x8F,
  0x0F, 0x38, 0x1D, 0xC0, 0x76, 0x01, 0x98, 0x06, 0xE0, 0x3B, 0x81, 0xE7,
  0x0F, 0x1F, 0xF8, 0x7F, 0xC0, 0x7C, 0x00, 0x07, 0xF0, 0x1F, 0xF8, 0x3F,
  0xF0, 0xE0, 0xF1, 0xC0, 0xE3, 0x81, 0xC6, 0x03, 0x9C, 0x06, 0x38, 0x1C,
  0x60, 0x70, 0xC3, 0xE3, 0xFF, 0x87, 0xFE, 0x0F, 0xF0, 0x18, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x00, 0x01, 0xFC, 0x1F, 0xF1, 0xE1,
  0xCF, 0x07, 0x38, 0x19, 0xC0, 0xE6, 0x03, 0x98, 0x0E, 0xE0, 0x33, 0x81,
  0xC6, 0x07, 0x1C, 0x3C, 0x7F, 0xE0, 0x7F, 0x80, 0x0E, 0x00, 0x30, 0x00,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x07, 0xF8, 0xFF, 0xC7, 0xFE, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x18, 0x01, 0xC0,
  0x0E, 0x00, 0x60, 0x00, 0x03, 0xF0, 0x3F, 0xE0, 0xFF, 0x87, 0x02, 0x1C,
  0x00, 0x7C, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xC6, 0x0F, 0x1F,
  0xF8, 0xFF, 0xC0, 0xFE, 0x00, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x7F,
  0xF7, 0xFF, 0xFF, 0xF1, 0xC0, 0x18, 0x03, 0x80, 0x38, 0x03, 0x00, 0x30,
  0x07, 0x00, 0x70, 0x43, 0xFC, 0x3F, 0xC1, 0xF0, 0x30, 0x3B, 0x81, 0xDC,
  0x0C, 0xC0, 0xEE, 0x07, 0x70, 0x33, 0x01, 0x98, 0x1C, 0xC0, 0xE6, 0x07,
  0x38, 0xF1, 0xFF, 0x87, 0xFE, 0x1F, 0x70, 0xE0, 0x37, 0x03, 0xB8, 0x1D,
  0xC1, 0xCE, 0x0E, 0x70, 0xE1, 0x87, 0x0C, 0x70, 0x63, 0x03, 0xB8, 0x1F,
  0x80, 0xF8, 0x03, 0xC0, 0x1C, 0x00, 0x30, 0x07, 0x70, 0x06, 0x70, 0x06,
  0x60, 0x0E, 0x61, 0x8C, 0x63, 0x8C, 0x63, 0x9C, 0x67, 0x98, 0x6D, 0xB8,
  0x6D, 0xB0, 0x78, 0xF0, 0x70, 0xE0, 0xF0, 0xE0, 0xE0, 0xC0, 0x1C, 0x0E,
  0x0E, 0x0C, 0x06, 0x18, 0x07, 0x38, 0x03, 0x70, 0x03, 0xE0, 0x01, 0xC0,
  0x03, 0xC0, 0x07, 0xE0, 0x0E, 0xE0, 0x1C, 0x70, 0x38, 0x70, 0x70, 0x30,
  0xE0, 0x38, 0x07, 0x01, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x0C, 0x0C, 0x03,
  0x07, 0x00, 0xE1, 0x80, 0x38, 0xE0, 0x0E, 0x30, 0x01, 0x9C, 0x00, 0x66,
  0x00, 0x1F, 0x80, 0x07, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x00, 0x0F, 0xFC, 0x7F,
  0xF1, 0xFF, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x3F, 0xF8, 0xFF, 0xE3, 0xFF, 0x80, 0x00, 0x7E,
  0x01, 0xF8, 0x07, 0xF0, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x03,
  0x80, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0xE0, 0x0F, 0xC0, 0x1F, 0x00,
  0x3E, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03,
  0x00, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x7C,
  0x00, 0x03, 0x01, 0x80, 0xC0, 0xE0, 0x70, 0x30, 0x18, 0x1C, 0x0E, 0x06,
  0x03, 0x03, 0x81, 0xC0, 0xC0, 0x60, 0x70, 0x38, 0x18, 0x0C, 0x06, 0x07,
  0x03, 0x01, 0x80, 0xC0, 0xE0, 0x70, 0x30, 0x00, 0x03, 0xF0, 0x07, 0xF0,
  0x0F, 0xE0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x03, 0xE0, 0x07, 0xC0, 0x1F,
  0x80, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0xE0, 0x03, 0x80, 0xFF, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x1E,
  0x0C, 0xFC, 0x76, 0x3F, 0xB0, 0x3C,
};

const GFXglyph UbuntuMono_Italic31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 8, 19, 16, 5, -19 },
  { 20, 9, 8, 16, 7, -19 },
  { 29, 17, 19, 16, 1, -19 },
  { 70, 15, 24, 16, 2, -21 },
  { 115, 19, 19, 16, 0, -19 },
  { 161, 13, 19, 16, 2, -19 },
  { 192, 4, 8, 16, 9, -21 },
  { 196, 11, 27, 16, 5, -22 },
  { 234, 11, 27, 16, 2, -22 },
  { 272, 12, 11, 16, 4, -19 },
  { 289, 13, 14, 16, 3, -15 },
  { 312, 7, 8, 16, 3, -4 },
  { 319, 8, 2, 16, 5, -9 },
  { 321, 5, 4, 16, 5, -4 },
  { 324, 18, 27, 16, -1, -22 },
  { 385, 13, 19, 16, 3, -19 },
  { 416, 11, 19, 16, 3, -19 },
  { 443, 14, 19, 16, 2, -19 },
  { 477, 14, 19, 16, 2, -19 },
  { 511, 15, 19, 16, 1, -19 },
  { 547, 15, 19, 16, 2, -19 },
  { 583, 14, 19, 16, 3, -19 },
  { 617, 14, 19, 16, 4, -19 },
  { 651, 15, 19, 16, 2, -19 },
  { 687, 15, 19, 16, 2, -19 },
  { 723, 7, 14, 16, 5, -14 },
  { 736, 9, 18, 16, 3, -14 },
  { 757, 14, 13, 16, 2, -14 },
  { 780, 14, 8, 16, 2, -12 },
  { 794, 14, 13, 16, 2, -15 },
  { 817, 11, 19, 16, 5, -19 },
  { 844, 15, 23, 16, 2, -19 },
  { 888, 15, 19, 16, 0, -19 },
  { 924, 15, 19, 16, 1, -19 },
  { 960, 15, 19, 16, 3, -19 },
  { 996, 15, 19, 16, 1, -19 },
  { 1032, 16, 19, 16, 2, -19 },
  { 1070, 16, 19, 16, 2, -19 },
  { 1108, 15, 19, 16, 2, -19 },
  { 1144, 17, 19, 16, 1, -19 },
  { 1185, 15, 19, 16, 2, -19 },
  { 1221, 15, 19, 16, 2, -19 },
  { 1257, 17, 19, 16, 1, -19 },
  { 1298, 11, 19, 16, 2, -19 },
  { 1325, 16, 19, 16, 1, -19 },
  { 1363, 17, 19, 16, 1, -19 },
  { 1404, 15, 19, 16, 2, -19 },
  { 1440, 15, 19, 16, 2, -19 },
  { 1476, 15, 24, 16, 2, -19 },
  { 1521, 15, 19, 16, 1, -19 },
  { 1557, 15, 19, 16, 2, -19 },
  { 1593, 13, 19, 16, 5, -19 },
  { 1624, 15, 19, 16, 3, -19 },
  { 1660, 15, 19, 16, 4, -19 },
  { 1696, 17, 19, 16, 2, -19 },
  { 1737, 19, 19, 16, 0, -19 },
  { 1783, 14, 19, 16, 5, -19 },
  { 1817, 17, 19, 16, 1, -19 },
  { 1858, 14, 27, 16, 3, -22 },
  { 1906, 5, 27, 16, 7, -22 },
  { 1923, 14, 27, 16, 1, -22 },
  { 1971, 13, 10, 16, 3, -19 },
  { 1988, 15, 2, 16, -1, 3 },
  { 1992, 5, 6, 16, 8, -22 },
  { 1996, 14, 14, 16, 2, -14 },
  { 2021, 14, 21, 16, 2, -21 },
  { 2058, 14, 14, 16, 2, -14 },
  { 2083, 16, 21, 16, 2, -21 },
  { 2125, 14, 14, 16, 2, -14 },
  { 2150, 19, 26, 16, 0, -21 },
  { 2212, 15, 19, 16, 1, -14 },
  { 2248, 14, 21, 16, 1, -21 },
  { 2285, 9, 20, 16, 4, -20 },
  { 2308, 15, 25, 16, 1, -20 },
  { 2355, 15, 21, 16, 2, -21 },
  { 2395, 8, 21, 16, 6, -21 },
  { 2416, 15, 14, 16, 1, -14 },
  { 2443, 13, 14, 16, 2, -14 },
  { 2466, 14, 14, 16, 2, -14 },
  { 2491, 15, 19, 16, 1, -14 },
  { 2527, 14, 19, 16, 2, -14 },
  { 2561, 13, 14, 16, 3, -14 },
  { 2584, 14, 14, 16, 2, -14 },
  { 2609, 12, 18, 16, 4, -18 },
  { 2636, 13, 14, 16, 3, -14 },
  { 2659, 13, 14, 16, 4, -14 },
  { 2682, 16, 14, 16, 2, -14 },
  { 2710, 16, 14, 16, 1, -14 },
  { 2738, 18, 19, 16, -1, -14 },
  { 2781, 14, 14, 16, 2, -14 },
  { 2806, 15, 27, 16, 3, -22 },
  { 2857, 9, 27, 16, 5, -22 },
  { 2888, 15, 27, 16, 0, -22 },
  { 2939, 14, 4, 16, 2, -12 },
};

const GFXfont UbuntuMono_Italic31pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Italic31pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Italic31pt7bGlyphs,
  0x20, 0x7E, 31
};

#endif // _UBUNTUMONO_ITALIC31PT7B_H_
