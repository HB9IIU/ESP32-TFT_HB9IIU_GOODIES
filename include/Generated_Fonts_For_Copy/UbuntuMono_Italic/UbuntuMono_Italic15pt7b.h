#ifndef _UBUNTUMONO_ITALIC15PT7B_H_
#define _UBUNTUMONO_ITALIC15PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Italic.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Italic15pt7bBitmaps[] PROGMEM = {
  0x00, 0x25, 0xA4, 0x84, 0x80, 0x52, 0xA5, 0x20, 0x12, 0x12, 0x7E, 0x24,
  0x2C, 0x48, 0xFE, 0xD0, 0x90, 0x0C, 0x10, 0x79, 0x02, 0x03, 0x01, 0x42,
  0xF8, 0x40, 0x80, 0x38, 0x94, 0x8A, 0x89, 0x83, 0xE0, 0xA8, 0xA4, 0x94,
  0x46, 0x00, 0x1C, 0x92, 0xCE, 0x77, 0x58, 0xA6, 0xFC, 0x56, 0x04, 0x61,
  0x08, 0x61, 0x0C, 0x20, 0x82, 0x0C, 0x10, 0x60, 0x80, 0x10, 0x60, 0x82,
  0x08, 0x30, 0x82, 0x08, 0x43, 0x08, 0x42, 0x00, 0x33, 0xB3, 0x0C, 0x79,
  0x20, 0x08, 0x20, 0x47, 0xE1, 0x06, 0x08, 0x00, 0x6D, 0x40, 0xE0, 0xF0,
  0x01, 0x02, 0x02, 0x04, 0x0C, 0x08, 0x10, 0x30, 0x20, 0x60, 0x40, 0x80,
  0x1C, 0x4D, 0x8A, 0x95, 0x78, 0xB1, 0x64, 0x70, 0x0C, 0x62, 0x82, 0x08,
  0x41, 0x04, 0xF8, 0x1C, 0x4C, 0x08, 0x20, 0xC6, 0x18, 0x20, 0xFC, 0x3C,
  0x4C, 0x18, 0x21, 0x80, 0x81, 0x46, 0xF8, 0x06, 0x18, 0x51, 0x24, 0xD9,
  0x3F, 0x04, 0x18, 0x1E, 0x60, 0x81, 0xC0, 0xC0, 0x81, 0x06, 0xF0, 0x0E,
  0x20, 0x83, 0xE4, 0x48, 0xB1, 0x26, 0x78, 0x7E, 0x08, 0x20, 0x83, 0x04,
  0x10, 0x20, 0xC0, 0x1C, 0x44, 0x89, 0x23, 0x88, 0xA1, 0x66, 0x78, 0x1C,
  0x4D, 0x0A, 0x14, 0x27, 0x81, 0x0C, 0xE0, 0x6C, 0x01, 0xB0, 0x33, 0x00,
  0x06, 0x64, 0x80, 0x02, 0x39, 0xC6, 0x03, 0x01, 0x80, 0x7E, 0x00, 0x07,
  0xE0, 0x60, 0x70, 0x10, 0xC6, 0x10, 0x00, 0x38, 0x30, 0xC6, 0x31, 0x80,
  0x10, 0xC0, 0x1E, 0x65, 0x8A, 0x7D, 0x34, 0xED, 0x4E, 0x80, 0x80, 0xE0,
  0x04, 0x1C, 0x48, 0x92, 0x24, 0x5F, 0xA1, 0x82, 0x3C, 0xCD, 0x0A, 0x27,
  0x88, 0xA1, 0x46, 0xF8, 0x1E, 0x32, 0x60, 0x40, 0xC0, 0xC0, 0xC0, 0x44,
  0x78, 0x3C, 0xC9, 0x0A, 0x14, 0x78, 0xA1, 0x44, 0xF0, 0x3E, 0x20, 0x20,
  0x60, 0x7C, 0x40, 0x40, 0xC0, 0xFC, 0x3E, 0x20, 0x20, 0x60, 0x7C, 0x40,
  0x40, 0xC0, 0x80, 0x1E, 0x45, 0x02, 0x0C, 0x10, 0xB1, 0x22, 0x78, 0x23,
  0x62, 0x42, 0x42, 0x7E, 0xC4, 0x84, 0x84, 0x8C, 0x3E, 0x10, 0x60, 0x81,
  0x02, 0x0C, 0x10, 0xF8, 0x1E, 0x04, 0x18, 0x20, 0x40, 0x83, 0x44, 0x70,
  0x22, 0x24, 0x68, 0x50, 0x60, 0x50, 0xD8, 0x88, 0x8C, 0x21, 0x18, 0x84,
  0x23, 0x10, 0xF8, 0x11, 0x13, 0x2B, 0x2D, 0x2D, 0x4B, 0x42, 0x42, 0xC2,
  0x23, 0x72, 0x52, 0x52, 0x56, 0xCC, 0x8C, 0x8C, 0x8C, 0x1C, 0x45, 0x0A,
  0x1C, 0x30, 0xE1, 0x66, 0x70, 0x3C, 0x45, 0x8A, 0x14, 0x4F, 0x30, 0x40,
  0x80, 0x1C, 0x45, 0x0A, 0x1C, 0x30, 0xE1, 0x66, 0x70, 0x40, 0x60, 0x3C,
  0x4D, 0x0A, 0x27, 0x89, 0x32, 0x44, 0x8C, 0x1E, 0x40, 0x81, 0x01, 0x81,
  0x81, 0x46, 0xF8, 0xFE, 0x20, 0xC1, 0x02, 0x04, 0x18, 0x20, 0x40, 0x23,
  0x62, 0x42, 0x42, 0x44, 0xC4, 0x84, 0xCC, 0x78, 0x83, 0x0A, 0x14, 0x48,
  0x92, 0x3C, 0x70, 0x40, 0x61, 0x43, 0x42, 0x52, 0x6A, 0xAC, 0xCC, 0xCC,
  0x88, 0x11, 0x8D, 0x82, 0x81, 0x80, 0xC0, 0xA0, 0xD0, 0xCC, 0x42, 0x00,
  0x83, 0x89, 0x32, 0x45, 0x04, 0x08, 0x30, 0x40, 0x3E, 0x06, 0x0C, 0x08,
  0x10, 0x20, 0x40, 0xC0, 0xFC, 0x1E, 0x20, 0x40, 0x83, 0x04, 0x08, 0x10,
  0x60, 0x81, 0x03, 0x80, 0xDB, 0x24, 0x92, 0x49, 0x30, 0x1E, 0x04, 0x10,
  0x20, 0x40, 0x82, 0x04, 0x08, 0x30, 0x47, 0x80, 0x10, 0xA6, 0xB2, 0x84,
  0xFC, 0x89, 0x00, 0x1E, 0xC9, 0x14, 0x28, 0xD9, 0x9F, 0x00, 0x20, 0x40,
  0x81, 0xE4, 0x48, 0xD1, 0x22, 0x89, 0xE0, 0x3E, 0xC3, 0x04, 0x08, 0x18,
  0x1F, 0x00, 0x03, 0x02, 0x02, 0x1E, 0x66, 0x46, 0xC4, 0x84, 0xCC, 0x74,
  0x3C, 0xCF, 0x17, 0xC8, 0x18, 0x1F, 0x00, 0x07, 0x86, 0x02, 0x03, 0xE0,
  0x80, 0x40, 0x60, 0x20, 0x10, 0x08, 0x0C, 0x1C, 0x00, 0x0F, 0x33, 0x22,
  0x62, 0x62, 0x66, 0x3C, 0x0C, 0xF8, 0x20, 0x82, 0x1F, 0x45, 0x14, 0x73,
  0x8A, 0x20, 0x33, 0x0E, 0x22, 0x64, 0x43, 0x02, 0x02, 0x00, 0x1E, 0x02,
  0x06, 0x04, 0x04, 0x04, 0x08, 0x08, 0xF0, 0x30, 0x40, 0x81, 0x36, 0xCB,
  0x18, 0x28, 0xC9, 0x18, 0xE2, 0x64, 0x44, 0xC8, 0x8F, 0x3F, 0x29, 0x2B,
  0x4A, 0x42, 0x42, 0x42, 0x3D, 0x14, 0x51, 0x47, 0x38, 0x80, 0x3C, 0xC9,
  0x1E, 0x28, 0x59, 0x9C, 0x00, 0x3E, 0x22, 0x23, 0x22, 0x62, 0x44, 0x78,
  0x40, 0xC0, 0x1E, 0xCD, 0x16, 0x28, 0x59, 0x9E, 0x04, 0x18, 0x3E, 0x41,
  0x82, 0x04, 0x08, 0x30, 0x00, 0x3C, 0x40, 0x81, 0xC0, 0xD1, 0x9E, 0x00,
  0x20, 0x8F, 0xD8, 0x41, 0x04, 0x10, 0x78, 0x46, 0x89, 0x16, 0x28, 0xD9,
  0x9F, 0x00, 0x86, 0x28, 0xB4, 0xD1, 0x84, 0x00, 0x43, 0x42, 0xD2, 0x94,
  0xAC, 0xCC, 0xC8, 0x33, 0x12, 0x1C, 0x08, 0x1C, 0x24, 0x46, 0x21, 0x23,
  0x32, 0x16, 0x14, 0x18, 0x18, 0x10, 0xE0, 0x3E, 0x18, 0x61, 0x86, 0x08,
  0x3E, 0x00, 0x0E, 0x08, 0x10, 0x10, 0x10, 0xE0, 0x20, 0x20, 0x20, 0x40,
  0x40, 0x78, 0x10, 0x84, 0x22, 0x10, 0x8C, 0x42, 0x11, 0x80, 0x1C, 0x08,
  0x10, 0x20, 0x40, 0xC2, 0x04, 0x08, 0x20, 0x47, 0x00, 0x73, 0x38,
};

const GFXglyph UbuntuMono_Italic15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 3, 9, 8, 3, -9 },
  { 5, 5, 4, 8, 3, -9 },
  { 8, 8, 9, 8, 1, -9 },
  { 17, 7, 11, 8, 1, -10 },
  { 27, 9, 9, 8, 0, -9 },
  { 38, 6, 9, 8, 1, -9 },
  { 45, 2, 4, 8, 4, -10 },
  { 46, 6, 14, 8, 2, -11 },
  { 57, 6, 14, 8, 1, -11 },
  { 68, 6, 6, 8, 2, -9 },
  { 73, 7, 7, 8, 1, -7 },
  { 80, 3, 4, 8, 2, -2 },
  { 82, 3, 1, 8, 3, -4 },
  { 83, 2, 2, 8, 3, -2 },
  { 84, 8, 12, 8, 0, -10 },
  { 96, 7, 9, 8, 1, -9 },
  { 104, 6, 9, 8, 1, -9 },
  { 111, 7, 9, 8, 1, -9 },
  { 119, 7, 9, 8, 1, -9 },
  { 127, 7, 9, 8, 1, -9 },
  { 135, 7, 9, 8, 1, -9 },
  { 143, 7, 9, 8, 1, -9 },
  { 151, 7, 9, 8, 2, -9 },
  { 159, 7, 9, 8, 1, -9 },
  { 167, 7, 9, 8, 1, -9 },
  { 175, 3, 7, 8, 3, -7 },
  { 178, 4, 9, 8, 2, -7 },
  { 183, 7, 6, 8, 1, -7 },
  { 189, 7, 4, 8, 1, -6 },
  { 193, 7, 6, 8, 1, -7 },
  { 199, 6, 9, 8, 2, -9 },
  { 206, 7, 11, 8, 1, -9 },
  { 216, 7, 9, 8, 0, -9 },
  { 224, 7, 9, 8, 1, -9 },
  { 232, 8, 9, 8, 1, -9 },
  { 241, 7, 9, 8, 1, -9 },
  { 249, 8, 9, 8, 1, -9 },
  { 258, 8, 9, 8, 1, -9 },
  { 267, 7, 9, 8, 1, -9 },
  { 275, 8, 9, 8, 1, -9 },
  { 284, 7, 9, 8, 1, -9 },
  { 292, 7, 9, 8, 1, -9 },
  { 300, 8, 9, 8, 1, -9 },
  { 309, 5, 9, 8, 1, -9 },
  { 315, 8, 9, 8, 0, -9 },
  { 324, 8, 9, 8, 1, -9 },
  { 333, 7, 9, 8, 1, -9 },
  { 341, 7, 9, 8, 1, -9 },
  { 349, 7, 11, 8, 1, -9 },
  { 359, 7, 9, 8, 1, -9 },
  { 367, 7, 9, 8, 1, -9 },
  { 375, 7, 9, 8, 2, -9 },
  { 383, 8, 9, 8, 1, -9 },
  { 392, 7, 9, 8, 2, -9 },
  { 400, 8, 9, 8, 1, -9 },
  { 409, 9, 9, 8, 0, -9 },
  { 420, 7, 9, 8, 2, -9 },
  { 428, 8, 9, 8, 1, -9 },
  { 437, 7, 12, 8, 1, -10 },
  { 448, 3, 12, 8, 3, -10 },
  { 453, 7, 12, 8, 0, -10 },
  { 464, 6, 5, 8, 2, -9 },
  { 468, 7, 1, 8, 0, 1 },
  { 469, 3, 3, 8, 4, -11 },
  { 471, 7, 7, 8, 1, -7 },
  { 478, 7, 10, 8, 1, -10 },
  { 487, 7, 7, 8, 1, -7 },
  { 494, 8, 10, 8, 1, -10 },
  { 504, 7, 7, 8, 1, -7 },
  { 511, 9, 12, 8, 0, -10 },
  { 525, 8, 9, 8, 0, -7 },
  { 534, 6, 10, 8, 1, -10 },
  { 542, 4, 10, 8, 2, -10 },
  { 547, 8, 12, 8, 0, -10 },
  { 559, 7, 10, 8, 1, -10 },
  { 568, 4, 10, 8, 3, -10 },
  { 573, 8, 7, 8, 0, -7 },
  { 580, 6, 7, 8, 1, -7 },
  { 586, 7, 7, 8, 1, -7 },
  { 593, 8, 9, 8, 0, -7 },
  { 602, 7, 9, 8, 1, -7 },
  { 610, 7, 7, 8, 1, -7 },
  { 617, 7, 7, 8, 1, -7 },
  { 624, 6, 9, 8, 2, -9 },
  { 631, 7, 7, 8, 1, -7 },
  { 638, 6, 7, 8, 2, -7 },
  { 644, 8, 7, 8, 1, -7 },
  { 651, 8, 7, 8, 0, -7 },
  { 658, 8, 9, 8, 0, -7 },
  { 667, 7, 7, 8, 1, -7 },
  { 674, 8, 12, 8, 1, -10 },
  { 686, 5, 12, 8, 2, -10 },
  { 694, 7, 12, 8, 0, -10 },
  { 705, 7, 2, 8, 1, -6 },
};

const GFXfont UbuntuMono_Italic15pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Italic15pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Italic15pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _UBUNTUMONO_ITALIC15PT7B_H_
