#ifndef _UBUNTUMONO_ITALIC54PT7B_H_
#define _UBUNTUMONO_ITALIC54PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Italic.ttf
// Size: 54pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Italic54pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0xFC, 0x07, 0xE0,
  0x7F, 0x03, 0xF8, 0x0F, 0xC0, 0x38, 0x00, 0x3C, 0x1E, 0x78, 0x3C, 0xF0,
  0x7B, 0xE1, 0xE7, 0x83, 0xCF, 0x07, 0x9E, 0x0F, 0x38, 0x1C, 0xF0, 0x79,
  0xE0, 0xF3, 0x81, 0xC7, 0x03, 0x8C, 0x06, 0x00, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0x78, 0x1E, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x03, 0xE0,
  0xF8, 0x00, 0x1E, 0x07, 0x80, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x0F, 0x00, 0x03,
  0xE0, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0x78, 0x1E, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x3C, 0x0F, 0x00,
  0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0x80, 0x78, 0x1E, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x3C, 0x0F,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0x00, 0xFC, 0x07, 0x80, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x80, 0x07, 0xC0, 0xF0, 0x0F, 0xE0,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x3F, 0xC0, 0x0F, 0x00, 0x3F, 0xE0, 0x07, 0x00, 0x3F, 0xF0, 0x07,
  0x80, 0x1E, 0x3C, 0x07, 0x80, 0x1E, 0x1E, 0x07, 0x80, 0x0F, 0x0F, 0x07,
  0x80, 0x07, 0x07, 0x87, 0x80, 0x03, 0x83, 0x87, 0x80, 0x03, 0xC1, 0xC3,
  0x80, 0x01, 0xE1, 0xE3, 0xC0, 0x00, 0xF0, 0xF3, 0xC0, 0x00, 0x78, 0xF3,
  0xC0, 0x00, 0x1F, 0xFB, 0xC0, 0x00, 0x0F, 0xFB, 0xC0, 0x00, 0x03, 0xFB,
  0xC0, 0x00, 0x00, 0xF3, 0xCF, 0x80, 0x00, 0x01, 0xEF, 0xE0, 0x00, 0x01,
  0xEF, 0xF8, 0x00, 0x01, 0xEF, 0xFC, 0x00, 0x01, 0xE7, 0x8E, 0x00, 0x01,
  0xE7, 0x87, 0x80, 0x01, 0xE3, 0x83, 0xC0, 0x01, 0xE1, 0xC1, 0xC0, 0x00,
  0xE0, 0xE0, 0xE0, 0x00, 0xF0, 0xF0, 0x70, 0x00, 0xF0, 0x78, 0x78, 0x00,
  0xF0, 0x3C, 0x3C, 0x00, 0xF0, 0x1E, 0x3C, 0x00, 0xF0, 0x07, 0xFE, 0x00,
  0xF0, 0x03, 0xFE, 0x00, 0x70, 0x01, 0xFE, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xFC, 0x01, 0xF8, 0x7C, 0x01, 0xF0, 0x3C, 0x01, 0xE0, 0x3C, 0x03, 0xE0,
  0x3C, 0x03, 0xE0, 0x78, 0x03, 0xC0, 0x78, 0x03, 0xE0, 0xF0, 0x01, 0xE3,
  0xE0, 0x01, 0xE7, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xF8,
  0x0F, 0x07, 0xFC, 0x1E, 0x0F, 0xFC, 0x1E, 0x1F, 0x3E, 0x1C, 0x3E, 0x1F,
  0x3C, 0x3C, 0x0F, 0x3C, 0x78, 0x0F, 0xF8, 0x78, 0x07, 0xF8, 0xF8, 0x03,
  0xF0, 0xF8, 0x03, 0xF0, 0xF8, 0x01, 0xE0, 0xF8, 0x03, 0xF0, 0xF8, 0x07,
  0xF0, 0xFC, 0x1F, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFC, 0x78, 0x1F, 0xF8,
  0x78, 0x0F, 0xC0, 0x7C, 0x1E, 0x7C, 0xF9, 0xE3, 0xCF, 0x9F, 0x3C, 0x78,
  0xF1, 0xC7, 0x8F, 0x1C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x0E, 0x00, 0x01,
  0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x38, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x0F, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x10, 0x3C, 0x09, 0xE1, 0xE3, 0xCF, 0xCE, 0x7F, 0x7F, 0xBF,
  0xF9, 0xFF, 0xFF, 0x80, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xE0, 0x01,
  0xEF, 0x80, 0x1F, 0x3E, 0x01, 0xF1, 0xF8, 0x1F, 0x87, 0xC0, 0xF8, 0x3E,
  0x01, 0xC0, 0xE0, 0x04, 0x02, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0xC1, 0xFC, 0x3F, 0x8F, 0xF1, 0xFE, 0x1F, 0xC1, 0xF8, 0x1F, 0x07,
  0xC3, 0xF3, 0xFC, 0x7F, 0x0F, 0x81, 0xC0, 0x00, 0x7F, 0xFB, 0xFF, 0xDF,
  0xFE, 0xFF, 0xF0, 0x3E, 0x7F, 0x7F, 0xFF, 0xFF, 0x7E, 0x3C, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF,
  0xE0, 0x3F, 0x87, 0xE0, 0xFC, 0x07, 0xC1, 0xF0, 0x0F, 0x87, 0xC0, 0x0F,
  0x1F, 0x00, 0x1E, 0x3E, 0x00, 0x3C, 0xF8, 0x00, 0x79, 0xF0, 0x00, 0xF3,
  0xC3, 0x81, 0xEF, 0x8F, 0x83, 0xDE, 0x3F, 0x8F, 0xBC, 0x7F, 0x1F, 0xF8,
  0xFE, 0x3D, 0xF0, 0xF8, 0x7B, 0xC1, 0xE1, 0xF7, 0x80, 0x03, 0xEF, 0x00,
  0x07, 0x9E, 0x00, 0x1F, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0xF8, 0xF0, 0x01,
  0xE1, 0xE0, 0x07, 0xC3, 0xC0, 0x1F, 0x07, 0xC0, 0x7E, 0x0F, 0xC3, 0xF8,
  0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x3F,
  0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xE7, 0xC0, 0x78,
  0x78, 0x06, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x07, 0xFF, 0xFE, 0x7F, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03,
  0xF0, 0x3F, 0x01, 0xC0, 0x1F, 0x01, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0x80,
  0x1F, 0xFF, 0xE0, 0x0F, 0x03, 0xF0, 0x02, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0xFF,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3F, 0x04, 0x00, 0x3F, 0x07, 0x80, 0x7F, 0x83, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0x7C, 0x00,
  0x1F, 0x3E, 0x00, 0x1F, 0x1E, 0x00, 0x1F, 0x0F, 0x00, 0x1F, 0x0F, 0x80,
  0x1F, 0x07, 0xC0, 0x1F, 0x03, 0xC0, 0x1F, 0x01, 0xE0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF8, 0x0F, 0x80, 0x78, 0x0F, 0x80, 0x3C, 0x07, 0x80, 0x1E,
  0x07, 0x80, 0x1F, 0x07, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x10, 0x00, 0xFC, 0x07, 0x80, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x03,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xE3, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0,
  0x7F, 0x01, 0xF8, 0x3E, 0x00, 0x7C, 0x1E, 0x00, 0x1F, 0x0F, 0x00, 0x0F,
  0x8F, 0x80, 0x07, 0xC7, 0xC0, 0x03, 0xE3, 0xE0, 0x01, 0xF1, 0xF0, 0x00,
  0xF0, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x0F, 0x80,
  0x7E, 0x07, 0xE0, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0x80,
  0x1F, 0xFF, 0xE0, 0x1F, 0x81, 0xF8, 0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x3E,
  0x0F, 0x80, 0x0F, 0x07, 0xC0, 0x0F, 0x83, 0xC0, 0x07, 0xC1, 0xE0, 0x03,
  0xC0, 0xF8, 0x03, 0xE0, 0x7C, 0x03, 0xE0, 0x1F, 0x83, 0xE0, 0x0F, 0xF7,
  0xE0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x03, 0xF1,
  0xFE, 0x03, 0xE0, 0x3F, 0x03, 0xE0, 0x0F, 0xC3, 0xE0, 0x03, 0xE1, 0xE0,
  0x01, 0xF0, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x3E,
  0x00, 0x3E, 0x1F, 0x00, 0x3F, 0x07, 0xE0, 0x7F, 0x03, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x3F,
  0x83, 0xF0, 0x3F, 0x00, 0xF8, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x0F,
  0x80, 0x0F, 0x87, 0x80, 0x07, 0xC7, 0xC0, 0x03, 0xE3, 0xE0, 0x01, 0xF1,
  0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x7C, 0x3C, 0x00, 0x3C, 0x1F, 0x80, 0xFE,
  0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x1F, 0xC7,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x01, 0xFF,
  0x80, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x7F, 0x07, 0xF0,
  0xFF, 0x0F, 0xF0, 0x7E, 0x03, 0xC0, 0x00, 0x3C, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x3F, 0x80, 0x7F, 0x01, 0xFE, 0x03, 0xFC, 0x03,
  0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x07, 0xF8, 0x0F, 0xE0,
  0x1F, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x3F, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x60, 0x0F,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0x06, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0xFE, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xC0,
  0x7E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xE0, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0xFE, 0x0F,
  0x80, 0x7E, 0x01, 0xF0, 0x3E, 0x00, 0x3C, 0x1F, 0x00, 0x0F, 0x07, 0xC0,
  0x03, 0xC3, 0xE0, 0x00, 0xF1, 0xF0, 0x00, 0x3C, 0x7C, 0x03, 0xFF, 0x3E,
  0x03, 0xFF, 0xCF, 0x83, 0xFF, 0xE3, 0xC1, 0xFF, 0xF9, 0xF0, 0xFC, 0x1E,
  0x78, 0x3E, 0x07, 0x9E, 0x1F, 0x03, 0xC7, 0x87, 0x80, 0xF3, 0xE3, 0xE0,
  0x3C, 0xF0, 0xF0, 0x0F, 0x3C, 0x3C, 0x07, 0x8F, 0x0F, 0x01, 0xE3, 0xC3,
  0xC0, 0x78, 0xF0, 0xF0, 0x3E, 0x3C, 0x3C, 0x0F, 0x8F, 0x0F, 0x83, 0xC3,
  0xC3, 0xF0, 0xF0, 0xF0, 0x7F, 0xFC, 0x3C, 0x0F, 0xFF, 0x0F, 0x01, 0xFF,
  0x83, 0xE0, 0x1F, 0x80, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x7B, 0xE0, 0x00, 0x1E, 0x78, 0x00, 0x0F, 0x1E,
  0x00, 0x07, 0x87, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x3C,
  0x1E, 0x00, 0x1E, 0x07, 0x80, 0x07, 0x81, 0xE0, 0x03, 0xC0, 0x78, 0x00,
  0xF0, 0x1F, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x7C,
  0x07, 0xC0, 0x1F, 0x01, 0xE0, 0x03, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC3, 0xE0, 0x00, 0xF0, 0xF0,
  0x00, 0x3C, 0x7C, 0x00, 0x0F, 0x1E, 0x00, 0x03, 0xCF, 0x80, 0x00, 0xF3,
  0xC0, 0x00, 0x3D, 0xF0, 0x00, 0x0F, 0x78, 0x00, 0x03, 0xC0, 0x00, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01,
  0xF0, 0x1F, 0xC0, 0x78, 0x01, 0xF0, 0x1E, 0x00, 0x3C, 0x0F, 0x80, 0x0F,
  0x03, 0xE0, 0x03, 0xC0, 0xF0, 0x00, 0xF0, 0x3C, 0x00, 0x7C, 0x1F, 0x00,
  0x3E, 0x07, 0xC0, 0x1F, 0x01, 0xE0, 0x1F, 0x80, 0x7F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0xF0, 0x07, 0xE0,
  0x3C, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xC1, 0xE0, 0x00,
  0xF0, 0x78, 0x00, 0x3C, 0x3E, 0x00, 0x1F, 0x0F, 0x00, 0x07, 0xC3, 0xC0,
  0x03, 0xE0, 0xF0, 0x01, 0xF8, 0x7C, 0x03, 0xFC, 0x1F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x01,
  0xFC, 0x07, 0x80, 0xFC, 0x00, 0x40, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x80, 0x7F, 0x01, 0xE0, 0x0F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x01,
  0xE0, 0x7F, 0x00, 0x78, 0x07, 0xE0, 0x3E, 0x00, 0xF8, 0x0F, 0x00, 0x1F,
  0x03, 0xC0, 0x07, 0xC0, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x3C, 0x1E, 0x00,
  0x0F, 0x07, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0xF8, 0x00, 0x3C, 0x3C,
  0x00, 0x0F, 0x0F, 0x00, 0x07, 0xC3, 0xC0, 0x01, 0xF1, 0xF0, 0x00, 0x78,
  0x78, 0x00, 0x3E, 0x1E, 0x00, 0x0F, 0x87, 0x80, 0x03, 0xC3, 0xE0, 0x01,
  0xF0, 0xF0, 0x00, 0xF8, 0x3C, 0x00, 0x3E, 0x0F, 0x00, 0x1F, 0x07, 0xC0,
  0x1F, 0xC1, 0xE0, 0x0F, 0xE0, 0x78, 0x1F, 0xF0, 0x1F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xE0, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFF,
  0xE0, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x01, 0xFE, 0x07, 0x80, 0xFC,
  0x00, 0x40, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x0F, 0x87, 0x80, 0x03, 0xE3, 0xE0, 0x00, 0xF0, 0xF8,
  0x00, 0x3C, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC3, 0xE0, 0x01, 0xE0,
  0xF8, 0x00, 0x78, 0x1F, 0x00, 0x3E, 0x07, 0xC0, 0x0F, 0x81, 0xF8, 0x03,
  0xC0, 0x3F, 0x81, 0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x78, 0x07, 0x80,
  0x07, 0xC0, 0x7C, 0x00, 0x3E, 0x03, 0xE0, 0x01, 0xE0, 0x1E, 0x00, 0x0F,
  0x00, 0xF0, 0x00, 0xF8, 0x0F, 0x80, 0x07, 0xC0, 0x7C, 0x00, 0x3C, 0x03,
  0xC0, 0x01, 0xE0, 0x1E, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0xF8, 0x0F, 0x80,
  0x07, 0x80, 0x78, 0x00, 0x3C, 0x03, 0xC0, 0x03, 0xE0, 0x3F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x07,
  0xC0, 0x03, 0xE0, 0x3E, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0xF0, 0x0F, 0x00,
  0x07, 0x80, 0xF8, 0x00, 0x7C, 0x07, 0xC0, 0x03, 0xC0, 0x3C, 0x00, 0x1E,
  0x01, 0xE0, 0x00, 0xF0, 0x0F, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x78, 0x07,
  0x80, 0x03, 0xC0, 0x3C, 0x00, 0x1E, 0x01, 0xE0, 0x01, 0xF0, 0x1F, 0x00,
  0x0F, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00,
  0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x02, 0x00, 0x3E, 0x01, 0xC0, 0x1F, 0x00, 0xFC, 0x1F, 0xC0,
  0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0xF8, 0x03, 0xC0, 0x07, 0xC0, 0x0F, 0x00,
  0x3E, 0x00, 0x3C, 0x01, 0xF0, 0x01, 0xF0, 0x0F, 0x80, 0x07, 0x80, 0x7C,
  0x00, 0x1E, 0x03, 0xE0, 0x00, 0x78, 0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x00,
  0x0F, 0x87, 0xC0, 0x00, 0x3C, 0x7E, 0x00, 0x00, 0xF3, 0xF0, 0x00, 0x07,
  0xDF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xF3, 0xF0,
  0x00, 0x03, 0xC7, 0xC0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x7C, 0x1F, 0x00,
  0x01, 0xE0, 0x7C, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x3E, 0x01, 0xE0, 0x00,
  0xF8, 0x07, 0xC0, 0x03, 0xC0, 0x0F, 0x00, 0x0F, 0x00, 0x3E, 0x00, 0x3C,
  0x00, 0x78, 0x01, 0xF0, 0x01, 0xF0, 0x07, 0x80, 0x07, 0xC0, 0x1E, 0x00,
  0x0F, 0x80, 0x78, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x07,
  0xC0, 0x0F, 0x80, 0x3E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x3F, 0x80,
  0x7F, 0x01, 0xF8, 0x03, 0xB8, 0x1F, 0xC0, 0x1D, 0xC0, 0xEE, 0x01, 0xEE,
  0x0F, 0x70, 0x0F, 0x70, 0xF7, 0x80, 0x73, 0x87, 0x3C, 0x07, 0x9C, 0x79,
  0xE0, 0x3C, 0xF3, 0x8E, 0x01, 0xC7, 0xBC, 0x70, 0x1E, 0x3D, 0xC7, 0x80,
  0xF0, 0xFC, 0x3C, 0x07, 0x87, 0xE1, 0xE0, 0x78, 0x3E, 0x0F, 0x03, 0xC1,
  0xF0, 0xF0, 0x1E, 0x0F, 0x07, 0x80, 0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x01,
  0xE0, 0x78, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0xF0, 0x3E, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x1F, 0x07, 0x80,
  0x00, 0xF0, 0x3C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x3C, 0x1F, 0x00, 0x03,
  0xE0, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x78, 0x07, 0xC0, 0x03,
  0xC0, 0x3E, 0x00, 0x1E, 0x03, 0xF8, 0x01, 0xE0, 0x1F, 0xC0, 0x0F, 0x00,
  0xFE, 0x00, 0x78, 0x07, 0xF8, 0x03, 0xC0, 0x7B, 0xC0, 0x3C, 0x03, 0xDE,
  0x01, 0xE0, 0x1E, 0x70, 0x0F, 0x00, 0xF3, 0xC0, 0x78, 0x0F, 0x1E, 0x07,
  0x80, 0x78, 0xF0, 0x3C, 0x03, 0xC3, 0x81, 0xE0, 0x1E, 0x1E, 0x0F, 0x01,
  0xE0, 0xF0, 0xF0, 0x0F, 0x07, 0x87, 0x80, 0x78, 0x1C, 0x3C, 0x03, 0xC0,
  0xF1, 0xE0, 0x3C, 0x07, 0x9F, 0x01, 0xE0, 0x3C, 0xF0, 0x0F, 0x00, 0xE7,
  0x80, 0x78, 0x07, 0x3C, 0x07, 0xC0, 0x3D, 0xE0, 0x3C, 0x01, 0xFE, 0x01,
  0xE0, 0x0F, 0xF0, 0x0F, 0x00, 0x3F, 0x80, 0xF8, 0x01, 0xFC, 0x07, 0x80,
  0x0F, 0xC0, 0x3C, 0x00, 0x7E, 0x01, 0xE0, 0x03, 0xF0, 0x0F, 0x00, 0x0F,
  0x80, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFE, 0x00,
  0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x1F, 0x83, 0xF0, 0x1F, 0x80, 0xFC,
  0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x07, 0x87, 0x80, 0x03,
  0xC7, 0xC0, 0x01, 0xE3, 0xC0, 0x00, 0xF3, 0xE0, 0x00, 0x79, 0xE0, 0x00,
  0x3C, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0x3C, 0x00,
  0x07, 0x9E, 0x00, 0x07, 0xCF, 0x00, 0x03, 0xEF, 0x80, 0x01, 0xE7, 0xC0,
  0x01, 0xF3, 0xE0, 0x00, 0xF1, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x7C, 0x7C,
  0x00, 0x7C, 0x1E, 0x00, 0x7C, 0x0F, 0x80, 0x7E, 0x07, 0xE0, 0xFE, 0x01,
  0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFE, 0x01, 0xE0, 0x1F, 0x80, 0x78, 0x03, 0xF0, 0x3E, 0x00, 0x7C,
  0x0F, 0x80, 0x0F, 0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x00, 0xF0, 0x7C, 0x00,
  0x3C, 0x1F, 0x00, 0x1F, 0x07, 0x80, 0x07, 0xC1, 0xE0, 0x03, 0xE0, 0xF8,
  0x00, 0xF8, 0x3E, 0x00, 0xFC, 0x0F, 0x00, 0xFE, 0x03, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x1F,
  0xFF, 0xE0, 0x1F, 0x83, 0xF0, 0x1F, 0x80, 0xFC, 0x1F, 0x00, 0x3E, 0x0F,
  0x80, 0x1F, 0x0F, 0x80, 0x07, 0x87, 0x80, 0x03, 0xC7, 0xC0, 0x01, 0xE3,
  0xC0, 0x00, 0xF3, 0xE0, 0x00, 0x79, 0xE0, 0x00, 0x3C, 0xF0, 0x00, 0x3E,
  0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0x3C, 0x00, 0x07, 0x9E, 0x00, 0x07,
  0xCF, 0x00, 0x03, 0xEF, 0x80, 0x01, 0xE7, 0xC0, 0x01, 0xF3, 0xE0, 0x00,
  0xF9, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x1E, 0x00,
  0x7C, 0x0F, 0x80, 0x7E, 0x07, 0xE0, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xC0, 0x1F, 0x01, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x78, 0x00,
  0xF0, 0x0F, 0x00, 0x1E, 0x03, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x78, 0x0F,
  0x00, 0x0F, 0x01, 0xE0, 0x01, 0xE0, 0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x0F,
  0x81, 0xE0, 0x03, 0xE0, 0x3C, 0x00, 0xF8, 0x0F, 0x80, 0xFF, 0x01, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x01, 0xF3, 0xFC, 0x00,
  0x3E, 0x07, 0x80, 0x07, 0x80, 0xF8, 0x00, 0xF0, 0x0F, 0x00, 0x3E, 0x01,
  0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF0, 0x03, 0xE0, 0x1E, 0x00, 0x7C, 0x03,
  0xC0, 0x07, 0x80, 0xF8, 0x00, 0xF0, 0x1E, 0x00, 0x1F, 0x03, 0xC0, 0x03,
  0xE0, 0x78, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFF, 0xE0,
  0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x01, 0xFC, 0x07, 0x80, 0x7C, 0x00,
  0x20, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x80, 0x03, 0xE0,
  0x7C, 0x07, 0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x01, 0xE0,
  0x78, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x03, 0xC0, 0x01, 0xE0, 0x78, 0x00,
  0x3C, 0x0F, 0x00, 0x0F, 0x83, 0xE0, 0x01, 0xE0, 0x78, 0x00, 0x3C, 0x0F,
  0x00, 0x0F, 0x83, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x3C, 0x0F, 0x00, 0x07,
  0x81, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0x81, 0xE0,
  0x00, 0xF0, 0x3C, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x00, 0xF0,
  0x3C, 0x00, 0x1E, 0x07, 0x80, 0x07, 0xC0, 0xF0, 0x00, 0xF8, 0x3E, 0x00,
  0x1E, 0x07, 0xC0, 0x03, 0xC0, 0xF8, 0x00, 0xF8, 0x1F, 0x00, 0x1E, 0x01,
  0xE0, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0x7F, 0xFF,
  0x80, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xEF, 0x80, 0x00, 0xFB, 0xE0, 0x00,
  0x3C, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0x87, 0x80, 0x03, 0xE1, 0xE0,
  0x00, 0xF0, 0x78, 0x00, 0x7C, 0x1E, 0x00, 0x1E, 0x07, 0x80, 0x0F, 0x81,
  0xE0, 0x03, 0xC0, 0x78, 0x01, 0xF0, 0x1E, 0x00, 0x78, 0x07, 0x80, 0x3E,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x1E, 0x03, 0xE0, 0x07, 0xC0,
  0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x1E, 0x00, 0x1F, 0x0F, 0x80, 0x07,
  0xC3, 0xC0, 0x00, 0xF1, 0xF0, 0x00, 0x3C, 0x78, 0x00, 0x0F, 0x3C, 0x00,
  0x03, 0xCF, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x3E, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x3E, 0x0F,
  0x00, 0x01, 0xE0, 0x78, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x78, 0x3E, 0x00,
  0x07, 0xC1, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0xF0, 0x1E, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x3C, 0x0F,
  0x07, 0x81, 0xC0, 0x78, 0x3C, 0x1E, 0x03, 0xC3, 0xE0, 0xF0, 0x1C, 0x3F,
  0x87, 0x81, 0xE1, 0xDC, 0x78, 0x0F, 0x1E, 0xE3, 0xC0, 0x78, 0xE7, 0x1E,
  0x03, 0x8F, 0x38, 0xE0, 0x1C, 0xF1, 0xCF, 0x00, 0xE7, 0x0E, 0x78, 0x0F,
  0x78, 0x73, 0x80, 0x7B, 0x83, 0xBC, 0x03, 0xBC, 0x1D, 0xE0, 0x1D, 0xC0,
  0xEE, 0x00, 0xFE, 0x07, 0xF0, 0x07, 0xE0, 0x3F, 0x00, 0x3E, 0x00, 0xF8,
  0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x03, 0xE0, 0x0F, 0x80, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0xF8, 0x0F,
  0x80, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x0F, 0x87,
  0xC0, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x00, 0xFB,
  0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01,
  0xF7, 0xC0, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x01,
  0xF8, 0x7C, 0x00, 0x01, 0xF8, 0x1E, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00,
  0xF8, 0x07, 0xC0, 0x00, 0xF8, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0xF0, 0x00,
  0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x0F, 0x00,
  0x7C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0xBE, 0x00, 0x03, 0xEF,
  0x80, 0x01, 0xF3, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x3E, 0x1E, 0x00, 0x1F,
  0x07, 0x80, 0x0F, 0x81, 0xF0, 0x03, 0xE0, 0x3C, 0x01, 0xF0, 0x0F, 0x00,
  0xF8, 0x03, 0xC0, 0x3C, 0x00, 0xF8, 0x1F, 0x00, 0x1E, 0x0F, 0x80, 0x07,
  0x83, 0xC0, 0x01, 0xF1, 0xE0, 0x00, 0x3C, 0xF0, 0x00, 0x0F, 0x7C, 0x00,
  0x03, 0xDE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80,
  0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF,
  0xC0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0xF0, 0xF0, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x7C,
  0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x00, 0x1F, 0xFF, 0x00, 0x0F,
  0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0xFF, 0x80,
  0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0,
  0x03, 0xEF, 0x00, 0x0F, 0x1E, 0x00, 0x7C, 0x78, 0x03, 0xE1, 0xE0, 0x1F,
  0x07, 0xC0, 0xF8, 0x0F, 0x03, 0xC0, 0x3C, 0x1F, 0x00, 0xF8, 0xF8, 0x01,
  0xE7, 0xC0, 0x07, 0xBE, 0x00, 0x1F, 0x70, 0x00, 0x3C, 0xC0, 0x00, 0x80,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xE0, 0x10, 0x1C, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3C, 0x0F, 0x03, 0x80,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFE, 0x03, 0xFF,
  0xFE, 0x07, 0xF8, 0x1E, 0x0F, 0xE0, 0x3E, 0x1F, 0x80, 0x3C, 0x1F, 0x00,
  0x3C, 0x3E, 0x00, 0x3C, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x78, 0x00,
  0x78, 0xF8, 0x00, 0x78, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF0, 0x00,
  0xF0, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0xF0, 0x01, 0xF0, 0xF8, 0x01,
  0xF0, 0xF8, 0x01, 0xE0, 0xF8, 0x03, 0xE0, 0x7E, 0x0F, 0xE0, 0x7F, 0xFF,
  0xF0, 0x3F, 0xFE, 0xF0, 0x1F, 0xFC, 0xF0, 0x07, 0xF0, 0xF0, 0x00, 0x38,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE7, 0xE0, 0x03, 0xDF,
  0xF8, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xF0, 0x7E, 0x07, 0xC0,
  0x1F, 0x07, 0x80, 0x1F, 0x07, 0x80, 0x0F, 0x07, 0x80, 0x0F, 0x0F, 0x00,
  0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x1F, 0x00,
  0x1F, 0x1E, 0x00, 0x1F, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x3E, 0x3E, 0x00,
  0x3E, 0x3C, 0x00, 0x7C, 0x3C, 0x00, 0xF8, 0x3C, 0x01, 0xF8, 0x7C, 0x07,
  0xF0, 0x78, 0x1F, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x7F, 0xFE,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xFE, 0x01, 0xFF,
  0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xF8, 0x0C, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x20, 0x7F, 0x00,
  0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xE0, 0xF8, 0x07, 0xE0, 0x1E, 0x01, 0xF8,
  0x03, 0xC0, 0x7E, 0x00, 0xF8, 0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x03, 0xC0,
  0x78, 0x00, 0x78, 0x1F, 0x00, 0x1F, 0x03, 0xE0, 0x03, 0xE0, 0x78, 0x00,
  0x78, 0x0F, 0x00, 0x0F, 0x03, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x0F,
  0x80, 0x0F, 0x01, 0xF0, 0x01, 0xE0, 0x3E, 0x00, 0x3C, 0x03, 0xC0, 0x0F,
  0x80, 0x7C, 0x03, 0xF0, 0x0F, 0xC1, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xF8, 0x01, 0xFF, 0xCF, 0x00, 0x0F, 0xE0, 0xE0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x7F, 0x07,
  0xE1, 0xF8, 0x07, 0xC7, 0xE0, 0x07, 0x9F, 0x80, 0x0F, 0x3E, 0x00, 0x3E,
  0xF8, 0x00, 0x7D, 0xF0, 0x01, 0xF3, 0xC0, 0x07, 0xEF, 0x80, 0xFF, 0x9F,
  0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0x80, 0xFF, 0xF0, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x04, 0x1F, 0xC0, 0x78, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xC0, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0x02,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x41, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x7F,
  0x83, 0xE0, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x03, 0xC0, 0x3F, 0x00, 0x3C,
  0x03, 0xE0, 0x07, 0xC0, 0x7C, 0x00, 0x7C, 0x07, 0xC0, 0x07, 0x80, 0x78,
  0x00, 0x78, 0x0F, 0x80, 0x07, 0x80, 0xF0, 0x00, 0xF8, 0x0F, 0x00, 0x0F,
  0x00, 0xF0, 0x00, 0xF0, 0x0F, 0x00, 0x0F, 0x00, 0xF0, 0x01, 0xF0, 0x0F,
  0x00, 0x1E, 0x00, 0xF8, 0x01, 0xE0, 0x0F, 0xC0, 0xFE, 0x00, 0x7F, 0xFF,
  0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFE, 0x3C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x78, 0x07, 0xE0, 0x07, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xEF, 0xE0, 0x03,
  0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x03, 0xE0, 0x7E, 0x07,
  0xC0, 0x3E, 0x07, 0xC0, 0x1F, 0x07, 0x80, 0x1F, 0x07, 0x80, 0x1F, 0x0F,
  0x80, 0x1F, 0x0F, 0x80, 0x1E, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x1F,
  0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x3E,
  0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3C, 0x00, 0x78, 0x3C, 0x00, 0x78, 0x3C,
  0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x78, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0x78,
  0x00, 0xF0, 0x00, 0x38, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x7F, 0xF0, 0x7F, 0xF0, 0xFF, 0xF0, 0x01, 0xF0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xFF, 0x03, 0xFF, 0x03, 0xFF,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0,
  0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x78, 0x1F, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x07, 0xC0,
  0xF8, 0x07, 0xE0, 0x3C, 0x03, 0xF0, 0x0F, 0x01, 0xF8, 0x07, 0xC0, 0xFC,
  0x01, 0xF0, 0xFC, 0x00, 0x78, 0x7E, 0x00, 0x1E, 0x3F, 0x00, 0x0F, 0xBF,
  0x80, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xFC, 0x00, 0x07, 0xDF, 0x80, 0x01, 0xE3, 0xE0, 0x00, 0x78, 0x7C, 0x00,
  0x3E, 0x0F, 0x80, 0x0F, 0x83, 0xF0, 0x03, 0xC0, 0x7C, 0x00, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x07, 0x80, 0x0F, 0x81, 0xE0,
  0x03, 0xE0, 0x78, 0x00, 0x78, 0x00, 0xFF, 0xF3, 0xFF, 0xCF, 0xFF, 0x3F,
  0xF8, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x7C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00,
  0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80,
  0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xF0, 0x37, 0xFF, 0xCF, 0xFF, 0x3F, 0xFC, 0x3F,
  0xC0, 0x00, 0xFC, 0x1F, 0x01, 0xFF, 0xDF, 0xE0, 0x7F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0x07, 0x87, 0xC7, 0xC3, 0xE1, 0xE0, 0xF0, 0xF0, 0x78, 0x3C,
  0x3C, 0x1E, 0x0F, 0x0F, 0x07, 0x83, 0xC3, 0xC3, 0xE1, 0xE1, 0xE0, 0xF0,
  0x78, 0x78, 0x3C, 0x1E, 0x1E, 0x0F, 0x07, 0x87, 0x87, 0xC3, 0xC3, 0xC1,
  0xE0, 0xF0, 0xF0, 0x78, 0x3C, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xC7,
  0x80, 0x01, 0xE1, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x1E, 0x1E, 0x00, 0x07,
  0x8F, 0x80, 0x03, 0xC3, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x3C, 0x00,
  0x0F, 0x00, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x03,
  0xFF, 0xFE, 0x07, 0xC0, 0x7E, 0x07, 0xC0, 0x3E, 0x07, 0x80, 0x1F, 0x07,
  0x80, 0x1F, 0x07, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1E, 0x0F,
  0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x1E,
  0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3C,
  0x00, 0x78, 0x3C, 0x00, 0x78, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x78,
  0x00, 0xF0, 0x78, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x7F, 0x0F, 0xC1, 0xF8,
  0x07, 0xC7, 0xE0, 0x0F, 0x8F, 0x80, 0x0F, 0x3E, 0x00, 0x1E, 0x7C, 0x00,
  0x3D, 0xF0, 0x00, 0x7B, 0xE0, 0x00, 0xF7, 0xC0, 0x03, 0xEF, 0x00, 0x07,
  0xDE, 0x00, 0x0F, 0xFC, 0x00, 0x1E, 0xF8, 0x00, 0x7D, 0xF0, 0x00, 0xFB,
  0xE0, 0x03, 0xE7, 0xC0, 0x07, 0xC7, 0x80, 0x1F, 0x0F, 0x80, 0x7E, 0x1F,
  0x83, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFE, 0x01, 0xF0, 0x1F, 0x80, 0x78, 0x03, 0xF0, 0x1E, 0x00,
  0x7C, 0x0F, 0x80, 0x0F, 0x03, 0xE0, 0x03, 0xC0, 0xF8, 0x00, 0xF0, 0x3C,
  0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x07, 0xC0, 0x03, 0xC1, 0xF0, 0x01, 0xF0,
  0x78, 0x00, 0x7C, 0x1E, 0x00, 0x1E, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x03,
  0xE0, 0xF0, 0x01, 0xF0, 0x3C, 0x00, 0xFC, 0x1F, 0x00, 0x7E, 0x07, 0xC0,
  0x3F, 0x01, 0xE0, 0x7F, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xF8, 0x1F, 0x07,
  0xE0, 0x1E, 0x0F, 0xC0, 0x1E, 0x1F, 0x80, 0x3E, 0x1F, 0x00, 0x3E, 0x3E,
  0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x78,
  0x00, 0x78, 0x78, 0x00, 0x78, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8,
  0x00, 0xF0, 0xF8, 0x00, 0xF0, 0xF8, 0x01, 0xF0, 0x78, 0x01, 0xF0, 0x7C,
  0x03, 0xE0, 0x7E, 0x0F, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xC0, 0x07, 0xF3, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7E, 0x00, 0x40, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x3F, 0x00, 0xC0, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x04, 0x00, 0x7C, 0x1E,
  0x01, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x7F,
  0xFF, 0xFB, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE0, 0x3C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0xC0, 0x7F, 0xFE, 0x01,
  0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x1F, 0xE0, 0x00, 0x1F, 0x00, 0x3E, 0x3C,
  0x00, 0x78, 0x78, 0x00, 0xF1, 0xF0, 0x01, 0xE3, 0xE0, 0x07, 0xC7, 0x80,
  0x0F, 0x8F, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x7C, 0x00, 0xF8, 0xF8, 0x01,
  0xF1, 0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x3E,
  0x3C, 0x00, 0x78, 0x78, 0x00, 0xF0, 0xF0, 0x03, 0xE1, 0xE0, 0x07, 0xC3,
  0xC0, 0x0F, 0x87, 0x80, 0x1E, 0x0F, 0x80, 0x7C, 0x1F, 0x83, 0xF8, 0x3F,
  0xFF, 0xF8, 0x3F, 0xFE, 0xF0, 0x3F, 0xF9, 0xE0, 0x1F, 0xC3, 0xC0, 0xF8,
  0x00, 0x7F, 0xE0, 0x01, 0xEF, 0x80, 0x0F, 0xBE, 0x00, 0x3E, 0xF8, 0x00,
  0xF3, 0xE0, 0x07, 0xC7, 0x80, 0x1E, 0x1E, 0x00, 0xF8, 0x78, 0x03, 0xC1,
  0xE0, 0x1F, 0x07, 0x80, 0x78, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x01, 0xF0,
  0x78, 0x07, 0xC3, 0xE0, 0x0F, 0x0F, 0x00, 0x3C, 0x7C, 0x00, 0xF1, 0xE0,
  0x03, 0xCF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0x3C, 0xF0, 0x00, 0x0F, 0x1E, 0x00, 0x01, 0xE3, 0xC0, 0x00,
  0x3C, 0x78, 0x00, 0x0F, 0x1E, 0x03, 0x81, 0xE3, 0xC0, 0xF0, 0x3C, 0x78,
  0x3E, 0x0F, 0x0F, 0x07, 0xC1, 0xE1, 0xE1, 0xF8, 0x38, 0x3C, 0x3F, 0x0F,
  0x07, 0x8F, 0xE1, 0xE0, 0xF1, 0xDE, 0x78, 0x1E, 0x7B, 0xCF, 0x03, 0xCE,
  0x79, 0xC0, 0x73, 0x8F, 0x78, 0x0E, 0xF0, 0xEF, 0x03, 0xDC, 0x1F, 0xC0,
  0x7F, 0x83, 0xF8, 0x0F, 0xE0, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x01,
  0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x01,
  0xF0, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x0F, 0x80, 0xF8, 0x00,
  0x78, 0x0F, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x3C, 0x3E, 0x00, 0x03, 0xE7,
  0xC0, 0x00, 0x1E, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x1F, 0x8F, 0x00,
  0x03, 0xF0, 0xF8, 0x00, 0x7E, 0x0F, 0x80, 0x0F, 0xC0, 0x7C, 0x01, 0xF8,
  0x07, 0xC0, 0x3F, 0x00, 0x3C, 0x07, 0xE0, 0x03, 0xE0, 0xFC, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x7C, 0x03, 0xE0, 0x01, 0xE0, 0x07, 0x80, 0x07,
  0x80, 0x1E, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x7C, 0x03, 0xE0, 0x01,
  0xF0, 0x0F, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x3C,
  0x07, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x07, 0x87,
  0xC0, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x78, 0xF8, 0x00, 0x01, 0xF3, 0xC0,
  0x00, 0x03, 0xDE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x01, 0x03, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F,
  0xFE, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x1F,
  0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07,
  0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x04, 0x0F, 0xF0, 0x0F, 0x1F, 0xF8,
  0x1E, 0x3F, 0xFE, 0x3E, 0x7C, 0x7F, 0xFC, 0x78, 0x1F, 0xF8, 0xF0, 0x0F,
  0xF0, 0x20, 0x03, 0xE0,
};

const GFXglyph UbuntuMono_Italic54pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 27, 0, -1 },
  { 1, 13, 33, 27, 9, -33 },
  { 55, 15, 13, 27, 12, -37 },
  { 80, 29, 33, 27, 2, -33 },
  { 200, 25, 42, 27, 4, -37 },
  { 332, 33, 33, 27, 0, -33 },
  { 469, 24, 33, 27, 3, -33 },
  { 568, 7, 14, 27, 16, -37 },
  { 581, 20, 47, 27, 8, -38 },
  { 699, 20, 47, 27, 3, -38 },
  { 817, 21, 20, 27, 7, -33 },
  { 870, 22, 24, 27, 5, -26 },
  { 936, 11, 14, 27, 6, -7 },
  { 956, 13, 4, 27, 9, -16 },
  { 963, 8, 7, 27, 9, -7 },
  { 970, 31, 47, 27, -1, -38 },
  { 1153, 23, 33, 27, 5, -33 },
  { 1248, 20, 33, 27, 5, -33 },
  { 1331, 24, 33, 27, 4, -33 },
  { 1430, 25, 33, 27, 3, -33 },
  { 1534, 25, 33, 27, 3, -33 },
  { 1638, 27, 33, 27, 3, -33 },
  { 1750, 25, 33, 27, 5, -33 },
  { 1854, 25, 33, 27, 7, -33 },
  { 1958, 25, 33, 27, 4, -33 },
  { 2062, 25, 33, 27, 4, -33 },
  { 2166, 12, 24, 27, 9, -24 },
  { 2202, 15, 31, 27, 6, -24 },
  { 2261, 24, 22, 27, 4, -25 },
  { 2327, 25, 14, 27, 3, -21 },
  { 2371, 24, 22, 27, 3, -25 },
  { 2437, 19, 33, 27, 9, -33 },
  { 2516, 26, 41, 27, 4, -34 },
  { 2650, 26, 33, 27, -1, -33 },
  { 2758, 26, 33, 27, 2, -33 },
  { 2866, 26, 33, 27, 5, -33 },
  { 2974, 26, 33, 27, 2, -33 },
  { 3082, 27, 33, 27, 4, -33 },
  { 3194, 27, 33, 27, 4, -33 },
  { 3306, 26, 33, 27, 4, -33 },
  { 3414, 29, 33, 27, 2, -33 },
  { 3534, 25, 33, 27, 4, -33 },
  { 3638, 26, 33, 27, 4, -33 },
  { 3746, 30, 33, 27, 2, -33 },
  { 3870, 20, 33, 27, 3, -33 },
  { 3953, 29, 33, 27, 1, -33 },
  { 4073, 29, 33, 27, 2, -33 },
  { 4193, 25, 33, 27, 4, -33 },
  { 4297, 26, 33, 27, 3, -33 },
  { 4405, 25, 42, 27, 4, -33 },
  { 4537, 27, 33, 27, 2, -33 },
  { 4649, 26, 33, 27, 3, -33 },
  { 4757, 24, 33, 27, 8, -33 },
  { 4856, 27, 33, 27, 4, -33 },
  { 4968, 26, 33, 27, 7, -33 },
  { 5076, 29, 33, 27, 3, -33 },
  { 5196, 33, 33, 27, 0, -33 },
  { 5333, 26, 33, 27, 8, -33 },
  { 5441, 29, 33, 27, 2, -33 },
  { 5561, 25, 47, 27, 5, -38 },
  { 5708, 8, 47, 27, 12, -38 },
  { 5755, 25, 47, 27, 1, -38 },
  { 5902, 22, 18, 27, 6, -33 },
  { 5952, 25, 4, 27, -1, 5 },
  { 5965, 9, 10, 27, 14, -37 },
  { 5977, 24, 27, 27, 4, -26 },
  { 6058, 24, 38, 27, 3, -37 },
  { 6172, 24, 27, 27, 4, -26 },
  { 6253, 27, 38, 27, 4, -37 },
  { 6382, 23, 27, 27, 4, -26 },
  { 6460, 32, 46, 27, 0, -37 },
  { 6644, 28, 35, 27, 1, -26 },
  { 6767, 24, 37, 27, 2, -37 },
  { 6878, 16, 36, 27, 7, -36 },
  { 6950, 26, 45, 27, 1, -36 },
  { 7097, 26, 37, 27, 3, -37 },
  { 7218, 14, 38, 27, 10, -37 },
  { 7285, 26, 26, 27, 2, -26 },
  { 7370, 24, 26, 27, 3, -26 },
  { 7448, 23, 27, 27, 4, -26 },
  { 7526, 26, 35, 27, 1, -26 },
  { 7640, 24, 35, 27, 4, -26 },
  { 7745, 23, 26, 27, 5, -26 },
  { 7820, 23, 27, 27, 4, -26 },
  { 7898, 21, 34, 27, 7, -33 },
  { 7988, 23, 26, 27, 5, -25 },
  { 8063, 22, 25, 27, 7, -25 },
  { 8132, 27, 25, 27, 4, -25 },
  { 8217, 28, 25, 27, 1, -25 },
  { 8305, 30, 34, 27, -1, -25 },
  { 8433, 24, 25, 27, 3, -25 },
  { 8508, 26, 47, 27, 5, -38 },
  { 8661, 16, 47, 27, 8, -38 },
  { 8755, 26, 47, 27, 0, -38 },
  { 8908, 24, 8, 27, 4, -18 },
};

const GFXfont UbuntuMono_Italic54pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Italic54pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Italic54pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _UBUNTUMONO_ITALIC54PT7B_H_
