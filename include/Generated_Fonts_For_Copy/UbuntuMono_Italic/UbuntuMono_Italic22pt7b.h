#ifndef _UBUNTUMONO_ITALIC22PT7B_H_
#define _UBUNTUMONO_ITALIC22PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Italic.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Italic22pt7bBitmaps[] PROGMEM = {
  0x00, 0x18, 0xC6, 0x63, 0x18, 0x84, 0x60, 0x01, 0x8E, 0x60, 0x4F, 0x3C,
  0xA2, 0x88, 0x02, 0x20, 0x66, 0x04, 0x60, 0xC4, 0x7F, 0xE7, 0xFE, 0x19,
  0x81, 0x18, 0x33, 0x0F, 0xFC, 0xFF, 0xC6, 0x60, 0x44, 0x0C, 0xC0, 0x03,
  0x00, 0x80, 0xF8, 0x7F, 0x30, 0x0C, 0x03, 0x00, 0xF8, 0x0F, 0x00, 0xC0,
  0x32, 0x0C, 0xFF, 0x1F, 0x01, 0x00, 0xC0, 0x30, 0x00, 0x0E, 0x18, 0xF1,
  0x8C, 0x88, 0x64, 0x83, 0x6C, 0x1E, 0xC0, 0x7C, 0x00, 0xDC, 0x05, 0xE0,
  0x49, 0x06, 0xC8, 0x66, 0xC6, 0x3C, 0x20, 0xE0, 0x07, 0x07, 0xE1, 0x98,
  0x66, 0x1B, 0x07, 0x81, 0xCC, 0xB2, 0x67, 0xB0, 0xEC, 0x33, 0x1C, 0x7D,
  0x9E, 0x60, 0xDB, 0x69, 0x00, 0x01, 0x01, 0x81, 0x81, 0x81, 0x81, 0x80,
  0x80, 0xC0, 0x60, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x01, 0x00, 0xC0, 0x60,
  0x18, 0x04, 0x00, 0x04, 0x03, 0x01, 0x80, 0x60, 0x30, 0x08, 0x06, 0x03,
  0x01, 0x00, 0x80, 0xC0, 0x60, 0x60, 0x30, 0x30, 0x30, 0x30, 0x70, 0x10,
  0x00, 0x18, 0x0C, 0x32, 0x5F, 0xE1, 0xC1, 0xA1, 0xD8, 0x44, 0x04, 0x06,
  0x03, 0x01, 0x8F, 0xFF, 0xFC, 0x60, 0x30, 0x18, 0x08, 0x00, 0x39, 0xCE,
  0x33, 0x60, 0xFF, 0xC0, 0xFF, 0x80, 0x00, 0x30, 0x06, 0x00, 0x60, 0x0C,
  0x00, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x02, 0x00, 0x60, 0x0C, 0x00, 0xC0,
  0x18, 0x01, 0x80, 0x30, 0x02, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x00, 0x0F,
  0x07, 0xE3, 0x99, 0xC3, 0x60, 0xDB, 0x2D, 0xDB, 0x36, 0xC1, 0xB0, 0xCC,
  0x33, 0x18, 0xFC, 0x1E, 0x00, 0x03, 0x07, 0x1E, 0x3E, 0x26, 0x06, 0x04,
  0x0C, 0x0C, 0x0C, 0x0C, 0x18, 0xFF, 0xFE, 0x0F, 0x0F, 0xE3, 0x18, 0x03,
  0x01, 0x80, 0x60, 0x30, 0x38, 0x1C, 0x0E, 0x06, 0x03, 0x00, 0xFF, 0x3F,
  0xC0, 0x07, 0x87, 0xF0, 0x8C, 0x03, 0x00, 0xC0, 0x70, 0xF0, 0x3C, 0x01,
  0x80, 0x20, 0x19, 0x0E, 0xFF, 0x1F, 0x80, 0x00, 0xC0, 0x70, 0x3C, 0x1A,
  0x0D, 0x86, 0x63, 0x19, 0x86, 0x61, 0x3F, 0xFF, 0xF8, 0x0C, 0x02, 0x01,
  0x80, 0x07, 0xE1, 0xFC, 0x30, 0x04, 0x01, 0x80, 0x3C, 0x07, 0xC0, 0x1C,
  0x01, 0x80, 0x30, 0x06, 0x21, 0xCF, 0xF0, 0xF8, 0x00, 0x01, 0xC1, 0xF1,
  0xE0, 0xE0, 0x20, 0x1F, 0x87, 0xF3, 0x06, 0xC1, 0xB0, 0x6C, 0x1B, 0x0C,
  0x7E, 0x0F, 0x00, 0x7F, 0xDF, 0xF0, 0x18, 0x0C, 0x06, 0x01, 0x80, 0xC0,
  0x60, 0x10, 0x0C, 0x06, 0x01, 0x80, 0x60, 0x30, 0x00, 0x0F, 0x07, 0xF3,
  0x0C, 0xC3, 0x20, 0x8C, 0x63, 0xE0, 0xFC, 0x63, 0x30, 0x6C, 0x13, 0x0C,
  0xFE, 0x1F, 0x00, 0x0F, 0x0F, 0xE3, 0x1D, 0x83, 0x60, 0xD8, 0x36, 0x0D,
  0xFE, 0x3F, 0x80, 0xC0, 0x70, 0x38, 0xFC, 0x38, 0x00, 0x31, 0xCC, 0x00,
  0x00, 0x1C, 0xE7, 0x00, 0x0C, 0x1C, 0x30, 0x00, 0x00, 0x00, 0x1C, 0x38,
  0x70, 0x61, 0x8C, 0x00, 0x00, 0x83, 0xC7, 0xDF, 0x0C, 0x07, 0x80, 0xE0,
  0x1C, 0x03, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x3F,
  0xE0, 0x30, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xC1, 0xE3, 0xE3, 0xC0, 0xC0,
  0x00, 0x3C, 0xFD, 0x18, 0x10, 0x61, 0x86, 0x10, 0x60, 0x00, 0x06, 0x0C,
  0x18, 0x00, 0x07, 0x87, 0xF3, 0x8D, 0xC1, 0x60, 0x51, 0xFC, 0xFF, 0x73,
  0x98, 0xA6, 0x69, 0x9A, 0x7E, 0x8F, 0x30, 0x0E, 0x01, 0xF0, 0x3C, 0x00,
  0x01, 0x80, 0xF0, 0x2C, 0x1B, 0x04, 0xC3, 0x30, 0x8C, 0x63, 0x30, 0xCF,
  0xF7, 0xFD, 0x83, 0xC0, 0xF0, 0x30, 0x1F, 0x83, 0xF8, 0x63, 0x18, 0x23,
  0x0C, 0x61, 0x8F, 0xE3, 0xFC, 0x61, 0xCC, 0x19, 0x03, 0x21, 0xCF, 0xF1,
  0xFC, 0x00, 0x07, 0xC3, 0xF8, 0xE1, 0x18, 0x06, 0x00, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x70, 0x87, 0xF0, 0x7C, 0x00, 0x1F, 0x03,
  0xF0, 0xC3, 0x18, 0x63, 0x04, 0x60, 0x98, 0x13, 0x06, 0x60, 0xCC, 0x19,
  0x06, 0x63, 0x8F, 0xE1, 0xF8, 0x00, 0x1F, 0xC7, 0xF3, 0x00, 0xC0, 0x30,
  0x08, 0x07, 0xF1, 0xFC, 0x60, 0x10, 0x0C, 0x03, 0x00, 0xFF, 0x3F, 0xC0,
  0x1F, 0xC3, 0xF8, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x1F, 0xC3, 0xF8, 0x60,
  0x0C, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x00, 0x07, 0x87, 0xF3, 0x85,
  0xC0, 0x60, 0x30, 0x0C, 0x03, 0x06, 0xC1, 0xB0, 0x4C, 0x33, 0x8C, 0x7F,
  0x0F, 0x80, 0x18, 0x31, 0x82, 0x30, 0x63, 0x06, 0x30, 0x63, 0x04, 0x3F,
  0xC7, 0xFC, 0x60, 0xC6, 0x08, 0x41, 0x8C, 0x18, 0xC1, 0x8C, 0x18, 0x1F,
  0xC7, 0xF0, 0x60, 0x18, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x18, 0x06, 0x01,
  0x80, 0x40, 0xFE, 0x3F, 0x80, 0x07, 0xE1, 0xFC, 0x01, 0x80, 0x20, 0x0C,
  0x01, 0x80, 0x30, 0x04, 0x01, 0x80, 0x30, 0x06, 0x21, 0x87, 0xF0, 0x78,
  0x00, 0x18, 0x61, 0x8C, 0x11, 0x83, 0x30, 0x36, 0x03, 0xC0, 0x38, 0x02,
  0xC0, 0x66, 0x06, 0x60, 0x63, 0x04, 0x30, 0xC1, 0x8C, 0x18, 0x18, 0x18,
  0x18, 0x10, 0x30, 0x30, 0x30, 0x20, 0x60, 0x60, 0x60, 0x40, 0x7F, 0xFF,
  0x0C, 0x30, 0xC3, 0x0E, 0x71, 0xE7, 0x1E, 0xF1, 0x6B, 0x17, 0xA3, 0x32,
  0x32, 0x62, 0x06, 0x60, 0x66, 0x04, 0x40, 0x44, 0x0C, 0x18, 0x31, 0x82,
  0x1C, 0x23, 0xC6, 0x34, 0x62, 0x44, 0x26, 0x46, 0x6C, 0x62, 0xC6, 0x2C,
  0x42, 0x8C, 0x38, 0xC3, 0x8C, 0x18, 0x0F, 0x07, 0xE3, 0x1D, 0x83, 0x60,
  0xF0, 0x3C, 0x0F, 0x02, 0xC1, 0xB0, 0x6C, 0x33, 0x1C, 0xFE, 0x1F, 0x00,
  0x1F, 0x83, 0xF8, 0x63, 0x8C, 0x33, 0x06, 0x60, 0xCC, 0x31, 0xFC, 0x7F,
  0x0C, 0x01, 0x80, 0x30, 0x04, 0x01, 0x80, 0x00, 0x0F, 0x07, 0xE3, 0x1D,
  0x83, 0x60, 0xD0, 0x3C, 0x0F, 0x02, 0xC1, 0xB0, 0x6C, 0x33, 0x1C, 0xFE,
  0x1F, 0x03, 0x00, 0xE0, 0x1E, 0x01, 0x00, 0x1F, 0x83, 0xF8, 0x63, 0x18,
  0x33, 0x06, 0x61, 0x8C, 0x71, 0xFC, 0x7E, 0x0C, 0x41, 0x8C, 0x21, 0x8C,
  0x19, 0x83, 0x00, 0x07, 0xC1, 0xFC, 0x61, 0x0C, 0x01, 0x80, 0x38, 0x03,
  0x80, 0x3C, 0x01, 0x80, 0x30, 0x06, 0x20, 0xCF, 0xF0, 0xFC, 0x00, 0x7F,
  0xFF, 0xF0, 0xC0, 0x20, 0x18, 0x06, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x20, 0x18, 0x00, 0x30, 0x64, 0x19, 0x83, 0x30, 0x66, 0x0C,
  0x83, 0x30, 0x66, 0x0C, 0xC1, 0x98, 0x63, 0x0C, 0x63, 0x8F, 0xE0, 0xF8,
  0x00, 0xC0, 0xF0, 0x3C, 0x1B, 0x06, 0xC3, 0x30, 0xCC, 0x63, 0x18, 0xCC,
  0x33, 0x05, 0x81, 0x60, 0x70, 0x18, 0x00, 0x30, 0x33, 0x03, 0x30, 0x33,
  0x02, 0x20, 0x62, 0x66, 0x66, 0x46, 0xA4, 0x6A, 0xC5, 0x28, 0x72, 0x86,
  0x38, 0xE3, 0x0C, 0x30, 0x0C, 0x18, 0x61, 0x81, 0x8C, 0x0C, 0xC0, 0x6C,
  0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x07, 0x80, 0x6C, 0x06, 0x20, 0x61, 0x87,
  0x0C, 0x30, 0x60, 0xC0, 0xD8, 0x19, 0x06, 0x30, 0x86, 0x30, 0xCC, 0x0B,
  0x01, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x00, 0xC0, 0x00, 0x1F,
  0xE1, 0xFE, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x06, 0x00, 0xFF, 0x8F, 0xF8, 0x07, 0xC3, 0xF0, 0xC0,
  0x30, 0x08, 0x06, 0x01, 0x80, 0x60, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x20,
  0x18, 0x06, 0x01, 0x80, 0x40, 0x1F, 0x0F, 0xC0, 0xDB, 0x6D, 0xB6, 0xC9,
  0x36, 0xDB, 0x6D, 0x80, 0x0F, 0x87, 0xC0, 0x60, 0x30, 0x10, 0x18, 0x0C,
  0x06, 0x02, 0x03, 0x01, 0x80, 0xC0, 0x40, 0x60, 0x30, 0x18, 0x08, 0x7C,
  0x3E, 0x00, 0x06, 0x07, 0x83, 0xC3, 0x23, 0x1B, 0x0D, 0x02, 0x7F, 0xFF,
  0xF8, 0x8C, 0x62, 0x0F, 0x9F, 0xDC, 0x7C, 0x2C, 0x34, 0x1A, 0x0D, 0x8E,
  0xFF, 0x3D, 0x80, 0x0C, 0x02, 0x01, 0x80, 0x60, 0x18, 0x05, 0xE3, 0xFC,
  0xC3, 0x30, 0xC8, 0x36, 0x0D, 0x86, 0x63, 0x9F, 0xC7, 0xC0, 0x0F, 0x9F,
  0xDC, 0x18, 0x0C, 0x04, 0x02, 0x01, 0x82, 0xFF, 0x1F, 0x00, 0x00, 0x60,
  0x08, 0x03, 0x00, 0x60, 0x0C, 0x1F, 0x8F, 0xF3, 0x8C, 0xE1, 0x98, 0x33,
  0x0E, 0x61, 0xCC, 0x71, 0xFE, 0x1E, 0xC0, 0x1F, 0x1F, 0xD8, 0x78, 0x3F,
  0xF7, 0xE2, 0x01, 0x82, 0xFF, 0x3F, 0x00, 0x00, 0x78, 0x0F, 0xC0, 0x60,
  0x06, 0x00, 0x30, 0x07, 0xF8, 0x3F, 0xC0, 0x40, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x18, 0x07, 0xC0,
  0x3C, 0x00, 0x03, 0xF0, 0xFE, 0x1C, 0x61, 0x86, 0x30, 0x63, 0x04, 0x30,
  0xC3, 0x0C, 0x3F, 0xC1, 0xFC, 0x01, 0x84, 0x38, 0x7F, 0x07, 0xE0, 0x08,
  0x0C, 0x06, 0x03, 0x01, 0x01, 0xF8, 0xFE, 0x63, 0x30, 0xB0, 0x58, 0x6C,
  0x34, 0x1E, 0x1B, 0x0C, 0x1C, 0x71, 0x80, 0x03, 0xEF, 0x84, 0x30, 0xC3,
  0x08, 0x30, 0xF1, 0xC0, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x00, 0x00, 0x1F,
  0x83, 0xF0, 0x06, 0x00, 0xC0, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x00,
  0xC0, 0x18, 0x47, 0x0F, 0xC1, 0xF0, 0x00, 0x0C, 0x01, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x21, 0x8C, 0x61, 0x98, 0x3E, 0x07, 0x01, 0xB0, 0x33, 0x06,
  0x30, 0xC6, 0x10, 0x60, 0xFB, 0xE1, 0x0C, 0x30, 0xC2, 0x18, 0x61, 0x84,
  0x30, 0xC5, 0xF7, 0x80, 0x3D, 0xC7, 0xF8, 0x99, 0x33, 0x26, 0x4C, 0xD9,
  0x90, 0x36, 0x04, 0xC1, 0x90, 0x30, 0x1F, 0x87, 0xE3, 0x0C, 0xC3, 0x30,
  0xC8, 0x36, 0x09, 0x86, 0x61, 0x90, 0x40, 0x1F, 0x1F, 0xDC, 0x7C, 0x3C,
  0x1E, 0x0F, 0x0D, 0x8E, 0xFE, 0x3E, 0x00, 0x0F, 0xC3, 0xFC, 0x61, 0x8C,
  0x31, 0x06, 0x60, 0xCC, 0x31, 0x8E, 0x3F, 0x8F, 0xC1, 0x80, 0x30, 0x06,
  0x00, 0x80, 0x00, 0x0F, 0xCF, 0xE7, 0x1B, 0x86, 0xC1, 0xB0, 0xCC, 0x33,
  0x1C, 0xFF, 0x1F, 0x80, 0x60, 0x18, 0x06, 0x01, 0x00, 0x1F, 0x9F, 0xCC,
  0x04, 0x06, 0x03, 0x01, 0x80, 0x80, 0xC0, 0x60, 0x00, 0x1F, 0x9F, 0xCC,
  0x26, 0x03, 0xC0, 0xF0, 0x0D, 0x06, 0xFE, 0x3E, 0x00, 0x18, 0x18, 0x18,
  0xFF, 0xFF, 0x30, 0x20, 0x60, 0x60, 0x60, 0x62, 0x7E, 0x3C, 0x61, 0xB0,
  0xD0, 0x78, 0x2C, 0x36, 0x1B, 0x0D, 0x8E, 0xFF, 0x3D, 0x80, 0xC1, 0xE1,
  0xB0, 0xD8, 0xCC, 0x66, 0x61, 0x20, 0xF0, 0x70, 0x30, 0x00, 0xC0, 0x78,
  0x0B, 0x33, 0x66, 0x4D, 0xD9, 0xAB, 0x29, 0x47, 0x38, 0xC6, 0x18, 0xC0,
  0x18, 0x60, 0xC4, 0x0C, 0xC0, 0x78, 0x07, 0x00, 0x70, 0x0D, 0x01, 0x98,
  0x31, 0x86, 0x0C, 0x18, 0x31, 0x86, 0x18, 0x61, 0x84, 0x08, 0xC0, 0xCC,
  0x0D, 0x80, 0xD0, 0x0F, 0x00, 0x60, 0x06, 0x00, 0xC0, 0xF8, 0x0F, 0x00,
  0x1F, 0xC7, 0xF0, 0x18, 0x0C, 0x0E, 0x06, 0x03, 0x01, 0x80, 0x7F, 0x3F,
  0xC0, 0x03, 0xC0, 0xF8, 0x18, 0x06, 0x00, 0xC0, 0x10, 0x06, 0x00, 0xC0,
  0x30, 0x1C, 0x03, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x18, 0x03, 0x00, 0x60,
  0x0F, 0x80, 0xF0, 0x00, 0x06, 0x08, 0x30, 0x60, 0xC1, 0x06, 0x0C, 0x18,
  0x20, 0xC1, 0x83, 0x04, 0x18, 0x30, 0x60, 0x83, 0x00, 0x0F, 0x81, 0xF0,
  0x02, 0x00, 0x40, 0x18, 0x03, 0x00, 0x40, 0x08, 0x01, 0x80, 0x3C, 0x0F,
  0x01, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x0C, 0x1F, 0x03, 0xC0, 0x00,
  0x70, 0xBC, 0xF3, 0xF0, 0xE0,
};

const GFXglyph UbuntuMono_Italic22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 5, 14, 11, 4, -14 },
  { 10, 6, 5, 11, 5, -14 },
  { 14, 12, 14, 11, 1, -14 },
  { 35, 10, 17, 11, 2, -15 },
  { 57, 13, 14, 11, 0, -14 },
  { 80, 10, 14, 11, 1, -14 },
  { 98, 3, 6, 11, 7, -15 },
  { 101, 9, 19, 11, 3, -15 },
  { 123, 9, 19, 11, 1, -15 },
  { 145, 9, 8, 11, 3, -14 },
  { 154, 9, 10, 11, 2, -11 },
  { 166, 5, 6, 11, 2, -3 },
  { 170, 5, 2, 11, 4, -7 },
  { 172, 3, 3, 11, 4, -3 },
  { 174, 12, 19, 11, 0, -15 },
  { 203, 10, 14, 11, 2, -14 },
  { 221, 8, 14, 11, 2, -14 },
  { 235, 10, 14, 11, 2, -14 },
  { 253, 10, 14, 11, 1, -14 },
  { 271, 10, 14, 11, 1, -14 },
  { 289, 11, 14, 11, 1, -14 },
  { 309, 10, 14, 11, 2, -14 },
  { 327, 10, 14, 11, 3, -14 },
  { 345, 10, 14, 11, 2, -14 },
  { 363, 10, 14, 11, 2, -14 },
  { 381, 5, 10, 11, 4, -10 },
  { 388, 7, 13, 11, 2, -10 },
  { 400, 9, 9, 11, 2, -10 },
  { 411, 11, 7, 11, 1, -9 },
  { 421, 10, 9, 11, 1, -11 },
  { 433, 7, 14, 11, 4, -14 },
  { 446, 10, 17, 11, 2, -14 },
  { 468, 10, 14, 11, 0, -14 },
  { 486, 11, 14, 11, 1, -14 },
  { 506, 11, 14, 11, 2, -14 },
  { 526, 11, 14, 11, 1, -14 },
  { 546, 10, 14, 11, 2, -14 },
  { 564, 11, 14, 11, 2, -14 },
  { 584, 10, 14, 11, 2, -14 },
  { 602, 12, 14, 11, 1, -14 },
  { 623, 10, 14, 11, 2, -14 },
  { 641, 11, 14, 11, 1, -14 },
  { 661, 12, 14, 11, 1, -14 },
  { 682, 8, 14, 11, 1, -14 },
  { 696, 12, 14, 11, 0, -14 },
  { 717, 12, 14, 11, 1, -14 },
  { 738, 10, 14, 11, 2, -14 },
  { 756, 11, 14, 11, 1, -14 },
  { 776, 10, 18, 11, 2, -14 },
  { 799, 11, 14, 11, 1, -14 },
  { 819, 11, 14, 11, 1, -14 },
  { 839, 10, 14, 11, 3, -14 },
  { 857, 11, 14, 11, 2, -14 },
  { 877, 10, 14, 11, 3, -14 },
  { 895, 12, 14, 11, 1, -14 },
  { 916, 13, 14, 11, 0, -14 },
  { 939, 11, 14, 11, 3, -14 },
  { 959, 12, 14, 11, 1, -14 },
  { 980, 10, 19, 11, 2, -15 },
  { 1004, 3, 19, 11, 5, -15 },
  { 1012, 9, 19, 11, 1, -15 },
  { 1034, 9, 7, 11, 2, -14 },
  { 1042, 11, 2, 11, -1, 2 },
  { 1045, 4, 4, 11, 6, -15 },
  { 1047, 9, 10, 11, 2, -10 },
  { 1059, 10, 15, 11, 1, -15 },
  { 1078, 9, 10, 11, 2, -10 },
  { 1090, 11, 15, 11, 2, -15 },
  { 1111, 9, 10, 11, 2, -10 },
  { 1123, 13, 19, 11, 0, -15 },
  { 1154, 12, 14, 11, 0, -10 },
  { 1175, 9, 15, 11, 1, -15 },
  { 1192, 6, 15, 11, 3, -15 },
  { 1204, 11, 19, 11, 0, -15 },
  { 1231, 11, 15, 11, 1, -15 },
  { 1252, 6, 15, 11, 4, -15 },
  { 1264, 11, 10, 11, 1, -10 },
  { 1278, 10, 10, 11, 1, -10 },
  { 1291, 9, 10, 11, 2, -10 },
  { 1303, 11, 14, 11, 0, -10 },
  { 1323, 10, 14, 11, 2, -10 },
  { 1341, 9, 10, 11, 2, -10 },
  { 1353, 9, 10, 11, 2, -10 },
  { 1365, 8, 13, 11, 3, -13 },
  { 1378, 9, 10, 11, 2, -10 },
  { 1390, 9, 10, 11, 3, -10 },
  { 1402, 11, 10, 11, 2, -10 },
  { 1416, 12, 10, 11, 0, -10 },
  { 1431, 12, 14, 11, 0, -10 },
  { 1452, 10, 10, 11, 1, -10 },
  { 1465, 11, 19, 11, 2, -15 },
  { 1492, 7, 19, 11, 3, -15 },
  { 1509, 11, 19, 11, 0, -15 },
  { 1536, 9, 4, 11, 2, -10 },
};

const GFXfont UbuntuMono_Italic22pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Italic22pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Italic22pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _UBUNTUMONO_ITALIC22PT7B_H_
