#ifndef _UBUNTUMONO_ITALIC6PT7B_H_
#define _UBUNTUMONO_ITALIC6PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Italic.ttf
// Size: 6pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Italic6pt7bBitmaps[] PROGMEM = {
  0x00, 0x70, 0xC0, 0x0D, 0x40, 0x28, 0xB4, 0x46, 0x6E, 0x6E, 0xF0, 0x80,
  0x6A, 0x80, 0x24, 0xA8, 0x20, 0x38, 0xC0, 0x80, 0x80, 0x25, 0x48, 0x6E,
  0xF0, 0x5A, 0x65, 0x60, 0x64, 0xB0, 0x2F, 0x80, 0x28, 0xB0, 0x6F, 0xCA,
  0x40, 0x6D, 0xF0, 0x6D, 0xA0, 0x20, 0x30, 0x18, 0x80, 0xC0, 0x47, 0x00,
  0xDA, 0x2F, 0xD4, 0x2F, 0xD0, 0x6E, 0xF0, 0x6B, 0x6E, 0xF0, 0x69, 0x60,
  0x69, 0x00, 0x72, 0xF0, 0x4E, 0xD0, 0x69, 0x20, 0x24, 0xB0, 0x46, 0x4A,
  0x4A, 0x60, 0x4E, 0xD0, 0x4E, 0xD0, 0x76, 0xF0, 0x6D, 0x40, 0x76, 0xD4,
  0x6D, 0x50, 0x68, 0xF0, 0xD2, 0x40, 0x4E, 0xF0, 0x3B, 0x40, 0x19, 0x6A,
  0x42, 0x4A, 0x3A, 0x40, 0x65, 0x60, 0x2A, 0x00, 0xF0, 0x25, 0x24, 0x70,
  0xC0, 0x00, 0x77, 0x80, 0x4E, 0xF0, 0x73, 0x80, 0x0E, 0xF0, 0x77, 0x80,
  0x26, 0x44, 0x40, 0x75, 0xE0, 0x4E, 0xD0, 0x2A, 0x2C, 0x9C, 0x4D, 0x50,
  0x2A, 0x76, 0x80, 0x76, 0x80, 0x77, 0x80, 0x77, 0xC0, 0x77, 0x80, 0xE0,
  0x69, 0x80, 0x3A, 0x17, 0x80, 0x38, 0x0E, 0x80, 0x6A, 0x80, 0x0D, 0x20,
  0x6B, 0x00, 0x2A, 0x00, 0x2A, 0x80, 0x24, 0xA4, 0x60,
};

const GFXglyph UbuntuMono_Italic6pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 1, 4, 3, 1, -4 },
  { 2, 2, 1, 3, 1, -4 },
  { 3, 3, 4, 3, 0, -4 },
  { 5, 3, 5, 3, 0, -4 },
  { 7, 4, 4, 3, 0, -4 },
  { 9, 3, 4, 3, 0, -4 },
  { 11, 1, 2, 3, 2, -4 },
  { 12, 2, 5, 3, 1, -4 },
  { 14, 3, 5, 3, 0, -4 },
  { 16, 2, 3, 3, 1, -4 },
  { 17, 2, 3, 3, 1, -3 },
  { 18, 1, 2, 3, 1, -1 },
  { 19, 1, 1, 3, 1, -2 },
  { 20, 1, 1, 3, 1, -1 },
  { 21, 3, 5, 3, 0, -4 },
  { 23, 3, 4, 3, 0, -4 },
  { 25, 2, 4, 3, 1, -4 },
  { 26, 3, 4, 3, 0, -4 },
  { 28, 3, 4, 3, 0, -4 },
  { 30, 3, 4, 3, 0, -4 },
  { 32, 3, 4, 3, 0, -4 },
  { 34, 2, 4, 3, 1, -4 },
  { 35, 3, 4, 3, 1, -4 },
  { 37, 3, 4, 3, 0, -4 },
  { 39, 3, 4, 3, 0, -4 },
  { 41, 1, 3, 3, 1, -3 },
  { 42, 1, 4, 3, 1, -3 },
  { 43, 3, 3, 3, 0, -3 },
  { 45, 3, 1, 3, 0, -2 },
  { 46, 3, 3, 3, 0, -3 },
  { 48, 2, 4, 3, 1, -4 },
  { 49, 3, 5, 3, 0, -4 },
  { 51, 3, 4, 3, 0, -4 },
  { 53, 3, 4, 3, 0, -4 },
  { 55, 2, 4, 3, 1, -4 },
  { 56, 3, 4, 3, 0, -4 },
  { 58, 3, 4, 3, 0, -4 },
  { 60, 3, 4, 3, 0, -4 },
  { 62, 3, 4, 3, 0, -4 },
  { 64, 3, 4, 3, 0, -4 },
  { 66, 3, 4, 3, 0, -4 },
  { 68, 3, 4, 3, 0, -4 },
  { 70, 4, 4, 3, 0, -4 },
  { 72, 3, 4, 3, 0, -4 },
  { 74, 3, 4, 3, 0, -4 },
  { 76, 3, 4, 3, 0, -4 },
  { 78, 3, 4, 3, 0, -4 },
  { 80, 3, 4, 3, 0, -4 },
  { 82, 3, 5, 3, 0, -4 },
  { 84, 3, 4, 3, 0, -4 },
  { 86, 3, 4, 3, 0, -4 },
  { 88, 3, 4, 3, 1, -4 },
  { 90, 3, 4, 3, 0, -4 },
  { 92, 3, 4, 3, 1, -4 },
  { 94, 4, 4, 3, 0, -4 },
  { 96, 4, 4, 3, 0, -4 },
  { 98, 3, 4, 3, 1, -4 },
  { 100, 3, 4, 3, 0, -4 },
  { 102, 2, 5, 3, 1, -4 },
  { 104, 1, 5, 3, 1, -4 },
  { 105, 3, 5, 3, 0, -4 },
  { 107, 2, 2, 3, 1, -4 },
  { 108, 3, 1, 3, 0, 0 },
  { 109, 1, 1, 3, 2, -4 },
  { 110, 3, 3, 3, 0, -3 },
  { 112, 3, 4, 3, 0, -4 },
  { 114, 3, 3, 3, 0, -3 },
  { 116, 3, 4, 3, 0, -4 },
  { 118, 3, 3, 3, 0, -3 },
  { 120, 4, 5, 3, 0, -4 },
  { 123, 3, 4, 3, 0, -3 },
  { 125, 3, 4, 3, 0, -4 },
  { 127, 2, 4, 3, 1, -4 },
  { 128, 3, 5, 3, 0, -4 },
  { 130, 3, 4, 3, 0, -4 },
  { 132, 2, 4, 3, 1, -4 },
  { 133, 3, 3, 3, 0, -3 },
  { 135, 3, 3, 3, 0, -3 },
  { 137, 3, 3, 3, 0, -3 },
  { 139, 3, 4, 3, 0, -3 },
  { 141, 3, 4, 3, 0, -3 },
  { 143, 2, 3, 3, 1, -3 },
  { 144, 3, 3, 3, 0, -3 },
  { 146, 2, 4, 3, 1, -4 },
  { 147, 3, 3, 3, 0, -3 },
  { 149, 2, 3, 3, 1, -3 },
  { 150, 3, 3, 3, 0, -3 },
  { 152, 3, 3, 3, 0, -3 },
  { 154, 3, 4, 3, 0, -3 },
  { 156, 3, 3, 3, 0, -3 },
  { 158, 2, 5, 3, 1, -4 },
  { 160, 2, 5, 3, 1, -4 },
  { 162, 3, 5, 3, 0, -4 },
  { 164, 3, 1, 3, 0, -2 },
};

const GFXfont UbuntuMono_Italic6pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Italic6pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Italic6pt7bGlyphs,
  0x20, 0x7E, 6
};

#endif // _UBUNTUMONO_ITALIC6PT7B_H_
