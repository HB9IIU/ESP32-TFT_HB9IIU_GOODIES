#ifndef _UBUNTUMONO_ITALIC37PT7B_H_
#define _UBUNTUMONO_ITALIC37PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Italic.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Italic37pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0x81, 0xC1, 0xE0, 0xE0, 0x70, 0x38, 0x3C, 0x1E, 0x0E, 0x07,
  0x03, 0x83, 0x81, 0xC0, 0xE0, 0x60, 0x00, 0x00, 0x00, 0x1E, 0x0F, 0x0F,
  0x87, 0xC1, 0xC0, 0x30, 0xEE, 0x39, 0xC7, 0x38, 0xE6, 0x18, 0xC3, 0x38,
  0x66, 0x18, 0xC3, 0x00, 0x00, 0x38, 0x70, 0x03, 0x86, 0x00, 0x70, 0xE0,
  0x07, 0x0E, 0x00, 0xE1, 0xC0, 0x0E, 0x1C, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF,
  0x1F, 0xFF, 0xE0, 0x38, 0x70, 0x03, 0x87, 0x00, 0x70, 0xE0, 0x07, 0x0E,
  0x00, 0xE1, 0xC0, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0xFF, 0x81, 0xC3,
  0x80, 0x38, 0x70, 0x03, 0x87, 0x00, 0x30, 0xE0, 0x07, 0x0E, 0x00, 0x60,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x0F,
  0xE0, 0x1F, 0xFC, 0x1F, 0xFC, 0x1E, 0x06, 0x0E, 0x00, 0x0F, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF0,
  0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE1, 0x01, 0xF1, 0xFF, 0xF0, 0xFF, 0xF0, 0x1F, 0xE0, 0x01, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x1C, 0x0F, 0xC0, 0xE0,
  0x7F, 0x03, 0x03, 0x9C, 0x18, 0x0E, 0x30, 0xE0, 0x30, 0xC7, 0x00, 0xC7,
  0x38, 0x03, 0x1D, 0xC0, 0x0C, 0xEE, 0x00, 0x3F, 0xB0, 0x00, 0xFD, 0x80,
  0x01, 0xEE, 0x00, 0x00, 0x73, 0xC0, 0x03, 0xBF, 0x00, 0x1C, 0xFE, 0x00,
  0x67, 0x38, 0x03, 0x18, 0x60, 0x1C, 0x63, 0x80, 0xE3, 0x8E, 0x07, 0x0E,
  0x70, 0x38, 0x1F, 0xC1, 0xC0, 0x7E, 0x06, 0x00, 0xF0, 0x00, 0x00, 0xF8,
  0x01, 0xFE, 0x03, 0xFE, 0x07, 0x8E, 0x07, 0x0E, 0x0E, 0x0E, 0x0E, 0x1C,
  0x0E, 0x38, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0x87, 0x1F, 0xC7, 0x39, 0xC6,
  0x70, 0xEE, 0x70, 0xFE, 0xE0, 0x7C, 0xE0, 0x3C, 0xE0, 0x38, 0xE0, 0x7C,
  0xF0, 0xFC, 0x7F, 0xDC, 0x7F, 0x9E, 0x1E, 0x0E, 0x3B, 0xDC, 0xE7, 0x3B,
  0x9C, 0xE6, 0x00, 0x00, 0x08, 0x00, 0x70, 0x03, 0xC0, 0x3E, 0x01, 0xE0,
  0x0F, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00,
  0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0x00, 0x00,
  0x80, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70,
  0x03, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x03, 0xE0, 0x07, 0x00, 0x10, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x10, 0xC3, 0x73, 0x3F, 0xFF, 0xF3, 0xFF, 0x80, 0xE0, 0x07, 0xC0, 0x3B,
  0x81, 0xCF, 0x0F, 0x3C, 0x18, 0x70, 0x20, 0x80, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x7F, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFE, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x1F, 0x3F, 0x1F, 0x1F, 0x0E,
  0x0E, 0x3C, 0xF8, 0xE0, 0xFF, 0xFF, 0xFF, 0x39, 0xFF, 0xDF, 0x78, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xFC, 0x03, 0xFE, 0x07, 0xFF, 0x0F, 0x8F, 0x0E, 0x07, 0x1E, 0x07, 0x3C,
  0x07, 0x38, 0x07, 0x38, 0x07, 0x71, 0xC7, 0x73, 0xC7, 0x73, 0xE7, 0xF3,
  0xCF, 0xE1, 0xCE, 0xE0, 0x0E, 0xE0, 0x1E, 0xE0, 0x1C, 0xE0, 0x3C, 0xF0,
  0x78, 0xF0, 0xF0, 0x7F, 0xE0, 0x3F, 0xC0, 0x1F, 0x00, 0x00, 0x1C, 0x00,
  0xF0, 0x07, 0x80, 0x7E, 0x07, 0xF8, 0x3E, 0xE0, 0xE7, 0x02, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x7F, 0xF9, 0xFF, 0xE7,
  0xFF, 0x80, 0x01, 0xF8, 0x07, 0xFE, 0x0F, 0xFF, 0x0E, 0x0F, 0x04, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0x70, 0x00, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8,
  0x00, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x60, 0xF0, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1F, 0x00, 0xFE, 0x00, 0x7C, 0x00,
  0x3F, 0x80, 0x03, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x07, 0x8C, 0x0F, 0x87, 0xFF, 0x87, 0xFF, 0x80, 0xFF,
  0x00, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0x70,
  0x07, 0x38, 0x07, 0x38, 0x07, 0x1C, 0x07, 0x0E, 0x07, 0x87, 0x03, 0x87,
  0x03, 0x83, 0x83, 0x81, 0xC3, 0x80, 0xE1, 0xC0, 0x71, 0xFF, 0xFE, 0xFF,
  0xFF, 0x7F, 0xFF, 0x80, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xF0,
  0x00, 0x7F, 0x80, 0x3F, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE1, 0x01, 0xF0, 0x7F,
  0xF8, 0x3F, 0xFC, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x7F, 0x01, 0xFF,
  0x03, 0xF0, 0x0F, 0x80, 0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0x73, 0xE0, 0x7F, 0xF8, 0xFF, 0xFC, 0xF0, 0x3C, 0xE0, 0x1C, 0xE0, 0x1C,
  0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x3C, 0xE0, 0x38, 0xF0, 0xF8, 0xFF, 0xF0,
  0x7F, 0xE0, 0x1F, 0x80, 0x3F, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xC0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00,
  0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x03, 0xC0, 0x00, 0x00, 0xFC, 0x01, 0xFF, 0x81, 0xFF, 0xC1,
  0xE0, 0xF0, 0xE0, 0x38, 0xE0, 0x1C, 0x70, 0x0E, 0x38, 0x0E, 0x1E, 0x0F,
  0x07, 0x8F, 0x03, 0xFE, 0x00, 0xFF, 0x01, 0xEF, 0xC1, 0xC1, 0xE1, 0xC0,
  0x79, 0xC0, 0x1C, 0xE0, 0x0E, 0x70, 0x0F, 0x38, 0x07, 0x1E, 0x0F, 0x87,
  0xFF, 0x83, 0xFF, 0x80, 0x7E, 0x00, 0x01, 0xF8, 0x01, 0xFF, 0x03, 0xFF,
  0xC1, 0xE1, 0xE1, 0xE0, 0x78, 0xE0, 0x1C, 0xE0, 0x0E, 0x70, 0x07, 0x38,
  0x03, 0x9C, 0x03, 0xCF, 0x03, 0xC3, 0xFF, 0xE1, 0xFF, 0xF0, 0x3F, 0x70,
  0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xFC,
  0x0F, 0xFC, 0x07, 0xF8, 0x03, 0xE0, 0x00, 0x0F, 0x07, 0xC7, 0xE3, 0xE0,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x83, 0xE3, 0xF0,
  0xF8, 0x78, 0x00, 0x03, 0xC0, 0x7C, 0x1F, 0x83, 0xE0, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x3E, 0x0F, 0xC0,
  0xF8, 0x1F, 0x01, 0xC0, 0x38, 0x1E, 0x0F, 0x81, 0xC0, 0x00, 0x00, 0x01,
  0x00, 0x0F, 0x00, 0x3F, 0x01, 0xFE, 0x0F, 0xF0, 0x3F, 0x80, 0xFC, 0x00,
  0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x78, 0x00, 0x18, 0x1F, 0xFF, 0x8F, 0xFF, 0xE3, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x7F, 0xFE,
  0x3F, 0xFF, 0x80, 0x08, 0x00, 0x0F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0E, 0x00, 0x3F, 0x00, 0xFF,
  0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x07, 0x80, 0x03, 0x00, 0x00, 0x0F,
  0xE0, 0xFF, 0x87, 0xFE, 0x20, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x01, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x7F, 0xC0, 0x3F, 0xF8, 0x1E, 0x0E, 0x0F, 0x01,
  0xC7, 0x80, 0x73, 0xC0, 0x1C, 0xE0, 0x07, 0x78, 0x3F, 0x9C, 0x3F, 0xE7,
  0x1F, 0xFB, 0x8F, 0x0E, 0xE3, 0x83, 0x39, 0xC1, 0xCE, 0x70, 0x73, 0x9C,
  0x1C, 0xC7, 0x0E, 0x31, 0xE3, 0x8C, 0x3F, 0xE3, 0x8F, 0xF0, 0xE0, 0xFC,
  0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xF8, 0x01,
  0xFE, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07,
  0xE0, 0x07, 0x70, 0x03, 0x98, 0x03, 0x8C, 0x01, 0x87, 0x01, 0xC3, 0x80,
  0xC1, 0xC0, 0xE0, 0xE0, 0xE0, 0x70, 0x70, 0x38, 0x70, 0x1C, 0x3F, 0xFE,
  0x3F, 0xFF, 0x1F, 0xFF, 0x9C, 0x01, 0xCE, 0x00, 0xEE, 0x00, 0x77, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0E, 0x07, 0xFC, 0x03, 0xFF, 0x83, 0xFF, 0xE1,
  0xC0, 0xF0, 0xE0, 0x38, 0x70, 0x1C, 0x78, 0x0E, 0x38, 0x07, 0x1C, 0x07,
  0x0E, 0x0F, 0x87, 0xFF, 0x87, 0xFF, 0x03, 0xFF, 0xE1, 0xC0, 0xF8, 0xE0,
  0x1C, 0xE0, 0x0E, 0x70, 0x07, 0x38, 0x07, 0x9C, 0x03, 0x9C, 0x07, 0xCF,
  0xFF, 0xC7, 0xFF, 0x83, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0xF0, 0x3F,
  0xFC, 0x1F, 0x02, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x00,
  0x01, 0xF0, 0x20, 0x3F, 0xF8, 0x07, 0xFE, 0x00, 0xFE, 0x00, 0x03, 0xFC,
  0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x1C, 0x1E, 0x07, 0x03, 0xC3, 0xC0, 0x70,
  0xE0, 0x1C, 0x38, 0x07, 0x0E, 0x01, 0xC7, 0x80, 0x71, 0xC0, 0x1C, 0x70,
  0x07, 0x1C, 0x01, 0xCF, 0x00, 0xF3, 0x80, 0x38, 0xE0, 0x1E, 0x38, 0x07,
  0x0C, 0x03, 0xC7, 0x01, 0xE1, 0xC1, 0xF0, 0x7F, 0xF8, 0x1F, 0xFC, 0x0F,
  0xF8, 0x00, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xF8, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0xFF,
  0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xFF,
  0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F,
  0xFC, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0E,
  0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x7F, 0xE0, 0x7F, 0xF8, 0x3E, 0x06, 0x0F, 0x00, 0x07, 0x00, 0x03,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x0E, 0x38, 0x03, 0x8E, 0x00, 0xE3, 0x80, 0x78, 0xE0, 0x1C,
  0x3C, 0x07, 0x0F, 0x01, 0xC1, 0xE0, 0xF0, 0x7F, 0xF8, 0x0F, 0xFE, 0x00,
  0xFE, 0x00, 0x03, 0x80, 0x70, 0x78, 0x07, 0x07, 0x00, 0x70, 0x70, 0x0F,
  0x07, 0x00, 0xE0, 0xF0, 0x0E, 0x0E, 0x00, 0xE0, 0xE0, 0x0E, 0x0E, 0x01,
  0xC0, 0xE0, 0x1C, 0x1F, 0xFF, 0xC1, 0xFF, 0xFC, 0x1F, 0xFF, 0x81, 0xC0,
  0x38, 0x3C, 0x03, 0x83, 0x80, 0x38, 0x38, 0x07, 0x03, 0x80, 0x70, 0x78,
  0x07, 0x07, 0x00, 0x70, 0x70, 0x0E, 0x07, 0x00, 0xE0, 0xE0, 0x0E, 0x00,
  0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0x0E, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x80, 0xF0, 0x38, 0x3C,
  0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x07, 0xE0, 0x00, 0x07, 0x00, 0xE0, 0x70,
  0x1C, 0x07, 0x03, 0x80, 0xE0, 0x78, 0x0E, 0x0F, 0x00, 0xE1, 0xE0, 0x0E,
  0x3C, 0x01, 0xC7, 0x80, 0x1C, 0xF0, 0x01, 0xDE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xBC, 0x00, 0x39, 0xE0, 0x07, 0x8F, 0x00,
  0x70, 0x70, 0x07, 0x07, 0x80, 0x70, 0x38, 0x0F, 0x03, 0xC0, 0xE0, 0x1C,
  0x0E, 0x01, 0xE0, 0xE0, 0x0E, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x7F, 0xFB, 0xFF, 0xEF, 0xFF, 0x80, 0x01,
  0xC0, 0x70, 0x3C, 0x0E, 0x03, 0xC1, 0xE0, 0x3C, 0x1E, 0x06, 0xC3, 0xE0,
  0x6C, 0x36, 0x06, 0xC6, 0xE0, 0xEC, 0x6E, 0x0C, 0xCC, 0xC0, 0xCD, 0xCC,
  0x1C, 0xD8, 0xC1, 0xCF, 0x9C, 0x18, 0xF1, 0xC3, 0x8E, 0x1C, 0x38, 0x01,
  0x83, 0x80, 0x38, 0x70, 0x03, 0x87, 0x00, 0x38, 0x70, 0x03, 0x86, 0x00,
  0x30, 0xE0, 0x07, 0x0E, 0x00, 0x70, 0xE0, 0x07, 0x00, 0x03, 0x80, 0x30,
  0x38, 0x07, 0x07, 0xC0, 0x70, 0x7C, 0x07, 0x07, 0xC0, 0x60, 0x6E, 0x0E,
  0x0E, 0xE0, 0xE0, 0xE6, 0x0E, 0x0E, 0x60, 0xC0, 0xC7, 0x1C, 0x1C, 0x71,
  0xC1, 0xC3, 0x1C, 0x1C, 0x31, 0x81, 0xC3, 0xB8, 0x18, 0x3B, 0x83, 0x81,
  0xB8, 0x38, 0x1B, 0x03, 0x81, 0xB0, 0x30, 0x1F, 0x07, 0x01, 0xF0, 0x70,
  0x1F, 0x07, 0x00, 0xE0, 0x60, 0x0E, 0x00, 0x00, 0xFC, 0x01, 0xFF, 0x01,
  0xFF, 0xC1, 0xF1, 0xE1, 0xE0, 0x78, 0xE0, 0x1C, 0xF0, 0x0E, 0x70, 0x07,
  0x78, 0x03, 0xB8, 0x01, 0xDC, 0x00, 0xFE, 0x00, 0xEE, 0x00, 0x77, 0x00,
  0x3B, 0x80, 0x1D, 0xC0, 0x1C, 0xE0, 0x1E, 0x70, 0x0E, 0x3C, 0x0F, 0x1F,
  0x0F, 0x07, 0xFF, 0x01, 0xFF, 0x00, 0x7E, 0x00, 0x03, 0xFC, 0x01, 0xFF,
  0xC0, 0x7F, 0xF8, 0x1C, 0x1F, 0x0F, 0x03, 0xC3, 0x80, 0x70, 0xE0, 0x1C,
  0x38, 0x07, 0x1E, 0x01, 0xC7, 0x00, 0xE1, 0xC0, 0x78, 0x70, 0x7C, 0x3F,
  0xFE, 0x0F, 0xFF, 0x03, 0xFE, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0xC1, 0xF1, 0xE1, 0xE0, 0x78, 0xE0,
  0x1C, 0xF0, 0x0E, 0x70, 0x07, 0x78, 0x03, 0xB8, 0x01, 0xDC, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0x77, 0x00, 0x3B, 0x80, 0x1D, 0xC0, 0x1C, 0xE0, 0x1E,
  0x70, 0x0E, 0x3C, 0x0F, 0x1F, 0x0F, 0x07, 0xFF, 0x01, 0xFF, 0x00, 0x7E,
  0x00, 0x1C, 0x00, 0x0F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7E, 0x00,
  0x06, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x38, 0x1E, 0x0E,
  0x03, 0x83, 0x80, 0xF0, 0xE0, 0x3C, 0x78, 0x0E, 0x1C, 0x03, 0x87, 0x00,
  0xE1, 0xC0, 0x70, 0xF0, 0x7C, 0x3F, 0xFE, 0x0F, 0xFE, 0x03, 0xBF, 0x01,
  0xE1, 0xC0, 0x70, 0x78, 0x1C, 0x0E, 0x07, 0x03, 0x83, 0xC0, 0x70, 0xE0,
  0x1C, 0x38, 0x07, 0x0E, 0x01, 0xE0, 0x00, 0x7F, 0x00, 0x7F, 0xF0, 0x3F,
  0xFC, 0x1E, 0x02, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01,
  0xE1, 0x80, 0xF0, 0x7F, 0xFC, 0x3F, 0xFC, 0x01, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFE, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0x0E, 0x01, 0xC7, 0x00,
  0x71, 0xC0, 0x1C, 0x70, 0x0E, 0x1C, 0x03, 0x8E, 0x00, 0xE3, 0x80, 0x38,
  0xE0, 0x1C, 0x38, 0x07, 0x1C, 0x01, 0xC7, 0x00, 0x71, 0xC0, 0x38, 0x70,
  0x0E, 0x38, 0x03, 0x8E, 0x00, 0xE3, 0x80, 0x70, 0xE0, 0x1C, 0x38, 0x0F,
  0x0F, 0x03, 0x81, 0xC1, 0xE0, 0x7F, 0xF0, 0x0F, 0xF8, 0x01, 0xF8, 0x00,
  0xE0, 0x03, 0xB8, 0x00, 0xEE, 0x00, 0x73, 0x80, 0x1C, 0xE0, 0x0E, 0x38,
  0x03, 0x8E, 0x01, 0xC3, 0x80, 0x70, 0xE0, 0x38, 0x38, 0x0E, 0x0E, 0x07,
  0x01, 0x81, 0xC0, 0x70, 0xE0, 0x1C, 0x38, 0x07, 0x1C, 0x01, 0xC7, 0x00,
  0x73, 0x80, 0x1C, 0xC0, 0x07, 0x70, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x00, 0x0E, 0x00, 0x70, 0xE0, 0x07, 0x0C, 0x00, 0x71,
  0xC0, 0x0E, 0x1C, 0x00, 0xE1, 0xC0, 0x0E, 0x1C, 0x00, 0xC1, 0x80, 0x1C,
  0x38, 0x01, 0xC3, 0x8E, 0x18, 0x38, 0xE1, 0x83, 0x1E, 0x38, 0x31, 0xE3,
  0x87, 0x37, 0x30, 0x77, 0x37, 0x07, 0x63, 0x70, 0x6E, 0x36, 0x06, 0xC3,
  0x60, 0x7C, 0x3E, 0x07, 0x83, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xE0,
  0x38, 0x00, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x70, 0x07, 0x81, 0xE0, 0x07,
  0x07, 0x80, 0x0E, 0x0E, 0x00, 0x1E, 0x38, 0x00, 0x1C, 0xE0, 0x00, 0x3B,
  0xC0, 0x00, 0x7F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x7B, 0x80, 0x01, 0xE7, 0x00,
  0x03, 0x87, 0x00, 0x0E, 0x0E, 0x00, 0x3C, 0x1C, 0x00, 0xF0, 0x1C, 0x03,
  0xC0, 0x38, 0x07, 0x00, 0x70, 0x1C, 0x00, 0xE0, 0x00, 0x70, 0x03, 0xDC,
  0x00, 0xE7, 0x00, 0x71, 0xC0, 0x3C, 0x70, 0x0E, 0x0C, 0x07, 0x03, 0x83,
  0x80, 0xE1, 0xE0, 0x38, 0x70, 0x07, 0x38, 0x01, 0xDC, 0x00, 0x7E, 0x00,
  0x0F, 0x80, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07,
  0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x00, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xFF, 0x80, 0xFF,
  0x80, 0xFF, 0x80, 0xE3, 0x8E, 0x38, 0xF1, 0xC7, 0x1C, 0x71, 0xC7, 0x1C,
  0x71, 0xC7, 0x1C, 0x79, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E,
  0x38, 0xF3, 0xC7, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0xE0,
  0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x00,
  0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x1D, 0xC0, 0x7B, 0x81, 0xE7, 0x07, 0x87,
  0x0E, 0x0E, 0x38, 0x1C, 0xE0, 0x1F, 0xC0, 0x3B, 0x00, 0x60, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x43, 0x8F, 0x1E, 0x38, 0x70, 0x80, 0x00,
  0xFE, 0x07, 0xFF, 0x0F, 0xFF, 0x1F, 0x0E, 0x3C, 0x0E, 0x78, 0x0E, 0x70,
  0x1C, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x38, 0xE0, 0x38, 0xE0,
  0x38, 0xF0, 0xF8, 0xFF, 0xF8, 0x7F, 0xF8, 0x3F, 0x1C, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x0F, 0x00, 0x07, 0x7E, 0x03, 0xFF, 0x81, 0xFF, 0xE1, 0xF0,
  0xF0, 0xE0, 0x3C, 0x70, 0x0E, 0x38, 0x07, 0x3C, 0x03, 0x9C, 0x03, 0x8E,
  0x01, 0xC7, 0x01, 0xE3, 0x00, 0xE3, 0x81, 0xF1, 0xC3, 0xF0, 0xFF, 0xF0,
  0x7F, 0xE0, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x07, 0xFF, 0x1F, 0xFE, 0x3F,
  0x02, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xF8, 0x18, 0x7F, 0xF8, 0x3F,
  0xF8, 0x0F, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00,
  0x3F, 0xC0, 0x3F, 0xF0, 0x3E, 0x1C, 0x1E, 0x07, 0x0F, 0x03, 0x87, 0x80,
  0xE1, 0xC0, 0x38, 0x70, 0x0E, 0x38, 0x07, 0x0E, 0x01, 0xC3, 0x80, 0x70,
  0xE0, 0x1C, 0x38, 0x06, 0x0F, 0x03, 0x81, 0xC3, 0xE0, 0x7F, 0xDC, 0x07,
  0xC7, 0x00, 0x01, 0xF8, 0x07, 0xFE, 0x1F, 0xFE, 0x3E, 0x0F, 0x78, 0x07,
  0x70, 0x0F, 0xF0, 0x0E, 0xE0, 0x7E, 0xFF, 0xFC, 0xFF, 0xF0, 0xFF, 0x80,
  0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x18, 0x7F, 0xF8, 0x3F, 0xF8, 0x0F, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38,
  0x00, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x1F, 0xF8, 0x0F, 0x87, 0x03,
  0xC0, 0xE0, 0xF0, 0x1C, 0x1C, 0x07, 0x07, 0x00, 0xE0, 0xE0, 0x1C, 0x3C,
  0x03, 0x87, 0x00, 0xE0, 0xE0, 0x1C, 0x1C, 0x03, 0x83, 0x80, 0xF0, 0x38,
  0x7C, 0x07, 0xFF, 0x80, 0x3E, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0xF0, 0x30, 0x3C, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0x03,
  0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFE, 0x1C,
  0x1E, 0x1C, 0x0F, 0x3C, 0x07, 0x38, 0x07, 0x38, 0x0E, 0x38, 0x0E, 0x78,
  0x0E, 0x70, 0x0E, 0x70, 0x1C, 0x70, 0x1C, 0xF0, 0x1C, 0xE0, 0x1C, 0xE0,
  0x38, 0xE0, 0x38, 0x03, 0x80, 0xF8, 0x1F, 0x03, 0xE0, 0x38, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x1F, 0xE3, 0xFC, 0x03, 0x80, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x3C, 0x07, 0xF8, 0x7F,
  0x07, 0xE0, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x1E, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0x3F, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C,
  0x00, 0x07, 0x01, 0x07, 0x80, 0xFF, 0xE0, 0x3F, 0xF0, 0x03, 0xF0, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0xF0, 0xE0,
  0x78, 0x38, 0x78, 0x0C, 0x3C, 0x07, 0x3E, 0x01, 0xDE, 0x00, 0x7F, 0x00,
  0x1F, 0x80, 0x0E, 0xF0, 0x03, 0x9E, 0x00, 0xE3, 0x80, 0x38, 0xF0, 0x1C,
  0x1E, 0x07, 0x03, 0x81, 0xC0, 0xF0, 0x70, 0x1C, 0x38, 0x07, 0x80, 0xFF,
  0x7F, 0xBF, 0xC1, 0xC0, 0xE0, 0x70, 0x38, 0x38, 0x1C, 0x0E, 0x07, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x0E, 0x07, 0x03,
  0xC2, 0xFF, 0x7F, 0x9F, 0x80, 0x07, 0xE7, 0x83, 0xFF, 0xF0, 0xC7, 0x9C,
  0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0x86, 0x1C, 0xE3, 0x86, 0x38,
  0xE3, 0x8E, 0x38, 0xE3, 0x00, 0x39, 0xC0, 0x0C, 0x70, 0x07, 0x1C, 0x01,
  0xC7, 0x00, 0x73, 0x80, 0x1C, 0xE0, 0x0E, 0x00, 0x03, 0xF8, 0x0F, 0xFE,
  0x0F, 0xFF, 0x0E, 0x0F, 0x1E, 0x07, 0x1C, 0x07, 0x1C, 0x07, 0x1C, 0x07,
  0x3C, 0x07, 0x38, 0x07, 0x38, 0x0E, 0x38, 0x0E, 0x78, 0x0E, 0x70, 0x0E,
  0x70, 0x1C, 0x70, 0x1C, 0xF0, 0x1C, 0x01, 0xF8, 0x07, 0xFC, 0x1F, 0xFE,
  0x3E, 0x1E, 0x3C, 0x0F, 0x78, 0x07, 0x70, 0x07, 0xF0, 0x0F, 0xE0, 0x0E,
  0xE0, 0x0E, 0xE0, 0x1E, 0xE0, 0x1C, 0xE0, 0x3C, 0xF0, 0x78, 0x7F, 0xF0,
  0x7F, 0xE0, 0x1F, 0x80, 0x01, 0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x3C,
  0x1E, 0x0E, 0x03, 0xC3, 0x80, 0x70, 0xE0, 0x1C, 0x78, 0x07, 0x1C, 0x03,
  0x87, 0x00, 0xE1, 0xC0, 0x78, 0xE0, 0x1C, 0x38, 0x1F, 0x0E, 0x1F, 0x83,
  0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xC0, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xFF, 0x03, 0xFF,
  0x0F, 0x87, 0x1E, 0x07, 0x3C, 0x0F, 0x78, 0x0E, 0x70, 0x0E, 0x70, 0x0E,
  0xE0, 0x1E, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x38, 0xF0, 0x38,
  0x70, 0x78, 0x7F, 0xF8, 0x1F, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF,
  0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0xE0, 0x00, 0x01, 0xFC, 0x07, 0xFE, 0x0F, 0xFE, 0x0E, 0x06,
  0x1C, 0x00, 0x1C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xF8,
  0x00, 0x78, 0x00, 0x38, 0x00, 0x38, 0x40, 0x78, 0xFF, 0xF0, 0xFF, 0xE0,
  0x3F, 0x80, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x82, 0x0F,
  0xF8, 0x3F, 0xE0, 0x3F, 0x00, 0x1C, 0x07, 0x38, 0x07, 0x38, 0x0E, 0x38,
  0x0E, 0x78, 0x0E, 0x70, 0x0E, 0x70, 0x1C, 0x70, 0x1C, 0xE0, 0x1C, 0xE0,
  0x3C, 0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x38, 0xF0, 0xF8, 0x7F, 0xF8, 0x7F,
  0xF8, 0x1F, 0x1C, 0xE0, 0x1F, 0xC0, 0x3B, 0x80, 0x77, 0x01, 0xCE, 0x03,
  0x9C, 0x0E, 0x38, 0x1C, 0x78, 0x70, 0x70, 0xE0, 0xE3, 0x81, 0xC7, 0x03,
  0x9C, 0x07, 0x70, 0x0F, 0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x38, 0x00, 0x70,
  0x01, 0xDC, 0x00, 0x77, 0x00, 0x19, 0xC0, 0x0E, 0x60, 0xC3, 0x98, 0x70,
  0xC6, 0x3C, 0x73, 0x8F, 0x1C, 0xE7, 0xC6, 0x39, 0xB3, 0x8E, 0xEE, 0xC3,
  0xB3, 0xF0, 0xF8, 0xFC, 0x3E, 0x1E, 0x0F, 0x07, 0x83, 0x81, 0xC0, 0xE0,
  0x70, 0x00, 0x0F, 0x01, 0xE0, 0xE0, 0x78, 0x1E, 0x1E, 0x01, 0xC3, 0x80,
  0x3C, 0xE0, 0x03, 0xB8, 0x00, 0x7E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x3E, 0x00, 0x0F, 0xE0, 0x03, 0xDC, 0x00, 0xF1, 0xC0, 0x3C, 0x38, 0x0F,
  0x07, 0x83, 0xC0, 0x70, 0xF0, 0x0E, 0x00, 0x03, 0x80, 0x78, 0x1C, 0x03,
  0x80, 0xE0, 0x1C, 0x07, 0x01, 0xE0, 0x3C, 0x0E, 0x00, 0xE0, 0x70, 0x07,
  0x07, 0x00, 0x38, 0x38, 0x01, 0xC3, 0x80, 0x0E, 0x1C, 0x00, 0x39, 0xC0,
  0x01, 0xCE, 0x00, 0x0E, 0xE0, 0x00, 0x77, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x87, 0x80, 0x07,
  0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x87, 0xFF,
  0xC3, 0xFF, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x01, 0xFF, 0xE1, 0xFF, 0xF0, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x0F, 0xF0, 0x07, 0xFC, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x01, 0xC0, 0x70,
  0x1C, 0x06, 0x03, 0x80, 0xE0, 0x38, 0x0C, 0x07, 0x01, 0xC0, 0x70, 0x18,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0x00, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x00, 0x3C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x3F, 0xE0, 0x0F, 0xF0, 0x03, 0xF8,
  0x00, 0x1E, 0x03, 0x3F, 0x07, 0x7F, 0xCE, 0xE3, 0xFE, 0xE0, 0xFC, 0xC0,
  0x78,
};

const GFXglyph UbuntuMono_Italic37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 19, 0, -1 },
  { 1, 9, 23, 19, 6, -23 },
  { 27, 11, 9, 19, 8, -23 },
  { 40, 20, 23, 19, 1, -23 },
  { 98, 17, 30, 19, 3, -26 },
  { 162, 22, 23, 19, 0, -23 },
  { 226, 16, 23, 19, 2, -23 },
  { 272, 5, 10, 19, 11, -25 },
  { 279, 14, 32, 19, 5, -26 },
  { 335, 14, 32, 19, 2, -26 },
  { 391, 14, 14, 19, 5, -23 },
  { 416, 16, 17, 19, 3, -18 },
  { 450, 8, 10, 19, 4, -5 },
  { 460, 8, 3, 19, 7, -11 },
  { 463, 6, 5, 19, 6, -5 },
  { 467, 21, 32, 19, -1, -26 },
  { 551, 16, 23, 19, 3, -23 },
  { 597, 14, 23, 19, 3, -23 },
  { 638, 16, 23, 19, 3, -23 },
  { 684, 17, 23, 19, 2, -23 },
  { 733, 17, 23, 19, 2, -23 },
  { 782, 18, 23, 19, 2, -23 },
  { 834, 16, 23, 19, 4, -23 },
  { 880, 17, 23, 19, 5, -23 },
  { 929, 17, 23, 19, 3, -23 },
  { 978, 17, 23, 19, 3, -23 },
  { 1027, 9, 17, 19, 6, -17 },
  { 1047, 11, 22, 19, 4, -17 },
  { 1078, 16, 15, 19, 3, -17 },
  { 1108, 18, 10, 19, 2, -15 },
  { 1131, 17, 15, 19, 2, -17 },
  { 1163, 13, 23, 19, 6, -23 },
  { 1201, 18, 28, 19, 3, -23 },
  { 1264, 17, 23, 19, 0, -23 },
  { 1313, 17, 23, 19, 2, -23 },
  { 1362, 18, 23, 19, 3, -23 },
  { 1414, 18, 23, 19, 1, -23 },
  { 1466, 18, 23, 19, 3, -23 },
  { 1518, 18, 23, 19, 3, -23 },
  { 1570, 18, 23, 19, 3, -23 },
  { 1622, 20, 23, 19, 1, -23 },
  { 1680, 17, 23, 19, 3, -23 },
  { 1729, 19, 23, 19, 2, -23 },
  { 1784, 20, 23, 19, 2, -23 },
  { 1842, 14, 23, 19, 2, -23 },
  { 1883, 20, 23, 19, 1, -23 },
  { 1941, 20, 23, 19, 1, -23 },
  { 1999, 17, 23, 19, 3, -23 },
  { 2048, 18, 23, 19, 2, -23 },
  { 2100, 17, 29, 19, 3, -23 },
  { 2162, 18, 23, 19, 2, -23 },
  { 2214, 18, 23, 19, 2, -23 },
  { 2266, 16, 23, 19, 6, -23 },
  { 2312, 18, 23, 19, 3, -23 },
  { 2364, 18, 23, 19, 5, -23 },
  { 2416, 20, 23, 19, 2, -23 },
  { 2474, 23, 23, 19, 0, -23 },
  { 2541, 18, 23, 19, 5, -23 },
  { 2593, 20, 23, 19, 1, -23 },
  { 2651, 16, 32, 19, 4, -26 },
  { 2715, 6, 32, 19, 8, -26 },
  { 2739, 17, 32, 19, 1, -26 },
  { 2807, 15, 12, 19, 4, -23 },
  { 2830, 17, 3, 19, -1, 4 },
  { 2837, 6, 7, 19, 10, -26 },
  { 2843, 16, 17, 19, 3, -17 },
  { 2877, 17, 26, 19, 2, -26 },
  { 2933, 16, 17, 19, 3, -17 },
  { 2967, 18, 26, 19, 3, -26 },
  { 3026, 16, 17, 19, 3, -17 },
  { 3060, 22, 32, 19, 0, -26 },
  { 3148, 19, 23, 19, 1, -17 },
  { 3203, 16, 26, 19, 2, -26 },
  { 3255, 11, 25, 19, 5, -25 },
  { 3290, 18, 31, 19, 1, -25 },
  { 3360, 18, 26, 19, 2, -26 },
  { 3419, 9, 26, 19, 7, -26 },
  { 3449, 18, 17, 19, 1, -17 },
  { 3488, 16, 17, 19, 2, -17 },
  { 3522, 16, 17, 19, 3, -17 },
  { 3556, 18, 23, 19, 1, -17 },
  { 3608, 16, 23, 19, 3, -17 },
  { 3654, 16, 17, 19, 3, -17 },
  { 3688, 16, 17, 19, 3, -17 },
  { 3722, 14, 22, 19, 5, -22 },
  { 3761, 16, 17, 19, 3, -17 },
  { 3795, 15, 17, 19, 5, -17 },
  { 3827, 18, 17, 19, 3, -17 },
  { 3866, 19, 17, 19, 1, -17 },
  { 3907, 21, 23, 19, -1, -17 },
  { 3968, 17, 17, 19, 2, -17 },
  { 4005, 18, 32, 19, 3, -26 },
  { 4077, 10, 32, 19, 6, -26 },
  { 4117, 18, 32, 19, 0, -26 },
  { 4189, 16, 6, 19, 3, -15 },
};

const GFXfont UbuntuMono_Italic37pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Italic37pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Italic37pt7bGlyphs,
  0x20, 0x7E, 37
};

#endif // _UBUNTUMONO_ITALIC37PT7B_H_
