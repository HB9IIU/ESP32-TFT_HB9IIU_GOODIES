#ifndef _UBUNTUMONO_ITALIC18PT7B_H_
#define _UBUNTUMONO_ITALIC18PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Italic.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Italic18pt7bBitmaps[] PROGMEM = {
  0x00, 0x13, 0x33, 0x22, 0x60, 0x0C, 0xC0, 0x4E, 0xE5, 0x20, 0x0C, 0x84,
  0xC6, 0x4F, 0xF1, 0x21, 0x30, 0x91, 0xFE, 0x48, 0x64, 0x26, 0x00, 0x02,
  0x03, 0x03, 0xC6, 0x03, 0x01, 0x80, 0x60, 0x0C, 0x02, 0x01, 0x11, 0x8F,
  0x81, 0x01, 0x80, 0x18, 0x44, 0x98, 0x96, 0x12, 0x82, 0xA0, 0x7F, 0x02,
  0xA0, 0xA4, 0x34, 0x8C, 0xB1, 0x0C, 0x00, 0x0E, 0x12, 0x32, 0x36, 0x3C,
  0x3B, 0x4A, 0xCE, 0xC4, 0xCE, 0x72, 0x69, 0x28, 0x04, 0x31, 0x8C, 0x61,
  0x0C, 0x20, 0x82, 0x08, 0x20, 0x83, 0x06, 0x08, 0x08, 0x18, 0x30, 0x20,
  0x60, 0xC1, 0x83, 0x04, 0x08, 0x30, 0x41, 0x06, 0x18, 0x40, 0x18, 0x31,
  0x69, 0xE3, 0x85, 0x89, 0x00, 0x18, 0x30, 0x47, 0xF3, 0x04, 0x08, 0x00,
  0x77, 0x2C, 0xF0, 0xFC, 0x00, 0xC0, 0x20, 0x18, 0x04, 0x02, 0x01, 0x80,
  0x40, 0x30, 0x08, 0x06, 0x01, 0x00, 0xC0, 0x20, 0x18, 0x04, 0x02, 0x00,
  0x1C, 0x45, 0x8E, 0x1D, 0xB6, 0x61, 0xC2, 0x8D, 0x13, 0xC0, 0x0C, 0x76,
  0xC2, 0x08, 0x61, 0x84, 0x10, 0xCF, 0xC0, 0x1E, 0x11, 0x01, 0x01, 0x03,
  0x06, 0x0C, 0x30, 0x60, 0x40, 0xFE, 0x1E, 0x13, 0x01, 0x01, 0x02, 0x1C,
  0x06, 0x02, 0x02, 0x86, 0xFC, 0x03, 0x07, 0x0F, 0x1A, 0x32, 0x66, 0x46,
  0xFF, 0x04, 0x0C, 0x0C, 0x0F, 0x8C, 0x04, 0x02, 0x03, 0xC0, 0x30, 0x08,
  0x04, 0x02, 0x43, 0x3E, 0x00, 0x07, 0x18, 0x20, 0x40, 0xFC, 0xC6, 0x86,
  0x86, 0x86, 0xCC, 0x78, 0x7F, 0x01, 0x81, 0x81, 0x80, 0x80, 0xC0, 0xC0,
  0x60, 0x60, 0x30, 0x10, 0x00, 0x0F, 0x08, 0xCC, 0x64, 0x23, 0x31, 0xE1,
  0x88, 0x86, 0xC3, 0x23, 0x1F, 0x00, 0x0E, 0x18, 0x88, 0x64, 0x36, 0x19,
  0x08, 0xFC, 0x04, 0x06, 0x06, 0x3C, 0x00, 0x33, 0x00, 0x00, 0xEE, 0x18,
  0xC0, 0x00, 0x01, 0xCE, 0x26, 0x00, 0x01, 0x0E, 0x78, 0x40, 0x70, 0x1C,
  0x06, 0x7F, 0x00, 0x00, 0xFF, 0x20, 0x38, 0x0E, 0x03, 0x0E, 0x70, 0xC0,
  0x7C, 0x10, 0x43, 0x18, 0x86, 0x00, 0x03, 0x0C, 0x00, 0x0F, 0x0C, 0xCC,
  0x2C, 0xF4, 0x9A, 0xCB, 0x45, 0xA2, 0xDB, 0x67, 0x10, 0x0C, 0x03, 0xC0,
  0x03, 0x07, 0x0D, 0x09, 0x19, 0x11, 0x31, 0x3F, 0x41, 0x41, 0x81, 0x3E,
  0x31, 0x21, 0x21, 0x63, 0x7C, 0x43, 0x43, 0xC3, 0xC6, 0xFC, 0x1F, 0x31,
  0x60, 0xC0, 0xC0, 0x80, 0x80, 0x80, 0x80, 0xC4, 0x7C, 0x3E, 0x23, 0x21,
  0x61, 0x61, 0x41, 0x41, 0xC3, 0xC6, 0x8C, 0xF8, 0x1F, 0x88, 0x0C, 0x06,
  0x02, 0x01, 0xF1, 0x80, 0xC0, 0x40, 0x20, 0x3F, 0x80, 0x1F, 0x88, 0x0C,
  0x06, 0x02, 0x01, 0xF1, 0x80, 0xC0, 0x40, 0x20, 0x30, 0x00, 0x0F, 0x8C,
  0x48, 0x0C, 0x04, 0x02, 0x03, 0x0D, 0x86, 0x42, 0x31, 0x0F, 0x80, 0x30,
  0x90, 0x48, 0x6C, 0x36, 0x13, 0xF9, 0x0D, 0x86, 0xC2, 0x41, 0x21, 0x80,
  0x1F, 0x82, 0x03, 0x01, 0x80, 0x80, 0x40, 0x20, 0x30, 0x18, 0x08, 0x3F,
  0x00, 0x0F, 0x80, 0xC0, 0x40, 0x20, 0x30, 0x18, 0x08, 0x04, 0x06, 0x22,
  0x1E, 0x00, 0x31, 0x8C, 0xC2, 0x60, 0xB0, 0x78, 0x1C, 0x05, 0x81, 0x30,
  0xC4, 0x31, 0x88, 0x20, 0x10, 0x60, 0xC1, 0x02, 0x0C, 0x18, 0x20, 0x41,
  0x83, 0xF0, 0x08, 0xC6, 0x31, 0x94, 0x67, 0x2E, 0x89, 0xA2, 0x49, 0x82,
  0x41, 0x90, 0x4C, 0x10, 0x30, 0x98, 0x4E, 0x65, 0x36, 0x92, 0x49, 0x34,
  0x8E, 0xC6, 0x43, 0x21, 0x80, 0x0F, 0x08, 0x88, 0x6C, 0x34, 0x1A, 0x09,
  0x05, 0x86, 0xC2, 0x23, 0x0E, 0x00, 0x1F, 0x18, 0x8C, 0x64, 0x32, 0x13,
  0x19, 0xF0, 0x80, 0x40, 0x60, 0x30, 0x00, 0x0F, 0x08, 0x88, 0x6C, 0x34,
  0x1A, 0x09, 0x05, 0x86, 0xC2, 0x23, 0x0E, 0x06, 0x01, 0x80, 0x60, 0x3E,
  0x18, 0x88, 0x44, 0x26, 0x13, 0x19, 0xF0, 0x98, 0xC4, 0x63, 0x21, 0x80,
  0x0F, 0x18, 0x8C, 0x06, 0x03, 0x00, 0x60, 0x18, 0x04, 0x02, 0x43, 0x1F,
  0x00, 0xFE, 0x10, 0x30, 0x30, 0x20, 0x20, 0x60, 0x60, 0x40, 0x40, 0x40,
  0x30, 0x90, 0x48, 0x6C, 0x36, 0x12, 0x09, 0x0C, 0x86, 0xC2, 0x23, 0x0F,
  0x00, 0xC1, 0xE0, 0x90, 0xC8, 0x44, 0x62, 0x21, 0x30, 0x90, 0x50, 0x28,
  0x18, 0x00, 0x20, 0xC8, 0x26, 0x09, 0x86, 0x49, 0x15, 0x45, 0x51, 0x9C,
  0xA6, 0x31, 0x8C, 0x40, 0x18, 0x61, 0x18, 0x36, 0x06, 0x80, 0x60, 0x0C,
  0x03, 0x80, 0xD0, 0x33, 0x0C, 0x21, 0x04, 0x00, 0x83, 0x82, 0xC6, 0xCC,
  0x48, 0x50, 0x60, 0x60, 0x60, 0x40, 0x40, 0x3F, 0x80, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0x40, 0x40, 0x60, 0x60, 0x3F, 0x80, 0x1F, 0x18, 0x10, 0x10,
  0x30, 0x30, 0x20, 0x20, 0x20, 0x60, 0x40, 0x40, 0x40, 0xC0, 0xC0, 0xF0,
  0x9B, 0x6D, 0xB2, 0x49, 0x24, 0x9B, 0x0F, 0x00, 0x80, 0x40, 0x60, 0x20,
  0x10, 0x08, 0x0C, 0x06, 0x02, 0x01, 0x01, 0x80, 0xC0, 0x40, 0x20, 0xF0,
  0x0C, 0x38, 0xD3, 0x34, 0x30, 0x40, 0xFF, 0x99, 0x80, 0x1F, 0x33, 0x63,
  0x42, 0xC2, 0xC6, 0x46, 0x7A, 0x10, 0x10, 0x30, 0x30, 0x3E, 0x23, 0x61,
  0x61, 0x43, 0x42, 0x46, 0xF8, 0x1F, 0x30, 0x60, 0x40, 0xC0, 0xC0, 0x42,
  0x3E, 0x00, 0x80, 0x40, 0x60, 0x30, 0xF9, 0x89, 0x8C, 0x86, 0xC3, 0x61,
  0x91, 0x8F, 0x40, 0x1E, 0x33, 0x61, 0x43, 0xFC, 0xC0, 0x42, 0x3E, 0x01,
  0xE0, 0x40, 0x18, 0x03, 0x01, 0xFC, 0x08, 0x03, 0x00, 0x60, 0x08, 0x01,
  0x00, 0x20, 0x0C, 0x01, 0x80, 0x20, 0x38, 0x00, 0x07, 0xC6, 0x23, 0x08,
  0x86, 0x21, 0x88, 0x42, 0x10, 0xFC, 0x03, 0x01, 0x8F, 0xC0, 0x10, 0x30,
  0x30, 0x20, 0x3E, 0x62, 0x63, 0x42, 0x42, 0xC6, 0xC6, 0x84, 0x18, 0x60,
  0x1C, 0x10, 0xC3, 0x08, 0x20, 0x83, 0xC0, 0x01, 0x80, 0xC0, 0x01, 0xE0,
  0x10, 0x18, 0x0C, 0x04, 0x02, 0x01, 0x01, 0x80, 0xC0, 0xC7, 0xC0, 0x10,
  0x08, 0x04, 0x06, 0x03, 0x11, 0x30, 0xB0, 0xE0, 0x58, 0x26, 0x11, 0x18,
  0xC0, 0xF0, 0x8C, 0x62, 0x11, 0x8C, 0x42, 0x10, 0xF0, 0x7F, 0x69, 0x49,
  0x49, 0xDB, 0xC2, 0x82, 0x82, 0x3E, 0x23, 0x23, 0x63, 0x43, 0x42, 0x42,
  0xC6, 0x1E, 0x33, 0x61, 0x41, 0xC3, 0xC2, 0x46, 0x78, 0x1F, 0x08, 0xCC,
  0x26, 0x12, 0x19, 0x09, 0x8C, 0xF8, 0x40, 0x20, 0x30, 0x00, 0x0F, 0x31,
  0x63, 0x43, 0xC2, 0xC2, 0x46, 0x7E, 0x04, 0x04, 0x0C, 0x3E, 0xC1, 0x02,
  0x04, 0x18, 0x20, 0x40, 0x1F, 0x30, 0x30, 0x18, 0x0E, 0x06, 0x46, 0x7C,
  0x18, 0x20, 0x43, 0xF3, 0x04, 0x08, 0x30, 0x60, 0xC0, 0xF0, 0x43, 0x8F,
  0x1C, 0x28, 0x51, 0xA3, 0x7A, 0xC2, 0xC6, 0x46, 0x4C, 0x48, 0x58, 0x70,
  0x60, 0x40, 0xA0, 0x52, 0x4B, 0x25, 0xF3, 0x33, 0x99, 0x88, 0x10, 0x86,
  0x40, 0xA0, 0x30, 0x0E, 0x06, 0x83, 0x31, 0x8C, 0x30, 0x84, 0x21, 0x18,
  0x44, 0x1B, 0x06, 0x80, 0xE0, 0x30, 0x08, 0x06, 0x0E, 0x00, 0x3F, 0x06,
  0x0C, 0x18, 0x10, 0x20, 0x40, 0xFC, 0x0F, 0x18, 0x18, 0x10, 0x10, 0x10,
  0x30, 0x20, 0xC0, 0x60, 0x60, 0x60, 0x40, 0x40, 0x40, 0x78, 0x18, 0xC4,
  0x23, 0x18, 0x84, 0x23, 0x10, 0x84, 0x63, 0x10, 0x0E, 0x01, 0x80, 0xC0,
  0x40, 0x20, 0x10, 0x18, 0x04, 0x03, 0x82, 0x03, 0x01, 0x80, 0x80, 0x40,
  0x61, 0xE0, 0x79, 0xCE,
};

const GFXglyph UbuntuMono_Italic18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 4, 11, 9, 3, -11 },
  { 7, 5, 4, 9, 4, -11 },
  { 10, 9, 11, 9, 1, -11 },
  { 23, 9, 14, 9, 1, -12 },
  { 39, 11, 11, 9, 0, -11 },
  { 55, 8, 11, 9, 1, -11 },
  { 66, 3, 5, 9, 5, -12 },
  { 68, 6, 16, 9, 3, -13 },
  { 80, 7, 16, 9, 1, -13 },
  { 94, 7, 7, 9, 2, -11 },
  { 101, 7, 7, 9, 2, -8 },
  { 108, 4, 4, 9, 2, -2 },
  { 110, 4, 1, 9, 3, -5 },
  { 111, 3, 2, 9, 3, -2 },
  { 112, 10, 16, 9, 0, -13 },
  { 132, 7, 11, 9, 2, -11 },
  { 142, 6, 11, 9, 2, -11 },
  { 151, 8, 11, 9, 1, -11 },
  { 162, 8, 11, 9, 1, -11 },
  { 173, 8, 11, 9, 1, -11 },
  { 184, 9, 11, 9, 1, -11 },
  { 197, 8, 11, 9, 2, -11 },
  { 208, 9, 11, 9, 2, -11 },
  { 221, 9, 11, 9, 1, -11 },
  { 234, 9, 11, 9, 1, -11 },
  { 247, 4, 8, 9, 3, -8 },
  { 251, 5, 10, 9, 2, -8 },
  { 258, 8, 7, 9, 1, -8 },
  { 265, 8, 4, 9, 1, -7 },
  { 269, 8, 7, 9, 1, -9 },
  { 276, 6, 11, 9, 3, -11 },
  { 285, 9, 13, 9, 1, -11 },
  { 300, 8, 11, 9, 0, -11 },
  { 311, 8, 11, 9, 1, -11 },
  { 322, 8, 11, 9, 2, -11 },
  { 333, 8, 11, 9, 1, -11 },
  { 344, 9, 11, 9, 1, -11 },
  { 357, 9, 11, 9, 1, -11 },
  { 370, 9, 11, 9, 1, -11 },
  { 383, 9, 11, 9, 1, -11 },
  { 396, 9, 11, 9, 1, -11 },
  { 409, 9, 11, 9, 1, -11 },
  { 422, 10, 11, 9, 1, -11 },
  { 436, 7, 11, 9, 1, -11 },
  { 446, 10, 11, 9, 0, -11 },
  { 460, 9, 11, 9, 1, -11 },
  { 473, 9, 11, 9, 1, -11 },
  { 486, 9, 11, 9, 1, -11 },
  { 499, 9, 14, 9, 1, -11 },
  { 515, 9, 11, 9, 1, -11 },
  { 528, 9, 11, 9, 1, -11 },
  { 541, 8, 11, 9, 3, -11 },
  { 552, 9, 11, 9, 1, -11 },
  { 565, 9, 11, 9, 2, -11 },
  { 578, 10, 11, 9, 1, -11 },
  { 592, 11, 11, 9, 0, -11 },
  { 608, 8, 11, 9, 3, -11 },
  { 619, 9, 11, 9, 1, -11 },
  { 632, 8, 16, 9, 2, -13 },
  { 648, 3, 16, 9, 4, -13 },
  { 654, 9, 16, 9, 0, -13 },
  { 672, 7, 6, 9, 2, -11 },
  { 678, 8, 1, 9, 0, 2 },
  { 679, 3, 3, 9, 5, -12 },
  { 681, 8, 8, 9, 1, -8 },
  { 689, 8, 12, 9, 1, -12 },
  { 701, 8, 8, 9, 1, -8 },
  { 709, 9, 12, 9, 1, -12 },
  { 723, 8, 8, 9, 1, -8 },
  { 731, 11, 15, 9, 0, -12 },
  { 752, 10, 11, 9, 0, -8 },
  { 766, 8, 12, 9, 1, -12 },
  { 778, 6, 11, 9, 2, -11 },
  { 787, 9, 14, 9, 0, -11 },
  { 803, 9, 12, 9, 1, -12 },
  { 817, 5, 12, 9, 3, -12 },
  { 825, 8, 8, 9, 1, -8 },
  { 833, 8, 8, 9, 1, -8 },
  { 841, 8, 8, 9, 1, -8 },
  { 849, 9, 11, 9, 0, -8 },
  { 862, 8, 11, 9, 1, -8 },
  { 873, 7, 8, 9, 2, -8 },
  { 880, 8, 8, 9, 1, -8 },
  { 888, 7, 11, 9, 2, -11 },
  { 898, 7, 8, 9, 2, -8 },
  { 905, 8, 8, 9, 2, -8 },
  { 913, 9, 8, 9, 1, -8 },
  { 922, 10, 8, 9, 0, -8 },
  { 932, 10, 11, 9, 0, -8 },
  { 946, 8, 8, 9, 1, -8 },
  { 954, 8, 16, 9, 2, -13 },
  { 970, 5, 16, 9, 3, -13 },
  { 980, 9, 16, 9, 0, -13 },
  { 998, 8, 2, 9, 1, -7 },
};

const GFXfont UbuntuMono_Italic18pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Italic18pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Italic18pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _UBUNTUMONO_ITALIC18PT7B_H_
