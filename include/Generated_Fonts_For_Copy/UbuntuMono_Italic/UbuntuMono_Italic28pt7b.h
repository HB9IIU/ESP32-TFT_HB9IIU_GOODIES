#ifndef _UBUNTUMONO_ITALIC28PT7B_H_
#define _UBUNTUMONO_ITALIC28PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Italic.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Italic28pt7bBitmaps[] PROGMEM = {
  0x00, 0x0C, 0x18, 0x70, 0xE1, 0x83, 0x06, 0x1C, 0x30, 0x60, 0xC0, 0x00,
  0x0C, 0x38, 0x70, 0xE0, 0x63, 0x63, 0x67, 0x66, 0xC6, 0xC6, 0xC4, 0x01,
  0x86, 0x03, 0x18, 0x0C, 0x30, 0x18, 0xC3, 0xFF, 0xE7, 0xFF, 0x81, 0x8C,
  0x06, 0x38, 0x0C, 0x60, 0x38, 0xC0, 0x63, 0x03, 0xFF, 0xCF, 0xFF, 0x86,
  0x30, 0x18, 0x60, 0x31, 0x80, 0xC3, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x07, 0xE0, 0xFF, 0x8E, 0x08, 0x60, 0x03, 0x00, 0x1C, 0x00, 0xF0, 0x03,
  0xE0, 0x07, 0x80, 0x0E, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x41, 0xE7, 0xFE,
  0x1F, 0xC0, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0x07, 0x03, 0x07, 0xC1, 0x87,
  0x61, 0x83, 0x31, 0x81, 0x99, 0x80, 0xCD, 0x80, 0x6D, 0x80, 0x3F, 0x80,
  0x0E, 0xF8, 0x00, 0xFE, 0x00, 0xDB, 0x00, 0xD8, 0x80, 0xCC, 0xC0, 0xC6,
  0x60, 0xC3, 0x30, 0xC1, 0xF0, 0x60, 0x70, 0x00, 0x03, 0xC0, 0xFE, 0x1C,
  0x61, 0x86, 0x18, 0xE1, 0x8C, 0x1B, 0x80, 0xF0, 0x1C, 0x37, 0x66, 0x67,
  0x6C, 0x3C, 0xC1, 0xCC, 0x1C, 0xC3, 0xCF, 0xEC, 0x7C, 0xE0, 0x37, 0x66,
  0x64, 0xC0, 0x00, 0x40, 0x1C, 0x0F, 0x03, 0x80, 0xE0, 0x18, 0x07, 0x01,
  0xC0, 0x30, 0x0E, 0x01, 0x80, 0x30, 0x0E, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x80, 0x30, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x10,
  0x00, 0x02, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0x80, 0x70, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x70, 0x18, 0x0E, 0x03, 0x01, 0xC0,
  0x60, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x80, 0x80, 0x00, 0x0C, 0x01, 0x83,
  0x31, 0x7A, 0xE3, 0xF8, 0x1C, 0x07, 0xC1, 0xDC, 0x73, 0x84, 0x20, 0x01,
  0x80, 0x30, 0x03, 0x00, 0x30, 0x03, 0x07, 0xFF, 0x7F, 0xF0, 0x60, 0x06,
  0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x18, 0xF3, 0xCF, 0x1C, 0xEF, 0x30, 0xFD,
  0xF8, 0x6F, 0xFE, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01,
  0x80, 0x07, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x07, 0x00,
  0x0C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x18,
  0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x00,
  0xC0, 0x00, 0x03, 0xE0, 0x3F, 0x83, 0x8C, 0x38, 0x73, 0x83, 0x98, 0x1D,
  0xCC, 0xEC, 0xE6, 0x67, 0x33, 0x39, 0xB8, 0x1D, 0xC0, 0xCE, 0x0E, 0x70,
  0xE1, 0x8E, 0x0F, 0xE0, 0x3E, 0x00, 0x00, 0xC0, 0xE0, 0x78, 0x7E, 0x3B,
  0x8C, 0xC0, 0x30, 0x0C, 0x07, 0x01, 0x80, 0x60, 0x18, 0x0E, 0x03, 0x00,
  0xC3, 0xFE, 0xFF, 0x80, 0x03, 0xE0, 0x7F, 0x87, 0x0C, 0x10, 0x70, 0x03,
  0x80, 0x18, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x38, 0x03,
  0x80, 0x38, 0x01, 0x80, 0x1F, 0xF8, 0xFF, 0xC0, 0x07, 0xE0, 0xFF, 0x08,
  0x70, 0x03, 0x00, 0x30, 0x07, 0x00, 0xE0, 0x7C, 0x0F, 0xC0, 0x0E, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x0E, 0xC1, 0xCF, 0xF8, 0x7E, 0x00, 0x00, 0x38,
  0x03, 0xC0, 0x3E, 0x03, 0xE0, 0x3B, 0x03, 0x98, 0x38, 0xC3, 0x8E, 0x18,
  0x61, 0x83, 0x18, 0x18, 0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x03, 0x00, 0x38,
  0x01, 0x80, 0x07, 0xF8, 0x3F, 0xC1, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x7C, 0x03, 0xF8, 0x03, 0xE0, 0x07, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x72, 0x0F, 0x1F, 0xF0, 0x7E, 0x00, 0x00, 0xF0, 0x3F, 0x0F, 0x01, 0xC0,
  0x38, 0x03, 0x00, 0x6F, 0x87, 0xFC, 0xE0, 0xEC, 0x0E, 0xC0, 0x6C, 0x0E,
  0xC0, 0xEC, 0x0C, 0xE3, 0xC7, 0xF8, 0x3E, 0x00, 0x3F, 0xF3, 0xFF, 0x80,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0xE0,
  0x06, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x00,
  0x03, 0xE0, 0x7F, 0x87, 0x0E, 0x30, 0x31, 0x81, 0x8C, 0x1C, 0x61, 0xC3,
  0xDC, 0x0F, 0xC1, 0xCF, 0x1C, 0x18, 0xC0, 0xCE, 0x06, 0x70, 0x33, 0x87,
  0x8F, 0xF8, 0x3F, 0x00, 0x03, 0xE0, 0x7F, 0x87, 0x0E, 0x70, 0x33, 0x01,
  0x98, 0x0C, 0xC0, 0xE7, 0x07, 0x3F, 0xF8, 0x7F, 0x80, 0x1C, 0x01, 0xC0,
  0x1E, 0x01, 0xE0, 0x3E, 0x1F, 0xC0, 0xF8, 0x00, 0x1C, 0xF3, 0xCE, 0x00,
  0x00, 0x00, 0x01, 0x8F, 0x3C, 0xE0, 0x07, 0x0F, 0x0F, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x18, 0x3C, 0x3C, 0x3C, 0x1C, 0x38, 0xF0, 0xC0, 0x00,
  0x10, 0x07, 0x80, 0xF8, 0x3E, 0x07, 0xC0, 0x70, 0x03, 0xE0, 0x07, 0xC0,
  0x07, 0xC0, 0x0E, 0x00, 0x10, 0x7F, 0xFB, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xF3, 0xFF, 0x80, 0x30, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0x03, 0xF0, 0xF8, 0x7E, 0x0F, 0x00, 0x80, 0x00, 0x1F, 0x0F,
  0xE2, 0x18, 0x06, 0x01, 0x80, 0xE0, 0x70, 0x30, 0x18, 0x0C, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x00, 0x01, 0xF0, 0x1F, 0xE0,
  0xE1, 0x87, 0x07, 0x38, 0x0C, 0xC0, 0x77, 0x0F, 0x98, 0xFE, 0x67, 0x1B,
  0x98, 0xEC, 0xE3, 0x33, 0x0C, 0xCC, 0x33, 0x39, 0xCC, 0x7E, 0x30, 0xF8,
  0xE0, 0x01, 0x80, 0x07, 0x00, 0x0F, 0xC0, 0x0F, 0x00, 0x00, 0x70, 0x07,
  0x80, 0x3C, 0x03, 0x60, 0x33, 0x01, 0x9C, 0x18, 0xE0, 0xC7, 0x0C, 0x18,
  0x60, 0xC6, 0x06, 0x7F, 0xF3, 0xFF, 0xB8, 0x0D, 0x80, 0x7C, 0x03, 0xC0,
  0x18, 0x0F, 0xF0, 0x3F, 0xE0, 0xC3, 0xC7, 0x07, 0x1C, 0x1C, 0x60, 0x61,
  0x83, 0x0F, 0xF8, 0x3F, 0xE0, 0xC1, 0xC3, 0x03, 0x8C, 0x0E, 0x70, 0x31,
  0x81, 0xC6, 0x0E, 0x1F, 0xF0, 0xFF, 0x00, 0x01, 0xF8, 0x1F, 0xF0, 0xE0,
  0x87, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0x60, 0x01, 0x80, 0x07, 0x04, 0x0F, 0xF0, 0x1F,
  0x80, 0x0F, 0xC0, 0x3F, 0xC1, 0xC3, 0x87, 0x06, 0x18, 0x1C, 0x60, 0x71,
  0x81, 0xCE, 0x07, 0x30, 0x18, 0xC0, 0x63, 0x03, 0x9C, 0x0E, 0x60, 0x71,
  0x83, 0x86, 0x1C, 0x3F, 0xE0, 0xFE, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0xC0,
  0x07, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0F, 0xF8, 0x3F, 0xE0, 0xC0,
  0x03, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x3F, 0xF8, 0xFF,
  0xC0, 0x0F, 0xFC, 0x3F, 0xF0, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x0F, 0xF8, 0x3F, 0xE0, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x00, 0x01, 0xF0, 0x1F, 0xE0, 0xE0,
  0x87, 0x00, 0x38, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80,
  0xCE, 0x07, 0x38, 0x18, 0xE0, 0x61, 0x83, 0x87, 0x0E, 0x0F, 0xF0, 0x1F,
  0x80, 0x0C, 0x06, 0x18, 0x1C, 0x30, 0x38, 0xE0, 0x61, 0x80, 0xC3, 0x03,
  0x86, 0x07, 0x1F, 0xFC, 0x3F, 0xF8, 0x60, 0x70, 0xC0, 0xE3, 0x81, 0x86,
  0x03, 0x0C, 0x06, 0x18, 0x1C, 0x70, 0x30, 0xC0, 0x60, 0x0F, 0xF8, 0x7F,
  0xC0, 0x60, 0x03, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x07, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x1F, 0xF0, 0xFF,
  0x80, 0x07, 0xF8, 0x1F, 0xE0, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xC0,
  0x07, 0x04, 0x38, 0x3F, 0xE0, 0x7E, 0x00, 0x0E, 0x0E, 0x18, 0x38, 0x30,
  0xE0, 0x63, 0x81, 0xCE, 0x03, 0x38, 0x06, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0x6E, 0x00, 0xCE, 0x01, 0x8C, 0x07, 0x1C, 0x0C, 0x18, 0x18, 0x38, 0x30,
  0x30, 0xE0, 0x70, 0x0C, 0x07, 0x01, 0x80, 0x60, 0x18, 0x0E, 0x03, 0x00,
  0xC0, 0x30, 0x1C, 0x06, 0x01, 0x80, 0x60, 0x38, 0x0C, 0x03, 0xFF, 0xFF,
  0x80, 0x03, 0x07, 0x07, 0x06, 0x07, 0x0E, 0x05, 0x0E, 0x0D, 0x1E, 0x0D,
  0x16, 0x0D, 0xB6, 0x19, 0xE6, 0x19, 0xEC, 0x19, 0xCC, 0x31, 0x8C, 0x30,
  0x0C, 0x30, 0x1C, 0x70, 0x18, 0x60, 0x18, 0x60, 0x18, 0x60, 0x18, 0x0E,
  0x06, 0x1C, 0x0C, 0x38, 0x38, 0xD8, 0x61, 0xB0, 0xC3, 0x61, 0x86, 0xC3,
  0x1C, 0xCC, 0x31, 0x98, 0x63, 0x30, 0xC6, 0x63, 0x87, 0x86, 0x0F, 0x0C,
  0x1E, 0x18, 0x3C, 0x70, 0x70, 0xC0, 0x60, 0x03, 0xE0, 0x7F, 0x87, 0x8E,
  0x30, 0x33, 0x81, 0x98, 0x0D, 0xC0, 0x6C, 0x03, 0x60, 0x3F, 0x01, 0xB8,
  0x0D, 0xC0, 0xEE, 0x06, 0x70, 0x71, 0xC7, 0x0F, 0xF0, 0x1E, 0x00, 0x0F,
  0xE0, 0xFF, 0x86, 0x0E, 0x30, 0x31, 0x81, 0x9C, 0x0C, 0xC0, 0xE6, 0x06,
  0x30, 0xF3, 0xFF, 0x1F, 0xE0, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x00, 0x03, 0xE0, 0x7F, 0x87, 0x8E, 0x30, 0x33, 0x81, 0x98,
  0x0D, 0xC0, 0x6C, 0x03, 0x60, 0x3F, 0x01, 0xB8, 0x0D, 0xC0, 0xEE, 0x06,
  0x70, 0x71, 0xC7, 0x0F, 0xF0, 0x3E, 0x00, 0xE0, 0x07, 0x00, 0x1E, 0x00,
  0x78, 0x00, 0xC0, 0x0F, 0xE0, 0x3F, 0xE0, 0xC3, 0x83, 0x07, 0x1C, 0x1C,
  0x60, 0x71, 0x81, 0x86, 0x06, 0x38, 0x70, 0xFF, 0x83, 0x78, 0x0C, 0x70,
  0x70, 0xC1, 0x83, 0x86, 0x06, 0x18, 0x18, 0xE0, 0x60, 0x03, 0xF0, 0x7F,
  0xC7, 0x04, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x70, 0x01, 0xE0, 0x07, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xC0, 0x06, 0x00, 0x73, 0x07, 0x1F, 0xF0, 0x7F,
  0x00, 0x7F, 0xFF, 0xFF, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x1C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x38, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x70, 0x00, 0x18, 0x0C, 0x60, 0x71, 0x81, 0xCE, 0x06, 0x30, 0x18,
  0xC0, 0xE7, 0x03, 0x1C, 0x0C, 0x60, 0x31, 0x81, 0xCE, 0x06, 0x38, 0x18,
  0xE0, 0xE3, 0x83, 0x86, 0x1C, 0x1F, 0xE0, 0x3F, 0x00, 0xC0, 0x3E, 0x01,
  0xB0, 0x1D, 0x80, 0xCC, 0x0E, 0x60, 0x63, 0x07, 0x18, 0x30, 0xC3, 0x86,
  0x18, 0x39, 0xC1, 0xCC, 0x0E, 0xC0, 0x36, 0x01, 0xE0, 0x0F, 0x00, 0x70,
  0x00, 0x38, 0x0E, 0x60, 0x18, 0xC0, 0x31, 0x80, 0x63, 0x01, 0x8E, 0x03,
  0x18, 0xC6, 0x33, 0x8C, 0x65, 0x30, 0xDA, 0x61, 0x24, 0xC6, 0xCB, 0x0F,
  0x1E, 0x1E, 0x3C, 0x38, 0x70, 0x70, 0xE0, 0xC1, 0xC0, 0x07, 0x03, 0x83,
  0x83, 0x80, 0xC3, 0x80, 0x71, 0x80, 0x39, 0x80, 0x0D, 0x80, 0x07, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xF0, 0x00, 0xD8, 0x00, 0xCE, 0x00, 0xE3,
  0x00, 0xE1, 0x80, 0xE0, 0xE0, 0xE0, 0x30, 0x60, 0x18, 0x00, 0xC0, 0x1F,
  0x01, 0xD8, 0x1C, 0xC0, 0xC6, 0x0C, 0x30, 0xE0, 0xC6, 0x06, 0x60, 0x36,
  0x01, 0xF0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x00, 0x0F, 0xFE, 0x1F, 0xFC, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x06, 0x00, 0x18, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x07, 0xF0,
  0x7F, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x01,
  0xC0, 0x18, 0x01, 0x80, 0x18, 0x03, 0x80, 0x30, 0x03, 0x00, 0x30, 0x07,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0F, 0xE0, 0xFE, 0x00,
  0xCE, 0xEE, 0xE6, 0x66, 0x66, 0x66, 0x67, 0x77, 0x77, 0x33, 0x33, 0x33,
  0x30, 0x07, 0xF0, 0x7F, 0x00, 0x30, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x38, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x06, 0x0F,
  0xE0, 0xFE, 0x00, 0x03, 0x80, 0xF0, 0x1F, 0x06, 0x61, 0xCC, 0x71, 0xDC,
  0x1F, 0x03, 0x40, 0x60, 0x7F, 0xFF, 0xFF, 0xC0, 0x47, 0x1C, 0x71, 0x80,
  0x03, 0xE0, 0xFF, 0x3C, 0x33, 0x87, 0x70, 0x66, 0x06, 0xE0, 0x6C, 0x0E,
  0xC0, 0xCC, 0x0C, 0xE1, 0xC7, 0xFC, 0x3E, 0xE0, 0x0C, 0x00, 0xC0, 0x0C,
  0x01, 0xC0, 0x1C, 0x01, 0x80, 0x1B, 0xC3, 0xFE, 0x38, 0x73, 0x03, 0x30,
  0x33, 0x03, 0x60, 0x36, 0x07, 0x60, 0x66, 0x0E, 0xC3, 0xCF, 0xF8, 0xFE,
  0x00, 0x07, 0xF1, 0xFF, 0x3C, 0x17, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0E, 0x00, 0x70, 0x47, 0xFC, 0x1F, 0x80, 0x00, 0x0C, 0x00,
  0x30, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x3F, 0x83, 0xFC, 0x1C,
  0x30, 0xE0, 0xC7, 0x07, 0x18, 0x18, 0xE0, 0x63, 0x81, 0x8E, 0x0E, 0x38,
  0x30, 0x61, 0xC1, 0xFF, 0x83, 0xE6, 0x00, 0x07, 0xC1, 0xFF, 0x3C, 0x77,
  0x03, 0x60, 0x7E, 0x0E, 0xFF, 0xCF, 0xF0, 0xC0, 0x0C, 0x00, 0xF0, 0x47,
  0xFC, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x1C, 0x00, 0x1C, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x01, 0xC0, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x01, 0xFC, 0x1F, 0xF0, 0xE1, 0x87,
  0x06, 0x38, 0x38, 0xC0, 0xE3, 0x03, 0x1C, 0x0C, 0x70, 0x70, 0xC3, 0x83,
  0xFE, 0x07, 0xD8, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x20, 0xE0, 0xFF, 0x81,
  0xF8, 0x00, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x1F,
  0xC1, 0xFF, 0x18, 0x71, 0x83, 0x38, 0x33, 0x03, 0x30, 0x33, 0x07, 0x70,
  0x76, 0x06, 0x60, 0x66, 0x0E, 0xE0, 0xC0, 0x0E, 0x0E, 0x0E, 0x0C, 0x00,
  0x00, 0xFC, 0xFC, 0x1C, 0x18, 0x18, 0x18, 0x38, 0x30, 0x30, 0x30, 0x38,
  0x3F, 0x1F, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x1F, 0xC1, 0xFE, 0x00, 0x70, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x70, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x38,
  0x41, 0x83, 0xFC, 0x0F, 0x80, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01,
  0xC0, 0x0C, 0x00, 0x60, 0xE3, 0x0E, 0x39, 0xC1, 0x9C, 0x0F, 0xC0, 0x78,
  0x07, 0xE0, 0x33, 0x81, 0x8C, 0x0C, 0x70, 0xE1, 0xC6, 0x06, 0x30, 0x38,
  0xFD, 0xF8, 0x30, 0xE1, 0x83, 0x06, 0x1C, 0x30, 0x60, 0xC3, 0x86, 0x0C,
  0x18, 0x30, 0x62, 0xFC, 0xF8, 0x1F, 0x78, 0x7F, 0xE3, 0x99, 0xCC, 0x67,
  0x31, 0x98, 0xCC, 0x67, 0x31, 0x98, 0xCE, 0x60, 0x31, 0x80, 0xCE, 0x03,
  0x30, 0x1C, 0xC0, 0x60, 0x0F, 0xC1, 0xFE, 0x38, 0x73, 0x07, 0x30, 0x33,
  0x07, 0x70, 0x66, 0x06, 0x60, 0x66, 0x0E, 0xE0, 0xCC, 0x0C, 0xC0, 0xC0,
  0x07, 0xC1, 0xFE, 0x3C, 0x73, 0x03, 0x70, 0x36, 0x03, 0xE0, 0x3E, 0x07,
  0xE0, 0x6E, 0x0E, 0x61, 0xC7, 0xF8, 0x3E, 0x00, 0x03, 0xF0, 0x3F, 0xE0,
  0xE1, 0xC3, 0x03, 0x0C, 0x0C, 0x70, 0x31, 0xC0, 0xC6, 0x07, 0x18, 0x18,
  0x60, 0xE3, 0x0F, 0x0F, 0xF8, 0x3F, 0x80, 0xC0, 0x07, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x00, 0x03, 0xF0, 0x7F, 0xC7, 0x0C, 0x70, 0x67, 0x07,
  0x30, 0x3B, 0x81, 0x9C, 0x0C, 0xE0, 0xE7, 0x07, 0x18, 0x70, 0xFF, 0x83,
  0xFC, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0x07, 0xF8,
  0xFF, 0x86, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x03, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x07, 0xE0, 0xFF, 0x1C,
  0x21, 0x80, 0x18, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xC0, 0x0C, 0x41,
  0xCF, 0xF8, 0x7F, 0x00, 0x0C, 0x03, 0x01, 0xC0, 0x70, 0xFF, 0xFF, 0xF3,
  0x80, 0xE0, 0x30, 0x0C, 0x07, 0x01, 0xC0, 0x60, 0x18, 0x07, 0x11, 0xFC,
  0x3F, 0x00, 0x38, 0x33, 0x03, 0x30, 0x77, 0x07, 0x70, 0x66, 0x06, 0x60,
  0xEE, 0x0E, 0xE0, 0xCE, 0x0C, 0x61, 0xC7, 0xFC, 0x3E, 0xE0, 0xC0, 0xF8,
  0x1B, 0x03, 0x60, 0xEC, 0x19, 0x87, 0x38, 0xC7, 0x30, 0x6E, 0x0D, 0x81,
  0xE0, 0x3C, 0x07, 0x00, 0x60, 0x0D, 0x80, 0x36, 0x01, 0x98, 0xC6, 0x67,
  0x19, 0x9C, 0xC6, 0xF3, 0x33, 0xD8, 0xD9, 0x63, 0x45, 0x8F, 0x1C, 0x38,
  0x70, 0xC1, 0x80, 0x0E, 0x0E, 0x0C, 0x38, 0x1C, 0xE0, 0x19, 0x80, 0x3E,
  0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x07, 0xE0, 0x1C, 0xC0, 0x71, 0xC1,
  0xC1, 0x87, 0x03, 0x00, 0x06, 0x07, 0x06, 0x07, 0x06, 0x06, 0x06, 0x0E,
  0x07, 0x0C, 0x07, 0x0C, 0x03, 0x1C, 0x03, 0x18, 0x03, 0x38, 0x03, 0xB0,
  0x03, 0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x7E, 0x00, 0x78, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x60, 0x0F, 0xFC, 0xFF, 0x80,
  0x00, 0x7C, 0x07, 0xF0, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x70,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x01, 0xE0,
  0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0F, 0xE0, 0x1F, 0x00, 0x03, 0x03, 0x03, 0x07,
  0x06, 0x06, 0x06, 0x0E, 0x0C, 0x0C, 0x0C, 0x1C, 0x18, 0x18, 0x18, 0x38,
  0x30, 0x30, 0x30, 0x30, 0x70, 0x60, 0x60, 0x60, 0xE0, 0x03, 0xE0, 0x1F,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x0E, 0x00, 0x18, 0x00, 0x78, 0x03, 0xE0, 0x1C, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x60, 0x3F, 0x80, 0xF8, 0x00, 0x3C, 0x1B, 0xF1, 0x99, 0xF9, 0x83, 0x80,
};

const GFXglyph UbuntuMono_Italic28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 7, 17, 14, 5, -17 },
  { 16, 8, 7, 14, 6, -17 },
  { 23, 15, 17, 14, 1, -17 },
  { 55, 13, 22, 14, 2, -19 },
  { 91, 17, 17, 14, 0, -17 },
  { 128, 12, 17, 14, 2, -17 },
  { 154, 4, 7, 14, 8, -19 },
  { 158, 11, 25, 14, 4, -20 },
  { 193, 10, 25, 14, 2, -20 },
  { 225, 11, 10, 14, 4, -17 },
  { 239, 12, 12, 14, 2, -13 },
  { 257, 6, 8, 14, 3, -4 },
  { 263, 7, 2, 14, 5, -8 },
  { 265, 4, 4, 14, 5, -4 },
  { 267, 15, 25, 14, 0, -20 },
  { 314, 13, 17, 14, 2, -17 },
  { 342, 10, 17, 14, 3, -17 },
  { 364, 13, 17, 14, 2, -17 },
  { 392, 12, 17, 14, 2, -17 },
  { 418, 13, 17, 14, 1, -17 },
  { 446, 13, 17, 14, 2, -17 },
  { 474, 12, 17, 14, 3, -17 },
  { 500, 13, 17, 14, 4, -17 },
  { 528, 13, 17, 14, 2, -17 },
  { 556, 13, 17, 14, 2, -17 },
  { 584, 6, 13, 14, 5, -13 },
  { 594, 8, 17, 14, 3, -13 },
  { 611, 13, 11, 14, 2, -13 },
  { 629, 13, 7, 14, 2, -11 },
  { 641, 12, 11, 14, 2, -13 },
  { 658, 10, 17, 14, 5, -17 },
  { 680, 14, 21, 14, 2, -17 },
  { 717, 13, 17, 14, 0, -17 },
  { 745, 14, 17, 14, 1, -17 },
  { 775, 14, 17, 14, 2, -17 },
  { 805, 14, 17, 14, 1, -17 },
  { 835, 14, 17, 14, 2, -17 },
  { 865, 14, 17, 14, 2, -17 },
  { 895, 14, 17, 14, 2, -17 },
  { 925, 15, 17, 14, 1, -17 },
  { 957, 13, 17, 14, 2, -17 },
  { 985, 14, 17, 14, 2, -17 },
  { 1015, 15, 17, 14, 1, -17 },
  { 1047, 10, 17, 14, 2, -17 },
  { 1069, 16, 17, 14, 0, -17 },
  { 1103, 15, 17, 14, 1, -17 },
  { 1135, 13, 17, 14, 2, -17 },
  { 1163, 13, 17, 14, 2, -17 },
  { 1191, 13, 22, 14, 2, -17 },
  { 1227, 14, 17, 14, 1, -17 },
  { 1257, 13, 17, 14, 2, -17 },
  { 1285, 12, 17, 14, 4, -17 },
  { 1311, 14, 17, 14, 2, -17 },
  { 1341, 13, 17, 14, 4, -17 },
  { 1369, 15, 17, 14, 2, -17 },
  { 1401, 17, 17, 14, 0, -17 },
  { 1438, 13, 17, 14, 4, -17 },
  { 1466, 15, 17, 14, 1, -17 },
  { 1498, 12, 25, 14, 3, -20 },
  { 1536, 4, 25, 14, 6, -20 },
  { 1549, 12, 25, 14, 1, -20 },
  { 1587, 11, 9, 14, 3, -17 },
  { 1600, 13, 2, 14, -1, 3 },
  { 1604, 5, 5, 14, 7, -19 },
  { 1608, 12, 13, 14, 2, -13 },
  { 1628, 12, 19, 14, 2, -19 },
  { 1657, 12, 13, 14, 2, -13 },
  { 1677, 14, 19, 14, 2, -19 },
  { 1711, 12, 13, 14, 2, -13 },
  { 1731, 17, 24, 14, 0, -19 },
  { 1782, 14, 18, 14, 1, -13 },
  { 1814, 12, 19, 14, 1, -19 },
  { 1843, 8, 19, 14, 4, -19 },
  { 1862, 13, 24, 14, 1, -19 },
  { 1901, 13, 19, 14, 2, -19 },
  { 1932, 7, 19, 14, 5, -19 },
  { 1949, 14, 13, 14, 1, -13 },
  { 1972, 12, 13, 14, 2, -13 },
  { 1992, 12, 13, 14, 2, -13 },
  { 2012, 14, 18, 14, 0, -13 },
  { 2044, 13, 18, 14, 2, -13 },
  { 2074, 13, 13, 14, 2, -13 },
  { 2096, 12, 13, 14, 2, -13 },
  { 2116, 10, 17, 14, 4, -17 },
  { 2138, 12, 13, 14, 2, -13 },
  { 2158, 11, 13, 14, 4, -13 },
  { 2176, 14, 13, 14, 2, -13 },
  { 2199, 15, 13, 14, 0, -13 },
  { 2224, 16, 18, 14, -1, -13 },
  { 2260, 12, 13, 14, 2, -13 },
  { 2280, 14, 25, 14, 2, -20 },
  { 2324, 8, 25, 14, 4, -20 },
  { 2349, 14, 25, 14, 0, -20 },
  { 2393, 13, 4, 14, 2, -11 },
};

const GFXfont UbuntuMono_Italic28pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Italic28pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Italic28pt7bGlyphs,
  0x20, 0x7E, 28
};

#endif // _UBUNTUMONO_ITALIC28PT7B_H_
