#ifndef _UBUNTUMONO_ITALIC19PT7B_H_
#define _UBUNTUMONO_ITALIC19PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Italic.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Italic19pt7bBitmaps[] PROGMEM = {
  0x00, 0x18, 0x84, 0x63, 0x10, 0x80, 0x03, 0x39, 0x80, 0x49, 0x24, 0xB2,
  0x90, 0x04, 0xC3, 0x20, 0x99, 0xFF, 0x7F, 0x84, 0xC3, 0x20, 0x98, 0xFF,
  0xBF, 0xC4, 0xC3, 0x20, 0x02, 0x01, 0x03, 0xC3, 0xF3, 0x09, 0x80, 0x60,
  0x3C, 0x07, 0x01, 0x90, 0xDF, 0xC7, 0xC0, 0x80, 0x40, 0x1C, 0x27, 0x88,
  0x92, 0x12, 0xC3, 0xF0, 0x74, 0x01, 0x60, 0x5E, 0x12, 0x46, 0xD9, 0x9E,
  0x21, 0x80, 0x0E, 0x1F, 0x33, 0x32, 0x1C, 0x39, 0x6B, 0xC6, 0xC6, 0xCE,
  0xFA, 0x73, 0xFE, 0x80, 0x02, 0x18, 0x61, 0x82, 0x0C, 0x30, 0x60, 0x81,
  0x02, 0x04, 0x0C, 0x08, 0x18, 0x10, 0x08, 0x18, 0x10, 0x30, 0x20, 0x40,
  0x81, 0x06, 0x0C, 0x30, 0x41, 0x86, 0x18, 0x40, 0x30, 0x22, 0x5F, 0xF1,
  0x0D, 0x13, 0x00, 0x08, 0x08, 0x18, 0x18, 0xFE, 0x10, 0x30, 0x30, 0x20,
  0x37, 0x33, 0x6C, 0x78, 0x7D, 0x80, 0x00, 0x40, 0x18, 0x06, 0x00, 0x80,
  0x30, 0x04, 0x01, 0x80, 0x20, 0x0C, 0x03, 0x00, 0x40, 0x18, 0x02, 0x00,
  0xC0, 0x10, 0x06, 0x00, 0x1E, 0x3F, 0x73, 0x63, 0xC3, 0xDB, 0x9B, 0x82,
  0x86, 0x8C, 0xFC, 0x70, 0x06, 0x38, 0xD1, 0x60, 0xC1, 0x02, 0x0C, 0x18,
  0x23, 0xF7, 0xE0, 0x0F, 0x0F, 0xC4, 0x60, 0x30, 0x18, 0x18, 0x38, 0x38,
  0x30, 0x30, 0x1F, 0x9F, 0xC0, 0x0F, 0x0F, 0xC4, 0x60, 0x30, 0x30, 0x70,
  0x78, 0x06, 0x03, 0x41, 0xBF, 0x8F, 0x80, 0x01, 0x83, 0x81, 0x41, 0x61,
  0x31, 0x91, 0x88, 0x84, 0xFF, 0x7F, 0x81, 0x00, 0x80, 0x0F, 0x87, 0xC6,
  0x02, 0x01, 0xC1, 0xF0, 0x1C, 0x06, 0x03, 0x43, 0xBF, 0x8F, 0x80, 0x07,
  0x1F, 0x38, 0x60, 0x7C, 0xFE, 0xC2, 0x82, 0x82, 0xC6, 0xFC, 0x78, 0x7F,
  0x7F, 0x02, 0x04, 0x0C, 0x18, 0x30, 0x20, 0x60, 0x40, 0xC0, 0x80, 0x0F,
  0x0F, 0xCC, 0x66, 0x13, 0x10, 0xF0, 0xFC, 0xC6, 0x41, 0x21, 0x9F, 0x87,
  0x80, 0x0F, 0x0F, 0xCC, 0x64, 0x12, 0x09, 0x0C, 0xFE, 0x3E, 0x03, 0x07,
  0x1F, 0x1E, 0x00, 0x31, 0xCC, 0x00, 0x01, 0x9C, 0x60, 0x18, 0x71, 0x80,
  0x00, 0x03, 0x1C, 0x30, 0xC6, 0x30, 0x01, 0x87, 0x9E, 0x08, 0x07, 0x00,
  0x70, 0x08, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x20, 0x1C, 0x01, 0xC0, 0x20,
  0xE3, 0xC3, 0x00, 0x3C, 0xFD, 0x18, 0x20, 0x86, 0x18, 0x00, 0x01, 0x83,
  0x86, 0x00, 0x07, 0x07, 0xE3, 0x8C, 0xC3, 0x60, 0xD9, 0xE4, 0xFB, 0x62,
  0xD9, 0xB7, 0xCC, 0xF1, 0x00, 0x40, 0x18, 0x03, 0xC0, 0x03, 0x03, 0x81,
  0x41, 0xA0, 0x98, 0xCC, 0x46, 0x63, 0x3F, 0xBF, 0xF0, 0x78, 0x30, 0x3F,
  0x1F, 0xCC, 0x64, 0x32, 0x13, 0xF1, 0xFC, 0x86, 0x41, 0x61, 0xBF, 0x9F,
  0x80, 0x0F, 0x1F, 0xDC, 0x4C, 0x0C, 0x06, 0x02, 0x01, 0x00, 0x80, 0x62,
  0x3F, 0x0F, 0x80, 0x3E, 0x1F, 0x8C, 0xE4, 0x36, 0x1B, 0x0D, 0x06, 0x82,
  0xC3, 0x63, 0x3F, 0x1F, 0x00, 0x1F, 0xC7, 0xF1, 0x00, 0xC0, 0x30, 0x0F,
  0xC3, 0xF1, 0x80, 0x60, 0x10, 0x07, 0xF3, 0xF8, 0x1F, 0xC7, 0xF1, 0x00,
  0xC0, 0x30, 0x0F, 0xC3, 0xF1, 0x80, 0x60, 0x18, 0x04, 0x03, 0x00, 0x0F,
  0x1F, 0x9C, 0x4C, 0x0C, 0x04, 0x02, 0x09, 0x04, 0x86, 0x63, 0x3F, 0x0F,
  0x80, 0x30, 0xCC, 0x32, 0x08, 0x82, 0x61, 0x9F, 0xE7, 0xF1, 0x04, 0x43,
  0x30, 0xCC, 0x22, 0x08, 0x1F, 0x8F, 0xC1, 0x80, 0x80, 0xC0, 0x60, 0x20,
  0x10, 0x18, 0x0C, 0x1F, 0x9F, 0xC0, 0x0F, 0x83, 0xE0, 0x18, 0x06, 0x01,
  0x00, 0x40, 0x30, 0x0C, 0x02, 0x11, 0x8F, 0xC1, 0xE0, 0x10, 0xCC, 0x63,
  0x30, 0x98, 0x3C, 0x1C, 0x07, 0x81, 0x30, 0x44, 0x31, 0x8C, 0x23, 0x0C,
  0x10, 0x20, 0xC1, 0x82, 0x04, 0x18, 0x30, 0x40, 0x83, 0xFF, 0xF0, 0x0C,
  0x61, 0x98, 0x73, 0x0A, 0xA1, 0x54, 0x6C, 0x89, 0xB1, 0x04, 0x60, 0x88,
  0x11, 0x06, 0x60, 0xC0, 0x30, 0xCE, 0x32, 0x88, 0xA2, 0x28, 0x9B, 0x64,
  0x51, 0x14, 0x45, 0x31, 0xCC, 0x72, 0x08, 0x1E, 0x3F, 0x63, 0x41, 0xC1,
  0x81, 0x83, 0x83, 0x86, 0xCE, 0xFC, 0x78, 0x1F, 0x1F, 0xCC, 0x66, 0x12,
  0x19, 0x0D, 0xFC, 0xFC, 0x40, 0x20, 0x30, 0x18, 0x00, 0x1E, 0x3F, 0x63,
  0x41, 0xC1, 0x81, 0x83, 0x83, 0x86, 0xCE, 0xFC, 0x78, 0x30, 0x3C, 0x18,
  0x1F, 0x1F, 0xCC, 0x66, 0x32, 0x1B, 0x1D, 0xFC, 0xF8, 0x44, 0x63, 0x30,
  0x98, 0x40, 0x0F, 0x0F, 0xCC, 0x26, 0x03, 0x00, 0xE0, 0x38, 0x06, 0x03,
  0x21, 0xBF, 0x8F, 0x80, 0xFF, 0xFF, 0x18, 0x10, 0x30, 0x30, 0x30, 0x20,
  0x60, 0x60, 0x60, 0x40, 0x61, 0xB0, 0xD0, 0x48, 0x6C, 0x36, 0x1A, 0x09,
  0x0C, 0x86, 0x66, 0x3F, 0x0F, 0x00, 0x81, 0x41, 0xA0, 0x90, 0xC8, 0x44,
  0x62, 0x21, 0x30, 0x90, 0x78, 0x38, 0x1C, 0x00, 0x30, 0x48, 0x12, 0x0D,
  0x82, 0x60, 0x93, 0x64, 0xD9, 0x54, 0x75, 0x39, 0xCC, 0x63, 0x18, 0x08,
  0x60, 0xC6, 0x0C, 0xC0, 0x58, 0x07, 0x00, 0x60, 0x06, 0x00, 0xF0, 0x1B,
  0x03, 0x10, 0x61, 0x84, 0x18, 0x81, 0xE1, 0xB0, 0x98, 0xC4, 0xC2, 0x41,
  0xC0, 0x60, 0x20, 0x30, 0x18, 0x08, 0x00, 0x1F, 0xCF, 0xF0, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x0F, 0xE3, 0xF8, 0x0F, 0x1F,
  0x18, 0x18, 0x10, 0x30, 0x30, 0x20, 0x20, 0x60, 0x60, 0x40, 0x40, 0xC0,
  0xF8, 0xF8, 0xDB, 0x64, 0x92, 0x4D, 0xB6, 0xDB, 0x0F, 0x87, 0xC0, 0x40,
  0x20, 0x10, 0x18, 0x08, 0x04, 0x06, 0x03, 0x01, 0x00, 0x80, 0xC0, 0x61,
  0xE0, 0xF0, 0x0C, 0x1C, 0x36, 0x22, 0x62, 0xC3, 0x7F, 0x80, 0xCC, 0x80,
  0x0F, 0x9F, 0x9C, 0x4C, 0x64, 0x36, 0x13, 0x18, 0xFC, 0x7A, 0x00, 0x18,
  0x08, 0x04, 0x06, 0x03, 0xE1, 0xF8, 0xC6, 0xC3, 0x61, 0x21, 0x91, 0xCF,
  0xCF, 0x80, 0x0F, 0x9F, 0x9C, 0x0C, 0x0C, 0x06, 0x03, 0x08, 0xFC, 0x3E,
  0x00, 0x01, 0x80, 0xC0, 0x60, 0x21, 0xF3, 0xF9, 0x8D, 0x86, 0x86, 0x43,
  0x23, 0x9F, 0xC7, 0x60, 0x1F, 0x1F, 0x9C, 0x68, 0x6F, 0xF7, 0xE3, 0x08,
  0xFC, 0x3C, 0x00, 0x01, 0xE0, 0x7C, 0x08, 0x03, 0x01, 0xFC, 0x3F, 0x81,
  0x00, 0x20, 0x0C, 0x01, 0x80, 0x20, 0x04, 0x01, 0x80, 0x30, 0x3C, 0x07,
  0x00, 0x07, 0xC3, 0xF1, 0x8C, 0xC2, 0x20, 0x88, 0x62, 0x18, 0xFC, 0x1F,
  0x00, 0xC7, 0xE1, 0xF0, 0x10, 0x10, 0x30, 0x30, 0x3E, 0x3F, 0x63, 0x63,
  0x63, 0x43, 0xC2, 0xC2, 0xC6, 0x31, 0xCC, 0x0F, 0x78, 0x84, 0x63, 0x18,
  0xF3, 0x80, 0x01, 0x80, 0x60, 0x18, 0x00, 0x0F, 0x83, 0xE0, 0x10, 0x04,
  0x03, 0x00, 0xC0, 0x20, 0x08, 0x06, 0x01, 0x87, 0xC1, 0xE0, 0x18, 0x0C,
  0x04, 0x02, 0x03, 0x19, 0x98, 0x98, 0x78, 0x70, 0x34, 0x13, 0x08, 0xCC,
  0x20, 0x7F, 0x84, 0x23, 0x10, 0x8C, 0x62, 0x10, 0xF7, 0x80, 0x3B, 0x3F,
  0xDB, 0x69, 0xB4, 0x96, 0x4B, 0x05, 0x06, 0x82, 0x00, 0x3E, 0x3F, 0x23,
  0x21, 0x61, 0x63, 0x43, 0x42, 0xC2, 0x3C, 0x7E, 0xE3, 0xC3, 0x82, 0x86,
  0x8E, 0xFC, 0x78, 0x1F, 0x07, 0xE1, 0x0C, 0xC3, 0x30, 0x88, 0x62, 0x39,
  0xFC, 0x7C, 0x10, 0x04, 0x03, 0x00, 0x1F, 0x7F, 0x62, 0xC2, 0x86, 0x86,
  0x8C, 0xFC, 0x7C, 0x0C, 0x08, 0x08, 0x3F, 0x7F, 0x60, 0x60, 0x40, 0x40,
  0xC0, 0xC0, 0x80, 0x0F, 0x0F, 0x8C, 0x07, 0x01, 0xE0, 0x31, 0x08, 0xFC,
  0x7C, 0x00, 0x30, 0x60, 0x87, 0xFF, 0xEC, 0x10, 0x20, 0xC1, 0x83, 0xE3,
  0xC0, 0x43, 0xC2, 0xC2, 0x86, 0x86, 0x84, 0x8C, 0xFC, 0x74, 0x87, 0x0E,
  0x14, 0x68, 0x9B, 0x3C, 0x70, 0x60, 0xC1, 0xC0, 0xA6, 0x53, 0x6A, 0xA5,
  0x53, 0x39, 0x98, 0x8C, 0x00, 0x18, 0xC6, 0x60, 0x90, 0x38, 0x06, 0x03,
  0x81, 0xB0, 0xCC, 0x61, 0x00, 0x10, 0xC4, 0x31, 0x08, 0x66, 0x19, 0x06,
  0xC0, 0xA0, 0x38, 0x0C, 0x06, 0x0F, 0x03, 0x80, 0x3F, 0x9F, 0x80, 0x81,
  0x81, 0x81, 0x81, 0x81, 0xFC, 0xFE, 0x00, 0x07, 0x87, 0xC2, 0x03, 0x01,
  0x80, 0x80, 0xC1, 0xC0, 0xE0, 0x10, 0x18, 0x0C, 0x04, 0x02, 0x01, 0xE0,
  0xF0, 0x08, 0xC6, 0x21, 0x08, 0xC4, 0x21, 0x18, 0xC4, 0x23, 0x18, 0x0E,
  0x07, 0x80, 0x40, 0x20, 0x30, 0x10, 0x08, 0x07, 0x03, 0x83, 0x01, 0x01,
  0x80, 0x80, 0x43, 0xE1, 0xE0, 0x79, 0xA7, 0x80,
};

const GFXglyph UbuntuMono_Italic19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 5, 12, 10, 3, -12 },
  { 9, 6, 5, 10, 4, -12 },
  { 13, 10, 12, 10, 1, -12 },
  { 28, 9, 15, 10, 1, -13 },
  { 45, 11, 12, 10, 0, -12 },
  { 62, 8, 12, 10, 1, -12 },
  { 74, 2, 5, 10, 6, -13 },
  { 76, 7, 16, 10, 3, -13 },
  { 90, 7, 16, 10, 1, -13 },
  { 104, 7, 7, 10, 3, -12 },
  { 111, 8, 9, 10, 2, -10 },
  { 120, 4, 6, 10, 2, -3 },
  { 123, 5, 1, 10, 3, -5 },
  { 124, 3, 3, 10, 3, -3 },
  { 126, 11, 16, 10, 0, -13 },
  { 148, 8, 12, 10, 2, -12 },
  { 160, 7, 12, 10, 2, -12 },
  { 171, 9, 12, 10, 1, -12 },
  { 185, 9, 12, 10, 1, -12 },
  { 199, 9, 12, 10, 1, -12 },
  { 213, 9, 12, 10, 1, -12 },
  { 227, 8, 12, 10, 2, -12 },
  { 239, 8, 12, 10, 3, -12 },
  { 251, 9, 12, 10, 1, -12 },
  { 265, 9, 12, 10, 1, -12 },
  { 279, 5, 9, 10, 3, -9 },
  { 285, 6, 12, 10, 2, -9 },
  { 294, 9, 7, 10, 1, -8 },
  { 302, 9, 4, 10, 1, -7 },
  { 307, 9, 7, 10, 1, -9 },
  { 315, 7, 12, 10, 3, -12 },
  { 326, 10, 15, 10, 1, -12 },
  { 345, 9, 12, 10, 0, -12 },
  { 359, 9, 12, 10, 1, -12 },
  { 373, 9, 12, 10, 2, -12 },
  { 387, 9, 12, 10, 1, -12 },
  { 401, 10, 12, 10, 1, -12 },
  { 416, 10, 12, 10, 1, -12 },
  { 431, 9, 12, 10, 2, -12 },
  { 445, 10, 12, 10, 1, -12 },
  { 460, 9, 12, 10, 1, -12 },
  { 474, 10, 12, 10, 1, -12 },
  { 489, 10, 12, 10, 1, -12 },
  { 504, 7, 12, 10, 1, -12 },
  { 515, 11, 12, 10, 0, -12 },
  { 532, 10, 12, 10, 1, -12 },
  { 547, 8, 12, 10, 2, -12 },
  { 559, 9, 12, 10, 1, -12 },
  { 573, 8, 15, 10, 2, -12 },
  { 588, 9, 12, 10, 1, -12 },
  { 602, 9, 12, 10, 1, -12 },
  { 616, 8, 12, 10, 3, -12 },
  { 628, 9, 12, 10, 2, -12 },
  { 642, 9, 12, 10, 3, -12 },
  { 656, 10, 12, 10, 1, -12 },
  { 671, 12, 12, 10, 0, -12 },
  { 689, 9, 12, 10, 3, -12 },
  { 703, 10, 12, 10, 1, -12 },
  { 718, 8, 16, 10, 2, -13 },
  { 734, 3, 16, 10, 4, -13 },
  { 740, 9, 16, 10, 0, -13 },
  { 758, 8, 6, 10, 2, -12 },
  { 764, 9, 1, 10, -1, 2 },
  { 766, 3, 3, 10, 5, -13 },
  { 768, 9, 9, 10, 1, -9 },
  { 779, 9, 13, 10, 1, -13 },
  { 794, 9, 9, 10, 1, -9 },
  { 805, 9, 13, 10, 2, -13 },
  { 820, 9, 9, 10, 1, -9 },
  { 831, 11, 16, 10, 0, -13 },
  { 853, 10, 12, 10, 0, -9 },
  { 868, 8, 13, 10, 1, -13 },
  { 881, 5, 13, 10, 3, -13 },
  { 890, 10, 16, 10, 0, -13 },
  { 910, 9, 13, 10, 1, -13 },
  { 925, 5, 13, 10, 3, -13 },
  { 934, 9, 9, 10, 1, -9 },
  { 945, 8, 9, 10, 1, -9 },
  { 954, 8, 9, 10, 2, -9 },
  { 963, 10, 12, 10, 0, -9 },
  { 978, 8, 12, 10, 2, -9 },
  { 990, 8, 9, 10, 2, -9 },
  { 999, 9, 9, 10, 1, -9 },
  { 1010, 7, 12, 10, 3, -12 },
  { 1021, 8, 9, 10, 2, -9 },
  { 1030, 7, 9, 10, 3, -9 },
  { 1038, 9, 9, 10, 2, -9 },
  { 1049, 10, 9, 10, 0, -9 },
  { 1061, 10, 12, 10, 0, -9 },
  { 1076, 9, 9, 10, 1, -9 },
  { 1087, 9, 16, 10, 2, -13 },
  { 1105, 5, 16, 10, 3, -13 },
  { 1115, 9, 16, 10, 0, -13 },
  { 1133, 9, 2, 10, 1, -7 },
};

const GFXfont UbuntuMono_Italic19pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Italic19pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Italic19pt7bGlyphs,
  0x20, 0x7E, 19
};

#endif // _UBUNTUMONO_ITALIC19PT7B_H_
