#ifndef _UBUNTUMONO_ITALIC58PT7B_H_
#define _UBUNTUMONO_ITALIC58PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Italic.ttf
// Size: 58pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Italic58pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xE0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0xFF, 0x03, 0xF8,
  0x0F, 0xE0, 0x1E, 0x00, 0x3E, 0x0F, 0x3C, 0x1F, 0x3C, 0x1F, 0x7C, 0x1E,
  0x7C, 0x1E, 0x78, 0x1E, 0x78, 0x3E, 0x78, 0x3C, 0x70, 0x3C, 0xF0, 0x3C,
  0xF0, 0x38, 0xE0, 0x38, 0xE0, 0x30, 0xC0, 0x70, 0x00, 0x00, 0xF0, 0x3E,
  0x00, 0x03, 0xE0, 0x78, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x1F, 0x03, 0xE0,
  0x00, 0x3C, 0x07, 0x80, 0x00, 0x78, 0x1F, 0x00, 0x01, 0xF0, 0x3C, 0x00,
  0x03, 0xC0, 0x78, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x1E, 0x03, 0xC0, 0x1F,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0x01, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x78,
  0x0F, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x07, 0x81,
  0xF0, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0xF8, 0x1E,
  0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFF, 0x80, 0x7C, 0x0F, 0x00, 0x00, 0xF0, 0x3E, 0x00,
  0x03, 0xE0, 0x78, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x1F, 0x03, 0xC0, 0x00,
  0x3C, 0x07, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x03,
  0xC0, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF8, 0x03, 0xF8, 0x0F, 0x00, 0xFC, 0x00, 0x40, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x04, 0x00, 0x1F, 0x81, 0xF0,
  0x0F, 0xE0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x07, 0xF8, 0x00,
  0x78, 0x01, 0xFF, 0x00, 0x1E, 0x00, 0x7F, 0xF0, 0x07, 0x80, 0x1F, 0x1E,
  0x01, 0xE0, 0x03, 0xC3, 0xC0, 0x78, 0x00, 0x70, 0x78, 0x1F, 0x00, 0x1E,
  0x0F, 0x07, 0xC0, 0x03, 0xC1, 0xE0, 0xF0, 0x00, 0x70, 0x3C, 0x3C, 0x00,
  0x0E, 0x07, 0x0F, 0x00, 0x01, 0xC1, 0xE3, 0xC0, 0x00, 0x3C, 0x3C, 0xF0,
  0x00, 0x07, 0x8F, 0x3E, 0x00, 0x00, 0xFF, 0xE7, 0x80, 0x00, 0x1F, 0xF9,
  0xE0, 0x00, 0x01, 0xFE, 0x78, 0x00, 0x00, 0x1F, 0x1E, 0x00, 0x00, 0x00,
  0x07, 0x8F, 0x80, 0x00, 0x01, 0xE7, 0xF8, 0x00, 0x00, 0x7D, 0xFF, 0x80,
  0x00, 0x0F, 0x3F, 0xF0, 0x00, 0x03, 0xCF, 0x9E, 0x00, 0x00, 0xF1, 0xE1,
  0xE0, 0x00, 0x3C, 0x78, 0x3C, 0x00, 0x0F, 0x0F, 0x07, 0x80, 0x03, 0xE1,
  0xC0, 0xE0, 0x00, 0xF8, 0x38, 0x1C, 0x00, 0x1E, 0x0F, 0x07, 0x80, 0x07,
  0x81, 0xE0, 0xF0, 0x01, 0xE0, 0x3C, 0x3C, 0x00, 0x78, 0x07, 0xCF, 0x80,
  0x1E, 0x00, 0x7F, 0xE0, 0x07, 0xC0, 0x0F, 0xFC, 0x00, 0xF0, 0x00, 0xFF,
  0x00, 0x3C, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x07, 0xC3, 0xF0, 0x07, 0xC0,
  0xF8, 0x03, 0xC0, 0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x1E, 0x00, 0xF0,
  0x0F, 0x00, 0x78, 0x0F, 0x80, 0x3C, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x0F,
  0x8F, 0x80, 0x03, 0xDF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x03, 0xC0, 0xFF, 0x81, 0xE0, 0xFF, 0xE0, 0xF0, 0xF9, 0xF0, 0xF0,
  0xF8, 0x7C, 0x78, 0xF8, 0x3F, 0x7C, 0x78, 0x0F, 0xBC, 0x7C, 0x03, 0xFE,
  0x3E, 0x01, 0xFE, 0x1E, 0x00, 0x7F, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x0F,
  0x87, 0xC0, 0x0F, 0xC3, 0xF0, 0x0F, 0xF0, 0xFC, 0x1F, 0xF8, 0x7F, 0xFF,
  0xBE, 0x1F, 0xFF, 0x9F, 0x07, 0xFF, 0x0F, 0x80, 0xFC, 0x07, 0xC0, 0x1F,
  0x1F, 0x3E, 0x3E, 0x3E, 0x3E, 0x3C, 0x7C, 0x7C, 0x78, 0x78, 0x78, 0x70,
  0x70, 0xF0, 0x00, 0x00, 0x08, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x7C,
  0x00, 0x01, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x01, 0x81, 0xE0,
  0x27, 0x87, 0x87, 0x9F, 0x8E, 0x7F, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0x80, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x3C,
  0xF0, 0x01, 0xF3, 0xE0, 0x0F, 0xC7, 0xC0, 0x7E, 0x1F, 0x81, 0xF0, 0x3E,
  0x01, 0xC0, 0xF0, 0x02, 0x01, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xE0, 0x3F, 0x83, 0xFC, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x1F, 0xE0,
  0x7E, 0x01, 0xF0, 0x1F, 0x01, 0xF8, 0x3F, 0x8F, 0xF8, 0x7F, 0x83, 0xF0,
  0x1C, 0x00, 0x7F, 0xFD, 0xFF, 0xF7, 0xFF, 0xDF, 0xFE, 0xFF, 0xF8, 0x3E,
  0x3F, 0xBF, 0xDF, 0xFF, 0xFF, 0xF9, 0xF8, 0x78, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF,
  0x80, 0x1F, 0xFF, 0xE0, 0x1F, 0xC3, 0xF0, 0x1F, 0x80, 0x7C, 0x0F, 0x80,
  0x3E, 0x0F, 0x80, 0x1F, 0x0F, 0xC0, 0x0F, 0x87, 0xC0, 0x07, 0xC7, 0xC0,
  0x01, 0xE3, 0xE0, 0x01, 0xF3, 0xE0, 0x00, 0xF9, 0xF0, 0x00, 0x7C, 0xF8,
  0x78, 0x3E, 0xF8, 0x7E, 0x1F, 0x7C, 0x3F, 0x0F, 0xBE, 0x3F, 0x87, 0xDF,
  0x1F, 0xC7, 0xDF, 0x0F, 0xE3, 0xEF, 0x83, 0xE1, 0xF7, 0xC0, 0xE0, 0xFB,
  0xE0, 0x00, 0xF9, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x3E,
  0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x1F,
  0x83, 0xF0, 0x1F, 0x80, 0xFC, 0x3F, 0x80, 0x7F, 0xFF, 0x80, 0x1F, 0xFF,
  0x80, 0x07, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x80, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0xC0, 0x1F, 0xFF, 0x00, 0xFF, 0x7C, 0x03, 0xF9, 0xE0, 0x0F, 0x8F, 0x80,
  0x30, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE,
  0x01, 0xF8, 0x1F, 0xC0, 0x38, 0x03, 0xF0, 0x08, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0x80,
  0xFC, 0x00, 0x40, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x08, 0x00, 0x3F, 0x81, 0xE0, 0x1F, 0xE0, 0x7F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0x7C, 0x00, 0x07, 0xCF, 0x80, 0x01, 0xF1, 0xE0, 0x00, 0x7C, 0x7C, 0x00,
  0x1F, 0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x01, 0xF0, 0x3C, 0x00, 0x7C, 0x07,
  0x80, 0x1F, 0x01, 0xF0, 0x03, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0x80, 0x3E,
  0x00, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xE0, 0x07, 0xC0, 0x7C, 0x00, 0xF0,
  0x1F, 0x00, 0x1E, 0x03, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xE0, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x80, 0x03, 0xF0, 0x0F, 0x00, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE3, 0xF8, 0x00,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0xF0, 0x0F,
  0xC3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x8F, 0x80,
  0x03, 0xE3, 0xC0, 0x00, 0xF8, 0xF0, 0x00, 0x3E, 0x3C, 0x00, 0x0F, 0x0F,
  0x00, 0x07, 0xC3, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x7E,
  0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x3F, 0xC0, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFF, 0x80,
  0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0xFC, 0x01,
  0xF0, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x07, 0xC0, 0x07, 0xC1, 0xE0,
  0x01, 0xF0, 0x78, 0x00, 0x7C, 0x1E, 0x00, 0x1E, 0x07, 0xC0, 0x0F, 0x81,
  0xF0, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x0F, 0xE3, 0xF0, 0x01, 0xFF, 0xF8,
  0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xBF, 0xE0, 0x1F, 0x81,
  0xF8, 0x0F, 0xC0, 0x3F, 0x07, 0xC0, 0x07, 0xE1, 0xF0, 0x00, 0xF8, 0xF8,
  0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x8F, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0xF8,
  0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x3F, 0x0F, 0x80, 0x1F, 0x83, 0xF8, 0x1F,
  0xE0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x0F, 0x80, 0xF8,
  0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0x7C,
  0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x1F, 0x00,
  0x07, 0xC3, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x0F, 0xC0, 0x07, 0xC0,
  0xFC, 0x07, 0xF8, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF8, 0x00, 0xFF, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x1F, 0x81, 0xFE, 0x0F, 0xF0, 0x7F,
  0x83, 0xFC, 0x1F, 0xC0, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x07, 0xF0, 0x7F, 0x83, 0xFE, 0x1F, 0xF0, 0xFF, 0x03, 0xF0, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x1F, 0x80, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xFC, 0x01, 0xFC, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x3F,
  0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xFC, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3F, 0x00, 0x7F, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x7E, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x03, 0xFF,
  0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x80, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x80, 0x02, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x01, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x3F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x70, 0x3F, 0x82, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0x80, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x7F,
  0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x01, 0xF8, 0x01, 0xF0, 0x3F, 0x00, 0x0F,
  0x03, 0xE0, 0x00, 0xF0, 0x7C, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0xF0, 0xF8,
  0x00, 0x0F, 0x1F, 0x00, 0x3F, 0xF1, 0xF0, 0x1F, 0xFF, 0x1E, 0x07, 0xFF,
  0xF3, 0xE0, 0xFF, 0xFE, 0x3C, 0x1F, 0xC1, 0xE7, 0xC1, 0xF0, 0x3E, 0x7C,
  0x3E, 0x03, 0xE7, 0xC3, 0xC0, 0x3C, 0x78, 0x7C, 0x03, 0xC7, 0x87, 0xC0,
  0x7C, 0xF8, 0x78, 0x07, 0xCF, 0x87, 0x80, 0x78, 0xF8, 0x78, 0x0F, 0x8F,
  0x87, 0x80, 0xF8, 0xF0, 0x78, 0x0F, 0x0F, 0x07, 0xC0, 0xF0, 0xF0, 0x7E,
  0x1F, 0x0F, 0x83, 0xFF, 0xF0, 0xF8, 0x1F, 0xFE, 0x0F, 0x80, 0xFF, 0xE0,
  0xF8, 0x03, 0xF8, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x04, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xBC, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x1F, 0x3E, 0x00, 0x01,
  0xE3, 0xE0, 0x00, 0x3E, 0x3E, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x7C, 0x3E,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0xF8, 0x1E, 0x00, 0x1F, 0x01, 0xE0, 0x01,
  0xE0, 0x1E, 0x00, 0x3E, 0x01, 0xE0, 0x03, 0xC0, 0x1E, 0x00, 0x7C, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x01, 0xF0, 0x0F, 0x00, 0x1F, 0x01,
  0xF0, 0x01, 0xF0, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x78, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0,
  0xF0, 0x00, 0x1F, 0x1F, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x1F, 0x3E, 0x00,
  0x01, 0xF7, 0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xE0, 0x1F, 0x00, 0xFE, 0x03, 0xE0, 0x0F, 0xC0, 0xF8, 0x00, 0xF8,
  0x1F, 0x00, 0x0F, 0x03, 0xE0, 0x01, 0xE0, 0x7C, 0x00, 0x7C, 0x1F, 0x00,
  0x0F, 0x83, 0xE0, 0x01, 0xE0, 0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x01,
  0xE0, 0x1F, 0xC0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xF8, 0x0F, 0x80, 0x3F, 0x81, 0xF0, 0x01, 0xF8, 0x3E,
  0x00, 0x1F, 0x07, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x0F,
  0x87, 0xC0, 0x01, 0xF0, 0xF0, 0x00, 0x3E, 0x1E, 0x00, 0x07, 0xC7, 0xC0,
  0x01, 0xF0, 0xF8, 0x00, 0x7E, 0x1E, 0x00, 0x1F, 0x83, 0xC0, 0x1F, 0xE0,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0x01, 0xE0, 0x1F, 0xC0, 0x04, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x10, 0x03, 0xF8, 0x0F, 0x80, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xF0,
  0x3F, 0xC0, 0x1F, 0x00, 0x7E, 0x01, 0xF0, 0x03, 0xE0, 0x1E, 0x00, 0x3F,
  0x01, 0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x03, 0xE0, 0x01, 0xF0, 0x3E,
  0x00, 0x1F, 0x03, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x01,
  0xF0, 0x7C, 0x00, 0x1F, 0x07, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x0F,
  0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x00, 0x03, 0xE1, 0xF0, 0x00,
  0x3E, 0x1F, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x7C, 0x1E, 0x00, 0x07, 0xC3,
  0xE0, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x83, 0xE0, 0x01, 0xF0, 0x3C, 0x00,
  0x3F, 0x07, 0xC0, 0x0F, 0xE0, 0x7C, 0x01, 0xFC, 0x07, 0xC0, 0xFF, 0x80,
  0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xF0, 0x0F, 0xE0, 0x3C, 0x03, 0xF0, 0x01, 0x00, 0xFC, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xE1, 0xF0,
  0x00, 0x7C, 0x3C, 0x00, 0x0F, 0x87, 0x80, 0x01, 0xF0, 0xF0, 0x00, 0x3C,
  0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x0F, 0xC0,
  0x07, 0x80, 0xF8, 0x01, 0xF0, 0x1F, 0x80, 0x3E, 0x01, 0xFC, 0x0F, 0xC0,
  0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x7C, 0x03, 0xE0,
  0x00, 0xF8, 0x07, 0xC0, 0x01, 0xF0, 0x0F, 0x00, 0x03, 0xC0, 0x3E, 0x00,
  0x0F, 0x80, 0x7C, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x3E, 0x01, 0xE0, 0x00,
  0x78, 0x07, 0xC0, 0x01, 0xF0, 0x0F, 0x80, 0x03, 0xE0, 0x1F, 0x00, 0x07,
  0xC0, 0x3C, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x7C,
  0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0x80, 0x7C, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x3E, 0x01,
  0xE0, 0x00, 0xF8, 0x07, 0xC0, 0x01, 0xF0, 0x0F, 0x80, 0x03, 0xE0, 0x1F,
  0x00, 0x07, 0xC0, 0x3C, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x3E, 0x01, 0xF0,
  0x00, 0x7C, 0x03, 0xE0, 0x00, 0xF8, 0x07, 0x80, 0x01, 0xE0, 0x1F, 0x00,
  0x07, 0xC0, 0x3E, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x1F, 0x00, 0xF0, 0x00,
  0x3C, 0x03, 0xE0, 0x00, 0xF8, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x00, 0x7F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x02, 0x00, 0x1F, 0x00, 0x70, 0x03, 0xF0,
  0x07, 0xC0, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x7E, 0x01, 0xF0,
  0x01, 0xF8, 0x03, 0xC0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00,
  0x7E, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x78, 0x07, 0xE0, 0x01, 0xF0, 0x1F,
  0x80, 0x03, 0xE0, 0x7E, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x0F, 0x07, 0xE0,
  0x00, 0x3E, 0x1F, 0x80, 0x00, 0x7C, 0x7E, 0x00, 0x00, 0xF9, 0xF8, 0x00,
  0x01, 0xF7, 0xE0, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7B, 0xF0, 0x00, 0x01,
  0xF3, 0xF0, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x0F,
  0x03, 0xE0, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0xF8,
  0x07, 0xC0, 0x01, 0xE0, 0x0F, 0x80, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0xF8, 0x00,
  0x3E, 0x01, 0xF0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0xFC, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFC, 0x01,
  0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x1D, 0xC0, 0x7F, 0x80, 0x3B, 0x80, 0xEE, 0x00, 0xF7, 0x03, 0xDC,
  0x01, 0xEE, 0x07, 0x78, 0x03, 0x9C, 0x1E, 0xF0, 0x0F, 0x3C, 0x79, 0xE0,
  0x1E, 0x78, 0xE3, 0xC0, 0x3C, 0xF3, 0xC7, 0x00, 0xF1, 0xE7, 0x1E, 0x01,
  0xE3, 0xDE, 0x3C, 0x03, 0xC7, 0xB8, 0x78, 0x0F, 0x07, 0xF0, 0xF0, 0x1E,
  0x0F, 0xC1, 0xE0, 0x3C, 0x1F, 0x07, 0x80, 0xF8, 0x3E, 0x0F, 0x01, 0xE0,
  0x78, 0x1E, 0x03, 0xC0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0xF8, 0x1F, 0x00,
  0x01, 0xF0, 0x3C, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x07, 0x81, 0xF0, 0x00,
  0x0F, 0x03, 0xE0, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x7C, 0x0F, 0x00, 0x00,
  0xF0, 0x3E, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x0F,
  0x83, 0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00,
  0x1E, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0xFC, 0x00, 0x1E, 0x00, 0xFE, 0x00,
  0x3E, 0x00, 0xFE, 0x00, 0x3E, 0x00, 0xFE, 0x00, 0x3C, 0x01, 0xFF, 0x00,
  0x3C, 0x01, 0xEF, 0x00, 0x7C, 0x01, 0xEF, 0x00, 0x7C, 0x01, 0xEF, 0x00,
  0x78, 0x03, 0xE7, 0x80, 0x78, 0x03, 0xC7, 0x80, 0xF8, 0x03, 0xC7, 0x80,
  0xF8, 0x03, 0xC7, 0xC0, 0xF0, 0x07, 0xC3, 0xC0, 0xF0, 0x07, 0xC3, 0xC0,
  0xF0, 0x07, 0x83, 0xC1, 0xF0, 0x07, 0x83, 0xC1, 0xE0, 0x07, 0x81, 0xE1,
  0xE0, 0x0F, 0x81, 0xE1, 0xE0, 0x0F, 0x01, 0xE3, 0xE0, 0x0F, 0x01, 0xE3,
  0xC0, 0x0F, 0x00, 0xF3, 0xC0, 0x1F, 0x00, 0xF3, 0xC0, 0x1E, 0x00, 0xF7,
  0xC0, 0x1E, 0x00, 0xF7, 0x80, 0x1E, 0x00, 0x77, 0x80, 0x3E, 0x00, 0x77,
  0x80, 0x3C, 0x00, 0x7F, 0x80, 0x3C, 0x00, 0x7F, 0x80, 0x3C, 0x00, 0x7F,
  0x00, 0x7C, 0x00, 0x7F, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x78, 0x00, 0x3F,
  0x00, 0x78, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x01, 0xFC,
  0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x7E, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x0F,
  0x80, 0x07, 0xC3, 0xE0, 0x01, 0xF1, 0xF0, 0x00, 0x3C, 0x78, 0x00, 0x0F,
  0x3E, 0x00, 0x03, 0xCF, 0x80, 0x01, 0xF7, 0xC0, 0x00, 0x7D, 0xF0, 0x00,
  0x1F, 0x7C, 0x00, 0x07, 0xDE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7B, 0xE0,
  0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x03, 0xEF, 0x80, 0x01, 0xF3,
  0xC0, 0x00, 0x7C, 0xF0, 0x00, 0x1E, 0x3C, 0x00, 0x0F, 0x8F, 0x80, 0x03,
  0xE3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x7E, 0x0F, 0xC0,
  0x3F, 0x01, 0xF8, 0x3F, 0x80, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x00,
  0xFF, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0xF0, 0x0F, 0xE0,
  0x1F, 0x00, 0x3F, 0x01, 0xF0, 0x01, 0xF0, 0x1F, 0x00, 0x1F, 0x01, 0xF0,
  0x00, 0xF0, 0x3E, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0xF0, 0x3E, 0x00, 0x1F,
  0x03, 0xE0, 0x01, 0xF0, 0x3C, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE0, 0x7C,
  0x00, 0x3E, 0x07, 0xC0, 0x07, 0xC0, 0x78, 0x01, 0xF8, 0x0F, 0x80, 0x7F,
  0x80, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0x80, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x03, 0xFF,
  0xFC, 0x01, 0xFC, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x7E, 0x00, 0x7C, 0x1F,
  0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC3, 0xE0, 0x01, 0xF1, 0xF0, 0x00, 0x3C,
  0x78, 0x00, 0x0F, 0x3E, 0x00, 0x03, 0xCF, 0x80, 0x01, 0xF7, 0xC0, 0x00,
  0x7D, 0xF0, 0x00, 0x1F, 0x7C, 0x00, 0x07, 0xDE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7B, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x03, 0xEF,
  0x80, 0x01, 0xF3, 0xC0, 0x00, 0x7C, 0xF0, 0x00, 0x1F, 0x3C, 0x00, 0x0F,
  0x8F, 0x80, 0x03, 0xE3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x3E, 0x00,
  0x7E, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x3F, 0x80, 0x7F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x01, 0xF0, 0x0F, 0xE0,
  0x1F, 0x00, 0x7E, 0x01, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0x1F, 0x03, 0xE0,
  0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x03, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x1E,
  0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x07, 0xC0, 0x78,
  0x00, 0xFC, 0x0F, 0x80, 0x1F, 0x80, 0xF8, 0x0F, 0xF0, 0x0F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x1F,
  0x03, 0xE0, 0x01, 0xE0, 0x3E, 0x00, 0x3E, 0x01, 0xF0, 0x03, 0xE0, 0x1F,
  0x00, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x80, 0x7C, 0x00, 0xF8, 0x07,
  0xC0, 0x07, 0x80, 0x7C, 0x00, 0x7C, 0x07, 0x80, 0x07, 0xC0, 0xF8, 0x00,
  0x7C, 0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x3E, 0x0F, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xE0, 0x0F, 0xF0, 0x1E, 0x00, 0x7E, 0x00, 0x10, 0x07, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x80, 0x01, 0xF8, 0x0F, 0x80, 0x7F, 0x80, 0x7F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x7C, 0x00, 0x1F, 0x07,
  0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x07, 0x80, 0x01, 0xE0, 0xF8, 0x00,
  0x3E, 0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x3E, 0x0F, 0x00, 0x03, 0xC1,
  0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x7C, 0x1E, 0x00,
  0x07, 0x83, 0xE0, 0x00, 0xF8, 0x3E, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0xF8,
  0x3C, 0x00, 0x0F, 0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x07, 0xC0,
  0x01, 0xF0, 0x78, 0x00, 0x1E, 0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x3E,
  0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0xC0, 0xF0,
  0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x80, 0xF8, 0x00, 0xF8, 0x0F, 0x80, 0x1F,
  0x80, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0x7F, 0xFF, 0xE0, 0x03,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xF8, 0x00,
  0x03, 0xEF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x7C,
  0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0xF8, 0xF8, 0x00, 0x1F, 0x0F, 0x80,
  0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x7C,
  0x0F, 0x80, 0x07, 0xC0, 0xF8, 0x00, 0xF8, 0x0F, 0x80, 0x0F, 0x80, 0xF8,
  0x01, 0xF0, 0x07, 0x80, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x07, 0x80, 0x3E,
  0x00, 0x78, 0x07, 0xC0, 0x07, 0x80, 0x78, 0x00, 0x78, 0x0F, 0x80, 0x07,
  0xC0, 0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x7C, 0x3E,
  0x00, 0x07, 0xC3, 0xC0, 0x00, 0x7C, 0x7C, 0x00, 0x07, 0xCF, 0x80, 0x00,
  0x7C, 0xF0, 0x00, 0x03, 0xDF, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x1E,
  0x03, 0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x3E,
  0x07, 0xC0, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x7C,
  0x07, 0x80, 0x00, 0x78, 0x07, 0x80, 0x00, 0x78, 0x0F, 0x80, 0x00, 0xF8,
  0x0F, 0x80, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0xF0,
  0x0F, 0x07, 0xC1, 0xF0, 0x1F, 0x07, 0xC1, 0xE0, 0x1E, 0x0F, 0xC1, 0xE0,
  0x1E, 0x0F, 0xC1, 0xE0, 0x1E, 0x1F, 0xC3, 0xC0, 0x1E, 0x3D, 0xC3, 0xC0,
  0x1E, 0x3D, 0xC3, 0xC0, 0x3C, 0x79, 0xC7, 0x80, 0x3C, 0x71, 0xC7, 0x80,
  0x3C, 0xF1, 0xC7, 0x80, 0x3C, 0xE1, 0xE7, 0x00, 0x39, 0xE1, 0xEF, 0x00,
  0x3B, 0xC1, 0xEF, 0x00, 0x7B, 0xC1, 0xEE, 0x00, 0x7F, 0x80, 0xEE, 0x00,
  0x7F, 0x80, 0xFE, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x0F, 0x80, 0x03,
  0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x1F, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0x3E,
  0x07, 0xE0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x00,
  0x7C, 0x7C, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x03, 0xF3, 0xC0, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00, 0x7E,
  0x3E, 0x00, 0x00, 0x3F, 0x07, 0x80, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x0F,
  0xC0, 0x7C, 0x00, 0x03, 0xE0, 0x0F, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x00,
  0xFC, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x07, 0xC0,
  0x0F, 0x80, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x1F,
  0x00, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x3F, 0x7C,
  0x00, 0x07, 0xCF, 0x80, 0x01, 0xF1, 0xF0, 0x00, 0x7E, 0x1E, 0x00, 0x0F,
  0x83, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0xFC, 0x0F, 0x80, 0x1F, 0x00, 0xF0,
  0x07, 0xC0, 0x1E, 0x01, 0xF0, 0x03, 0xE0, 0x3E, 0x00, 0x7C, 0x0F, 0x80,
  0x07, 0x83, 0xE0, 0x00, 0xF8, 0x78, 0x00, 0x1F, 0x1F, 0x00, 0x01, 0xE7,
  0xC0, 0x00, 0x3D, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xF8, 0x7C, 0x3E,
  0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x1E, 0x0F, 0x07, 0xC3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0x78,
  0x3C, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F,
  0x87, 0xC1, 0xE0, 0xF0, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x07, 0x83, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x03,
  0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x3E, 0xF0, 0x00,
  0x7C, 0xF0, 0x00, 0xF8, 0xF8, 0x01, 0xF8, 0x78, 0x03, 0xF0, 0x78, 0x03,
  0xE0, 0x7C, 0x07, 0xC0, 0x3C, 0x0F, 0x80, 0x3C, 0x1F, 0x00, 0x3E, 0x3F,
  0x00, 0x1E, 0x7E, 0x00, 0x1E, 0x7C, 0x00, 0x1F, 0x78, 0x00, 0x0E, 0x10,
  0x00, 0x08, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xE0, 0x10, 0x0E, 0x07, 0xC1, 0xF0, 0x3E, 0x07, 0xC1,
  0xF8, 0x3E, 0x07, 0xC0, 0xE0, 0x10, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF,
  0xF0, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x03, 0xFE, 0x0F, 0x81, 0xFC,
  0x03, 0xE0, 0xFE, 0x00, 0xF0, 0x3E, 0x00, 0x3C, 0x1F, 0x00, 0x1F, 0x0F,
  0xC0, 0x07, 0xC3, 0xE0, 0x01, 0xF1, 0xF8, 0x00, 0x78, 0x7C, 0x00, 0x3E,
  0x1F, 0x00, 0x0F, 0x87, 0x80, 0x03, 0xE3, 0xE0, 0x00, 0xF0, 0xF8, 0x00,
  0x3C, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC3, 0xE0, 0x01, 0xE0, 0xF8,
  0x00, 0x78, 0x3E, 0x00, 0x1E, 0x0F, 0xC0, 0x0F, 0x81, 0xF0, 0x07, 0xE0,
  0x7F, 0x07, 0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xF9,
  0xF0, 0x07, 0xF8, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x7F, 0x00, 0x1E, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x07, 0xF0, 0x3F, 0x03, 0xE0,
  0x0F, 0xC1, 0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x78,
  0x00, 0x7C, 0x3C, 0x00, 0x1E, 0x3E, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x8F,
  0x80, 0x07, 0xC7, 0x80, 0x03, 0xE3, 0xC0, 0x01, 0xF3, 0xE0, 0x01, 0xF1,
  0xF0, 0x00, 0xF8, 0xF0, 0x00, 0xFC, 0x78, 0x00, 0x7C, 0x7C, 0x00, 0x7E,
  0x3E, 0x00, 0x7E, 0x1E, 0x00, 0x7E, 0x0F, 0x00, 0xFE, 0x0F, 0x81, 0xFE,
  0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8,
  0x07, 0xFF, 0xFE, 0x03, 0xFC, 0x03, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x20, 0x3F, 0x80, 0x78, 0x07,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0xFC,
  0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x03,
  0xFC, 0x1F, 0x80, 0x3F, 0x80, 0x78, 0x03, 0xF0, 0x07, 0xC0, 0x3F, 0x00,
  0x3E, 0x03, 0xF0, 0x01, 0xF0, 0x1F, 0x00, 0x0F, 0x01, 0xF8, 0x00, 0xF8,
  0x0F, 0x80, 0x07, 0xC0, 0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xE0, 0x3E,
  0x00, 0x0F, 0x01, 0xF0, 0x00, 0xF8, 0x0F, 0x80, 0x07, 0xC0, 0x78, 0x00,
  0x3C, 0x03, 0xC0, 0x01, 0xE0, 0x1E, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0xF8,
  0x07, 0xC0, 0x07, 0xC0, 0x3E, 0x00, 0x3E, 0x01, 0xF8, 0x07, 0xF0, 0x07,
  0xE0, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFD, 0xE0, 0x03, 0xFF,
  0x8F, 0x00, 0x07, 0xF0, 0x78, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xFE,
  0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x3F, 0x81, 0xF8, 0x3F, 0x00,
  0x7C, 0x3F, 0x00, 0x3E, 0x3F, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x9F, 0x00,
  0x07, 0xCF, 0x80, 0x07, 0xEF, 0x80, 0x07, 0xE7, 0xC0, 0x07, 0xF3, 0xE0,
  0x3F, 0xF3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFC, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x10, 0x3F, 0x80, 0x78,
  0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0x81, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF,
  0xFE, 0x00, 0x3F, 0xC0, 0xF8, 0x01, 0xFC, 0x03, 0xE0, 0x0F, 0xC0, 0x0F,
  0x80, 0x7E, 0x00, 0x3C, 0x01, 0xF0, 0x01, 0xF0, 0x0F, 0x80, 0x07, 0xC0,
  0x3E, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x78, 0x07, 0xC0, 0x03, 0xE0, 0x1E,
  0x00, 0x0F, 0x80, 0xF8, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0xF0, 0x0F, 0x80,
  0x07, 0xC0, 0x3E, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x7C, 0x03, 0xE0, 0x01,
  0xE0, 0x0F, 0x80, 0x07, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x07, 0xF8,
  0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x07, 0xF1, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x20, 0x01,
  0xF8, 0x01, 0xF0, 0x1F, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07,
  0xE0, 0x7F, 0x03, 0xE0, 0x0F, 0x81, 0xE0, 0x07, 0xC0, 0xF0, 0x01, 0xF0,
  0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x1E,
  0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x07, 0xC3, 0xC0, 0x03,
  0xC3, 0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x78, 0x00,
  0x7C, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x0F, 0x00,
  0x0F, 0x8F, 0x80, 0x07, 0x87, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE1, 0xE0,
  0x01, 0xF0, 0x00, 0x3C, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFF, 0xF0, 0x3F, 0xF8, 0x0F, 0xF8, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x02, 0x00, 0x7E, 0x00, 0x78,
  0x0F, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x7E, 0x03, 0xC0, 0x0F, 0xC0, 0x3C, 0x01,
  0xF8, 0x07, 0xC0, 0x7F, 0x00, 0x7C, 0x0F, 0xE0, 0x07, 0x81, 0xFC, 0x00,
  0x78, 0x7F, 0x00, 0x0F, 0x8F, 0xE0, 0x00, 0xFB, 0xFC, 0x00, 0x0F, 0x7F,
  0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xFC, 0x00, 0x01, 0xE7, 0xE0, 0x00, 0x3E, 0x3F, 0x00, 0x03, 0xE1,
  0xF0, 0x00, 0x3E, 0x1F, 0x80, 0x03, 0xC0, 0xFC, 0x00, 0x7C, 0x07, 0xE0,
  0x07, 0xC0, 0x3E, 0x00, 0x7C, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xF8,
  0x00, 0xF8, 0x0F, 0x80, 0x0F, 0x80, 0xF8, 0x00, 0x7C, 0x0F, 0x80, 0x07,
  0xC0, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xF8, 0xFF, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3E,
  0x02, 0x3F, 0x06, 0x3F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFE, 0x07, 0xF8, 0x00,
  0x7F, 0x0F, 0xC0, 0x3F, 0xFB, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0x07, 0xC3, 0xF1, 0xF0, 0x78, 0x3E, 0x0F, 0x07, 0x83, 0xE0, 0xF0,
  0x78, 0x3C, 0x0F, 0x0F, 0x83, 0xC1, 0xF0, 0xF0, 0x3C, 0x1F, 0x0F, 0x07,
  0xC1, 0xE0, 0xF0, 0x7C, 0x1E, 0x1F, 0x07, 0x81, 0xE1, 0xF0, 0x78, 0x3E,
  0x1E, 0x0F, 0x83, 0xC1, 0xE0, 0xF8, 0x3C, 0x3E, 0x0F, 0x03, 0xC3, 0xE0,
  0x00, 0x7C, 0x3C, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x78, 0x3C, 0x00, 0x07,
  0x87, 0xC0, 0x00, 0xF8, 0x78, 0x00, 0x0F, 0x87, 0x80, 0x00, 0xF0, 0x78,
  0x00, 0x0F, 0x0F, 0x80, 0x01, 0xF0, 0xF0, 0x00, 0x1F, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xC0, 0x7C, 0x07, 0xF0, 0x3E, 0x00, 0xF8, 0x1E, 0x00, 0x7E, 0x1F,
  0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x07, 0xC3, 0xC0, 0x03, 0xC1,
  0xE0, 0x01, 0xE1, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x7C,
  0x3C, 0x00, 0x3C, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x0F,
  0x87, 0x80, 0x07, 0x87, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE1, 0xF0, 0x01,
  0xF0, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x78, 0x7C, 0x00, 0x7C, 0x3E, 0x00,
  0x3E, 0x1F, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xF8, 0x01,
  0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xF0, 0x7E, 0x0F, 0xC0, 0x3F, 0x1F,
  0x80, 0x1F, 0x1F, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x7C,
  0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF0,
  0x00, 0x3E, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0xF8, 0xF8,
  0x01, 0xF8, 0xFC, 0x03, 0xF0, 0x7E, 0x0F, 0xE0, 0x7F, 0xFF, 0xC0, 0x3F,
  0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0xF8,
  0x0F, 0xE0, 0x0F, 0x00, 0x3F, 0x01, 0xF0, 0x01, 0xF0, 0x1F, 0x00, 0x1F,
  0x01, 0xF0, 0x01, 0xF0, 0x1F, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0xF0, 0x3E,
  0x00, 0x1F, 0x03, 0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x03, 0xC0, 0x01,
  0xF0, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x07,
  0x80, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0xC0, 0xF8, 0x01,
  0xF8, 0x0F, 0x80, 0x3F, 0x01, 0xF0, 0x07, 0xE0, 0x1F, 0x03, 0xFE, 0x01,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFE,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x03, 0xFC,
  0x0F, 0x81, 0xF8, 0x03, 0xE0, 0xFC, 0x01, 0xF0, 0x7E, 0x00, 0x7C, 0x3F,
  0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC7, 0xE0, 0x03, 0xE1, 0xF0, 0x00, 0xF8,
  0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0xC3, 0xE0, 0x01,
  0xF0, 0xF8, 0x00, 0x7C, 0x3C, 0x00, 0x1F, 0x0F, 0x00, 0x07, 0x83, 0xC0,
  0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x03,
  0xF0, 0x0F, 0xC0, 0x7E, 0x0F, 0xF0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0x80, 0x07, 0xF3, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xE0, 0x3F, 0x00, 0x30, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xFF, 0x00,
  0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xF0, 0x0C, 0x07, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF0, 0x40, 0x01, 0xF0, 0x78, 0x07, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x38, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x30,
  0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0x80, 0x0F,
  0x80, 0x0F, 0x87, 0x80, 0x07, 0xC7, 0xC0, 0x03, 0xC3, 0xE0, 0x03, 0xE1,
  0xF0, 0x01, 0xF0, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x78, 0x7C, 0x00, 0x7C,
  0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x0F, 0x80, 0x0F,
  0x87, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE1, 0xE0, 0x01, 0xF1, 0xF0, 0x01,
  0xF0, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x1F, 0x00,
  0x1E, 0x0F, 0x80, 0x0F, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x0F, 0xC1, 0xFC,
  0x1F, 0xE0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0x3E, 0x00,
  0xFE, 0x0E, 0x00, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7B, 0xE0, 0x01, 0xF7,
  0xC0, 0x03, 0xEF, 0x80, 0x0F, 0x9F, 0x00, 0x1F, 0x3E, 0x00, 0x3C, 0x7C,
  0x00, 0xF8, 0xF8, 0x01, 0xE1, 0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0x03, 0xC0,
  0x3E, 0x07, 0x80, 0x78, 0x0F, 0x81, 0xF0, 0x1F, 0x07, 0xC0, 0x3E, 0x0F,
  0x80, 0x7C, 0x3E, 0x00, 0xF8, 0x78, 0x01, 0xF1, 0xF0, 0x01, 0xE7, 0xC0,
  0x03, 0xEF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF1, 0xE0, 0x00, 0x07, 0x9F, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x03, 0xC7,
  0xC0, 0x00, 0x1E, 0x3C, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x0F, 0x0F, 0x01,
  0xC0, 0x78, 0x78, 0x1E, 0x07, 0xC3, 0xC0, 0xF8, 0x3C, 0x1E, 0x0F, 0xC1,
  0xE1, 0xF0, 0x7E, 0x1E, 0x0F, 0x87, 0xF0, 0xF0, 0x78, 0x7F, 0x87, 0x83,
  0xC3, 0xFC, 0x78, 0x1E, 0x3D, 0xE3, 0xC0, 0xF1, 0xC7, 0x3C, 0x07, 0x9E,
  0x39, 0xE0, 0x3D, 0xE1, 0xCF, 0x01, 0xEE, 0x0E, 0xF0, 0x0F, 0xF0, 0x7F,
  0x80, 0x7F, 0x03, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0x80, 0xFC, 0x00,
  0xF8, 0x07, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x7C, 0x03, 0xE0, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x1F,
  0x00, 0xF8, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x03, 0xE0,
  0xF8, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x7E,
  0x1F, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0xFC, 0x03,
  0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x3F, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x7E,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3C, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0xF0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x1E, 0x03,
  0xE0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1F, 0x07,
  0xC0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x0F, 0x9F,
  0x00, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x07, 0xBC,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x40, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFF,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0,
  0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF8,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x03,
  0x03, 0xFE, 0x00, 0xF1, 0xFF, 0xE0, 0x78, 0xFF, 0xFC, 0x3E, 0x3C, 0x3F,
  0xFF, 0x1E, 0x03, 0xFF, 0x87, 0x00, 0x7F, 0xC0, 0xC0, 0x07, 0xC0,
};

const GFXglyph UbuntuMono_Italic58pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 29, 0, -1 },
  { 1, 14, 36, 29, 10, -36 },
  { 64, 16, 14, 29, 13, -39 },
  { 92, 31, 36, 29, 2, -36 },
  { 232, 27, 46, 29, 4, -40 },
  { 388, 35, 36, 29, 0, -36 },
  { 546, 25, 36, 29, 3, -36 },
  { 659, 8, 15, 29, 17, -39 },
  { 674, 22, 51, 29, 8, -41 },
  { 815, 22, 51, 29, 3, -41 },
  { 956, 22, 21, 29, 8, -36 },
  { 1014, 24, 26, 29, 5, -28 },
  { 1092, 13, 16, 29, 6, -8 },
  { 1118, 14, 5, 29, 10, -17 },
  { 1127, 9, 8, 29, 10, -8 },
  { 1136, 33, 51, 29, -1, -41 },
  { 1347, 25, 36, 29, 5, -36 },
  { 1460, 22, 36, 29, 5, -36 },
  { 1559, 26, 36, 29, 4, -36 },
  { 1676, 27, 36, 29, 3, -36 },
  { 1798, 27, 36, 29, 3, -36 },
  { 1920, 29, 36, 29, 3, -36 },
  { 2051, 26, 36, 29, 6, -36 },
  { 2168, 26, 36, 29, 8, -36 },
  { 2285, 26, 36, 29, 5, -36 },
  { 2402, 27, 36, 29, 4, -36 },
  { 2524, 13, 27, 29, 10, -27 },
  { 2568, 17, 35, 29, 6, -27 },
  { 2643, 25, 23, 29, 5, -26 },
  { 2715, 27, 15, 29, 4, -23 },
  { 2766, 26, 23, 29, 3, -27 },
  { 2841, 21, 36, 29, 9, -36 },
  { 2936, 28, 44, 29, 4, -36 },
  { 3090, 28, 36, 29, -1, -36 },
  { 3216, 27, 36, 29, 3, -36 },
  { 3338, 28, 36, 29, 5, -36 },
  { 3464, 28, 36, 29, 2, -36 },
  { 3590, 29, 36, 29, 4, -36 },
  { 3721, 29, 36, 29, 4, -36 },
  { 3852, 27, 36, 29, 5, -36 },
  { 3974, 31, 36, 29, 2, -36 },
  { 4114, 27, 36, 29, 4, -36 },
  { 4236, 28, 36, 29, 4, -36 },
  { 4362, 31, 36, 29, 3, -36 },
  { 4502, 21, 36, 29, 3, -36 },
  { 4597, 31, 36, 29, 1, -36 },
  { 4737, 32, 36, 29, 2, -36 },
  { 4881, 26, 36, 29, 5, -36 },
  { 4998, 28, 36, 29, 3, -36 },
  { 5124, 26, 46, 29, 5, -36 },
  { 5274, 28, 36, 29, 3, -36 },
  { 5400, 29, 36, 29, 3, -36 },
  { 5531, 25, 36, 29, 9, -36 },
  { 5644, 28, 36, 29, 5, -36 },
  { 5770, 28, 36, 29, 8, -36 },
  { 5896, 32, 36, 29, 3, -36 },
  { 6040, 34, 36, 29, 1, -36 },
  { 6193, 27, 36, 29, 9, -36 },
  { 6315, 31, 36, 29, 2, -36 },
  { 6455, 26, 51, 29, 6, -41 },
  { 6621, 9, 51, 29, 13, -41 },
  { 6679, 26, 51, 29, 1, -41 },
  { 6845, 24, 19, 29, 6, -36 },
  { 6902, 27, 4, 29, -2, 6 },
  { 6916, 10, 11, 29, 15, -41 },
  { 6930, 26, 29, 29, 4, -28 },
  { 7025, 25, 41, 29, 4, -40 },
  { 7154, 26, 29, 29, 4, -28 },
  { 7249, 29, 41, 29, 5, -40 },
  { 7398, 25, 29, 29, 4, -28 },
  { 7489, 34, 50, 29, 1, -40 },
  { 7702, 30, 38, 29, 1, -28 },
  { 7845, 25, 40, 29, 3, -40 },
  { 7970, 17, 39, 29, 8, -39 },
  { 8053, 28, 49, 29, 1, -39 },
  { 8225, 28, 40, 29, 4, -40 },
  { 8365, 16, 41, 29, 10, -40 },
  { 8447, 28, 28, 29, 2, -28 },
  { 8545, 25, 28, 29, 4, -28 },
  { 8633, 24, 29, 29, 5, -28 },
  { 8720, 28, 38, 29, 1, -28 },
  { 8853, 26, 38, 29, 5, -28 },
  { 8977, 25, 28, 29, 5, -28 },
  { 9065, 24, 29, 29, 5, -28 },
  { 9152, 22, 36, 29, 8, -35 },
  { 9251, 25, 28, 29, 5, -27 },
  { 9339, 23, 27, 29, 8, -27 },
  { 9417, 29, 27, 29, 5, -27 },
  { 9515, 30, 27, 29, 1, -27 },
  { 9617, 32, 37, 29, -1, -27 },
  { 9765, 27, 27, 29, 3, -27 },
  { 9857, 28, 51, 29, 5, -41 },
  { 10036, 16, 51, 29, 9, -41 },
  { 10138, 28, 51, 29, 0, -41 },
  { 10317, 26, 8, 29, 4, -19 },
};

const GFXfont UbuntuMono_Italic58pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Italic58pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Italic58pt7bGlyphs,
  0x20, 0x7E, 58
};

#endif // _UBUNTUMONO_ITALIC58PT7B_H_
