#ifndef _UBUNTUMONO_ITALIC61PT7B_H_
#define _UBUNTUMONO_ITALIC61PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Italic.ttf
// Size: 61pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Italic61pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0,
  0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x3F, 0x80, 0xFE, 0x03, 0xFC,
  0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x01, 0xE0, 0x00, 0x1F, 0x07, 0xC7, 0x81,
  0xE1, 0xE0, 0x78, 0xF8, 0x3E, 0x3E, 0x0F, 0x8F, 0x03, 0xC3, 0xC0, 0xF1,
  0xF0, 0x3C, 0x78, 0x1F, 0x1E, 0x07, 0x87, 0x81, 0xE1, 0xC0, 0x78, 0x70,
  0x1C, 0x1C, 0x07, 0x06, 0x01, 0x80, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00,
  0x7C, 0x0F, 0x80, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0x3E, 0x03, 0xC0, 0x00,
  0x1E, 0x03, 0xE0, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0x07, 0x80, 0xF0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x03, 0xC0, 0x7C, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0x7C, 0x0F, 0x80,
  0x00, 0x3C, 0x07, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x1E, 0x03, 0xE0,
  0x00, 0x1F, 0x01, 0xE0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x0F, 0x80, 0xF0,
  0x00, 0x07, 0xC0, 0xF8, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x3F, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFE, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x3C, 0x07,
  0xC0, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x1F, 0x01,
  0xE0, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x07, 0xC0,
  0xF8, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xC0, 0x78, 0x01,
  0xF8, 0x00, 0x40, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x60, 0x00, 0xFC, 0x03, 0xC0, 0x1F, 0xE0, 0x3F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0x80, 0x1F,
  0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xE0, 0x0F, 0x80, 0x0F, 0x9F, 0x00, 0x78,
  0x00, 0xF8, 0x78, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x78, 0x00, 0x3C, 0x1E,
  0x07, 0xC0, 0x03, 0xC0, 0xF0, 0x7C, 0x00, 0x1E, 0x07, 0x87, 0xC0, 0x00,
  0xF0, 0x38, 0x3C, 0x00, 0x07, 0x83, 0xC3, 0xC0, 0x00, 0x3C, 0x1E, 0x3C,
  0x00, 0x01, 0xE1, 0xF3, 0xC0, 0x00, 0x0F, 0x9F, 0x3E, 0x00, 0x00, 0x7F,
  0xF3, 0xE0, 0x00, 0x01, 0xFF, 0xBE, 0x00, 0x00, 0x07, 0xF9, 0xE0, 0x00,
  0x00, 0x1F, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0x00, 0x1F,
  0x3F, 0xC0, 0x00, 0x01, 0xF3, 0xFE, 0x00, 0x00, 0x1F, 0x3F, 0xF8, 0x00,
  0x00, 0xF3, 0xE3, 0xC0, 0x00, 0x0F, 0x1E, 0x1E, 0x00, 0x00, 0xF1, 0xE0,
  0xF0, 0x00, 0x0F, 0x0F, 0x07, 0x80, 0x00, 0xF8, 0x70, 0x3C, 0x00, 0x0F,
  0x83, 0x81, 0xE0, 0x00, 0xF8, 0x3C, 0x0F, 0x00, 0x07, 0x81, 0xE0, 0xF0,
  0x00, 0x78, 0x0F, 0x07, 0x80, 0x07, 0x80, 0x78, 0x7C, 0x00, 0x7C, 0x03,
  0xE3, 0xC0, 0x07, 0xC0, 0x0F, 0xFE, 0x00, 0x7C, 0x00, 0x7F, 0xE0, 0x03,
  0xC0, 0x01, 0xFE, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x07,
  0xE1, 0xF8, 0x00, 0xF8, 0x1F, 0x00, 0x3E, 0x01, 0xE0, 0x07, 0xC0, 0x3C,
  0x00, 0xF0, 0x0F, 0x80, 0x1E, 0x01, 0xF0, 0x07, 0xC0, 0x7C, 0x00, 0xF8,
  0x0F, 0x80, 0x0F, 0x03, 0xE0, 0x01, 0xE0, 0xF8, 0x00, 0x3E, 0x3E, 0x00,
  0x07, 0xDF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x07, 0x80, 0xFF, 0x81, 0xF0, 0x7F, 0xF0, 0x3C, 0x1F, 0x9F, 0x07, 0x87,
  0xE3, 0xF1, 0xF0, 0xF8, 0x3E, 0x3C, 0x3E, 0x03, 0xEF, 0x8F, 0x80, 0x7F,
  0xE1, 0xF0, 0x07, 0xFC, 0x3E, 0x00, 0x7F, 0x07, 0xC0, 0x0F, 0xE1, 0xF8,
  0x00, 0xF8, 0x3F, 0x00, 0x3F, 0x03, 0xE0, 0x0F, 0xF0, 0x7C, 0x03, 0xFE,
  0x0F, 0xE1, 0xFF, 0xE0, 0xFF, 0xFF, 0x7C, 0x1F, 0xFF, 0xCF, 0x81, 0xFF,
  0xE1, 0xF8, 0x0F, 0xE0, 0x1F, 0x00, 0x1F, 0x1F, 0x1F, 0x3E, 0x3E, 0x3E,
  0x3E, 0x7C, 0x7C, 0x7C, 0x78, 0x78, 0x78, 0x70, 0xF0, 0xF0, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x38, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xC0, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x20, 0x3C, 0x04, 0x3C, 0x3C,
  0x1E, 0x7F, 0x3C, 0x7E, 0x7F, 0xDD, 0xFE, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFE, 0x01, 0xFF, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xF7,
  0x80, 0x03, 0xE7, 0xC0, 0x07, 0xE3, 0xE0, 0x0F, 0xC3, 0xF0, 0x0F, 0xC1,
  0xF8, 0x0F, 0x81, 0xF0, 0x07, 0x80, 0xE0, 0x01, 0x00, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x01, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF8, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xF0, 0x0F, 0xE0, 0x7F, 0x81, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0x80,
  0xFE, 0x00, 0xF8, 0x07, 0xC0, 0x3F, 0x07, 0xF8, 0xFF, 0xC1, 0xFC, 0x07,
  0xC0, 0x1C, 0x00, 0x7F, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xF8,
  0x3E, 0x3F, 0xBF, 0xDF, 0xFF, 0xFF, 0xFB, 0xF8, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xC0, 0x0F, 0xE0, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0xFC, 0x01,
  0xF0, 0x1F, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x3E,
  0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF1, 0xF0, 0x00, 0x3E, 0x3E, 0x00, 0x07,
  0xCF, 0xC0, 0x00, 0xF9, 0xF0, 0x78, 0x1F, 0x3E, 0x1F, 0x87, 0xEF, 0xC7,
  0xF0, 0xF9, 0xF0, 0xFE, 0x1F, 0x3E, 0x1F, 0xC3, 0xE7, 0xC3, 0xF8, 0x7C,
  0xF8, 0x7E, 0x1F, 0x3F, 0x07, 0x83, 0xE7, 0xC0, 0x00, 0x7C, 0xF8, 0x00,
  0x1F, 0x1F, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x0F,
  0x80, 0x07, 0xE1, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x3E, 0x03, 0xE0, 0x0F,
  0xC0, 0x7C, 0x03, 0xF0, 0x0F, 0xC1, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xFD, 0xF0, 0x1F,
  0xC7, 0xC0, 0x3C, 0x3E, 0x00, 0x80, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x0F, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x01, 0xFC, 0x0F,
  0xE0, 0x0F, 0x00, 0x3E, 0x00, 0xE0, 0x03, 0xF0, 0x04, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0x80,
  0xFE, 0x00, 0x80, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x60, 0x00, 0xFE, 0x0F,
  0x00, 0x7F, 0x83, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x03, 0xE7,
  0xC0, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF0, 0x78, 0x00,
  0x3E, 0x0F, 0x80, 0x07, 0xC0, 0xF8, 0x00, 0xF8, 0x0F, 0x80, 0x1F, 0x80,
  0xF0, 0x01, 0xF0, 0x1F, 0x00, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0xF8, 0x01, 0xE0, 0x0F, 0x00, 0x3E, 0x01, 0xF0, 0x03, 0xE0, 0x3E, 0x00,
  0x3E, 0x03, 0xC0, 0x03, 0xE0, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x20, 0x00,
  0xFE, 0x00, 0x78, 0x07, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x1F, 0xC0, 0x03, 0xEF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xE0, 0x7F, 0x80, 0xFE, 0x07, 0xC0, 0x03, 0xF0, 0x7C, 0x00, 0x1F, 0x0F,
  0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00,
  0x1F, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0,
  0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x7E, 0x0F, 0xC0,
  0x0F, 0xC0, 0x7C, 0x01, 0xF8, 0x07, 0xF0, 0x7F, 0x80, 0x3F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x07,
  0xFF, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0x80, 0x3E, 0x03, 0xF0, 0x03,
  0xF0, 0x3E, 0x00, 0x1F, 0x03, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x07,
  0xC0, 0x03, 0xF0, 0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0, 0x7E, 0x00,
  0x7C, 0x03, 0xE0, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x01, 0xFC, 0x7F, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xE7,
  0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x00, 0x7E, 0x03, 0xE0, 0x03, 0xF0,
  0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80,
  0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x3E,
  0x0F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0x7F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80,
  0x0F, 0xFF, 0xFC, 0x01, 0xFC, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x07, 0xE0,
  0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x0F, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x1F,
  0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x1F, 0x00, 0x01, 0xF1, 0xF0,
  0x00, 0x3F, 0x1F, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x3E, 0x1F, 0x80, 0x03,
  0xE0, 0xF8, 0x00, 0x7E, 0x0F, 0xE0, 0x3F, 0xE0, 0x7F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0x8F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x3F, 0xC1, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFC,
  0x1F, 0xC0, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x3F, 0x83, 0xFC, 0x1F, 0xF0, 0xFF, 0x87, 0xF8, 0x3F, 0x80, 0xF8, 0x00,
  0x00, 0x0F, 0x00, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x1F, 0xF0, 0x03, 0xF8, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F,
  0x80, 0x0F, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x7F, 0x80,
  0xFF, 0xC0, 0x1F, 0xC0, 0x07, 0xC0, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x80,
  0x07, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xC0, 0x0F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x00, 0x02,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x03,
  0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x01,
  0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x1F,
  0xFF, 0x80, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x0F, 0x01, 0xF8, 0x10, 0x03,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0x81, 0xF8,
  0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x07, 0xC0, 0x7E, 0x00, 0x1F, 0x03,
  0xF0, 0x00, 0x7C, 0x0F, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0xC1, 0xF0,
  0x00, 0x1F, 0x0F, 0x80, 0x1F, 0xFC, 0x3E, 0x03, 0xFF, 0xF1, 0xF0, 0x1F,
  0xFF, 0x87, 0xC1, 0xFF, 0xFE, 0x3E, 0x0F, 0xE0, 0xF8, 0xF8, 0x3E, 0x03,
  0xE3, 0xE1, 0xF0, 0x0F, 0x1F, 0x07, 0xC0, 0x7C, 0x7C, 0x3E, 0x01, 0xF1,
  0xF0, 0xF8, 0x07, 0xC7, 0xC3, 0xC0, 0x1E, 0x1E, 0x0F, 0x00, 0xF8, 0xF8,
  0x7C, 0x03, 0xE3, 0xE1, 0xF0, 0x0F, 0x8F, 0x87, 0xC0, 0x3C, 0x3E, 0x1F,
  0x01, 0xF0, 0xF8, 0x3C, 0x07, 0xC3, 0xE0, 0xF8, 0x1F, 0x0F, 0x83, 0xF0,
  0x78, 0x3E, 0x07, 0xFF, 0xE0, 0xF8, 0x0F, 0xFF, 0x81, 0xE0, 0x1F, 0xFE,
  0x07, 0xC0, 0x1F, 0xC0, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x07, 0xDF,
  0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0xF1, 0xF0, 0x00, 0x07, 0xC7, 0xC0,
  0x00, 0x1E, 0x1F, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x1F, 0x03, 0xC0, 0x00, 0xF8, 0x0F, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x1F,
  0x00, 0xF8, 0x00, 0x7C, 0x03, 0xE0, 0x03, 0xE0, 0x0F, 0x80, 0x0F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xE0, 0x0F, 0x80, 0x0F,
  0x80, 0x3C, 0x00, 0x3E, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x07, 0xC0, 0x00, 0xF8, 0x1E,
  0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x3E, 0x1F, 0x00,
  0x00, 0xF8, 0xF8, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x0F, 0x9F, 0x00, 0x00,
  0x3F, 0x7C, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0,
  0x1F, 0x80, 0x7F, 0x00, 0xF8, 0x00, 0xFC, 0x07, 0xC0, 0x07, 0xE0, 0x3E,
  0x00, 0x1F, 0x03, 0xF0, 0x00, 0xF8, 0x1F, 0x00, 0x07, 0xC0, 0xF8, 0x00,
  0x3E, 0x07, 0xC0, 0x03, 0xE0, 0x3E, 0x00, 0x1F, 0x03, 0xE0, 0x01, 0xF0,
  0x1F, 0x00, 0x1F, 0x80, 0xF8, 0x07, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0xF8, 0x03,
  0xF8, 0x07, 0x80, 0x07, 0xE0, 0x7C, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0xFC,
  0x1F, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0xF8, 0x7C,
  0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xE1, 0xF0, 0x00,
  0x3E, 0x0F, 0x80, 0x03, 0xF0, 0x7C, 0x00, 0x7F, 0x03, 0xE0, 0x0F, 0xF0,
  0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0x80, 0xF8, 0x03, 0xF8,
  0x00, 0x40, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x04, 0x00, 0x7F, 0x00, 0xF0, 0x01, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xF8, 0x1F, 0xE0, 0x03, 0xE0, 0x0F,
  0xC0, 0x0F, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0xF8,
  0x07, 0xC0, 0x03, 0xF0, 0x1F, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x1F, 0x03,
  0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0xC1, 0xF0,
  0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF0, 0x7C, 0x00,
  0x0F, 0xC3, 0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x03,
  0xE0, 0xF8, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF0,
  0x7C, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF8, 0x3E,
  0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x7E, 0x03, 0xE0, 0x03, 0xF8, 0x0F, 0x80,
  0x1F, 0xC0, 0x7C, 0x01, 0xFE, 0x01, 0xF0, 0x1F, 0xF0, 0x07, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0,
  0x07, 0xF0, 0x1F, 0x00, 0xFE, 0x00, 0x10, 0x07, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x0F, 0x80, 0x00,
  0xF8, 0x7C, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x03, 0xE0,
  0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC1, 0xF0,
  0x00, 0x7C, 0x0F, 0x80, 0x03, 0xE0, 0x7E, 0x00, 0x1F, 0x01, 0xF0, 0x00,
  0xF8, 0x0F, 0xC0, 0x0F, 0x80, 0x7F, 0x00, 0x7C, 0x01, 0xFE, 0x07, 0xE0,
  0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x07, 0xC0,
  0x1F, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x01, 0xF0,
  0x07, 0xC0, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x7C,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x7E, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x03,
  0xE0, 0x0F, 0x80, 0x01, 0xF0, 0x07, 0xC0, 0x01, 0xF8, 0x07, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x3E, 0x00,
  0x07, 0xC0, 0x1F, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x03, 0xE0, 0x0F, 0x80,
  0x01, 0xF0, 0x07, 0xC0, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x7C, 0x03, 0xE0,
  0x00, 0x7C, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x7C, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x07, 0xC0, 0x1F,
  0x00, 0x03, 0xE0, 0x0F, 0x80, 0x01, 0xF0, 0x07, 0xC0, 0x01, 0xF0, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x08, 0x00, 0x3F, 0x00, 0x38, 0x01,
  0xF8, 0x01, 0xF8, 0x1F, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x3F, 0x00, 0x7C, 0x00, 0x3F, 0x80, 0x3E, 0x00, 0x3F, 0x80, 0x1F, 0x00,
  0x3F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x07, 0xC0,
  0x1F, 0x80, 0x03, 0xE0, 0x1F, 0x80, 0x01, 0xF0, 0x1F, 0x80, 0x00, 0xF8,
  0x1F, 0x80, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x3E,
  0x1F, 0x80, 0x00, 0x1F, 0x3F, 0x80, 0x00, 0x1F, 0x3F, 0x80, 0x00, 0x0F,
  0xBF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x00,
  0x7C, 0xFC, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x3E, 0x1F, 0x80, 0x00,
  0x1F, 0x07, 0xE0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x0F, 0xC0, 0x7C, 0x00,
  0x07, 0xC0, 0x3F, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x01, 0xF0, 0x07, 0xE0,
  0x00, 0xF8, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x1F, 0x80, 0x1F, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x03,
  0xF0, 0x0F, 0x80, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x80,
  0x00, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x07,
  0xE0, 0x03, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x03,
  0xF8, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x7F, 0x80,
  0xEF, 0x00, 0x3B, 0xC0, 0xF7, 0x80, 0x3C, 0xE0, 0x73, 0xC0, 0x1E, 0x70,
  0x79, 0xE0, 0x0F, 0x38, 0x39, 0xE0, 0x0F, 0x1E, 0x3C, 0xF0, 0x07, 0x8F,
  0x1C, 0x78, 0x03, 0xC7, 0x9E, 0x3C, 0x03, 0xE3, 0xDE, 0x3E, 0x01, 0xE1,
  0xEF, 0x1F, 0x00, 0xF0, 0xFF, 0x0F, 0x00, 0xF8, 0x7F, 0x07, 0x80, 0x7C,
  0x3F, 0x83, 0xC0, 0x3C, 0x1F, 0x83, 0xE0, 0x3E, 0x07, 0xC1, 0xF0, 0x1F,
  0x03, 0xC0, 0xF0, 0x0F, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x3C, 0x07,
  0xC0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x0F, 0x81,
  0xF0, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x03, 0xE0,
  0x3C, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x78,
  0x0F, 0x80, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7E, 0x00, 0x07, 0x80, 0x3F, 0x00, 0x07, 0xC0, 0x1F, 0x80,
  0x03, 0xE0, 0x0F, 0xE0, 0x01, 0xE0, 0x0F, 0xF0, 0x00, 0xF0, 0x07, 0xF8,
  0x00, 0xF8, 0x03, 0xFC, 0x00, 0x7C, 0x01, 0xFF, 0x00, 0x3E, 0x01, 0xF7,
  0x80, 0x1E, 0x00, 0xFB, 0xC0, 0x0F, 0x00, 0x79, 0xF0, 0x0F, 0x80, 0x3C,
  0xF8, 0x07, 0xC0, 0x1E, 0x3C, 0x03, 0xC0, 0x1F, 0x1E, 0x01, 0xE0, 0x0F,
  0x8F, 0x81, 0xF0, 0x07, 0x83, 0xC0, 0xF8, 0x03, 0xC1, 0xE0, 0x78, 0x03,
  0xE0, 0xF0, 0x3C, 0x01, 0xF0, 0x7C, 0x3E, 0x00, 0xF0, 0x1E, 0x1F, 0x00,
  0x78, 0x0F, 0x0F, 0x00, 0x7C, 0x07, 0x87, 0x80, 0x3E, 0x03, 0xC7, 0xC0,
  0x1E, 0x00, 0xF3, 0xE0, 0x0F, 0x00, 0x79, 0xE0, 0x0F, 0x80, 0x3C, 0xF0,
  0x07, 0xC0, 0x1E, 0x78, 0x03, 0xE0, 0x0F, 0x7C, 0x01, 0xE0, 0x03, 0xBE,
  0x01, 0xF0, 0x01, 0xFE, 0x00, 0xF8, 0x00, 0xFF, 0x00, 0x7C, 0x00, 0x7F,
  0x80, 0x3C, 0x00, 0x3F, 0xC0, 0x1E, 0x00, 0x1F, 0xC0, 0x1F, 0x00, 0x07,
  0xE0, 0x0F, 0x80, 0x03, 0xF0, 0x07, 0x80, 0x01, 0xF8, 0x03, 0xC0, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0x80, 0x07, 0xFF, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0x80, 0x7E, 0x03,
  0xF0, 0x03, 0xE0, 0x7E, 0x00, 0x3F, 0x07, 0xC0, 0x01, 0xF0, 0xF8, 0x00,
  0x1F, 0x0F, 0x80, 0x01, 0xF1, 0xF0, 0x00, 0x1F, 0x1F, 0x00, 0x01, 0xF3,
  0xE0, 0x00, 0x1F, 0x3E, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x1F, 0x7C, 0x00,
  0x01, 0xF7, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3E,
  0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7C, 0xF8, 0x00, 0x07, 0xCF, 0x80,
  0x00, 0x7C, 0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0xF8, 0xF8, 0x00, 0x0F,
  0x8F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x3F, 0x0F, 0x80, 0x03, 0xE0, 0xF8,
  0x00, 0x7C, 0x07, 0xC0, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xF0, 0x7F,
  0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xF8, 0x07, 0xF8, 0x03, 0xE0,
  0x07, 0xE0, 0x0F, 0x80, 0x0F, 0xC0, 0x3E, 0x00, 0x1F, 0x01, 0xF0, 0x00,
  0x7C, 0x07, 0xC0, 0x01, 0xF0, 0x1F, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x1F,
  0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x03, 0xE0, 0x3E, 0x00, 0x0F, 0x80,
  0xF8, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF0, 0x1F, 0x00, 0x0F, 0xC0, 0x7C,
  0x00, 0xFE, 0x01, 0xF0, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0x80, 0x07, 0xFF, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0x80, 0x7E, 0x03,
  0xF0, 0x03, 0xE0, 0x7E, 0x00, 0x3F, 0x07, 0xC0, 0x01, 0xF0, 0xF8, 0x00,
  0x1F, 0x0F, 0x80, 0x01, 0xF1, 0xF0, 0x00, 0x1F, 0x1F, 0x00, 0x01, 0xF3,
  0xE0, 0x00, 0x1F, 0x3E, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x1F, 0x7C, 0x00,
  0x01, 0xF7, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3E,
  0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7E, 0xF8, 0x00, 0x07, 0xCF, 0x80,
  0x00, 0x7C, 0xF8, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0xF8, 0xF8, 0x00, 0x0F,
  0x8F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x3F, 0x0F, 0x80, 0x03, 0xE0, 0xF8,
  0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xF0, 0x7F,
  0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0x80, 0x7F, 0x00, 0xF8, 0x00, 0xFC,
  0x07, 0xC0, 0x07, 0xE0, 0x3E, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0xF8, 0x0F,
  0x80, 0x07, 0xC0, 0xF8, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF0, 0x3E, 0x00,
  0x0F, 0x81, 0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x7E,
  0x07, 0xC0, 0x07, 0xE0, 0x3E, 0x00, 0x7E, 0x03, 0xE0, 0x1F, 0xE0, 0x1F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0x80, 0x03, 0xE0, 0x3E, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0xF8, 0x07, 0xC0,
  0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F,
  0x00, 0x3E, 0x00, 0xF8, 0x00, 0xF8, 0x0F, 0x80, 0x07, 0xC0, 0x7C, 0x00,
  0x3E, 0x03, 0xE0, 0x01, 0xF0, 0x1F, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3E,
  0x0F, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00,
  0x7F, 0x80, 0xF8, 0x01, 0xF8, 0x00, 0x40, 0x0F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x30, 0x00, 0x3F, 0x00,
  0xF8, 0x07, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x01, 0xF0,
  0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0xF8, 0x1F,
  0x00, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x0F, 0x80,
  0x01, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x00,
  0xF8, 0x1F, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x3E,
  0x0F, 0x80, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x03,
  0xE0, 0x00, 0x7C, 0x1F, 0x80, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0x81, 0xF0,
  0x00, 0x3E, 0x07, 0xC0, 0x00, 0xF8, 0x1F, 0x00, 0x07, 0xC0, 0xF8, 0x00,
  0x1F, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x01, 0xF0, 0x3E, 0x00, 0x0F,
  0x80, 0xF8, 0x00, 0x3E, 0x03, 0xE0, 0x01, 0xF8, 0x0F, 0x80, 0x07, 0xC0,
  0x3F, 0x00, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x03,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x7D, 0xF8, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x3E, 0x7E, 0x00, 0x03,
  0xF3, 0xF0, 0x00, 0x1F, 0x1F, 0x80, 0x01, 0xF8, 0x7C, 0x00, 0x0F, 0x83,
  0xE0, 0x00, 0xFC, 0x1F, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x7E, 0x07, 0xC0,
  0x03, 0xE0, 0x3E, 0x00, 0x3F, 0x01, 0xF0, 0x01, 0xF0, 0x0F, 0x80, 0x1F,
  0x80, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00,
  0xF8, 0x07, 0xC0, 0x07, 0xC0, 0x3E, 0x00, 0x3E, 0x03, 0xE0, 0x01, 0xF0,
  0x1F, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x7C, 0x0F, 0x80, 0x01, 0xE0, 0xF8,
  0x00, 0x0F, 0x07, 0xC0, 0x00, 0x78, 0x7C, 0x00, 0x03, 0xE3, 0xC0, 0x00,
  0x1F, 0x3E, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x01, 0xF0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x07, 0xC0, 0xF8, 0x00,
  0x03, 0xE0, 0x7C, 0x00, 0x01, 0xE0, 0x3E, 0x00, 0x01, 0xF0, 0x1E, 0x00,
  0x00, 0xF8, 0x1F, 0x00, 0x00, 0x78, 0x0F, 0x80, 0x00, 0x3C, 0x07, 0xC0,
  0x00, 0x3E, 0x03, 0xE0, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0xF8, 0x00, 0x07, 0xC0, 0x7C, 0x1F, 0x03, 0xC0, 0x3C,
  0x0F, 0x81, 0xE0, 0x1E, 0x0F, 0xC1, 0xF0, 0x0F, 0x07, 0xE0, 0xF8, 0x0F,
  0x87, 0xF0, 0x78, 0x07, 0xC7, 0xB8, 0x3C, 0x03, 0xC3, 0xDC, 0x3E, 0x01,
  0xE3, 0xCE, 0x1E, 0x00, 0xF1, 0xE7, 0x0F, 0x00, 0x79, 0xE3, 0x87, 0x80,
  0x78, 0xF1, 0xE7, 0x80, 0x3C, 0xF0, 0xF3, 0xC0, 0x1E, 0x70, 0x79, 0xE0,
  0x0F, 0x78, 0x3D, 0xE0, 0x07, 0xB8, 0x1E, 0xF0, 0x03, 0xBC, 0x0F, 0x78,
  0x03, 0xDC, 0x03, 0xB8, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0xF8, 0x03,
  0xF0, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0xFC, 0x00, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x07, 0xE1, 0xF0, 0x00,
  0x00, 0x3E, 0x3E, 0x00, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xF9, 0xE0, 0x00, 0x00, 0x3F,
  0x1F, 0x00, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x00, 0x7E, 0x0F, 0x80, 0x00,
  0x0F, 0xC0, 0xF8, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x7C,
  0x00, 0x03, 0xF0, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x0F, 0xC0,
  0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x03,
  0xF0, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x1F,
  0x00, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0xF8,
  0xF0, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0xC1, 0xF0,
  0x00, 0x7E, 0x0F, 0x80, 0x03, 0xE0, 0x3C, 0x00, 0x3E, 0x01, 0xF0, 0x03,
  0xF0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x01, 0xE0, 0x1F, 0x00,
  0x0F, 0x81, 0xF8, 0x00, 0x7C, 0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x0F,
  0x8F, 0x80, 0x00, 0x7C, 0x7C, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x0F, 0x7C,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xF8, 0x3F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0xF8, 0x3E, 0x0F, 0x83, 0xF0, 0xFC, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7E, 0x0F, 0x83, 0xE0,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3F,
  0x0F, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x1F,
  0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x7E, 0xF8, 0x00, 0xFC,
  0xF8, 0x01, 0xF8, 0x78, 0x03, 0xF0, 0x7C, 0x03, 0xE0, 0x7C, 0x07, 0xC0,
  0x3C, 0x0F, 0xC0, 0x3E, 0x1F, 0x80, 0x3E, 0x3F, 0x00, 0x1E, 0x3E, 0x00,
  0x1F, 0x7C, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x10, 0x00,
  0x0C, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xE0, 0x10, 0x07, 0x01, 0xF0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xC0, 0x78, 0x04, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x1F, 0xF0,
  0x3E, 0x07, 0xF0, 0x0F, 0x81, 0xF8, 0x01, 0xF0, 0x7E, 0x00, 0x3E, 0x1F,
  0x80, 0x07, 0xC3, 0xE0, 0x01, 0xF0, 0xFC, 0x00, 0x3E, 0x1F, 0x00, 0x07,
  0xC3, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0xC3, 0xE0,
  0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x1F, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0xF8,
  0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE1, 0xF8, 0x00, 0x7C, 0x1F, 0x00,
  0x0F, 0x03, 0xE0, 0x03, 0xE0, 0x7E, 0x00, 0xFC, 0x07, 0xE0, 0x7F, 0x80,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xF3, 0xE0, 0x07, 0xF0,
  0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC7,
  0xF0, 0x00, 0xFB, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80,
  0x7F, 0x03, 0xF8, 0x1F, 0x80, 0x3F, 0x03, 0xE0, 0x03, 0xE0, 0x7C, 0x00,
  0x7E, 0x0F, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x0F,
  0x80, 0x03, 0xE1, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x8F, 0x80, 0x03,
  0xE1, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x87, 0x80, 0x03, 0xF1, 0xF0,
  0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x87, 0xC0, 0x03, 0xE0, 0xF0, 0x00, 0xFC,
  0x3E, 0x00, 0x3F, 0x07, 0xC0, 0x0F, 0xC0, 0xF8, 0x07, 0xF0, 0x1F, 0x03,
  0xFC, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xE0, 0x1C, 0x0F, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x04, 0x07, 0xF8, 0x07, 0x80, 0x7F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xC0, 0x0F, 0xF8, 0x1F, 0x00, 0x7F, 0x80, 0x7C, 0x03, 0xF8, 0x01,
  0xF0, 0x0F, 0xC0, 0x0F, 0x80, 0x7E, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0xF8,
  0x0F, 0x80, 0x03, 0xE0, 0x7E, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x7C, 0x07,
  0xC0, 0x01, 0xF0, 0x3F, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x03, 0xE0,
  0x00, 0xF8, 0x0F, 0x80, 0x03, 0xE0, 0x3E, 0x00, 0x0F, 0x80, 0xF8, 0x00,
  0x3E, 0x03, 0xE0, 0x01, 0xF0, 0x0F, 0x80, 0x07, 0xC0, 0x3E, 0x00, 0x1F,
  0x00, 0xFC, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0xC0,
  0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xBC, 0x00, 0x3F, 0xF8, 0xF8, 0x00,
  0x3F, 0x83, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x01,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xC0, 0xFC, 0x0F, 0xE0, 0x0F,
  0xC3, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x1F, 0x80, 0x03, 0xE7, 0xE0,
  0x00, 0xF8, 0xF8, 0x00, 0x1F, 0x1F, 0x00, 0x07, 0xE7, 0xC0, 0x03, 0xF8,
  0xF8, 0x07, 0xFE, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x04, 0x07, 0xF8, 0x07, 0x80, 0x7F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFC, 0x0C, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xF0, 0x01, 0xFE, 0x07, 0xE0, 0x07, 0xF0, 0x0F, 0x80, 0x1F, 0x80,
  0x1F, 0x00, 0x7E, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x7C, 0x03, 0xE0, 0x01,
  0xF0, 0x0F, 0xC0, 0x03, 0xE0, 0x1F, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x0F,
  0x80, 0xF8, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0xF8,
  0x0F, 0x80, 0x01, 0xF0, 0x1F, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x0F, 0x80,
  0x7C, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x78, 0x01,
  0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x1F, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFC, 0x7C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x40, 0x01, 0xF8, 0x01, 0xF0, 0x0F,
  0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7D, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0x80, 0xFC, 0x0F, 0xE0, 0x7C, 0x00, 0xFC, 0x1F, 0x00, 0x3F, 0x07,
  0xC0, 0x07, 0xC1, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x1F,
  0x0F, 0x80, 0x07, 0xC3, 0xE0, 0x03, 0xF1, 0xF0, 0x00, 0xF8, 0x7C, 0x00,
  0x3E, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xE3, 0xE0, 0x01, 0xF0, 0xF8,
  0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC3, 0xE0, 0x03, 0xE1,
  0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x07,
  0xE3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x00, 0x00,
  0x1E, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x1F,
  0xC0, 0x07, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xC3, 0xFF, 0xF0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0xC0, 0xFF,
  0xF0, 0x1F, 0xFC, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x20, 0x03, 0xF0, 0x01, 0xF0, 0x3F, 0x80, 0x07, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x7C, 0x00, 0xFE, 0x03,
  0xE0, 0x0F, 0xE0, 0x1F, 0x00, 0xFC, 0x00, 0xF0, 0x1F, 0xC0, 0x0F, 0x81,
  0xFC, 0x00, 0x7C, 0x3F, 0xC0, 0x03, 0xE3, 0xF8, 0x00, 0x1E, 0x7F, 0x80,
  0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xF7, 0xF0, 0x00, 0x0F, 0x9F,
  0x80, 0x00, 0x7C, 0x7E, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x3E, 0x07, 0xE0,
  0x01, 0xF0, 0x1F, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0xF8, 0x03, 0xF0, 0x07,
  0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7E, 0x01, 0xF0, 0x01, 0xF0, 0x1F, 0x00,
  0x0F, 0xC0, 0xF8, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0xFC,
  0x7F, 0xFC, 0xFF, 0xFC, 0xFF, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF8,
  0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7E, 0x01, 0x7E, 0x07, 0x3F, 0xFF, 0x3F, 0xFF, 0x1F, 0xFF, 0x07, 0xF8,
  0x00, 0x3F, 0x83, 0xE0, 0x0F, 0xFF, 0x3F, 0xC0, 0x3F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFE, 0x03, 0xC3, 0xF8, 0xFC, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07,
  0x81, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1E, 0x07, 0x81, 0xF0, 0x78, 0x1E, 0x07, 0x83, 0xE0, 0x00, 0x3E, 0x0F,
  0x80, 0x00, 0xF8, 0x3C, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x0F, 0x07, 0xC0,
  0x00, 0x3C, 0x1F, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x07, 0xC1, 0xE0, 0x00,
  0x1E, 0x0F, 0x80, 0x00, 0x78, 0x3E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFE, 0x03, 0xE0, 0x3F, 0x81, 0xF0, 0x03, 0xF0, 0x7C, 0x00, 0x7C,
  0x1F, 0x00, 0x1F, 0x07, 0xC0, 0x07, 0xC3, 0xE0, 0x01, 0xF0, 0xF8, 0x00,
  0x7C, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC3, 0xE0, 0x03, 0xE1, 0xF0,
  0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x07, 0xC3,
  0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x07,
  0xC7, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x1F, 0x00,
  0x0F, 0x8F, 0x80, 0x07, 0xC3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF,
  0xFC, 0x07, 0xF8, 0x3F, 0x81, 0xF8, 0x07, 0xE0, 0xFC, 0x00, 0xF8, 0x7E,
  0x00, 0x3F, 0x1F, 0x00, 0x07, 0xCF, 0xC0, 0x01, 0xF3, 0xE0, 0x00, 0x7D,
  0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0xFB, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xEF, 0x80,
  0x01, 0xF3, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x3F, 0x3E, 0x00, 0x0F, 0x8F,
  0x80, 0x07, 0xE3, 0xF0, 0x03, 0xF0, 0x7C, 0x01, 0xF8, 0x1F, 0xC1, 0xFC,
  0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFC, 0x07, 0xF8, 0x03, 0xE0, 0x07,
  0xE0, 0x0F, 0x80, 0x0F, 0x80, 0x3E, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x7C,
  0x07, 0xC0, 0x01, 0xF0, 0x1F, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x1F, 0x03,
  0xF0, 0x00, 0x7C, 0x0F, 0x80, 0x01, 0xF0, 0x3E, 0x00, 0x0F, 0x80, 0xF8,
  0x00, 0x3E, 0x07, 0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x07, 0xE0, 0x7C, 0x00,
  0x1F, 0x01, 0xF0, 0x00, 0x7C, 0x07, 0xC0, 0x03, 0xE0, 0x3E, 0x00, 0x1F,
  0x80, 0xF8, 0x00, 0xFC, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0x80, 0x7F, 0x80,
  0x7E, 0x07, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x1F, 0xE0, 0x7C, 0x0F, 0xF0,
  0x0F, 0x83, 0xF8, 0x01, 0xF0, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0x87,
  0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x3F, 0x00, 0x0F, 0xC7, 0xC0, 0x01,
  0xF0, 0xF8, 0x00, 0x3E, 0x3F, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0xF8, 0xF8,
  0x00, 0x3E, 0x1F, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x1F,
  0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x07, 0xE0,
  0x03, 0xE0, 0x7C, 0x01, 0xF8, 0x0F, 0xE0, 0xFF, 0x00, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xF3, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0x80, 0x08, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x03, 0xF8, 0x0F, 0x00,
  0xF8, 0x00, 0x40, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xF0, 0x20, 0x00, 0xF8, 0x1F, 0x00, 0xFE, 0x07, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xC0, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0xC0, 0x7F,
  0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0x80, 0x07, 0xC3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x1F,
  0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x7C, 0x00,
  0x3E, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC3, 0xE0, 0x01, 0xF0, 0xF8,
  0x00, 0x7C, 0x7E, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xE1,
  0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x7E, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x07,
  0xC3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x0F, 0x80,
  0x0F, 0x83, 0xF0, 0x0F, 0xE0, 0x7E, 0x0F, 0xFC, 0x1F, 0xFF, 0xFF, 0x03,
  0xFF, 0xF7, 0xC0, 0x7F, 0xF9, 0xF0, 0x07, 0xF8, 0x3C, 0x00, 0xF8, 0x00,
  0x1F, 0x7C, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xDF, 0x00, 0x07, 0xCF, 0x80,
  0x03, 0xE7, 0xE0, 0x03, 0xE3, 0xF0, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0x7C,
  0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x7C, 0x07,
  0xC0, 0x3E, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x1F, 0x00,
  0x3E, 0x1F, 0x80, 0x1F, 0x0F, 0x80, 0x0F, 0x8F, 0x80, 0x07, 0xC7, 0xC0,
  0x03, 0xE7, 0xC0, 0x01, 0xF7, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x01, 0xF3, 0xC0, 0x00,
  0x07, 0x8F, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x03,
  0xC7, 0xC0, 0x00, 0x1F, 0x1F, 0x01, 0xC0, 0x7C, 0x7C, 0x0F, 0x81, 0xE1,
  0xE0, 0x3E, 0x0F, 0x87, 0x81, 0xF8, 0x3C, 0x1E, 0x0F, 0xE0, 0xF0, 0x78,
  0x3F, 0x87, 0xC1, 0xE1, 0xFE, 0x1E, 0x0F, 0x87, 0xF8, 0x78, 0x3E, 0x3D,
  0xE3, 0xE0, 0xF9, 0xE7, 0x8F, 0x03, 0xE7, 0x8E, 0x7C, 0x0F, 0xBC, 0x39,
  0xE0, 0x3C, 0xF0, 0xF7, 0x80, 0xF7, 0x83, 0xFC, 0x03, 0xFC, 0x0F, 0xF0,
  0x0F, 0xF0, 0x3F, 0xC0, 0x3F, 0x80, 0xFE, 0x00, 0xFC, 0x03, 0xF8, 0x03,
  0xF0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x00,
  0xF8, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00,
  0x7E, 0x01, 0xF8, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x3F, 0x03, 0xE0, 0x00,
  0x1F, 0x07, 0xC0, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0x0F, 0x9F, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00,
  0x7E, 0x7C, 0x00, 0x00, 0xFC, 0x3E, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x03,
  0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x07, 0xC0, 0x1F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x1F, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x07, 0xC0, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x03, 0xE0,
  0x07, 0xE0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x03, 0xF0,
  0x07, 0xC0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x3E, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x00, 0xF8, 0x7C, 0x00,
  0x00, 0x3E, 0x1F, 0x00, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x01, 0xF7, 0xC0,
  0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x18,
  0x1F, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x01, 0x81, 0xFF, 0x00, 0x78, 0x7F,
  0xF0, 0x0F, 0x1F, 0xFF, 0x03, 0xE7, 0xC3, 0xF0, 0xF8, 0xF0, 0x3F, 0xFE,
  0x3C, 0x03, 0xFF, 0x87, 0x80, 0x1F, 0xE0, 0x20, 0x01, 0xF8, 0x00,
};

const GFXglyph UbuntuMono_Italic61pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 31, 0, -1 },
  { 1, 14, 38, 31, 11, -38 },
  { 68, 18, 15, 31, 13, -41 },
  { 102, 33, 38, 31, 2, -38 },
  { 259, 29, 48, 31, 4, -42 },
  { 433, 37, 38, 31, 0, -38 },
  { 609, 27, 38, 31, 3, -38 },
  { 738, 8, 16, 31, 18, -41 },
  { 754, 23, 53, 31, 9, -43 },
  { 907, 23, 53, 31, 3, -43 },
  { 1060, 24, 22, 31, 8, -38 },
  { 1126, 26, 26, 31, 5, -29 },
  { 1211, 14, 16, 31, 6, -8 },
  { 1239, 14, 5, 31, 11, -18 },
  { 1248, 9, 8, 31, 11, -8 },
  { 1257, 35, 53, 31, -1, -43 },
  { 1489, 27, 38, 31, 5, -38 },
  { 1618, 22, 38, 31, 6, -38 },
  { 1723, 28, 38, 31, 4, -38 },
  { 1856, 27, 38, 31, 4, -38 },
  { 1985, 28, 38, 31, 3, -38 },
  { 2118, 31, 38, 31, 3, -38 },
  { 2266, 28, 38, 31, 6, -38 },
  { 2399, 28, 38, 31, 8, -38 },
  { 2532, 28, 38, 31, 5, -38 },
  { 2665, 28, 38, 31, 5, -38 },
  { 2798, 13, 28, 31, 11, -28 },
  { 2844, 18, 36, 31, 6, -28 },
  { 2925, 27, 24, 31, 5, -28 },
  { 3006, 28, 15, 31, 4, -23 },
  { 3059, 27, 24, 31, 4, -27 },
  { 3140, 22, 38, 31, 10, -38 },
  { 3245, 30, 46, 31, 4, -38 },
  { 3418, 30, 38, 31, -1, -38 },
  { 3561, 29, 38, 31, 3, -38 },
  { 3699, 30, 38, 31, 5, -38 },
  { 3842, 30, 38, 31, 2, -38 },
  { 3985, 31, 38, 31, 4, -38 },
  { 4133, 31, 38, 31, 4, -38 },
  { 4281, 29, 38, 31, 5, -38 },
  { 4419, 33, 38, 31, 2, -38 },
  { 4576, 29, 38, 31, 4, -38 },
  { 4714, 30, 38, 31, 4, -38 },
  { 4857, 33, 38, 31, 3, -38 },
  { 5014, 23, 38, 31, 3, -38 },
  { 5124, 33, 38, 31, 1, -38 },
  { 5281, 33, 38, 31, 2, -38 },
  { 5438, 28, 38, 31, 5, -38 },
  { 5571, 30, 38, 31, 3, -38 },
  { 5714, 28, 48, 31, 5, -38 },
  { 5882, 29, 38, 31, 3, -38 },
  { 6020, 30, 38, 31, 3, -38 },
  { 6163, 27, 38, 31, 9, -38 },
  { 6292, 30, 38, 31, 5, -38 },
  { 6435, 29, 38, 31, 8, -38 },
  { 6573, 33, 38, 31, 4, -38 },
  { 6730, 36, 38, 31, 1, -38 },
  { 6901, 29, 38, 31, 9, -38 },
  { 7039, 33, 38, 31, 2, -38 },
  { 7196, 27, 53, 31, 6, -43 },
  { 7375, 10, 53, 31, 13, -43 },
  { 7442, 27, 53, 31, 2, -43 },
  { 7621, 24, 20, 31, 7, -38 },
  { 7681, 29, 4, 31, -2, 6 },
  { 7696, 11, 11, 31, 16, -42 },
  { 7712, 27, 30, 31, 4, -29 },
  { 7814, 27, 43, 31, 4, -42 },
  { 7960, 27, 30, 31, 4, -29 },
  { 8062, 30, 43, 31, 5, -42 },
  { 8224, 27, 30, 31, 4, -29 },
  { 8326, 35, 52, 31, 1, -42 },
  { 8554, 31, 39, 31, 1, -29 },
  { 8706, 26, 42, 31, 3, -42 },
  { 8843, 18, 40, 31, 8, -40 },
  { 8933, 30, 50, 31, 1, -40 },
  { 9121, 29, 42, 31, 4, -42 },
  { 9274, 16, 43, 31, 11, -42 },
  { 9360, 30, 29, 31, 2, -29 },
  { 9469, 26, 29, 31, 4, -29 },
  { 9564, 26, 30, 31, 5, -29 },
  { 9662, 30, 39, 31, 1, -29 },
  { 9809, 27, 39, 31, 5, -29 },
  { 9941, 27, 29, 31, 5, -29 },
  { 10039, 26, 30, 31, 5, -29 },
  { 10137, 23, 38, 31, 8, -37 },
  { 10247, 26, 29, 31, 5, -28 },
  { 10342, 25, 28, 31, 8, -28 },
  { 10430, 30, 28, 31, 5, -28 },
  { 10535, 32, 28, 31, 1, -28 },
  { 10647, 34, 38, 31, -1, -28 },
  { 10809, 27, 28, 31, 4, -28 },
  { 10904, 30, 53, 31, 5, -43 },
  { 11103, 18, 53, 31, 9, -43 },
  { 11223, 29, 53, 31, 0, -43 },
  { 11416, 27, 9, 31, 5, -21 },
};

const GFXfont UbuntuMono_Italic61pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Italic61pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Italic61pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _UBUNTUMONO_ITALIC61PT7B_H_
