#ifndef _UBUNTUMONO_ITALIC57PT7B_H_
#define _UBUNTUMONO_ITALIC57PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Italic.ttf
// Size: 57pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Italic57pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x7E, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF0,
  0x07, 0x80, 0x00, 0x3C, 0x1F, 0x3C, 0x1E, 0x7C, 0x1E, 0x7C, 0x1E, 0x78,
  0x3E, 0x78, 0x3C, 0x78, 0x3C, 0xF0, 0x3C, 0xF0, 0x38, 0xF0, 0x38, 0xE0,
  0x78, 0xE0, 0x70, 0xE0, 0x70, 0xC0, 0x70, 0x00, 0x01, 0xF0, 0x3C, 0x00,
  0x07, 0x81, 0xF0, 0x00, 0x3E, 0x07, 0x80, 0x00, 0xF0, 0x1E, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x78, 0x1F, 0x00, 0x03, 0xE0,
  0x78, 0x00, 0x0F, 0x03, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xF0, 0x3E, 0x00,
  0x07, 0x80, 0xF0, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0xF8, 0x1E, 0x00, 0x03,
  0xC0, 0xF8, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x78, 0x0F, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x0F, 0x01, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x1E, 0x00,
  0x03, 0xC0, 0xF0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x78, 0x1F, 0x00, 0x03,
  0xE0, 0x78, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x00, 0x01, 0xE0,
  0x7C, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x07, 0xF0, 0x0E, 0x00, 0xF8, 0x00, 0x40,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x04, 0x00,
  0x1F, 0x81, 0xF0, 0x0F, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x03, 0xC0,
  0x0F, 0xE0, 0x01, 0xE0, 0x07, 0xFC, 0x00, 0xF0, 0x03, 0xFF, 0x00, 0x78,
  0x01, 0xF3, 0xC0, 0x3E, 0x00, 0x78, 0x78, 0x0F, 0x00, 0x3C, 0x1E, 0x07,
  0x80, 0x0F, 0x07, 0x83, 0xC0, 0x03, 0x81, 0xC1, 0xE0, 0x00, 0xE0, 0x70,
  0xF0, 0x00, 0x38, 0x3C, 0x78, 0x00, 0x0E, 0x0F, 0x3E, 0x00, 0x03, 0x87,
  0x8F, 0x00, 0x00, 0xF1, 0xE7, 0x80, 0x00, 0x3F, 0xF3, 0xC0, 0x00, 0x0F,
  0xFD, 0xE0, 0x00, 0x01, 0xFE, 0xF0, 0x00, 0x00, 0x3E, 0x78, 0xF8, 0x00,
  0x00, 0x3E, 0xFF, 0x00, 0x00, 0x0F, 0x7F, 0xC0, 0x00, 0x07, 0xBF, 0xF8,
  0x00, 0x03, 0xCF, 0x1E, 0x00, 0x01, 0xE7, 0x87, 0x80, 0x00, 0xF1, 0xE0,
  0xE0, 0x00, 0x78, 0x70, 0x78, 0x00, 0x3E, 0x3C, 0x1E, 0x00, 0x0F, 0x0F,
  0x07, 0x80, 0x07, 0x83, 0xC1, 0xE0, 0x03, 0xC0, 0xF0, 0xF0, 0x01, 0xE0,
  0x3C, 0x3C, 0x00, 0xF0, 0x0F, 0x1E, 0x00, 0x78, 0x03, 0xFF, 0x80, 0x3E,
  0x00, 0x7F, 0xC0, 0x0F, 0x00, 0x1F, 0xE0, 0x07, 0x80, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF,
  0xC0, 0x0F, 0xC3, 0xE0, 0x07, 0xC0, 0xF0, 0x07, 0xC0, 0x78, 0x03, 0xE0,
  0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x1E, 0x00, 0x78, 0x1F, 0x00, 0x3C,
  0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x07, 0xBF, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x07, 0x81, 0xFF, 0x03, 0xC1, 0xFF, 0x83, 0xC1,
  0xF3, 0xE1, 0xE1, 0xF0, 0xF1, 0xF1, 0xF0, 0x7C, 0xF1, 0xF0, 0x1F, 0x78,
  0xF8, 0x0F, 0xF8, 0x78, 0x03, 0xFC, 0x7C, 0x00, 0xFC, 0x3E, 0x00, 0x7E,
  0x1F, 0x00, 0x3F, 0x0F, 0x80, 0x3F, 0x87, 0xE0, 0x3F, 0xC1, 0xF8, 0x7F,
  0xF0, 0xFF, 0xFE, 0xF8, 0x3F, 0xFE, 0x3C, 0x0F, 0xFE, 0x1F, 0x01, 0xF8,
  0x0F, 0x80, 0x1F, 0x3E, 0x3E, 0x3E, 0x3E, 0x7C, 0x7C, 0x7C, 0x78, 0x78,
  0x78, 0xF0, 0xF0, 0xF0, 0xE0, 0x00, 0x00, 0x10, 0x00, 0x00, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x38, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x01, 0x81, 0xE0, 0x47, 0x87, 0x87,
  0x9F, 0x9C, 0x7E, 0xFF, 0xF7, 0xFB, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x00,
  0x7F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x3D, 0xF0, 0x01, 0xF3,
  0xE0, 0x0F, 0x8F, 0xC0, 0x7E, 0x1F, 0x81, 0xF0, 0x7E, 0x03, 0xC0, 0xE0,
  0x02, 0x01, 0x00, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x7F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x7F, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x07, 0xF0, 0x3F, 0x01, 0xF0, 0x3E, 0x07, 0xC1, 0xFC,
  0xFF, 0x8F, 0xE0, 0xFC, 0x0E, 0x00, 0x7F, 0xF9, 0xFF, 0xEF, 0xFF, 0xBF,
  0xFE, 0x3E, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3C, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x1F, 0xC3, 0xF0,
  0x1F, 0x80, 0xF8, 0x1F, 0x80, 0x3E, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x0F,
  0x87, 0xC0, 0x07, 0xC7, 0xC0, 0x03, 0xE3, 0xE0, 0x01, 0xF3, 0xE0, 0x00,
  0xF9, 0xF0, 0xF0, 0x7D, 0xF0, 0xFC, 0x3E, 0xF8, 0xFE, 0x1E, 0x7C, 0x7F,
  0x1F, 0x3C, 0x3F, 0x8F, 0xBE, 0x1F, 0x87, 0xDF, 0x07, 0x83, 0xCF, 0x80,
  0x03, 0xE7, 0xC0, 0x01, 0xF3, 0xE0, 0x00, 0xF1, 0xF0, 0x00, 0xF8, 0xF8,
  0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x7E, 0x1F, 0x00, 0x3E, 0x0F,
  0x80, 0x3E, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x7F, 0x00, 0xFF, 0xFF, 0x00,
  0x3F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0x00,
  0x3F, 0xF8, 0x07, 0xFF, 0x80, 0xFF, 0xBC, 0x03, 0xF3, 0xE0, 0x1E, 0x1F,
  0x00, 0xC0, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x0F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xF3, 0xFF, 0xFF, 0xBF, 0xFF, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFF,
  0x80, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x01, 0xF8, 0x1F, 0x80, 0x70,
  0x03, 0xF0, 0x08, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFE, 0x00, 0x78, 0x1F, 0xC0, 0x18, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x08, 0x00,
  0x3F, 0x03, 0xC0, 0x3F, 0xC1, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0x3C, 0x00, 0x0F, 0x9F, 0x00,
  0x07, 0xC7, 0xC0, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0x78, 0x00, 0xF8, 0x1E,
  0x00, 0x7C, 0x0F, 0x80, 0x3E, 0x03, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0xC0,
  0x3C, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x07, 0xC0, 0x78, 0x01, 0xE0, 0x3E,
  0x00, 0x78, 0x1F, 0x00, 0x3E, 0x07, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x02, 0x00, 0x1F, 0xC0, 0x78, 0x07, 0xF8,
  0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC7, 0xF0,
  0x01, 0xEF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x0F, 0xE0,
  0x3F, 0x07, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x1E,
  0x00, 0x07, 0x87, 0x80, 0x03, 0xE3, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x3E,
  0x3E, 0x00, 0x0F, 0x87, 0x80, 0x07, 0xC1, 0xE0, 0x01, 0xF0, 0x7C, 0x00,
  0xF8, 0x1F, 0x00, 0x7E, 0x03, 0xF0, 0x7F, 0x00, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x0F, 0x80,
  0xF8, 0x00, 0xF8, 0x1F, 0x00, 0x1F, 0x03, 0xC0, 0x03, 0xE0, 0x78, 0x00,
  0x78, 0x0F, 0x00, 0x1F, 0x01, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x00, 0xFE, 0x0F, 0x80, 0x0F, 0xF7, 0xE0, 0x00, 0xFF, 0xF8,
  0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xE1, 0xFE, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x00, 0xFC, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x01, 0xF0,
  0x7C, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0xF8, 0x7C, 0x00,
  0x1F, 0x07, 0xC0, 0x07, 0xC0, 0xF8, 0x01, 0xF8, 0x1F, 0xC0, 0xFE, 0x01,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xC1, 0xF8, 0x07, 0xE0, 0x1F, 0x81, 0xF8,
  0x01, 0xF0, 0x3E, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xC1, 0xF0, 0x00, 0x78,
  0x3E, 0x00, 0x0F, 0x07, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x1E, 0x00,
  0x07, 0x83, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xC1,
  0xFC, 0x07, 0xF8, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFE,
  0xF0, 0x00, 0xFF, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x3F, 0x81, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xF8, 0x1F,
  0xC0, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0xFE, 0x0F, 0xF0, 0x7F,
  0x83, 0xFC, 0x1F, 0xE0, 0xFE, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x3F,
  0x80, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x01, 0xFC, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x07,
  0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFE, 0x03,
  0xFE, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0x00,
  0x1F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xE0, 0x02, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xFE, 0x03, 0xFF, 0xF8,
  0x1F, 0xFF, 0xE0, 0x70, 0x3F, 0x02, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x03,
  0xFF, 0xFC, 0x00, 0x7F, 0x07, 0xE0, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x01,
  0xF0, 0x3F, 0x00, 0x1F, 0x07, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x0F,
  0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x1F, 0x00, 0x7F, 0xF1, 0xF0, 0x1F,
  0xFE, 0x3E, 0x07, 0xFF, 0xE3, 0xE0, 0xFF, 0xFE, 0x3C, 0x1F, 0xC3, 0xE7,
  0xC1, 0xF0, 0x3C, 0x7C, 0x3E, 0x03, 0xC7, 0x83, 0xC0, 0x7C, 0x78, 0x7C,
  0x07, 0xCF, 0x87, 0x80, 0x78, 0xF8, 0x78, 0x07, 0x8F, 0x87, 0x80, 0xF8,
  0xF0, 0xF8, 0x0F, 0x8F, 0x0F, 0x80, 0xF0, 0xF0, 0x78, 0x0F, 0x0F, 0x07,
  0x81, 0xF0, 0xF0, 0x7C, 0x1F, 0x0F, 0x07, 0xE1, 0xE0, 0xF8, 0x3F, 0xFE,
  0x0F, 0x83, 0xFF, 0xE0, 0xF8, 0x0F, 0xFE, 0x07, 0x80, 0x3F, 0x80, 0x78,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x7F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0xF3, 0xC0, 0x00,
  0x1E, 0x3C, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0xC3,
  0xC0, 0x00, 0x78, 0x3C, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0xF0, 0x3E, 0x00,
  0x1E, 0x03, 0xE0, 0x01, 0xE0, 0x3E, 0x00, 0x3C, 0x03, 0xE0, 0x07, 0xC0,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x1E, 0x00, 0xF0, 0x01, 0xE0,
  0x1F, 0x00, 0x1E, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0x80, 0x01, 0xE0, 0xF8, 0x00, 0x1E,
  0x0F, 0x00, 0x01, 0xE1, 0xF0, 0x00, 0x1F, 0x1E, 0x00, 0x01, 0xF3, 0xE0,
  0x00, 0x1F, 0x3C, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1F, 0x78, 0x00, 0x01,
  0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xE0, 0x1F, 0x01, 0xFC, 0x07, 0xC0, 0x0F, 0xC0, 0xF8, 0x00,
  0xF8, 0x1F, 0x00, 0x1F, 0x03, 0xE0, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x1F,
  0x00, 0x0F, 0x03, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x0F, 0x00, 0x3F,
  0x03, 0xE0, 0x1F, 0xC0, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x0F, 0x80, 0x3F, 0x81, 0xF0, 0x01, 0xF0,
  0x3C, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0x7C, 0x3E, 0x00,
  0x0F, 0x87, 0x80, 0x01, 0xF0, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x87,
  0xC0, 0x03, 0xE0, 0xF0, 0x01, 0xFC, 0x1E, 0x00, 0xFF, 0x07, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFE, 0x00, 0xFE, 0x03, 0xC0, 0x1F, 0x80, 0x04, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x01, 0x00, 0x3F, 0x80, 0xF0,
  0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xF0, 0x3F, 0xC0, 0x1F, 0x00, 0xFC,
  0x01, 0xE0, 0x07, 0xE0, 0x1E, 0x00, 0x3E, 0x03, 0xE0, 0x03, 0xE0, 0x3E,
  0x00, 0x1F, 0x03, 0xC0, 0x01, 0xF0, 0x3C, 0x00, 0x1F, 0x07, 0xC0, 0x01,
  0xF0, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x78, 0x00, 0x1F, 0x0F,
  0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1E, 0x0F, 0x80, 0x03, 0xE0, 0xF0, 0x00,
  0x3E, 0x1F, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x07, 0xC1,
  0xE0, 0x00, 0xFC, 0x3E, 0x00, 0x0F, 0x83, 0xE0, 0x01, 0xF8, 0x3E, 0x00,
  0x3F, 0x03, 0xC0, 0x07, 0xE0, 0x7C, 0x00, 0xFE, 0x07, 0xC0, 0x3F, 0xC0,
  0x7C, 0x0F, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7F,
  0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xE0, 0x3C, 0x07, 0xF0, 0x01,
  0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x7C, 0x00, 0x1F, 0x0F,
  0x00, 0x03, 0xE1, 0xE0, 0x00, 0x7C, 0x3C, 0x00, 0x0F, 0x07, 0x80, 0x03,
  0xE0, 0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x01, 0xE0, 0x7C,
  0x00, 0x7C, 0x0F, 0xC0, 0x0F, 0x80, 0xFC, 0x01, 0xF0, 0x1F, 0xE0, 0x7C,
  0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x7C, 0x03,
  0xE0, 0x00, 0xF0, 0x07, 0x80, 0x03, 0xE0, 0x1F, 0x00, 0x07, 0xC0, 0x3E,
  0x00, 0x0F, 0x80, 0x7C, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x7C, 0x03, 0xE0,
  0x00, 0xF8, 0x07, 0xC0, 0x01, 0xF0, 0x0F, 0x80, 0x03, 0xC0, 0x1E, 0x00,
  0x0F, 0x80, 0x7C, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x3E, 0x01, 0xF0, 0x00,
  0x78, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x7C,
  0x03, 0xE0, 0x00, 0xF8, 0x07, 0xC0, 0x01, 0xE0, 0x0F, 0x80, 0x03, 0xC0,
  0x1E, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x3C, 0x01,
  0xF0, 0x00, 0x78, 0x03, 0xC0, 0x01, 0xF0, 0x0F, 0x80, 0x03, 0xE0, 0x1F,
  0x00, 0x07, 0x80, 0x3E, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x3E, 0x01, 0xF0,
  0x00, 0x7C, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x20, 0x01, 0xF0, 0x07,
  0x00, 0x3F, 0x00, 0x7C, 0x0F, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0x80, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0xFC, 0x01, 0xE0, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x3F,
  0x00, 0x1F, 0x00, 0xFC, 0x00, 0x3C, 0x03, 0xF0, 0x00, 0xF8, 0x0F, 0xC0,
  0x01, 0xF0, 0x3F, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x07, 0x83, 0xF0, 0x00,
  0x1F, 0x0F, 0xC0, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x00,
  0xF3, 0xF0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3D, 0xF8, 0x00, 0x00, 0xF9,
  0xF8, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x07, 0x83,
  0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x7C, 0x07,
  0xC0, 0x00, 0xF0, 0x07, 0xC0, 0x03, 0xE0, 0x0F, 0x80, 0x07, 0xC0, 0x0F,
  0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0xF8, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFC, 0x00, 0x1E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x07,
  0xE0, 0x07, 0xF0, 0x0F, 0xC0, 0x0F, 0xE0, 0x3F, 0x80, 0x1F, 0xC0, 0x77,
  0x00, 0x7F, 0x81, 0xFE, 0x00, 0xFF, 0x03, 0xBC, 0x01, 0xCE, 0x0F, 0x78,
  0x07, 0x9C, 0x1C, 0xE0, 0x0F, 0x38, 0x79, 0xC0, 0x1E, 0x70, 0xE7, 0x80,
  0x78, 0xE3, 0x8F, 0x00, 0xF1, 0xCF, 0x1E, 0x01, 0xE3, 0xDC, 0x3C, 0x07,
  0x87, 0xF8, 0xF0, 0x0F, 0x0F, 0xE1, 0xE0, 0x1E, 0x1F, 0xC3, 0xC0, 0x7C,
  0x3F, 0x07, 0x80, 0xF0, 0x3E, 0x0F, 0x01, 0xE0, 0x78, 0x3E, 0x03, 0xC0,
  0x00, 0x78, 0x0F, 0x80, 0x00, 0xF0, 0x1E, 0x00, 0x01, 0xE0, 0x3C, 0x00,
  0x07, 0xC0, 0xF8, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00,
  0x3C, 0x07, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x03,
  0xE0, 0x78, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x1E, 0x01, 0xF8, 0x00, 0x7C, 0x03, 0xF0, 0x00,
  0xF0, 0x07, 0xE0, 0x01, 0xE0, 0x0F, 0xE0, 0x03, 0xC0, 0x3F, 0xC0, 0x0F,
  0x80, 0x7F, 0x80, 0x1E, 0x00, 0xF7, 0x80, 0x3C, 0x01, 0xEF, 0x00, 0x78,
  0x07, 0xDE, 0x01, 0xF0, 0x0F, 0x3E, 0x03, 0xC0, 0x1E, 0x3C, 0x07, 0x80,
  0x3C, 0x78, 0x0F, 0x00, 0xF8, 0xF0, 0x3E, 0x01, 0xE0, 0xF0, 0x78, 0x03,
  0xC1, 0xE0, 0xF0, 0x07, 0x83, 0xC1, 0xE0, 0x0F, 0x07, 0x83, 0xC0, 0x3E,
  0x07, 0x0F, 0x80, 0x78, 0x0F, 0x1E, 0x00, 0xF0, 0x1E, 0x3C, 0x01, 0xE0,
  0x3C, 0x78, 0x07, 0xC0, 0x39, 0xF0, 0x0F, 0x00, 0x73, 0xC0, 0x1E, 0x00,
  0xF7, 0x80, 0x3C, 0x01, 0xEF, 0x00, 0xF8, 0x03, 0xFE, 0x01, 0xE0, 0x03,
  0xF8, 0x03, 0xC0, 0x07, 0xF0, 0x07, 0x80, 0x0F, 0xE0, 0x1F, 0x00, 0x1F,
  0xC0, 0x3C, 0x00, 0x3F, 0x00, 0x78, 0x00, 0x7E, 0x00, 0xF0, 0x00, 0x7C,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFF, 0x00,
  0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x01, 0xF8, 0x3F, 0x80, 0xFC, 0x03,
  0xE0, 0x7C, 0x00, 0xF8, 0x3F, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC7, 0xC0,
  0x01, 0xF1, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xCF,
  0x00, 0x01, 0xF7, 0xC0, 0x00, 0x7D, 0xF0, 0x00, 0x1E, 0x78, 0x00, 0x07,
  0xBE, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x3E, 0xF8, 0x00,
  0x0F, 0x3C, 0x00, 0x07, 0xCF, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0xF8, 0xF0,
  0x00, 0x3E, 0x3C, 0x00, 0x1F, 0x0F, 0x00, 0x07, 0xC3, 0xE0, 0x03, 0xE0,
  0xF8, 0x01, 0xF0, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0xFE, 0x01, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFC, 0x01, 0xF0, 0x0F, 0xE0, 0x1F, 0x00, 0x3E, 0x01, 0xF0, 0x03, 0xF0,
  0x1E, 0x00, 0x1F, 0x03, 0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x03, 0xE0,
  0x01, 0xF0, 0x3C, 0x00, 0x1F, 0x03, 0xC0, 0x01, 0xE0, 0x7C, 0x00, 0x3E,
  0x07, 0xC0, 0x07, 0xC0, 0x78, 0x00, 0x7C, 0x07, 0x80, 0x1F, 0x80, 0xF8,
  0x07, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0,
  0x01, 0xFF, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0xE0,
  0x03, 0xFF, 0xFC, 0x01, 0xF8, 0x3F, 0x80, 0xFC, 0x03, 0xE0, 0x7C, 0x00,
  0xF8, 0x3F, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC7, 0xC0, 0x01, 0xF1, 0xF0,
  0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xCF, 0x00, 0x01, 0xF7,
  0xC0, 0x00, 0x7D, 0xF0, 0x00, 0x1E, 0x78, 0x00, 0x07, 0xBE, 0x00, 0x03,
  0xEF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0x3C, 0x00,
  0x07, 0xCF, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0xF8, 0xF0, 0x00, 0x3E, 0x3C,
  0x00, 0x1F, 0x0F, 0x00, 0x07, 0xC3, 0xE0, 0x03, 0xE0, 0xF8, 0x01, 0xF0,
  0x3F, 0x00, 0xFC, 0x07, 0xE0, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0x80, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xE0, 0x1F, 0x01, 0xFC, 0x03, 0xC0, 0x0F, 0xC0, 0xF8, 0x00,
  0xF8, 0x1F, 0x00, 0x1F, 0x03, 0xE0, 0x03, 0xE0, 0x78, 0x00, 0x7C, 0x1F,
  0x00, 0x0F, 0x83, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x07,
  0x81, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x81, 0xF0,
  0x1F, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00,
  0x3E, 0xFF, 0x80, 0x07, 0x81, 0xF0, 0x01, 0xF0, 0x1F, 0x00, 0x3E, 0x01,
  0xE0, 0x07, 0xC0, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0x7C, 0x07,
  0xC0, 0x0F, 0x80, 0xF8, 0x01, 0xF0, 0x1E, 0x00, 0x1F, 0x07, 0xC0, 0x03,
  0xE0, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFE, 0x00, 0xFE, 0x01, 0xE0, 0x0F, 0x80, 0x04, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x02, 0x00, 0x0F, 0xC0, 0x7C, 0x03, 0xFC,
  0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xE0, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x1E,
  0x07, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE0, 0xF8,
  0x00, 0x3C, 0x0F, 0x80, 0x03, 0xC0, 0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x07,
  0xC1, 0xF0, 0x00, 0x78, 0x1F, 0x00, 0x07, 0x81, 0xE0, 0x00, 0xF8, 0x3E,
  0x00, 0x0F, 0x83, 0xE0, 0x00, 0xF0, 0x3E, 0x00, 0x0F, 0x03, 0xC0, 0x01,
  0xF0, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xE0, 0x7C, 0x00, 0x1E, 0x07,
  0x80, 0x03, 0xE0, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xC0, 0xF8, 0x00,
  0x7C, 0x0F, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x7C, 0x0F, 0x00, 0x07, 0x80,
  0xF0, 0x00, 0xF8, 0x0F, 0x80, 0x0F, 0x80, 0xF8, 0x01, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0x7E, 0x0F, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80,
  0x01, 0xFF, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x07, 0xCF, 0x80, 0x00,
  0xF9, 0xF0, 0x00, 0x3E, 0x3E, 0x00, 0x07, 0xC7, 0xC0, 0x01, 0xF0, 0xF8,
  0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x7C,
  0x0F, 0x80, 0x0F, 0x81, 0xF0, 0x03, 0xE0, 0x3E, 0x00, 0x78, 0x07, 0xC0,
  0x1F, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0xF8, 0x01, 0xE0, 0x1E, 0x00,
  0x3C, 0x07, 0xC0, 0x07, 0x80, 0xF0, 0x00, 0xF0, 0x3E, 0x00, 0x1E, 0x0F,
  0x80, 0x03, 0xC1, 0xF0, 0x00, 0x78, 0x7C, 0x00, 0x0F, 0x8F, 0x00, 0x01,
  0xF3, 0xE0, 0x00, 0x3E, 0x78, 0x00, 0x07, 0xDF, 0x00, 0x00, 0xFB, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x07,
  0xC0, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x01, 0xE0, 0x7C,
  0x00, 0x07, 0xC0, 0xF8, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0x3C, 0x07, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x01, 0xE0, 0x3C, 0x00,
  0x03, 0xC0, 0x78, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x1F, 0x01, 0xE0, 0xF0,
  0x3C, 0x07, 0xC3, 0xE0, 0x78, 0x0F, 0x07, 0xC0, 0xF0, 0x1E, 0x1F, 0xC3,
  0xC0, 0x3C, 0x3F, 0x87, 0x80, 0x78, 0xF7, 0x0F, 0x00, 0xE1, 0xCE, 0x3C,
  0x03, 0xC7, 0x9C, 0x78, 0x07, 0x8E, 0x38, 0xF0, 0x0F, 0x3C, 0x71, 0xC0,
  0x1E, 0xF0, 0xE7, 0x80, 0x39, 0xE1, 0xCF, 0x00, 0x77, 0x83, 0x9C, 0x01,
  0xEE, 0x07, 0x78, 0x03, 0xFC, 0x0F, 0xF0, 0x07, 0x70, 0x1F, 0xC0, 0x0F,
  0xE0, 0x3F, 0x80, 0x1F, 0x80, 0x7F, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x3E,
  0x00, 0x01, 0xF0, 0x1F, 0x80, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x0F, 0x83,
  0xE0, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0x1F,
  0x7C, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x03, 0xE3, 0xC0,
  0x00, 0x01, 0xF0, 0xF8, 0x00, 0x00, 0xFC, 0x3E, 0x00, 0x00, 0x7E, 0x07,
  0x80, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x07, 0xC0,
  0x0F, 0x00, 0x03, 0xF0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x1F, 0x00, 0x01, 0xF0, 0x0F,
  0xC0, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x03, 0xEF, 0x00, 0x00, 0xFD, 0xE0,
  0x00, 0x1F, 0x3E, 0x00, 0x07, 0xC7, 0xC0, 0x01, 0xF8, 0xF8, 0x00, 0x3E,
  0x0F, 0x00, 0x0F, 0x81, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0x7C, 0x07, 0xC0,
  0x1F, 0x00, 0x78, 0x07, 0xC0, 0x0F, 0x00, 0xF0, 0x01, 0xF0, 0x3E, 0x00,
  0x3E, 0x0F, 0x80, 0x03, 0xC3, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x0F, 0x9F,
  0x00, 0x00, 0xF7, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x0F,
  0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x78, 0x3C, 0x1E, 0x0F, 0x87, 0xC3, 0xE1,
  0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC1, 0xE0, 0xF0, 0x78, 0x3E,
  0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x07, 0x83,
  0xC1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8,
  0x3C, 0x1E, 0x0F, 0x07, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F,
  0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF0,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x1F,
  0x3C, 0x00, 0x7C, 0x78, 0x01, 0xF0, 0xF8, 0x07, 0xC0, 0xF0, 0x1F, 0x81,
  0xE0, 0x3E, 0x03, 0xE0, 0xF8, 0x07, 0xC3, 0xE0, 0x07, 0x8F, 0x80, 0x0F,
  0xBF, 0x00, 0x1F, 0x7C, 0x00, 0x1E, 0xF0, 0x00, 0x3C, 0x40, 0x00, 0x60,
  0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xE0, 0x10, 0x0E, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0x80, 0x40, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0xC0, 0xF0, 0x3F, 0x80, 0x78, 0x3F, 0x00,
  0x7C, 0x3F, 0x00, 0x3E, 0x1F, 0x00, 0x1E, 0x1F, 0x00, 0x0F, 0x0F, 0x80,
  0x0F, 0x8F, 0x80, 0x07, 0xC7, 0xC0, 0x03, 0xC3, 0xC0, 0x01, 0xE3, 0xE0,
  0x01, 0xF1, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x78, 0x7C, 0x00, 0x3C, 0x3E,
  0x00, 0x1E, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x07, 0xC1,
  0xF0, 0x0F, 0xE0, 0xFC, 0x0F, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xBC,
  0x07, 0xFF, 0x9E, 0x00, 0xFF, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1E, 0x3F, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE,
  0x03, 0xF8, 0x3F, 0x81, 0xF0, 0x07, 0xC1, 0xF0, 0x03, 0xE0, 0xF8, 0x00,
  0xF8, 0x78, 0x00, 0x7C, 0x3C, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x1F, 0x00,
  0x0F, 0x8F, 0x00, 0x07, 0xC7, 0x80, 0x03, 0xC7, 0xC0, 0x03, 0xE3, 0xE0,
  0x01, 0xF1, 0xF0, 0x00, 0xF8, 0xF0, 0x00, 0xF8, 0x78, 0x00, 0x7C, 0x7C,
  0x00, 0x7C, 0x3E, 0x00, 0x7E, 0x1E, 0x00, 0x7E, 0x0F, 0x00, 0xFE, 0x0F,
  0x81, 0xFE, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0xC0, 0x30, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x20, 0x7F, 0x00, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFF,
  0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xC1, 0xF0, 0x0F,
  0xE0, 0x1F, 0x01, 0xFC, 0x01, 0xE0, 0x1F, 0x80, 0x1E, 0x03, 0xF0, 0x03,
  0xE0, 0x3E, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xC0, 0x7C, 0x00, 0x3C, 0x0F,
  0x80, 0x07, 0xC0, 0xF8, 0x00, 0x7C, 0x0F, 0x80, 0x07, 0x80, 0xF0, 0x00,
  0x78, 0x0F, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0xF8, 0x0F, 0x00, 0x0F, 0x80,
  0xF0, 0x00, 0xF0, 0x0F, 0x80, 0x0F, 0x00, 0xF8, 0x01, 0xF0, 0x0F, 0x80,
  0x3F, 0x00, 0x7E, 0x0F, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFE, 0xF8,
  0x01, 0xFF, 0xCF, 0x80, 0x07, 0xF0, 0x70, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x7F, 0x83, 0xF0,
  0x7F, 0x00, 0x7C, 0x7E, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x3E, 0x00, 0x0F,
  0x9F, 0x00, 0x0F, 0x9F, 0x00, 0x0F, 0xCF, 0x80, 0x0F, 0xC7, 0x80, 0x7F,
  0xE7, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x80, 0xFF, 0xF0,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x20, 0x7F, 0x01, 0xF0, 0x3F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xF0, 0x20, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xF0, 0x03, 0xFC, 0x0F, 0x00, 0x3F, 0x00, 0xF8, 0x03, 0xF0, 0x07,
  0xC0, 0x3F, 0x00, 0x3E, 0x03, 0xF0, 0x01, 0xE0, 0x1F, 0x00, 0x0F, 0x01,
  0xF0, 0x00, 0xF8, 0x0F, 0x80, 0x07, 0xC0, 0x78, 0x00, 0x3E, 0x07, 0xC0,
  0x01, 0xE0, 0x3E, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0xF8, 0x0F, 0x80, 0x07,
  0xC0, 0x7C, 0x00, 0x3C, 0x03, 0xE0, 0x03, 0xE0, 0x1F, 0x00, 0x1F, 0x00,
  0xF8, 0x01, 0xF8, 0x07, 0xF0, 0x3F, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xF8, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x80, 0x07, 0xE0, 0x0F, 0x00, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xEF, 0xE0, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x07, 0xFF,
  0xFE, 0x07, 0xE0, 0x7F, 0x07, 0x80, 0x3F, 0x0F, 0x80, 0x1F, 0x0F, 0x80,
  0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00,
  0x1F, 0x1F, 0x00, 0x1E, 0x1E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00,
  0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3C, 0x3C, 0x00, 0x7C, 0x7C, 0x00,
  0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x78, 0x78, 0x00, 0xF8, 0xF8, 0x00,
  0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0x00, 0x38,
  0x00, 0xFC, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0xFC,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xFF, 0x07, 0xFF, 0x03, 0xFF,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x02, 0x00, 0x7C, 0x00, 0x78, 0x1F, 0xC0, 0x07, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x01, 0xF8, 0x3E, 0x00, 0xFC, 0x07, 0xC0, 0x3F, 0x00, 0xF0, 0x1F, 0xC0,
  0x1E, 0x07, 0xF0, 0x07, 0xC3, 0xFC, 0x00, 0xF9, 0xFE, 0x00, 0x1E, 0x7F,
  0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0x7E, 0x00, 0x03, 0xE7, 0xE0,
  0x00, 0x7C, 0x7E, 0x00, 0x0F, 0x87, 0xE0, 0x01, 0xE0, 0x7C, 0x00, 0x7C,
  0x07, 0xC0, 0x0F, 0x80, 0xFC, 0x01, 0xF0, 0x0F, 0x80, 0x3C, 0x00, 0xF8,
  0x0F, 0x80, 0x1F, 0x01, 0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x3E, 0x07, 0x80,
  0x03, 0xE0, 0x7F, 0xF8, 0xFF, 0xF1, 0xFF, 0xE7, 0xFF, 0xC0, 0x0F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00,
  0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00,
  0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x67,
  0xFF, 0xCF, 0xFF, 0x8F, 0xFF, 0x07, 0xF8, 0x00, 0x7E, 0x0F, 0x80, 0x3F,
  0xFB, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xC7, 0xE1,
  0xF0, 0x78, 0x3C, 0x1F, 0x07, 0x83, 0xC1, 0xF0, 0xF8, 0x3C, 0x1E, 0x0F,
  0x83, 0xC1, 0xE0, 0xF0, 0x7C, 0x1E, 0x0F, 0x07, 0x81, 0xE1, 0xF0, 0x78,
  0x3E, 0x1F, 0x07, 0x83, 0xC1, 0xE0, 0xF8, 0x3C, 0x1E, 0x0F, 0x03, 0xC1,
  0xE0, 0xF0, 0x7C, 0x3E, 0x0F, 0x07, 0x83, 0xC0, 0x00, 0x78, 0x3C, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0,
  0x78, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1E, 0x0F, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0xF8,
  0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xC0, 0x7E, 0x07, 0x80, 0x3F,
  0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x00, 0x1F,
  0x0F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1E,
  0x1E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3C,
  0x3C, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x78,
  0x78, 0x00, 0x78, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF0,
  0xF0, 0x00, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF8,
  0x03, 0xFF, 0xFC, 0x07, 0xF0, 0x7E, 0x0F, 0xC0, 0x3E, 0x1F, 0x80, 0x3E,
  0x3F, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F,
  0x7C, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x3E,
  0xF8, 0x00, 0x3E, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x7C,
  0xF0, 0x00, 0xFC, 0xF8, 0x00, 0xF8, 0xF8, 0x01, 0xF0, 0xF8, 0x03, 0xF0,
  0x7E, 0x0F, 0xE0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0xF8, 0x0F, 0xE0, 0x1F, 0x00, 0x3E,
  0x01, 0xF0, 0x03, 0xE0, 0x1F, 0x00, 0x1F, 0x01, 0xE0, 0x01, 0xF0, 0x3E,
  0x00, 0x1F, 0x03, 0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x03, 0xE0, 0x01,
  0xF0, 0x7C, 0x00, 0x1E, 0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x07,
  0xC0, 0x03, 0xE0, 0x78, 0x00, 0x7C, 0x0F, 0x80, 0x07, 0xC0, 0xF8, 0x00,
  0xF8, 0x0F, 0x80, 0x1F, 0x80, 0xF0, 0x03, 0xF0, 0x1F, 0x00, 0x7E, 0x01,
  0xF0, 0x3F, 0xC0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x7F, 0xC1,
  0xF0, 0x7F, 0x00, 0xF8, 0x3F, 0x00, 0x7C, 0x3E, 0x00, 0x3C, 0x3F, 0x00,
  0x3E, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0x8F, 0x80,
  0x07, 0xC7, 0xC0, 0x03, 0xE3, 0xE0, 0x01, 0xF1, 0xE0, 0x00, 0xF0, 0xF0,
  0x00, 0xF8, 0x78, 0x00, 0x7C, 0x3C, 0x00, 0x3E, 0x1E, 0x00, 0x1E, 0x0F,
  0x80, 0x0F, 0x07, 0xC0, 0x0F, 0x83, 0xF0, 0x0F, 0xC0, 0xFC, 0x1F, 0xC0,
  0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0xFE, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xE0, 0x7F, 0x00, 0x20, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x3F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xC0, 0x1F, 0x80, 0x60, 0x1F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0,
  0x80, 0x07, 0xE0, 0x78, 0x0F, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x38, 0x00, 0x07, 0xC0,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xFC, 0x06, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x7F, 0xFC,
  0x00, 0xFF, 0x00, 0x0F, 0x00, 0x0F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1F,
  0x1F, 0x00, 0x1F, 0x1E, 0x00, 0x1E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3E,
  0x3E, 0x00, 0x3E, 0x3C, 0x00, 0x3C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x7C,
  0x7C, 0x00, 0x7C, 0x78, 0x00, 0x78, 0x78, 0x00, 0xF8, 0xF8, 0x00, 0xF8,
  0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF0, 0xF8, 0x01, 0xF0, 0xF0, 0x01, 0xF0,
  0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x07, 0xF0, 0xFC, 0x1F, 0xF0,
  0x7F, 0xFF, 0xF0, 0x7F, 0xFE, 0xF0, 0x3F, 0xFC, 0xF0, 0x0F, 0xF0, 0xF0,
  0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xBE, 0x00, 0x3E, 0xF8,
  0x00, 0xFB, 0xE0, 0x07, 0xCF, 0x80, 0x1F, 0x3E, 0x00, 0x78, 0xF8, 0x03,
  0xE3, 0xE0, 0x0F, 0x0F, 0x80, 0x7C, 0x3E, 0x03, 0xE0, 0x78, 0x0F, 0x81,
  0xE0, 0x7C, 0x07, 0xC1, 0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x7C, 0x01, 0xF1,
  0xF0, 0x07, 0xCF, 0x80, 0x0F, 0x7C, 0x00, 0x3D, 0xF0, 0x00, 0xFF, 0x80,
  0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x00,
  0x3C, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1E, 0x7C, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0x3E, 0x78, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x3C, 0x78, 0x1E, 0x07,
  0xC7, 0x81, 0xE0, 0x78, 0x78, 0x3E, 0x07, 0x8F, 0x83, 0xE0, 0xF8, 0xF8,
  0x7E, 0x0F, 0x0F, 0x07, 0xE0, 0xF0, 0xF0, 0xFE, 0x1E, 0x0F, 0x0E, 0xF1,
  0xE0, 0xF1, 0xEF, 0x3E, 0x0F, 0x3C, 0xF3, 0xC0, 0xF3, 0x8F, 0x3C, 0x0F,
  0x78, 0xF7, 0x80, 0xF7, 0x07, 0x78, 0x0F, 0xF0, 0x7F, 0x00, 0xFE, 0x07,
  0xF0, 0x0F, 0xC0, 0x7F, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0x80, 0x7E, 0x00,
  0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0xF8, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x7C,
  0x07, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x07, 0xCF,
  0x80, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x03,
  0xF3, 0xE0, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0xFC, 0x1F, 0x00, 0x07, 0xE0,
  0x7C, 0x00, 0x3F, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x07,
  0xC0, 0x3E, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x3E, 0x01,
  0xF0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3E, 0x03,
  0xE0, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1F, 0x0F,
  0x80, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x0F, 0x1E,
  0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x0F, 0xBC, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x40, 0xFE, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0,
  0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x1F,
  0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xE0,
  0x03, 0x03, 0xFE, 0x01, 0xE1, 0xFF, 0xC0, 0x78, 0xFF, 0xFC, 0x3C, 0x7C,
  0x3F, 0xFF, 0x1E, 0x07, 0xFF, 0x8F, 0x00, 0x7F, 0xC0, 0xC0, 0x07, 0xC0,
};

const GFXglyph UbuntuMono_Italic57pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 29, 0, -1 },
  { 1, 14, 35, 29, 10, -35 },
  { 63, 16, 14, 29, 13, -39 },
  { 91, 30, 35, 29, 2, -35 },
  { 223, 27, 46, 29, 4, -40 },
  { 379, 34, 35, 29, 0, -35 },
  { 528, 25, 35, 29, 3, -35 },
  { 638, 8, 15, 29, 17, -39 },
  { 653, 22, 50, 29, 8, -40 },
  { 791, 22, 50, 29, 3, -40 },
  { 929, 22, 21, 29, 8, -35 },
  { 987, 24, 25, 29, 5, -27 },
  { 1062, 12, 16, 29, 6, -8 },
  { 1086, 14, 4, 29, 10, -16 },
  { 1093, 8, 8, 29, 10, -8 },
  { 1101, 33, 49, 29, -1, -40 },
  { 1304, 25, 35, 29, 5, -35 },
  { 1414, 21, 35, 29, 5, -35 },
  { 1506, 26, 35, 29, 4, -35 },
  { 1620, 26, 35, 29, 3, -35 },
  { 1734, 26, 35, 29, 3, -35 },
  { 1848, 28, 35, 29, 3, -35 },
  { 1971, 26, 35, 29, 5, -35 },
  { 2085, 26, 35, 29, 8, -35 },
  { 2199, 27, 35, 29, 4, -35 },
  { 2318, 27, 35, 29, 4, -35 },
  { 2437, 13, 26, 29, 10, -26 },
  { 2480, 17, 34, 29, 6, -26 },
  { 2553, 26, 23, 29, 4, -26 },
  { 2628, 26, 15, 29, 4, -23 },
  { 2677, 26, 23, 29, 3, -26 },
  { 2752, 21, 35, 29, 9, -35 },
  { 2844, 28, 44, 29, 4, -36 },
  { 2998, 28, 35, 29, -1, -35 },
  { 3121, 27, 35, 29, 3, -35 },
  { 3240, 28, 35, 29, 5, -35 },
  { 3363, 28, 35, 29, 2, -35 },
  { 3486, 28, 35, 29, 4, -35 },
  { 3609, 29, 35, 29, 4, -35 },
  { 3736, 27, 35, 29, 5, -35 },
  { 3855, 31, 35, 29, 2, -35 },
  { 3991, 27, 35, 29, 4, -35 },
  { 4110, 28, 35, 29, 4, -35 },
  { 4233, 31, 35, 29, 3, -35 },
  { 4369, 21, 35, 29, 3, -35 },
  { 4461, 31, 35, 29, 1, -35 },
  { 4597, 31, 35, 29, 2, -35 },
  { 4733, 26, 35, 29, 5, -35 },
  { 4847, 28, 35, 29, 3, -35 },
  { 4970, 26, 44, 29, 5, -35 },
  { 5113, 27, 35, 29, 3, -35 },
  { 5232, 28, 35, 29, 3, -35 },
  { 5355, 25, 35, 29, 9, -35 },
  { 5465, 28, 35, 29, 5, -35 },
  { 5588, 27, 35, 29, 8, -35 },
  { 5707, 31, 35, 29, 3, -35 },
  { 5843, 34, 35, 29, 1, -35 },
  { 5992, 27, 35, 29, 8, -35 },
  { 6111, 31, 35, 29, 2, -35 },
  { 6247, 25, 49, 29, 6, -40 },
  { 6401, 9, 49, 29, 12, -40 },
  { 6457, 26, 49, 29, 1, -40 },
  { 6617, 23, 19, 29, 6, -35 },
  { 6672, 27, 4, 29, -2, 5 },
  { 6686, 10, 10, 29, 15, -39 },
  { 6699, 25, 28, 29, 4, -27 },
  { 6787, 25, 41, 29, 4, -40 },
  { 6916, 25, 28, 29, 4, -27 },
  { 7004, 28, 41, 29, 5, -40 },
  { 7148, 25, 28, 29, 4, -27 },
  { 7236, 33, 49, 29, 1, -40 },
  { 7439, 29, 36, 29, 1, -27 },
  { 7570, 24, 40, 29, 3, -40 },
  { 7690, 16, 38, 29, 8, -38 },
  { 7766, 28, 47, 29, 1, -38 },
  { 7931, 27, 40, 29, 4, -40 },
  { 8066, 15, 41, 29, 10, -40 },
  { 8143, 28, 27, 29, 2, -27 },
  { 8238, 24, 27, 29, 4, -27 },
  { 8319, 24, 28, 29, 5, -27 },
  { 8403, 28, 36, 29, 1, -27 },
  { 8529, 25, 36, 29, 5, -27 },
  { 8642, 25, 27, 29, 5, -27 },
  { 8727, 25, 28, 29, 4, -27 },
  { 8815, 21, 35, 29, 8, -34 },
  { 8907, 24, 27, 29, 5, -26 },
  { 8988, 22, 26, 29, 8, -26 },
  { 9060, 28, 26, 29, 5, -26 },
  { 9151, 30, 26, 29, 1, -26 },
  { 9249, 32, 35, 29, -1, -26 },
  { 9389, 26, 26, 29, 3, -26 },
  { 9474, 28, 49, 29, 5, -40 },
  { 9646, 16, 49, 29, 9, -40 },
  { 9744, 27, 49, 29, 0, -40 },
  { 9910, 26, 8, 29, 4, -19 },
};

const GFXfont UbuntuMono_Italic57pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Italic57pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Italic57pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _UBUNTUMONO_ITALIC57PT7B_H_
