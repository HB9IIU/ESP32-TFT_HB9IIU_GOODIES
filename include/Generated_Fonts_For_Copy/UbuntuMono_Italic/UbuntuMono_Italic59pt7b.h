#ifndef _UBUNTUMONO_ITALIC59PT7B_H_
#define _UBUNTUMONO_ITALIC59PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Italic.ttf
// Size: 59pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Italic59pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x1F, 0x80, 0x3C, 0x00, 0x3E, 0x0F, 0x9F, 0x07, 0x8F, 0x83,
  0xC7, 0x83, 0xE3, 0xC1, 0xF3, 0xE0, 0xF1, 0xE0, 0x78, 0xF0, 0x3C, 0x78,
  0x1E, 0x3C, 0x1E, 0x1C, 0x0F, 0x1E, 0x07, 0x8F, 0x03, 0x87, 0x01, 0xC3,
  0x80, 0xE0, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x01,
  0xF0, 0x3C, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x03,
  0xC0, 0x78, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x07,
  0x80, 0xF0, 0x00, 0x0F, 0x81, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x3C,
  0x07, 0x80, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x78,
  0x0F, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x01, 0xF0,
  0x3E, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x3F, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xE0, 0x0F, 0x81, 0xF0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x1F, 0x03,
  0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x3E, 0x07,
  0xC0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x78, 0x0F,
  0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0xFE, 0x03, 0xC0, 0x1F, 0x80, 0x04,
  0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x30, 0x00, 0x7C, 0x07, 0xC0, 0x3F, 0xC0,
  0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x03, 0xFC, 0x00, 0x3C,
  0x00, 0x7F, 0xE0, 0x07, 0xC0, 0x0F, 0xFE, 0x00, 0xF8, 0x00, 0xF1, 0xE0,
  0x0F, 0x00, 0x1E, 0x1E, 0x01, 0xE0, 0x01, 0xE0, 0xE0, 0x3C, 0x00, 0x3C,
  0x0E, 0x07, 0x80, 0x03, 0xC1, 0xE0, 0xF8, 0x00, 0x3C, 0x1E, 0x1F, 0x00,
  0x03, 0xC1, 0xE1, 0xE0, 0x00, 0x3C, 0x3C, 0x3C, 0x00, 0x03, 0xC3, 0xC7,
  0x80, 0x00, 0x3C, 0x7C, 0xF0, 0x00, 0x03, 0xFF, 0x9E, 0x00, 0x00, 0x1F,
  0xF3, 0xE0, 0x00, 0x01, 0xFE, 0x3C, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x3F, 0x00, 0x00, 0x03, 0xC7,
  0xF8, 0x00, 0x00, 0x7C, 0xFF, 0x80, 0x00, 0x0F, 0x9F, 0xFC, 0x00, 0x00,
  0xF3, 0xE3, 0xC0, 0x00, 0x1E, 0x3C, 0x3C, 0x00, 0x03, 0xC3, 0x83, 0xC0,
  0x00, 0x78, 0x78, 0x3C, 0x00, 0x0F, 0x87, 0x83, 0xC0, 0x01, 0xF0, 0x70,
  0x3C, 0x00, 0x1E, 0x07, 0x03, 0xC0, 0x03, 0xC0, 0x70, 0x78, 0x00, 0x78,
  0x07, 0x87, 0x80, 0x0F, 0x00, 0x78, 0xF0, 0x01, 0xF0, 0x07, 0xFF, 0x00,
  0x3E, 0x00, 0x7F, 0xE0, 0x03, 0xC0, 0x03, 0xFC, 0x00, 0x78, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xE0,
  0x00, 0xFF, 0xFC, 0x00, 0x7E, 0x1F, 0x00, 0x3E, 0x03, 0xC0, 0x0F, 0x80,
  0xF0, 0x07, 0xC0, 0x3C, 0x01, 0xF0, 0x1F, 0x00, 0x7C, 0x07, 0xC0, 0x1F,
  0x03, 0xE0, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x7C, 0x00, 0x3C, 0x7E, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80,
  0xF0, 0x3F, 0xE0, 0x7C, 0x1F, 0xFC, 0x1E, 0x0F, 0xDF, 0x07, 0x87, 0xC3,
  0xE3, 0xE3, 0xE0, 0x7C, 0xF0, 0xF8, 0x1F, 0x3C, 0x7C, 0x03, 0xFE, 0x1F,
  0x00, 0xFF, 0x87, 0xC0, 0x1F, 0xC3, 0xE0, 0x03, 0xF0, 0xF8, 0x00, 0xF8,
  0x3F, 0x00, 0x3E, 0x0F, 0xC0, 0x1F, 0xC1, 0xF0, 0x0F, 0xF0, 0x7E, 0x0F,
  0xFE, 0x0F, 0xFF, 0xEF, 0x83, 0xFF, 0xF3, 0xE0, 0x7F, 0xF0, 0x7C, 0x07,
  0xE0, 0x1F, 0x00, 0x3E, 0x7C, 0xF9, 0xF7, 0xCF, 0x9F, 0x3E, 0x79, 0xF3,
  0xE7, 0x8F, 0x1E, 0x38, 0x70, 0x00, 0x00, 0x10, 0x00, 0x00, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x04, 0x07, 0x81, 0x1E, 0x0E,
  0x0F, 0x3F, 0x1C, 0x7E, 0x7F, 0xBB, 0xFD, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xF0, 0x0F, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x7B, 0xC0,
  0x01, 0xF7, 0xC0, 0x07, 0xC7, 0xC0, 0x1F, 0x8F, 0xC0, 0x7E, 0x0F, 0xC0,
  0x7C, 0x1F, 0x00, 0x70, 0x1C, 0x00, 0x40, 0x10, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x0F, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFC, 0x00, 0x78, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x3F, 0x81, 0xFE,
  0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x1F, 0xE0, 0x7F, 0x01, 0xF0, 0x0F, 0x81,
  0xF8, 0x3F, 0x8F, 0xF8, 0x7F, 0x83, 0xF0, 0x0C, 0x00, 0x7F, 0xFD, 0xFF,
  0xF7, 0xFF, 0xDF, 0xFF, 0xFF, 0xF8, 0x1E, 0x3F, 0x9F, 0xFF, 0xFF, 0xFF,
  0xF9, 0xFC, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x03,
  0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x03, 0xE0,
  0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x07, 0xC0, 0x07, 0xC3, 0xE0, 0x01,
  0xF0, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x1F, 0x00, 0x07, 0xCF, 0x80,
  0x01, 0xF3, 0xE0, 0xE0, 0x7C, 0xF8, 0xFC, 0x1F, 0x7C, 0x3F, 0x8F, 0x9F,
  0x0F, 0xE3, 0xE7, 0xC3, 0xF8, 0xF9, 0xF0, 0xFC, 0x3E, 0xF8, 0x3F, 0x0F,
  0x3E, 0x07, 0x87, 0xCF, 0x80, 0x01, 0xF3, 0xE0, 0x00, 0xFC, 0xF8, 0x00,
  0x3E, 0x3E, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0xC3, 0xE0, 0x01, 0xF0, 0xF8,
  0x00, 0xF8, 0x3E, 0x00, 0x7E, 0x0F, 0x80, 0x3F, 0x01, 0xF0, 0x1F, 0x80,
  0x7E, 0x0F, 0xC0, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xE0, 0x07, 0xFF,
  0x00, 0x7F, 0xFC, 0x03, 0xFD, 0xF0, 0x0F, 0xC7, 0xC0, 0x3C, 0x1E, 0x00,
  0xC0, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x01,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xE0, 0x1F, 0x81, 0xFC, 0x01, 0xC0, 0x0F, 0x80, 0x20, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x0F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0xF8, 0x1F, 0xC0, 0x10, 0x03, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE1, 0x00, 0x07, 0xF0,
  0x78, 0x07, 0xF8, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0x3C, 0x00, 0x07, 0xCF, 0x80,
  0x01, 0xF1, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x07, 0x80, 0x07, 0xC1,
  0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x7C, 0x07, 0xC0, 0x0F, 0x80, 0xF0, 0x03,
  0xE0, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x0F, 0x80, 0x1E,
  0x01, 0xF0, 0x07, 0xC0, 0x7C, 0x00, 0xF8, 0x1F, 0x00, 0x1F, 0x03, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFE, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x08, 0x00, 0x3F, 0x80, 0x78, 0x07,
  0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE3, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0x07, 0xF8, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0xF8, 0x00,
  0x3E, 0x3E, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xE3, 0xE0, 0x00, 0xF8, 0xF8,
  0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xE3, 0xE0, 0x01, 0xF8,
  0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x3F, 0x0F, 0x80, 0x0F, 0x83, 0xF0, 0x0F,
  0xE0, 0x7E, 0x07, 0xF0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xC0, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x0F, 0x80, 0xF8, 0x01, 0xF8, 0x1F,
  0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x0F,
  0x03, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x01, 0xF8,
  0x07, 0xC0, 0x1F, 0x83, 0xF0, 0x01, 0xFE, 0xFC, 0x00, 0x1F, 0xFF, 0x00,
  0x07, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0xFC, 0x3F, 0x80, 0x3E, 0x01,
  0xF8, 0x0F, 0x80, 0x1F, 0x83, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x1F,
  0x00, 0x07, 0xC3, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x03,
  0xE1, 0xF0, 0x00, 0xFC, 0x3E, 0x00, 0x1F, 0x07, 0xE0, 0x0F, 0xE0, 0xFE,
  0x07, 0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x01, 0xFE, 0x0F, 0xC0, 0x1F, 0x80,
  0x7E, 0x03, 0xF0, 0x03, 0xE0, 0x7E, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xE0,
  0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80,
  0x01, 0xE0, 0xF8, 0x00, 0x1E, 0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x3E,
  0x0F, 0x80, 0x03, 0xE0, 0xFC, 0x00, 0x3E, 0x07, 0xE0, 0x1F, 0xE0, 0x7F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0x8F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x1F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC,
  0x1F, 0xC0, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x07, 0xF0,
  0x3F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x03, 0xF8, 0x0F, 0x00, 0x00, 0x1F,
  0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01,
  0xFC, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F,
  0xF0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x3F, 0x00, 0x7F, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x7E, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x40, 0x1F, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xC0, 0x06, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xFE, 0x03, 0xFF, 0xF8,
  0x1F, 0xFF, 0xE0, 0xF0, 0x3F, 0x04, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x01, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xF8, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xF8, 0x3F,
  0x00, 0x7E, 0x00, 0xF8, 0x07, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0x1F, 0x03,
  0xE0, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3E, 0x1F, 0x00,
  0x01, 0xF0, 0xF8, 0x03, 0xFF, 0x8F, 0x80, 0xFF, 0xF8, 0x7C, 0x0F, 0xFF,
  0xC7, 0xC0, 0xFF, 0xFE, 0x3E, 0x0F, 0xC1, 0xF1, 0xE0, 0xFC, 0x0F, 0x1F,
  0x0F, 0xC0, 0x78, 0xF8, 0x7C, 0x07, 0xC7, 0xC3, 0xC0, 0x3E, 0x3C, 0x3E,
  0x01, 0xE1, 0xE1, 0xF0, 0x0F, 0x1F, 0x0F, 0x80, 0xF8, 0xF8, 0x78, 0x07,
  0xC7, 0xC3, 0xC0, 0x3C, 0x3E, 0x1F, 0x03, 0xE1, 0xF0, 0xF8, 0x1F, 0x0F,
  0x87, 0xC0, 0xF8, 0x7C, 0x1F, 0x87, 0x83, 0xE0, 0xFF, 0xFC, 0x1F, 0x03,
  0xFF, 0xE0, 0xF8, 0x0F, 0xFF, 0x03, 0xC0, 0x1F, 0xE0, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3D, 0xF0,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0x1E, 0x7C, 0x00, 0x01, 0xF1, 0xE0, 0x00,
  0x0F, 0x0F, 0x00, 0x00, 0xF8, 0x78, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x7C,
  0x1E, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x3C, 0x07, 0xC0, 0x03, 0xE0, 0x3E,
  0x00, 0x1E, 0x01, 0xF0, 0x01, 0xF0, 0x0F, 0x80, 0x0F, 0x00, 0x7C, 0x00,
  0xF8, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xC0,
  0x07, 0xC0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFC, 0x0F, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x0F, 0x07,
  0xC0, 0x00, 0x78, 0x7C, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x1E, 0x3E, 0x00,
  0x00, 0xF9, 0xF0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x01, 0xF0, 0x0F, 0xE0, 0x1F,
  0x00, 0x3F, 0x01, 0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x03, 0xE0, 0x01,
  0xF0, 0x3E, 0x00, 0x1F, 0x03, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x07,
  0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x07, 0xC0, 0x0F, 0xC0, 0x78, 0x07,
  0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xF0, 0x1F, 0x00, 0x7F, 0x01, 0xF0, 0x01, 0xF8, 0x1F, 0x00,
  0x0F, 0x81, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C,
  0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0xF8, 0x3C, 0x00, 0x0F, 0x87, 0xC0,
  0x01, 0xF8, 0x7C, 0x00, 0x3F, 0x07, 0xC0, 0x07, 0xF0, 0x78, 0x03, 0xFE,
  0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xF0, 0x1F, 0x00, 0xFE, 0x00,
  0x10, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x01, 0x00, 0x3F,
  0xC0, 0x78, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0x01, 0xFC,
  0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0xC0, 0x3E, 0x00, 0x3E, 0x01,
  0xF0, 0x01, 0xF0, 0x1F, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x3E, 0x07, 0xC0,
  0x01, 0xF0, 0x3E, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x03,
  0xE0, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x3C, 0x00, 0x07, 0xC3,
  0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x07, 0x80,
  0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x03,
  0xE0, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xF0, 0x7C, 0x00, 0x1F, 0x03,
  0xE0, 0x01, 0xF8, 0x1F, 0x00, 0x1F, 0x81, 0xF0, 0x03, 0xF8, 0x0F, 0x80,
  0x3F, 0x80, 0x7C, 0x0F, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFE, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0x80, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0x03,
  0xE0, 0x1F, 0x80, 0x04, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0,
  0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x3E, 0x0F, 0x80,
  0x03, 0xE0, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xC0, 0xF8, 0x00, 0x7C,
  0x0F, 0xC0, 0x07, 0xC0, 0x7C, 0x00, 0x7C, 0x07, 0xE0, 0x07, 0x80, 0x3F,
  0x80, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0xF0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x3E, 0x01, 0xF0, 0x00,
  0x7C, 0x01, 0xF0, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x7C, 0x03, 0xE0, 0x00,
  0x7C, 0x03, 0xE0, 0x00, 0x78, 0x03, 0xE0, 0x00, 0xF8, 0x03, 0xE0, 0x00,
  0xF8, 0x07, 0xC0, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0xF0, 0x07, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x0F, 0x80, 0x03, 0xE0, 0x0F, 0x80, 0x03, 0xE0, 0x0F, 0x00, 0x03,
  0xE0, 0x1F, 0x00, 0x03, 0xC0, 0x1F, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x07,
  0xC0, 0x1E, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x0F,
  0x80, 0x3E, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x0F,
  0x80, 0x7C, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x00, 0x7F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x80, 0x07, 0xE0, 0x0E,
  0x00, 0x7E, 0x00, 0x7C, 0x0F, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x7E, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0xF0,
  0x03, 0xF0, 0x01, 0xF0, 0x07, 0xE0, 0x01, 0xF0, 0x0F, 0xC0, 0x01, 0xF0,
  0x1F, 0x80, 0x01, 0xE0, 0x3F, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x03, 0xE0,
  0xFC, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x03, 0xC3, 0xF0, 0x00, 0x07, 0xC7,
  0xE0, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x07, 0xBF,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0x3F, 0x00, 0x00, 0x1F, 0x1F,
  0x80, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1E, 0x07,
  0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x3E, 0x01,
  0xF0, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F,
  0x00, 0x3F, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0xEE,
  0x00, 0x77, 0x81, 0xFE, 0x00, 0x77, 0x81, 0xDE, 0x00, 0xF7, 0x83, 0xDE,
  0x00, 0xF7, 0x83, 0x9E, 0x00, 0xE7, 0x87, 0x9C, 0x01, 0xE7, 0x87, 0x3C,
  0x01, 0xE7, 0x8F, 0x3C, 0x01, 0xE3, 0x8E, 0x3C, 0x03, 0xC3, 0x9C, 0x3C,
  0x03, 0xC3, 0xBC, 0x7C, 0x03, 0xC3, 0xB8, 0x78, 0x07, 0xC3, 0xF8, 0x78,
  0x07, 0x83, 0xF0, 0x78, 0x07, 0x83, 0xF0, 0x78, 0x0F, 0x83, 0xE0, 0xF8,
  0x0F, 0x03, 0xE0, 0xF8, 0x0F, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0xF0,
  0x1F, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x01, 0xF0,
  0x3E, 0x00, 0x01, 0xE0, 0x3E, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x03, 0xE0,
  0x3C, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x03, 0xC0,
  0x78, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x1F,
  0x00, 0xFE, 0x00, 0x1E, 0x00, 0xFE, 0x00, 0x1E, 0x00, 0xFF, 0x00, 0x3E,
  0x00, 0xFF, 0x00, 0x3E, 0x01, 0xFF, 0x00, 0x3C, 0x01, 0xEF, 0x00, 0x3C,
  0x01, 0xE7, 0x80, 0x3C, 0x01, 0xE7, 0x80, 0x7C, 0x03, 0xE7, 0x80, 0x78,
  0x03, 0xE7, 0xC0, 0x78, 0x03, 0xC3, 0xC0, 0x78, 0x03, 0xC3, 0xC0, 0xF8,
  0x07, 0xC3, 0xC0, 0xF0, 0x07, 0xC3, 0xC0, 0xF0, 0x07, 0x81, 0xE0, 0xF0,
  0x07, 0x81, 0xE1, 0xF0, 0x07, 0x81, 0xE1, 0xF0, 0x0F, 0x81, 0xE1, 0xE0,
  0x0F, 0x00, 0xF1, 0xE0, 0x0F, 0x00, 0xF3, 0xE0, 0x0F, 0x00, 0xF3, 0xE0,
  0x1F, 0x00, 0xF3, 0xC0, 0x1E, 0x00, 0xF3, 0xC0, 0x1E, 0x00, 0x73, 0xC0,
  0x1E, 0x00, 0x7F, 0xC0, 0x3E, 0x00, 0x7F, 0x80, 0x3E, 0x00, 0x7F, 0x80,
  0x3C, 0x00, 0x7F, 0x80, 0x3C, 0x00, 0x3F, 0x80, 0x7C, 0x00, 0x3F, 0x00,
  0x7C, 0x00, 0x3F, 0x00, 0x78, 0x00, 0x3F, 0x00, 0x78, 0x00, 0x3F, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xC1, 0xFC, 0x07, 0xE0, 0x1F,
  0x80, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xE1, 0xF0,
  0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF3, 0xE0, 0x00, 0x3E,
  0x7C, 0x00, 0x07, 0xCF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0x7C, 0x00,
  0x03, 0xCF, 0x80, 0x00, 0xF9, 0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x03, 0xEF,
  0x80, 0x00, 0x7D, 0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x03, 0xE7, 0xC0, 0x00,
  0x7C, 0xF8, 0x00, 0x1F, 0x1F, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0xF8, 0x7C,
  0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x3E,
  0x03, 0xE0, 0x1F, 0x80, 0x7F, 0x07, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0x7F,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0,
  0x0F, 0x80, 0xFF, 0x00, 0x7C, 0x01, 0xF8, 0x07, 0xC0, 0x07, 0xE0, 0x3E,
  0x00, 0x1F, 0x01, 0xF0, 0x00, 0xF8, 0x0F, 0x80, 0x07, 0xC0, 0xF8, 0x00,
  0x3E, 0x07, 0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0xF8,
  0x0F, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x7C, 0x07, 0xC0, 0x07, 0xE0, 0x3E,
  0x00, 0x7E, 0x01, 0xE0, 0x1F, 0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xC0, 0x1F, 0xC1, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xF8, 0x01, 0xF0,
  0x3E, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0x7C, 0x7C, 0x00,
  0x0F, 0x8F, 0x80, 0x01, 0xF3, 0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x07, 0xCF,
  0x80, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x03, 0xCF, 0x80, 0x00,
  0xF9, 0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7D, 0xF0,
  0x00, 0x1F, 0x3E, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x7C, 0xF8, 0x00, 0x1F,
  0x1F, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x0F, 0x80,
  0x07, 0xC1, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x3E, 0x03, 0xE0, 0x1F, 0x80,
  0x7F, 0x07, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x01, 0xF0, 0x0F, 0xE0, 0x1F, 0x00, 0x3F,
  0x01, 0xF0, 0x01, 0xF0, 0x1E, 0x00, 0x1F, 0x03, 0xE0, 0x01, 0xF0, 0x3E,
  0x00, 0x1F, 0x03, 0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x01,
  0xF0, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x0F,
  0x80, 0x07, 0xC0, 0xF8, 0x01, 0xF8, 0x0F, 0x80, 0x7F, 0x80, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x01,
  0xF0, 0x3E, 0x00, 0x1E, 0x01, 0xF0, 0x03, 0xE0, 0x1F, 0x00, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF8, 0x07, 0xC0, 0x07, 0xC0,
  0x7C, 0x00, 0x7C, 0x07, 0xC0, 0x07, 0xC0, 0x7C, 0x00, 0x3C, 0x0F, 0x80,
  0x03, 0xE0, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xF0, 0x0F, 0x00, 0x7E, 0x00, 0x10, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xFC, 0x06, 0x00, 0x0F, 0xC0, 0x3C, 0x01, 0xFC,
  0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x3E, 0x00, 0x07,
  0xC1, 0xF0, 0x00, 0x3C, 0x0F, 0x80, 0x03, 0xE0, 0x7C, 0x00, 0x1F, 0x03,
  0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x7C, 0x0F, 0x80,
  0x03, 0xE0, 0x78, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF0, 0x3E, 0x00, 0x0F,
  0x81, 0xF0, 0x00, 0x7C, 0x0F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1E, 0x07,
  0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x7C, 0x1F, 0x00,
  0x03, 0xE0, 0xF8, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x0F,
  0x83, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x3E, 0x07,
  0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0xF8, 0x0F, 0x80,
  0x07, 0xC0, 0x7C, 0x00, 0x7C, 0x03, 0xE0, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0x7E, 0x07, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7C, 0xF8, 0x00,
  0x07, 0xCF, 0x80, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF0,
  0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x3E, 0x0F, 0x80,
  0x07, 0xC0, 0xF8, 0x00, 0x7C, 0x07, 0x80, 0x0F, 0x80, 0x78, 0x00, 0xF8,
  0x07, 0x80, 0x1F, 0x00, 0x78, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0x7C,
  0x03, 0xE0, 0x07, 0xC0, 0x7C, 0x00, 0x7C, 0x07, 0xC0, 0x07, 0xC0, 0xF8,
  0x00, 0x7C, 0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x07,
  0xC3, 0xE0, 0x00, 0x7C, 0x3C, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x3C, 0x78,
  0x00, 0x03, 0xCF, 0x80, 0x00, 0x3C, 0xF0, 0x00, 0x03, 0xDF, 0x00, 0x00,
  0x3D, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x03, 0xE0,
  0x00, 0x1F, 0x03, 0xE0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0x1E, 0x03, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3E, 0x07, 0xC0,
  0x00, 0x3C, 0x07, 0x80, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x7C, 0x07, 0x80,
  0x00, 0x78, 0x0F, 0x80, 0x00, 0x78, 0x0F, 0x80, 0x00, 0x78, 0x0F, 0x00,
  0x00, 0xF8, 0x0F, 0x03, 0xC0, 0xF0, 0x0F, 0x07, 0xC0, 0xF0, 0x1F, 0x0F,
  0xC1, 0xF0, 0x1E, 0x0F, 0xC1, 0xE0, 0x1E, 0x1F, 0xC1, 0xE0, 0x1E, 0x1D,
  0xC1, 0xE0, 0x1E, 0x3D, 0xE3, 0xC0, 0x1E, 0x39, 0xE3, 0xC0, 0x3C, 0x79,
  0xE3, 0xC0, 0x3C, 0x71, 0xE3, 0x80, 0x3C, 0xF1, 0xE7, 0x80, 0x3C, 0xE0,
  0xE7, 0x80, 0x3D, 0xE0, 0xE7, 0x00, 0x3B, 0xC0, 0xEF, 0x00, 0x3B, 0xC0,
  0xEF, 0x00, 0x7F, 0x80, 0xEE, 0x00, 0x7F, 0x80, 0xEE, 0x00, 0x7F, 0x00,
  0xFE, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x7C, 0x00,
  0xFC, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x78, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x07, 0xE0, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x0F, 0x80, 0x01, 0xF0, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x0F, 0xC1,
  0xF8, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x03,
  0xF3, 0xE0, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07,
  0xEF, 0x00, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x00, 0x3E, 0x1E, 0x00, 0x00,
  0x0F, 0xC3, 0xE0, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x00, 0xFC, 0x0F, 0x80,
  0x00, 0x3F, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x01, 0xF8, 0x03,
  0xE0, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x07, 0xE0,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x0F,
  0xC0, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7E, 0xF8,
  0x00, 0x07, 0xCF, 0x80, 0x00, 0xFC, 0xF8, 0x00, 0x0F, 0x87, 0x80, 0x01,
  0xF0, 0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x03,
  0xC0, 0x0F, 0x80, 0x3C, 0x01, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x3E, 0x03,
  0xE0, 0x01, 0xE0, 0x7C, 0x00, 0x1F, 0x07, 0x80, 0x01, 0xF0, 0xF8, 0x00,
  0x0F, 0x1F, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x0F, 0xBC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF,
  0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE0,
  0xF0, 0x78, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E,
  0x1F, 0x0F, 0x83, 0xC1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x0F, 0x07, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C,
  0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x3E, 0x1F, 0x0F, 0x87,
  0xC3, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F,
  0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3E,
  0xF0, 0x00, 0x7E, 0xF8, 0x00, 0x7C, 0x78, 0x00, 0xF8, 0x78, 0x01, 0xF0,
  0x7C, 0x03, 0xF0, 0x7C, 0x07, 0xE0, 0x3C, 0x07, 0xC0, 0x3E, 0x0F, 0x80,
  0x3E, 0x1F, 0x00, 0x1E, 0x3F, 0x00, 0x1F, 0x7E, 0x00, 0x1F, 0x7C, 0x00,
  0x0F, 0x38, 0x00, 0x0F, 0x10, 0x00, 0x0C, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x10, 0x07, 0x01,
  0xF0, 0x3F, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x38, 0x02,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0x03, 0xFE, 0x07, 0x81, 0xFC, 0x01, 0xE0, 0xFE, 0x00, 0xF8,
  0x3F, 0x00, 0x3E, 0x1F, 0x80, 0x0F, 0x8F, 0xC0, 0x03, 0xC3, 0xE0, 0x01,
  0xF0, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x1F, 0x00, 0x07, 0x87, 0xC0,
  0x03, 0xE3, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x0F,
  0x80, 0x07, 0xC3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x1F,
  0x07, 0xC0, 0x0F, 0xC1, 0xF0, 0x07, 0xF0, 0x7F, 0x07, 0xFC, 0x0F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xF8, 0xF0, 0x03, 0xF8, 0x3C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF9, 0xFC, 0x00, 0x3F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x01, 0xFE, 0x0F, 0xE0, 0x7C,
  0x01, 0xF8, 0x1E, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xC3, 0xE0, 0x01, 0xF0,
  0xF8, 0x00, 0x7C, 0x3C, 0x00, 0x1F, 0x0F, 0x00, 0x07, 0xC7, 0xC0, 0x01,
  0xF1, 0xF0, 0x00, 0x78, 0x7C, 0x00, 0x3E, 0x1E, 0x00, 0x0F, 0x8F, 0x80,
  0x03, 0xE3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x3C, 0x00, 0x3F, 0x1F,
  0x00, 0x1F, 0x87, 0xC0, 0x0F, 0xC1, 0xF0, 0x07, 0xF0, 0x78, 0x03, 0xF8,
  0x1E, 0x07, 0xFC, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0xF0,
  0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFC, 0x01, 0x81, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x20, 0x3F,
  0xC0, 0x78, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x0F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xE0, 0x7C, 0x01, 0xFC, 0x03,
  0xE0, 0x1F, 0x80, 0x1F, 0x01, 0xF8, 0x00, 0xF0, 0x0F, 0x80, 0x0F, 0x80,
  0xF8, 0x00, 0x7C, 0x0F, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x1E, 0x03, 0xE0,
  0x01, 0xF0, 0x3E, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x7C, 0x0F, 0x80, 0x03,
  0xC0, 0x7C, 0x00, 0x3E, 0x03, 0xE0, 0x01, 0xF0, 0x1F, 0x00, 0x0F, 0x80,
  0xF8, 0x00, 0x78, 0x07, 0xC0, 0x03, 0xC0, 0x3E, 0x00, 0x1E, 0x01, 0xF0,
  0x01, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x03, 0xFC, 0x01, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xEF, 0x00, 0x1F, 0xFC, 0x7C, 0x00, 0x3F, 0x83, 0xC0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFE, 0x03, 0xF8, 0x1F, 0x81, 0xF8, 0x03, 0xF0, 0xFC, 0x00, 0x7C,
  0x7E, 0x00, 0x1F, 0x1F, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xE3, 0xE0, 0x00,
  0xF9, 0xF0, 0x00, 0x7E, 0x7C, 0x00, 0x7F, 0x1F, 0x01, 0xFF, 0x87, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x20, 0x3F, 0x80, 0x78, 0x07, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0x81, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xE0, 0x7C, 0x01, 0xFC, 0x03, 0xE0,
  0x0F, 0xE0, 0x0F, 0x80, 0x7E, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0xF8, 0x0F,
  0xC0, 0x07, 0xC0, 0x3E, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x7C, 0x07, 0xC0,
  0x01, 0xF0, 0x1F, 0x00, 0x07, 0x80, 0x78, 0x00, 0x3E, 0x03, 0xE0, 0x00,
  0xF8, 0x0F, 0x80, 0x03, 0xE0, 0x3E, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x7C,
  0x03, 0xE0, 0x01, 0xF0, 0x0F, 0x80, 0x07, 0xC0, 0x3F, 0x00, 0x3E, 0x00,
  0x7E, 0x07, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFC, 0x00, 0x07, 0xF9, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x20, 0x00, 0xFC, 0x01, 0xF0, 0x0F, 0xE0, 0x07, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x3F, 0x80, 0x0F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x03, 0xF0, 0x1F, 0x81, 0xF0, 0x07, 0xE0,
  0xF8, 0x01, 0xF0, 0x78, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x3E,
  0x1F, 0x00, 0x1F, 0x0F, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0xC7, 0xC0, 0x07,
  0xC3, 0xE0, 0x03, 0xE1, 0xE0, 0x01, 0xF1, 0xF0, 0x00, 0xF8, 0xF8, 0x00,
  0x78, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x1F, 0x00,
  0x0F, 0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x07, 0xC7, 0xC0, 0x03, 0xE3, 0xE0,
  0x01, 0xF1, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00,
  0x3F, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xF8,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x87, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00,
  0xFF, 0xF0, 0x3F, 0xF8, 0x0F, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x40, 0x0F, 0xC0, 0x07,
  0x80, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x03, 0xF0, 0x3E,
  0x00, 0xFE, 0x03, 0xC0, 0x1F, 0xC0, 0x7C, 0x03, 0xF0, 0x07, 0xC0, 0xFE,
  0x00, 0x7C, 0x1F, 0xC0, 0x07, 0x83, 0xF8, 0x00, 0xF8, 0xFF, 0x00, 0x0F,
  0x9F, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0x7E, 0x00, 0x03,
  0xE3, 0xF0, 0x00, 0x3E, 0x1F, 0x80, 0x03, 0xE0, 0xFC, 0x00, 0x3E, 0x07,
  0xC0, 0x03, 0xC0, 0x7E, 0x00, 0x7C, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF8, 0x07, 0x80, 0x0F, 0x80, 0xF8, 0x00, 0xFC, 0x0F, 0x80,
  0x07, 0xC0, 0xF8, 0x00, 0x7E, 0x00, 0xFF, 0xF9, 0xFF, 0xF3, 0xFF, 0xE7,
  0xFF, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x2F, 0xC1, 0xDF, 0xFF, 0x9F, 0xFF, 0x1F, 0xFE, 0x1F,
  0xE0, 0x00, 0x7F, 0x07, 0xC0, 0x1F, 0xFC, 0xFF, 0x00, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xE0, 0x7C, 0x3F, 0x1F, 0x83, 0xE1, 0xF0, 0x7C, 0x1E,
  0x07, 0x83, 0xE0, 0xF0, 0x7C, 0x1F, 0x0F, 0x83, 0xE0, 0xF0, 0x7C, 0x1E,
  0x07, 0x83, 0xC0, 0xF0, 0x7C, 0x1E, 0x0F, 0x83, 0xE0, 0xF0, 0x7C, 0x1E,
  0x0F, 0x83, 0xC0, 0xF0, 0x78, 0x1E, 0x0F, 0x83, 0xC1, 0xF0, 0x7C, 0x1E,
  0x0F, 0x83, 0xC1, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0xF0, 0x78, 0x00,
  0x0F, 0x83, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x1E,
  0x0F, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x78, 0x3E,
  0x00, 0x03, 0xC1, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x7E, 0x03, 0xF0, 0x3E,
  0x00, 0xFC, 0x1F, 0x00, 0x3E, 0x0F, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x87,
  0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE1, 0xE0, 0x01, 0xF1, 0xF0, 0x00, 0xF8,
  0xF8, 0x00, 0x78, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x1F,
  0x1F, 0x00, 0x0F, 0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x07, 0xC3, 0xC0, 0x03,
  0xE3, 0xE0, 0x01, 0xE1, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x78, 0x00,
  0x7C, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0,
  0x7F, 0x07, 0xF0, 0x7E, 0x00, 0xF8, 0x7E, 0x00, 0x7C, 0x3E, 0x00, 0x1F,
  0x3F, 0x00, 0x0F, 0x9F, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xEF, 0x80, 0x01,
  0xF7, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7B, 0xE0, 0x00, 0x7D, 0xF0, 0x00,
  0x3E, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0xBE, 0x00, 0x0F, 0x9F, 0x00,
  0x07, 0xCF, 0x80, 0x07, 0xC7, 0xC0, 0x07, 0xE3, 0xE0, 0x07, 0xE1, 0xF8,
  0x07, 0xE0, 0x7E, 0x0F, 0xF0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x03,
  0xFF, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xC0, 0x7F,
  0x00, 0x7C, 0x01, 0xF8, 0x03, 0xC0, 0x07, 0xC0, 0x3E, 0x00, 0x1F, 0x01,
  0xF0, 0x00, 0xF8, 0x0F, 0x80, 0x07, 0xC0, 0x7C, 0x00, 0x3E, 0x07, 0xC0,
  0x01, 0xF0, 0x3E, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x7C, 0x0F, 0x80, 0x07,
  0xC0, 0xF8, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x81,
  0xF0, 0x00, 0xF8, 0x1F, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x7C, 0x07, 0xC0,
  0x07, 0xC0, 0x3E, 0x00, 0x7E, 0x03, 0xE0, 0x0F, 0xE0, 0x1F, 0x01, 0xFE,
  0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x03,
  0xFF, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x03, 0xFC, 0x0F, 0x81, 0xFC, 0x03, 0xE0, 0xFC, 0x00, 0xF8, 0x7E,
  0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC7, 0xE0, 0x01, 0xF1,
  0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x8F, 0x80, 0x03,
  0xE3, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x0F, 0x80,
  0x07, 0xC3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x0F,
  0x80, 0x0F, 0x83, 0xF0, 0x07, 0xE0, 0x7E, 0x07, 0xF0, 0x1F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xF3, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0xF8, 0x01, 0x00, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0,
  0x3F, 0x80, 0x60, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0xC0,
  0x03, 0xE0, 0x78, 0x07, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x01, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0xC0, 0x7F, 0xFF, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x01, 0xFE, 0x00,
  0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x07, 0xC7, 0xC0, 0x03, 0xE3, 0xE0, 0x01,
  0xF1, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x78, 0x00, 0x7C, 0x7C, 0x00,
  0x3E, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x0F, 0x00, 0x0F, 0x8F, 0x80,
  0x07, 0xC7, 0xC0, 0x03, 0xC3, 0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xF1, 0xF0,
  0x00, 0xF8, 0xF8, 0x00, 0x78, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x1F,
  0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x0F, 0xC3, 0xF0, 0x0F, 0xE0,
  0xFC, 0x1F, 0xF0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0x1E,
  0x00, 0xFE, 0x0F, 0x00, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00,
  0x3E, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0xF8, 0xF8, 0x00,
  0xF8, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x03, 0xE0, 0x78, 0x03,
  0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0x7C, 0x0F,
  0x80, 0x7C, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x3C, 0x7C,
  0x00, 0x3E, 0xFC, 0x00, 0x3E, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x3C,
  0xF8, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0xF1, 0xE0,
  0x00, 0x0F, 0x8F, 0x01, 0xE0, 0x78, 0x78, 0x1F, 0x03, 0xC3, 0xC0, 0xF8,
  0x3E, 0x1E, 0x0F, 0xC1, 0xE0, 0xF0, 0x7E, 0x0F, 0x0F, 0x87, 0xF0, 0xF8,
  0x7C, 0x3F, 0x87, 0x83, 0xE3, 0xDC, 0x3C, 0x1E, 0x3C, 0xE3, 0xC0, 0xF1,
  0xE7, 0x9E, 0x07, 0x9E, 0x3D, 0xE0, 0x3D, 0xE1, 0xEF, 0x01, 0xEF, 0x0F,
  0xF8, 0x0F, 0xF0, 0x7F, 0x80, 0x7F, 0x03, 0xFC, 0x03, 0xF8, 0x0F, 0xC0,
  0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3C,
  0x00, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x7C, 0x01, 0xF0, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x03, 0xE0, 0x1F, 0x80, 0x07, 0xE0, 0x3E, 0x00, 0x07,
  0xC0, 0xF8, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x1F,
  0xBE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFD, 0xF8,
  0x00, 0x03, 0xF1, 0xF0, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x3F, 0x03, 0xE0,
  0x00, 0xFC, 0x07, 0xC0, 0x03, 0xF0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x07,
  0xC0, 0x0F, 0x80, 0x07, 0xE0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x07, 0xC0,
  0x3E, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0x7C,
  0x0F, 0x80, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x00,
  0xF9, 0xF0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x40, 0x7E, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x01, 0x81, 0xFF, 0x00, 0x78, 0x7F, 0xF8, 0x0F, 0x1F, 0xFF, 0xC7, 0xC3,
  0xE3, 0xFF, 0xF8, 0xF0, 0x1F, 0xFE, 0x1E, 0x00, 0xFF, 0x81, 0x80, 0x0F,
  0xC0,
};

const GFXglyph UbuntuMono_Italic59pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 30, 0, -1 },
  { 1, 14, 37, 30, 10, -37 },
  { 66, 17, 15, 30, 13, -40 },
  { 98, 32, 37, 30, 2, -37 },
  { 246, 28, 47, 30, 4, -41 },
  { 411, 36, 37, 30, 0, -37 },
  { 578, 26, 37, 30, 3, -37 },
  { 699, 7, 16, 30, 18, -40 },
  { 713, 22, 51, 30, 9, -41 },
  { 854, 23, 51, 30, 3, -41 },
  { 1001, 23, 22, 30, 8, -37 },
  { 1065, 25, 26, 30, 5, -29 },
  { 1147, 13, 16, 30, 6, -8 },
  { 1173, 14, 5, 30, 10, -18 },
  { 1182, 9, 8, 30, 10, -8 },
  { 1191, 34, 51, 30, -1, -41 },
  { 1408, 26, 37, 30, 5, -37 },
  { 1529, 22, 37, 30, 5, -37 },
  { 1631, 27, 37, 30, 4, -37 },
  { 1756, 26, 37, 30, 4, -37 },
  { 1877, 27, 37, 30, 3, -37 },
  { 2002, 30, 37, 30, 3, -37 },
  { 2141, 26, 37, 30, 6, -37 },
  { 2262, 27, 37, 30, 8, -37 },
  { 2387, 27, 37, 30, 5, -37 },
  { 2512, 28, 37, 30, 4, -37 },
  { 2642, 13, 27, 30, 10, -27 },
  { 2686, 17, 35, 30, 6, -27 },
  { 2761, 26, 24, 30, 5, -27 },
  { 2839, 27, 15, 30, 4, -23 },
  { 2890, 26, 24, 30, 4, -27 },
  { 2968, 21, 37, 30, 10, -37 },
  { 3066, 29, 45, 30, 4, -37 },
  { 3230, 29, 37, 30, -1, -37 },
  { 3365, 28, 37, 30, 3, -37 },
  { 3495, 29, 37, 30, 5, -37 },
  { 3630, 29, 37, 30, 2, -37 },
  { 3765, 29, 37, 30, 4, -37 },
  { 3900, 30, 37, 30, 4, -37 },
  { 4039, 28, 37, 30, 5, -37 },
  { 4169, 32, 37, 30, 2, -37 },
  { 4317, 28, 37, 30, 4, -37 },
  { 4447, 29, 37, 30, 4, -37 },
  { 4582, 32, 37, 30, 3, -37 },
  { 4730, 22, 37, 30, 3, -37 },
  { 4832, 32, 37, 30, 1, -37 },
  { 4980, 32, 37, 30, 2, -37 },
  { 5128, 27, 37, 30, 5, -37 },
  { 5253, 29, 37, 30, 3, -37 },
  { 5388, 27, 47, 30, 5, -37 },
  { 5547, 28, 37, 30, 3, -37 },
  { 5677, 29, 37, 30, 3, -37 },
  { 5812, 26, 37, 30, 9, -37 },
  { 5933, 29, 37, 30, 5, -37 },
  { 6068, 28, 37, 30, 8, -37 },
  { 6198, 32, 37, 30, 3, -37 },
  { 6346, 35, 37, 30, 1, -37 },
  { 6508, 28, 37, 30, 9, -37 },
  { 6638, 32, 37, 30, 2, -37 },
  { 6786, 26, 51, 30, 6, -41 },
  { 6952, 9, 51, 30, 13, -41 },
  { 7010, 27, 51, 30, 1, -41 },
  { 7183, 24, 20, 30, 6, -37 },
  { 7243, 28, 4, 30, -2, 6 },
  { 7257, 11, 11, 30, 15, -41 },
  { 7273, 26, 29, 30, 4, -28 },
  { 7368, 26, 42, 30, 4, -41 },
  { 7505, 26, 29, 30, 4, -28 },
  { 7600, 29, 42, 30, 5, -41 },
  { 7753, 26, 29, 30, 4, -28 },
  { 7848, 34, 51, 30, 1, -41 },
  { 8065, 30, 38, 30, 1, -28 },
  { 8208, 25, 41, 30, 3, -41 },
  { 8337, 17, 39, 30, 8, -39 },
  { 8420, 29, 49, 30, 1, -39 },
  { 8598, 28, 41, 30, 4, -41 },
  { 8742, 15, 42, 30, 11, -41 },
  { 8821, 29, 28, 30, 2, -28 },
  { 8923, 25, 28, 30, 4, -28 },
  { 9011, 25, 29, 30, 5, -28 },
  { 9102, 29, 38, 30, 1, -28 },
  { 9240, 26, 38, 30, 5, -28 },
  { 9364, 26, 28, 30, 5, -28 },
  { 9455, 25, 29, 30, 5, -28 },
  { 9546, 22, 37, 30, 8, -36 },
  { 9648, 25, 28, 30, 5, -27 },
  { 9736, 24, 27, 30, 8, -27 },
  { 9817, 29, 27, 30, 5, -27 },
  { 9915, 31, 27, 30, 1, -27 },
  { 10020, 33, 37, 30, -1, -27 },
  { 10173, 27, 27, 30, 3, -27 },
  { 10265, 29, 51, 30, 5, -41 },
  { 10450, 17, 51, 30, 9, -41 },
  { 10559, 28, 51, 30, 0, -41 },
  { 10738, 27, 8, 30, 4, -19 },
};

const GFXfont UbuntuMono_Italic59pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Italic59pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Italic59pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _UBUNTUMONO_ITALIC59PT7B_H_
