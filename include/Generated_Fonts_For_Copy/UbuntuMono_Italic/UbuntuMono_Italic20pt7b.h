#ifndef _UBUNTUMONO_ITALIC20PT7B_H_
#define _UBUNTUMONO_ITALIC20PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Italic.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Italic20pt7bBitmaps[] PROGMEM = {
  0x00, 0x18, 0xC6, 0x23, 0x18, 0x80, 0x03, 0x38, 0xC0, 0x6D, 0x34, 0x92,
  0x88, 0x04, 0x43, 0x30, 0x89, 0xFF, 0x7F, 0xC4, 0x43, 0x30, 0xC8, 0xFF,
  0xBF, 0xE4, 0x43, 0x20, 0x03, 0x00, 0xC0, 0xF8, 0x7E, 0x18, 0x04, 0x01,
  0x80, 0x78, 0x0F, 0x00, 0xC0, 0x11, 0x0C, 0x7F, 0x1F, 0x01, 0x00, 0x40,
  0x1C, 0x31, 0xC6, 0x34, 0xC2, 0x48, 0x3D, 0x03, 0xA0, 0x05, 0xC0, 0xBC,
  0x1A, 0x43, 0x24, 0x63, 0xC4, 0x38, 0x0F, 0x0F, 0x8C, 0x46, 0x61, 0xC1,
  0xCD, 0xB4, 0x8E, 0xC6, 0x63, 0x3F, 0xCE, 0x60, 0x6B, 0x68, 0x02, 0x0C,
  0x30, 0xC3, 0x0C, 0x18, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x18, 0x30,
  0x20, 0x08, 0x0C, 0x06, 0x06, 0x02, 0x03, 0x03, 0x03, 0x02, 0x02, 0x06,
  0x0C, 0x0C, 0x18, 0x30, 0xE0, 0x40, 0x10, 0x22, 0x4F, 0xF1, 0x0D, 0x91,
  0x00, 0x0C, 0x08, 0x08, 0x18, 0xFF, 0x10, 0x10, 0x30, 0x30, 0x37, 0x33,
  0x6C, 0xFF, 0x7D, 0x80, 0x00, 0x60, 0x08, 0x03, 0x00, 0xC0, 0x10, 0x06,
  0x00, 0x80, 0x30, 0x04, 0x01, 0x80, 0x60, 0x08, 0x03, 0x00, 0x40, 0x18,
  0x02, 0x00, 0xC0, 0x00, 0x0E, 0x3F, 0x71, 0x61, 0xC1, 0xD9, 0xDB, 0x9B,
  0x86, 0xCE, 0xFC, 0x78, 0x06, 0x1C, 0x71, 0xA2, 0xC1, 0x82, 0x04, 0x18,
  0x33, 0xFF, 0xF0, 0x0F, 0x0F, 0xC4, 0x20, 0x10, 0x18, 0x1C, 0x3C, 0x38,
  0x30, 0x30, 0x1F, 0xDF, 0xE0, 0x0F, 0x0F, 0xC4, 0x60, 0x10, 0x18, 0x78,
  0x3C, 0x06, 0x01, 0x21, 0xBF, 0xCF, 0x80, 0x01, 0x81, 0xC1, 0xE1, 0xA1,
  0x91, 0x99, 0x8C, 0x84, 0xFF, 0xFF, 0xC1, 0x80, 0x80, 0x0F, 0xC3, 0xF0,
  0x80, 0x60, 0x1C, 0x0F, 0xC0, 0x30, 0x04, 0x01, 0x10, 0xCF, 0xE1, 0xF0,
  0x03, 0x87, 0xCE, 0x04, 0x05, 0xE7, 0xFB, 0x0D, 0x86, 0xC3, 0x63, 0x3F,
  0x8F, 0x00, 0x7F, 0xBF, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x40, 0x60, 0x60,
  0x30, 0x30, 0x18, 0x00, 0x1F, 0x1F, 0xCC, 0x6C, 0x36, 0x31, 0xE0, 0xF9,
  0x86, 0x83, 0x43, 0x3F, 0x8F, 0x00, 0x0F, 0x07, 0xE3, 0x0C, 0xC3, 0x20,
  0xCC, 0x23, 0xF8, 0x7E, 0x03, 0x01, 0x87, 0xC1, 0xC0, 0x39, 0xCE, 0x00,
  0x01, 0x9C, 0x60, 0x1C, 0x71, 0xC0, 0x00, 0x03, 0x1C, 0x30, 0xC6, 0x30,
  0x01, 0x06, 0x18, 0xE0, 0xC0, 0xF0, 0x1C, 0x06, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x20, 0x0E, 0x01, 0xC0, 0x30, 0x70, 0xE1, 0xC1, 0x00, 0x3E, 0x7C,
  0x88, 0x10, 0xC2, 0x08, 0x00, 0x00, 0xC3, 0x86, 0x00, 0x07, 0x87, 0xF1,
  0x8C, 0xC1, 0x60, 0x59, 0xF4, 0xFD, 0x22, 0xD9, 0xB3, 0xEC, 0xF1, 0x00,
  0x40, 0x18, 0x01, 0xC0, 0x03, 0x81, 0xC1, 0x61, 0xB0, 0x98, 0xC4, 0x42,
  0x61, 0x3F, 0xBF, 0xD8, 0x38, 0x10, 0x1F, 0x1F, 0xCC, 0x26, 0x12, 0x1B,
  0xF9, 0xFC, 0xC3, 0x41, 0xA1, 0xBF, 0xDF, 0x80, 0x0F, 0x8F, 0xCC, 0x2C,
  0x0C, 0x06, 0x03, 0x01, 0x00, 0xC0, 0x61, 0x3F, 0x87, 0x80, 0x1E, 0x1F,
  0xCC, 0x66, 0x12, 0x0B, 0x05, 0x82, 0x83, 0x43, 0x63, 0xBF, 0x9F, 0x00,
  0x1F, 0xC7, 0xF1, 0x80, 0x40, 0x30, 0x0F, 0xC3, 0xF0, 0x80, 0x60, 0x18,
  0x07, 0xF1, 0xFC, 0x1F, 0xC7, 0xF1, 0x80, 0x40, 0x30, 0x0F, 0xC3, 0xF0,
  0x80, 0x60, 0x18, 0x04, 0x01, 0x00, 0x0F, 0x1F, 0xDC, 0x2C, 0x0C, 0x06,
  0x02, 0x0D, 0x06, 0x82, 0x63, 0x3F, 0x8F, 0x80, 0x10, 0x46, 0x08, 0xC3,
  0x10, 0x62, 0x08, 0xFF, 0x1F, 0xE3, 0x0C, 0x41, 0x18, 0x23, 0x0C, 0x41,
  0x80, 0x1F, 0xC7, 0xF0, 0x60, 0x18, 0x04, 0x03, 0x00, 0xC0, 0x30, 0x08,
  0x06, 0x07, 0xE1, 0xF8, 0x0F, 0xC3, 0xF0, 0x08, 0x02, 0x01, 0x80, 0x60,
  0x10, 0x0C, 0x03, 0x11, 0x8F, 0xE1, 0xF0, 0x10, 0xC6, 0x30, 0xCC, 0x1B,
  0x02, 0xC0, 0x70, 0x1E, 0x03, 0x60, 0x46, 0x08, 0x43, 0x0C, 0x61, 0x80,
  0x18, 0x20, 0xC1, 0x83, 0x04, 0x18, 0x30, 0x40, 0x83, 0xFF, 0xF0, 0x0C,
  0x61, 0x8C, 0x72, 0x8A, 0xF1, 0x56, 0x6E, 0x89, 0x91, 0x02, 0x60, 0xCC,
  0x19, 0x02, 0x60, 0x40, 0x18, 0x47, 0x08, 0xE3, 0x14, 0x62, 0xC8, 0xC9,
  0x19, 0x62, 0x2C, 0x47, 0x18, 0x63, 0x0C, 0x41, 0x80, 0x1E, 0x1F, 0x9C,
  0x6C, 0x3C, 0x1E, 0x0E, 0x05, 0x06, 0x83, 0x63, 0x3F, 0x0F, 0x00, 0x1F,
  0x07, 0xE3, 0x0C, 0xC3, 0x30, 0xC8, 0x67, 0xF1, 0xF8, 0x60, 0x10, 0x0C,
  0x03, 0x00, 0x1E, 0x1F, 0x9C, 0x6C, 0x3C, 0x1E, 0x0E, 0x05, 0x06, 0x83,
  0x63, 0x3F, 0x0F, 0x03, 0x01, 0xE0, 0x30, 0x1F, 0x0F, 0xE3, 0x0C, 0xC3,
  0x20, 0x88, 0x67, 0xF1, 0xF8, 0x46, 0x10, 0x8C, 0x33, 0x0C, 0x0F, 0x87,
  0xF1, 0x08, 0xC0, 0x38, 0x07, 0x80, 0xF0, 0x0C, 0x01, 0x10, 0xCF, 0xF1,
  0xF0, 0xFF, 0xFF, 0xC6, 0x03, 0x01, 0x01, 0x80, 0xC0, 0x60, 0x20, 0x30,
  0x18, 0x0C, 0x00, 0x20, 0x98, 0x66, 0x19, 0x06, 0xC1, 0x30, 0xC8, 0x32,
  0x08, 0x86, 0x31, 0x8F, 0xC1, 0xE0, 0x81, 0xC0, 0xA0, 0xD0, 0x4C, 0x66,
  0x23, 0x31, 0x90, 0xD8, 0x78, 0x38, 0x1C, 0x00, 0x30, 0x66, 0x0C, 0x81,
  0x10, 0x66, 0x0C, 0xD9, 0x13, 0x22, 0xEC, 0x55, 0x0C, 0xE3, 0x9C, 0x61,
  0x00, 0x08, 0x30, 0xC6, 0x0C, 0xC0, 0x78, 0x07, 0x00, 0x70, 0x07, 0x00,
  0xD0, 0x19, 0x03, 0x18, 0x61, 0x86, 0x08, 0xC1, 0xE0, 0xF0, 0xC8, 0xC4,
  0x43, 0x60, 0xE0, 0x60, 0x30, 0x10, 0x18, 0x0C, 0x00, 0x1F, 0xC7, 0xF0,
  0x0C, 0x04, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x20, 0x10, 0x0F, 0xF3, 0xFC,
  0x0F, 0x87, 0xC2, 0x03, 0x01, 0x80, 0x80, 0x40, 0x60, 0x30, 0x10, 0x08,
  0x0C, 0x06, 0x02, 0x01, 0x01, 0xF0, 0xF8, 0x00, 0xD9, 0x24, 0x9B, 0x6D,
  0xB6, 0xC9, 0x20, 0x07, 0x87, 0xC0, 0x60, 0x30, 0x10, 0x08, 0x0C, 0x06,
  0x02, 0x01, 0x01, 0x80, 0xC0, 0x40, 0x60, 0x30, 0xF8, 0x78, 0x00, 0x06,
  0x0E, 0x1A, 0x32, 0x23, 0x61, 0x41, 0x7F, 0xC0, 0x44, 0x22, 0x0F, 0x9F,
  0xDC, 0x6C, 0x24, 0x36, 0x1B, 0x1C, 0xFE, 0x3F, 0x00, 0x18, 0x0C, 0x06,
  0x02, 0x03, 0x01, 0xF8, 0xFE, 0x63, 0x21, 0xB0, 0xD8, 0x68, 0xE7, 0xE7,
  0xE0, 0x0F, 0x9F, 0xDC, 0x0C, 0x04, 0x06, 0x01, 0x84, 0xFE, 0x3E, 0x00,
  0x00, 0xC0, 0x20, 0x18, 0x06, 0x01, 0x87, 0xE3, 0xD1, 0x8C, 0xC3, 0x20,
  0xC8, 0x73, 0x1C, 0xFE, 0x1E, 0x80, 0x0F, 0x1F, 0xDC, 0x6C, 0x37, 0xF7,
  0xE3, 0x04, 0xFE, 0x3E, 0x00, 0x00, 0xF0, 0x1F, 0x03, 0x00, 0x30, 0x02,
  0x01, 0xFE, 0x1F, 0xE0, 0x60, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x08,
  0x01, 0x80, 0x18, 0x0F, 0x00, 0xF0, 0x00, 0x07, 0xE1, 0xF8, 0x73, 0x18,
  0x63, 0x0C, 0x41, 0x0C, 0x21, 0xFC, 0x1F, 0x80, 0x61, 0xFC, 0x3E, 0x00,
  0x18, 0x0C, 0x04, 0x06, 0x03, 0x01, 0xF0, 0xFC, 0xC2, 0x61, 0x30, 0x98,
  0xD8, 0x6C, 0x36, 0x10, 0x18, 0xE1, 0x80, 0xF3, 0xC3, 0x08, 0x61, 0x86,
  0x1E, 0x38, 0x00, 0xC0, 0x70, 0x0C, 0x00, 0x0F, 0x83, 0xE0, 0x18, 0x06,
  0x01, 0x00, 0xC0, 0x30, 0x08, 0x02, 0x01, 0x87, 0xC1, 0xE0, 0x18, 0x06,
  0x01, 0x80, 0x40, 0x10, 0x0C, 0x63, 0x30, 0xD8, 0x2C, 0x1E, 0x06, 0xC1,
  0x98, 0x46, 0x30, 0xC0, 0xF7, 0x8C, 0x42, 0x31, 0x88, 0xC6, 0x31, 0x9F,
  0xB8, 0x3F, 0x9F, 0xD9, 0x2D, 0x94, 0xCA, 0x4F, 0x05, 0x82, 0x83, 0x00,
  0x1F, 0x1F, 0xCC, 0x64, 0x36, 0x1B, 0x0D, 0x84, 0x86, 0xC3, 0x00, 0x1E,
  0x7F, 0x63, 0xC3, 0x83, 0x83, 0xC6, 0xFC, 0x78, 0x0F, 0x87, 0xF1, 0x8C,
  0x43, 0x30, 0xCC, 0x32, 0x38, 0xFC, 0x7E, 0x18, 0x04, 0x03, 0x00, 0x1F,
  0x9F, 0x98, 0xD8, 0x68, 0x24, 0x33, 0x19, 0xFC, 0x7C, 0x06, 0x03, 0x01,
  0x80, 0x1F, 0x3F, 0x60, 0x60, 0x60, 0x40, 0xC0, 0xC0, 0xC0, 0x1F, 0x3F,
  0x60, 0x70, 0x3C, 0x0E, 0x86, 0xFC, 0xF8, 0x10, 0x60, 0xC7, 0xFF, 0xEC,
  0x18, 0x20, 0x40, 0x81, 0xF3, 0xE0, 0x61, 0x43, 0xC3, 0xC2, 0x86, 0x86,
  0xCE, 0xFE, 0x7E, 0x83, 0x86, 0x86, 0xCC, 0xCC, 0xD8, 0xD0, 0x70, 0x60,
  0xC0, 0xB0, 0x28, 0x9A, 0x64, 0xBB, 0x2A, 0x8E, 0xA3, 0x38, 0x8C, 0x00,
  0x18, 0xC1, 0x10, 0x34, 0x03, 0x80, 0x60, 0x1C, 0x06, 0xC1, 0x88, 0x61,
  0x80, 0x10, 0x63, 0x18, 0x63, 0x0C, 0x41, 0x98, 0x16, 0x03, 0xC0, 0x70,
  0x0C, 0x03, 0x03, 0xE0, 0x70, 0x00, 0x1F, 0x9F, 0xC0, 0xC0, 0xC1, 0x81,
  0x81, 0x81, 0xFC, 0xFE, 0x00, 0x07, 0x87, 0xC3, 0x01, 0x01, 0x80, 0xC0,
  0x40, 0x60, 0xE0, 0x70, 0x08, 0x04, 0x06, 0x02, 0x01, 0x80, 0xF8, 0x38,
  0x00, 0x0C, 0x20, 0x86, 0x18, 0x41, 0x0C, 0x30, 0x82, 0x18, 0x61, 0x04,
  0x30, 0xC0, 0x0F, 0x03, 0xC0, 0x18, 0x04, 0x01, 0x00, 0xC0, 0x30, 0x0C,
  0x01, 0xC0, 0xE0, 0x60, 0x10, 0x04, 0x03, 0x00, 0x83, 0xE0, 0xF0, 0x00,
  0x38, 0xA6, 0x51, 0xC0,
};

const GFXglyph UbuntuMono_Italic20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 5, 12, 10, 3, -12 },
  { 9, 6, 5, 10, 4, -12 },
  { 13, 10, 12, 10, 1, -12 },
  { 28, 10, 16, 10, 1, -14 },
  { 48, 12, 12, 10, 0, -12 },
  { 66, 9, 12, 10, 1, -12 },
  { 80, 3, 5, 10, 6, -14 },
  { 82, 7, 17, 10, 3, -14 },
  { 97, 8, 17, 10, 1, -14 },
  { 114, 7, 7, 10, 3, -12 },
  { 121, 8, 9, 10, 2, -10 },
  { 130, 4, 6, 10, 2, -3 },
  { 133, 4, 2, 10, 4, -6 },
  { 134, 3, 3, 10, 3, -3 },
  { 136, 11, 17, 10, 0, -14 },
  { 160, 8, 12, 10, 2, -12 },
  { 172, 7, 12, 10, 2, -12 },
  { 183, 9, 12, 10, 1, -12 },
  { 197, 9, 12, 10, 1, -12 },
  { 211, 9, 12, 10, 1, -12 },
  { 225, 10, 12, 10, 1, -12 },
  { 240, 9, 12, 10, 2, -12 },
  { 254, 9, 12, 10, 3, -12 },
  { 268, 9, 12, 10, 2, -12 },
  { 282, 10, 12, 10, 1, -12 },
  { 297, 5, 9, 10, 3, -9 },
  { 303, 6, 12, 10, 2, -9 },
  { 312, 8, 8, 10, 2, -10 },
  { 320, 10, 4, 10, 1, -7 },
  { 325, 9, 8, 10, 1, -9 },
  { 334, 7, 12, 10, 3, -12 },
  { 345, 10, 15, 10, 1, -12 },
  { 364, 9, 12, 10, 0, -12 },
  { 378, 9, 12, 10, 1, -12 },
  { 392, 9, 12, 10, 2, -12 },
  { 406, 9, 12, 10, 1, -12 },
  { 420, 10, 12, 10, 1, -12 },
  { 435, 10, 12, 10, 1, -12 },
  { 450, 9, 12, 10, 2, -12 },
  { 464, 11, 12, 10, 1, -12 },
  { 481, 10, 12, 10, 1, -12 },
  { 496, 10, 12, 10, 1, -12 },
  { 511, 11, 12, 10, 1, -12 },
  { 528, 7, 12, 10, 1, -12 },
  { 539, 11, 12, 10, 0, -12 },
  { 556, 11, 12, 10, 1, -12 },
  { 573, 9, 12, 10, 2, -12 },
  { 587, 10, 12, 10, 1, -12 },
  { 602, 9, 15, 10, 2, -12 },
  { 619, 10, 12, 10, 1, -12 },
  { 634, 10, 12, 10, 1, -12 },
  { 649, 9, 12, 10, 3, -12 },
  { 663, 10, 12, 10, 2, -12 },
  { 678, 9, 12, 10, 3, -12 },
  { 692, 11, 12, 10, 1, -12 },
  { 709, 12, 12, 10, 0, -12 },
  { 727, 9, 12, 10, 3, -12 },
  { 741, 10, 12, 10, 1, -12 },
  { 756, 9, 17, 10, 2, -14 },
  { 776, 3, 17, 10, 4, -14 },
  { 783, 9, 17, 10, 0, -14 },
  { 803, 8, 7, 10, 2, -12 },
  { 810, 10, 1, 10, -1, 2 },
  { 812, 4, 4, 10, 5, -14 },
  { 814, 9, 9, 10, 1, -9 },
  { 825, 9, 14, 10, 1, -14 },
  { 841, 9, 9, 10, 1, -9 },
  { 852, 10, 14, 10, 2, -14 },
  { 870, 9, 9, 10, 1, -9 },
  { 881, 12, 17, 10, 0, -14 },
  { 907, 11, 12, 10, 0, -9 },
  { 924, 9, 14, 10, 1, -14 },
  { 940, 6, 13, 10, 3, -13 },
  { 950, 10, 16, 10, 0, -13 },
  { 970, 10, 14, 10, 1, -14 },
  { 988, 5, 14, 10, 4, -14 },
  { 997, 9, 9, 10, 1, -9 },
  { 1008, 9, 9, 10, 1, -9 },
  { 1019, 8, 9, 10, 2, -9 },
  { 1028, 10, 12, 10, 0, -9 },
  { 1043, 9, 12, 10, 2, -9 },
  { 1057, 8, 9, 10, 2, -9 },
  { 1066, 8, 9, 10, 2, -9 },
  { 1075, 7, 12, 10, 3, -12 },
  { 1086, 8, 9, 10, 2, -9 },
  { 1095, 8, 9, 10, 3, -9 },
  { 1104, 10, 9, 10, 2, -9 },
  { 1116, 11, 9, 10, 0, -9 },
  { 1129, 11, 12, 10, 0, -9 },
  { 1146, 9, 9, 10, 1, -9 },
  { 1157, 9, 17, 10, 2, -14 },
  { 1177, 6, 17, 10, 3, -14 },
  { 1190, 10, 17, 10, 0, -14 },
  { 1212, 9, 3, 10, 1, -8 },
};

const GFXfont UbuntuMono_Italic20pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Italic20pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Italic20pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _UBUNTUMONO_ITALIC20PT7B_H_
