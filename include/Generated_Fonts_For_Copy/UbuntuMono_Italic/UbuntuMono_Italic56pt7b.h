#ifndef _UBUNTUMONO_ITALIC56PT7B_H_
#define _UBUNTUMONO_ITALIC56PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Italic.ttf
// Size: 56pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Italic56pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x07, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x1E, 0x00, 0x1E, 0x0F,
  0x3E, 0x0F, 0x3E, 0x1F, 0x3C, 0x1E, 0x3C, 0x1E, 0x3C, 0x1E, 0x78, 0x1E,
  0x78, 0x3C, 0x78, 0x3C, 0x70, 0x3C, 0x70, 0x38, 0x70, 0x38, 0x60, 0x38,
  0xE0, 0x30, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x3C,
  0x07, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0xF8, 0x1E, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x0F, 0x03, 0xC0,
  0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xF8, 0x01, 0xF0, 0x3C, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0xF0, 0x3E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1E, 0x03,
  0xC0, 0x00, 0x78, 0x1E, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x0F, 0x03, 0xE0,
  0x07, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x1E,
  0x07, 0xC0, 0x00, 0x78, 0x1E, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0x7C, 0x0F, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x0F, 0x81, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F,
  0xC0, 0x78, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x20, 0x00,
  0xF8, 0x1F, 0x01, 0xFE, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x1F, 0xE0, 0x01, 0xE0, 0x0F, 0xFC,
  0x00, 0xF0, 0x03, 0xFF, 0x00, 0x78, 0x01, 0xF3, 0xC0, 0x3C, 0x00, 0x78,
  0x70, 0x1E, 0x00, 0x3C, 0x1C, 0x0F, 0x00, 0x0E, 0x07, 0x07, 0xC0, 0x03,
  0x81, 0xC1, 0xE0, 0x00, 0xE0, 0xF0, 0xF0, 0x00, 0x38, 0x3C, 0x78, 0x00,
  0x0E, 0x1E, 0x3C, 0x00, 0x03, 0xCF, 0x9E, 0x00, 0x00, 0xFF, 0xCF, 0x00,
  0x00, 0x3F, 0xF3, 0xC0, 0x00, 0x07, 0xF1, 0xE0, 0x00, 0x00, 0xF8, 0xF0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x7C, 0x00, 0x00, 0x1E,
  0x3F, 0x80, 0x00, 0x0F, 0x9F, 0xF0, 0x00, 0x03, 0xCF, 0xFC, 0x00, 0x01,
  0xE7, 0xCF, 0x00, 0x00, 0xF1, 0xE1, 0xE0, 0x00, 0x78, 0x70, 0x78, 0x00,
  0x3C, 0x3C, 0x1C, 0x00, 0x1E, 0x0E, 0x07, 0x00, 0x07, 0x83, 0x81, 0xC0,
  0x03, 0xC0, 0xE0, 0xF0, 0x01, 0xE0, 0x38, 0x3C, 0x00, 0xF0, 0x0F, 0x1E,
  0x00, 0x78, 0x03, 0xFF, 0x80, 0x3C, 0x00, 0xFF, 0xC0, 0x0F, 0x00, 0x1F,
  0xE0, 0x07, 0x80, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0xC3, 0xE0, 0x07, 0x80,
  0xF0, 0x07, 0xC0, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x3C, 0x00, 0xF0,
  0x1E, 0x00, 0x78, 0x1E, 0x00, 0x3C, 0x1F, 0x00, 0x1E, 0x1F, 0x00, 0x0F,
  0xBF, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x0F, 0x81,
  0xFE, 0x07, 0x81, 0xFF, 0x83, 0xC1, 0xF3, 0xC3, 0xE1, 0xE1, 0xF1, 0xE1,
  0xF0, 0x7C, 0xF1, 0xF0, 0x1E, 0xF0, 0xF0, 0x0F, 0xF8, 0x78, 0x03, 0xF8,
  0x7C, 0x01, 0xFC, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x3F,
  0x87, 0xE0, 0x3F, 0xC1, 0xF8, 0x7F, 0xE0, 0xFF, 0xFE, 0xF8, 0x3F, 0xFE,
  0x7C, 0x0F, 0xFC, 0x3E, 0x01, 0xF8, 0x0F, 0x80, 0x3E, 0x7C, 0xF9, 0xE7,
  0xCF, 0x9F, 0x3C, 0x79, 0xF3, 0xC7, 0x8F, 0x1C, 0x38, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x03, 0x80, 0x00, 0x3E, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x70, 0x00, 0x07, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F,
  0xE0, 0x00, 0x3E, 0x00, 0x01, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x20,
  0x38, 0x09, 0xE1, 0xC3, 0xDF, 0xCE, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFC, 0x03, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xEF, 0x00, 0x0F,
  0x7C, 0x00, 0xF1, 0xF0, 0x0F, 0x8F, 0x80, 0xF8, 0x3E, 0x07, 0xC1, 0xF0,
  0x1C, 0x07, 0x00, 0x20, 0x20, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x7E, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0x7F, 0x01, 0xE0, 0x3E, 0x07, 0xC3, 0xF8, 0xFF, 0x0F, 0xE0,
  0xF8, 0x0E, 0x00, 0x7F, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3C, 0x7E,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x78, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xF8,
  0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFE, 0x01, 0xF8, 0x3E, 0x03, 0xF0, 0x1F,
  0x07, 0xE0, 0x1F, 0x07, 0xC0, 0x1F, 0x0F, 0x80, 0x0F, 0x1F, 0x00, 0x0F,
  0x1F, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x3E, 0x00, 0x0F, 0x3C, 0x1C, 0x1F,
  0x7C, 0x7E, 0x1F, 0x7C, 0x7E, 0x1F, 0x7C, 0x7F, 0x1F, 0x78, 0x7E, 0x1E,
  0xF8, 0x7E, 0x1E, 0xF8, 0x3C, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3C,
  0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0xF8, 0xF0, 0x00, 0xF8,
  0xF0, 0x01, 0xF0, 0xF8, 0x03, 0xF0, 0xF8, 0x07, 0xE0, 0xF8, 0x0F, 0xC0,
  0x7C, 0x1F, 0x80, 0x7F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00,
  0x0F, 0xE0, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x80, 0xFF, 0x7C,
  0x07, 0xF3, 0xE0, 0x1E, 0x1E, 0x00, 0x81, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0,
  0x0F, 0xFF, 0xFE, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0,
  0x1F, 0x83, 0xF8, 0x0E, 0x00, 0x7C, 0x02, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFE, 0x00, 0x78, 0x1F, 0x80, 0x10, 0x03, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x08,
  0x00, 0x3F, 0x07, 0x80, 0x7F, 0x81, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x3E, 0xF0, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0x9F,
  0x00, 0x07, 0xC7, 0x80, 0x03, 0xE1, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0xF8,
  0x3E, 0x00, 0x7C, 0x0F, 0x00, 0x3E, 0x03, 0xC0, 0x0F, 0x01, 0xF0, 0x07,
  0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x07, 0x80, 0x78, 0x03, 0xE0,
  0x3C, 0x00, 0xF8, 0x1F, 0x00, 0x3C, 0x07, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFE, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x02, 0x00, 0x1F, 0x80, 0x78, 0x07,
  0xF8, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xCF,
  0xF0, 0x01, 0xEF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x1F,
  0xE0, 0x3F, 0x07, 0xC0, 0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x78, 0x00, 0x3E,
  0x1E, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xE3, 0xE0, 0x00, 0xF8, 0xF8, 0x00,
  0x3C, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC1, 0xE0, 0x03, 0xF0, 0x7C,
  0x00, 0xF8, 0x1F, 0x00, 0x7C, 0x07, 0xE0, 0x7F, 0x00, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x03, 0xFF,
  0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x7C, 0x01, 0xF0, 0x3E, 0x00, 0x7C, 0x0F,
  0x80, 0x1F, 0x03, 0xC0, 0x07, 0xC1, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x7C,
  0x1F, 0x00, 0x3E, 0x03, 0xC0, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x3F, 0x07,
  0xE0, 0x07, 0xFB, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F,
  0xFF, 0x00, 0x3F, 0x0F, 0xE0, 0x1F, 0x80, 0xFC, 0x0F, 0x80, 0x1F, 0x03,
  0xE0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x78, 0x00, 0x3E, 0x1E, 0x00, 0x0F,
  0x8F, 0x80, 0x03, 0xE3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x1F, 0x00,
  0x3E, 0x07, 0xE0, 0x7F, 0x80, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x03,
  0xFF, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFF,
  0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x01, 0xFC, 0x1F, 0x80, 0xFC,
  0x03, 0xE0, 0x7E, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC3,
  0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x3C, 0x00, 0x1F, 0x0F, 0x00, 0x07,
  0xC3, 0xC0, 0x01, 0xF0, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x1E, 0x0F, 0x80,
  0x0F, 0x83, 0xF0, 0x0F, 0xE0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x00, 0x1F, 0xC7, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x7F, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x07, 0xE0, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x07, 0xE0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFE, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0x7E, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x07, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x07,
  0xC0, 0x3F, 0x80, 0xFF, 0x00, 0xFE, 0x00, 0xF8, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0x80, 0x1F, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC0, 0x02, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xFC, 0x0F,
  0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0x03, 0xF0, 0x80, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0xE0,
  0x0F, 0xE0, 0x7E, 0x03, 0xF0, 0x07, 0xC0, 0xFC, 0x00, 0x78, 0x1F, 0x00,
  0x0F, 0x07, 0xC0, 0x01, 0xE1, 0xF0, 0x00, 0x3C, 0x3E, 0x00, 0x07, 0x8F,
  0x80, 0x3F, 0xF1, 0xF0, 0x3F, 0xFE, 0x7C, 0x0F, 0xFF, 0xCF, 0x83, 0xFF,
  0xF1, 0xE0, 0xFC, 0x1E, 0x7C, 0x3F, 0x07, 0xCF, 0x87, 0xC0, 0xF9, 0xE1,
  0xF0, 0x1E, 0x3C, 0x3C, 0x03, 0xCF, 0x87, 0x80, 0xF9, 0xF1, 0xF0, 0x1F,
  0x3C, 0x3E, 0x03, 0xC7, 0x87, 0xC0, 0x78, 0xF0, 0xF8, 0x1F, 0x1E, 0x1F,
  0x03, 0xE3, 0xC3, 0xE0, 0x78, 0x78, 0x3C, 0x0F, 0x0F, 0x07, 0xE3, 0xE1,
  0xE0, 0xFF, 0xFC, 0x3E, 0x0F, 0xFF, 0x07, 0xC0, 0xFF, 0xE0, 0x78, 0x07,
  0xF0, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x81, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x0F, 0x3E, 0x00,
  0x03, 0xE7, 0xC0, 0x00, 0x78, 0x78, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC1,
  0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x3E, 0x07, 0x80, 0x07, 0x80, 0xF0, 0x01,
  0xF0, 0x1E, 0x00, 0x3C, 0x03, 0xC0, 0x0F, 0x80, 0x78, 0x01, 0xE0, 0x0F,
  0x80, 0x78, 0x01, 0xF0, 0x0F, 0x00, 0x3E, 0x03, 0xC0, 0x07, 0xC0, 0x7F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC,
  0x1E, 0x00, 0x0F, 0x87, 0x80, 0x01, 0xF0, 0xF0, 0x00, 0x3E, 0x3E, 0x00,
  0x07, 0xC7, 0x80, 0x00, 0xF9, 0xF0, 0x00, 0x1F, 0x7C, 0x00, 0x03, 0xEF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x03, 0xE0, 0x1F, 0xC0,
  0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x03, 0xC0, 0x03,
  0xC1, 0xF0, 0x00, 0xF0, 0x7C, 0x00, 0x7C, 0x1F, 0x00, 0x1E, 0x07, 0x80,
  0x0F, 0x83, 0xE0, 0x07, 0xC0, 0xF8, 0x0F, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x7C, 0x03, 0xF8,
  0x1E, 0x00, 0x3F, 0x07, 0x80, 0x07, 0xC3, 0xE0, 0x00, 0xF0, 0xF8, 0x00,
  0x3C, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0xC7, 0xC0, 0x01, 0xF1, 0xF0,
  0x00, 0xF8, 0x78, 0x00, 0x7E, 0x1E, 0x00, 0x3F, 0x07, 0x80, 0x7F, 0xC3,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xF0, 0x0F, 0xE0, 0x3C, 0x03, 0xF0, 0x01, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x60, 0x0F, 0xE0, 0x3C, 0x01, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0x80, 0x1F, 0x03, 0xF8, 0x03, 0xC0, 0x1F, 0x80, 0x78, 0x01, 0xF0,
  0x1F, 0x00, 0x1F, 0x03, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x0F, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0xF0, 0x7C, 0x00, 0x1E, 0x0F, 0x80, 0x03, 0xC1,
  0xE0, 0x00, 0x78, 0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE1, 0xF0, 0x00,
  0x7C, 0x3C, 0x00, 0x0F, 0x87, 0x80, 0x01, 0xE1, 0xF0, 0x00, 0x7C, 0x3E,
  0x00, 0x0F, 0x87, 0x80, 0x01, 0xF0, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x0F,
  0x87, 0xC0, 0x03, 0xE0, 0xF0, 0x00, 0xFC, 0x1E, 0x00, 0x3F, 0x07, 0xC0,
  0x0F, 0xC0, 0xF8, 0x07, 0xF0, 0x1E, 0x03, 0xFC, 0x03, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFE, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFE, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x0F, 0xF0, 0x3C, 0x03, 0xF0,
  0x01, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x3C, 0x00, 0x0F,
  0x87, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x87, 0xC0,
  0x01, 0xF0, 0x78, 0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x81, 0xF0, 0x01, 0xF0,
  0x3E, 0x00, 0x3E, 0x07, 0xE0, 0x07, 0x80, 0x7E, 0x01, 0xF0, 0x0F, 0xE0,
  0x3E, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x3C, 0x03, 0xE0, 0x01, 0xF0,
  0x0F, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x78, 0x07,
  0xC0, 0x03, 0xE0, 0x1E, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x3E, 0x03, 0xE0,
  0x00, 0xF0, 0x0F, 0x80, 0x07, 0xC0, 0x3C, 0x00, 0x1F, 0x00, 0xF0, 0x00,
  0x7C, 0x07, 0xC0, 0x01, 0xE0, 0x1F, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x3E,
  0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFC, 0x03, 0xC0, 0x01, 0xF0, 0x1F, 0x00, 0x07, 0x80, 0x7C,
  0x00, 0x1E, 0x01, 0xF0, 0x00, 0xF8, 0x07, 0x80, 0x03, 0xE0, 0x3E, 0x00,
  0x0F, 0x00, 0xF8, 0x00, 0x3C, 0x03, 0xE0, 0x01, 0xF0, 0x0F, 0x00, 0x07,
  0xC0, 0x3C, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x78, 0x07, 0xC0, 0x03, 0xE0,
  0x1E, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0xF0, 0x0F,
  0x80, 0x07, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x02, 0x00, 0x3F, 0x00,
  0xE0, 0x0F, 0xC0, 0x1F, 0x03, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0x80, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0xF8, 0x07, 0xC0, 0x07, 0xE0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF8,
  0x01, 0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x7E, 0x00, 0x3E, 0x03, 0xF0, 0x00,
  0xF8, 0x1F, 0x80, 0x03, 0xC0, 0xF8, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x7C,
  0x3E, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x07, 0x8F, 0x80, 0x00, 0x1E, 0xFC,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x07, 0xCF, 0x80, 0x00,
  0x1E, 0x1F, 0x00, 0x00, 0x78, 0x7E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F,
  0x81, 0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0xF0, 0x0F, 0x80, 0x03, 0xC0,
  0x1E, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xE0, 0x07, 0x80, 0x0F, 0x80, 0x3E, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x7C,
  0x03, 0xC0, 0x00, 0xF8, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF7,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFC, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xFC, 0x07, 0xF0, 0x07, 0xF0, 0x3F, 0x80, 0x3F, 0xC0, 0xEE, 0x00,
  0xEF, 0x07, 0xB8, 0x03, 0xBC, 0x1D, 0xE0, 0x1E, 0xF0, 0xF7, 0x80, 0x79,
  0xC3, 0x9E, 0x01, 0xC7, 0x1E, 0x78, 0x0F, 0x1C, 0x71, 0xC0, 0x3C, 0x73,
  0x8F, 0x00, 0xF1, 0xCE, 0x3C, 0x07, 0x87, 0x70, 0xF0, 0x1E, 0x1D, 0xC3,
  0xC0, 0x78, 0x7E, 0x0F, 0x03, 0xC1, 0xF8, 0x78, 0x0F, 0x07, 0xC1, 0xE0,
  0x3C, 0x1F, 0x07, 0x81, 0xF0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xF8, 0x1E,
  0x00, 0x03, 0xC0, 0x78, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x3C, 0x0F, 0x00,
  0x00, 0xF0, 0x3C, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1E, 0x07, 0xC0, 0x00,
  0x78, 0x1E, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3E,
  0x0F, 0x80, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x3C, 0x03, 0xF0, 0x00,
  0xF0, 0x0F, 0xC0, 0x03, 0xC0, 0x3F, 0x00, 0x1F, 0x01, 0xFC, 0x00, 0x78,
  0x07, 0xF8, 0x01, 0xE0, 0x1F, 0xE0, 0x07, 0x80, 0x7F, 0x80, 0x3E, 0x01,
  0xEF, 0x00, 0xF0, 0x0F, 0x3C, 0x03, 0xC0, 0x3C, 0xF0, 0x0F, 0x00, 0xF3,
  0xC0, 0x3C, 0x03, 0xC7, 0x81, 0xE0, 0x1E, 0x1E, 0x07, 0x80, 0x78, 0x78,
  0x1E, 0x01, 0xE0, 0xE0, 0x78, 0x07, 0x83, 0xC3, 0xC0, 0x3E, 0x0F, 0x0F,
  0x00, 0xF0, 0x3C, 0x3C, 0x03, 0xC0, 0x70, 0xF0, 0x0F, 0x01, 0xE7, 0xC0,
  0x7C, 0x07, 0x9E, 0x01, 0xE0, 0x1E, 0x78, 0x07, 0x80, 0x79, 0xE0, 0x1E,
  0x00, 0xEF, 0x80, 0xF8, 0x03, 0xBC, 0x03, 0xC0, 0x0F, 0xF0, 0x0F, 0x00,
  0x3F, 0xC0, 0x3C, 0x00, 0xFF, 0x00, 0xF0, 0x01, 0xF8, 0x07, 0xC0, 0x07,
  0xE0, 0x1E, 0x00, 0x1F, 0x80, 0x78, 0x00, 0x7E, 0x01, 0xE0, 0x01, 0xF0,
  0x0F, 0x80, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xFF, 0x00,
  0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x01, 0xFC, 0x1F, 0x80, 0x7C, 0x03,
  0xF0, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x07, 0xC0, 0x07, 0xC3, 0xE0,
  0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x7C, 0x00, 0x0F, 0x1E, 0x00, 0x03, 0xCF,
  0x80, 0x01, 0xF3, 0xE0, 0x00, 0x7C, 0xF0, 0x00, 0x1F, 0x3C, 0x00, 0x07,
  0xDF, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x79, 0xE0, 0x00, 0x3E, 0x78, 0x00,
  0x0F, 0x9E, 0x00, 0x03, 0xC7, 0x80, 0x01, 0xF3, 0xE0, 0x00, 0x7C, 0xF8,
  0x00, 0x3E, 0x1E, 0x00, 0x0F, 0x87, 0x80, 0x07, 0xC1, 0xF0, 0x01, 0xF0,
  0x7C, 0x00, 0xF8, 0x1F, 0x80, 0x7C, 0x03, 0xF0, 0x7E, 0x00, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xE0, 0x1F, 0x01, 0xFC, 0x03, 0xE0, 0x0F, 0xC0, 0x78, 0x00, 0xF8, 0x0F,
  0x00, 0x1F, 0x03, 0xE0, 0x01, 0xE0, 0x7C, 0x00, 0x3C, 0x0F, 0x00, 0x07,
  0x81, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0x81, 0xE0,
  0x01, 0xF0, 0x3C, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x81, 0xF0, 0x1F, 0xE0,
  0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00,
  0xFC, 0x1F, 0x80, 0x7C, 0x03, 0xF0, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x1F,
  0x07, 0xC0, 0x07, 0xC3, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x7C, 0x00,
  0x0F, 0x1E, 0x00, 0x03, 0xCF, 0x80, 0x01, 0xF3, 0xE0, 0x00, 0x7C, 0xF0,
  0x00, 0x1F, 0x3C, 0x00, 0x07, 0xDF, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x79,
  0xE0, 0x00, 0x3E, 0x78, 0x00, 0x0F, 0x9E, 0x00, 0x03, 0xC7, 0x80, 0x01,
  0xF3, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x87, 0x80,
  0x07, 0xC1, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x1F, 0x80, 0x7C, 0x03,
  0xF0, 0x7E, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x06, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x1E,
  0x01, 0xFC, 0x03, 0xC0, 0x0F, 0x80, 0xF8, 0x01, 0xF0, 0x1F, 0x00, 0x1F,
  0x03, 0xC0, 0x03, 0xE0, 0x78, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x03, 0xE0,
  0x01, 0xE0, 0x7C, 0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x83, 0xE0, 0x03, 0xE0,
  0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x3F, 0x01, 0xE0, 0x1F, 0xC0, 0x7F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x3D, 0xFF, 0x80, 0x0F,
  0x81, 0xF0, 0x01, 0xF0, 0x1F, 0x00, 0x3E, 0x03, 0xE0, 0x07, 0x80, 0x3C,
  0x00, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x0F, 0x80, 0xF0,
  0x01, 0xF0, 0x1E, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xC0, 0xF8, 0x00, 0x7C,
  0x1E, 0x00, 0x0F, 0x83, 0xC0, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0xFE,
  0x03, 0xC0, 0x1F, 0x80, 0x04, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x02, 0x00, 0x0F, 0xC0, 0x7C, 0x03, 0xF8, 0x07, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x01, 0xE0,
  0xF8, 0x00, 0x7C, 0x1E, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xE0, 0xF8, 0x00,
  0x3C, 0x1F, 0x00, 0x0F, 0x83, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x3C, 0x1F,
  0x00, 0x07, 0x83, 0xE0, 0x01, 0xF0, 0x78, 0x00, 0x3E, 0x1F, 0x00, 0x07,
  0x83, 0xE0, 0x00, 0xF0, 0x7C, 0x00, 0x3E, 0x0F, 0x00, 0x07, 0xC1, 0xE0,
  0x00, 0xF0, 0x7C, 0x00, 0x1E, 0x0F, 0x80, 0x07, 0xC1, 0xE0, 0x00, 0xF8,
  0x3C, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xC1, 0xF0, 0x00, 0xF8, 0x3C, 0x00,
  0x1F, 0x07, 0x80, 0x03, 0xE0, 0xF0, 0x00, 0x78, 0x1E, 0x00, 0x1F, 0x03,
  0xC0, 0x03, 0xE0, 0x78, 0x00, 0xF8, 0x0F, 0x80, 0x1F, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x83, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x03,
  0xFF, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x3E, 0xF0, 0x00, 0x1F, 0x3C,
  0x00, 0x07, 0xCF, 0x80, 0x03, 0xE3, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x7C,
  0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x03, 0xE0, 0xF8, 0x01,
  0xF0, 0x3E, 0x00, 0x7C, 0x0F, 0x80, 0x3E, 0x03, 0xE0, 0x0F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x80, 0xF8, 0x03, 0xE0, 0x3C, 0x00,
  0x78, 0x1F, 0x00, 0x1E, 0x07, 0x80, 0x07, 0x83, 0xE0, 0x01, 0xE0, 0xF0,
  0x00, 0x78, 0x7C, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0x8F, 0x00, 0x01, 0xE7,
  0xC0, 0x00, 0x79, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x78, 0x0F, 0x00, 0x00,
  0xF0, 0x3E, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x0F,
  0x01, 0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x78, 0x0F, 0x80, 0x00, 0xF0,
  0x1F, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x0F, 0x00,
  0xF0, 0x00, 0x1E, 0x01, 0xE0, 0xF0, 0x3C, 0x07, 0x83, 0xE0, 0xF0, 0x0F,
  0x07, 0xC1, 0xE0, 0x1E, 0x1F, 0x83, 0xC0, 0x3C, 0x3F, 0x07, 0x80, 0x78,
  0xEE, 0x1E, 0x01, 0xE3, 0xDC, 0x3C, 0x03, 0xC7, 0x3C, 0x78, 0x07, 0x9E,
  0x79, 0xE0, 0x0F, 0x38, 0x73, 0xC0, 0x1C, 0xF0, 0xE7, 0x80, 0x39, 0xC1,
  0xCE, 0x00, 0xF7, 0x83, 0xBC, 0x01, 0xEE, 0x07, 0x78, 0x03, 0xFC, 0x0E,
  0xE0, 0x07, 0x70, 0x1D, 0xC0, 0x0F, 0xE0, 0x3F, 0x80, 0x1F, 0x80, 0x7E,
  0x00, 0x3F, 0x00, 0xFC, 0x00, 0x7C, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x03, 0xE0, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x0F, 0x80,
  0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x1F,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00,
  0x3E, 0x07, 0xC0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x01, 0xF0, 0xF8, 0x00,
  0x00, 0x7C, 0x7C, 0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x03, 0xEF, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07,
  0xEF, 0x00, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x00, 0xF8, 0x78, 0x00, 0x00,
  0x7C, 0x1E, 0x00, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0xF0, 0x00,
  0x07, 0xC0, 0x3C, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x01, 0xF0, 0x03, 0xE0,
  0x00, 0xFC, 0x00, 0x78, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x0F, 0x80, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x3E, 0x3C, 0x00, 0x07, 0xC7,
  0x80, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x81, 0xE0, 0x03,
  0xE0, 0x3C, 0x00, 0xF8, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x07, 0xC0, 0x0F,
  0x01, 0xF0, 0x01, 0xE0, 0x7C, 0x00, 0x3E, 0x0F, 0x00, 0x03, 0xC3, 0xE0,
  0x00, 0x78, 0xF8, 0x00, 0x0F, 0x1E, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x1F,
  0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0xF8, 0x7C, 0x3E,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0xF8, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xE1, 0xF0, 0xF8, 0x7C,
  0x3E, 0x1F, 0x0F, 0x87, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1F, 0x0F, 0x87,
  0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x07, 0x83, 0xC1, 0xE0, 0xF8,
  0x7C, 0x3E, 0x1F, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x07, 0xFF,
  0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x07, 0xFF, 0xE0, 0x03,
  0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x0F, 0xBC, 0x00, 0x3E, 0x7C, 0x00, 0x7C, 0xF8, 0x01, 0xF0, 0xF0, 0x07,
  0xC1, 0xE0, 0x1F, 0x03, 0xE0, 0x7C, 0x03, 0xC0, 0xF8, 0x07, 0x83, 0xE0,
  0x0F, 0x8F, 0x80, 0x0F, 0x3E, 0x00, 0x1E, 0xF8, 0x00, 0x3E, 0xF0, 0x00,
  0x38, 0x40, 0x00, 0x40, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x20, 0x38, 0x3E, 0x1F, 0x87, 0xE1, 0xF0,
  0x7C, 0x1F, 0x07, 0x81, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFF, 0xC0,
  0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x3F, 0xC0, 0xF0, 0x3F, 0x00, 0xF8,
  0x3F, 0x00, 0x7C, 0x3F, 0x00, 0x3C, 0x1F, 0x00, 0x1E, 0x1F, 0x00, 0x1F,
  0x0F, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0x87, 0xC0, 0x03, 0xC3, 0xC0, 0x03,
  0xE3, 0xE0, 0x01, 0xF1, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x78, 0x7C, 0x00,
  0x7C, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x07, 0xC0,
  0x0F, 0x81, 0xF0, 0x0F, 0xC0, 0xFC, 0x1F, 0xE0, 0x7F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFC, 0x07, 0xFF, 0xBE, 0x00, 0xFE, 0x0F, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xCF, 0xE0,
  0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xF0, 0x7E,
  0x0F, 0x80, 0x3F, 0x0F, 0x80, 0x1F, 0x0F, 0x00, 0x1F, 0x0F, 0x00, 0x0F,
  0x0F, 0x00, 0x0F, 0x1F, 0x00, 0x0F, 0x1F, 0x00, 0x0F, 0x1E, 0x00, 0x1F,
  0x1E, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x3E, 0x00, 0x1E, 0x3C, 0x00, 0x3E,
  0x3C, 0x00, 0x3E, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0xFC, 0x78, 0x00, 0xF8,
  0x78, 0x03, 0xF8, 0x78, 0x07, 0xF0, 0xF8, 0x1F, 0xE0, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x7F, 0x80,
  0x60, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x40, 0x7F, 0x01, 0xE0,
  0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xFF, 0x80, 0x01,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x03, 0xFC, 0x0F,
  0x00, 0x7F, 0x00, 0xF0, 0x0F, 0xC0, 0x0F, 0x00, 0xF8, 0x01, 0xF0, 0x1F,
  0x00, 0x1F, 0x03, 0xF0, 0x01, 0xE0, 0x3E, 0x00, 0x1E, 0x03, 0xC0, 0x03,
  0xE0, 0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xC0, 0x78, 0x00, 0x3C, 0x07,
  0x80, 0x07, 0xC0, 0x78, 0x00, 0x7C, 0x0F, 0x80, 0x07, 0x80, 0xF8, 0x00,
  0x78, 0x07, 0x80, 0x07, 0x80, 0x78, 0x00, 0xF8, 0x07, 0xC0, 0x0F, 0x80,
  0x7C, 0x01, 0xF8, 0x07, 0xF0, 0x7F, 0x80, 0x3F, 0xFF, 0xF8, 0x01, 0xFF,
  0xF7, 0x80, 0x0F, 0xFE, 0x78, 0x00, 0x3F, 0x87, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xF0, 0x3F,
  0x0F, 0xC0, 0x1F, 0x1F, 0x80, 0x0F, 0x1F, 0x00, 0x0F, 0x3E, 0x00, 0x1F,
  0x3E, 0x00, 0x1F, 0x7C, 0x00, 0x3F, 0x7C, 0x00, 0xFE, 0x78, 0x0F, 0xFC,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0x80, 0xFF, 0xF8, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7E, 0x00, 0x10, 0x7F, 0x80, 0xF0, 0x3F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x03, 0xF8, 0x10, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x08, 0x3F, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x03,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xF8, 0x1F, 0x00, 0x7F, 0x00,
  0xF8, 0x03, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0x3C, 0x03, 0xF0, 0x03, 0xE0,
  0x1F, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0xF8, 0x0F, 0x80, 0x07, 0x80, 0x78,
  0x00, 0x7C, 0x07, 0xC0, 0x03, 0xE0, 0x3E, 0x00, 0x1F, 0x01, 0xF0, 0x00,
  0xF0, 0x0F, 0x00, 0x07, 0x80, 0x78, 0x00, 0x7C, 0x03, 0xC0, 0x03, 0xE0,
  0x1F, 0x00, 0x1E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x7F, 0x80, 0x1F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xF9,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x80, 0x07, 0xE0, 0x0F, 0x00, 0xFE, 0x00, 0x7F,
  0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xCF, 0xE0, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x07,
  0xFF, 0xFE, 0x07, 0xC0, 0x7E, 0x07, 0x80, 0x3E, 0x0F, 0x80, 0x1F, 0x0F,
  0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x00, 0x1F, 0x1F, 0x00, 0x1E, 0x1F,
  0x00, 0x1E, 0x1F, 0x00, 0x3E, 0x1E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E,
  0x00, 0x3C, 0x3E, 0x00, 0x7C, 0x3C, 0x00, 0x7C, 0x3C, 0x00, 0x7C, 0x7C,
  0x00, 0x78, 0x7C, 0x00, 0x78, 0x78, 0x00, 0xF8, 0x78, 0x00, 0xF8, 0xF8,
  0x00, 0xF8, 0xF8, 0x00, 0xF0, 0xF0, 0x01, 0xF0, 0xF0, 0x01, 0xF0, 0x00,
  0x3C, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0,
  0x01, 0xF0, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x01,
  0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xF8, 0x03, 0xFC, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xC0, 0x04, 0x00, 0xF8, 0x01, 0xE0, 0x7E, 0x00, 0x3F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x1F, 0x81, 0xF0,
  0x07, 0xE0, 0x3C, 0x03, 0xF8, 0x07, 0x80, 0xFE, 0x00, 0xF0, 0x7F, 0x00,
  0x3E, 0x1F, 0xC0, 0x07, 0x8F, 0xF0, 0x00, 0xF7, 0xFC, 0x00, 0x1F, 0xFE,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7B, 0xF0, 0x00, 0x1F, 0x3F, 0x00, 0x03, 0xE3, 0xF0,
  0x00, 0x78, 0x3E, 0x00, 0x0F, 0x03, 0xE0, 0x03, 0xE0, 0x7E, 0x00, 0x7C,
  0x07, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0xC0, 0x7C, 0x00, 0xF8,
  0x0F, 0x80, 0x1F, 0x81, 0xE0, 0x01, 0xF0, 0x3C, 0x00, 0x3E, 0x00, 0x7F,
  0xF8, 0xFF, 0xF3, 0xFF, 0xE7, 0xFF, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x33, 0xFF, 0xE7, 0xFF, 0xC7, 0xFF,
  0x83, 0xF8, 0x00, 0xFE, 0x0F, 0x80, 0x7F, 0xF7, 0xF8, 0x1F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xF0, 0x78, 0x7E, 0x3E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x7C, 0x1E, 0x0F, 0x0F, 0x07, 0x81, 0xE1, 0xE0, 0xF0, 0x7C,
  0x3C, 0x1E, 0x0F, 0x0F, 0x83, 0xC1, 0xE1, 0xE0, 0xF8, 0x3C, 0x3C, 0x1E,
  0x0F, 0x87, 0x83, 0xC1, 0xE1, 0xF0, 0x78, 0x3C, 0x3C, 0x1F, 0x07, 0x87,
  0x80, 0x01, 0xF0, 0xF0, 0x00, 0x3C, 0x3E, 0x00, 0x07, 0x87, 0x80, 0x00,
  0xF0, 0xF0, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF0, 0xF0,
  0x00, 0x1E, 0x1E, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xC0,
  0x7E, 0x07, 0x80, 0x3E, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x00,
  0x1F, 0x0F, 0x00, 0x1F, 0x1F, 0x00, 0x1E, 0x1F, 0x00, 0x1E, 0x1F, 0x00,
  0x3E, 0x1E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3C, 0x3E, 0x00,
  0x3C, 0x3C, 0x00, 0x7C, 0x3C, 0x00, 0x7C, 0x7C, 0x00, 0x78, 0x7C, 0x00,
  0x78, 0x78, 0x00, 0xF8, 0x78, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00,
  0xF0, 0xF0, 0x01, 0xF0, 0xF0, 0x01, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xF0, 0x7E, 0x07, 0xC0,
  0x3F, 0x0F, 0x80, 0x1F, 0x1F, 0x80, 0x1F, 0x1F, 0x00, 0x0F, 0x3E, 0x00,
  0x0F, 0x3E, 0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x7C, 0x00, 0x1F, 0x7C, 0x00,
  0x1F, 0x7C, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0x78, 0x00, 0x3E, 0xF8, 0x00,
  0x3E, 0xF8, 0x00, 0x3E, 0x78, 0x00, 0x7C, 0x78, 0x00, 0xFC, 0x7C, 0x01,
  0xF8, 0x7C, 0x03, 0xF0, 0x7F, 0x07, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF,
  0x80, 0x0F, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0x80, 0xFC,
  0x03, 0xE0, 0x0F, 0xC0, 0x7C, 0x00, 0xF8, 0x0F, 0x80, 0x1F, 0x01, 0xE0,
  0x01, 0xE0, 0x7C, 0x00, 0x3C, 0x0F, 0x80, 0x07, 0x81, 0xF0, 0x00, 0xF0,
  0x3C, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x3E, 0x00,
  0x1E, 0x07, 0x80, 0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x07,
  0xC0, 0x07, 0xC0, 0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x7E, 0x07, 0xC0, 0x3F,
  0x80, 0xF8, 0x1F, 0xE0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0xFF,
  0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0xC0,
  0xF8, 0x3F, 0x80, 0x78, 0x3F, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x1F, 0x00,
  0x1F, 0x1F, 0x80, 0x0F, 0x0F, 0x80, 0x07, 0x87, 0x80, 0x07, 0xC7, 0xC0,
  0x03, 0xE3, 0xE0, 0x01, 0xE1, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0xF8, 0x78,
  0x00, 0x7C, 0x7C, 0x00, 0x3C, 0x3E, 0x00, 0x1E, 0x0F, 0x00, 0x1F, 0x07,
  0x80, 0x0F, 0x83, 0xE0, 0x07, 0x81, 0xF0, 0x07, 0xC0, 0xFE, 0x0F, 0xE0,
  0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0x7E, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x03,
  0xFF, 0xFE, 0x07, 0xF0, 0x06, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x03,
  0xF8, 0x0E, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x20, 0x01, 0xF0, 0x3C, 0x07, 0xF0, 0x7F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x38, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xE0, 0x7C, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x06, 0x07, 0xFF, 0xF0, 0x1F,
  0xFF, 0x80, 0x7F, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0x00, 0x1F, 0x1F, 0x00,
  0x1F, 0x1F, 0x00, 0x1E, 0x1E, 0x00, 0x3E, 0x1E, 0x00, 0x3E, 0x3E, 0x00,
  0x3E, 0x3E, 0x00, 0x3C, 0x3E, 0x00, 0x7C, 0x3C, 0x00, 0x7C, 0x7C, 0x00,
  0x7C, 0x7C, 0x00, 0x78, 0x7C, 0x00, 0x78, 0x78, 0x00, 0xF8, 0xF8, 0x00,
  0xF8, 0xF8, 0x00, 0xF0, 0xF8, 0x00, 0xF0, 0xF0, 0x01, 0xF0, 0xF0, 0x01,
  0xF0, 0xF0, 0x01, 0xF0, 0xF0, 0x01, 0xE0, 0xF8, 0x03, 0xE0, 0xF8, 0x07,
  0xE0, 0xFC, 0x1F, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xF9,
  0xF0, 0x0F, 0xE0, 0xF0, 0x78, 0x00, 0x3E, 0xF0, 0x00, 0x79, 0xE0, 0x01,
  0xF3, 0xC0, 0x03, 0xE7, 0x80, 0x0F, 0x8F, 0x00, 0x1F, 0x1E, 0x00, 0x3C,
  0x3E, 0x00, 0xF8, 0x7C, 0x01, 0xE0, 0xF8, 0x07, 0xC1, 0xF0, 0x0F, 0x03,
  0xE0, 0x3E, 0x07, 0xC0, 0x78, 0x07, 0x81, 0xF0, 0x0F, 0x07, 0xC0, 0x1E,
  0x0F, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x78, 0x00, 0xF9, 0xF0, 0x01, 0xF7,
  0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF3, 0xE0,
  0x00, 0x0F, 0x3C, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x1E, 0x3C, 0x00, 0x01,
  0xE3, 0xC0, 0x00, 0x3C, 0x3C, 0x0F, 0x03, 0xC3, 0xC0, 0xF0, 0x3C, 0x7C,
  0x1F, 0x07, 0x87, 0xC1, 0xF0, 0x78, 0x78, 0x3F, 0x07, 0x87, 0x87, 0xF0,
  0xF0, 0x78, 0x77, 0x0F, 0x07, 0x8F, 0x71, 0xE0, 0x78, 0xE7, 0x1E, 0x07,
  0x9E, 0x71, 0xE0, 0x79, 0xC7, 0xBC, 0x07, 0xBC, 0x7B, 0xC0, 0x7B, 0x87,
  0xF8, 0x07, 0xF0, 0x7F, 0x80, 0x7F, 0x07, 0xF8, 0x07, 0xE0, 0x3F, 0x00,
  0x7E, 0x03, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3C, 0x00, 0x01, 0xF0, 0x00, 0xF8, 0x0F, 0x80, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x01, 0xF0, 0x0F, 0x80, 0x07, 0xC0, 0xF8, 0x00, 0x3E, 0x07, 0xC0,
  0x00, 0xF8, 0x7C, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x7E, 0x3E, 0x00, 0x07,
  0xE0, 0xF8, 0x00, 0x7E, 0x07, 0xC0, 0x07, 0xE0, 0x1E, 0x00, 0x7E, 0x00,
  0xF8, 0x07, 0xE0, 0x07, 0xC0, 0x7E, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0xF8,
  0x00, 0x00, 0x78, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x7C, 0x01, 0xE0, 0x01,
  0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x78, 0x00, 0x7C, 0x01, 0xF0,
  0x00, 0x78, 0x03, 0xE0, 0x00, 0xF0, 0x0F, 0x80, 0x01, 0xF0, 0x1F, 0x00,
  0x03, 0xE0, 0x3C, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0x0F, 0x07, 0xC0, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00,
  0x3C, 0x78, 0x00, 0x00, 0x79, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x10, 0x3F, 0x80,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0,
  0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x02, 0x07, 0xFC, 0x03,
  0xC7, 0xFF, 0x03, 0xC7, 0xFF, 0xE3, 0xE7, 0xC3, 0xFF, 0xE3, 0xC0, 0xFF,
  0xE3, 0xC0, 0x1F, 0xE0, 0x60, 0x07, 0xE0,
};

const GFXglyph UbuntuMono_Italic56pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 28, 0, -1 },
  { 1, 13, 35, 28, 10, -35 },
  { 58, 16, 14, 28, 12, -38 },
  { 86, 30, 35, 28, 2, -35 },
  { 218, 26, 44, 28, 4, -39 },
  { 361, 34, 35, 28, 0, -35 },
  { 510, 25, 35, 28, 3, -35 },
  { 620, 7, 15, 28, 17, -38 },
  { 634, 21, 48, 28, 8, -39 },
  { 760, 21, 48, 28, 3, -39 },
  { 886, 21, 21, 28, 8, -35 },
  { 942, 23, 24, 28, 5, -27 },
  { 1011, 12, 16, 28, 6, -8 },
  { 1035, 13, 4, 28, 10, -16 },
  { 1042, 8, 8, 28, 10, -8 },
  { 1050, 32, 48, 28, -1, -39 },
  { 1242, 24, 35, 28, 5, -35 },
  { 1347, 21, 35, 28, 5, -35 },
  { 1439, 25, 35, 28, 4, -35 },
  { 1549, 26, 35, 28, 3, -35 },
  { 1663, 26, 35, 28, 3, -35 },
  { 1777, 28, 35, 28, 3, -35 },
  { 1900, 26, 35, 28, 5, -35 },
  { 2014, 25, 35, 28, 8, -35 },
  { 2124, 26, 35, 28, 4, -35 },
  { 2238, 26, 35, 28, 4, -35 },
  { 2352, 12, 26, 28, 10, -26 },
  { 2391, 16, 34, 28, 6, -26 },
  { 2459, 25, 22, 28, 4, -26 },
  { 2528, 26, 15, 28, 4, -22 },
  { 2577, 25, 22, 28, 3, -25 },
  { 2646, 20, 35, 28, 9, -35 },
  { 2734, 27, 42, 28, 4, -35 },
  { 2876, 27, 35, 28, -1, -35 },
  { 2995, 26, 35, 28, 3, -35 },
  { 3109, 27, 35, 28, 5, -35 },
  { 3228, 27, 35, 28, 2, -35 },
  { 3347, 28, 35, 28, 4, -35 },
  { 3470, 28, 35, 28, 4, -35 },
  { 3593, 27, 35, 28, 4, -35 },
  { 3712, 30, 35, 28, 2, -35 },
  { 3844, 26, 35, 28, 4, -35 },
  { 3958, 27, 35, 28, 4, -35 },
  { 4077, 30, 35, 28, 3, -35 },
  { 4209, 21, 35, 28, 3, -35 },
  { 4301, 30, 35, 28, 1, -35 },
  { 4433, 30, 35, 28, 2, -35 },
  { 4565, 26, 35, 28, 4, -35 },
  { 4679, 27, 35, 28, 3, -35 },
  { 4798, 26, 44, 28, 4, -35 },
  { 4941, 27, 35, 28, 3, -35 },
  { 5060, 28, 35, 28, 3, -35 },
  { 5183, 24, 35, 28, 9, -35 },
  { 5288, 27, 35, 28, 5, -35 },
  { 5407, 26, 35, 28, 8, -35 },
  { 5521, 31, 35, 28, 3, -35 },
  { 5657, 34, 35, 28, 0, -35 },
  { 5806, 27, 35, 28, 8, -35 },
  { 5925, 30, 35, 28, 2, -35 },
  { 6057, 26, 48, 28, 5, -39 },
  { 6213, 9, 48, 28, 12, -39 },
  { 6267, 25, 48, 28, 1, -39 },
  { 6417, 23, 19, 28, 6, -35 },
  { 6472, 26, 4, 28, -2, 5 },
  { 6485, 9, 10, 28, 15, -39 },
  { 6497, 25, 28, 28, 4, -27 },
  { 6585, 24, 40, 28, 4, -39 },
  { 6705, 25, 28, 28, 4, -27 },
  { 6793, 28, 40, 28, 4, -39 },
  { 6933, 24, 28, 28, 4, -27 },
  { 7017, 33, 48, 28, 0, -39 },
  { 7215, 29, 36, 28, 1, -27 },
  { 7346, 24, 39, 28, 3, -39 },
  { 7463, 17, 38, 28, 7, -38 },
  { 7544, 27, 47, 28, 1, -38 },
  { 7703, 27, 39, 28, 4, -39 },
  { 7835, 15, 40, 28, 10, -39 },
  { 7910, 27, 27, 28, 2, -27 },
  { 8002, 24, 27, 28, 4, -27 },
  { 8083, 24, 28, 28, 4, -27 },
  { 8167, 27, 36, 28, 1, -27 },
  { 8289, 25, 36, 28, 4, -27 },
  { 8402, 24, 27, 28, 5, -27 },
  { 8483, 24, 28, 28, 4, -27 },
  { 8567, 21, 35, 28, 8, -34 },
  { 8659, 24, 27, 28, 5, -26 },
  { 8740, 23, 26, 28, 7, -26 },
  { 8815, 28, 26, 28, 4, -26 },
  { 8906, 29, 26, 28, 1, -26 },
  { 9001, 31, 35, 28, -1, -26 },
  { 9137, 26, 26, 28, 3, -26 },
  { 9222, 27, 48, 28, 5, -39 },
  { 9384, 16, 48, 28, 9, -39 },
  { 9480, 27, 48, 28, 0, -39 },
  { 9642, 25, 8, 28, 4, -19 },
};

const GFXfont UbuntuMono_Italic56pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Italic56pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Italic56pt7bGlyphs,
  0x20, 0x7E, 56
};

#endif // _UBUNTUMONO_ITALIC56PT7B_H_
