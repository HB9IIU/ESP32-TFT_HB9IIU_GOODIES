#ifndef _UBUNTUMONO_ITALIC35PT7B_H_
#define _UBUNTUMONO_ITALIC35PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Italic.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Italic35pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x07, 0x07, 0x07, 0x0E, 0x0E, 0x0E, 0x0E, 0x1C, 0x1C, 0x1C,
  0x18, 0x18, 0x18, 0x00, 0x00, 0x00, 0x70, 0xF8, 0xF8, 0xF0, 0x70, 0x71,
  0xDC, 0x66, 0x3B, 0x8E, 0xE3, 0xB0, 0xCC, 0x33, 0x0C, 0x82, 0x00, 0x00,
  0x30, 0xE0, 0x0E, 0x18, 0x01, 0x87, 0x00, 0x70, 0xC0, 0x0E, 0x38, 0x01,
  0x87, 0x07, 0xFF, 0xF8, 0xFF, 0xFE, 0x1F, 0xFF, 0xC0, 0x71, 0xC0, 0x0C,
  0x38, 0x03, 0x86, 0x00, 0x61, 0xC0, 0x1C, 0x30, 0x1F, 0xFF, 0xE3, 0xFF,
  0xFC, 0x7F, 0xFF, 0x03, 0x0E, 0x00, 0xE1, 0x80, 0x18, 0x70, 0x07, 0x0C,
  0x00, 0xC3, 0x80, 0x00, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x0F, 0xE0, 0x1F, 0xFC, 0x1F, 0xFC, 0x0E, 0x06, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF0,
  0x00, 0x78, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x04, 0x07, 0x87, 0xFF,
  0x83, 0xFF, 0x80, 0x7F, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03,
  0x80, 0x00, 0x03, 0xC0, 0x38, 0x3F, 0x03, 0x81, 0xF8, 0x18, 0x1C, 0xC1,
  0x80, 0xC6, 0x18, 0x06, 0x31, 0xC0, 0x71, 0x9C, 0x03, 0x9D, 0xC0, 0x0F,
  0xDC, 0x00, 0x7E, 0xC0, 0x01, 0xCC, 0x00, 0x00, 0xEF, 0x00, 0x0E, 0xF8,
  0x00, 0xEF, 0xE0, 0x0E, 0x67, 0x00, 0x67, 0x18, 0x06, 0x30, 0xC0, 0x61,
  0x8E, 0x07, 0x0C, 0xE0, 0x70, 0x7F, 0x07, 0x03, 0xF0, 0x30, 0x0F, 0x00,
  0x00, 0xF8, 0x07, 0xF8, 0x1F, 0xF0, 0x38, 0xE0, 0xE0, 0xC1, 0xC3, 0x83,
  0x86, 0x07, 0x1C, 0x0E, 0xF0, 0x0F, 0x80, 0x3E, 0x18, 0xFC, 0x73, 0x9C,
  0xCE, 0x3F, 0x98, 0x3F, 0x70, 0x3C, 0xE0, 0x71, 0xC0, 0xF3, 0xC7, 0xE7,
  0xFE, 0xC7, 0xF9, 0xC7, 0xC3, 0x80, 0x39, 0xDC, 0xE7, 0x39, 0x8C, 0x40,
  0x00, 0x10, 0x01, 0xC0, 0x1E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x1E, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x0C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x06,
  0x00, 0x20, 0x00, 0x00, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00,
  0x38, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xC0,
  0x0E, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x78, 0x07, 0x80, 0x78,
  0x0F, 0x80, 0x70, 0x01, 0x00, 0x00, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x8E,
  0x3F, 0x37, 0xFF, 0xFD, 0xFF, 0xC0, 0xE0, 0x0D, 0x80, 0xEE, 0x0E, 0x38,
  0x71, 0xC1, 0x04, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x18, 0x00, 0x70, 0x3F, 0xFF, 0x7F, 0xFE, 0x03, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x00, 0x1C, 0x7C, 0xF9, 0xF1, 0xE1,
  0xC7, 0x1C, 0xF1, 0x80, 0x7F, 0xFF, 0xFF, 0x77, 0xFF, 0xF7, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0C,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xF8, 0x07, 0xF8, 0x1F, 0xF8, 0x78, 0xF1, 0xE0, 0xE7,
  0x81, 0xCE, 0x03, 0x9C, 0x07, 0x71, 0x8E, 0xE7, 0x9D, 0xCF, 0x3F, 0x1E,
  0x7E, 0x39, 0xDC, 0x03, 0xB8, 0x07, 0x70, 0x1C, 0xE0, 0x79, 0xC0, 0xE3,
  0xC7, 0xC3, 0xFF, 0x07, 0xF8, 0x03, 0xE0, 0x00, 0x00, 0x38, 0x03, 0xC0,
  0x7C, 0x0F, 0xE1, 0xFF, 0x07, 0x38, 0x21, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0xFF, 0xEF, 0xFF, 0x7F, 0xF8, 0x00, 0xF8, 0x03, 0xFE,
  0x0F, 0xFF, 0x07, 0x0F, 0x04, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x0F, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x7F, 0xFC,
  0x7F, 0xF8, 0xFF, 0xF8, 0x01, 0xF8, 0x07, 0xFE, 0x07, 0xFE, 0x02, 0x0F,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x3E, 0x03, 0xF8,
  0x03, 0xF0, 0x03, 0xF8, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x1C, 0x40, 0x7C, 0x7F, 0xF8, 0xFF, 0xF0, 0x3F, 0x80,
  0x00, 0x0F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xEE, 0x01, 0xCE,
  0x03, 0x8C, 0x07, 0x1C, 0x0E, 0x1C, 0x0E, 0x1C, 0x1C, 0x18, 0x38, 0x38,
  0x70, 0x38, 0x70, 0x38, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0x7F, 0xE0, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C,
  0x00, 0x07, 0xC0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x10, 0x3E,
  0x1F, 0xFE, 0x0F, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x7F, 0x01,
  0xFF, 0x03, 0xF0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x3B,
  0xF0, 0x3F, 0xF8, 0x7F, 0xFC, 0x78, 0x3C, 0x70, 0x1C, 0xE0, 0x1C, 0xE0,
  0x1C, 0xE0, 0x1C, 0xE0, 0x1C, 0xF0, 0x38, 0x70, 0x78, 0x7F, 0xF0, 0x3F,
  0xE0, 0x1F, 0x80, 0x3F, 0xFF, 0x3F, 0xFE, 0x3F, 0xFE, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x01,
  0xF8, 0x03, 0xFE, 0x0F, 0xFE, 0x0F, 0x0F, 0x1C, 0x07, 0x1C, 0x07, 0x1C,
  0x07, 0x1C, 0x0E, 0x1E, 0x1C, 0x1F, 0xF8, 0x0F, 0xE0, 0x0F, 0xF0, 0x3C,
  0xF8, 0x70, 0x3C, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x38, 0xF0,
  0xF8, 0xFF, 0xF0, 0x7F, 0xE0, 0x1F, 0x80, 0x01, 0xF8, 0x07, 0xFC, 0x0F,
  0xFE, 0x1E, 0x0E, 0x1C, 0x0F, 0x38, 0x07, 0x38, 0x07, 0x38, 0x07, 0x38,
  0x07, 0x38, 0x0E, 0x3C, 0x1E, 0x3F, 0xFE, 0x1F, 0xFE, 0x0F, 0xDC, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xF0, 0x07, 0xC0, 0xFF, 0x80, 0xFE,
  0x00, 0xF8, 0x00, 0x0E, 0x1F, 0x1F, 0x1F, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x70, 0xF8, 0xF8, 0xF8, 0x70, 0x03, 0x81, 0xF0, 0x7C, 0x1F,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x3E, 0x0F,
  0x83, 0xE0, 0x78, 0x0E, 0x07, 0x03, 0x83, 0xC0, 0xC0, 0x00, 0x00, 0x02,
  0x00, 0x3C, 0x01, 0xF8, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x3F, 0x00, 0x70,
  0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x06,
  0x00, 0x3F, 0xFF, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFE, 0xFF, 0xFC, 0x18, 0x00, 0x1E, 0x00, 0x1F, 0x80, 0x03,
  0xE0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0E, 0x00, 0x7E, 0x01, 0xF8, 0x0F,
  0xE0, 0x7F, 0x80, 0xFC, 0x00, 0xF0, 0x00, 0x80, 0x00, 0x0F, 0xC3, 0xFE,
  0x3F, 0xF3, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x60, 0x0E, 0x01, 0xC0, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0xC0, 0x3F,
  0xF8, 0x1F, 0x0E, 0x0F, 0x01, 0x83, 0x80, 0x71, 0xC0, 0x1C, 0x70, 0x06,
  0x38, 0x3F, 0x8E, 0x3F, 0xE7, 0x1F, 0xF9, 0xC7, 0x8E, 0x73, 0x83, 0x1C,
  0xE1, 0xC6, 0x30, 0x73, 0x8C, 0x18, 0xE3, 0x8E, 0x38, 0xFF, 0x8E, 0x1F,
  0xE1, 0x83, 0xF0, 0x60, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x07, 0xF8, 0x00, 0x7E, 0x00, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x3E, 0x00, 0x76, 0x00, 0x66, 0x00, 0xE7, 0x00, 0xC7, 0x01, 0xC7, 0x01,
  0x87, 0x03, 0x87, 0x07, 0x07, 0x07, 0x07, 0x0E, 0x07, 0x0E, 0x07, 0x1F,
  0xFF, 0x1F, 0xFF, 0x3F, 0xFF, 0x38, 0x07, 0x70, 0x07, 0x70, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0x0F, 0xF8, 0x0F, 0xFE, 0x0F, 0xFF, 0x0E, 0x0F, 0x0E,
  0x07, 0x1C, 0x07, 0x1C, 0x07, 0x1C, 0x07, 0x18, 0x1E, 0x3F, 0xFC, 0x3F,
  0xF0, 0x3F, 0xFC, 0x38, 0x1E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70,
  0x0E, 0x60, 0x1C, 0xE0, 0x7C, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0x80, 0x00,
  0x7E, 0x00, 0xFF, 0xC1, 0xFF, 0xE1, 0xF0, 0x21, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x04, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x7E, 0x00, 0x07, 0xF8,
  0x03, 0xFF, 0x01, 0xFF, 0xC0, 0xE1, 0xE0, 0xE0, 0x78, 0x70, 0x1C, 0x38,
  0x0E, 0x1C, 0x07, 0x1C, 0x03, 0x8E, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0x73,
  0x80, 0x39, 0xC0, 0x38, 0xE0, 0x1C, 0x60, 0x1E, 0x70, 0x1E, 0x38, 0x1E,
  0x1C, 0x3F, 0x0F, 0xFE, 0x0F, 0xFE, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0xC1,
  0xFF, 0xF0, 0x7F, 0xF8, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0,
  0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C,
  0x00, 0x07, 0x00, 0x01, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0x00, 0x03,
  0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0xFF, 0x81, 0xFF, 0xC0,
  0x7F, 0xF0, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xFE, 0x01, 0xFF, 0x81, 0xFF, 0xC1, 0xF0, 0x41, 0xE0, 0x01,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00,
  0x1C, 0x03, 0x8E, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0x71, 0xC0, 0x70, 0xE0,
  0x38, 0x78, 0x1C, 0x1E, 0x0E, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0x7E, 0x00,
  0x07, 0x00, 0xE0, 0xE0, 0x1C, 0x1C, 0x03, 0x83, 0x00, 0xE0, 0xE0, 0x1C,
  0x1C, 0x03, 0x83, 0x80, 0x70, 0x70, 0x1C, 0x1C, 0x03, 0x83, 0xFF, 0xF0,
  0x7F, 0xFE, 0x0F, 0xFF, 0x83, 0x80, 0x70, 0x70, 0x0E, 0x0E, 0x01, 0xC1,
  0xC0, 0x38, 0x30, 0x0E, 0x0E, 0x01, 0xC1, 0xC0, 0x38, 0x38, 0x07, 0x06,
  0x01, 0xC1, 0xC0, 0x38, 0x00, 0x03, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xC0,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x0F, 0xFE, 0x07,
  0xFF, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x00,
  0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x38, 0x20, 0x3C, 0x1C, 0x3C, 0x1F, 0xFE, 0x07, 0xFE,
  0x00, 0xFC, 0x00, 0x07, 0x01, 0xC1, 0xC0, 0x70, 0x38, 0x1C, 0x07, 0x07,
  0x00, 0xE1, 0xC0, 0x38, 0x70, 0x07, 0x1C, 0x00, 0xE7, 0x00, 0x1F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xB8, 0x00, 0x63, 0x80,
  0x1C, 0x38, 0x03, 0x87, 0x00, 0x70, 0x70, 0x0E, 0x0E, 0x03, 0x80, 0xE0,
  0x70, 0x1C, 0x0E, 0x01, 0xC1, 0xC0, 0x38, 0x00, 0x07, 0x00, 0x38, 0x01,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x06, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x18, 0x01, 0xFF, 0xFF, 0xFF, 0x7F, 0xF8, 0x03, 0x80, 0xC0, 0x70,
  0x38, 0x0E, 0x07, 0x03, 0xC1, 0xE0, 0x78, 0x7C, 0x1F, 0x0D, 0x83, 0x73,
  0x70, 0x66, 0x6E, 0x0C, 0xD9, 0x83, 0x9B, 0x30, 0x63, 0xC6, 0x0C, 0x79,
  0xC3, 0x8E, 0x38, 0x71, 0xC7, 0x0C, 0x00, 0xC3, 0x80, 0x38, 0x70, 0x07,
  0x0E, 0x00, 0xE1, 0x80, 0x1C, 0x70, 0x03, 0x0E, 0x00, 0xE1, 0x80, 0x1C,
  0x00, 0x07, 0x80, 0x60, 0xF0, 0x1C, 0x1E, 0x03, 0x83, 0xC0, 0x60, 0x7C,
  0x0C, 0x1D, 0x83, 0x83, 0xB0, 0x70, 0x67, 0x0C, 0x0C, 0xE1, 0x83, 0x8C,
  0x70, 0x71, 0x8E, 0x0C, 0x39, 0xC1, 0x87, 0x30, 0x70, 0x6E, 0x0E, 0x0D,
  0xC1, 0xC1, 0xB8, 0x30, 0x36, 0x0E, 0x07, 0xC1, 0xC0, 0x78, 0x38, 0x0F,
  0x06, 0x01, 0xC0, 0xC0, 0x38, 0x00, 0x01, 0xF8, 0x03, 0xFC, 0x0F, 0xFE,
  0x0F, 0x0E, 0x1C, 0x07, 0x3C, 0x07, 0x38, 0x07, 0x70, 0x07, 0x70, 0x07,
  0x70, 0x07, 0xE0, 0x07, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x1C,
  0xE0, 0x1C, 0xE0, 0x38, 0xE0, 0x78, 0xF0, 0xF0, 0x7F, 0xE0, 0x7F, 0xC0,
  0x1F, 0x00, 0x07, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0xC1, 0xC1, 0xF0, 0xE0,
  0x38, 0x70, 0x1C, 0x30, 0x0E, 0x38, 0x07, 0x1C, 0x07, 0x0E, 0x03, 0x86,
  0x07, 0x87, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xF8, 0x03, 0xFC, 0x07, 0xFE, 0x0F, 0x0E, 0x1C, 0x07, 0x3C,
  0x07, 0x38, 0x07, 0x70, 0x07, 0x70, 0x07, 0x70, 0x07, 0xE0, 0x07, 0xE0,
  0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x3C, 0xE0,
  0x78, 0xF0, 0xF0, 0x7F, 0xE0, 0x7F, 0xC0, 0x1F, 0x80, 0x0E, 0x00, 0x0E,
  0x00, 0x0F, 0x80, 0x07, 0xE0, 0x03, 0xE0, 0x00, 0xC0, 0x07, 0xF8, 0x0F,
  0xFE, 0x0F, 0xFF, 0x0E, 0x0F, 0x0E, 0x07, 0x1C, 0x03, 0x1C, 0x03, 0x1C,
  0x07, 0x1C, 0x07, 0x18, 0x0F, 0x38, 0x1E, 0x3F, 0xFC, 0x3F, 0xF8, 0x3F,
  0xE0, 0x70, 0xE0, 0x70, 0x70, 0x70, 0x70, 0x70, 0x38, 0xE0, 0x38, 0xE0,
  0x38, 0xE0, 0x38, 0xE0, 0x1C, 0x00, 0xFE, 0x01, 0xFF, 0xC1, 0xFF, 0xE1,
  0xF0, 0x20, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0F, 0x00,
  0x03, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x18, 0x1F, 0x1F, 0xFF, 0x0F,
  0xFF, 0x01, 0xFE, 0x00, 0x7F, 0xFF, 0x7F, 0xFE, 0xFF, 0xFE, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x1C, 0x03, 0x8E, 0x01, 0xC7, 0x00, 0xE3, 0x00, 0xE3, 0x80, 0x71, 0xC0,
  0x38, 0xE0, 0x1C, 0x60, 0x1C, 0x70, 0x0E, 0x38, 0x07, 0x1C, 0x03, 0x8C,
  0x03, 0x8E, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0x71, 0xC0, 0x70, 0xE0, 0x38,
  0x70, 0x3C, 0x3C, 0x3C, 0x0F, 0xFC, 0x07, 0xFC, 0x00, 0xFC, 0x00, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0,
  0x38, 0xE0, 0x38, 0xE0, 0x70, 0xE0, 0x70, 0xE0, 0xE0, 0xE0, 0xE0, 0xE1,
  0xC0, 0xE1, 0xC0, 0xE3, 0x80, 0x63, 0x00, 0x67, 0x00, 0x66, 0x00, 0x6E,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x0C, 0x00, 0xE3, 0x80, 0x1C,
  0x70, 0x03, 0x0E, 0x00, 0xE1, 0xC0, 0x1C, 0x30, 0x03, 0x0E, 0x00, 0x61,
  0xC0, 0x1C, 0x38, 0xE3, 0x86, 0x3C, 0x60, 0xC7, 0x9C, 0x19, 0xB3, 0x87,
  0x36, 0x60, 0xEC, 0xCC, 0x19, 0x9B, 0x83, 0x63, 0x60, 0x6C, 0x6C, 0x0F,
  0x0D, 0x83, 0xE1, 0xE0, 0x78, 0x3C, 0x0F, 0x07, 0x81, 0xC0, 0xE0, 0x00,
  0x03, 0x80, 0x38, 0x0E, 0x03, 0x80, 0x70, 0x3C, 0x03, 0x81, 0xC0, 0x0E,
  0x1C, 0x00, 0x71, 0xC0, 0x03, 0x9C, 0x00, 0x0E, 0xE0, 0x00, 0x7E, 0x00,
  0x03, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0xFE,
  0x00, 0x0F, 0x30, 0x00, 0x71, 0xC0, 0x07, 0x0E, 0x00, 0x70, 0x70, 0x07,
  0x81, 0xC0, 0x78, 0x0E, 0x03, 0x80, 0x70, 0x38, 0x03, 0x80, 0xE0, 0x07,
  0x70, 0x03, 0x98, 0x03, 0x8E, 0x03, 0xC7, 0x01, 0xC3, 0x81, 0xC1, 0xC1,
  0xC0, 0x60, 0xE0, 0x38, 0xE0, 0x1C, 0xE0, 0x06, 0x60, 0x03, 0xF0, 0x01,
  0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x03, 0xFF, 0xE0,
  0x7F, 0xFC, 0x1F, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x3F, 0xFF, 0x07, 0xFF, 0xC1, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xC0, 0x01, 0xC0,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x7F, 0x80, 0x7F, 0x80,
  0x7F, 0x80, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x38, 0xC7, 0x39, 0xCE,
  0x73, 0x9C, 0xE7, 0x39, 0xC6, 0x39, 0xCE, 0x73, 0x9C, 0x01, 0xFE, 0x01,
  0xFE, 0x01, 0xFE, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03,
  0x80, 0x03, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x00, 0x00, 0xE0, 0x07,
  0x80, 0x3E, 0x01, 0xFC, 0x07, 0x70, 0x38, 0xC1, 0xC3, 0x8E, 0x0E, 0x38,
  0x19, 0xC0, 0x7E, 0x01, 0xD0, 0x02, 0x7F, 0xFF, 0xFF, 0xFF, 0x23, 0xC7,
  0x0E, 0x1C, 0x20, 0x00, 0xFE, 0x03, 0xFF, 0x0F, 0xFF, 0x1F, 0x06, 0x3C,
  0x0E, 0x38, 0x0E, 0x70, 0x0C, 0x70, 0x1C, 0x70, 0x1C, 0x60, 0x18, 0xE0,
  0x38, 0x70, 0x38, 0x70, 0x78, 0x7F, 0xF8, 0x3F, 0xD8, 0x1F, 0x9C, 0x03,
  0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0xF8, 0x0F, 0xFC, 0x1F, 0xFE, 0x1E, 0x0E, 0x1C,
  0x07, 0x1C, 0x07, 0x38, 0x07, 0x38, 0x06, 0x38, 0x0E, 0x30, 0x0E, 0x70,
  0x1C, 0x70, 0x3C, 0x70, 0xF8, 0x7F, 0xF0, 0x7F, 0xE0, 0xFF, 0x00, 0x00,
  0xFE, 0x07, 0xFF, 0x0F, 0xFE, 0x1F, 0x02, 0x3C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78,
  0x08, 0x7F, 0xF8, 0x3F, 0xF8, 0x0F, 0xE0, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C,
  0x01, 0xFE, 0x03, 0xFF, 0x07, 0xC3, 0x87, 0x81, 0x83, 0x81, 0xC3, 0x80,
  0xE1, 0xC0, 0x71, 0xC0, 0x38, 0xE0, 0x38, 0x70, 0x1C, 0x38, 0x0E, 0x1C,
  0x07, 0x0E, 0x07, 0x07, 0x87, 0xC1, 0xFF, 0xE0, 0x3E, 0x70, 0x01, 0xF8,
  0x07, 0xFE, 0x0F, 0xFE, 0x1E, 0x0F, 0x3C, 0x07, 0x78, 0x0E, 0x70, 0x3E,
  0x7F, 0xFC, 0x7F, 0xF8, 0xFF, 0xC0, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x08,
  0x7F, 0xF8, 0x3F, 0xF8, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xC0,
  0x03, 0xFC, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x7F, 0xE0, 0x3C, 0x38, 0x1C, 0x0E, 0x0E, 0x03,
  0x87, 0x01, 0xC1, 0xC0, 0x70, 0xE0, 0x1C, 0x38, 0x06, 0x0E, 0x03, 0x83,
  0x80, 0xE0, 0xE0, 0x38, 0x3C, 0x3C, 0x07, 0xFF, 0x00, 0xFD, 0xC0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x0E, 0x04, 0x0F, 0x03, 0xFF, 0xC0, 0xFF, 0xE0,
  0x0F, 0xE0, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1D, 0xF0, 0x3F, 0xF8, 0x7F, 0xF0,
  0xE0, 0xF3, 0x80, 0xE7, 0x01, 0xCE, 0x03, 0x9C, 0x0E, 0x70, 0x1C, 0xE0,
  0x39, 0xC0, 0x73, 0x81, 0xCE, 0x03, 0x9C, 0x07, 0x38, 0x0E, 0x70, 0x38,
  0x03, 0x01, 0xE0, 0xF8, 0x1E, 0x07, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x3F,
  0x8F, 0xE0, 0x38, 0x0E, 0x03, 0x01, 0xC0, 0x70, 0x1C, 0x06, 0x03, 0x80,
  0xE0, 0x3C, 0x07, 0xF1, 0xFC, 0x1F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03,
  0xE0, 0x01, 0xE0, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x70, 0x10, 0x78, 0x1F, 0xF8, 0x0F, 0xF8, 0x01, 0xF0, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x07, 0x87, 0x07, 0x87, 0x07, 0x03, 0x87, 0x01,
  0xCF, 0x00, 0xEF, 0x00, 0xEE, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x1D, 0xE0,
  0x0C, 0x78, 0x0E, 0x1E, 0x07, 0x07, 0x03, 0x81, 0xC1, 0x80, 0xE1, 0xC0,
  0x38, 0x7F, 0x1F, 0xCF, 0xF0, 0x1C, 0x06, 0x03, 0x80, 0xE0, 0x38, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x38, 0x0E, 0x03, 0x80, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x9F, 0xE3, 0xF8, 0x7C, 0x07, 0xCF, 0x07, 0xFF, 0xC7,
  0x1C, 0xE3, 0x8C, 0x31, 0xC6, 0x38, 0xC7, 0x1C, 0xE3, 0x8E, 0x71, 0xC6,
  0x38, 0xC7, 0x18, 0xE3, 0x9C, 0x01, 0xCE, 0x00, 0xC7, 0x00, 0xE3, 0x00,
  0x73, 0x80, 0x39, 0xC0, 0x18, 0x03, 0xF8, 0x1F, 0xF8, 0x3F, 0xF8, 0xE0,
  0xF1, 0xC0, 0xE3, 0x81, 0xC7, 0x03, 0x9C, 0x07, 0x38, 0x0E, 0x70, 0x1C,
  0xE0, 0x73, 0x80, 0xE7, 0x01, 0xCE, 0x03, 0x98, 0x0E, 0x70, 0x1C, 0x03,
  0xF0, 0x1F, 0xF0, 0x7F, 0xF1, 0xF0, 0xE7, 0x80, 0xEE, 0x01, 0xFC, 0x03,
  0xF0, 0x06, 0xE0, 0x1D, 0xC0, 0x3B, 0x80, 0xF7, 0x03, 0xCF, 0x0F, 0x1F,
  0xFE, 0x1F, 0xF0, 0x0F, 0xC0, 0x01, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0xC1,
  0xC1, 0xE0, 0xE0, 0x78, 0x70, 0x1C, 0x70, 0x0E, 0x38, 0x06, 0x1C, 0x07,
  0x0C, 0x03, 0x8E, 0x03, 0xC7, 0x03, 0xC3, 0x87, 0xC1, 0xFF, 0xC1, 0xFF,
  0xC0, 0xFF, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xFE, 0x0F, 0xFC, 0x7C, 0x39, 0xE0, 0x73,
  0x81, 0xCE, 0x03, 0x9C, 0x07, 0x70, 0x0E, 0xE0, 0x39, 0xC0, 0x73, 0x80,
  0xE7, 0x01, 0xCE, 0x07, 0x1E, 0x1E, 0x1F, 0xFC, 0x0F, 0xB8, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x03, 0xFE,
  0x1F, 0xFC, 0x7F, 0xF8, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x38, 0x00, 0x70, 0x00, 0x03, 0xF8, 0x0F, 0xF8, 0x3F, 0xF0, 0xF0, 0x61,
  0xC0, 0x03, 0x80, 0x07, 0xC0, 0x07, 0xF0, 0x07, 0xF0, 0x01, 0xE0, 0x01,
  0xC0, 0x01, 0x84, 0x07, 0x1F, 0xFE, 0x3F, 0xF8, 0x1F, 0xC0, 0x07, 0x00,
  0x38, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0x1C,
  0x00, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0xC2, 0x1F, 0xF0, 0x7F, 0x81, 0xF8, 0x00, 0x38, 0x0E, 0x70,
  0x1C, 0xE0, 0x73, 0x80, 0xE7, 0x01, 0xCE, 0x03, 0x98, 0x0E, 0x70, 0x1C,
  0xE0, 0x39, 0xC0, 0x63, 0x81, 0xC7, 0x03, 0x8F, 0x1F, 0x1F, 0xFE, 0x1F,
  0xEC, 0x1F, 0x9C, 0xE0, 0x1B, 0x80, 0xEE, 0x03, 0xB8, 0x1C, 0xE0, 0x73,
  0x83, 0x8E, 0x0E, 0x38, 0x70, 0xE1, 0xC3, 0x8E, 0x07, 0x30, 0x1D, 0xC0,
  0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0xB8, 0x01, 0xD8,
  0x00, 0xCC, 0x00, 0xEE, 0x18, 0x77, 0x1C, 0x33, 0x8E, 0x39, 0xCF, 0x98,
  0xE7, 0xCC, 0x76, 0x6E, 0x37, 0x36, 0x1B, 0x1F, 0x0F, 0x8F, 0x07, 0x87,
  0x83, 0x83, 0xC1, 0xC1, 0xC0, 0x0E, 0x03, 0x81, 0xC1, 0xE0, 0x70, 0x70,
  0x0E, 0x38, 0x03, 0x9C, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x03, 0x80, 0x01,
  0xE0, 0x00, 0xFC, 0x00, 0x77, 0x00, 0x38, 0xE0, 0x1C, 0x38, 0x0E, 0x07,
  0x07, 0x01, 0xC3, 0x80, 0x38, 0x03, 0x80, 0x70, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x81, 0xC0, 0x38, 0x1C, 0x03, 0x83, 0x80, 0x1C,
  0x38, 0x01, 0xC7, 0x00, 0x1C, 0x70, 0x01, 0xCE, 0x00, 0x0C, 0xE0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x43, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFE, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0x7F, 0xF8, 0xFF, 0xF0, 0xFF, 0xF0, 0x00, 0x1F, 0x80, 0x3F,
  0xC0, 0x3F, 0xE0, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00,
  0x70, 0x01, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x0E, 0x00, 0x03, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7E, 0x00,
  0x00, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x01,
  0xC0, 0x70, 0x1C, 0x06, 0x03, 0x80, 0xE0, 0x38, 0x0C, 0x07, 0x01, 0xC0,
  0x70, 0x18, 0x0E, 0x03, 0x80, 0xE0, 0x30, 0x1C, 0x07, 0x01, 0xC0, 0x60,
  0x38, 0x00, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x3E, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x1F,
  0xF0, 0x0F, 0xF0, 0x07, 0xE0, 0x00, 0x1E, 0x04, 0x7E, 0x1D, 0xFE, 0x37,
  0x1F, 0xEC, 0x1F, 0x98, 0x1E, 0x00,
};

const GFXglyph UbuntuMono_Italic35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 8, 22, 18, 6, -22 },
  { 23, 10, 9, 18, 8, -22 },
  { 35, 19, 22, 18, 1, -22 },
  { 88, 17, 27, 18, 2, -24 },
  { 146, 21, 22, 18, 0, -22 },
  { 204, 15, 22, 18, 2, -22 },
  { 246, 5, 9, 18, 10, -24 },
  { 252, 13, 31, 18, 5, -25 },
  { 303, 13, 31, 18, 2, -25 },
  { 354, 13, 13, 18, 5, -22 },
  { 376, 15, 14, 18, 3, -16 },
  { 403, 7, 10, 18, 4, -5 },
  { 412, 8, 3, 18, 6, -11 },
  { 415, 5, 5, 18, 6, -5 },
  { 419, 20, 30, 18, -1, -24 },
  { 494, 15, 22, 18, 3, -22 },
  { 536, 13, 22, 18, 3, -22 },
  { 572, 16, 22, 18, 2, -22 },
  { 616, 16, 22, 18, 2, -22 },
  { 660, 16, 22, 18, 2, -22 },
  { 704, 17, 22, 18, 2, -22 },
  { 751, 16, 22, 18, 3, -22 },
  { 795, 16, 22, 18, 5, -22 },
  { 839, 16, 22, 18, 3, -22 },
  { 883, 16, 22, 18, 3, -22 },
  { 927, 8, 16, 18, 6, -16 },
  { 943, 10, 21, 18, 4, -16 },
  { 970, 15, 14, 18, 3, -16 },
  { 997, 16, 8, 18, 2, -13 },
  { 1013, 16, 14, 18, 2, -16 },
  { 1041, 12, 22, 18, 6, -22 },
  { 1074, 18, 27, 18, 2, -22 },
  { 1135, 16, 22, 18, 0, -22 },
  { 1179, 16, 22, 18, 2, -22 },
  { 1223, 17, 22, 18, 3, -22 },
  { 1270, 17, 22, 18, 1, -22 },
  { 1317, 18, 22, 18, 2, -22 },
  { 1367, 18, 22, 18, 2, -22 },
  { 1417, 17, 22, 18, 3, -22 },
  { 1464, 19, 22, 18, 1, -22 },
  { 1517, 17, 22, 18, 2, -22 },
  { 1564, 17, 22, 18, 2, -22 },
  { 1611, 19, 22, 18, 2, -22 },
  { 1664, 13, 22, 18, 2, -22 },
  { 1700, 19, 22, 18, 1, -22 },
  { 1753, 19, 22, 18, 1, -22 },
  { 1806, 16, 22, 18, 3, -22 },
  { 1850, 17, 22, 18, 2, -22 },
  { 1897, 16, 28, 18, 3, -22 },
  { 1953, 16, 22, 18, 2, -22 },
  { 1997, 17, 22, 18, 2, -22 },
  { 2044, 16, 22, 18, 5, -22 },
  { 2088, 17, 22, 18, 3, -22 },
  { 2135, 16, 22, 18, 5, -22 },
  { 2179, 19, 22, 18, 2, -22 },
  { 2232, 21, 22, 18, 0, -22 },
  { 2290, 17, 22, 18, 5, -22 },
  { 2337, 19, 22, 18, 1, -22 },
  { 2390, 16, 30, 18, 3, -24 },
  { 2450, 5, 30, 18, 8, -24 },
  { 2469, 16, 30, 18, 1, -24 },
  { 2529, 14, 12, 18, 4, -22 },
  { 2550, 16, 2, 18, -1, 3 },
  { 2554, 6, 6, 18, 9, -24 },
  { 2559, 16, 16, 18, 2, -16 },
  { 2591, 16, 24, 18, 2, -24 },
  { 2639, 16, 16, 18, 2, -16 },
  { 2671, 17, 24, 18, 3, -24 },
  { 2722, 16, 16, 18, 2, -16 },
  { 2754, 21, 30, 18, 0, -24 },
  { 2833, 18, 22, 18, 1, -16 },
  { 2883, 15, 24, 18, 2, -24 },
  { 2928, 10, 24, 18, 5, -24 },
  { 2958, 17, 30, 18, 1, -24 },
  { 3022, 17, 24, 18, 2, -24 },
  { 3073, 10, 24, 18, 6, -24 },
  { 3103, 17, 16, 18, 1, -16 },
  { 3137, 15, 16, 18, 2, -16 },
  { 3167, 15, 16, 18, 3, -16 },
  { 3197, 17, 22, 18, 1, -16 },
  { 3244, 15, 22, 18, 3, -16 },
  { 3286, 15, 16, 18, 3, -16 },
  { 3316, 15, 16, 18, 3, -16 },
  { 3346, 13, 21, 18, 5, -21 },
  { 3381, 15, 16, 18, 3, -16 },
  { 3411, 14, 16, 18, 5, -16 },
  { 3439, 17, 16, 18, 3, -16 },
  { 3473, 18, 16, 18, 1, -16 },
  { 3509, 20, 22, 18, -1, -16 },
  { 3564, 16, 16, 18, 2, -16 },
  { 3596, 17, 30, 18, 3, -24 },
  { 3660, 10, 30, 18, 5, -24 },
  { 3698, 17, 30, 18, 0, -24 },
  { 3762, 15, 6, 18, 3, -15 },
};

const GFXfont UbuntuMono_Italic35pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Italic35pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Italic35pt7bGlyphs,
  0x20, 0x7E, 35
};

#endif // _UBUNTUMONO_ITALIC35PT7B_H_
