#ifndef _UBUNTUMONO_ITALIC27PT7B_H_
#define _UBUNTUMONO_ITALIC27PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Italic.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Italic27pt7bBitmaps[] PROGMEM = {
  0x00, 0x0C, 0x71, 0xC6, 0x18, 0xE3, 0x8C, 0x30, 0xC2, 0x00, 0x03, 0x8E,
  0x38, 0xE0, 0x67, 0x66, 0x66, 0xC6, 0xC4, 0xC4, 0x8C, 0x01, 0x8C, 0x06,
  0x30, 0x31, 0x80, 0xC6, 0x3F, 0xFC, 0xFF, 0xF0, 0xC6, 0x03, 0x18, 0x0C,
  0x60, 0x63, 0x01, 0x8C, 0x1F, 0xFE, 0xFF, 0xF0, 0xC6, 0x06, 0x30, 0x18,
  0xC0, 0xC6, 0x00, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x3E, 0x0F, 0xF1, 0xC1,
  0x18, 0x01, 0x80, 0x18, 0x01, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xC0, 0x0E,
  0x00, 0xE0, 0x0C, 0x41, 0xCF, 0xF8, 0x7F, 0x00, 0x80, 0x18, 0x01, 0x80,
  0x07, 0x03, 0x0F, 0x86, 0x19, 0x8C, 0x19, 0x98, 0x11, 0x98, 0x13, 0x30,
  0x1F, 0x60, 0x1E, 0xC0, 0x01, 0x80, 0x03, 0x38, 0x03, 0x7C, 0x06, 0xCC,
  0x0C, 0xCC, 0x18, 0x8C, 0x30, 0x98, 0x60, 0xF8, 0x60, 0xF0, 0x07, 0x81,
  0xF8, 0x73, 0x8C, 0x61, 0x8C, 0x33, 0x86, 0xE0, 0xF8, 0x1C, 0x6F, 0xCF,
  0x9F, 0x61, 0xEC, 0x39, 0x83, 0x31, 0xF7, 0xF6, 0x78, 0xC0, 0x76, 0x66,
  0xCC, 0xC0, 0x00, 0xC0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x01, 0x80, 0xC0,
  0x70, 0x18, 0x06, 0x03, 0x80, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0E, 0x01, 0x80, 0x70, 0x0C, 0x03, 0x80, 0x40, 0x04, 0x01, 0x80, 0x70,
  0x0C, 0x01, 0x80, 0x60, 0x18, 0x07, 0x00, 0xC0, 0x30, 0x1C, 0x06, 0x01,
  0x80, 0x60, 0x38, 0x0C, 0x07, 0x01, 0x80, 0xC0, 0x70, 0x38, 0x1C, 0x0E,
  0x02, 0x00, 0x0C, 0x03, 0x0C, 0xCF, 0xFF, 0x7F, 0x07, 0x03, 0xE0, 0xDC,
  0x73, 0x88, 0x40, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x06, 0x07, 0xFF,
  0xFF, 0xE0, 0x60, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x38, 0xF3, 0xCF,
  0x18, 0xEF, 0x30, 0xFF, 0xF0, 0xEF, 0xFE, 0x00, 0x0E, 0x00, 0x18, 0x00,
  0x70, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0,
  0x03, 0x80, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x80, 0x06,
  0x00, 0x1C, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x1C, 0x00,
  0x30, 0x00, 0x00, 0x03, 0xC0, 0xFE, 0x1C, 0x71, 0x83, 0x38, 0x33, 0x03,
  0x76, 0x36, 0x73, 0x67, 0x7E, 0x66, 0xE0, 0x6E, 0x0E, 0xE0, 0xCE, 0x1C,
  0x63, 0x87, 0xF0, 0x3C, 0x00, 0x00, 0xC0, 0xF0, 0xFC, 0x7F, 0x19, 0x80,
  0x60, 0x18, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x1C, 0x06, 0x01, 0x80, 0x61,
  0xFF, 0x7F, 0xC0, 0x07, 0xC0, 0xFE, 0x1C, 0x71, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x60, 0x0E, 0x01, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0x60, 0x0F, 0xFC, 0xFF, 0xC0, 0x07, 0xC1, 0xFE, 0x08, 0x70, 0x03, 0x00,
  0x30, 0x06, 0x00, 0xE0, 0xF8, 0x0F, 0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0C, 0x81, 0xCF, 0xF8, 0x7E, 0x00, 0x00, 0x38, 0x03, 0x80, 0x3C,
  0x03, 0x60, 0x33, 0x03, 0x38, 0x31, 0x83, 0x8C, 0x18, 0x61, 0x87, 0x18,
  0x30, 0xFF, 0xEF, 0xFF, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x07,
  0xF8, 0x3F, 0xC3, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x78, 0x03, 0xF0,
  0x03, 0xC0, 0x06, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0x62, 0x0F, 0x1F,
  0xF0, 0x7E, 0x00, 0x00, 0xF0, 0x3F, 0x0F, 0x01, 0xC0, 0x30, 0x07, 0x00,
  0x6F, 0x0F, 0xFC, 0xE1, 0xCC, 0x0C, 0xC0, 0xCC, 0x0C, 0xC0, 0xCC, 0x1C,
  0xE3, 0x87, 0xF0, 0x3E, 0x00, 0x7F, 0xF7, 0xFF, 0x00, 0xE0, 0x1C, 0x01,
  0x80, 0x30, 0x07, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x18, 0x03, 0x00, 0x30,
  0x06, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x00, 0x03, 0xE0, 0x7F, 0x87, 0x0C,
  0x30, 0x71, 0x83, 0x0C, 0x18, 0x61, 0x83, 0xF8, 0x1F, 0x81, 0xCE, 0x18,
  0x39, 0xC0, 0xCC, 0x06, 0x60, 0x73, 0x87, 0x0F, 0xF0, 0x3F, 0x00, 0x07,
  0xC0, 0xFE, 0x1C, 0x73, 0x83, 0x30, 0x33, 0x03, 0x30, 0x33, 0x87, 0x3F,
  0xF0, 0xFF, 0x00, 0x60, 0x0E, 0x01, 0xC0, 0x38, 0x0F, 0x0F, 0xE0, 0xF0,
  0x00, 0x18, 0xF3, 0xCE, 0x00, 0x00, 0x00, 0x03, 0x8F, 0x3C, 0xE0, 0x06,
  0x0F, 0x0F, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x3C, 0x3C, 0x3C,
  0x18, 0x38, 0xF0, 0xC0, 0x00, 0x10, 0x0F, 0x07, 0xE1, 0xF0, 0x78, 0x0E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xC0, 0x7F, 0xF7, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0xFF, 0xE0, 0x20, 0x03, 0x80, 0x3E,
  0x00, 0x78, 0x01, 0xE0, 0x06, 0x03, 0xE0, 0xF8, 0x7C, 0x0F, 0x00, 0x80,
  0x00, 0x1F, 0x0F, 0xF2, 0x1C, 0x03, 0x00, 0xC0, 0x60, 0x30, 0x38, 0x1C,
  0x06, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x0F, 0x03, 0xC0, 0x60, 0x00, 0x03,
  0xE0, 0x3F, 0x83, 0x8E, 0x30, 0x33, 0x81, 0x98, 0x0D, 0x87, 0xEC, 0x7F,
  0xE7, 0x36, 0x71, 0xB3, 0x0D, 0x98, 0xEC, 0xC6, 0x67, 0x33, 0x1F, 0x98,
  0x7C, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x00, 0xF0,
  0x07, 0x80, 0x6C, 0x03, 0x60, 0x33, 0x01, 0x98, 0x18, 0xC0, 0xC6, 0x0C,
  0x30, 0xE1, 0x86, 0x0C, 0x7F, 0xE3, 0xFF, 0x38, 0x1D, 0x80, 0xFC, 0x07,
  0xC0, 0x38, 0x0F, 0xE0, 0x7F, 0xC7, 0x0E, 0x38, 0x31, 0x81, 0x8C, 0x1C,
  0x61, 0xC7, 0xFC, 0x3F, 0xE1, 0x83, 0x8C, 0x0C, 0xE0, 0x66, 0x03, 0x30,
  0x39, 0x83, 0x8F, 0xF8, 0xFF, 0x00, 0x01, 0xF0, 0x1F, 0xE0, 0xE0, 0x87,
  0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x04, 0x0F, 0xF0, 0x1F, 0x80,
  0x0F, 0xC0, 0x7F, 0x87, 0x1C, 0x30, 0x71, 0x81, 0x8C, 0x0C, 0xE0, 0x66,
  0x03, 0x30, 0x19, 0x81, 0xDC, 0x0C, 0xC0, 0x66, 0x07, 0x30, 0x73, 0x8F,
  0x1F, 0xF0, 0xFE, 0x00, 0x0F, 0xF8, 0x7F, 0xC7, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0xE0, 0x07, 0xFC, 0x3F, 0xC1, 0x80, 0x1C, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x1F, 0xF8, 0xFF, 0xC0, 0x0F, 0xF8, 0x7F, 0xC7,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07, 0xFC, 0x3F, 0xE1, 0x80,
  0x1C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x00,
  0x03, 0xF0, 0x3F, 0xC7, 0x84, 0x30, 0x03, 0x00, 0x38, 0x01, 0x80, 0x0C,
  0x00, 0xE0, 0x07, 0x03, 0x30, 0x19, 0x80, 0xCE, 0x0E, 0x70, 0x61, 0xC3,
  0x07, 0xF8, 0x1F, 0x80, 0x0C, 0x0C, 0x18, 0x18, 0x70, 0x30, 0xC0, 0xE1,
  0x81, 0xC3, 0x03, 0x0E, 0x06, 0x1F, 0xFC, 0x3F, 0xF8, 0x60, 0x61, 0xC0,
  0xC3, 0x01, 0x86, 0x07, 0x0C, 0x0C, 0x18, 0x18, 0x70, 0x30, 0xC0, 0xE0,
  0x0F, 0xF8, 0x7F, 0x80, 0x60, 0x07, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0xE0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x1F, 0xF0, 0xFF, 0x80, 0x07, 0xF8, 0x3F, 0xC0, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0xE1, 0x0E, 0x1F, 0xE0, 0x7E, 0x00, 0x0C, 0x0C, 0x18, 0x38,
  0x30, 0xE0, 0xE3, 0x81, 0x8E, 0x03, 0x38, 0x06, 0xE0, 0x1F, 0x80, 0x3E,
  0x00, 0x6C, 0x00, 0xCC, 0x01, 0x9C, 0x07, 0x18, 0x0C, 0x18, 0x18, 0x38,
  0x30, 0x30, 0xE0, 0x60, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x1C, 0x06, 0x01,
  0x80, 0x60, 0x38, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x18, 0x06, 0x01, 0xFF,
  0x7F, 0xC0, 0x03, 0x06, 0x0E, 0x1C, 0x1C, 0x38, 0x78, 0xF0, 0xF1, 0x41,
  0xA6, 0x82, 0x4B, 0x0C, 0xB6, 0x19, 0x4C, 0x33, 0x98, 0xC6, 0x61, 0x80,
  0xC3, 0x01, 0x8E, 0x03, 0x18, 0x06, 0x30, 0x1C, 0x60, 0x30, 0x0C, 0x0E,
  0x1C, 0x18, 0x38, 0x30, 0xF0, 0x61, 0xB0, 0xC3, 0x63, 0x06, 0xC6, 0x19,
  0x8C, 0x31, 0x98, 0x63, 0x60, 0xC6, 0xC3, 0x0D, 0x86, 0x0B, 0x0C, 0x1C,
  0x18, 0x38, 0x60, 0x70, 0xC0, 0xE0, 0x03, 0xC0, 0x7F, 0x87, 0x1C, 0x30,
  0x63, 0x03, 0xB8, 0x1D, 0x80, 0xEC, 0x06, 0x60, 0x37, 0x01, 0xB0, 0x1D,
  0x80, 0xCC, 0x0E, 0x70, 0x61, 0x87, 0x0F, 0xF0, 0x3E, 0x00, 0x0F, 0xE0,
  0x3F, 0xE0, 0xC3, 0x83, 0x07, 0x1C, 0x1C, 0x60, 0x71, 0x81, 0x86, 0x0E,
  0x38, 0x70, 0xFF, 0x83, 0xF8, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x00, 0x03, 0xC0, 0x7F, 0x87, 0x1C, 0x30, 0x63, 0x03,
  0xB8, 0x1D, 0x80, 0xEC, 0x06, 0x60, 0x37, 0x01, 0xB0, 0x1D, 0x80, 0xCC,
  0x0E, 0x70, 0x61, 0x87, 0x0F, 0xF0, 0x3E, 0x00, 0xC0, 0x07, 0x80, 0x1F,
  0x00, 0x30, 0x00, 0x0F, 0xE0, 0x7F, 0x83, 0x0E, 0x38, 0x31, 0x81, 0x8C,
  0x0C, 0x60, 0x67, 0x07, 0x38, 0x71, 0xFF, 0x0F, 0xE0, 0x63, 0x07, 0x1C,
  0x30, 0x61, 0x83, 0x0C, 0x0C, 0xE0, 0x60, 0x01, 0xF0, 0x1F, 0xF0, 0xE0,
  0x83, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07,
  0x80, 0x06, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x86, 0x0E, 0x1F, 0xF0, 0x3F,
  0x00, 0xFF, 0xFF, 0xFF, 0x06, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x01,
  0xC0, 0x18, 0x01, 0x80, 0x18, 0x03, 0x80, 0x30, 0x03, 0x00, 0x30, 0x07,
  0x00, 0x60, 0x00, 0x18, 0x18, 0x60, 0x63, 0x81, 0x8C, 0x0E, 0x30, 0x30,
  0xC0, 0xC7, 0x03, 0x18, 0x1C, 0x60, 0x71, 0x81, 0x8E, 0x06, 0x30, 0x38,
  0xC0, 0xC3, 0x83, 0x06, 0x1C, 0x1F, 0xE0, 0x3E, 0x00, 0xC0, 0x36, 0x03,
  0xB0, 0x19, 0x80, 0xCC, 0x0C, 0x60, 0x63, 0x06, 0x18, 0x30, 0xC3, 0x06,
  0x18, 0x31, 0x81, 0x9C, 0x0C, 0xC0, 0x6C, 0x03, 0xE0, 0x0E, 0x00, 0x70,
  0x00, 0x30, 0x0C, 0xC0, 0x33, 0x01, 0x8C, 0x06, 0x30, 0x19, 0x80, 0x66,
  0x73, 0x19, 0xCC, 0x6F, 0x31, 0x3C, 0x8D, 0xB6, 0x36, 0x58, 0xF1, 0x63,
  0x87, 0x0E, 0x1C, 0x30, 0x60, 0xC1, 0x80, 0x06, 0x03, 0x07, 0x06, 0x03,
  0x0E, 0x03, 0x1C, 0x03, 0x98, 0x01, 0xB0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xC0, 0x03, 0xC0, 0x07, 0x60, 0x06, 0x60, 0x0E, 0x70, 0x1C, 0x30, 0x38,
  0x30, 0x70, 0x30, 0x60, 0x38, 0xC0, 0x3E, 0x03, 0xB8, 0x18, 0xC1, 0xC6,
  0x0C, 0x30, 0xC1, 0x8C, 0x06, 0x60, 0x36, 0x01, 0xE0, 0x06, 0x00, 0x30,
  0x03, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x00, 0x0F, 0xFC, 0x3F,
  0xF0, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0xC0, 0x06, 0x00, 0x3F,
  0xF8, 0xFF, 0xE0, 0x07, 0xF0, 0x7E, 0x06, 0x00, 0xE0, 0x0C, 0x00, 0xC0,
  0x0C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x03, 0x80, 0x30, 0x03, 0x00,
  0x30, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x0F, 0xC0,
  0xFC, 0x00, 0xCC, 0xCC, 0xEE, 0xE6, 0x66, 0x66, 0x66, 0x66, 0x67, 0x77,
  0x33, 0x30, 0x07, 0xF0, 0x7E, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x0F, 0xE0, 0xFC,
  0x00, 0x03, 0x00, 0xF0, 0x3E, 0x06, 0xC1, 0x8C, 0x61, 0x9C, 0x37, 0x03,
  0x40, 0x40, 0x7F, 0xFF, 0xFF, 0x80, 0x47, 0x1C, 0x61, 0x00, 0x07, 0xE1,
  0xFF, 0x3C, 0x67, 0x06, 0x60, 0x6E, 0x0E, 0xC0, 0xCC, 0x0C, 0xC0, 0xCC,
  0x0C, 0xE3, 0xC7, 0xFC, 0x3E, 0xC0, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x1F, 0xC3, 0xFE, 0x38, 0x63, 0x07, 0x30, 0x77, 0x07,
  0x60, 0x66, 0x06, 0x60, 0xEE, 0x1C, 0xC3, 0x8F, 0xF0, 0xFC, 0x00, 0x07,
  0xE1, 0xFF, 0x3C, 0x27, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xE0, 0x47, 0xFC, 0x1F, 0x80, 0x00, 0x1C, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x3F, 0x03, 0xFC, 0x3C, 0x70, 0xC1,
  0x87, 0x06, 0x18, 0x18, 0xE0, 0xE3, 0x03, 0x0C, 0x0C, 0x38, 0x30, 0xE1,
  0xC1, 0xFF, 0x03, 0xEC, 0x00, 0x07, 0xC1, 0xFE, 0x38, 0x77, 0x07, 0x60,
  0x6E, 0x1E, 0xFF, 0xCF, 0xE0, 0xC0, 0x0C, 0x00, 0xE0, 0xC7, 0xFC, 0x1F,
  0x80, 0x00, 0x1F, 0x00, 0x7F, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x07, 0xFE, 0x0F, 0xFC, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0x01,
  0xF8, 0x3F, 0xC3, 0x86, 0x38, 0x73, 0x83, 0x18, 0x19, 0xC0, 0xCE, 0x0E,
  0x70, 0x63, 0x87, 0x0F, 0xF8, 0x3D, 0x80, 0x0C, 0x00, 0xE2, 0x0E, 0x1F,
  0xE0, 0x7E, 0x00, 0x06, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0xC0,
  0x1F, 0xC1, 0xFE, 0x18, 0x73, 0x83, 0x30, 0x33, 0x03, 0x30, 0x73, 0x06,
  0x70, 0x66, 0x06, 0x60, 0xE6, 0x0C, 0xE0, 0xC0, 0x0C, 0x1E, 0x1E, 0x0C,
  0x00, 0x00, 0xFC, 0xFC, 0x18, 0x18, 0x18, 0x38, 0x30, 0x30, 0x30, 0x30,
  0x30, 0x3E, 0x1E, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x07, 0x08,
  0x70, 0x7F, 0x03, 0xF0, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01,
  0x80, 0x0C, 0x00, 0x61, 0xC7, 0x1C, 0x31, 0xC1, 0xBC, 0x0F, 0x80, 0xF8,
  0x06, 0xE0, 0x33, 0x01, 0x8C, 0x0C, 0x70, 0xC1, 0x86, 0x0E, 0x30, 0x30,
  0xFD, 0xF8, 0x70, 0xC1, 0x83, 0x0E, 0x18, 0x30, 0x61, 0xC3, 0x06, 0x0C,
  0x38, 0x70, 0xE2, 0xFC, 0xF0, 0x1F, 0x70, 0xFF, 0xCC, 0xE6, 0x63, 0x33,
  0x31, 0x99, 0x8D, 0x8C, 0xCC, 0x66, 0x60, 0x33, 0x01, 0xB0, 0x19, 0x80,
  0xCC, 0x06, 0x00, 0x1F, 0xC7, 0xFC, 0xC3, 0x98, 0x33, 0x06, 0xE0, 0xD8,
  0x1B, 0x07, 0x60, 0xCC, 0x1B, 0x83, 0x60, 0x6C, 0x1C, 0x07, 0xC1, 0xFE,
  0x38, 0x67, 0x07, 0x60, 0x76, 0x07, 0xE0, 0x6C, 0x06, 0xC0, 0xEE, 0x0C,
  0xE1, 0xC7, 0xF8, 0x3E, 0x00, 0x07, 0xE0, 0x3F, 0xE0, 0xC3, 0x83, 0x07,
  0x0C, 0x1C, 0x70, 0x71, 0x81, 0x86, 0x06, 0x18, 0x38, 0xE1, 0xC3, 0x0E,
  0x0F, 0xF0, 0x3F, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x00, 0x03,
  0xF0, 0xFF, 0x3C, 0x73, 0x06, 0x70, 0x66, 0x06, 0xE0, 0xEC, 0x0C, 0xC0,
  0xCE, 0x0C, 0xE1, 0xC7, 0xF8, 0x3F, 0x80, 0x18, 0x03, 0x80, 0x30, 0x03,
  0x00, 0x07, 0xF1, 0xFF, 0x18, 0x01, 0x80, 0x38, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x00, 0x07, 0xE1, 0xFE,
  0x18, 0x21, 0x80, 0x18, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xC0, 0x0C,
  0x41, 0xCF, 0xF8, 0x7E, 0x00, 0x0C, 0x07, 0x01, 0x80, 0x60, 0xFF, 0xFF,
  0xF3, 0x00, 0xC0, 0x30, 0x1C, 0x07, 0x01, 0x80, 0x60, 0x18, 0x06, 0x11,
  0xFC, 0x3E, 0x00, 0x30, 0x33, 0x07, 0x30, 0x67, 0x06, 0x60, 0x66, 0x0E,
  0x60, 0xCE, 0x0C, 0xC0, 0xCE, 0x0C, 0xE3, 0xC7, 0xFC, 0x3C, 0xC0, 0xC0,
  0xF0, 0x3C, 0x1B, 0x06, 0xC3, 0xB0, 0xCC, 0x73, 0x18, 0xEC, 0x1B, 0x07,
  0x81, 0xC0, 0x70, 0x00, 0x60, 0x19, 0x80, 0x66, 0x01, 0x98, 0xCC, 0x67,
  0x31, 0x9C, 0xCC, 0xF6, 0x32, 0xD8, 0xDB, 0x63, 0xCF, 0x0F, 0x3C, 0x38,
  0x60, 0xC1, 0x80, 0x0C, 0x0C, 0x1C, 0x38, 0x18, 0xE0, 0x3B, 0x80, 0x36,
  0x00, 0x78, 0x00, 0x60, 0x01, 0xE0, 0x07, 0xC0, 0x1D, 0xC0, 0x71, 0x81,
  0xC3, 0x87, 0x03, 0x00, 0x0C, 0x0C, 0x30, 0x30, 0xC1, 0xC3, 0x06, 0x0C,
  0x18, 0x38, 0xC0, 0x63, 0x01, 0x98, 0x06, 0x60, 0x1B, 0x00, 0x7C, 0x00,
  0xE0, 0x03, 0x00, 0x1C, 0x00, 0xE0, 0x3F, 0x00, 0xF0, 0x00, 0x1F, 0xF1,
  0xFE, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0x60, 0x0F, 0xF8, 0xFF, 0x80, 0x00, 0xF8, 0x0F, 0xC0, 0xE0, 0x06,
  0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x07, 0x00,
  0xF0, 0x07, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x03, 0x07, 0x06, 0x06,
  0x06, 0x0E, 0x0C, 0x0C, 0x0C, 0x1C, 0x18, 0x18, 0x18, 0x38, 0x30, 0x30,
  0x30, 0x70, 0x60, 0x60, 0x60, 0xE0, 0xC0, 0x07, 0xC0, 0x3F, 0x00, 0x1C,
  0x00, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00,
  0x38, 0x00, 0xF0, 0x0F, 0x80, 0xE0, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x0E, 0x00, 0x60, 0x7F, 0x03, 0xE0, 0x00, 0x3C, 0x37, 0xE7,
  0xE7, 0xEC, 0x3C,
};

const GFXglyph UbuntuMono_Italic27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 6, 17, 14, 5, -17 },
  { 14, 8, 7, 14, 6, -17 },
  { 21, 14, 17, 14, 1, -17 },
  { 51, 12, 22, 14, 2, -19 },
  { 84, 16, 17, 14, 0, -17 },
  { 118, 11, 17, 14, 2, -17 },
  { 142, 4, 7, 14, 8, -18 },
  { 146, 10, 24, 14, 4, -19 },
  { 176, 10, 24, 14, 2, -19 },
  { 206, 10, 10, 14, 4, -17 },
  { 219, 12, 12, 14, 2, -13 },
  { 237, 6, 8, 14, 3, -4 },
  { 243, 6, 2, 14, 5, -8 },
  { 245, 4, 4, 14, 5, -4 },
  { 247, 15, 23, 14, 0, -19 },
  { 291, 12, 17, 14, 2, -17 },
  { 317, 10, 17, 14, 2, -17 },
  { 339, 12, 17, 14, 2, -17 },
  { 365, 12, 17, 14, 2, -17 },
  { 391, 13, 17, 14, 1, -17 },
  { 419, 13, 17, 14, 2, -17 },
  { 447, 12, 17, 14, 3, -17 },
  { 473, 12, 17, 14, 4, -17 },
  { 499, 13, 17, 14, 2, -17 },
  { 527, 12, 17, 14, 2, -17 },
  { 553, 6, 13, 14, 5, -13 },
  { 563, 8, 17, 14, 3, -13 },
  { 580, 12, 11, 14, 2, -12 },
  { 597, 12, 7, 14, 2, -10 },
  { 608, 12, 11, 14, 2, -13 },
  { 625, 10, 17, 14, 4, -17 },
  { 647, 13, 21, 14, 2, -17 },
  { 682, 13, 17, 14, 0, -17 },
  { 710, 13, 17, 14, 1, -17 },
  { 738, 14, 17, 14, 2, -17 },
  { 768, 13, 17, 14, 1, -17 },
  { 796, 13, 17, 14, 2, -17 },
  { 824, 13, 17, 14, 2, -17 },
  { 852, 13, 17, 14, 2, -17 },
  { 880, 15, 17, 14, 1, -17 },
  { 912, 13, 17, 14, 2, -17 },
  { 940, 13, 17, 14, 2, -17 },
  { 968, 15, 17, 14, 1, -17 },
  { 1000, 10, 17, 14, 1, -17 },
  { 1022, 15, 17, 14, 0, -17 },
  { 1054, 15, 17, 14, 1, -17 },
  { 1086, 13, 17, 14, 2, -17 },
  { 1114, 14, 17, 14, 1, -17 },
  { 1144, 13, 21, 14, 2, -17 },
  { 1179, 13, 17, 14, 1, -17 },
  { 1207, 14, 17, 14, 1, -17 },
  { 1237, 12, 17, 14, 4, -17 },
  { 1263, 14, 17, 14, 2, -17 },
  { 1293, 13, 17, 14, 4, -17 },
  { 1321, 14, 17, 14, 2, -17 },
  { 1351, 16, 17, 14, 0, -17 },
  { 1385, 13, 17, 14, 4, -17 },
  { 1413, 14, 17, 14, 1, -17 },
  { 1443, 12, 23, 14, 3, -19 },
  { 1478, 4, 23, 14, 6, -19 },
  { 1490, 12, 23, 14, 1, -19 },
  { 1525, 11, 9, 14, 3, -17 },
  { 1538, 13, 2, 14, -1, 3 },
  { 1542, 5, 5, 14, 7, -19 },
  { 1546, 12, 13, 14, 2, -13 },
  { 1566, 12, 19, 14, 2, -19 },
  { 1595, 12, 13, 14, 2, -13 },
  { 1615, 14, 19, 14, 2, -19 },
  { 1649, 12, 13, 14, 2, -13 },
  { 1669, 16, 23, 14, 0, -19 },
  { 1715, 13, 17, 14, 1, -13 },
  { 1743, 12, 19, 14, 1, -19 },
  { 1772, 8, 19, 14, 4, -19 },
  { 1791, 13, 23, 14, 1, -19 },
  { 1829, 13, 19, 14, 2, -19 },
  { 1860, 7, 19, 14, 5, -19 },
  { 1877, 13, 13, 14, 1, -13 },
  { 1899, 11, 13, 14, 2, -13 },
  { 1917, 12, 13, 14, 2, -13 },
  { 1937, 14, 17, 14, 0, -13 },
  { 1967, 12, 17, 14, 2, -13 },
  { 1993, 12, 13, 14, 2, -13 },
  { 2013, 12, 13, 14, 2, -13 },
  { 2033, 10, 17, 14, 4, -17 },
  { 2055, 12, 13, 14, 2, -13 },
  { 2075, 10, 13, 14, 4, -13 },
  { 2092, 14, 13, 14, 2, -13 },
  { 2115, 15, 13, 14, 0, -13 },
  { 2140, 14, 17, 14, 0, -13 },
  { 2170, 12, 13, 14, 2, -13 },
  { 2190, 13, 23, 14, 2, -19 },
  { 2228, 8, 23, 14, 4, -19 },
  { 2251, 13, 23, 14, 0, -19 },
  { 2289, 12, 4, 14, 2, -11 },
};

const GFXfont UbuntuMono_Italic27pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Italic27pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Italic27pt7bGlyphs,
  0x20, 0x7E, 27
};

#endif // _UBUNTUMONO_ITALIC27PT7B_H_
