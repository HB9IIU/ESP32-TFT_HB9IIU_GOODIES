#ifndef _UBUNTUMONO_ITALIC33PT7B_H_
#define _UBUNTUMONO_ITALIC33PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Italic.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Italic33pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x0E, 0x0E, 0x0E, 0x0E, 0x1C, 0x1C, 0x1C, 0x18, 0x18, 0x38,
  0x30, 0x30, 0x00, 0x00, 0x00, 0x60, 0xF0, 0xF0, 0xE0, 0x31, 0xDC, 0x67,
  0x19, 0x8E, 0x63, 0x18, 0xCC, 0x33, 0x08, 0x00, 0x61, 0xC0, 0x38, 0x60,
  0x0C, 0x38, 0x03, 0x0C, 0x01, 0xC7, 0x07, 0xFF, 0xE1, 0xFF, 0xF8, 0xFF,
  0xFE, 0x03, 0x0C, 0x01, 0xC7, 0x00, 0x61, 0x80, 0x38, 0xE0, 0x0C, 0x30,
  0x1F, 0xFF, 0xC7, 0xFF, 0xF1, 0xFF, 0xF8, 0x38, 0xE0, 0x0C, 0x30, 0x07,
  0x1C, 0x01, 0x86, 0x00, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0xFC,
  0x03, 0xFF, 0x07, 0xFE, 0x0F, 0x06, 0x0E, 0x00, 0x0C, 0x00, 0x0E, 0x00,
  0x0F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x78, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x38, 0x60, 0x78, 0x7F, 0xF0, 0xFF, 0xE0, 0x1F, 0x80,
  0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x70, 0x7C,
  0x0E, 0x0F, 0xE1, 0xC0, 0xC6, 0x18, 0x1C, 0x63, 0x01, 0x8E, 0x60, 0x18,
  0xCC, 0x01, 0xFD, 0x80, 0x0F, 0xB8, 0x00, 0xF7, 0x00, 0x00, 0xEF, 0x00,
  0x0D, 0xF8, 0x01, 0xBF, 0x80, 0x33, 0x18, 0x06, 0x31, 0x80, 0xC6, 0x38,
  0x1C, 0x73, 0x03, 0x87, 0xF0, 0x70, 0x3E, 0x06, 0x03, 0xC0, 0x01, 0xF0,
  0x1F, 0xE0, 0x7F, 0x83, 0x86, 0x0E, 0x18, 0x30, 0xE0, 0xC7, 0x03, 0xF8,
  0x07, 0xC0, 0x3C, 0x33, 0xF9, 0xDC, 0xE6, 0x61, 0xFB, 0x83, 0xCE, 0x0F,
  0x38, 0x3C, 0xE1, 0xF3, 0xFE, 0xC7, 0xF3, 0x8F, 0x8E, 0x77, 0x76, 0xEE,
  0xCC, 0xC0, 0x00, 0x20, 0x07, 0x00, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x1C, 0x03, 0x80, 0x30, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x07, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x08, 0x00, 0x01, 0x00,
  0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60,
  0x0E, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x38, 0x07, 0x00, 0xE0, 0x1E, 0x03,
  0xC0, 0xF0, 0x0E, 0x00, 0x40, 0x00, 0x0E, 0x00, 0x60, 0x06, 0x0C, 0x63,
  0xF6, 0xFF, 0xFF, 0x7F, 0xC0, 0xF0, 0x1B, 0x83, 0x9C, 0x71, 0xE1, 0x08,
  0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x0F, 0xFF,
  0xBF, 0xFE, 0x07, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x30,
  0x00, 0x0E, 0x1F, 0x1F, 0x1E, 0x0E, 0x1C, 0x78, 0x60, 0xFF, 0xFE, 0xFE,
  0x77, 0xFD, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0C,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x00, 0x01, 0xF0,
  0x1F, 0xE0, 0xFF, 0xC7, 0x87, 0x3C, 0x1C, 0xE0, 0x77, 0x81, 0xDC, 0xE7,
  0x77, 0x9F, 0x9E, 0x7E, 0x31, 0xF8, 0x06, 0xE0, 0x3B, 0x80, 0xEE, 0x07,
  0x38, 0x3C, 0xE1, 0xE3, 0xFF, 0x07, 0xF8, 0x0F, 0x80, 0x00, 0x30, 0x0F,
  0x03, 0xE0, 0xFE, 0x1F, 0xE1, 0xCE, 0x18, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x00, 0x70, 0x07, 0x0F, 0xFE,
  0xFF, 0xEF, 0xFE, 0x01, 0xF8, 0x0F, 0xF8, 0x3F, 0xF8, 0x70, 0x70, 0x40,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x00, 0xFF,
  0xF1, 0xFF, 0xC7, 0xFF, 0x80, 0x01, 0xF0, 0x0F, 0xF8, 0x1F, 0xF8, 0x30,
  0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x1E, 0x03, 0xF8, 0x07, 0xC0,
  0x0F, 0xC0, 0x03, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x40,
  0xF9, 0xFF, 0xE3, 0xFF, 0x81, 0xFC, 0x00, 0x00, 0x0E, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xE0, 0x1D, 0xC0, 0x73, 0x81, 0xC6, 0x07, 0x1C, 0x0C, 0x38,
  0x30, 0x70, 0xE0, 0xC3, 0x83, 0x86, 0x07, 0x1F, 0xFF, 0xBF, 0xFF, 0x7F,
  0xFE, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x03, 0xFF, 0x03,
  0xFF, 0x03, 0xFF, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0F,
  0x80, 0x0F, 0xE0, 0x0F, 0xF0, 0x00, 0xF8, 0x00, 0x38, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x38, 0x00, 0x38, 0x40, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0x3F,
  0x80, 0x00, 0x1E, 0x01, 0xFC, 0x0F, 0xF8, 0x3F, 0x00, 0xF0, 0x03, 0x80,
  0x0E, 0x00, 0x1B, 0xF0, 0x7F, 0xF0, 0xFF, 0xF1, 0xC0, 0xE7, 0x01, 0xCE,
  0x01, 0x9C, 0x07, 0x38, 0x0E, 0x70, 0x3C, 0xF0, 0xF0, 0xFF, 0xC0, 0xFF,
  0x00, 0xFC, 0x00, 0x3F, 0xFD, 0xFF, 0xF7, 0xFF, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x03, 0x80,
  0x1C, 0x00, 0x60, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0x01, 0xF0, 0x0F, 0xF8, 0x3F, 0xF0, 0xF0, 0xF1, 0xC0, 0xE3,
  0x01, 0xC6, 0x07, 0x0E, 0x1C, 0x1F, 0x70, 0x1F, 0xC0, 0x7F, 0xC1, 0xC7,
  0x87, 0x07, 0x9C, 0x07, 0x30, 0x0E, 0x60, 0x3C, 0xE0, 0xF1, 0xFF, 0xC1,
  0xFF, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x07, 0xFC, 0x0F, 0xFE, 0x0F, 0x0E,
  0x1C, 0x07, 0x1C, 0x07, 0x18, 0x07, 0x38, 0x07, 0x38, 0x06, 0x1C, 0x0E,
  0x1F, 0xFE, 0x0F, 0xFE, 0x07, 0xFC, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0,
  0x03, 0xE0, 0x7F, 0xC0, 0x7F, 0x00, 0x7C, 0x00, 0x1E, 0x7C, 0xF8, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x8F, 0x9E, 0x3C, 0x00, 0x03, 0xC1,
  0xF0, 0x7C, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x1F, 0x07, 0xC1, 0xE0, 0x38, 0x1C, 0x1E, 0x06, 0x00, 0x00, 0x04,
  0x00, 0xF0, 0x1F, 0x81, 0xF0, 0x3F, 0x03, 0xE0, 0x0E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x20, 0x3F, 0xFE, 0x7F,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x7F, 0xFC,
  0x10, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0x00, 0x3E, 0x03, 0xF0, 0x1F, 0x01, 0xF8, 0x07, 0x80, 0x0C, 0x00,
  0x00, 0x0F, 0xC1, 0xFE, 0x1F, 0xF1, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60,
  0x0C, 0x03, 0x80, 0x70, 0x0C, 0x01, 0xC0, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x0F, 0x80, 0xF8, 0x07, 0x00, 0x00, 0x7C, 0x01, 0xFE, 0x07,
  0xFF, 0x0F, 0x87, 0x0E, 0x03, 0x1C, 0x03, 0x3C, 0x03, 0x38, 0x3F, 0x38,
  0xFF, 0x71, 0xFF, 0x73, 0xC7, 0x63, 0x86, 0x63, 0x0E, 0xE7, 0x0E, 0xE7,
  0x0E, 0xE7, 0x0C, 0xE7, 0x9C, 0xE3, 0xFC, 0x63, 0xFC, 0x60, 0xF8, 0x70,
  0x00, 0x70, 0x00, 0x3C, 0x00, 0x1F, 0xC0, 0x07, 0xC0, 0x00, 0x3C, 0x00,
  0x78, 0x01, 0xF0, 0x03, 0x60, 0x0C, 0xE0, 0x39, 0xC0, 0x63, 0x81, 0xC7,
  0x03, 0x0E, 0x0E, 0x1C, 0x18, 0x38, 0x70, 0x30, 0xC0, 0x63, 0xFF, 0xCF,
  0xFF, 0x9F, 0xFF, 0x78, 0x06, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x30, 0x07,
  0xFC, 0x07, 0xFE, 0x07, 0xFF, 0x0E, 0x07, 0x0E, 0x07, 0x0E, 0x07, 0x0C,
  0x07, 0x1C, 0x1E, 0x1F, 0xFC, 0x1F, 0xF0, 0x1F, 0xFC, 0x38, 0x1E, 0x38,
  0x0E, 0x38, 0x0E, 0x30, 0x0E, 0x30, 0x1E, 0x70, 0x3C, 0x7F, 0xF8, 0x7F,
  0xF0, 0x7F, 0xC0, 0x00, 0xFC, 0x03, 0xFF, 0x0F, 0xFE, 0x1F, 0x02, 0x1C,
  0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xF8,
  0x20, 0x7F, 0xF0, 0x3F, 0xF0, 0x1F, 0xC0, 0x07, 0xF0, 0x07, 0xFC, 0x0F,
  0xFE, 0x0E, 0x1F, 0x0E, 0x07, 0x0C, 0x07, 0x1C, 0x07, 0x1C, 0x03, 0x1C,
  0x07, 0x18, 0x07, 0x38, 0x07, 0x38, 0x07, 0x38, 0x0E, 0x30, 0x0E, 0x70,
  0x1C, 0x70, 0x3C, 0x60, 0xF8, 0x7F, 0xF0, 0xFF, 0xE0, 0xFF, 0x00, 0x07,
  0xFF, 0x83, 0xFF, 0x81, 0xFF, 0xC1, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x30, 0x00, 0x38, 0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x3F,
  0xFC, 0x1F, 0xFE, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF,
  0xC1, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1F,
  0xFC, 0x0F, 0xFC, 0x07, 0xFE, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xFC, 0x07, 0xFC, 0x3F, 0xF8, 0xF8, 0x23, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x66, 0x01, 0xCC,
  0x03, 0x98, 0x07, 0x38, 0x1C, 0x70, 0x38, 0xF0, 0x70, 0xFF, 0xE0, 0xFF,
  0x80, 0xFE, 0x00, 0x07, 0x01, 0xC1, 0x80, 0x70, 0xE0, 0x18, 0x38, 0x0E,
  0x0E, 0x03, 0x83, 0x00, 0xE1, 0xC0, 0x30, 0x70, 0x1C, 0x1F, 0xFF, 0x07,
  0xFF, 0xC3, 0xFF, 0xE0, 0xE0, 0x18, 0x38, 0x0E, 0x0E, 0x03, 0x83, 0x00,
  0xC1, 0xC0, 0x30, 0x70, 0x1C, 0x1C, 0x07, 0x06, 0x01, 0xC3, 0x80, 0x60,
  0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFE, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x7F, 0xE0,
  0x7F, 0xE0, 0xFF, 0xE0, 0x01, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x40, 0x70,
  0x70, 0xF0, 0xFF, 0xE0, 0x7F, 0xC0, 0x1F, 0x00, 0x07, 0x01, 0xC1, 0xC0,
  0xE0, 0x60, 0x70, 0x18, 0x38, 0x0E, 0x1C, 0x03, 0x9E, 0x00, 0xCF, 0x00,
  0x37, 0x80, 0x1F, 0xC0, 0x07, 0xC0, 0x01, 0xB8, 0x00, 0x67, 0x00, 0x38,
  0xE0, 0x0E, 0x38, 0x03, 0x87, 0x00, 0xC1, 0xC0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x01, 0xC1, 0x80, 0x70, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x38, 0x03, 0x00, 0x30,
  0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x03,
  0x81, 0x83, 0xC1, 0xC1, 0xE1, 0xE0, 0xF0, 0xF0, 0xD8, 0xD8, 0x6C, 0x6C,
  0x36, 0x6E, 0x3B, 0x76, 0x19, 0xB3, 0x0C, 0xF1, 0x8E, 0x79, 0xC7, 0x38,
  0xE3, 0x00, 0x63, 0x80, 0x31, 0xC0, 0x18, 0xC0, 0x1C, 0x60, 0x0E, 0x70,
  0x06, 0x38, 0x03, 0x18, 0x03, 0x80, 0x07, 0x01, 0xC1, 0xC0, 0x70, 0x78,
  0x1C, 0x3E, 0x06, 0x0F, 0x81, 0x83, 0x70, 0xE0, 0xDC, 0x38, 0x73, 0x0C,
  0x1C, 0xC3, 0x06, 0x39, 0xC1, 0x86, 0x70, 0xE1, 0x98, 0x38, 0x66, 0x0C,
  0x1B, 0x83, 0x07, 0xE1, 0xC0, 0xF0, 0x70, 0x3C, 0x18, 0x0F, 0x06, 0x03,
  0xC3, 0x80, 0xE0, 0x01, 0xF0, 0x0F, 0xF0, 0x3F, 0xF0, 0xF0, 0xF3, 0xC0,
  0xE7, 0x01, 0xDC, 0x03, 0xB8, 0x07, 0x60, 0x0F, 0xC0, 0x1B, 0x80, 0x37,
  0x00, 0xEC, 0x01, 0xD8, 0x07, 0x30, 0x0E, 0x70, 0x38, 0xF1, 0xF1, 0xFF,
  0xC1, 0xFF, 0x00, 0xF8, 0x00, 0x07, 0xF8, 0x0F, 0xFC, 0x0F, 0xFE, 0x0E,
  0x0F, 0x0C, 0x07, 0x1C, 0x07, 0x1C, 0x07, 0x1C, 0x06, 0x18, 0x0E, 0x38,
  0x3E, 0x3F, 0xFC, 0x3F, 0xF0, 0x3F, 0xC0, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x01, 0xF0, 0x0F,
  0xF0, 0x3F, 0xF0, 0xF0, 0xF3, 0xC0, 0xE7, 0x01, 0xDC, 0x03, 0xB8, 0x07,
  0x60, 0x0F, 0xC0, 0x1F, 0x80, 0x37, 0x00, 0xEC, 0x01, 0xD8, 0x07, 0x30,
  0x0E, 0x70, 0x38, 0xF1, 0xF1, 0xFF, 0xC1, 0xFF, 0x01, 0xF8, 0x01, 0xC0,
  0x03, 0xE0, 0x03, 0xF0, 0x03, 0xE0, 0x01, 0xC0, 0x07, 0xF8, 0x07, 0xFE,
  0x07, 0xFF, 0x06, 0x0F, 0x0E, 0x07, 0x0E, 0x03, 0x0E, 0x03, 0x0C, 0x07,
  0x1C, 0x07, 0x1C, 0x1E, 0x1F, 0xFC, 0x1F, 0xF8, 0x3F, 0xE0, 0x38, 0x70,
  0x38, 0x70, 0x30, 0x30, 0x70, 0x38, 0x70, 0x38, 0x70, 0x18, 0x60, 0x1C,
  0x01, 0xFC, 0x03, 0xFF, 0x07, 0xFE, 0x0F, 0x02, 0x0E, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xF8,
  0x00, 0x38, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x40, 0x78, 0xFF, 0xF0,
  0xFF, 0xE0, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x00, 0x1C, 0x00, 0x1C, 0x07, 0x18, 0x07, 0x38, 0x06, 0x38, 0x0E, 0x38,
  0x0E, 0x30, 0x0E, 0x70, 0x0C, 0x70, 0x1C, 0x60, 0x1C, 0xE0, 0x18, 0xE0,
  0x38, 0xE0, 0x38, 0xC0, 0x38, 0xC0, 0x30, 0xC0, 0x70, 0xE0, 0x70, 0xF1,
  0xE0, 0xFF, 0xE0, 0x7F, 0xC0, 0x3F, 0x00, 0xE0, 0x07, 0xE0, 0x06, 0x60,
  0x0E, 0x60, 0x0C, 0x60, 0x1C, 0x60, 0x18, 0x60, 0x38, 0x60, 0x30, 0x60,
  0x70, 0x70, 0xE0, 0x70, 0xE0, 0x71, 0xC0, 0x71, 0xC0, 0x73, 0x80, 0x73,
  0x00, 0x77, 0x00, 0x76, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x1C,
  0x01, 0xC7, 0x00, 0x61, 0x80, 0x38, 0x60, 0x0E, 0x38, 0x03, 0x0E, 0x00,
  0xC3, 0x80, 0x70, 0xC0, 0x1C, 0x31, 0xC6, 0x0C, 0x71, 0x87, 0x3C, 0xE1,
  0x9F, 0x30, 0x66, 0xCC, 0x1B, 0x37, 0x06, 0xCD, 0x81, 0x63, 0x60, 0xF8,
  0x78, 0x3C, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0x03, 0x80, 0x70, 0x38,
  0x0E, 0x01, 0xC1, 0xC0, 0x1C, 0x38, 0x01, 0xC7, 0x00, 0x0E, 0x70, 0x00,
  0xEE, 0x00, 0x0F, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00,
  0x1F, 0x80, 0x01, 0xD8, 0x00, 0x39, 0xC0, 0x07, 0x1C, 0x00, 0xE0, 0xC0,
  0x1C, 0x0E, 0x03, 0xC0, 0xE0, 0x38, 0x0E, 0x07, 0x00, 0x70, 0xE0, 0x0E,
  0xE0, 0x0E, 0xE0, 0x1C, 0xE0, 0x38, 0x60, 0x38, 0x70, 0x70, 0x70, 0xE0,
  0x70, 0xC0, 0x31, 0xC0, 0x3B, 0x80, 0x3F, 0x00, 0x1E, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x30, 0x00, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xF8, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x1F, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF, 0xE0, 0x01,
  0xFE, 0x03, 0xFC, 0x0F, 0xF8, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0x80, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0,
  0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xFF, 0x01,
  0xFC, 0x07, 0xF8, 0x00, 0xE7, 0x38, 0xC6, 0x31, 0xCE, 0x73, 0x9C, 0xE7,
  0x39, 0xCE, 0x31, 0x8C, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x70, 0x01, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x81, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x00, 0x01, 0xC0, 0x1E, 0x01, 0xF8, 0x0F, 0xC0, 0xE6, 0x0E,
  0x38, 0xE1, 0xCE, 0x06, 0x70, 0x3F, 0x01, 0xD0, 0x04, 0x7F, 0xFF, 0xFF,
  0xFC, 0x47, 0x3C, 0xE3, 0x88, 0x01, 0xFC, 0x0F, 0xFC, 0x3F, 0xF0, 0xF8,
  0x63, 0xC1, 0xCF, 0x03, 0x9C, 0x06, 0x30, 0x1C, 0xE0, 0x39, 0xC0, 0x63,
  0x81, 0xC3, 0x87, 0x87, 0xFF, 0x07, 0xFF, 0x07, 0xCE, 0x00, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x1D, 0xF0, 0x3F, 0xF0, 0x7F, 0xF0, 0xF0, 0xE3, 0x80, 0xE7, 0x01,
  0xCE, 0x03, 0x98, 0x06, 0x30, 0x1C, 0xE0, 0x79, 0xC1, 0xE3, 0x07, 0x87,
  0xFF, 0x1F, 0xF8, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x0F, 0xFC, 0x7F, 0xF1,
  0xF0, 0x23, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x03, 0xC0, 0x87, 0xFF, 0x07, 0xFE, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0C, 0x01, 0xFC, 0x0F, 0xFC, 0x1E, 0x1C, 0x38, 0x18, 0x70,
  0x18, 0x70, 0x38, 0xE0, 0x38, 0xE0, 0x30, 0xC0, 0x70, 0xC0, 0x70, 0xC0,
  0x70, 0xE0, 0x70, 0xE1, 0xF0, 0x7F, 0xF0, 0x3E, 0x70, 0x01, 0xF0, 0x0F,
  0xF8, 0x7F, 0xF1, 0xF0, 0xF3, 0x80, 0xEE, 0x03, 0x9C, 0x1F, 0x3F, 0xFC,
  0xFF, 0xF1, 0xFF, 0x03, 0x80, 0x03, 0x80, 0x87, 0xFF, 0x07, 0xFE, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xC0,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00,
  0x70, 0x00, 0x0F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x7F, 0x01, 0xFF, 0x81, 0xE1, 0xC1, 0xC0, 0xE1, 0xC0, 0x60, 0xE0,
  0x70, 0xE0, 0x38, 0x70, 0x1C, 0x38, 0x0C, 0x1C, 0x0E, 0x0E, 0x07, 0x07,
  0x0F, 0x81, 0xFF, 0x80, 0x7D, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0xC0, 0xF0,
  0x7F, 0xF0, 0x3F, 0xF0, 0x07, 0xE0, 0x00, 0x03, 0x80, 0x06, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0F, 0xF0,
  0x1F, 0xF8, 0x7F, 0xF0, 0xE0, 0xF1, 0xC0, 0xE3, 0x81, 0xCE, 0x03, 0x9C,
  0x06, 0x38, 0x1C, 0x70, 0x38, 0xC0, 0x73, 0x80, 0xC7, 0x03, 0x8E, 0x07,
  0x18, 0x0E, 0x00, 0x03, 0x81, 0xE0, 0x78, 0x1C, 0x00, 0x00, 0x07, 0xF1,
  0xFC, 0x7E, 0x01, 0x80, 0xE0, 0x38, 0x0C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xFC, 0x3F, 0x07, 0xC0, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x03, 0xFC, 0x07, 0xFC,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0xC1, 0xC0, 0xFF, 0xC0, 0xFF, 0x80, 0x7E, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0C, 0x00, 0x0C, 0x0E, 0x1C, 0x1C, 0x1C, 0x78, 0x18, 0xF0, 0x1B, 0xC0,
  0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x80, 0x33, 0x80, 0x71, 0xC0, 0x70, 0xE0,
  0x70, 0xE0, 0x60, 0x70, 0xE0, 0x70, 0xE0, 0x38, 0xFE, 0x7F, 0x3F, 0x81,
  0xC0, 0xC0, 0x60, 0x70, 0x38, 0x18, 0x0C, 0x0E, 0x07, 0x03, 0x01, 0x81,
  0xC0, 0xE0, 0x60, 0x30, 0x18, 0x0E, 0x27, 0xFB, 0xFC, 0xF8, 0x0F, 0x9E,
  0x1F, 0xFF, 0x1C, 0xE7, 0x18, 0xE3, 0x18, 0xE7, 0x38, 0xC7, 0x38, 0xC6,
  0x31, 0xC6, 0x31, 0x8E, 0x70, 0x0E, 0x70, 0x0E, 0x60, 0x0C, 0x60, 0x0C,
  0xE0, 0x1C, 0xE0, 0x1C, 0x07, 0xF0, 0x7F, 0xE1, 0xFF, 0xC7, 0x07, 0x1C,
  0x1C, 0xE0, 0x33, 0x80, 0xCE, 0x07, 0x38, 0x1D, 0xC0, 0x77, 0x01, 0x9C,
  0x0E, 0x60, 0x3B, 0x80, 0xCE, 0x07, 0x00, 0x07, 0xE0, 0x3F, 0xC3, 0xFF,
  0x8F, 0x0E, 0x70, 0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x06, 0xC0, 0x3B, 0x00,
  0xEE, 0x07, 0x38, 0x7C, 0xFF, 0xE1, 0xFF, 0x03, 0xF0, 0x00, 0x03, 0xF8,
  0x0F, 0xFC, 0x0F, 0xFE, 0x0E, 0x0E, 0x1C, 0x07, 0x1C, 0x07, 0x1C, 0x07,
  0x18, 0x06, 0x38, 0x0E, 0x38, 0x0E, 0x38, 0x1C, 0x30, 0x7C, 0x7F, 0xF8,
  0x7F, 0xE0, 0x7F, 0x80, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xC0, 0x00, 0x01, 0xFC, 0x3F, 0xF1, 0xE1, 0xCE, 0x07, 0x70, 0x19, 0xC0,
  0xEE, 0x03, 0xB8, 0x0E, 0xC0, 0x33, 0x01, 0xCC, 0x07, 0x38, 0x1C, 0xF1,
  0xE1, 0xFF, 0x83, 0xEE, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x60, 0x03, 0xFC, 0x7F, 0xF1, 0xFF, 0xC7, 0x00, 0x18, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x03,
  0x80, 0x0E, 0x00, 0x00, 0x03, 0xF0, 0x3F, 0xE1, 0xFF, 0x87, 0x06, 0x18,
  0x00, 0x70, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0x30,
  0x38, 0xFF, 0xE3, 0xFF, 0x03, 0xF0, 0x00, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xC0, 0x1C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x18, 0x03, 0x80, 0x38, 0x03,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0xC7, 0xFC, 0x3F, 0xC1,
  0xF0, 0x38, 0x1C, 0xC0, 0x77, 0x01, 0x9C, 0x0E, 0x70, 0x3B, 0x80, 0xCE,
  0x07, 0x38, 0x1C, 0xE0, 0x73, 0x01, 0x8E, 0x0E, 0x38, 0x78, 0xFF, 0xE1,
  0xFF, 0xC3, 0xE7, 0x00, 0xE0, 0x1B, 0x80, 0xE6, 0x03, 0x98, 0x1C, 0x60,
  0x71, 0xC3, 0x87, 0x0E, 0x1C, 0x70, 0x71, 0x81, 0xCE, 0x07, 0x70, 0x0D,
  0xC0, 0x3E, 0x00, 0xF0, 0x03, 0x80, 0x00, 0x60, 0x07, 0x60, 0x07, 0xE0,
  0x06, 0xE0, 0x0E, 0xE3, 0x8C, 0xE3, 0x8C, 0xC7, 0x9C, 0xC7, 0x98, 0xCD,
  0x98, 0xDD, 0xB0, 0xD9, 0xB0, 0xF1, 0xF0, 0xF1, 0xE0, 0xE0, 0xE0, 0xC0,
  0xC0, 0x0E, 0x07, 0x07, 0x07, 0x01, 0xC3, 0x80, 0xE3, 0x80, 0x3B, 0x80,
  0x1F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0xB8, 0x03, 0x9C,
  0x03, 0x86, 0x03, 0x83, 0x83, 0x81, 0xC3, 0x80, 0x70, 0x03, 0x00, 0xE0,
  0x60, 0x38, 0x0C, 0x07, 0x01, 0xC0, 0xC0, 0x38, 0x38, 0x07, 0x06, 0x00,
  0xE1, 0xC0, 0x0C, 0x30, 0x01, 0xCE, 0x00, 0x39, 0x80, 0x07, 0x70, 0x00,
  0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0xC0, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xFE, 0x1F,
  0xFC, 0x3F, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0xFF, 0x1F, 0xFE, 0x3F,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0xFF, 0x01, 0xFE, 0x01, 0xC0, 0x01, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x06, 0x00, 0x0E, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x38, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x1F, 0x80, 0x01, 0x80,
  0xC0, 0xE0, 0x70, 0x30, 0x18, 0x1C, 0x0E, 0x06, 0x03, 0x03, 0x81, 0xC0,
  0xC0, 0x60, 0x70, 0x38, 0x18, 0x0C, 0x0E, 0x07, 0x03, 0x01, 0x81, 0xC0,
  0xE0, 0x60, 0x30, 0x38, 0x1C, 0x00, 0x01, 0xF0, 0x01, 0xFC, 0x03, 0xFC,
  0x00, 0x1C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x7E, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0xFF, 0x00, 0xFF, 0x00,
  0xFC, 0x00, 0x1E, 0x06, 0x7F, 0x1D, 0xC7, 0xF7, 0x07, 0x80,
};

const GFXglyph UbuntuMono_Italic33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 8, 20, 17, 6, -20 },
  { 21, 10, 8, 17, 7, -21 },
  { 31, 18, 20, 17, 1, -20 },
  { 76, 16, 26, 17, 2, -23 },
  { 128, 20, 20, 17, 0, -20 },
  { 178, 14, 20, 17, 2, -20 },
  { 213, 4, 9, 17, 10, -22 },
  { 218, 12, 29, 17, 5, -23 },
  { 262, 12, 29, 17, 2, -23 },
  { 306, 12, 12, 17, 5, -20 },
  { 324, 14, 14, 17, 3, -16 },
  { 349, 8, 8, 17, 3, -4 },
  { 357, 8, 3, 17, 6, -10 },
  { 360, 5, 4, 17, 6, -4 },
  { 363, 19, 28, 17, -1, -23 },
  { 430, 14, 20, 17, 3, -20 },
  { 465, 12, 20, 17, 3, -20 },
  { 495, 15, 20, 17, 2, -20 },
  { 533, 15, 20, 17, 2, -20 },
  { 571, 15, 20, 17, 2, -20 },
  { 609, 16, 20, 17, 2, -20 },
  { 649, 15, 20, 17, 3, -20 },
  { 687, 14, 20, 17, 5, -20 },
  { 722, 15, 20, 17, 3, -20 },
  { 760, 16, 20, 17, 2, -20 },
  { 800, 7, 15, 17, 6, -15 },
  { 814, 10, 19, 17, 3, -15 },
  { 838, 14, 13, 17, 3, -15 },
  { 861, 15, 8, 17, 2, -13 },
  { 876, 15, 13, 17, 2, -15 },
  { 901, 12, 20, 17, 5, -20 },
  { 931, 16, 25, 17, 2, -21 },
  { 981, 15, 20, 17, 0, -20 },
  { 1019, 16, 20, 17, 1, -20 },
  { 1059, 16, 20, 17, 3, -20 },
  { 1099, 16, 20, 17, 1, -20 },
  { 1139, 17, 20, 17, 2, -20 },
  { 1182, 17, 20, 17, 2, -20 },
  { 1225, 15, 20, 17, 3, -20 },
  { 1263, 18, 20, 17, 1, -20 },
  { 1308, 16, 20, 17, 2, -20 },
  { 1348, 16, 20, 17, 2, -20 },
  { 1388, 18, 20, 17, 1, -20 },
  { 1433, 12, 20, 17, 2, -20 },
  { 1463, 17, 20, 17, 1, -20 },
  { 1506, 18, 20, 17, 1, -20 },
  { 1551, 15, 20, 17, 3, -20 },
  { 1589, 16, 20, 17, 2, -20 },
  { 1629, 15, 25, 17, 3, -20 },
  { 1676, 16, 20, 17, 1, -20 },
  { 1716, 16, 20, 17, 2, -20 },
  { 1756, 14, 20, 17, 5, -20 },
  { 1791, 16, 20, 17, 3, -20 },
  { 1831, 16, 20, 17, 4, -20 },
  { 1871, 18, 20, 17, 2, -20 },
  { 1916, 20, 20, 17, 0, -20 },
  { 1966, 16, 20, 17, 5, -20 },
  { 2006, 18, 20, 17, 1, -20 },
  { 2051, 15, 28, 17, 3, -23 },
  { 2104, 5, 28, 17, 7, -23 },
  { 2122, 15, 28, 17, 1, -23 },
  { 2175, 13, 11, 17, 4, -20 },
  { 2193, 15, 2, 17, -1, 3 },
  { 2197, 5, 6, 17, 9, -23 },
  { 2201, 15, 15, 17, 2, -15 },
  { 2230, 15, 23, 17, 2, -23 },
  { 2274, 15, 15, 17, 2, -15 },
  { 2303, 16, 23, 17, 3, -23 },
  { 2349, 15, 15, 17, 2, -15 },
  { 2378, 20, 28, 17, 0, -23 },
  { 2448, 17, 20, 17, 1, -15 },
  { 2491, 15, 23, 17, 1, -23 },
  { 2535, 10, 21, 17, 4, -21 },
  { 2562, 16, 26, 17, 1, -21 },
  { 2614, 16, 23, 17, 2, -23 },
  { 2660, 9, 23, 17, 6, -23 },
  { 2686, 16, 15, 17, 1, -15 },
  { 2716, 14, 15, 17, 2, -15 },
  { 2743, 14, 15, 17, 3, -15 },
  { 2770, 16, 20, 17, 1, -15 },
  { 2810, 14, 20, 17, 3, -15 },
  { 2845, 14, 15, 17, 3, -15 },
  { 2872, 14, 15, 17, 3, -15 },
  { 2899, 12, 20, 17, 5, -20 },
  { 2929, 14, 15, 17, 3, -15 },
  { 2956, 14, 15, 17, 4, -15 },
  { 2983, 16, 15, 17, 3, -15 },
  { 3013, 17, 15, 17, 1, -15 },
  { 3045, 19, 20, 17, -1, -15 },
  { 3093, 15, 15, 17, 2, -15 },
  { 3122, 16, 28, 17, 3, -23 },
  { 3178, 9, 28, 17, 5, -23 },
  { 3210, 16, 28, 17, 0, -23 },
  { 3266, 15, 4, 17, 2, -12 },
};

const GFXfont UbuntuMono_Italic33pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Italic33pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Italic33pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _UBUNTUMONO_ITALIC33PT7B_H_
