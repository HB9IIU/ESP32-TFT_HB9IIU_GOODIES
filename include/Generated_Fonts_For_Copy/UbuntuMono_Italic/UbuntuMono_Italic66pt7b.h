#ifndef _UBUNTUMONO_ITALIC66PT7B_H_
#define _UBUNTUMONO_ITALIC66PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Italic.ttf
// Size: 66pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Italic66pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03,
  0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07,
  0xC0, 0x07, 0x80, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x3F, 0x00, 0x7F, 0x80, 0x7F,
  0x80, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0x3C, 0x00, 0x3E,
  0x07, 0xCF, 0x81, 0xF3, 0xE0, 0x7C, 0xF8, 0x3F, 0x7C, 0x0F, 0x9F, 0x03,
  0xE7, 0xC0, 0xF9, 0xE0, 0x3C, 0x78, 0x1F, 0x3E, 0x07, 0xCF, 0x01, 0xE3,
  0xC0, 0x78, 0xF0, 0x1E, 0x38, 0x07, 0x0E, 0x01, 0xC3, 0x80, 0x70, 0x00,
  0x00, 0x7C, 0x07, 0xC0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0xF8,
  0x00, 0x03, 0xE0, 0x3E, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x7C, 0x07,
  0xC0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x03, 0xE0,
  0x3E, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x7C, 0x07, 0xC0, 0x1F, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x3E, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0xF8, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x01, 0xF0, 0x1F, 0x00,
  0x00, 0x7C, 0x07, 0xC0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0xF8,
  0x00, 0x07, 0xC0, 0x3E, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0xF8, 0x07,
  0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3E,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x01,
  0xF0, 0x1F, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x3E, 0x03, 0xE0, 0x00,
  0x1F, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x03, 0xE0, 0x1F, 0x00,
  0x00, 0xF8, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0x00, 0xF8, 0x07, 0xF0, 0x00, 0x40, 0x1F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x20, 0x00, 0x1F,
  0x81, 0xE0, 0x00, 0xFE, 0x07, 0xE0, 0x1F, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x1E, 0x00, 0x1F, 0xF0, 0x00, 0x3E, 0x00, 0x3F, 0xF8, 0x00, 0x7C,
  0x00, 0x3F, 0xF8, 0x00, 0xF8, 0x00, 0x7F, 0xF8, 0x01, 0xF0, 0x00, 0xFC,
  0x78, 0x03, 0xE0, 0x00, 0xF8, 0x78, 0x03, 0xC0, 0x00, 0xF0, 0x7C, 0x07,
  0xC0, 0x01, 0xE0, 0x78, 0x0F, 0x80, 0x01, 0xE0, 0x78, 0x1F, 0x00, 0x01,
  0xE0, 0x78, 0x3E, 0x00, 0x01, 0xE0, 0x78, 0x7C, 0x00, 0x01, 0xE0, 0x78,
  0xF8, 0x00, 0x01, 0xE0, 0xF8, 0xF0, 0x00, 0x01, 0xE1, 0xF1, 0xF0, 0x00,
  0x01, 0xE3, 0xF3, 0xE0, 0x00, 0x01, 0xFF, 0xE7, 0xC0, 0x00, 0x01, 0xFF,
  0xEF, 0x80, 0x00, 0x00, 0xFF, 0xDF, 0x00, 0x00, 0x00, 0xFF, 0x9E, 0x00,
  0x00, 0x00, 0x3E, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00,
  0x00, 0xF9, 0xFF, 0x00, 0x00, 0x01, 0xF3, 0xFF, 0x80, 0x00, 0x03, 0xE3,
  0xFF, 0x80, 0x00, 0x07, 0xC7, 0xFF, 0x80, 0x00, 0x07, 0x8F, 0xC7, 0xC0,
  0x00, 0x0F, 0x8F, 0x87, 0xC0, 0x00, 0x1F, 0x0F, 0x03, 0xC0, 0x00, 0x3E,
  0x1E, 0x03, 0xC0, 0x00, 0x7C, 0x1E, 0x07, 0x80, 0x00, 0xF8, 0x1E, 0x07,
  0x80, 0x00, 0xF0, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0x1E, 0x0F, 0x80, 0x03,
  0xE0, 0x1E, 0x0F, 0x80, 0x07, 0xC0, 0x1F, 0x1F, 0x00, 0x0F, 0x80, 0x1F,
  0xFF, 0x00, 0x1F, 0x00, 0x1F, 0xFE, 0x00, 0x3E, 0x00, 0x0F, 0xFC, 0x00,
  0x3C, 0x00, 0x0F, 0xF8, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xF0, 0xFE, 0x00, 0xFC, 0x07, 0xE0, 0x0F,
  0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x80, 0x7C, 0x01, 0xF8, 0x07,
  0xC0, 0x1F, 0x00, 0xF8, 0x01, 0xF0, 0x0F, 0x80, 0x1F, 0x81, 0xF0, 0x00,
  0xF8, 0x7E, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x0F, 0x01, 0xFF, 0x01, 0xF0,
  0x7F, 0xF8, 0x1F, 0x0F, 0xEF, 0xC1, 0xE1, 0xF8, 0xFC, 0x3E, 0x3F, 0x07,
  0xE3, 0xE3, 0xE0, 0x3F, 0x7C, 0x7C, 0x03, 0xF7, 0xC7, 0xC0, 0x1F, 0xF8,
  0xFC, 0x00, 0xFF, 0x8F, 0xC0, 0x0F, 0xF0, 0xF8, 0x00, 0x7F, 0x0F, 0x80,
  0x07, 0xE0, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xF0, 0xFC, 0x01, 0xFF,
  0x0F, 0xF0, 0x7F, 0xF8, 0x7F, 0xFF, 0xEF, 0x87, 0xFF, 0xFC, 0xF8, 0x3F,
  0xFF, 0x0F, 0xC1, 0xFF, 0xE0, 0xFC, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x0F,
  0x8F, 0xC7, 0xE3, 0xE1, 0xF1, 0xF8, 0xFC, 0x7C, 0x3E, 0x1F, 0x0F, 0x0F,
  0x87, 0xC3, 0xC1, 0xE0, 0xF0, 0x70, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x02, 0x01, 0xE0, 0x11, 0xE0, 0x78, 0x3C, 0x7E, 0x1E, 0x3F, 0x9F, 0xE7,
  0xBF, 0xEF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xF3, 0xE0,
  0x00, 0xFC, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x87, 0xF0, 0x1F, 0xC0,
  0xFC, 0x03, 0xF0, 0x3E, 0x00, 0x38, 0x07, 0x00, 0x04, 0x01, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x0F, 0xE0, 0x7F, 0xC1, 0xFF, 0x0F, 0xFC, 0x1F, 0xF0,
  0x7F, 0xC1, 0xFF, 0x01, 0xFC, 0x03, 0xE0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x7F, 0x8F, 0xF8, 0x3F, 0xC0, 0xFC, 0x03, 0x80, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0x0F, 0xE7, 0xFD, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFD, 0xFE, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0x83, 0xF8,
  0x07, 0xF0, 0x0F, 0xC0, 0x7F, 0x00, 0x7E, 0x07, 0xF0, 0x01, 0xF0, 0x3F,
  0x00, 0x0F, 0x83, 0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x03, 0xF1, 0xF8, 0x00,
  0x1F, 0x8F, 0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x07, 0xC7, 0xE0, 0xE0, 0x3E,
  0x3E, 0x1F, 0x81, 0xF3, 0xF0, 0xFE, 0x0F, 0x9F, 0x8F, 0xF0, 0xFC, 0xF8,
  0x7F, 0x87, 0xE7, 0xC3, 0xFC, 0x3F, 0x7E, 0x1F, 0xE1, 0xF3, 0xF0, 0x7E,
  0x1F, 0x9F, 0x01, 0xE0, 0xFC, 0xF8, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x7E,
  0x3E, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF8, 0x7C,
  0x00, 0x1F, 0x83, 0xE0, 0x00, 0xFC, 0x1F, 0x00, 0x0F, 0xC0, 0xFC, 0x00,
  0xFE, 0x07, 0xE0, 0x0F, 0xE0, 0x3F, 0x00, 0xFE, 0x01, 0xFE, 0x1F, 0xE0,
  0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x0F,
  0xFE, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0x7C, 0x03, 0xFE,
  0xFC, 0x03, 0xF8, 0xFC, 0x01, 0xE0, 0xF8, 0x01, 0x00, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xF8, 0x1F, 0xE0, 0x0F, 0x00, 0x1F,
  0x80, 0x38, 0x00, 0x7E, 0x00, 0x40, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0xF8, 0x0F, 0xE0, 0x03, 0x80, 0x1F, 0xC0, 0x08,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7F, 0x02, 0x00, 0x03, 0xF8, 0x1F, 0x00, 0x7F, 0xE0, 0x7F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F,
  0x7C, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x0F, 0xC7,
  0xC0, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF0, 0x7C,
  0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x7C, 0x07, 0xE0,
  0x01, 0xF0, 0x0F, 0xC0, 0x07, 0xC0, 0x1F, 0x00, 0x1F, 0x80, 0x3E, 0x00,
  0x7E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xE0, 0x03, 0xE0, 0x0F,
  0x80, 0x07, 0xC0, 0x1F, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x3F, 0x01, 0xFF,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x20, 0x00, 0x7F, 0x80, 0x78, 0x03, 0xFF, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xE1, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xC0, 0x3F, 0xC1,
  0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF8, 0x7C,
  0x00, 0x07, 0xE1, 0xF0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x7E, 0x3F, 0x00,
  0x01, 0xF0, 0xFC, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x1F, 0x0F, 0xC0, 0x00,
  0xFC, 0x3F, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0xFE,
  0x07, 0xE0, 0x07, 0xF0, 0x1F, 0xE0, 0x7F, 0x80, 0x3F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xE0, 0x7F,
  0x80, 0x3F, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x7E,
  0x07, 0xE0, 0x00, 0xF8, 0x0F, 0xC0, 0x01, 0xF0, 0x1F, 0x00, 0x03, 0xE0,
  0x3E, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x7E, 0x01,
  0xFC, 0x01, 0xF8, 0x01, 0xFC, 0x07, 0xE0, 0x03, 0xFE, 0x3F, 0x80, 0x03,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xE0, 0x01, 0xFE, 0x7F, 0xE0, 0x07, 0xF0, 0x3F, 0xC0, 0x1F, 0x80,
  0x1F, 0xC0, 0x7E, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0x3F, 0x07, 0xC0, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x01,
  0xF0, 0x7E, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3F,
  0x81, 0xF8, 0x00, 0xFE, 0x03, 0xFC, 0x0F, 0xF8, 0x07, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x07,
  0xFC, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0xFC, 0x00, 0x3F, 0x07, 0xF0,
  0x00, 0xFC, 0x1F, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0xC3, 0xF0, 0x00,
  0x1F, 0x0F, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x07,
  0xC3, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF0,
  0xFE, 0x00, 0x0F, 0xC1, 0xFC, 0x03, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0x3F,
  0xC3, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x03, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0,
  0x7F, 0xC0, 0xFF, 0x81, 0xFE, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x0F, 0xE0, 0x3F, 0xE0, 0x7F,
  0xC1, 0xFF, 0x83, 0xFF, 0x03, 0xFE, 0x07, 0xF8, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x03, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00,
  0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x01, 0xFF,
  0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x03, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x80, 0x7F, 0xC0,
  0x0F, 0xF0, 0x01, 0xF8, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF,
  0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F,
  0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0xE0, 0x3F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0xF0, 0x1F, 0xC1, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F,
  0xC0, 0xFE, 0x00, 0xFF, 0x00, 0x7E, 0x01, 0xFE, 0x00, 0x3F, 0x01, 0xF8,
  0x00, 0x1F, 0x03, 0xF0, 0x00, 0x1F, 0x07, 0xF0, 0x00, 0x1F, 0x07, 0xE0,
  0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x1F, 0x1F, 0x80,
  0x0F, 0xFE, 0x1F, 0x00, 0x7F, 0xFE, 0x3F, 0x01, 0xFF, 0xFE, 0x3F, 0x03,
  0xFF, 0xFE, 0x3E, 0x07, 0xFF, 0xFE, 0x7E, 0x0F, 0xF0, 0x7C, 0x7C, 0x0F,
  0xC0, 0x7C, 0x7C, 0x1F, 0x80, 0x7C, 0x7C, 0x1F, 0x00, 0xF8, 0xFC, 0x3F,
  0x00, 0xF8, 0xF8, 0x3E, 0x00, 0xF8, 0xF8, 0x3E, 0x00, 0xF8, 0xF8, 0x3E,
  0x01, 0xF0, 0xF8, 0x7E, 0x01, 0xF0, 0xF8, 0x7E, 0x01, 0xF0, 0xF8, 0x7E,
  0x03, 0xF0, 0xF8, 0x3E, 0x03, 0xE0, 0xF8, 0x3F, 0x03, 0xE0, 0xF8, 0x3F,
  0x83, 0xE0, 0xF8, 0x3F, 0xFF, 0xE0, 0xF8, 0x1F, 0xFF, 0xC0, 0xF8, 0x0F,
  0xFF, 0xC0, 0xF8, 0x07, 0xFF, 0xC0, 0xF8, 0x00, 0xFE, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xF0, 0x10, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00,
  0x1F, 0x7C, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00,
  0x7C, 0x7C, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x01,
  0xF0, 0x7C, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x07,
  0xE0, 0x3E, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x0F,
  0x80, 0x3E, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xFF, 0x07, 0xC0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3F, 0x0F, 0x80,
  0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3F, 0x1F, 0x00, 0x00, 0x3F, 0x3F, 0x00,
  0x00, 0x3F, 0x3E, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0x7C, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0xFC, 0x01, 0xFE, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0xF8,
  0x00, 0x3E, 0x01, 0xF8, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3E, 0x01, 0xF8,
  0x00, 0x3E, 0x01, 0xF0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x7E, 0x03, 0xF0,
  0x00, 0x7C, 0x03, 0xE0, 0x00, 0xFC, 0x03, 0xE0, 0x03, 0xF8, 0x03, 0xE0,
  0x0F, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xC0,
  0x1F, 0xF0, 0x0F, 0x80, 0x03, 0xF0, 0x0F, 0x80, 0x01, 0xF8, 0x0F, 0x80,
  0x01, 0xF8, 0x1F, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x00,
  0x00, 0xF8, 0x1F, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x3E, 0x00,
  0x03, 0xF0, 0x3E, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x07, 0xF0, 0x7E, 0x00,
  0x1F, 0xE0, 0x7C, 0x00, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F,
  0xC0, 0x7E, 0x00, 0xFE, 0x00, 0x1C, 0x01, 0xFC, 0x00, 0x04, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x02, 0x00, 0x3F, 0xE0,
  0x3E, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xE0, 0x3F, 0xE0, 0x03,
  0xF0, 0x07, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x7F, 0x00,
  0x7C, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x03, 0xE0,
  0x1F, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x7E,
  0x07, 0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0xF8, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x01,
  0xF0, 0x3E, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00,
  0x7C, 0x0F, 0x80, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x3F, 0x03, 0xE0, 0x00,
  0x1F, 0x03, 0xF0, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x1F, 0xC0, 0xF8, 0x00,
  0x0F, 0xC0, 0x7C, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x0F, 0xE0, 0x3F, 0x00,
  0x0F, 0xE0, 0x1F, 0x00, 0x1F, 0xE0, 0x0F, 0x80, 0x1F, 0xE0, 0x0F, 0xC0,
  0x7F, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xC0, 0x7E, 0x00, 0xFF,
  0x00, 0x1C, 0x01, 0xFC, 0x00, 0x04, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x03, 0xF0, 0x7C, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xE0, 0xFC, 0x00,
  0x03, 0xE0, 0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x00,
  0x07, 0xC0, 0xFC, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x0F, 0xC0, 0x7C, 0x00,
  0x0F, 0xC0, 0x7E, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x0F, 0x80, 0x7F, 0x00,
  0x1F, 0x80, 0x3F, 0x80, 0x1F, 0x80, 0x3F, 0xE0, 0x3F, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x03,
  0xE0, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x07, 0xE0, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x7C, 0x00,
  0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x0F,
  0x80, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0xF8,
  0x01, 0xF8, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x01, 0xF8, 0x01, 0xF0, 0x00,
  0x1F, 0x80, 0x3F, 0x00, 0x01, 0xF0, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x3F,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xC0, 0x00,
  0x7E, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0xFC,
  0x00, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x1F, 0x80, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x01,
  0xF8, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x01, 0xF0, 0x03, 0xF0,
  0x00, 0x1F, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x03, 0xE0, 0x00, 0x3F, 0x00,
  0x7E, 0x00, 0x03, 0xE0, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x07,
  0xE0, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x08, 0x00, 0x3F, 0x80, 0x0E, 0x00,
  0x3F, 0x80, 0x07, 0xE0, 0x7F, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0x7C,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0xFC, 0x01, 0xF8, 0x00,
  0x0F, 0x80, 0x3F, 0x00, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0xFC,
  0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x01, 0xF0,
  0x7E, 0x00, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x00,
  0x3E, 0x7F, 0x00, 0x00, 0x03, 0xEF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x00,
  0xFC, 0xFE, 0x00, 0x00, 0x0F, 0x87, 0xF0, 0x00, 0x00, 0xF8, 0x3F, 0x00,
  0x00, 0x1F, 0x81, 0xF8, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x1F, 0x00,
  0xFC, 0x00, 0x01, 0xF0, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x01, 0xF8,
  0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x7C, 0x00,
  0x0F, 0xC0, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE,
  0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x07, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x03, 0xFE, 0x01, 0xFE,
  0x00, 0x3D, 0xE0, 0x3D, 0xE0, 0x03, 0xDE, 0x07, 0xDE, 0x00, 0x79, 0xE0,
  0x7B, 0xC0, 0x07, 0x9E, 0x0F, 0x3C, 0x00, 0x79, 0xE0, 0xF3, 0xC0, 0x0F,
  0x9E, 0x1E, 0x3C, 0x00, 0xF1, 0xE1, 0xE7, 0xC0, 0x0F, 0x1E, 0x3C, 0x7C,
  0x01, 0xF1, 0xE7, 0xC7, 0xC0, 0x1F, 0x1E, 0x78, 0x78, 0x01, 0xE1, 0xEF,
  0x07, 0x80, 0x3E, 0x0E, 0xF0, 0xF8, 0x03, 0xE0, 0xFE, 0x0F, 0x80, 0x3E,
  0x0F, 0xE0, 0xF8, 0x07, 0xC0, 0xFC, 0x0F, 0x00, 0x7C, 0x0F, 0xC0, 0xF0,
  0x07, 0xC0, 0xF8, 0x1F, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x3E, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x1F, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00,
  0x7C, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x00, 0x7C, 0x07, 0xC0,
  0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x0F, 0xC0,
  0x00, 0x7C, 0x01, 0xFC, 0x00, 0x0F, 0x80, 0x3F, 0x80, 0x03, 0xE0, 0x0F,
  0xF0, 0x00, 0x7C, 0x01, 0xFE, 0x00, 0x0F, 0x80, 0x3F, 0xE0, 0x01, 0xF0,
  0x07, 0xFC, 0x00, 0x7C, 0x01, 0xF7, 0x80, 0x0F, 0x80, 0x3E, 0xF8, 0x01,
  0xF0, 0x07, 0xDF, 0x00, 0x3E, 0x00, 0xF9, 0xE0, 0x07, 0x80, 0x3E, 0x3C,
  0x01, 0xF0, 0x07, 0xC7, 0xC0, 0x3E, 0x00, 0xF8, 0xF8, 0x07, 0xC0, 0x1F,
  0x0F, 0x00, 0xF8, 0x03, 0xC1, 0xE0, 0x3E, 0x00, 0xF8, 0x3E, 0x07, 0xC0,
  0x1F, 0x07, 0xC0, 0xF8, 0x03, 0xE0, 0x78, 0x1F, 0x00, 0x78, 0x0F, 0x07,
  0xC0, 0x1F, 0x01, 0xF0, 0xF8, 0x03, 0xE0, 0x3E, 0x1F, 0x00, 0x7C, 0x03,
  0xC3, 0xE0, 0x0F, 0x00, 0x78, 0xF8, 0x03, 0xE0, 0x0F, 0x1F, 0x00, 0x7C,
  0x01, 0xF3, 0xE0, 0x0F, 0x80, 0x1E, 0x7C, 0x01, 0xF0, 0x03, 0xCF, 0x00,
  0x7C, 0x00, 0x7B, 0xE0, 0x0F, 0x80, 0x0F, 0x7C, 0x01, 0xF0, 0x01, 0xFF,
  0x80, 0x3E, 0x00, 0x1F, 0xE0, 0x0F, 0x80, 0x03, 0xFC, 0x01, 0xF0, 0x00,
  0x7F, 0x80, 0x3E, 0x00, 0x0F, 0xF0, 0x07, 0xC0, 0x01, 0xFC, 0x01, 0xF0,
  0x00, 0x3F, 0x80, 0x3E, 0x00, 0x03, 0xF0, 0x07, 0xC0, 0x00, 0x7E, 0x00,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0x80, 0x1F, 0xF0, 0x7F, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0xFC, 0x00, 0x7E,
  0x03, 0xF0, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0xFC, 0x1F, 0x80, 0x01, 0xF8,
  0x7E, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x0F, 0xC7,
  0xE0, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x7C, 0x7C,
  0x00, 0x00, 0xF8, 0xF8, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x03, 0xE7, 0xE0,
  0x00, 0x0F, 0xCF, 0x80, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x3E, 0x3E, 0x00,
  0x00, 0x7C, 0x7C, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x03, 0xE3, 0xF0, 0x00,
  0x0F, 0xC7, 0xE0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x3E, 0x1F, 0x80, 0x00,
  0xFC, 0x3F, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x1F,
  0x80, 0xFC, 0x00, 0x7E, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x0F, 0xF0,
  0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFC, 0x03, 0xFE, 0x00, 0xF8, 0x00, 0xFE,
  0x00, 0xF8, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3F,
  0x01, 0xF0, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x3F,
  0x03, 0xF0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x7E,
  0x07, 0xE0, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0xFC, 0x07, 0xC0, 0x01, 0xF8,
  0x07, 0xC0, 0x07, 0xF8, 0x0F, 0xC0, 0x1F, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80,
  0x1F, 0xF0, 0x7F, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0xFC, 0x00, 0x7E, 0x03,
  0xF0, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x7E,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x0F, 0xC7, 0xE0,
  0x00, 0x1F, 0x8F, 0x80, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x7C, 0x7C, 0x00,
  0x00, 0xF8, 0xF8, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x03, 0xE7, 0xE0, 0x00,
  0x0F, 0xCF, 0x80, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00,
  0x7C, 0x7C, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x0F,
  0xC7, 0xE0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0xFC,
  0x3F, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x1F, 0x80,
  0xFC, 0x00, 0x7E, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x0F, 0xF0, 0x03,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFC,
  0x03, 0xFE, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0xF8,
  0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3F, 0x01, 0xF8,
  0x00, 0x3F, 0x01, 0xF0, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0x3E, 0x03, 0xF0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x7E, 0x03, 0xE0,
  0x00, 0xFC, 0x07, 0xE0, 0x01, 0xFC, 0x07, 0xE0, 0x03, 0xF8, 0x07, 0xC0,
  0x1F, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0x8F, 0xF8, 0x00, 0x1F, 0x80,
  0xFC, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x1F, 0x00,
  0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x0F, 0x80, 0x7E, 0x00,
  0x0F, 0x80, 0x7C, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x0F, 0xC0, 0x7C, 0x00,
  0x07, 0xC0, 0xFC, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0x80, 0x3C, 0x00, 0xFE,
  0x00, 0x04, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x20, 0x00,
  0x0F, 0xC0, 0x78, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x07, 0xC0,
  0x7E, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x01, 0xF8,
  0x0F, 0x80, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x7E,
  0x03, 0xE0, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x0F,
  0x80, 0xF8, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x03,
  0xE0, 0x3F, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00,
  0xFC, 0x07, 0xC0, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00,
  0x3F, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x0F, 0x80, 0xFC, 0x00,
  0x07, 0xC0, 0x7C, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x03, 0xF0, 0x1F, 0x00,
  0x01, 0xF0, 0x1F, 0x80, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0xFC, 0x07, 0xE0,
  0x00, 0x7E, 0x03, 0xF0, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x7C,
  0x00, 0x1F, 0x80, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x07,
  0xF0, 0x3F, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03,
  0xF7, 0xE0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x3F,
  0x3F, 0x00, 0x00, 0x7C, 0x7E, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x03, 0xE1,
  0xF8, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x7E, 0x0F,
  0xC0, 0x00, 0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x3F, 0x00, 0x07, 0xC0, 0x3E,
  0x00, 0x1F, 0x80, 0x7C, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0xFC, 0x01, 0xF0,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x1F, 0x80, 0x0F, 0x80,
  0x3E, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x7C, 0x07,
  0xE0, 0x00, 0xF8, 0x0F, 0x80, 0x01, 0xF0, 0x3F, 0x00, 0x03, 0xF0, 0x7C,
  0x00, 0x07, 0xE1, 0xF8, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x0F, 0x8F, 0x80,
  0x00, 0x1F, 0x1F, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x7C, 0xF8, 0x00,
  0x00, 0xFB, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x00,
  0x3E, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x7E, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x07, 0xC0,
  0x7C, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00,
  0xF8, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x01, 0xF0, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x1E, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x0F, 0x01, 0xF0, 0x3E, 0x01, 0xF0, 0x3F, 0x03,
  0xE0, 0x1F, 0x07, 0xF0, 0x3C, 0x01, 0xF0, 0x7F, 0x07, 0xC0, 0x1E, 0x0F,
  0xF0, 0x7C, 0x01, 0xE0, 0xFF, 0x07, 0x80, 0x1E, 0x1E, 0xF0, 0xF8, 0x03,
  0xE1, 0xEF, 0x0F, 0x80, 0x3E, 0x3C, 0xF0, 0xF0, 0x03, 0xC7, 0xC7, 0x0F,
  0x00, 0x3C, 0x78, 0x71, 0xF0, 0x03, 0xCF, 0x87, 0x1E, 0x00, 0x3C, 0xF0,
  0x79, 0xE0, 0x07, 0x9E, 0x07, 0xBE, 0x00, 0x79, 0xE0, 0x7B, 0xC0, 0x07,
  0xBC, 0x07, 0xBC, 0x00, 0x7F, 0xC0, 0x7B, 0xC0, 0x07, 0xF8, 0x07, 0xF8,
  0x00, 0x7F, 0x80, 0x7F, 0x80, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x0F, 0xC0,
  0x00, 0x03, 0xE0, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x00, 0x1F, 0x8F, 0x80,
  0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x00,
  0x1F, 0xDF, 0x00, 0x00, 0x00, 0x7F, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x3E,
  0x00, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x00,
  0x3F, 0x80, 0xF8, 0x00, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x01,
  0xF0, 0x00, 0x07, 0xE0, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00,
  0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0x80, 0x07, 0xF0, 0x00,
  0x1F, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01,
  0xFB, 0xE0, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x3F,
  0x0F, 0x80, 0x00, 0x7E, 0x1F, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x07, 0xE0,
  0x7E, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0xFC, 0x01,
  0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x1F, 0x80, 0x07,
  0xC0, 0x3E, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x1F,
  0x0F, 0xC0, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x7D,
  0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFC,
  0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF8, 0x7E, 0x1F, 0x87,
  0xE1, 0xF8, 0x7E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8,
  0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC0, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xEF, 0x80, 0x01, 0xF9, 0xF0, 0x00, 0x7E, 0x3E, 0x00, 0x1F, 0x83, 0xE0,
  0x07, 0xE0, 0x7C, 0x00, 0xFC, 0x0F, 0x80, 0x3F, 0x00, 0xF8, 0x0F, 0xC0,
  0x1F, 0x03, 0xF0, 0x03, 0xE0, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x07, 0xC7,
  0xE0, 0x00, 0xF9, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xF3, 0x80, 0x00,
  0x3C, 0x30, 0x00, 0x06, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x08, 0x03, 0x80, 0x7C, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xE0, 0x08, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0x01, 0xFF, 0x80, 0xF8, 0x1F, 0xF0, 0x0F, 0xC1, 0xFE, 0x00, 0x7E,
  0x0F, 0xE0, 0x03, 0xE0, 0xFE, 0x00, 0x1F, 0x0F, 0xE0, 0x01, 0xF8, 0x7E,
  0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x7C, 0x3F, 0x00, 0x03, 0xE1, 0xF0, 0x00,
  0x3F, 0x1F, 0x80, 0x01, 0xF8, 0xFC, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x7C,
  0x3E, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x3F, 0x0F, 0x80, 0x01, 0xF0, 0x7C,
  0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xE0, 0xFC, 0x00,
  0x3F, 0x07, 0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x3F, 0xC0, 0xFE, 0x07, 0xFE,
  0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x7C, 0x01,
  0xFF, 0xE3, 0xE0, 0x03, 0xFC, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE3,
  0xF8, 0x00, 0x3E, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFC, 0x07, 0xFC, 0x0F, 0xE0, 0x3F, 0x00, 0x3F, 0x81,
  0xF0, 0x00, 0xFC, 0x0F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x07, 0xC0,
  0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3E, 0x1F, 0x80, 0x01,
  0xF0, 0xF8, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0xE3,
  0xF0, 0x00, 0x3F, 0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x87, 0xC0,
  0x00, 0xFC, 0x3E, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0xFE, 0x1F, 0x00, 0x07,
  0xE0, 0xF8, 0x00, 0xFE, 0x07, 0xC0, 0x0F, 0xF0, 0x7E, 0x00, 0xFF, 0x03,
  0xE0, 0x3F, 0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0x80, 0x30, 0x1F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x80,
  0xFF, 0x80, 0x3C, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x3F, 0xE0, 0xFE, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x80, 0x1F,
  0x00, 0x3F, 0x80, 0x0F, 0x80, 0x3F, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x07,
  0xE0, 0x1F, 0x80, 0x03, 0xE0, 0x1F, 0x80, 0x01, 0xF0, 0x0F, 0xC0, 0x00,
  0xF8, 0x07, 0xC0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x7E, 0x03, 0xF0, 0x00,
  0x3E, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0xFC, 0x00,
  0x0F, 0xC0, 0x7E, 0x00, 0x07, 0xC0, 0x3F, 0x00, 0x03, 0xE0, 0x1F, 0x80,
  0x01, 0xF0, 0x0F, 0xC0, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0xF8, 0x03, 0xF0,
  0x00, 0x7C, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x7F, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFC, 0xF8, 0x00, 0x7F, 0xFC, 0x7C, 0x00, 0x07, 0xF0, 0x3C, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xE0, 0x7F, 0x07, 0xF0, 0x03,
  0xF0, 0xFE, 0x00, 0x1F, 0x1F, 0xC0, 0x01, 0xF1, 0xF8, 0x00, 0x1F, 0x3F,
  0x00, 0x03, 0xF3, 0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x07, 0xF7, 0xE0, 0x00,
  0xFE, 0x7C, 0x00, 0x3F, 0xEF, 0xC0, 0x3F, 0xFC, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x02, 0x07, 0xFC,
  0x01, 0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x60, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x10, 0x7F,
  0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xF8, 0x1F,
  0x80, 0x07, 0xF8, 0x03, 0xE0, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x1F, 0x80,
  0x03, 0xF0, 0x07, 0xE0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0xFC,
  0x00, 0x0F, 0x80, 0x3E, 0x00, 0x03, 0xE0, 0x1F, 0x80, 0x01, 0xF8, 0x07,
  0xE0, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x1F, 0x00, 0x03, 0xF0, 0x07, 0xC0, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x03, 0xE0, 0x07, 0xE0, 0x01,
  0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0x3F, 0x81, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x01,
  0xFE, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x30, 0x00, 0x3F, 0x80, 0x0F, 0x80, 0x7F, 0xC0, 0x07, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x1F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xE0, 0x3F, 0x80, 0xFF, 0x03, 0xE0, 0x03, 0xF0, 0x3E, 0x00, 0x3F, 0x03,
  0xE0, 0x01, 0xF0, 0x7E, 0x00, 0x1F, 0x07, 0xE0, 0x01, 0xF0, 0x7C, 0x00,
  0x1F, 0x07, 0xC0, 0x01, 0xF0, 0xFC, 0x00, 0x1F, 0x0F, 0xC0, 0x03, 0xF0,
  0xF8, 0x00, 0x3F, 0x0F, 0x80, 0x03, 0xE1, 0xF8, 0x00, 0x3E, 0x1F, 0x80,
  0x07, 0xE1, 0xF0, 0x00, 0x7E, 0x1F, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x7C,
  0x3F, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0xFC, 0x3E, 0x00, 0x0F, 0x83, 0xE0,
  0x00, 0xF8, 0x7E, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF8, 0x7C, 0x00, 0x1F,
  0x87, 0xC0, 0x01, 0xF0, 0xFC, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xF0, 0x00,
  0x1F, 0x00, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x83, 0xFF,
  0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x00, 0x3E, 0x00, 0x0F,
  0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFF,
  0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0x80, 0x7F, 0xF0, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x30, 0x01, 0xF8, 0x00, 0x3C, 0x07, 0xF8, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x7E, 0x01, 0xF8,
  0x00, 0xFE, 0x01, 0xF0, 0x01, 0xF8, 0x01, 0xF0, 0x07, 0xF0, 0x03, 0xF0,
  0x0F, 0xE0, 0x03, 0xF0, 0x1F, 0xC0, 0x03, 0xE0, 0x3F, 0x80, 0x03, 0xE0,
  0x7F, 0x00, 0x03, 0xE1, 0xFE, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x07, 0xC7,
  0xF0, 0x00, 0x07, 0xDF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xBF,
  0x80, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x1F, 0x07,
  0xF0, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3F, 0x01,
  0xFC, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7F, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x3F, 0x80, 0x7C, 0x00,
  0x1F, 0x80, 0x7C, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x0F, 0xC0, 0x7F, 0xFE,
  0x3F, 0xFF, 0x3F, 0xFF, 0x9F, 0xFF, 0x8F, 0xFF, 0xC0, 0x03, 0xE0, 0x03,
  0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0xBF, 0x81, 0xCF, 0xFF, 0xE7, 0xFF, 0xF1, 0xFF, 0xF8, 0x7F, 0xF8,
  0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0xF8, 0x00, 0xFF, 0xFB, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0x0F, 0xE3, 0xF0, 0x1F,
  0x07, 0xE0, 0xF8, 0x0F, 0x83, 0xE0, 0x7C, 0x07, 0xC1, 0xF0, 0x3E, 0x03,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x07, 0xC0, 0x78, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x78, 0x0F, 0x83, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x03,
  0xE0, 0x7C, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00,
  0xF8, 0x1F, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x3E, 0x07, 0xC0, 0x00,
  0x1F, 0x03, 0xE0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x01, 0xFC, 0x07, 0xF8,
  0x0F, 0xC0, 0x0F, 0xC0, 0x7C, 0x00, 0x7E, 0x03, 0xE0, 0x01, 0xF8, 0x3F,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x0F, 0x80, 0x03, 0xF0, 0x7C, 0x00,
  0x1F, 0x07, 0xE0, 0x00, 0xF8, 0x3F, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x7E,
  0x0F, 0x80, 0x03, 0xF0, 0x7C, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0xF8, 0x3F,
  0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x7E, 0x0F, 0x80, 0x03, 0xE0, 0xFC, 0x00,
  0x1F, 0x07, 0xE0, 0x01, 0xF8, 0x3E, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x7C,
  0x1F, 0x80, 0x03, 0xE0, 0xFC, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF8, 0x3E,
  0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x7C, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xC0, 0xFE, 0x07, 0xF0, 0x07, 0xF0, 0xFE,
  0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x1F, 0x1F, 0x80, 0x01,
  0xF3, 0xF0, 0x00, 0x1F, 0x3F, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x1F, 0x7E,
  0x00, 0x01, 0xF7, 0xE0, 0x00, 0x3F, 0x7C, 0x00, 0x03, 0xF7, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xF8, 0xFC, 0x00,
  0x3F, 0x87, 0xE0, 0x07, 0xF0, 0x7E, 0x00, 0xFF, 0x07, 0xF8, 0x3F, 0xE0,
  0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x00, 0x7F,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x7C,
  0x00, 0x3F, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0xF8, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x1F, 0x01, 0xF8,
  0x00, 0x1F, 0x01, 0xF0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x1F, 0x03, 0xF0,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0xE0,
  0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0xFC, 0x07, 0xE0,
  0x00, 0xFC, 0x07, 0xC0, 0x01, 0xF8, 0x07, 0xC0, 0x03, 0xF8, 0x0F, 0xC0,
  0x0F, 0xF0, 0x0F, 0xC0, 0x1F, 0xE0, 0x0F, 0x80, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFE, 0x00, 0xFF, 0x81, 0xF8, 0x07, 0xF0, 0x07, 0xE0, 0x3F, 0x80, 0x1F,
  0x81, 0xF8, 0x00, 0x7C, 0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xC1,
  0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xF8, 0x3F, 0x00, 0x07, 0xE0, 0xF8,
  0x00, 0x1F, 0x87, 0xE0, 0x00, 0x7E, 0x1F, 0x80, 0x01, 0xF0, 0x7C, 0x00,
  0x07, 0xC1, 0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x03,
  0xE0, 0xFC, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x3E, 0x0F, 0xC0, 0x01, 0xF8,
  0x3F, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x7C, 0x07,
  0xE0, 0x03, 0xF0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x81, 0xFE, 0x00, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFC,
  0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xC0,
  0x06, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xE0, 0x1F, 0xE0, 0x3E, 0x01, 0xF8, 0x00, 0x40, 0x3F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xF0, 0x20, 0x00, 0x7E, 0x03, 0xC0, 0x1F, 0xE0, 0x7F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x1F,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFC, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x02, 0x01, 0xFC, 0x0F, 0x00,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xE0,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0xF8, 0x00, 0x3F, 0x0F,
  0x80, 0x03, 0xE1, 0xF8, 0x00, 0x3E, 0x1F, 0x80, 0x03, 0xE1, 0xF0, 0x00,
  0x7E, 0x1F, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x7C, 0x3F, 0x00, 0x07, 0xC3,
  0xE0, 0x00, 0xFC, 0x3E, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0xF8, 0x7E, 0x00,
  0x0F, 0x87, 0xC0, 0x01, 0xF8, 0x7C, 0x00, 0x1F, 0x87, 0xC0, 0x01, 0xF0,
  0xFC, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xF0, 0xF8, 0x00, 0x3F, 0x0F, 0x80,
  0x03, 0xE0, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x7E,
  0x0F, 0x80, 0x07, 0xE0, 0xF8, 0x00, 0xFE, 0x0F, 0xC0, 0x1F, 0xE0, 0xFE,
  0x07, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFB,
  0xE0, 0x1F, 0xFE, 0x3E, 0x00, 0x7F, 0x81, 0xE0, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0xFB, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x1F,
  0xBF, 0x00, 0x07, 0xCF, 0xC0, 0x03, 0xF3, 0xF0, 0x00, 0xF8, 0xFC, 0x00,
  0x7E, 0x3F, 0x00, 0x1F, 0x0F, 0xC0, 0x0F, 0xC1, 0xF0, 0x03, 0xE0, 0x7C,
  0x01, 0xF8, 0x1F, 0x00, 0x7C, 0x07, 0xC0, 0x3F, 0x01, 0xF0, 0x0F, 0x80,
  0x7E, 0x07, 0xE0, 0x1F, 0x81, 0xF0, 0x07, 0xE0, 0xF8, 0x00, 0xF8, 0x7E,
  0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x8F, 0xC0, 0x03, 0xE7, 0xE0, 0x00, 0xFD,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x07, 0xCF, 0x80, 0x00,
  0x07, 0xC7, 0xC0, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x01, 0xF1, 0xF0, 0x00,
  0x01, 0xF0, 0xF8, 0x00, 0x00, 0xF8, 0x7C, 0x07, 0x80, 0x7C, 0x3E, 0x03,
  0xC0, 0x7C, 0x1E, 0x03, 0xE0, 0x3E, 0x1F, 0x01, 0xF0, 0x1E, 0x0F, 0x81,
  0xF8, 0x1F, 0x07, 0xC0, 0xFC, 0x0F, 0x83, 0xE0, 0xFF, 0x07, 0x81, 0xF0,
  0xFF, 0x87, 0xC0, 0xF8, 0x7B, 0xC3, 0xE0, 0x7C, 0x79, 0xE3, 0xE0, 0x3E,
  0x3C, 0xF1, 0xF0, 0x1E, 0x3C, 0x78, 0xF0, 0x0F, 0x1E, 0x3C, 0xF8, 0x07,
  0x9E, 0x1E, 0x7C, 0x03, 0xCF, 0x0F, 0x3C, 0x01, 0xEF, 0x07, 0xBE, 0x01,
  0xFF, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0x00,
  0x3F, 0xC0, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x07, 0xC0, 0x0F, 0xC0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x1F, 0x80, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x3F, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x7E, 0x00, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x00, 0xF8, 0xFC, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x03, 0xF9, 0xF0, 0x00, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0x3F, 0x87,
  0xE0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0xFC, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x1F,
  0x80, 0x1F, 0x80, 0x01, 0xF8, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x3F, 0x00,
  0x00, 0xF8, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x00, 0xF8, 0x07,
  0xC0, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0xF8, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0x00, 0x7E, 0x3E, 0x00, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x00, 0x3E, 0x7C,
  0x00, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x60, 0x7F, 0x80, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x60, 0x3F, 0xE0, 0x03, 0xC3, 0xFF, 0x80, 0x3E, 0x3F, 0xFF,
  0x03, 0xE3, 0xFF, 0xFC, 0x3F, 0x3F, 0x0F, 0xFF, 0xF1, 0xF0, 0x3F, 0xFF,
  0x1F, 0x00, 0x7F, 0xF0, 0xF0, 0x01, 0xFF, 0x01, 0x80, 0x03, 0xF0, 0x00,
};

const GFXglyph UbuntuMono_Italic66pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 33, 0, -1 },
  { 1, 16, 41, 33, 11, -41 },
  { 83, 18, 16, 33, 15, -45 },
  { 119, 34, 41, 33, 3, -41 },
  { 294, 30, 52, 33, 5, -46 },
  { 489, 40, 41, 33, 0, -41 },
  { 694, 28, 41, 33, 4, -41 },
  { 838, 9, 18, 33, 20, -45 },
  { 859, 25, 57, 33, 10, -46 },
  { 1038, 25, 57, 33, 4, -46 },
  { 1217, 26, 24, 33, 9, -41 },
  { 1295, 27, 29, 33, 6, -32 },
  { 1393, 14, 18, 33, 7, -9 },
  { 1425, 15, 5, 33, 12, -19 },
  { 1435, 10, 9, 33, 11, -9 },
  { 1447, 38, 57, 33, -1, -46 },
  { 1718, 29, 41, 33, 6, -41 },
  { 1867, 24, 41, 33, 6, -41 },
  { 1990, 30, 41, 33, 5, -41 },
  { 2144, 30, 41, 33, 4, -41 },
  { 2298, 31, 41, 33, 3, -41 },
  { 2457, 32, 41, 33, 4, -41 },
  { 2621, 30, 41, 33, 6, -41 },
  { 2775, 30, 41, 33, 9, -41 },
  { 2929, 31, 41, 33, 5, -41 },
  { 3088, 30, 41, 33, 5, -41 },
  { 3242, 15, 30, 33, 11, -30 },
  { 3299, 19, 39, 33, 7, -30 },
  { 3392, 29, 26, 33, 5, -30 },
  { 3487, 31, 18, 33, 4, -26 },
  { 3557, 29, 26, 33, 4, -30 },
  { 3652, 23, 41, 33, 11, -41 },
  { 3770, 32, 50, 33, 5, -41 },
  { 3970, 32, 41, 33, -1, -41 },
  { 4134, 32, 41, 33, 3, -41 },
  { 4298, 32, 41, 33, 6, -41 },
  { 4462, 33, 41, 33, 2, -41 },
  { 4632, 32, 41, 33, 5, -41 },
  { 4796, 33, 41, 33, 5, -41 },
  { 4966, 32, 41, 33, 5, -41 },
  { 5130, 36, 41, 33, 2, -41 },
  { 5315, 31, 41, 33, 5, -41 },
  { 5474, 33, 41, 33, 4, -41 },
  { 5644, 36, 41, 33, 3, -41 },
  { 5829, 24, 41, 33, 4, -41 },
  { 5952, 36, 41, 33, 1, -41 },
  { 6137, 35, 41, 33, 3, -41 },
  { 6317, 31, 41, 33, 5, -41 },
  { 6476, 32, 41, 33, 4, -41 },
  { 6640, 31, 52, 33, 5, -41 },
  { 6842, 32, 41, 33, 3, -41 },
  { 7006, 32, 41, 33, 4, -41 },
  { 7170, 29, 41, 33, 10, -41 },
  { 7319, 33, 41, 33, 5, -41 },
  { 7489, 31, 41, 33, 9, -41 },
  { 7648, 36, 41, 33, 4, -41 },
  { 7833, 39, 41, 33, 1, -41 },
  { 8033, 31, 41, 33, 10, -41 },
  { 8192, 36, 41, 33, 2, -41 },
  { 8377, 30, 57, 33, 6, -46 },
  { 8591, 10, 57, 33, 14, -46 },
  { 8663, 29, 57, 33, 2, -46 },
  { 8870, 27, 22, 33, 7, -41 },
  { 8945, 31, 5, 33, -2, 6 },
  { 8965, 12, 12, 33, 17, -46 },
  { 8983, 29, 33, 33, 5, -32 },
  { 9103, 29, 47, 33, 4, -46 },
  { 9274, 29, 33, 33, 5, -32 },
  { 9394, 33, 47, 33, 5, -46 },
  { 9588, 28, 33, 33, 5, -32 },
  { 9704, 38, 57, 33, 1, -46 },
  { 9975, 34, 43, 33, 1, -32 },
  { 10158, 28, 46, 33, 3, -46 },
  { 10319, 19, 45, 33, 9, -45 },
  { 10426, 32, 56, 33, 1, -45 },
  { 10650, 32, 46, 33, 4, -46 },
  { 10834, 17, 47, 33, 12, -46 },
  { 10934, 33, 32, 33, 2, -32 },
  { 11066, 29, 32, 33, 4, -32 },
  { 11182, 28, 33, 33, 5, -32 },
  { 11298, 32, 43, 33, 1, -32 },
  { 11470, 30, 43, 33, 5, -32 },
  { 11632, 28, 32, 33, 6, -32 },
  { 11744, 28, 33, 33, 5, -32 },
  { 11860, 25, 42, 33, 9, -41 },
  { 11992, 28, 32, 33, 6, -31 },
  { 12104, 26, 31, 33, 9, -31 },
  { 12205, 33, 31, 33, 5, -31 },
  { 12333, 35, 31, 33, 1, -31 },
  { 12469, 36, 42, 33, -1, -31 },
  { 12658, 30, 31, 33, 4, -31 },
  { 12775, 32, 57, 33, 6, -46 },
  { 13003, 19, 57, 33, 10, -46 },
  { 13139, 32, 57, 33, 0, -46 },
  { 13367, 29, 10, 33, 5, -22 },
};

const GFXfont UbuntuMono_Italic66pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Italic66pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Italic66pt7bGlyphs,
  0x20, 0x7E, 66
};

#endif // _UBUNTUMONO_ITALIC66PT7B_H_
