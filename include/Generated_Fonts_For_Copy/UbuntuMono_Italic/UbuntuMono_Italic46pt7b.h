#ifndef _UBUNTUMONO_ITALIC46PT7B_H_
#define _UBUNTUMONO_ITALIC46PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Italic.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Italic46pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x81, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x1C,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xE0, 0x38, 0x00, 0x3C, 0x39, 0xC3, 0xCE, 0x1E, 0xF0, 0xE7, 0x07,
  0x38, 0x79, 0xC3, 0x8C, 0x1C, 0xE0, 0xE7, 0x06, 0x30, 0x30, 0x00, 0x0E,
  0x0F, 0x00, 0x1E, 0x0E, 0x00, 0x1C, 0x0E, 0x00, 0x1C, 0x1E, 0x00, 0x3C,
  0x1C, 0x00, 0x38, 0x3C, 0x00, 0x78, 0x38, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFE, 0x01, 0xE0, 0xE0, 0x01, 0xC1, 0xE0, 0x01, 0xC1,
  0xE0, 0x03, 0xC1, 0xC0, 0x03, 0x83, 0xC0, 0x07, 0x83, 0x80, 0x07, 0x07,
  0x80, 0x07, 0x07, 0x80, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF8, 0x1C, 0x1E, 0x00, 0x3C, 0x1C, 0x00, 0x38, 0x3C, 0x00, 0x78, 0x38,
  0x00, 0x70, 0x78, 0x00, 0x70, 0x78, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x7F, 0x80, 0x0F, 0xFF, 0x80, 0x7F, 0xFE, 0x03, 0xE0, 0x30, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x02, 0x00, 0x7C,
  0x1E, 0x03, 0xE0, 0x7F, 0xFF, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0xE0, 0x1F, 0xC0, 0x1C, 0x03, 0xFE, 0x03, 0xC0,
  0x38, 0xE0, 0x78, 0x07, 0x8E, 0x07, 0x00, 0x70, 0xE0, 0xE0, 0x07, 0x0E,
  0x1C, 0x00, 0x60, 0xE3, 0x80, 0x06, 0x1E, 0x70, 0x00, 0x61, 0xCF, 0x00,
  0x07, 0x3D, 0xE0, 0x00, 0x7F, 0x9C, 0x00, 0x07, 0xF3, 0x80, 0x00, 0x3E,
  0x70, 0x00, 0x00, 0x0E, 0x7C, 0x00, 0x01, 0xCF, 0xE0, 0x00, 0x3D, 0xFE,
  0x00, 0x07, 0xBC, 0xE0, 0x00, 0xF3, 0x86, 0x00, 0x0E, 0x30, 0x60, 0x01,
  0xC7, 0x0E, 0x00, 0x38, 0x70, 0xE0, 0x07, 0x07, 0x0E, 0x00, 0xE0, 0x71,
  0xE0, 0x1E, 0x07, 0x1C, 0x03, 0xC0, 0x7F, 0xC0, 0x38, 0x03, 0xF8, 0x07,
  0x00, 0x1E, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xC0, 0x3E,
  0x3C, 0x03, 0xC1, 0xC0, 0x78, 0x1C, 0x07, 0x81, 0xC0, 0x70, 0x3C, 0x07,
  0x07, 0x80, 0x78, 0xF0, 0x07, 0x9E, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00,
  0x7E, 0x0F, 0x0F, 0xE0, 0xE1, 0xEF, 0x0E, 0x3C, 0x79, 0xE7, 0x87, 0x9C,
  0xF0, 0x3F, 0xCF, 0x01, 0xF8, 0xF0, 0x1F, 0x8F, 0x00, 0xF0, 0xF0, 0x0F,
  0x0F, 0x03, 0xF8, 0xF8, 0x7F, 0x87, 0xFF, 0xF8, 0x7F, 0xE3, 0xC1, 0xF8,
  0x3C, 0x3C, 0xF7, 0x9E, 0x79, 0xC7, 0x3C, 0xE3, 0x8E, 0x30, 0x00, 0x01,
  0x00, 0x03, 0x80, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x38, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x07, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0x80, 0x00, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x60, 0xE0, 0x9E,
  0x39, 0xE7, 0xED, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0x80, 0x78, 0x00, 0x3F,
  0x00, 0x1E, 0xE0, 0x0F, 0x3C, 0x07, 0xC7, 0x81, 0xE1, 0xF0, 0x38, 0x38,
  0x04, 0x08, 0x00, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x87, 0xE1, 0xFC, 0x7F, 0x1F, 0xC3, 0xF0, 0x78, 0x3E, 0x3F,
  0x3F, 0x8F, 0x83, 0x80, 0x7F, 0xEF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3D, 0xFF,
  0xFF, 0xFF, 0xCF, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xE0, 0x3E, 0x1E,
  0x07, 0x80, 0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0xF1, 0xE0, 0x0F, 0x3C, 0x00,
  0xF3, 0xC0, 0x0F, 0x3C, 0x00, 0xF7, 0x87, 0x0F, 0x78, 0xF8, 0xF7, 0x9F,
  0x8E, 0xF1, 0xF9, 0xEF, 0x1F, 0x1E, 0xF0, 0xE1, 0xEF, 0x00, 0x3C, 0xF0,
  0x03, 0xCF, 0x00, 0x38, 0xF0, 0x07, 0x8F, 0x00, 0xF0, 0xF0, 0x0F, 0x0F,
  0x01, 0xE0, 0x78, 0x7C, 0x07, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0x80, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x0F, 0xF0, 0x1F,
  0xF8, 0x3F, 0xB8, 0x0F, 0x3C, 0x04, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x3F, 0xFF, 0x9F, 0xFF, 0xDF, 0xFF, 0xE0,
  0x00, 0x3F, 0x80, 0x07, 0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xC1, 0xF0, 0x38,
  0x07, 0x81, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xFF, 0xFC, 0x3F, 0xFF, 0xE1, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0xFF, 0x00, 0xFF, 0xFC, 0x03, 0x83,
  0xE0, 0x10, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x1F, 0x80, 0x0F, 0xF8,
  0x00, 0x7F, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x08, 0x00, 0xF8, 0x70, 0x1F, 0x87, 0xFF, 0xF8, 0x3F, 0xFF,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xEF, 0x00,
  0x1F, 0x3C, 0x00, 0x78, 0xE0, 0x03, 0xC3, 0x80, 0x1E, 0x1E, 0x00, 0xF0,
  0x78, 0x07, 0x81, 0xC0, 0x3C, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x3C, 0x03, 0xC1, 0xE0, 0x0E, 0x07, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF0, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x7F, 0xFC,
  0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x60, 0x3F, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0xC0, 0x07, 0xFE, 0x00, 0xFE,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x79, 0xFC, 0x03, 0xFF, 0xF8,
  0x3F, 0xFF, 0xE1, 0xF8, 0x1F, 0x0F, 0x00, 0x7C, 0x78, 0x01, 0xE3, 0x80,
  0x0F, 0x3C, 0x00, 0x79, 0xE0, 0x03, 0xCF, 0x00, 0x3C, 0x78, 0x01, 0xE1,
  0xE0, 0x1F, 0x0F, 0x01, 0xF0, 0x7C, 0x1F, 0x01, 0xFF, 0xF0, 0x07, 0xFF,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE,
  0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0x00,
  0xFF, 0xFC, 0x0F, 0xC3, 0xE0, 0x78, 0x0F, 0x87, 0x80, 0x3C, 0x3C, 0x01,
  0xE1, 0xC0, 0x0F, 0x0E, 0x00, 0xF0, 0x78, 0x07, 0x83, 0xC0, 0x78, 0x1F,
  0x07, 0x80, 0x7E, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xE3, 0xF0,
  0x3C, 0x0F, 0x83, 0xC0, 0x1E, 0x3C, 0x00, 0xF1, 0xE0, 0x07, 0x8E, 0x00,
  0x3C, 0x70, 0x01, 0xE3, 0xC0, 0x1E, 0x1E, 0x01, 0xF0, 0xF8, 0x1F, 0x03,
  0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x03,
  0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xF8, 0x3E, 0x07, 0xC0, 0x78, 0x3E, 0x01,
  0xE0, 0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x1E, 0x00, 0x3C, 0x78, 0x00, 0xF1,
  0xE0, 0x03, 0x87, 0x80, 0x1E, 0x1F, 0x00, 0x78, 0x3E, 0x07, 0xE0, 0xFF,
  0xFF, 0x81, 0xFF, 0xFC, 0x01, 0xFC, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x80, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0x83, 0xF0, 0xFC, 0x3F, 0x0F, 0xC1, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0xFE, 0x3F, 0x8F,
  0xE3, 0xF0, 0x78, 0x00, 0x00, 0xF0, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x1F, 0x80, 0xFE, 0x07, 0xF0, 0x3F,
  0x80, 0xFC, 0x03, 0xC0, 0x3E, 0x07, 0xE0, 0xFE, 0x07, 0xC0, 0x38, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x0F, 0x00, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x0F, 0x00,
  0x00, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01,
  0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0x20, 0x1F, 0xFF, 0xF9,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F,
  0xFF, 0xF0, 0x0C, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01,
  0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0x7F, 0x80, 0x0F, 0xC0, 0x00, 0xF0, 0x00, 0x08, 0x00, 0x00, 0x03,
  0xF8, 0x07, 0xFF, 0x03, 0xFF, 0xC1, 0x81, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0xF8, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0xC1, 0xE0, 0x3E,
  0x01, 0xC0, 0xF8, 0x03, 0xC1, 0xE0, 0x07, 0x87, 0x80, 0x0F, 0x0E, 0x00,
  0x1E, 0x3C, 0x07, 0xF8, 0x70, 0x3F, 0xF1, 0xE1, 0xFF, 0xE3, 0x87, 0xC3,
  0xCF, 0x0F, 0x07, 0x1E, 0x3C, 0x0E, 0x3C, 0x70, 0x3C, 0x71, 0xE0, 0x78,
  0xE3, 0xC0, 0xF3, 0xC7, 0x81, 0xC7, 0x8F, 0x07, 0x8F, 0x1E, 0x0F, 0x1E,
  0x3C, 0x1E, 0x3C, 0x78, 0x38, 0x78, 0x78, 0x70, 0xF0, 0xFF, 0xE1, 0xE0,
  0xFF, 0xC1, 0xC0, 0x7E, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7B, 0x80, 0x00, 0xE7, 0x00, 0x03, 0x8E,
  0x00, 0x0F, 0x1C, 0x00, 0x1C, 0x3C, 0x00, 0x78, 0x78, 0x00, 0xE0, 0xF0,
  0x03, 0xC1, 0xE0, 0x07, 0x03, 0xC0, 0x1E, 0x07, 0x80, 0x38, 0x0F, 0x00,
  0xF0, 0x1E, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x38, 0x1F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xC0, 0x03, 0x87, 0x80, 0x07, 0x0E, 0x00,
  0x0E, 0x3C, 0x00, 0x1C, 0x70, 0x00, 0x39, 0xE0, 0x00, 0x7B, 0x80, 0x00,
  0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0xF0, 0x3F,
  0x03, 0x80, 0x3C, 0x1E, 0x00, 0xF0, 0x78, 0x03, 0xC1, 0xE0, 0x0F, 0x07,
  0x00, 0x3C, 0x3C, 0x01, 0xE0, 0xF0, 0x0F, 0x83, 0xC0, 0xFC, 0x0F, 0xFF,
  0xC0, 0x7F, 0xFE, 0x01, 0xFF, 0xFE, 0x07, 0x80, 0xF8, 0x1E, 0x00, 0xF0,
  0x70, 0x03, 0xC3, 0xC0, 0x07, 0x0F, 0x00, 0x1C, 0x38, 0x00, 0xF0, 0xE0,
  0x03, 0xC7, 0x80, 0x1F, 0x1E, 0x00, 0xF8, 0x70, 0x0F, 0xC1, 0xFF, 0xFE,
  0x0F, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0xF0,
  0x0F, 0xFF, 0xC0, 0xFC, 0x0F, 0x07, 0xC0, 0x08, 0x3E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x40,
  0x3E, 0x07, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0xE0, 0x7C, 0x07, 0x80,
  0xF8, 0x1E, 0x01, 0xE0, 0x78, 0x03, 0xC1, 0xC0, 0x0F, 0x0F, 0x00, 0x3C,
  0x3C, 0x00, 0xF0, 0xF0, 0x03, 0xC3, 0x80, 0x0F, 0x1E, 0x00, 0x3C, 0x78,
  0x00, 0xF1, 0xE0, 0x03, 0xC7, 0x00, 0x0E, 0x3C, 0x00, 0x78, 0xF0, 0x01,
  0xE3, 0xC0, 0x0F, 0x0E, 0x00, 0x3C, 0x78, 0x01, 0xE1, 0xE0, 0x0F, 0x87,
  0x80, 0x7C, 0x1C, 0x03, 0xE0, 0xF0, 0x3F, 0x03, 0xFF, 0xF8, 0x0F, 0xFF,
  0x80, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF,
  0xF0, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x07, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0xFC, 0x1E, 0x07, 0xC0, 0x10,
  0x3E, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x1E, 0x3C, 0x00, 0x78, 0xF0, 0x01, 0xC3, 0xC0, 0x0F, 0x0F,
  0x00, 0x3C, 0x3C, 0x00, 0xF0, 0xF0, 0x03, 0x83, 0xC0, 0x1E, 0x0F, 0x80,
  0x78, 0x1E, 0x01, 0xE0, 0x7E, 0x07, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF0,
  0x01, 0xFE, 0x00, 0x03, 0xC0, 0x07, 0x01, 0xE0, 0x07, 0x80, 0xF0, 0x03,
  0xC0, 0x70, 0x01, 0xE0, 0x78, 0x00, 0xE0, 0x3C, 0x00, 0xF0, 0x1E, 0x00,
  0x78, 0x0E, 0x00, 0x3C, 0x0F, 0x00, 0x1C, 0x07, 0x80, 0x1E, 0x03, 0xC0,
  0x0F, 0x01, 0xE0, 0x07, 0x81, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xE0, 0x38, 0x00, 0xF0, 0x3C, 0x00, 0x78, 0x1E, 0x00, 0x78, 0x0F,
  0x00, 0x3C, 0x07, 0x80, 0x1E, 0x07, 0x80, 0x0F, 0x03, 0xC0, 0x0F, 0x01,
  0xE0, 0x07, 0x80, 0xF0, 0x03, 0xC0, 0xF0, 0x01, 0xE0, 0x78, 0x00, 0xE0,
  0x3C, 0x00, 0xF0, 0x1E, 0x00, 0x78, 0x00, 0x01, 0xFF, 0xFC, 0x07, 0xFF,
  0xF0, 0x3F, 0xFF, 0x80, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xC0, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x80,
  0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0xF8, 0x08, 0x03, 0xC0, 0x78, 0x3F, 0x03, 0xFF, 0xF8, 0x07,
  0xFF, 0x80, 0x03, 0xF8, 0x00, 0x01, 0xE0, 0x0F, 0x81, 0xE0, 0x0F, 0x80,
  0xF0, 0x0F, 0x80, 0x78, 0x0F, 0x80, 0x3C, 0x0F, 0x80, 0x1C, 0x0F, 0x80,
  0x1E, 0x0F, 0x80, 0x0F, 0x0F, 0x80, 0x07, 0x8F, 0x00, 0x03, 0x8F, 0x00,
  0x03, 0xCF, 0x00, 0x01, 0xEF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x3D, 0xF0, 0x00, 0x1E, 0x78, 0x00, 0x0E, 0x1E,
  0x00, 0x0F, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x03, 0xC0, 0xF0, 0x01, 0xC0,
  0x7C, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x38,
  0x01, 0xE0, 0x3C, 0x00, 0x78, 0x1E, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00,
  0x78, 0x00, 0x3F, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF0, 0x00, 0x70, 0x07,
  0x80, 0x78, 0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x3F, 0x03, 0xE0, 0x1F, 0x81,
  0xF0, 0x0D, 0xC1, 0xF8, 0x0E, 0xE1, 0xDC, 0x07, 0x70, 0xEE, 0x03, 0xB8,
  0xE7, 0x03, 0x9C, 0x77, 0x01, 0xCE, 0x73, 0x80, 0xE7, 0x71, 0xC0, 0xF3,
  0xB8, 0xE0, 0x70, 0xF8, 0xF0, 0x38, 0x7C, 0x78, 0x3C, 0x3C, 0x38, 0x1E,
  0x1C, 0x1C, 0x0E, 0x00, 0x0E, 0x07, 0x00, 0x0F, 0x07, 0x80, 0x07, 0x83,
  0x80, 0x03, 0x81, 0xC0, 0x01, 0xC1, 0xE0, 0x01, 0xE0, 0xF0, 0x00, 0xF0,
  0x70, 0x00, 0x78, 0x78, 0x00, 0x38, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x07, 0x81, 0xF0, 0x03, 0x80, 0xF8, 0x01, 0xC0, 0x7E,
  0x01, 0xE0, 0x3F, 0x00, 0xF0, 0x3F, 0x80, 0x70, 0x1D, 0xC0, 0x38, 0x0E,
  0xF0, 0x3C, 0x07, 0x38, 0x1E, 0x07, 0x9C, 0x0E, 0x03, 0xCE, 0x07, 0x01,
  0xC3, 0x87, 0x80, 0xE1, 0xC3, 0xC0, 0xF0, 0xE1, 0xC0, 0x78, 0x70, 0xE0,
  0x38, 0x1C, 0xF0, 0x1C, 0x0E, 0x78, 0x1E, 0x07, 0x38, 0x0F, 0x03, 0x9C,
  0x07, 0x01, 0xDE, 0x03, 0x80, 0x7F, 0x03, 0xC0, 0x3F, 0x01, 0xE0, 0x1F,
  0x80, 0xE0, 0x0F, 0xC0, 0x70, 0x07, 0xE0, 0x78, 0x01, 0xE0, 0x3C, 0x00,
  0xF0, 0x1C, 0x00, 0x78, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xFE, 0x00, 0x7F,
  0xF8, 0x07, 0xC3, 0xE0, 0x78, 0x0F, 0x07, 0x80, 0x3C, 0x78, 0x01, 0xE3,
  0xC0, 0x0F, 0x3C, 0x00, 0x79, 0xE0, 0x03, 0xDE, 0x00, 0x1E, 0xF0, 0x00,
  0xF7, 0x80, 0x07, 0xF8, 0x00, 0x3B, 0xC0, 0x03, 0xDE, 0x00, 0x1E, 0xF0,
  0x00, 0xF7, 0x80, 0x0F, 0x3C, 0x00, 0x79, 0xE0, 0x03, 0x8F, 0x00, 0x3C,
  0x78, 0x03, 0xC3, 0xC0, 0x1E, 0x1E, 0x01, 0xE0, 0x7C, 0x3E, 0x03, 0xFF,
  0xE0, 0x0F, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x03, 0xFF,
  0xE0, 0x07, 0xFF, 0xE0, 0x1E, 0x03, 0xE0, 0x3C, 0x03, 0xE0, 0x78, 0x03,
  0xC0, 0xF0, 0x07, 0x83, 0xC0, 0x0F, 0x07, 0x80, 0x1E, 0x0F, 0x00, 0x3C,
  0x1E, 0x00, 0x70, 0x38, 0x01, 0xE0, 0xF0, 0x07, 0x81, 0xE0, 0x1F, 0x03,
  0xC0, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x78,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xF8,
  0x07, 0xC3, 0xE0, 0x78, 0x0F, 0x07, 0x80, 0x3C, 0x78, 0x01, 0xE3, 0xC0,
  0x0F, 0x3C, 0x00, 0x79, 0xE0, 0x03, 0xDE, 0x00, 0x1E, 0xF0, 0x00, 0xF7,
  0x80, 0x07, 0xF8, 0x00, 0x3B, 0xC0, 0x03, 0xDE, 0x00, 0x1E, 0xF0, 0x00,
  0xF7, 0x80, 0x0F, 0x3C, 0x00, 0x79, 0xE0, 0x03, 0x8F, 0x00, 0x3C, 0x78,
  0x03, 0xC3, 0xC0, 0x1E, 0x1E, 0x01, 0xE0, 0x7C, 0x3E, 0x03, 0xFF, 0xE0,
  0x0F, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x80,
  0xF0, 0x3F, 0x03, 0xC0, 0x3C, 0x0E, 0x00, 0xF0, 0x78, 0x03, 0xC1, 0xE0,
  0x0F, 0x07, 0x80, 0x3C, 0x1C, 0x00, 0xF0, 0xF0, 0x03, 0xC3, 0xC0, 0x1E,
  0x0F, 0x00, 0xF8, 0x38, 0x0F, 0xC1, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x1F,
  0xFE, 0x00, 0x70, 0x78, 0x03, 0xC0, 0xF0, 0x0F, 0x03, 0xC0, 0x3C, 0x07,
  0x80, 0xE0, 0x1E, 0x07, 0x80, 0x78, 0x1E, 0x00, 0xF0, 0x78, 0x03, 0xC1,
  0xC0, 0x0F, 0x0F, 0x00, 0x1C, 0x3C, 0x00, 0x78, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0x80, 0x60, 0x3E, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x10, 0x01, 0xF0, 0x78, 0x0F, 0xC0, 0xFF, 0xFF, 0x01, 0xFF,
  0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x1C, 0x1E, 0x00, 0x78, 0x3C, 0x00, 0xF0,
  0x70, 0x01, 0xE1, 0xE0, 0x03, 0x83, 0xC0, 0x0F, 0x07, 0x80, 0x1E, 0x0E,
  0x00, 0x3C, 0x3C, 0x00, 0x70, 0x78, 0x01, 0xE0, 0xF0, 0x03, 0xC1, 0xC0,
  0x07, 0x87, 0x80, 0x0E, 0x0F, 0x00, 0x3C, 0x1E, 0x00, 0x78, 0x38, 0x00,
  0xF0, 0xF0, 0x01, 0xC1, 0xE0, 0x07, 0x83, 0xC0, 0x0F, 0x07, 0x80, 0x1E,
  0x0F, 0x00, 0x78, 0x1E, 0x00, 0xF0, 0x3C, 0x03, 0xE0, 0x78, 0x07, 0x80,
  0x78, 0x3E, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0x00, 0x00,
  0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xEF, 0x00, 0x07, 0xBC, 0x00, 0x3C, 0xF0,
  0x00, 0xF3, 0xC0, 0x07, 0x8F, 0x00, 0x1E, 0x3C, 0x00, 0xF0, 0x70, 0x03,
  0xC1, 0xC0, 0x1E, 0x07, 0x00, 0x78, 0x1C, 0x03, 0xC0, 0x70, 0x0F, 0x01,
  0xE0, 0x78, 0x07, 0x81, 0xE0, 0x1E, 0x0F, 0x00, 0x78, 0x38, 0x01, 0xE1,
  0xE0, 0x07, 0x87, 0x00, 0x1E, 0x3C, 0x00, 0x79, 0xE0, 0x01, 0xE7, 0x80,
  0x03, 0xBC, 0x00, 0x0E, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x07, 0x07, 0x80, 0x03, 0x83,
  0xC0, 0x03, 0xC1, 0xC0, 0x01, 0xE0, 0xE0, 0x00, 0xE0, 0xF0, 0x00, 0xF0,
  0x78, 0x00, 0x78, 0x38, 0x00, 0x38, 0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x1E,
  0x0F, 0x00, 0x0F, 0x07, 0x87, 0x07, 0x03, 0x87, 0xC3, 0x81, 0xC3, 0xE3,
  0xC0, 0xE3, 0xF1, 0xC0, 0xF1, 0xB8, 0xE0, 0x71, 0xDC, 0xF0, 0x39, 0xCE,
  0x70, 0x1C, 0xE7, 0x38, 0x0E, 0xE3, 0x9C, 0x07, 0x70, 0xDC, 0x03, 0x70,
  0x6E, 0x03, 0xF0, 0x37, 0x01, 0xF8, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x7C,
  0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x01,
  0xF0, 0x07, 0x80, 0x3E, 0x00, 0x78, 0x03, 0xC0, 0x07, 0xC0, 0x78, 0x00,
  0x3C, 0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x3E, 0x1E, 0x00, 0x01, 0xE3,
  0xC0, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x07, 0x9C, 0x00,
  0x00, 0xF9, 0xE0, 0x00, 0x1F, 0x0E, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x3C,
  0x0F, 0x00, 0x07, 0x80, 0xF0, 0x00, 0xF8, 0x07, 0x80, 0x1F, 0x00, 0x78,
  0x03, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0x38, 0x07, 0x80, 0x03, 0xC0, 0xF0,
  0x00, 0x7B, 0xC0, 0x01, 0xEF, 0x00, 0x0F, 0x3C, 0x00, 0x78, 0x70, 0x01,
  0xE1, 0xC0, 0x0F, 0x07, 0x80, 0x78, 0x1E, 0x01, 0xE0, 0x78, 0x0F, 0x00,
  0xE0, 0x78, 0x03, 0xC3, 0xC0, 0x0F, 0x0F, 0x00, 0x1C, 0x78, 0x00, 0x7B,
  0xC0, 0x01, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xF0,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xF1, 0xE3, 0xC7, 0x8F,
  0x1E, 0x1C, 0x38, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF0,
  0xE1, 0xC3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x0E,
  0x1C, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x00, 0x3F, 0xF8, 0x03, 0xFF,
  0x80, 0x1F, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x3F, 0xF8, 0x03, 0xFF,
  0xC0, 0x1F, 0xFC, 0x00, 0x00, 0x1C, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00,
  0x7F, 0x00, 0x1F, 0xF0, 0x07, 0xDE, 0x00, 0xF1, 0xC0, 0x3C, 0x3C, 0x0F,
  0x07, 0x83, 0xC0, 0x70, 0xF8, 0x0F, 0x1E, 0x01, 0xE7, 0x80, 0x1D, 0xE0,
  0x03, 0xC8, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x20, 0x70, 0xF8, 0x7C, 0x3E, 0x1E, 0x0F, 0x06, 0x00, 0x1F, 0xE0, 0x07,
  0xFF, 0x80, 0x7F, 0xFC, 0x0F, 0xC1, 0xE0, 0xF8, 0x0F, 0x0F, 0x80, 0x78,
  0x78, 0x03, 0x87, 0x80, 0x3C, 0x3C, 0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x00,
  0x70, 0xE0, 0x07, 0x8F, 0x00, 0x3C, 0x78, 0x01, 0xE3, 0xC0, 0x0F, 0x1E,
  0x00, 0x70, 0xF0, 0x07, 0x87, 0x80, 0x3C, 0x1E, 0x03, 0xE0, 0xF8, 0x3F,
  0x03, 0xFF, 0xF8, 0x0F, 0xFD, 0xC0, 0x3F, 0x8F, 0x00, 0x00, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0xBF,
  0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0xE0, 0xFC, 0x3E, 0x0F, 0x00, 0xF0, 0xE0,
  0x0F, 0x1E, 0x00, 0xF1, 0xE0, 0x0F, 0x1E, 0x00, 0xF1, 0xC0, 0x0F, 0x1C,
  0x00, 0xF3, 0xC0, 0x0F, 0x3C, 0x00, 0xF3, 0xC0, 0x1E, 0x38, 0x01, 0xE7,
  0x80, 0x3C, 0x78, 0x03, 0xC7, 0x80, 0x78, 0x70, 0x1F, 0x0F, 0x07, 0xE0,
  0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x07,
  0xFF, 0x80, 0xFF, 0xFC, 0x0F, 0xC0, 0x40, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x03,
  0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xE0, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0xFC,
  0x1C, 0x03, 0xE0, 0x78, 0x0F, 0x00, 0xF0, 0x3C, 0x01, 0xE0, 0xF8, 0x03,
  0x81, 0xE0, 0x07, 0x03, 0xC0, 0x1E, 0x0F, 0x00, 0x3C, 0x1E, 0x00, 0x78,
  0x3C, 0x00, 0xE0, 0x78, 0x03, 0xC0, 0xF0, 0x07, 0x81, 0xE0, 0x0F, 0x03,
  0xC0, 0x1C, 0x07, 0x80, 0x38, 0x0F, 0x00, 0xF0, 0x0F, 0x07, 0xE0, 0x1F,
  0xFF, 0xE0, 0x1F, 0xFB, 0xC0, 0x0F, 0xC7, 0x80, 0x00, 0x3F, 0x80, 0x1F,
  0xFC, 0x03, 0xFF, 0xE0, 0x7C, 0x1F, 0x0F, 0x80, 0xF1, 0xE0, 0x0F, 0x3E,
  0x00, 0xF3, 0xC0, 0x0F, 0x78, 0x01, 0xF7, 0x80, 0x3E, 0x78, 0x1F, 0xC7,
  0xFF, 0xF8, 0xFF, 0xFE, 0x0F, 0xFE, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x18, 0x3F, 0xFF,
  0x80, 0xFF, 0xF8, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x43, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF8, 0x07,
  0xE0, 0xF0, 0x1F, 0x01, 0xE0, 0x7C, 0x03, 0x81, 0xF0, 0x0F, 0x03, 0xC0,
  0x1E, 0x0F, 0x00, 0x3C, 0x1E, 0x00, 0x70, 0x78, 0x01, 0xE0, 0xF0, 0x03,
  0xC1, 0xE0, 0x07, 0x83, 0xC0, 0x0E, 0x07, 0x80, 0x3C, 0x0F, 0x00, 0x78,
  0x1E, 0x01, 0xF0, 0x3E, 0x0F, 0xC0, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x00,
  0x1F, 0x9E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x80, 0x1F, 0x01, 0xC0, 0x7C, 0x07, 0xFF, 0xF0, 0x0F, 0xFF,
  0xC0, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0xBF, 0x00, 0x7F, 0xFC, 0x07,
  0xFF, 0xE0, 0xF8, 0x3E, 0x0F, 0x01, 0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0xF1,
  0xE0, 0x0F, 0x1E, 0x00, 0xF1, 0xE0, 0x0F, 0x1E, 0x00, 0xE1, 0xC0, 0x1E,
  0x3C, 0x01, 0xE3, 0xC0, 0x1E, 0x3C, 0x01, 0xC3, 0x80, 0x3C, 0x78, 0x03,
  0xC7, 0x80, 0x3C, 0x78, 0x03, 0x87, 0x00, 0x78, 0xF0, 0x07, 0x8F, 0x00,
  0x78, 0x00, 0xE0, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x87, 0xFC, 0x3F, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF8,
  0x03, 0xFF, 0x07, 0xF8, 0x07, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x0F, 0xFF,
  0x80, 0x3F, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x01, 0x00, 0x78, 0x07, 0x07, 0xC0, 0x3F, 0xFE, 0x00, 0xFF, 0xF0, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x1F,
  0x07, 0x00, 0xF0, 0x3C, 0x0F, 0x80, 0xF0, 0x7C, 0x03, 0x87, 0xE0, 0x0E,
  0x3F, 0x00, 0x7B, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xC0,
  0x00, 0xFF, 0x80, 0x03, 0xDF, 0x00, 0x0F, 0x3E, 0x00, 0x3C, 0x7C, 0x01,
  0xE0, 0xF8, 0x07, 0x81, 0xE0, 0x1E, 0x07, 0xC0, 0x78, 0x0F, 0x03, 0xC0,
  0x1E, 0x0F, 0x00, 0x78, 0x3C, 0x00, 0xF0, 0x7F, 0xE7, 0xFE, 0xFF, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x78, 0x07,
  0x80, 0x78, 0x07, 0xC1, 0x3F, 0xF3, 0xFF, 0x0F, 0xE0, 0x01, 0xF8, 0xF8,
  0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x38, 0x78, 0xF0, 0x70, 0xE1, 0xE1,
  0xE1, 0xC3, 0xC3, 0xC3, 0x87, 0x87, 0x0F, 0x0E, 0x0E, 0x1E, 0x1C, 0x3C,
  0x38, 0x78, 0x78, 0x70, 0xF0, 0xE1, 0xE1, 0xE1, 0xC3, 0xC3, 0x87, 0x87,
  0x87, 0x0F, 0x00, 0x1E, 0x1C, 0x00, 0x3C, 0x38, 0x00, 0x70, 0xF0, 0x00,
  0xE1, 0xE0, 0x03, 0xC3, 0x80, 0x07, 0x87, 0x00, 0x0E, 0x0E, 0x00, 0x1C,
  0x00, 0x00, 0xFF, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0xF0, 0x3E, 0x0F,
  0x01, 0xE0, 0xF0, 0x0F, 0x0E, 0x00, 0xF1, 0xE0, 0x0F, 0x1E, 0x00, 0xF1,
  0xE0, 0x0E, 0x1C, 0x01, 0xE3, 0xC0, 0x1E, 0x3C, 0x01, 0xE3, 0xC0, 0x1C,
  0x38, 0x03, 0xC7, 0x80, 0x3C, 0x78, 0x03, 0xC7, 0x80, 0x3C, 0x70, 0x07,
  0x8F, 0x00, 0x78, 0xF0, 0x07, 0x8F, 0x00, 0x78, 0x00, 0x7E, 0x00, 0x7F,
  0xF0, 0x1F, 0xFF, 0x07, 0xC1, 0xE1, 0xF0, 0x1E, 0x7C, 0x03, 0xCF, 0x00,
  0x7B, 0xC0, 0x0F, 0x78, 0x01, 0xEE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xBC, 0x00, 0xF7, 0x80, 0x1E, 0xF0, 0x07,
  0x9E, 0x01, 0xF3, 0xC0, 0x7C, 0x3C, 0x1F, 0x07, 0xFF, 0xC0, 0x7F, 0xF0,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x80,
  0xF0, 0x3E, 0x03, 0xC0, 0x7C, 0x0E, 0x00, 0xF0, 0x78, 0x03, 0xC1, 0xE0,
  0x0F, 0x07, 0x80, 0x3C, 0x1C, 0x00, 0xF0, 0xF0, 0x03, 0xC3, 0xC0, 0x0F,
  0x0F, 0x00, 0x3C, 0x3C, 0x01, 0xE1, 0xE0, 0x07, 0x87, 0x80, 0x3E, 0x1E,
  0x00, 0xF0, 0x78, 0x07, 0x81, 0xC0, 0x7E, 0x0F, 0x07, 0xF0, 0x3F, 0xFF,
  0x00, 0xFF, 0xF8, 0x03, 0xFF, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0x03, 0xFF, 0xF0, 0x7E, 0x0F,
  0x0F, 0x81, 0xE1, 0xE0, 0x1E, 0x3C, 0x01, 0xE7, 0xC0, 0x1E, 0x78, 0x01,
  0xC7, 0x80, 0x3C, 0xF0, 0x03, 0xCF, 0x00, 0x3C, 0xF0, 0x03, 0x8F, 0x00,
  0x78, 0xF0, 0x07, 0x8F, 0x00, 0x78, 0xF0, 0x07, 0x0F, 0x00, 0xF0, 0xF0,
  0x0F, 0x07, 0x83, 0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x0F, 0xDE, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x7F, 0xF0, 0x7F, 0xFF, 0x07, 0xFF,
  0xE0, 0xF8, 0x02, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x3F, 0xFC, 0x1F, 0xFF, 0x03, 0xC0, 0x60, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x07, 0x00, 0x01, 0xE1, 0x00, 0x3C, 0x78, 0x1F, 0x0F,
  0xFF, 0xE1, 0xFF, 0xF0, 0x07, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x78, 0x00,
  0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x01, 0xFF,
  0xFE, 0x7F, 0xFF, 0xBF, 0xFF, 0xE0, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x81, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x07, 0xF0,
  0x00, 0x1E, 0x00, 0xF1, 0xE0, 0x0E, 0x3C, 0x01, 0xE3, 0xC0, 0x1E, 0x3C,
  0x01, 0xE3, 0xC0, 0x1C, 0x38, 0x03, 0xC7, 0x80, 0x3C, 0x78, 0x03, 0xC7,
  0x80, 0x3C, 0x70, 0x07, 0x8F, 0x00, 0x78, 0xF0, 0x07, 0x8F, 0x00, 0x78,
  0xF0, 0x07, 0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x0F, 0x01, 0xF0, 0xF8, 0x3F,
  0x07, 0xFF, 0xF0, 0x3F, 0xF7, 0x01, 0xFC, 0x78, 0xF0, 0x01, 0xDE, 0x00,
  0x7B, 0xC0, 0x0F, 0x78, 0x03, 0xCF, 0x00, 0x79, 0xE0, 0x1E, 0x1C, 0x03,
  0xC3, 0x80, 0xF0, 0x78, 0x1E, 0x0F, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x3C,
  0x07, 0x87, 0x00, 0xF1, 0xE0, 0x0E, 0x78, 0x01, 0xCF, 0x00, 0x3F, 0xC0,
  0x07, 0xF0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1C, 0xF0, 0x00, 0x39, 0xE0, 0x00, 0xF3, 0x80, 0x01, 0xC7, 0x00, 0x03,
  0x8E, 0x0E, 0x0F, 0x1C, 0x1C, 0x1C, 0x78, 0x78, 0x38, 0xF0, 0xF0, 0xE1,
  0xE3, 0xE1, 0xC3, 0x8E, 0xE7, 0x87, 0x1D, 0xCE, 0x0E, 0x73, 0x9C, 0x1C,
  0xE7, 0x70, 0x3B, 0x8E, 0xE0, 0x7E, 0x1F, 0xC0, 0xFC, 0x3F, 0x01, 0xF0,
  0x7E, 0x03, 0xE0, 0x78, 0x07, 0x80, 0xF0, 0x0E, 0x01, 0xC0, 0x00, 0x03,
  0xC0, 0x1E, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x7C, 0x01, 0xE0, 0x78, 0x00,
  0xF0, 0xF0, 0x00, 0xF1, 0xE0, 0x00, 0x7B, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0xFF, 0x00, 0x01, 0xF7, 0x80, 0x03, 0xE7, 0x80, 0x07, 0xC7, 0x80, 0x0F,
  0x83, 0xC0, 0x1F, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x7C, 0x01, 0xE0, 0xF8,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x78, 0x01, 0xE0, 0x1E, 0x00, 0x78,
  0x03, 0x80, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x3C, 0x03, 0xC0, 0x0F, 0x00,
  0xE0, 0x03, 0xC0, 0x78, 0x00, 0xF0, 0x1E, 0x00, 0x3C, 0x0F, 0x00, 0x07,
  0x03, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x1E, 0x1C, 0x00,
  0x07, 0x8F, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x3D, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x10,
  0x7C, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0xC0, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x80,
  0x38, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1E,
  0x00, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1C, 0x00, 0x01, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xC0, 0x30, 0xFF, 0x03, 0xCF, 0xFE, 0x3C, 0xF1,
  0xFF, 0xC7, 0x03, 0xFC, 0x30, 0x07, 0xC0,
};

const GFXglyph UbuntuMono_Italic46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 23, 0, -1 },
  { 1, 11, 28, 23, 8, -28 },
  { 40, 13, 11, 23, 10, -29 },
  { 58, 24, 28, 23, 2, -28 },
  { 142, 22, 36, 23, 3, -32 },
  { 241, 28, 28, 23, 0, -28 },
  { 339, 20, 28, 23, 3, -28 },
  { 409, 6, 12, 23, 14, -31 },
  { 418, 17, 40, 23, 7, -32 },
  { 503, 17, 40, 23, 3, -32 },
  { 588, 18, 17, 23, 6, -28 },
  { 627, 19, 19, 23, 4, -22 },
  { 673, 10, 12, 23, 5, -6 },
  { 688, 11, 4, 23, 8, -14 },
  { 694, 7, 6, 23, 8, -6 },
  { 700, 26, 40, 23, -1, -32 },
  { 830, 20, 28, 23, 4, -28 },
  { 900, 17, 28, 23, 4, -28 },
  { 960, 21, 28, 23, 3, -28 },
  { 1034, 21, 28, 23, 3, -28 },
  { 1108, 22, 28, 23, 2, -28 },
  { 1185, 22, 28, 23, 3, -28 },
  { 1262, 21, 28, 23, 4, -28 },
  { 1336, 21, 28, 23, 6, -28 },
  { 1410, 21, 28, 23, 4, -28 },
  { 1484, 22, 28, 23, 3, -28 },
  { 1561, 10, 21, 23, 8, -21 },
  { 1588, 13, 27, 23, 5, -21 },
  { 1632, 20, 18, 23, 4, -21 },
  { 1677, 21, 11, 23, 3, -17 },
  { 1706, 20, 18, 23, 3, -21 },
  { 1751, 17, 28, 23, 7, -28 },
  { 1811, 23, 35, 23, 3, -29 },
  { 1912, 23, 28, 23, -1, -28 },
  { 1993, 22, 28, 23, 2, -28 },
  { 2070, 22, 28, 23, 4, -28 },
  { 2147, 22, 28, 23, 2, -28 },
  { 2224, 23, 28, 23, 3, -28 },
  { 2305, 23, 28, 23, 3, -28 },
  { 2386, 22, 28, 23, 4, -28 },
  { 2463, 25, 28, 23, 2, -28 },
  { 2551, 22, 28, 23, 3, -28 },
  { 2628, 22, 28, 23, 3, -28 },
  { 2705, 25, 28, 23, 2, -28 },
  { 2793, 17, 28, 23, 2, -28 },
  { 2853, 25, 28, 23, 1, -28 },
  { 2941, 25, 28, 23, 2, -28 },
  { 3029, 21, 28, 23, 4, -28 },
  { 3103, 23, 28, 23, 2, -28 },
  { 3184, 21, 36, 23, 4, -28 },
  { 3279, 22, 28, 23, 2, -28 },
  { 3356, 23, 28, 23, 2, -28 },
  { 3437, 20, 28, 23, 7, -28 },
  { 3507, 23, 28, 23, 4, -28 },
  { 3588, 22, 28, 23, 6, -28 },
  { 3665, 25, 28, 23, 3, -28 },
  { 3753, 28, 28, 23, 0, -28 },
  { 3851, 22, 28, 23, 7, -28 },
  { 3928, 24, 28, 23, 2, -28 },
  { 4012, 20, 40, 23, 5, -32 },
  { 4112, 7, 40, 23, 10, -32 },
  { 4147, 21, 40, 23, 1, -32 },
  { 4252, 19, 15, 23, 5, -28 },
  { 4288, 21, 3, 23, -1, 4 },
  { 4296, 8, 8, 23, 12, -31 },
  { 4304, 21, 23, 23, 3, -22 },
  { 4365, 20, 33, 23, 3, -32 },
  { 4448, 21, 23, 23, 3, -22 },
  { 4509, 23, 33, 23, 4, -32 },
  { 4604, 20, 23, 23, 3, -22 },
  { 4662, 28, 40, 23, 0, -32 },
  { 4802, 23, 30, 23, 1, -22 },
  { 4889, 20, 32, 23, 2, -32 },
  { 4969, 14, 30, 23, 6, -30 },
  { 5022, 22, 38, 23, 1, -30 },
  { 5127, 22, 32, 23, 3, -32 },
  { 5215, 12, 33, 23, 8, -32 },
  { 5265, 23, 22, 23, 1, -22 },
  { 5329, 20, 22, 23, 3, -22 },
  { 5384, 19, 23, 23, 4, -22 },
  { 5439, 22, 30, 23, 1, -22 },
  { 5522, 20, 30, 23, 4, -22 },
  { 5597, 20, 22, 23, 4, -22 },
  { 5652, 19, 23, 23, 4, -22 },
  { 5707, 18, 29, 23, 6, -28 },
  { 5773, 20, 22, 23, 4, -21 },
  { 5828, 19, 21, 23, 6, -21 },
  { 5878, 23, 21, 23, 4, -21 },
  { 5939, 24, 21, 23, 1, -21 },
  { 6002, 26, 29, 23, -1, -21 },
  { 6097, 20, 21, 23, 3, -21 },
  { 6150, 22, 40, 23, 4, -32 },
  { 6260, 13, 40, 23, 7, -32 },
  { 6325, 22, 40, 23, 0, -32 },
  { 6435, 21, 6, 23, 3, -15 },
};

const GFXfont UbuntuMono_Italic46pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Italic46pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Italic46pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _UBUNTUMONO_ITALIC46PT7B_H_
