#ifndef _UBUNTUMONO_ITALIC49PT7B_H_
#define _UBUNTUMONO_ITALIC49PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Italic.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Italic49pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xE0,
  0x3C, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x07, 0x00,
  0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x7E, 0x07, 0xE0, 0xFE, 0x07, 0xE0, 0x7C, 0x03, 0x80, 0x3C, 0x3C,
  0xE0, 0xE7, 0x87, 0x9E, 0x1E, 0x78, 0x79, 0xC1, 0xC7, 0x07, 0x3C, 0x3C,
  0xE0, 0xE3, 0x83, 0x8C, 0x0E, 0x30, 0x30, 0x00, 0x07, 0x83, 0xC0, 0x03,
  0xC0, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x38, 0x1C, 0x00, 0x1E, 0x0F, 0x00,
  0x07, 0x03, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0x78, 0x0F, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x03, 0xC1, 0xE0, 0x00, 0xE0,
  0x70, 0x00, 0x78, 0x3C, 0x00, 0x1C, 0x0F, 0x00, 0x0F, 0x07, 0x80, 0x03,
  0xC1, 0xE0, 0x01, 0xE0, 0x70, 0x00, 0x78, 0x3C, 0x01, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x01, 0xE0, 0xF0, 0x00, 0x70, 0x3C,
  0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0x07, 0x81, 0xC0, 0x01, 0xE0,
  0xF0, 0x00, 0x70, 0x38, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x01, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x07,
  0xE0, 0x38, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0xC1, 0x00, 0x0F, 0x03, 0x80, 0x7E, 0x0F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x38, 0x03, 0xF8, 0x01, 0xC0, 0x1F, 0xF0,
  0x0E, 0x00, 0xFF, 0xC0, 0x78, 0x03, 0xCF, 0x03, 0xC0, 0x0E, 0x1C, 0x1E,
  0x00, 0x70, 0x70, 0xF0, 0x01, 0xC1, 0xC3, 0x80, 0x07, 0x0F, 0x1C, 0x00,
  0x1C, 0x38, 0xE0, 0x00, 0x71, 0xE7, 0x80, 0x01, 0xFF, 0x3C, 0x00, 0x07,
  0xFD, 0xE0, 0x00, 0x0F, 0xEF, 0x00, 0x00, 0x1E, 0x38, 0x00, 0x00, 0x01,
  0xCF, 0x80, 0x00, 0x0E, 0x7F, 0x00, 0x00, 0x7B, 0xFE, 0x00, 0x03, 0xDF,
  0xF8, 0x00, 0x1E, 0x79, 0xE0, 0x00, 0xF1, 0xC3, 0x80, 0x03, 0x8E, 0x0E,
  0x00, 0x1C, 0x38, 0x38, 0x00, 0xE0, 0xE1, 0xE0, 0x07, 0x83, 0x87, 0x00,
  0x3C, 0x0E, 0x3C, 0x01, 0xE0, 0x3F, 0xE0, 0x0F, 0x00, 0xFF, 0x80, 0x38,
  0x01, 0xFC, 0x01, 0xC0, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xFF,
  0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0x1F, 0x01, 0xE0, 0x78, 0x0F,
  0x03, 0xC0, 0xF0, 0x1C, 0x07, 0x81, 0xE0, 0x3C, 0x1E, 0x00, 0xE1, 0xE0,
  0x07, 0x9E, 0x00, 0x3F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC1, 0xE1, 0xFE,
  0x0F, 0x1F, 0x78, 0x71, 0xE3, 0xE7, 0x9E, 0x0F, 0xB8, 0xF0, 0x3F, 0xCF,
  0x01, 0xFC, 0x78, 0x07, 0xE3, 0xC0, 0x1E, 0x1E, 0x00, 0xF0, 0xF0, 0x1F,
  0xC7, 0xC1, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xF3, 0xC3, 0xFE, 0x1E, 0x0F,
  0xC0, 0xF0, 0x3C, 0xF7, 0xDE, 0x79, 0xE7, 0x3C, 0xF3, 0x8E, 0x38, 0xC0,
  0x00, 0x00, 0x80, 0x00, 0x38, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x0E, 0x00, 0x07, 0xC0, 0x00,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F,
  0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0x70, 0x00,
  0x10, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x04, 0x0E, 0x0C, 0xE1, 0xC7, 0xBF, 0xBB, 0xF7, 0xFF, 0xFE, 0x7F, 0xFF,
  0x80, 0x3C, 0x00, 0x0F, 0xC0, 0x03, 0xFC, 0x00, 0xFB, 0xC0, 0x1E, 0x7C,
  0x07, 0xC7, 0xC1, 0xF0, 0xF8, 0x1E, 0x0E, 0x00, 0x80, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x03, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFD, 0xFF, 0xFF, 0xE0, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x81, 0xF8, 0x3F, 0x87, 0xF0,
  0xFE, 0x1F, 0xC1, 0xF0, 0x1E, 0x07, 0xC1, 0xF0, 0xFC, 0x7F, 0x0F, 0x81,
  0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x79, 0xFB, 0xFF, 0xFF,
  0xFF, 0x9E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0x80,
  0x0F, 0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xF0, 0xF8, 0x1F, 0x01, 0xE0, 0xF8,
  0x07, 0xC3, 0xC0, 0x1F, 0x1F, 0x00, 0x3C, 0x78, 0x00, 0xF3, 0xE0, 0x03,
  0xCF, 0x1E, 0x1E, 0x3C, 0xFC, 0x79, 0xE3, 0xF1, 0xE7, 0x8F, 0xC7, 0x9E,
  0x3F, 0x1E, 0x78, 0x70, 0xF3, 0xC0, 0x03, 0xCF, 0x00, 0x0F, 0x3C, 0x00,
  0x78, 0xF0, 0x01, 0xE3, 0xC0, 0x0F, 0x8F, 0x00, 0x7C, 0x3E, 0x01, 0xE0,
  0xF8, 0x0F, 0x81, 0xF0, 0xFC, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x07, 0xE0,
  0x07, 0xF0, 0x0F, 0xF0, 0x3F, 0xF8, 0x3F, 0xBC, 0x1F, 0x1E, 0x0C, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0,
  0x00, 0x78, 0x1F, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x3E, 0x07, 0xC0,
  0x30, 0x07, 0xC0, 0x40, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x01,
  0xE0, 0xFC, 0x02, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x7F, 0xC0,
  0x01, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x40, 0x03, 0xE1, 0xC0, 0x7F, 0x8F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0x7F, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0xF7, 0x80, 0x03, 0xCE, 0x00, 0x0F, 0x3C, 0x00, 0x3C,
  0x78, 0x00, 0xF0, 0xF0, 0x03, 0xC1, 0xC0, 0x0F, 0x07, 0x80, 0x3C, 0x0F,
  0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x01, 0xE0,
  0x78, 0x03, 0xC0, 0xF0, 0x07, 0x83, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFE, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x40, 0x07, 0xE0, 0x70, 0x1F, 0xC0, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0xFF, 0x00, 0x07, 0xE0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x3F, 0x80, 0x3F, 0xFF, 0x81, 0xFF, 0xFF, 0x07, 0xFF,
  0xFC, 0x3F, 0x81, 0xF8, 0xF0, 0x01, 0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x1E,
  0x3C, 0x00, 0x78, 0xF0, 0x01, 0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x3E, 0x3C,
  0x00, 0xF0, 0xF8, 0x07, 0xC3, 0xF0, 0x7E, 0x07, 0xFF, 0xF0, 0x1F, 0xFF,
  0x80, 0x1F, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xC0,
  0x1F, 0xFF, 0x80, 0xFF, 0xFF, 0x03, 0xF0, 0x7C, 0x1F, 0x00, 0xF0, 0x78,
  0x03, 0xC3, 0xC0, 0x0F, 0x0F, 0x00, 0x3C, 0x3C, 0x00, 0xF0, 0xF0, 0x07,
  0x83, 0xE0, 0x3C, 0x07, 0xE3, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0xE0, 0x0F, 0xBF, 0xC0, 0x78, 0x1F, 0x83, 0xC0, 0x3E, 0x1E, 0x00,
  0x78, 0xF0, 0x01, 0xF3, 0xC0, 0x07, 0x8F, 0x00, 0x1E, 0x3C, 0x00, 0x78,
  0xF0, 0x03, 0xE3, 0xF0, 0x3F, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x3F,
  0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0x80, 0x1F,
  0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xE0, 0xFC, 0x3E, 0x01, 0xF0, 0xF0, 0x03,
  0xC7, 0xC0, 0x0F, 0x1E, 0x00, 0x3C, 0x78, 0x00, 0xF1, 0xE0, 0x03, 0xC7,
  0x80, 0x0F, 0x1E, 0x00, 0x3C, 0x78, 0x01, 0xF1, 0xF0, 0x1F, 0x87, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x1F, 0xCF, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00,
  0x7F, 0x00, 0x0F, 0xF8, 0x0F, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0xFF, 0x80,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0x81, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x1F,
  0x81, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x1F, 0x83, 0xF8, 0x7F, 0x0F, 0xE1, 0xF8, 0x1E, 0x00,
  0x00, 0x78, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0x80,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x1F, 0x80, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x1F,
  0x00, 0xFC, 0x07, 0xF0, 0x0F, 0x80, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x01, 0xC0, 0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xF0, 0x00, 0x3E,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0x00, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0x80, 0x04, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0x80, 0x07, 0xFE, 0x00, 0x7F,
  0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x03,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0xFC, 0x07, 0xFF,
  0x87, 0xFF, 0xE1, 0xFF, 0xF0, 0x80, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x7C,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xFE,
  0x01, 0xFC, 0x1F, 0x03, 0xF0, 0x0F, 0x03, 0xE0, 0x0F, 0x07, 0xC0, 0x07,
  0x0F, 0x80, 0x07, 0x0F, 0x00, 0x07, 0x1F, 0x00, 0x0F, 0x1E, 0x01, 0xFF,
  0x3E, 0x07, 0xFF, 0x3C, 0x1F, 0xFF, 0x3C, 0x3F, 0xFE, 0x3C, 0x3E, 0x1E,
  0x78, 0x7C, 0x1E, 0x78, 0x78, 0x1E, 0x78, 0xF0, 0x1C, 0x78, 0xF0, 0x3C,
  0x70, 0xF0, 0x3C, 0xF0, 0xF0, 0x3C, 0xF0, 0xF0, 0x78, 0xF0, 0xF0, 0x78,
  0xF0, 0xF8, 0x78, 0xF0, 0xFF, 0xF8, 0xF0, 0x7F, 0xF0, 0x78, 0x3F, 0xF0,
  0x78, 0x0F, 0xE0, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xDC, 0x00, 0x03, 0x9E,
  0x00, 0x07, 0x9E, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x1E, 0x00, 0x1E, 0x1E,
  0x00, 0x1C, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x38, 0x1E, 0x00, 0x78, 0x1E,
  0x00, 0xF0, 0x0E, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x0E, 0x01, 0xE0, 0x0E,
  0x03, 0xC0, 0x0F, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0x0F, 0x00, 0x0F, 0x0E, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x1E, 0x00, 0x0F,
  0x3C, 0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x0F,
  0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE,
  0x03, 0xC0, 0x7F, 0x03, 0xC0, 0x1F, 0x03, 0xC0, 0x0F, 0x07, 0xC0, 0x0E,
  0x07, 0x80, 0x1E, 0x07, 0x80, 0x1E, 0x07, 0x80, 0x3C, 0x07, 0x00, 0xF8,
  0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x0E, 0x01, 0xF8,
  0x1E, 0x00, 0x78, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x1C, 0x00, 0x3C,
  0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x7C, 0x3C, 0x00, 0x78, 0x38, 0x00, 0xF8,
  0x78, 0x01, 0xF8, 0x78, 0x0F, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0,
  0x7F, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xFE,
  0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xF8, 0x1E, 0x07, 0xE0, 0x02,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x40, 0x3F, 0x03, 0xC0,
  0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFC,
  0x03, 0xC0, 0xFC, 0x03, 0xC0, 0x7E, 0x07, 0x80, 0x3E, 0x07, 0x80, 0x1E,
  0x07, 0x80, 0x1E, 0x07, 0x80, 0x1F, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x0F,
  0x0F, 0x00, 0x1F, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1E,
  0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x3E, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C,
  0x3C, 0x00, 0x7C, 0x3C, 0x00, 0xF8, 0x78, 0x01, 0xF0, 0x78, 0x03, 0xF0,
  0x78, 0x07, 0xE0, 0x78, 0x3F, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00,
  0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xC0, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xC0, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF0, 0x3F, 0x81, 0xC0, 0xFC, 0x00, 0x83, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x78,
  0xF0, 0x00, 0xF1, 0xE0, 0x01, 0xE3, 0xC0, 0x03, 0xC7, 0x80, 0x0F, 0x0F,
  0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x3E, 0x00, 0xF8, 0x7C, 0x01, 0xE0, 0x7C,
  0x03, 0xC0, 0xFC, 0x0F, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0xFF,
  0xF8, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x78, 0x00, 0xF0,
  0x3C, 0x00, 0x3C, 0x0F, 0x00, 0x1E, 0x03, 0xC0, 0x07, 0x80, 0xF0, 0x01,
  0xE0, 0x7C, 0x00, 0x78, 0x1E, 0x00, 0x3C, 0x07, 0x80, 0x0F, 0x01, 0xE0,
  0x03, 0xC0, 0xF8, 0x00, 0xF0, 0x3C, 0x00, 0x38, 0x0F, 0x00, 0x1E, 0x03,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1E, 0x00, 0x3C,
  0x07, 0x80, 0x0F, 0x01, 0xE0, 0x03, 0xC0, 0xF0, 0x01, 0xF0, 0x3C, 0x00,
  0x78, 0x0F, 0x00, 0x1E, 0x03, 0xC0, 0x07, 0x81, 0xE0, 0x01, 0xE0, 0x78,
  0x00, 0xF0, 0x1E, 0x00, 0x3C, 0x07, 0x80, 0x0F, 0x03, 0xC0, 0x03, 0xC0,
  0xF0, 0x01, 0xE0, 0x3C, 0x00, 0x78, 0x00, 0x00, 0xFF, 0xFE, 0x01, 0xFF,
  0xFE, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x7F, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x20, 0x07,
  0xC0, 0x30, 0x0F, 0xC0, 0x7C, 0x1F, 0x80, 0xFF, 0xFF, 0x00, 0x7F, 0xFE,
  0x00, 0x3F, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xE0, 0x07, 0xC0, 0x3C,
  0x01, 0xF0, 0x07, 0x80, 0x7C, 0x00, 0xF0, 0x0F, 0x00, 0x3C, 0x03, 0xC0,
  0x07, 0x80, 0xF0, 0x00, 0xF0, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x87,
  0xC0, 0x00, 0xF1, 0xF0, 0x00, 0x1E, 0x7C, 0x00, 0x03, 0xDF, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0x7C, 0x00, 0x03, 0xCF, 0x80, 0x00, 0x78, 0xF8, 0x00, 0x0F,
  0x0F, 0x80, 0x03, 0xE0, 0xF0, 0x00, 0x78, 0x1F, 0x00, 0x0F, 0x01, 0xE0,
  0x01, 0xE0, 0x1E, 0x00, 0x3C, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xE0,
  0x07, 0x80, 0x3C, 0x00, 0x78, 0x07, 0x80, 0x0F, 0x01, 0xE0, 0x01, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F,
  0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xE0, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x0F, 0xC0, 0x7F, 0x03, 0xF0, 0x1D, 0xC1, 0xFC, 0x07, 0x70, 0xEE, 0x03,
  0x9C, 0x3B, 0x80, 0xE7, 0x1C, 0xE0, 0x39, 0xC7, 0x38, 0x1E, 0x73, 0x9E,
  0x07, 0x1C, 0xE7, 0x81, 0xC7, 0x71, 0xC0, 0xF1, 0xDC, 0x70, 0x3C, 0x7E,
  0x1C, 0x0E, 0x1F, 0x0F, 0x07, 0x87, 0xC3, 0xC1, 0xE0, 0xE0, 0xF0, 0x78,
  0x00, 0x38, 0x1C, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xE0,
  0xE0, 0x00, 0x78, 0x78, 0x00, 0x1C, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0x03,
  0xC1, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x01, 0xC0, 0x7C, 0x00, 0xF0, 0x1F, 0x00, 0x3C, 0x0F, 0xC0, 0x0F,
  0x03, 0xF8, 0x03, 0x80, 0xFE, 0x01, 0xE0, 0x3B, 0x80, 0x78, 0x1E, 0xE0,
  0x1E, 0x07, 0xBC, 0x07, 0x01, 0xE7, 0x03, 0xC0, 0x71, 0xC0, 0xF0, 0x3C,
  0x78, 0x3C, 0x0F, 0x1E, 0x0E, 0x03, 0xC3, 0x87, 0x80, 0xE0, 0xE1, 0xE0,
  0x78, 0x3C, 0x78, 0x1E, 0x0F, 0x1C, 0x07, 0x81, 0xCF, 0x01, 0xC0, 0x73,
  0xC0, 0x70, 0x1C, 0xF0, 0x3C, 0x07, 0xB8, 0x0F, 0x00, 0xEE, 0x03, 0x80,
  0x3F, 0x80, 0xE0, 0x0F, 0xE0, 0x78, 0x03, 0xF0, 0x1E, 0x00, 0xFC, 0x07,
  0x80, 0x3F, 0x01, 0xC0, 0x07, 0xC0, 0xF0, 0x01, 0xE0, 0x3C, 0x00, 0x78,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x1F, 0xFF,
  0xC0, 0x7F, 0x0F, 0xC0, 0xF8, 0x0F, 0x83, 0xE0, 0x0F, 0x0F, 0x80, 0x1E,
  0x1E, 0x00, 0x3C, 0x7C, 0x00, 0x7C, 0xF0, 0x00, 0xF1, 0xE0, 0x01, 0xE7,
  0x80, 0x03, 0xCF, 0x00, 0x07, 0x9E, 0x00, 0x0F, 0x7C, 0x00, 0x1E, 0xF0,
  0x00, 0x79, 0xE0, 0x00, 0xF3, 0xC0, 0x01, 0xE7, 0x80, 0x07, 0x8F, 0x00,
  0x0F, 0x1E, 0x00, 0x3E, 0x3C, 0x00, 0xF8, 0x78, 0x01, 0xE0, 0xF8, 0x07,
  0xC0, 0xF8, 0x3F, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0x80,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x03, 0xFF,
  0xFC, 0x03, 0xFF, 0xFE, 0x03, 0xC0, 0x7E, 0x03, 0xC0, 0x3E, 0x07, 0xC0,
  0x1E, 0x07, 0x80, 0x1F, 0x07, 0x80, 0x1E, 0x07, 0x80, 0x1E, 0x0F, 0x80,
  0x1E, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x3C, 0x0F, 0x00, 0x3C, 0x1F, 0x00,
  0xF8, 0x1E, 0x03, 0xF0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x3F, 0xFC,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x7F, 0x0F,
  0xC0, 0xF8, 0x0F, 0x83, 0xE0, 0x0F, 0x0F, 0x80, 0x1E, 0x1E, 0x00, 0x3C,
  0x7C, 0x00, 0x7C, 0xF0, 0x00, 0xF1, 0xE0, 0x01, 0xE7, 0x80, 0x03, 0xCF,
  0x00, 0x07, 0x9E, 0x00, 0x0F, 0x3C, 0x00, 0x1E, 0xF0, 0x00, 0x79, 0xE0,
  0x00, 0xF3, 0xC0, 0x01, 0xE7, 0x80, 0x07, 0x8F, 0x00, 0x0F, 0x1E, 0x00,
  0x3E, 0x3C, 0x00, 0xF8, 0x78, 0x01, 0xF0, 0xF8, 0x07, 0xC0, 0xF8, 0x3F,
  0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0xFE, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFE,
  0x03, 0xE0, 0x7E, 0x03, 0xC0, 0x1F, 0x03, 0xC0, 0x0F, 0x03, 0xC0, 0x0F,
  0x07, 0xC0, 0x0F, 0x07, 0x80, 0x0F, 0x07, 0x80, 0x0E, 0x07, 0x80, 0x1E,
  0x0F, 0x80, 0x3C, 0x0F, 0x00, 0x7C, 0x0F, 0x01, 0xF8, 0x0F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x1F, 0x0F, 0x00, 0x1E, 0x07, 0x80,
  0x3E, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x01, 0xE0, 0x78, 0x01, 0xE0, 0x78, 0x01, 0xE0, 0x78, 0x01, 0xF0,
  0x78, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xFE,
  0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xF0, 0x1E, 0x03, 0xC0, 0x04,
  0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x40, 0x03, 0xE0, 0x78, 0x0F, 0xE0,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x80, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x0F, 0x07, 0x80, 0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x1E, 0x0F,
  0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x1E,
  0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x7C, 0x3C, 0x00, 0x78, 0x3C,
  0x00, 0x78, 0x3C, 0x00, 0x78, 0x78, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0x78,
  0x00, 0xF0, 0xF8, 0x00, 0xF0, 0xF0, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0xF0,
  0x01, 0xE0, 0xF0, 0x03, 0xE0, 0xF0, 0x03, 0xC0, 0xF0, 0x07, 0xC0, 0xF8,
  0x07, 0x80, 0x7C, 0x1F, 0x80, 0x7F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x1F,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7B, 0xC0,
  0x01, 0xF7, 0x80, 0x03, 0xCF, 0x00, 0x07, 0x9E, 0x00, 0x1E, 0x3C, 0x00,
  0x3C, 0x78, 0x00, 0xF0, 0xF0, 0x01, 0xE1, 0xE0, 0x07, 0x83, 0xC0, 0x0F,
  0x07, 0x80, 0x3C, 0x0F, 0x00, 0xF8, 0x1E, 0x01, 0xE0, 0x3C, 0x07, 0xC0,
  0x78, 0x0F, 0x00, 0xF0, 0x3C, 0x01, 0xE0, 0x78, 0x01, 0xC1, 0xE0, 0x03,
  0x83, 0xC0, 0x07, 0x8F, 0x00, 0x0F, 0x1E, 0x00, 0x1E, 0x78, 0x00, 0x3C,
  0xE0, 0x00, 0x7B, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x03, 0xC1,
  0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x0E, 0x0F, 0x00, 0x07,
  0x83, 0xC0, 0x01, 0xE0, 0xE0, 0x00, 0x78, 0x38, 0x00, 0x1C, 0x1E, 0x00,
  0x0F, 0x07, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0xE0, 0x70, 0x78, 0x78, 0x1C,
  0x3E, 0x1E, 0x0F, 0x0F, 0x87, 0x03, 0xC7, 0xE1, 0xC0, 0xE1, 0xF8, 0xF0,
  0x38, 0xEE, 0x38, 0x0E, 0x73, 0x8E, 0x07, 0x9C, 0xE3, 0x81, 0xCE, 0x39,
  0xC0, 0x73, 0x8E, 0x70, 0x1D, 0xC1, 0x9C, 0x07, 0x70, 0x6E, 0x01, 0xF8,
  0x1B, 0x80, 0x6E, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0xC0, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x0F, 0x00,
  0xF8, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x78, 0x1E, 0x00, 0x01, 0xE0, 0xF8,
  0x00, 0x07, 0xC7, 0xC0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x3C, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x1F, 0x3C,
  0x00, 0x00, 0xF8, 0xF0, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x1E, 0x07, 0x80,
  0x00, 0xF8, 0x1E, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x3E, 0x00, 0xF0, 0x01,
  0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x3C, 0x00, 0x1E, 0x01, 0xF0,
  0x00, 0x78, 0x00, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7D, 0xE0, 0x01, 0xF3,
  0xC0, 0x03, 0xC7, 0x80, 0x0F, 0x8F, 0x00, 0x3E, 0x1E, 0x00, 0x78, 0x1E,
  0x01, 0xE0, 0x3C, 0x07, 0xC0, 0x78, 0x0F, 0x00, 0xF0, 0x3C, 0x00, 0xF0,
  0xF0, 0x01, 0xE3, 0xE0, 0x03, 0xC7, 0x80, 0x03, 0xDE, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x00, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1,
  0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x8F,
  0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF8, 0xF1,
  0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0x78, 0x01, 0xE3, 0xC0, 0x3C, 0x3C, 0x07, 0xC3, 0xC0,
  0xF8, 0x1E, 0x1F, 0x01, 0xE1, 0xE0, 0x1E, 0x3C, 0x00, 0xF7, 0x80, 0x0F,
  0x78, 0x00, 0xF3, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x20, 0x70, 0xF8, 0x7C, 0x3C, 0x1E, 0x0F, 0x07, 0x02, 0x00,
  0x0F, 0xF8, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x07, 0xF0,
  0x38, 0x3F, 0x01, 0xE1, 0xF8, 0x07, 0x87, 0xC0, 0x1E, 0x3E, 0x00, 0x70,
  0xF0, 0x03, 0xC7, 0xC0, 0x0F, 0x1E, 0x00, 0x3C, 0x78, 0x00, 0xE1, 0xE0,
  0x07, 0x87, 0x80, 0x1E, 0x3E, 0x00, 0x78, 0xF8, 0x01, 0xE1, 0xE0, 0x07,
  0x07, 0x80, 0x3C, 0x1E, 0x01, 0xF0, 0x7E, 0x1F, 0xC0, 0xFF, 0xFF, 0x03,
  0xFF, 0xFE, 0x07, 0xFF, 0x78, 0x07, 0xE1, 0xE0, 0x00, 0x70, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x39, 0xF8, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x7E,
  0x0F, 0x83, 0xE0, 0x1E, 0x0F, 0x00, 0x7C, 0x3C, 0x00, 0xF0, 0xF0, 0x03,
  0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x3C, 0x78, 0x01, 0xF1, 0xE0, 0x07, 0x87,
  0x00, 0x1E, 0x3C, 0x00, 0x78, 0xF0, 0x03, 0xC3, 0xC0, 0x1F, 0x0E, 0x00,
  0x7C, 0x78, 0x03, 0xE1, 0xE0, 0x3F, 0x07, 0x83, 0xF8, 0x1F, 0xFF, 0xC0,
  0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xF0, 0x18, 0x3F,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1F, 0x00, 0x10, 0x3F, 0x01, 0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xFC,
  0x03, 0xFF, 0xF0, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF8, 0x07, 0xF0, 0xF8,
  0x0F, 0xC0, 0x78, 0x0F, 0x00, 0x78, 0x1E, 0x00, 0xF8, 0x3E, 0x00, 0xF0,
  0x3C, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0x78, 0x01, 0xE0,
  0xF0, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0xF0, 0x03, 0xC0,
  0xF0, 0x03, 0xC0, 0xF0, 0x03, 0xC0, 0xF0, 0x03, 0xC0, 0xF0, 0x03, 0xC0,
  0x78, 0x07, 0xC0, 0x7C, 0x1F, 0xC0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFB, 0xC0,
  0x0F, 0xE1, 0xC0, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x01,
  0xFF, 0xFE, 0x0F, 0xE0, 0xF8, 0x3E, 0x01, 0xF1, 0xF0, 0x03, 0xCF, 0x80,
  0x0F, 0x3E, 0x00, 0x78, 0xF0, 0x01, 0xE7, 0x80, 0x1F, 0x9E, 0x03, 0xFC,
  0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xF8, 0x00, 0xF0,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x10, 0x7F, 0x03,
  0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x0F, 0x81, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x21, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x0F, 0xC1, 0xE0, 0x0F, 0x80,
  0xF0, 0x0F, 0x80, 0x78, 0x0F, 0x80, 0x3C, 0x0F, 0x80, 0x3C, 0x07, 0x80,
  0x1E, 0x07, 0xC0, 0x0F, 0x03, 0xC0, 0x07, 0x81, 0xE0, 0x03, 0xC0, 0xF0,
  0x03, 0xC0, 0xF0, 0x01, 0xE0, 0x78, 0x00, 0xF0, 0x3C, 0x00, 0x78, 0x1E,
  0x00, 0x78, 0x0F, 0x00, 0x3C, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x7F, 0x00,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xF3, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x10, 0x01, 0xF0, 0x0E, 0x03, 0xF8,
  0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF7, 0xE0, 0x07, 0xFF, 0xC0, 0x7F, 0xFF, 0x03,
  0xFF, 0xFC, 0x1E, 0x07, 0xE0, 0xF0, 0x0F, 0x0F, 0x00, 0x78, 0x78, 0x03,
  0xC3, 0xC0, 0x1E, 0x1E, 0x00, 0xF1, 0xE0, 0x07, 0x8F, 0x00, 0x3C, 0x78,
  0x03, 0xE3, 0xC0, 0x1E, 0x3C, 0x00, 0xF1, 0xE0, 0x07, 0x8F, 0x00, 0x3C,
  0x78, 0x03, 0xC3, 0xC0, 0x1E, 0x3C, 0x00, 0xF1, 0xE0, 0x07, 0x8F, 0x00,
  0x78, 0x78, 0x03, 0xC7, 0x80, 0x1E, 0x00, 0x00, 0xE0, 0x07, 0xC0, 0x3F,
  0x80, 0xFE, 0x03, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0xFF, 0xE3, 0xFF, 0x00, 0x3C, 0x00, 0xF0, 0x07,
  0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0xFF, 0xC3, 0xFF, 0x07, 0xFC, 0x07, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x70, 0x3E,
  0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x3E, 0x07, 0x80, 0x7C, 0x07, 0x80, 0xF8, 0x07, 0x83, 0xF0, 0x07, 0x07,
  0xE0, 0x0F, 0x0F, 0xC0, 0x0F, 0x3F, 0x00, 0x0F, 0x7E, 0x00, 0x0F, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1E, 0xF8,
  0x00, 0x3C, 0x7C, 0x00, 0x3C, 0x3E, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x1F,
  0x00, 0x78, 0x0F, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0xC0, 0x78, 0x03,
  0xC0, 0xF0, 0x03, 0xE0, 0xF0, 0x01, 0xE0, 0xFF, 0xE7, 0xFF, 0x3F, 0xF8,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xF0, 0x4F, 0xFF, 0x7F,
  0xF9, 0xFF, 0xC3, 0xF8, 0x01, 0xF8, 0x78, 0x07, 0xFD, 0xFE, 0x0F, 0xFF,
  0xFE, 0x0F, 0x1F, 0x1E, 0x0F, 0x0E, 0x0F, 0x0E, 0x0E, 0x0E, 0x0E, 0x1E,
  0x0E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1C, 0x1E, 0x1E, 0x1C, 0x1C,
  0x1C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x38, 0x38,
  0x38, 0x78, 0x00, 0x38, 0x78, 0x00, 0x78, 0x78, 0x00, 0x78, 0x70, 0x00,
  0x78, 0x70, 0x00, 0x70, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0xE0, 0x00,
  0xF0, 0xE0, 0x00, 0xE0, 0x00, 0x7F, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFC,
  0x0F, 0xFF, 0xE0, 0x78, 0x1F, 0x87, 0x80, 0x7C, 0x3C, 0x01, 0xE1, 0xE0,
  0x0F, 0x0F, 0x00, 0x78, 0xF8, 0x03, 0xC7, 0x80, 0x1E, 0x3C, 0x00, 0xF1,
  0xE0, 0x0F, 0x1F, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80, 0x1E, 0x3C, 0x01,
  0xE1, 0xE0, 0x0F, 0x1E, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80, 0x1E, 0x3C,
  0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0x78, 0x00, 0x7F, 0x00, 0x0F, 0xFE,
  0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFC, 0x1F, 0x0F, 0x80, 0x78, 0xF8,
  0x03, 0xE7, 0xC0, 0x0F, 0x7C, 0x00, 0x7B, 0xC0, 0x03, 0xDE, 0x00, 0x1E,
  0xF0, 0x01, 0xFF, 0x00, 0x0F, 0x78, 0x00, 0x7B, 0xC0, 0x03, 0xDE, 0x00,
  0x3E, 0xF0, 0x01, 0xE7, 0x80, 0x1F, 0x3C, 0x01, 0xF1, 0xF0, 0x1F, 0x87,
  0xC1, 0xF8, 0x3F, 0xFF, 0x80, 0xFF, 0xF8, 0x03, 0xFF, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x01, 0xFF,
  0xFE, 0x03, 0xE0, 0x7E, 0x03, 0xC0, 0x1E, 0x03, 0xC0, 0x1F, 0x03, 0xC0,
  0x0F, 0x07, 0xC0, 0x0F, 0x07, 0x80, 0x0F, 0x07, 0x80, 0x0F, 0x07, 0x80,
  0x0F, 0x0F, 0x80, 0x1E, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x0F, 0x00,
  0x3E, 0x0F, 0x00, 0x3C, 0x1E, 0x00, 0x7C, 0x1E, 0x00, 0xF8, 0x1E, 0x03,
  0xF0, 0x1E, 0x0F, 0xE0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x3F, 0xFE,
  0x00, 0x3F, 0xF8, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFC, 0x1E,
  0x0F, 0xC0, 0x78, 0x3C, 0x01, 0xE1, 0xE0, 0x0F, 0x0F, 0x80, 0x3C, 0x3C,
  0x00, 0xF1, 0xE0, 0x03, 0xC7, 0x80, 0x1F, 0x1E, 0x00, 0x78, 0xF0, 0x01,
  0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x1E, 0x3C, 0x00, 0xF0, 0xF0, 0x03, 0xC3,
  0xC0, 0x0F, 0x0F, 0x00, 0x3C, 0x3C, 0x00, 0xE0, 0x78, 0x07, 0x81, 0xF0,
  0x7E, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x0F, 0xEF, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0xE0, 0x7F,
  0xFF, 0x81, 0xFF, 0xFE, 0x07, 0xC0, 0x10, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x07, 0xFF, 0x80, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7C, 0x06,
  0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x80, 0x0F, 0x07, 0x81, 0xF8, 0x7F, 0xFF, 0x83, 0xFF, 0xF8, 0x0F,
  0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xE0, 0x60, 0xFF, 0xF8, 0x3F, 0xFE, 0x07, 0xFF,
  0x80, 0x7F, 0x00, 0x1E, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80, 0x1E, 0x3C,
  0x01, 0xE3, 0xE0, 0x0F, 0x1E, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80, 0x3C,
  0x3C, 0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0x78, 0xF0, 0x07, 0xC7, 0x80,
  0x3C, 0x78, 0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0x78, 0xF0, 0x07, 0x87,
  0x80, 0x3C, 0x3E, 0x03, 0xE1, 0xF8, 0x7F, 0x07, 0xFF, 0xF8, 0x3F, 0xFF,
  0xE0, 0xFF, 0xCF, 0x01, 0xF8, 0x78, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x0F, 0x78, 0x01, 0xEF, 0x00, 0x79, 0xE0, 0x0F, 0x3C, 0x03, 0xC7, 0x80,
  0x78, 0xF0, 0x1F, 0x1E, 0x03, 0xC3, 0xC0, 0xF0, 0x78, 0x1E, 0x07, 0x87,
  0x80, 0xF0, 0xF0, 0x1E, 0x3C, 0x03, 0xC7, 0x80, 0x79, 0xE0, 0x0F, 0x78,
  0x01, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x00, 0x38, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x0E, 0x78, 0x00,
  0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1C, 0x78, 0x38, 0x3C, 0x70, 0x38,
  0x3C, 0x70, 0x78, 0x38, 0x70, 0xF8, 0x78, 0x70, 0xFC, 0x78, 0xF1, 0xFC,
  0x70, 0xF1, 0xDC, 0xF0, 0xF3, 0x9C, 0xE0, 0xF3, 0x9C, 0xE0, 0xF7, 0x1D,
  0xE0, 0xFE, 0x1D, 0xC0, 0xEE, 0x1F, 0xC0, 0xFC, 0x1F, 0x80, 0xFC, 0x1F,
  0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x03, 0xC0,
  0x07, 0x80, 0xF8, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x07, 0xC0, 0xF8, 0x00,
  0xF0, 0x7C, 0x00, 0x3E, 0x1E, 0x00, 0x07, 0x8F, 0x00, 0x01, 0xF7, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xCF, 0x00, 0x03, 0xE3, 0xC0, 0x01, 0xF0, 0x78, 0x00, 0xF8, 0x1E, 0x00,
  0x7C, 0x07, 0xC0, 0x3E, 0x00, 0xF0, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x07,
  0x80, 0x00, 0xF0, 0x01, 0xE0, 0x1E, 0x00, 0x3C, 0x03, 0xC0, 0x0F, 0x00,
  0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x01,
  0xE0, 0x07, 0xC0, 0x7C, 0x00, 0x78, 0x0F, 0x00, 0x0F, 0x01, 0xE0, 0x01,
  0xE0, 0x78, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x78, 0x78,
  0x00, 0x0F, 0x1E, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x3C, 0xF0, 0x00, 0x03,
  0xDE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x01, 0x03, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00,
  0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0x80, 0x30,
  0xFE, 0x01, 0xCF, 0xFC, 0x1E, 0xFF, 0xF1, 0xE7, 0x8F, 0xFF, 0x78, 0x3F,
  0xF3, 0x80, 0x7F, 0x0C, 0x01, 0xF0,
};

const GFXglyph UbuntuMono_Italic49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 25, 0, -1 },
  { 1, 12, 30, 25, 8, -30 },
  { 46, 14, 12, 25, 11, -31 },
  { 67, 26, 30, 25, 2, -30 },
  { 165, 23, 39, 25, 3, -34 },
  { 278, 30, 30, 25, 0, -30 },
  { 391, 21, 30, 25, 3, -30 },
  { 470, 6, 13, 25, 15, -33 },
  { 480, 19, 42, 25, 7, -34 },
  { 580, 18, 42, 25, 3, -34 },
  { 675, 19, 18, 25, 7, -30 },
  { 718, 21, 21, 25, 4, -24 },
  { 774, 11, 14, 25, 5, -7 },
  { 794, 11, 4, 25, 9, -15 },
  { 800, 7, 7, 25, 9, -7 },
  { 807, 28, 42, 25, -1, -34 },
  { 954, 22, 30, 25, 4, -30 },
  { 1037, 17, 30, 25, 5, -30 },
  { 1101, 23, 30, 25, 3, -30 },
  { 1188, 22, 30, 25, 3, -30 },
  { 1271, 23, 30, 25, 2, -30 },
  { 1358, 24, 30, 25, 3, -30 },
  { 1448, 22, 30, 25, 5, -30 },
  { 1531, 22, 30, 25, 7, -30 },
  { 1614, 22, 30, 25, 4, -30 },
  { 1697, 22, 30, 25, 4, -30 },
  { 1780, 11, 23, 25, 9, -23 },
  { 1812, 15, 30, 25, 5, -23 },
  { 1869, 21, 20, 25, 4, -23 },
  { 1922, 23, 12, 25, 3, -19 },
  { 1957, 22, 20, 25, 3, -22 },
  { 2012, 17, 30, 25, 8, -30 },
  { 2076, 24, 38, 25, 3, -31 },
  { 2190, 24, 30, 25, -1, -30 },
  { 2280, 24, 30, 25, 2, -30 },
  { 2370, 24, 30, 25, 4, -30 },
  { 2460, 24, 30, 25, 2, -30 },
  { 2550, 25, 30, 25, 3, -30 },
  { 2644, 25, 30, 25, 3, -30 },
  { 2738, 23, 30, 25, 4, -30 },
  { 2825, 26, 30, 25, 2, -30 },
  { 2923, 24, 30, 25, 3, -30 },
  { 3013, 24, 30, 25, 3, -30 },
  { 3103, 27, 30, 25, 2, -30 },
  { 3205, 18, 30, 25, 3, -30 },
  { 3273, 26, 30, 25, 1, -30 },
  { 3371, 26, 30, 25, 2, -30 },
  { 3469, 23, 30, 25, 4, -30 },
  { 3556, 24, 30, 25, 3, -30 },
  { 3646, 23, 38, 25, 4, -30 },
  { 3756, 24, 30, 25, 2, -30 },
  { 3846, 24, 30, 25, 3, -30 },
  { 3936, 22, 30, 25, 7, -30 },
  { 4019, 24, 30, 25, 4, -30 },
  { 4109, 23, 30, 25, 7, -30 },
  { 4196, 26, 30, 25, 3, -30 },
  { 4294, 30, 30, 25, 0, -30 },
  { 4407, 23, 30, 25, 7, -30 },
  { 4494, 26, 30, 25, 2, -30 },
  { 4592, 22, 42, 25, 5, -34 },
  { 4708, 7, 42, 25, 11, -34 },
  { 4745, 22, 42, 25, 1, -34 },
  { 4861, 20, 16, 25, 5, -30 },
  { 4901, 22, 3, 25, -1, 5 },
  { 4910, 8, 9, 25, 13, -34 },
  { 4919, 22, 25, 25, 3, -24 },
  { 4988, 22, 35, 25, 3, -34 },
  { 5085, 22, 25, 25, 3, -24 },
  { 5154, 24, 35, 25, 4, -34 },
  { 5259, 22, 25, 25, 3, -24 },
  { 5328, 29, 42, 25, 0, -34 },
  { 5481, 25, 32, 25, 1, -24 },
  { 5581, 21, 34, 25, 2, -34 },
  { 5671, 14, 34, 25, 7, -34 },
  { 5731, 24, 42, 25, 1, -34 },
  { 5857, 24, 34, 25, 3, -34 },
  { 5959, 13, 35, 25, 9, -34 },
  { 6016, 24, 24, 25, 2, -24 },
  { 6088, 21, 24, 25, 3, -24 },
  { 6151, 21, 25, 25, 4, -24 },
  { 6217, 24, 32, 25, 1, -24 },
  { 6313, 22, 32, 25, 4, -24 },
  { 6401, 22, 24, 25, 4, -24 },
  { 6467, 21, 25, 25, 4, -24 },
  { 6533, 18, 31, 25, 7, -30 },
  { 6603, 21, 24, 25, 4, -23 },
  { 6666, 19, 23, 25, 7, -23 },
  { 6721, 24, 23, 25, 4, -23 },
  { 6790, 26, 23, 25, 1, -23 },
  { 6865, 27, 31, 25, -1, -23 },
  { 6970, 22, 23, 25, 3, -23 },
  { 7034, 24, 42, 25, 4, -34 },
  { 7160, 15, 42, 25, 7, -34 },
  { 7239, 24, 42, 25, 0, -34 },
  { 7365, 21, 8, 25, 4, -17 },
};

const GFXfont UbuntuMono_Italic49pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Italic49pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Italic49pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _UBUNTUMONO_ITALIC49PT7B_H_
