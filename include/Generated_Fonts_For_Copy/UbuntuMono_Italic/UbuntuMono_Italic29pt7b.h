#ifndef _UBUNTUMONO_ITALIC29PT7B_H_
#define _UBUNTUMONO_ITALIC29PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Italic.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Italic29pt7bBitmaps[] PROGMEM = {
  0x00, 0x0E, 0x1C, 0x30, 0x61, 0xC3, 0x86, 0x0C, 0x38, 0x60, 0xC0, 0x00,
  0x00, 0x18, 0x78, 0xF1, 0xC0, 0x33, 0xB9, 0x98, 0xCC, 0x66, 0x62, 0x33,
  0x18, 0x00, 0xC6, 0x03, 0x0C, 0x06, 0x30, 0x1C, 0x60, 0x31, 0xC7, 0xFF,
  0xCF, 0xFF, 0x83, 0x18, 0x0C, 0x30, 0x18, 0xC0, 0x61, 0x83, 0xFF, 0xEF,
  0xFF, 0x86, 0x38, 0x0C, 0x60, 0x30, 0xC0, 0x63, 0x01, 0xC6, 0x00, 0x00,
  0x60, 0x03, 0x80, 0x0C, 0x00, 0xFC, 0x0F, 0xF8, 0x38, 0x21, 0xC0, 0x06,
  0x00, 0x1C, 0x00, 0x70, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0x80,
  0x07, 0x00, 0x1C, 0x00, 0x61, 0x03, 0x8F, 0xFC, 0x1F, 0xC0, 0x0C, 0x00,
  0x30, 0x01, 0xC0, 0x00, 0x07, 0x81, 0x83, 0xE0, 0xC0, 0xD8, 0x60, 0x62,
  0x38, 0x18, 0x8C, 0x06, 0x66, 0x01, 0x9B, 0x00, 0x7D, 0x80, 0x0E, 0xC0,
  0x00, 0x67, 0x00, 0x3B, 0xE0, 0x0D, 0x98, 0x06, 0x46, 0x03, 0x31, 0x81,
  0x8C, 0x40, 0xC3, 0x30, 0x70, 0xFC, 0x18, 0x1C, 0x00, 0x03, 0xC0, 0xFE,
  0x0C, 0x61, 0xC6, 0x18, 0x61, 0x8E, 0x1D, 0xC0, 0xF0, 0x1E, 0x33, 0xE3,
  0x67, 0x7E, 0x3E, 0xC1, 0xEC, 0x1C, 0xC1, 0xCE, 0x3E, 0xFE, 0xE7, 0xC6,
  0x66, 0xEE, 0xCC, 0xC8, 0x00, 0x60, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x00, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0x30, 0x06, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x01, 0x80, 0x30, 0x07, 0x00, 0x60, 0x0E, 0x00,
  0xE0, 0x08, 0x00, 0x02, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x1C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x70,
  0x0C, 0x03, 0x80, 0x60, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x00,
  0x80, 0x00, 0x0E, 0x01, 0xC0, 0x18, 0x23, 0x3F, 0x5E, 0x7F, 0x03, 0x80,
  0xD8, 0x3B, 0x8E, 0x38, 0x44, 0x00, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x06,
  0x00, 0x30, 0x3F, 0xF9, 0xFF, 0xC0, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x80,
  0x18, 0x00, 0x1C, 0xF3, 0xC7, 0x1C, 0xEF, 0x30, 0x7F, 0xFC, 0x7F, 0xF6,
  0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00,
  0x1C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00,
  0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0,
  0x00, 0xE0, 0x00, 0x60, 0x00, 0x00, 0x01, 0xE0, 0x3F, 0x83, 0x8E, 0x38,
  0x31, 0x81, 0x9C, 0x0C, 0xC0, 0x6E, 0x63, 0x67, 0xBB, 0x3D, 0xD8, 0xCD,
  0xC0, 0xEE, 0x07, 0x70, 0x71, 0x83, 0x0E, 0x38, 0x7F, 0x81, 0xF0, 0x00,
  0x00, 0xC0, 0x70, 0x7C, 0x7E, 0x3D, 0x84, 0x60, 0x38, 0x0C, 0x03, 0x00,
  0xC0, 0x70, 0x1C, 0x06, 0x01, 0x80, 0xE0, 0x38, 0xFF, 0xFF, 0xE0, 0x03,
  0xE0, 0x7F, 0x83, 0x0E, 0x10, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x0C,
  0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x07, 0xE0, 0x7F, 0x82, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xC0, 0x1E, 0x07, 0xC0, 0x3E, 0x00, 0x38, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0x98, 0x3C, 0xFF, 0xC3, 0xF8, 0x00, 0x00,
  0x1C, 0x00, 0xE0, 0x0F, 0x80, 0x76, 0x03, 0xB8, 0x1C, 0xC0, 0xE3, 0x03,
  0x0C, 0x18, 0x70, 0xC1, 0x87, 0x06, 0x1F, 0xFE, 0x7F, 0xF8, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x60,
  0x01, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x07, 0xC0, 0x1F, 0xC0, 0x07,
  0x80, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x30, 0x70, 0xFF,
  0x81, 0xF8, 0x00, 0x00, 0x78, 0x1F, 0xC1, 0xE0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x0D, 0xF0, 0xFF, 0xE7, 0x07, 0x30, 0x19, 0x80, 0xCC, 0x06,
  0x60, 0x33, 0x03, 0x9C, 0x38, 0x7F, 0x81, 0xF0, 0x00, 0x3F, 0xF9, 0xFF,
  0xC0, 0x1C, 0x01, 0xC0, 0x0C, 0x00, 0xC0, 0x0E, 0x00, 0xE0, 0x06, 0x00,
  0x70, 0x07, 0x00, 0x30, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0xE0,
  0x07, 0x00, 0x00, 0x03, 0xE0, 0x1F, 0xE0, 0xE3, 0x87, 0x07, 0x18, 0x1C,
  0x60, 0x61, 0x83, 0x87, 0x9C, 0x0F, 0xE0, 0x7F, 0x83, 0x8E, 0x1C, 0x1C,
  0x60, 0x33, 0x81, 0xCE, 0x07, 0x18, 0x38, 0x7F, 0xC0, 0x7C, 0x00, 0x03,
  0xE0, 0x3F, 0xC1, 0xE3, 0x86, 0x06, 0x38, 0x18, 0xC0, 0x73, 0x01, 0x8C,
  0x06, 0x38, 0x38, 0x7F, 0xE0, 0xFB, 0x80, 0x1C, 0x00, 0x60, 0x03, 0x80,
  0x1C, 0x03, 0xE0, 0xFE, 0x03, 0xE0, 0x00, 0x1C, 0x7C, 0xF0, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0xE3, 0xC7, 0x86, 0x00, 0x07, 0x07, 0xC3, 0xC0, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x0F, 0x07, 0x81, 0xC0, 0xE0, 0xE1,
  0xE0, 0xC0, 0x00, 0x00, 0x18, 0x03, 0xC0, 0xFC, 0x3F, 0x07, 0xC0, 0x70,
  0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x10, 0x3F, 0xFB, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFB, 0xFF, 0xC0, 0x30, 0x01, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x18, 0x07, 0xC1, 0xF8, 0x7E, 0x07,
  0x80, 0x20, 0x00, 0x1F, 0x0F, 0xF2, 0x1C, 0x03, 0x01, 0xC0, 0x60, 0x30,
  0x38, 0x1C, 0x0C, 0x03, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x00, 0x01, 0xF0, 0x1F, 0xE0, 0xE1, 0xC7, 0x03, 0x18, 0x0C, 0xE0,
  0x33, 0x0F, 0xDC, 0xFF, 0x63, 0x9D, 0x98, 0x6E, 0x61, 0xB3, 0x8E, 0xCE,
  0x3B, 0x38, 0xCC, 0x63, 0x31, 0xFC, 0xE3, 0xE3, 0x80, 0x07, 0x00, 0x1E,
  0x00, 0x3F, 0x80, 0x3E, 0x00, 0x00, 0x70, 0x01, 0xE0, 0x0F, 0x80, 0x76,
  0x01, 0x98, 0x0C, 0x60, 0x31, 0x81, 0x86, 0x06, 0x18, 0x30, 0x61, 0xC1,
  0x87, 0xFE, 0x3F, 0xF8, 0xC0, 0x67, 0x01, 0x98, 0x07, 0xE0, 0x1F, 0x00,
  0x70, 0x0F, 0xF0, 0x3F, 0xE0, 0xC1, 0xC3, 0x03, 0x1C, 0x0C, 0x70, 0x31,
  0x81, 0xC6, 0x0E, 0x3F, 0xE0, 0xFF, 0xC3, 0x03, 0x8C, 0x06, 0x30, 0x19,
  0xC0, 0xE6, 0x03, 0x98, 0x3C, 0x7F, 0xE3, 0xFE, 0x00, 0x03, 0xF0, 0x1F,
  0xE1, 0xE0, 0x8E, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x3C,
  0x10, 0x7F, 0xC0, 0x7E, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0xC3, 0x87, 0x07,
  0x1C, 0x1C, 0x60, 0x31, 0x80, 0xCE, 0x03, 0x38, 0x0C, 0xC0, 0x73, 0x01,
  0xDC, 0x06, 0x70, 0x39, 0x81, 0xC6, 0x0F, 0x18, 0x78, 0xFF, 0x83, 0xF8,
  0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0x80, 0x06, 0x00, 0x3F, 0xF0, 0xFF, 0x83, 0x00, 0x0C, 0x00, 0x70, 0x01,
  0xC0, 0x06, 0x00, 0x18, 0x00, 0xFF, 0xE3, 0xFF, 0x80, 0x0F, 0xFC, 0x1F,
  0xF8, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00,
  0x3F, 0xF0, 0x7F, 0xC0, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18,
  0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x01, 0xF8, 0x1F, 0xF0, 0xE0,
  0x87, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80,
  0xCE, 0x03, 0x38, 0x1C, 0xE0, 0x73, 0x81, 0x86, 0x06, 0x1C, 0x18, 0x3F,
  0xE0, 0x7F, 0x00, 0x0E, 0x07, 0x0C, 0x06, 0x0C, 0x06, 0x1C, 0x06, 0x1C,
  0x0E, 0x1C, 0x0C, 0x18, 0x0C, 0x18, 0x0C, 0x3F, 0xFC, 0x3F, 0xF8, 0x30,
  0x18, 0x30, 0x18, 0x70, 0x38, 0x70, 0x30, 0x60, 0x30, 0x60, 0x30, 0xE0,
  0x70, 0xE0, 0x70, 0x0F, 0xFC, 0x3F, 0xE0, 0x1C, 0x00, 0x60, 0x01, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0xFF, 0xC3, 0xFE, 0x00, 0x07,
  0xFC, 0x1F, 0xF0, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80,
  0x0C, 0x10, 0x70, 0xFF, 0x80, 0xF8, 0x00, 0x0E, 0x07, 0x0E, 0x0E, 0x0C,
  0x1C, 0x0C, 0x38, 0x0C, 0x70, 0x1D, 0xC0, 0x1B, 0x80, 0x1F, 0x00, 0x1E,
  0x00, 0x3F, 0x00, 0x33, 0x80, 0x31, 0x80, 0x31, 0xC0, 0x70, 0xE0, 0x70,
  0xE0, 0x60, 0x70, 0x60, 0x70, 0xE0, 0x30, 0x0C, 0x03, 0x01, 0xC0, 0x60,
  0x18, 0x06, 0x03, 0x80, 0xC0, 0x30, 0x0C, 0x07, 0x01, 0xC0, 0x60, 0x18,
  0x0E, 0x03, 0x80, 0xFF, 0xFF, 0xF0, 0x06, 0x06, 0x0C, 0x1C, 0x3C, 0x38,
  0x78, 0xF0, 0xB3, 0x63, 0x66, 0x86, 0xDB, 0x0D, 0xB6, 0x33, 0xCC, 0x67,
  0x18, 0xCE, 0x73, 0x80, 0xC6, 0x01, 0x8C, 0x03, 0x38, 0x06, 0x60, 0x1C,
  0xC0, 0x31, 0x80, 0x60, 0x0E, 0x07, 0x0E, 0x06, 0x0F, 0x06, 0x0F, 0x06,
  0x1F, 0x06, 0x1B, 0x0C, 0x19, 0x8C, 0x19, 0x8C, 0x39, 0x8C, 0x31, 0x9C,
  0x30, 0xD8, 0x30, 0xD8, 0x70, 0xD8, 0x60, 0xF8, 0x60, 0x70, 0x60, 0x70,
  0x60, 0x70, 0xC0, 0x70, 0x03, 0xE0, 0x1F, 0xE0, 0xE3, 0x87, 0x06, 0x38,
  0x1C, 0xC0, 0x77, 0x01, 0xDC, 0x07, 0x60, 0x19, 0x80, 0x6E, 0x03, 0xB8,
  0x0E, 0xE0, 0x33, 0x81, 0xCE, 0x0E, 0x1C, 0x70, 0x7F, 0x80, 0x78, 0x00,
  0x0F, 0xE0, 0x3F, 0xE1, 0xC3, 0x86, 0x07, 0x18, 0x1C, 0x60, 0x73, 0x81,
  0x8C, 0x0E, 0x30, 0x70, 0xFF, 0x87, 0xF8, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x03, 0xE0, 0x1F, 0xE0,
  0xE3, 0x87, 0x06, 0x38, 0x1C, 0xC0, 0x77, 0x01, 0xDC, 0x07, 0x60, 0x19,
  0x80, 0x6E, 0x03, 0xB8, 0x0E, 0xE0, 0x33, 0x81, 0xCE, 0x0E, 0x1C, 0x70,
  0x7F, 0x80, 0x7C, 0x01, 0xC0, 0x03, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x18,
  0x00, 0x0F, 0xF0, 0x3F, 0xE0, 0xC1, 0xC3, 0x03, 0x0C, 0x0C, 0x70, 0x31,
  0x80, 0xC6, 0x07, 0x18, 0x38, 0xFF, 0xC3, 0xFC, 0x0C, 0x30, 0x30, 0xC1,
  0xC3, 0x87, 0x06, 0x18, 0x18, 0x60, 0x73, 0x80, 0xC0, 0x03, 0xF0, 0x3F,
  0xF0, 0xE0, 0x87, 0x00, 0x18, 0x00, 0x60, 0x01, 0xC0, 0x07, 0x80, 0x0F,
  0x80, 0x0F, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x01, 0x80, 0x06, 0x30,
  0x78, 0xFF, 0xC1, 0xFC, 0x00, 0x7F, 0xFB, 0xFF, 0xC1, 0xC0, 0x0C, 0x00,
  0x60, 0x07, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x00, 0x1C,
  0x0E, 0x30, 0x18, 0x60, 0x31, 0xC0, 0xE3, 0x81, 0xC6, 0x03, 0x0C, 0x06,
  0x38, 0x1C, 0x70, 0x38, 0xC0, 0x61, 0x80, 0xC3, 0x03, 0x8E, 0x07, 0x1C,
  0x0C, 0x38, 0x38, 0x38, 0xE0, 0x7F, 0xC0, 0x3E, 0x00, 0xC0, 0x1F, 0x00,
  0xEC, 0x03, 0xB0, 0x0C, 0xC0, 0x73, 0x81, 0x8E, 0x0E, 0x38, 0x30, 0xE1,
  0x83, 0x8E, 0x0E, 0x30, 0x39, 0xC0, 0x66, 0x01, 0xB8, 0x06, 0xC0, 0x1F,
  0x00, 0x78, 0x01, 0xC0, 0x00, 0x18, 0x06, 0x70, 0x0C, 0xE0, 0x39, 0x80,
  0x63, 0x00, 0xC6, 0x01, 0x9C, 0x07, 0x31, 0x8C, 0x67, 0x18, 0xCF, 0x31,
  0xB6, 0xC3, 0x6D, 0x8D, 0x9B, 0x1A, 0x3C, 0x3C, 0x78, 0x70, 0xF0, 0xE1,
  0xC1, 0x81, 0x80, 0x07, 0x01, 0x80, 0xC0, 0xE0, 0x38, 0x70, 0x0E, 0x38,
  0x01, 0x8C, 0x00, 0x76, 0x00, 0x1F, 0x80, 0x03, 0xC0, 0x00, 0xE0, 0x00,
  0x78, 0x00, 0x3E, 0x00, 0x0D, 0xC0, 0x07, 0x30, 0x03, 0x8C, 0x01, 0xC3,
  0x80, 0xE0, 0x60, 0x70, 0x18, 0x1C, 0x07, 0x00, 0xE0, 0x1D, 0x80, 0xE6,
  0x03, 0x18, 0x1C, 0x60, 0xE1, 0xC3, 0x03, 0x18, 0x0C, 0xE0, 0x3F, 0x00,
  0x78, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00,
  0x30, 0x00, 0xC0, 0x00, 0x07, 0xFE, 0x0F, 0xFE, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00,
  0xFF, 0xF0, 0xFF, 0xF0, 0x03, 0xF8, 0x1F, 0xC1, 0xC0, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x03, 0x80, 0x1F, 0xC0, 0xFE, 0x00, 0xE7, 0x18, 0xC6,
  0x31, 0x8C, 0x63, 0x9C, 0xE7, 0x39, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xE7,
  0x38, 0x03, 0xF8, 0x3F, 0x80, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03,
  0x80, 0x18, 0x1F, 0xC0, 0xFE, 0x00, 0x01, 0x80, 0x3C, 0x07, 0xC0, 0xEC,
  0x0C, 0xE1, 0x86, 0x38, 0x67, 0x06, 0xE0, 0x34, 0x02, 0x7F, 0xFF, 0xFF,
  0xE0, 0x47, 0x18, 0x61, 0x00, 0x03, 0xF0, 0x7F, 0xC7, 0x0C, 0x70, 0x67,
  0x07, 0x30, 0x3B, 0x81, 0x9C, 0x0C, 0xC0, 0xE7, 0x07, 0x38, 0x78, 0xFF,
  0xC3, 0xE6, 0x00, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0E,
  0x00, 0x60, 0x03, 0x78, 0x3F, 0xF1, 0xE3, 0x8C, 0x0E, 0x60, 0x73, 0x03,
  0xB8, 0x19, 0x80, 0xCC, 0x0E, 0x60, 0xE7, 0x1E, 0x3F, 0xE1, 0xFC, 0x00,
  0x03, 0xF0, 0x7F, 0xCF, 0x04, 0x70, 0x07, 0x00, 0x30, 0x03, 0x80, 0x18,
  0x00, 0xC0, 0x07, 0x00, 0x1C, 0x10, 0xFF, 0xC1, 0xF8, 0x00, 0x00, 0x0E,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x01,
  0xFC, 0x0F, 0xF8, 0x3C, 0x70, 0xE0, 0xC3, 0x81, 0x86, 0x07, 0x0C, 0x0E,
  0x38, 0x18, 0x70, 0x30, 0xE0, 0x60, 0xE3, 0xC1, 0xFF, 0x81, 0xF3, 0x00,
  0x07, 0xE0, 0xFF, 0x8F, 0x0E, 0xE0, 0x76, 0x03, 0x70, 0x7B, 0xFF, 0x9F,
  0xE0, 0xC0, 0x07, 0x00, 0x1C, 0x10, 0xFF, 0xC1, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x1F, 0xC0, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x0F, 0xFE, 0x07, 0xFE, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x1F, 0xF0, 0xF1, 0xC7, 0x07, 0x38,
  0x18, 0xC0, 0x63, 0x03, 0x8C, 0x0C, 0x30, 0x30, 0xC3, 0xC3, 0xFF, 0x07,
  0xD8, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x30, 0x70, 0xFF, 0x81, 0xF8, 0x00,
  0x06, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x03,
  0xFC, 0x1F, 0xF0, 0xC1, 0xC6, 0x0E, 0x70, 0x73, 0x83, 0x98, 0x1C, 0xC0,
  0xCE, 0x06, 0x70, 0x73, 0x03, 0x18, 0x19, 0xC1, 0xC0, 0x06, 0x0F, 0x0F,
  0x0E, 0x00, 0x00, 0xFC, 0xFC, 0x0C, 0x1C, 0x18, 0x18, 0x18, 0x38, 0x38,
  0x38, 0x38, 0x1F, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0x82, 0x0E, 0x0F, 0xF0, 0x1F, 0x00, 0x06, 0x00,
  0x38, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x0E,
  0x18, 0x70, 0xE3, 0x83, 0x38, 0x0D, 0xC0, 0x3C, 0x01, 0xF8, 0x07, 0x70,
  0x18, 0xE0, 0x61, 0xC3, 0x87, 0x0E, 0x0E, 0x30, 0x38, 0x7E, 0xFE, 0x0C,
  0x0C, 0x1C, 0x1C, 0x18, 0x18, 0x38, 0x38, 0x30, 0x30, 0x70, 0x70, 0x60,
  0x60, 0x60, 0x61, 0x7F, 0x3E, 0x0F, 0x38, 0x7F, 0xF1, 0x9C, 0xCE, 0x63,
  0x31, 0x8C, 0xC6, 0x73, 0x39, 0x98, 0xC6, 0x60, 0x19, 0x80, 0xE6, 0x03,
  0x30, 0x0C, 0xC0, 0x30, 0x0F, 0xC1, 0xFF, 0x38, 0x73, 0x83, 0x30, 0x33,
  0x03, 0x70, 0x37, 0x07, 0x60, 0x66, 0x06, 0xE0, 0x6E, 0x0E, 0xC0, 0xC0,
  0x07, 0xC0, 0xFF, 0x8F, 0x1C, 0x70, 0x77, 0x03, 0xB0, 0x1D, 0x80, 0xDC,
  0x06, 0xE0, 0x77, 0x07, 0x1C, 0x78, 0xFF, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x3F, 0xE1, 0xC3, 0x87, 0x07, 0x18, 0x1C, 0x60, 0x73, 0x81, 0x8C, 0x06,
  0x30, 0x38, 0xC1, 0xC7, 0x0E, 0x1F, 0xF0, 0x7F, 0x01, 0x80, 0x0E, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x03, 0xF8, 0x7F, 0xC7, 0x8E, 0x70,
  0x77, 0x03, 0x30, 0x39, 0x81, 0xDC, 0x0E, 0xE0, 0x67, 0x07, 0x1C, 0x78,
  0xFF, 0x83, 0xEC, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x0F, 0xF1, 0xFF, 0x38, 0x03, 0x00, 0x30, 0x07, 0x00, 0x70, 0x06, 0x00,
  0x60, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x00, 0x03, 0xF0, 0x7F, 0x87,
  0x04, 0x30, 0x01, 0xC0, 0x0F, 0x00, 0x1F, 0x00, 0x38, 0x00, 0xE0, 0x07,
  0x10, 0x30, 0xFF, 0x83, 0xF0, 0x00, 0x0E, 0x01, 0x80, 0x30, 0x0E, 0x0F,
  0xFF, 0xFF, 0xC6, 0x01, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x38, 0x07, 0x00,
  0xC0, 0x1C, 0x21, 0xFC, 0x1F, 0x00, 0x38, 0x39, 0x81, 0xCC, 0x0C, 0x60,
  0x67, 0x07, 0x30, 0x39, 0x81, 0x8C, 0x0C, 0xE0, 0xE7, 0x07, 0x18, 0x78,
  0xFF, 0xC3, 0xE6, 0x00, 0xC0, 0x78, 0x1F, 0x03, 0x60, 0x6E, 0x19, 0xC3,
  0x38, 0xC3, 0x38, 0x66, 0x0D, 0x81, 0xF0, 0x3C, 0x07, 0x00, 0x70, 0x0E,
  0xC0, 0x19, 0x80, 0x33, 0x18, 0xC6, 0x31, 0x8C, 0xE3, 0x19, 0x4C, 0x36,
  0xD8, 0xF9, 0xE1, 0xB3, 0xC3, 0xC7, 0x87, 0x0E, 0x0E, 0x1C, 0x00, 0x1C,
  0x0C, 0x18, 0x30, 0x38, 0xC0, 0x33, 0x00, 0x7E, 0x00, 0x78, 0x00, 0xE0,
  0x03, 0xE0, 0x0E, 0xC0, 0x39, 0xC0, 0xE1, 0x83, 0x83, 0x0E, 0x07, 0x00,
  0x06, 0x03, 0x03, 0x01, 0x81, 0xC1, 0xC0, 0xE0, 0xC0, 0x70, 0xE0, 0x18,
  0x60, 0x0C, 0x30, 0x06, 0x38, 0x03, 0x98, 0x01, 0xDC, 0x00, 0x6C, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x7E, 0x00,
  0x3C, 0x00, 0x00, 0x1F, 0xF8, 0xFF, 0x80, 0x18, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0xFF, 0x8F, 0xFC,
  0x00, 0x00, 0xF8, 0x07, 0xE0, 0x38, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0xF0, 0x03,
  0xE0, 0x03, 0x80, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x70, 0x01, 0x80, 0x07, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x03, 0x81, 0x80,
  0xC0, 0x60, 0x70, 0x30, 0x18, 0x0C, 0x0E, 0x06, 0x03, 0x01, 0x81, 0xC0,
  0xC0, 0x60, 0x30, 0x38, 0x1C, 0x0C, 0x06, 0x03, 0x03, 0x81, 0x80, 0xC0,
  0x60, 0x00, 0x03, 0xE0, 0x0F, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x1C, 0x00,
  0x7C, 0x03, 0xF0, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0xE0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x3F, 0x80, 0xFC, 0x00, 0x1C, 0x1B,
  0xF9, 0xD9, 0xFD, 0x83, 0xC0,
};

const GFXglyph UbuntuMono_Italic29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 7, 18, 15, 5, -18 },
  { 17, 9, 7, 15, 6, -18 },
  { 25, 15, 18, 15, 1, -18 },
  { 59, 14, 23, 15, 2, -20 },
  { 100, 18, 18, 15, 0, -18 },
  { 141, 12, 18, 15, 2, -18 },
  { 168, 4, 8, 15, 9, -20 },
  { 172, 11, 25, 15, 4, -20 },
  { 207, 11, 25, 15, 2, -20 },
  { 242, 11, 11, 15, 4, -18 },
  { 258, 13, 12, 15, 2, -14 },
  { 278, 6, 8, 15, 3, -4 },
  { 284, 7, 2, 15, 5, -8 },
  { 286, 4, 4, 15, 5, -4 },
  { 288, 17, 25, 15, -1, -20 },
  { 342, 13, 18, 15, 2, -18 },
  { 372, 10, 18, 15, 3, -18 },
  { 395, 13, 18, 15, 2, -18 },
  { 425, 13, 18, 15, 2, -18 },
  { 455, 14, 18, 15, 1, -18 },
  { 487, 14, 18, 15, 2, -18 },
  { 519, 13, 18, 15, 3, -18 },
  { 549, 13, 18, 15, 4, -18 },
  { 579, 14, 18, 15, 2, -18 },
  { 611, 14, 18, 15, 2, -18 },
  { 643, 7, 13, 15, 5, -13 },
  { 655, 9, 17, 15, 3, -13 },
  { 675, 13, 11, 15, 2, -13 },
  { 693, 13, 7, 15, 2, -11 },
  { 705, 13, 11, 15, 2, -13 },
  { 723, 10, 18, 15, 5, -18 },
  { 746, 14, 22, 15, 2, -18 },
  { 785, 14, 18, 15, 0, -18 },
  { 817, 14, 18, 15, 1, -18 },
  { 849, 14, 18, 15, 3, -18 },
  { 881, 14, 18, 15, 1, -18 },
  { 913, 14, 18, 15, 2, -18 },
  { 945, 15, 18, 15, 2, -18 },
  { 979, 14, 18, 15, 2, -18 },
  { 1011, 16, 18, 15, 1, -18 },
  { 1047, 14, 18, 15, 2, -18 },
  { 1079, 14, 18, 15, 2, -18 },
  { 1111, 16, 18, 15, 1, -18 },
  { 1147, 10, 18, 15, 2, -18 },
  { 1170, 15, 18, 15, 1, -18 },
  { 1204, 16, 18, 15, 1, -18 },
  { 1240, 14, 18, 15, 2, -18 },
  { 1272, 14, 18, 15, 2, -18 },
  { 1304, 14, 23, 15, 2, -18 },
  { 1345, 14, 18, 15, 1, -18 },
  { 1377, 14, 18, 15, 2, -18 },
  { 1409, 13, 18, 15, 4, -18 },
  { 1439, 15, 18, 15, 2, -18 },
  { 1473, 14, 18, 15, 4, -18 },
  { 1505, 15, 18, 15, 2, -18 },
  { 1539, 18, 18, 15, 0, -18 },
  { 1580, 14, 18, 15, 4, -18 },
  { 1612, 16, 18, 15, 1, -18 },
  { 1648, 13, 25, 15, 3, -20 },
  { 1689, 5, 25, 15, 6, -20 },
  { 1705, 13, 25, 15, 1, -20 },
  { 1746, 12, 10, 15, 3, -18 },
  { 1761, 14, 2, 15, -1, 3 },
  { 1765, 5, 5, 15, 8, -20 },
  { 1769, 13, 13, 15, 2, -13 },
  { 1791, 13, 20, 15, 2, -20 },
  { 1824, 13, 13, 15, 2, -13 },
  { 1846, 15, 20, 15, 2, -20 },
  { 1884, 13, 13, 15, 2, -13 },
  { 1906, 17, 25, 15, 0, -20 },
  { 1960, 14, 18, 15, 1, -13 },
  { 1992, 13, 20, 15, 1, -20 },
  { 2025, 8, 19, 15, 4, -19 },
  { 2044, 14, 24, 15, 1, -19 },
  { 2086, 14, 20, 15, 2, -20 },
  { 2121, 8, 20, 15, 5, -20 },
  { 2141, 14, 13, 15, 1, -13 },
  { 2164, 12, 13, 15, 2, -13 },
  { 2184, 13, 13, 15, 2, -13 },
  { 2206, 14, 18, 15, 1, -13 },
  { 2238, 13, 18, 15, 2, -13 },
  { 2268, 12, 13, 15, 3, -13 },
  { 2288, 13, 13, 15, 2, -13 },
  { 2310, 11, 17, 15, 4, -17 },
  { 2334, 13, 13, 15, 2, -13 },
  { 2356, 11, 13, 15, 4, -13 },
  { 2374, 15, 13, 15, 2, -13 },
  { 2399, 15, 13, 15, 1, -13 },
  { 2424, 17, 18, 15, -1, -13 },
  { 2463, 13, 13, 15, 2, -13 },
  { 2485, 14, 25, 15, 3, -20 },
  { 2529, 9, 25, 15, 4, -20 },
  { 2558, 14, 25, 15, 0, -20 },
  { 2602, 13, 4, 15, 2, -11 },
};

const GFXfont UbuntuMono_Italic29pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Italic29pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Italic29pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _UBUNTUMONO_ITALIC29PT7B_H_
