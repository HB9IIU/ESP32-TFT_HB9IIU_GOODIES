#ifndef _UBUNTUMONO_ITALIC13PT7B_H_
#define _UBUNTUMONO_ITALIC13PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Italic.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Italic13pt7bBitmaps[] PROGMEM = {
  0x00, 0x24, 0xA4, 0x36, 0xAA, 0xA0, 0x14, 0x9F, 0xD2, 0x53, 0xF9, 0x28,
  0x08, 0xF4, 0x18, 0x30, 0x28, 0xBC, 0x21, 0x00, 0x32, 0x52, 0x54, 0x78,
  0x1C, 0x2A, 0x4A, 0x8C, 0x3A, 0x52, 0xE6, 0xCE, 0x5D, 0xA8, 0x09, 0x88,
  0x88, 0x42, 0x10, 0x82, 0x10, 0x20, 0x84, 0x10, 0x88, 0x42, 0x22, 0x20,
  0x25, 0xD8, 0xE5, 0x00, 0x10, 0x4F, 0x88, 0x20, 0x6C, 0xE0, 0xE0, 0xF0,
  0x02, 0x08, 0x10, 0x40, 0x82, 0x08, 0x10, 0x40, 0x82, 0x00, 0x39, 0x94,
  0x7D, 0xBA, 0x29, 0x9C, 0x09, 0xD4, 0x21, 0x08, 0x9F, 0x39, 0x10, 0x42,
  0x31, 0x8C, 0x3E, 0x38, 0x90, 0x8C, 0x08, 0x20, 0xBC, 0x0C, 0x62, 0x92,
  0x9B, 0xE1, 0x04, 0x3C, 0x82, 0x1C, 0x08, 0x21, 0xBC, 0x0C, 0xC4, 0x1E,
  0x8A, 0x28, 0x9C, 0x7C, 0x21, 0x08, 0x61, 0x0C, 0x20, 0x39, 0x94, 0x5A,
  0x5A, 0x28, 0x9C, 0x39, 0x14, 0x51, 0x7C, 0x21, 0x38, 0x6C, 0x0D, 0x80,
  0x33, 0x00, 0x66, 0x2C, 0x0D, 0xC8, 0x1C, 0x18, 0x7C, 0x00, 0x3E, 0x40,
  0xC0, 0x9C, 0x80, 0x70, 0x44, 0x44, 0x03, 0x18, 0x1D, 0x94, 0x67, 0xA6,
  0xAB, 0xA0, 0xC1, 0xC0, 0x0C, 0x51, 0x49, 0x25, 0xF4, 0x61, 0x79, 0x14,
  0xDC, 0x8A, 0x28, 0xBC, 0x1D, 0x94, 0x20, 0x82, 0x0C, 0x1E, 0x3C, 0x4C,
  0x89, 0x14, 0x68, 0x93, 0x38, 0x3C, 0x84, 0x1E, 0x41, 0x08, 0x3E, 0x3C,
  0x84, 0x1E, 0x41, 0x08, 0x20, 0x1D, 0x94, 0x20, 0x8A, 0x2C, 0x9E, 0x22,
  0x22, 0x22, 0x3E, 0x44, 0x44, 0x44, 0x44, 0x3C, 0x41, 0x04, 0x20, 0x82,
  0x3C, 0x3C, 0x10, 0x42, 0x08, 0x29, 0x3C, 0x44, 0x91, 0xC3, 0x0A, 0x12,
  0x24, 0x44, 0x24, 0x44, 0x48, 0x8F, 0x12, 0x6C, 0xDA, 0xD5, 0xA8, 0x91,
  0x42, 0x64, 0xC9, 0x92, 0xA9, 0x93, 0x26, 0x4C, 0x39, 0x94, 0x61, 0x86,
  0x29, 0x9C, 0x39, 0x14, 0x53, 0x7A, 0x08, 0x20, 0x39, 0x94, 0x61, 0x86,
  0x29, 0x9C, 0x20, 0xC0, 0x79, 0x14, 0x52, 0xF2, 0x49, 0x22, 0x3D, 0x04,
  0x0C, 0x18, 0x28, 0xBC, 0xFC, 0x82, 0x08, 0x41, 0x04, 0x10, 0x45, 0x14,
  0x51, 0x8A, 0x29, 0x9C, 0x86, 0x28, 0xA4, 0x92, 0x8C, 0x30, 0x42, 0x89,
  0x15, 0xAB, 0x5B, 0x36, 0x48, 0x33, 0x12, 0x14, 0x18, 0x18, 0x28, 0x64,
  0x44, 0x86, 0x29, 0x1C, 0x61, 0x04, 0x10, 0x3E, 0x04, 0x10, 0x41, 0x04,
  0x10, 0x3E, 0x1C, 0x42, 0x08, 0x20, 0x84, 0x10, 0x41, 0x0F, 0x00, 0xAA,
  0xAB, 0x54, 0x1C, 0x10, 0x42, 0x08, 0x20, 0x84, 0x10, 0x4F, 0x00, 0x18,
  0xA6, 0xB1, 0xFC, 0x4C, 0x3D, 0x28, 0xA2, 0x9B, 0xE0, 0x20, 0x84, 0x1E,
  0x4D, 0x38, 0xA6, 0xF0, 0x39, 0x08, 0x20, 0x81, 0xE0, 0x04, 0x08, 0x11,
  0xE4, 0xD1, 0xA2, 0x44, 0x78, 0x39, 0x38, 0xBC, 0x81, 0xE0, 0x07, 0x08,
  0x08, 0x3E, 0x10, 0x10, 0x10, 0x10, 0x20, 0x20, 0xE0, 0x1E, 0x45, 0x92,
  0x24, 0x47, 0x82, 0x7C, 0x22, 0x10, 0xF4, 0xE6, 0x31, 0x90, 0x22, 0x0E,
  0x44, 0x44, 0x60, 0x04, 0x08, 0x00, 0xE0, 0x40, 0x82, 0x04, 0x08, 0x23,
  0xC0, 0x20, 0x84, 0x13, 0x51, 0x8B, 0x24, 0x88, 0xE2, 0x24, 0x44, 0x44,
  0x70, 0x3E, 0x55, 0x4A, 0xA4, 0x48, 0x80, 0x7A, 0x53, 0x98, 0xC4, 0x39,
  0x38, 0xE2, 0x89, 0xC0, 0x3C, 0x4C, 0x9A, 0x24, 0xCF, 0x10, 0x40, 0x3D,
  0x38, 0xA2, 0x89, 0xC1, 0x04, 0x3D, 0x04, 0x10, 0x42, 0x00, 0x39, 0x06,
  0x06, 0x0B, 0xC0, 0x22, 0x3E, 0x84, 0x42, 0x0E, 0x4D, 0x28, 0xA2, 0x99,
  0xE0, 0x8C, 0xA5, 0x4A, 0x60, 0x85, 0x2A, 0xD6, 0xCD, 0x92, 0x00, 0x26,
  0x28, 0x60, 0xC2, 0x88, 0x80, 0x22, 0x48, 0x91, 0x41, 0x82, 0x0C, 0x70,
  0x7C, 0x63, 0x18, 0xC3, 0xC0, 0x1C, 0x41, 0x08, 0x23, 0x04, 0x10, 0x41,
  0x07, 0x00, 0x12, 0x22, 0x24, 0x44, 0x48, 0x80, 0x18, 0x10, 0x82, 0x08,
  0x31, 0x84, 0x10, 0x4E, 0x00, 0x66, 0x60,
};

const GFXglyph UbuntuMono_Italic13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 3, 8, 7, 2, -8 },
  { 4, 4, 3, 7, 3, -8 },
  { 6, 6, 8, 7, 1, -8 },
  { 12, 6, 10, 7, 1, -9 },
  { 20, 8, 8, 7, 0, -8 },
  { 28, 5, 8, 7, 1, -8 },
  { 33, 2, 3, 7, 4, -9 },
  { 34, 5, 11, 7, 2, -9 },
  { 41, 5, 11, 7, 1, -9 },
  { 48, 5, 5, 7, 2, -8 },
  { 52, 6, 5, 7, 1, -6 },
  { 56, 3, 4, 7, 1, -2 },
  { 58, 3, 1, 7, 2, -4 },
  { 59, 2, 2, 7, 2, -2 },
  { 60, 7, 11, 7, 0, -9 },
  { 70, 6, 8, 7, 1, -8 },
  { 76, 5, 8, 7, 1, -8 },
  { 81, 6, 8, 7, 1, -8 },
  { 87, 6, 8, 7, 1, -8 },
  { 93, 6, 8, 7, 1, -8 },
  { 99, 6, 8, 7, 1, -8 },
  { 105, 6, 8, 7, 1, -8 },
  { 111, 6, 8, 7, 2, -8 },
  { 117, 6, 8, 7, 1, -8 },
  { 123, 6, 8, 7, 1, -8 },
  { 129, 3, 6, 7, 2, -6 },
  { 132, 4, 8, 7, 1, -6 },
  { 136, 6, 5, 7, 1, -6 },
  { 140, 6, 4, 7, 1, -6 },
  { 143, 6, 5, 7, 1, -6 },
  { 147, 5, 8, 7, 2, -8 },
  { 152, 6, 10, 7, 1, -8 },
  { 160, 6, 8, 7, 0, -8 },
  { 166, 6, 8, 7, 1, -8 },
  { 172, 6, 8, 7, 1, -8 },
  { 178, 7, 8, 7, 0, -8 },
  { 185, 6, 8, 7, 1, -8 },
  { 191, 6, 8, 7, 1, -8 },
  { 197, 6, 8, 7, 1, -8 },
  { 203, 8, 8, 7, 0, -8 },
  { 211, 6, 8, 7, 1, -8 },
  { 217, 6, 8, 7, 1, -8 },
  { 223, 7, 8, 7, 1, -8 },
  { 230, 4, 8, 7, 1, -8 },
  { 234, 7, 8, 7, 0, -8 },
  { 241, 7, 8, 7, 1, -8 },
  { 248, 6, 8, 7, 1, -8 },
  { 254, 6, 8, 7, 1, -8 },
  { 260, 6, 10, 7, 1, -8 },
  { 268, 6, 8, 7, 1, -8 },
  { 274, 6, 8, 7, 1, -8 },
  { 280, 6, 8, 7, 2, -8 },
  { 286, 6, 8, 7, 1, -8 },
  { 292, 6, 8, 7, 2, -8 },
  { 298, 7, 8, 7, 1, -8 },
  { 305, 8, 8, 7, 0, -8 },
  { 313, 6, 8, 7, 2, -8 },
  { 319, 7, 8, 7, 0, -8 },
  { 326, 6, 11, 7, 1, -9 },
  { 335, 2, 11, 7, 3, -9 },
  { 338, 6, 11, 7, 0, -9 },
  { 347, 6, 4, 7, 1, -8 },
  { 350, 6, 1, 7, 0, 1 },
  { 351, 3, 2, 7, 3, -9 },
  { 352, 6, 6, 7, 1, -6 },
  { 357, 6, 9, 7, 1, -9 },
  { 364, 6, 6, 7, 1, -6 },
  { 369, 7, 9, 7, 1, -9 },
  { 377, 6, 6, 7, 1, -6 },
  { 382, 8, 11, 7, 0, -9 },
  { 393, 7, 8, 7, 0, -6 },
  { 400, 5, 9, 7, 1, -9 },
  { 406, 4, 9, 7, 2, -9 },
  { 411, 7, 11, 7, 0, -9 },
  { 421, 6, 9, 7, 1, -9 },
  { 428, 4, 9, 7, 2, -9 },
  { 433, 7, 6, 7, 0, -6 },
  { 439, 5, 6, 7, 1, -6 },
  { 443, 6, 6, 7, 1, -6 },
  { 448, 7, 8, 7, 0, -6 },
  { 455, 6, 8, 7, 1, -6 },
  { 461, 6, 6, 7, 1, -6 },
  { 466, 6, 6, 7, 1, -6 },
  { 471, 5, 8, 7, 2, -8 },
  { 476, 6, 6, 7, 1, -6 },
  { 481, 5, 6, 7, 2, -6 },
  { 485, 7, 6, 7, 1, -6 },
  { 491, 7, 6, 7, 0, -6 },
  { 497, 7, 8, 7, 0, -6 },
  { 504, 6, 6, 7, 1, -6 },
  { 509, 6, 11, 7, 1, -9 },
  { 518, 4, 11, 7, 2, -9 },
  { 524, 6, 11, 7, 0, -9 },
  { 533, 6, 2, 7, 1, -5 },
};

const GFXfont UbuntuMono_Italic13pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Italic13pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Italic13pt7bGlyphs,
  0x20, 0x7E, 13
};

#endif // _UBUNTUMONO_ITALIC13PT7B_H_
