#ifndef _UBUNTUMONO_ITALIC14PT7B_H_
#define _UBUNTUMONO_ITALIC14PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Italic.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Italic14pt7bBitmaps[] PROGMEM = {
  0x00, 0x32, 0x22, 0x24, 0x04, 0xC0, 0x59, 0xA0, 0x12, 0x29, 0xF9, 0x44,
  0x89, 0x3F, 0x48, 0xA0, 0x08, 0x78, 0x83, 0x03, 0x03, 0x03, 0x44, 0xF0,
  0x40, 0x80, 0x31, 0x2A, 0x54, 0x34, 0x08, 0x16, 0x2A, 0x4A, 0x8C, 0x38,
  0xA4, 0x8C, 0x66, 0x69, 0xA6, 0xE8, 0x5A, 0x08, 0x88, 0xC4, 0x42, 0x10,
  0x86, 0x10, 0x80, 0x10, 0x82, 0x10, 0x84, 0x22, 0x11, 0x11, 0x00, 0x27,
  0x4C, 0xA5, 0x00, 0x10, 0x41, 0x3F, 0x20, 0x82, 0x00, 0x22, 0x24, 0x70,
  0x48, 0x02, 0x02, 0x04, 0x04, 0x08, 0x18, 0x10, 0x20, 0x20, 0x40, 0x40,
  0x80, 0x1C, 0x94, 0x55, 0xF6, 0x18, 0xB6, 0x70, 0x08, 0xCA, 0x31, 0x08,
  0x42, 0xF8, 0x3C, 0x90, 0x41, 0x08, 0xC6, 0x30, 0xF8, 0x3C, 0x90, 0x43,
  0x30, 0x20, 0xC2, 0xF0, 0x0C, 0x73, 0xCA, 0x4A, 0x2F, 0xC4, 0x10, 0x1E,
  0x40, 0x83, 0x80, 0x81, 0x82, 0x04, 0xF0, 0x0E, 0x60, 0x83, 0xC4, 0x58,
  0xA1, 0x64, 0x70, 0x7C, 0x31, 0x84, 0x21, 0x84, 0x30, 0x80, 0x1C, 0x49,
  0x13, 0x23, 0x89, 0xA1, 0x44, 0x70, 0x3D, 0x94, 0x51, 0x44, 0xF0, 0x84,
  0xE0, 0x32, 0x00, 0x04, 0x40, 0x18, 0x80, 0x00, 0x10, 0x84, 0x40, 0x04,
  0xEC, 0x1C, 0x08, 0x7C, 0x00, 0x3F, 0x40, 0xE0, 0x5E, 0x80, 0x78, 0x42,
  0x22, 0x20, 0x18, 0xC0, 0x1C, 0x45, 0x0A, 0xFB, 0x54, 0xA9, 0x4E, 0x80,
  0x81, 0xC0, 0x0C, 0x18, 0x50, 0xA2, 0x44, 0x9F, 0x23, 0x86, 0x3D, 0x14,
  0x51, 0x7B, 0x38, 0x62, 0xF0, 0x1E, 0x45, 0x02, 0x0C, 0x10, 0x20, 0x24,
  0x78, 0x3C, 0x44, 0x89, 0x12, 0x28, 0x51, 0xA6, 0x78, 0x3E, 0x40, 0x82,
  0x07, 0x88, 0x10, 0x60, 0xF8, 0x3E, 0x40, 0x82, 0x07, 0xC8, 0x10, 0x60,
  0x80, 0x1C, 0x45, 0x02, 0x08, 0x10, 0xA3, 0x64, 0x78, 0x31, 0x21, 0x22,
  0x22, 0x3E, 0x62, 0x46, 0x44, 0x44, 0x3C, 0x30, 0x40, 0x81, 0x06, 0x08,
  0x10, 0xF8, 0x1E, 0x08, 0x10, 0x20, 0x41, 0x02, 0x4C, 0xF0, 0x26, 0xD9,
  0x22, 0x86, 0x1E, 0x24, 0x44, 0x88, 0x23, 0x10, 0x84, 0x22, 0x10, 0xF8,
  0x13, 0x33, 0x35, 0x36, 0x5A, 0x4A, 0x42, 0x42, 0x84, 0x22, 0xC5, 0x9A,
  0xA5, 0x52, 0xA5, 0x44, 0x88, 0x1C, 0x49, 0x1A, 0x38, 0x50, 0xA1, 0x64,
  0x70, 0x3C, 0xC9, 0x1A, 0x24, 0x4F, 0x30, 0x40, 0x80, 0x1C, 0x49, 0x1A,
  0x38, 0x50, 0xA1, 0x64, 0x70, 0x40, 0x60, 0x3D, 0x14, 0x51, 0x7B, 0x48,
  0xA2, 0x88, 0x3E, 0x41, 0x81, 0x03, 0x81, 0x03, 0x44, 0xF0, 0xFC, 0xC2,
  0x08, 0x21, 0x84, 0x10, 0x40, 0x62, 0x85, 0x12, 0x24, 0x50, 0xA3, 0x44,
  0x70, 0x85, 0x0A, 0x24, 0x49, 0x12, 0x28, 0x50, 0xC0, 0x42, 0x85, 0x0A,
  0xAB, 0x56, 0xB5, 0x64, 0x88, 0x11, 0x09, 0x86, 0x81, 0x80, 0x80, 0xE0,
  0x90, 0xC8, 0x46, 0x00, 0x85, 0x09, 0x22, 0x85, 0x0C, 0x18, 0x20, 0x40,
  0x1F, 0x02, 0x04, 0x0C, 0x18, 0x10, 0x20, 0x40, 0x7C, 0x1E, 0x20, 0x41,
  0x82, 0x04, 0x08, 0x30, 0x40, 0x81, 0x07, 0x80, 0xAB, 0xF5, 0x55, 0x1E,
  0x08, 0x10, 0x20, 0xC1, 0x02, 0x04, 0x18, 0x20, 0x47, 0x80, 0x31, 0x93,
  0x18, 0x80, 0xFC, 0xA4, 0x3D, 0x9C, 0x62, 0x8A, 0x27, 0x80, 0x20, 0x82,
  0x1E, 0x45, 0x14, 0x63, 0x9B, 0xC0, 0x3D, 0x8C, 0x20, 0x83, 0x07, 0x80,
  0x02, 0x04, 0x19, 0xF6, 0x48, 0xA3, 0x46, 0x8C, 0xF0, 0x3D, 0x18, 0xFE,
  0x83, 0x07, 0x80, 0x07, 0x08, 0x08, 0x3F, 0x08, 0x18, 0x10, 0x10, 0x10,
  0x10, 0x20, 0xE0, 0x0E, 0x64, 0x8B, 0x14, 0x4D, 0x8D, 0x04, 0xF8, 0x20,
  0x84, 0x1E, 0x4D, 0x3C, 0xA2, 0x8A, 0x20, 0x32, 0x0E, 0x26, 0x44, 0x47,
  0x06, 0x0C, 0x00, 0xF0, 0x40, 0x81, 0x06, 0x08, 0x10, 0x27, 0x80, 0x20,
  0x40, 0x83, 0x24, 0x8A, 0x18, 0x68, 0x99, 0x10, 0x72, 0x22, 0x24, 0x44,
  0x47, 0x3E, 0x55, 0x2A, 0xD4, 0x28, 0x91, 0x00, 0x79, 0x14, 0x51, 0xCA,
  0x28, 0x80, 0x39, 0x14, 0x61, 0x8E, 0x27, 0x00, 0x3C, 0x44, 0x89, 0x16,
  0x68, 0x9E, 0x20, 0xC0, 0x3D, 0x94, 0x63, 0x8A, 0x27, 0x86, 0x10, 0x3C,
  0x84, 0x10, 0x41, 0x0C, 0x00, 0x3D, 0x86, 0x0E, 0x0A, 0x2F, 0x00, 0x21,
  0x3E, 0x84, 0x21, 0x18, 0x70, 0x45, 0x14, 0x72, 0x8A, 0x27, 0x80, 0x8C,
  0x65, 0x2A, 0x71, 0x00, 0x43, 0x86, 0x55, 0xAB, 0x5B, 0x26, 0x00, 0x22,
  0x16, 0x14, 0x18, 0x18, 0x2C, 0x44, 0x22, 0x22, 0x26, 0x34, 0x14, 0x18,
  0x18, 0x30, 0xE0, 0x7C, 0x21, 0x08, 0x63, 0x0F, 0x80, 0x0E, 0x20, 0x40,
  0x83, 0x1C, 0x08, 0x10, 0x60, 0x81, 0x03, 0x80, 0x11, 0x32, 0x22, 0x64,
  0x44, 0x48, 0x1C, 0x08, 0x10, 0x20, 0x81, 0xC2, 0x04, 0x10, 0x20, 0x47,
  0x00, 0x66, 0x60,
};

const GFXglyph UbuntuMono_Italic14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 4, 9, 7, 2, -9 },
  { 6, 4, 3, 7, 3, -9 },
  { 8, 7, 9, 7, 1, -9 },
  { 16, 7, 11, 7, 1, -10 },
  { 26, 8, 9, 7, 0, -9 },
  { 35, 6, 9, 7, 1, -9 },
  { 42, 2, 4, 7, 4, -10 },
  { 43, 5, 12, 7, 2, -10 },
  { 51, 5, 12, 7, 1, -10 },
  { 59, 5, 5, 7, 2, -9 },
  { 63, 6, 7, 7, 1, -7 },
  { 69, 4, 4, 7, 1, -2 },
  { 71, 4, 1, 7, 2, -4 },
  { 72, 3, 2, 7, 2, -2 },
  { 73, 8, 12, 7, 0, -10 },
  { 85, 6, 9, 7, 1, -9 },
  { 92, 5, 9, 7, 1, -9 },
  { 98, 6, 9, 7, 1, -9 },
  { 105, 6, 9, 7, 1, -9 },
  { 112, 6, 9, 7, 1, -9 },
  { 119, 7, 9, 7, 1, -9 },
  { 127, 7, 9, 7, 1, -9 },
  { 135, 6, 9, 7, 2, -9 },
  { 142, 7, 9, 7, 1, -9 },
  { 150, 6, 9, 7, 1, -9 },
  { 157, 4, 7, 7, 2, -7 },
  { 161, 5, 9, 7, 1, -7 },
  { 167, 6, 5, 7, 1, -6 },
  { 171, 6, 4, 7, 1, -6 },
  { 174, 6, 5, 7, 1, -7 },
  { 178, 5, 9, 7, 2, -9 },
  { 184, 7, 11, 7, 1, -9 },
  { 194, 7, 9, 7, 0, -9 },
  { 202, 6, 9, 7, 1, -9 },
  { 209, 7, 9, 7, 1, -9 },
  { 217, 7, 9, 7, 0, -9 },
  { 225, 7, 9, 7, 1, -9 },
  { 233, 7, 9, 7, 1, -9 },
  { 241, 7, 9, 7, 1, -9 },
  { 249, 8, 9, 7, 0, -9 },
  { 258, 7, 9, 7, 1, -9 },
  { 266, 7, 9, 7, 1, -9 },
  { 274, 7, 9, 7, 1, -9 },
  { 282, 5, 9, 7, 1, -9 },
  { 288, 8, 9, 7, 0, -9 },
  { 297, 7, 9, 7, 1, -9 },
  { 305, 7, 9, 7, 1, -9 },
  { 313, 7, 9, 7, 1, -9 },
  { 321, 7, 11, 7, 1, -9 },
  { 331, 6, 9, 7, 1, -9 },
  { 338, 7, 9, 7, 1, -9 },
  { 346, 6, 9, 7, 2, -9 },
  { 353, 7, 9, 7, 1, -9 },
  { 361, 7, 9, 7, 2, -9 },
  { 369, 7, 9, 7, 1, -9 },
  { 377, 9, 9, 7, 0, -9 },
  { 388, 7, 9, 7, 2, -9 },
  { 396, 8, 9, 7, 0, -9 },
  { 405, 7, 12, 7, 1, -10 },
  { 416, 2, 12, 7, 3, -10 },
  { 419, 7, 12, 7, 0, -10 },
  { 430, 5, 5, 7, 2, -9 },
  { 434, 6, 1, 7, 0, 1 },
  { 435, 2, 3, 7, 4, -10 },
  { 436, 6, 7, 7, 1, -7 },
  { 442, 6, 10, 7, 1, -10 },
  { 450, 6, 7, 7, 1, -7 },
  { 456, 7, 10, 7, 1, -10 },
  { 465, 6, 7, 7, 1, -7 },
  { 471, 8, 12, 7, 0, -10 },
  { 483, 7, 9, 7, 0, -7 },
  { 491, 6, 10, 7, 1, -10 },
  { 499, 4, 10, 7, 2, -10 },
  { 504, 7, 12, 7, 0, -10 },
  { 515, 7, 10, 7, 1, -10 },
  { 524, 4, 10, 7, 2, -10 },
  { 529, 7, 7, 7, 0, -7 },
  { 536, 6, 7, 7, 1, -7 },
  { 542, 6, 7, 7, 1, -7 },
  { 548, 7, 9, 7, 0, -7 },
  { 556, 6, 9, 7, 1, -7 },
  { 563, 6, 7, 7, 1, -7 },
  { 569, 6, 7, 7, 1, -7 },
  { 575, 5, 9, 7, 2, -9 },
  { 581, 6, 7, 7, 1, -7 },
  { 587, 5, 7, 7, 2, -7 },
  { 592, 7, 7, 7, 1, -7 },
  { 599, 8, 7, 7, 0, -7 },
  { 606, 8, 9, 7, 0, -7 },
  { 615, 6, 7, 7, 1, -7 },
  { 621, 7, 12, 7, 1, -10 },
  { 632, 4, 12, 7, 2, -10 },
  { 638, 7, 12, 7, 0, -10 },
  { 649, 6, 2, 7, 1, -6 },
};

const GFXfont UbuntuMono_Italic14pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Italic14pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Italic14pt7bGlyphs,
  0x20, 0x7E, 14
};

#endif // _UBUNTUMONO_ITALIC14PT7B_H_
