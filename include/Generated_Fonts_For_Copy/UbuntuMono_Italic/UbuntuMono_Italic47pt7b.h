#ifndef _UBUNTUMONO_ITALIC47PT7B_H_
#define _UBUNTUMONO_ITALIC47PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Italic.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Italic47pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xE0, 0x3C, 0x07, 0x81, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x3E,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x0E,
  0x01, 0xC0, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x7C, 0x1F,
  0x83, 0xF0, 0x7E, 0x07, 0x80, 0x3C, 0x3C, 0xF0, 0xE3, 0x83, 0x8E, 0x1E,
  0x78, 0x79, 0xE1, 0xC7, 0x07, 0x1C, 0x1C, 0x70, 0x61, 0x83, 0x86, 0x0E,
  0x38, 0x30, 0x00, 0x0F, 0x07, 0x80, 0x07, 0x03, 0x80, 0x07, 0x83, 0xC0,
  0x03, 0xC1, 0xC0, 0x01, 0xC1, 0xE0, 0x01, 0xE0, 0xE0, 0x00, 0xE0, 0xF0,
  0x00, 0xF0, 0x78, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xC0, 0x3C, 0x1E, 0x00, 0x1E, 0x0E, 0x00, 0x0E, 0x0F, 0x00, 0x0F, 0x07,
  0x00, 0x07, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x03, 0x83, 0xC0, 0x1F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x80, 0xE0, 0x70, 0x00, 0x70,
  0x78, 0x00, 0x78, 0x38, 0x00, 0x38, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x1C,
  0x0E, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x7F, 0x80, 0x07, 0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xF0, 0x38, 0x0F, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0xF8, 0x20, 0x03, 0xC1, 0xE0, 0x3E, 0x07, 0xFF, 0xF8, 0x1F, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x70, 0x0F, 0xE0,
  0x0E, 0x01, 0xFE, 0x01, 0xC0, 0x3C, 0xE0, 0x38, 0x03, 0x8E, 0x07, 0x80,
  0x70, 0xE0, 0xF0, 0x07, 0x0E, 0x1E, 0x00, 0x70, 0xE1, 0xC0, 0x07, 0x0E,
  0x38, 0x00, 0x70, 0xE7, 0x00, 0x07, 0x1C, 0xE0, 0x00, 0x73, 0xDE, 0x00,
  0x07, 0xFB, 0xC0, 0x00, 0x3F, 0x78, 0x00, 0x01, 0xE7, 0x3C, 0x00, 0x00,
  0xEF, 0xE0, 0x00, 0x1D, 0xFF, 0x00, 0x03, 0x9C, 0x70, 0x00, 0x7B, 0x87,
  0x00, 0x0F, 0x38, 0x70, 0x01, 0xE3, 0x87, 0x00, 0x1C, 0x70, 0x70, 0x03,
  0x87, 0x07, 0x00, 0x70, 0x70, 0xE0, 0x0E, 0x07, 0x0E, 0x01, 0xE0, 0x79,
  0xE0, 0x3C, 0x03, 0xFC, 0x07, 0x80, 0x3F, 0x80, 0x70, 0x01, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0xC0, 0x1E, 0x3E, 0x03, 0xC1,
  0xE0, 0x38, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1C, 0x07, 0x83, 0xC0, 0x78,
  0x78, 0x07, 0x8F, 0x80, 0x39, 0xF0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xE0, 0x70, 0xFF, 0x0F, 0x1E, 0xF0, 0xE3, 0xC7, 0x9E, 0x78, 0x3D, 0xE7,
  0x03, 0xDC, 0xF0, 0x1F, 0xCF, 0x00, 0xF8, 0xF0, 0x0F, 0x0F, 0x00, 0xF8,
  0xF0, 0x1F, 0x8F, 0x87, 0xF8, 0x7F, 0xFB, 0xC3, 0xFE, 0x3C, 0x1F, 0x83,
  0xC0, 0x3C, 0xF3, 0xDE, 0x79, 0xE7, 0x9C, 0x73, 0xCE, 0x38, 0xE0, 0x00,
  0x01, 0x00, 0x00, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1C, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x38,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0x40, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x02, 0x0E, 0x0C,
  0xF1, 0xC7, 0x9F, 0xBB, 0xF3, 0xFF, 0xFE, 0x3F, 0xFF, 0x80, 0x1C, 0x00,
  0x07, 0xE0, 0x01, 0xDE, 0x00, 0x7B, 0xE0, 0x1E, 0x3C, 0x07, 0xC7, 0xC0,
  0x70, 0x70, 0x04, 0x04, 0x00, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x00,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x07, 0x83,
  0xF1, 0xFC, 0x7F, 0x1F, 0xC3, 0xF0, 0x38, 0x1E, 0x1F, 0x3F, 0x8F, 0x83,
  0x80, 0x7F, 0xEF, 0xFD, 0xFF, 0xFF, 0xF0, 0x3C, 0xFF, 0xFF, 0xFF, 0xCF,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x03,
  0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xC3, 0xE0, 0x7C, 0x0F, 0x07, 0xC0, 0x78,
  0x3C, 0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0x79, 0xE0, 0x03, 0xCF, 0x00,
  0x1E, 0x70, 0xE1, 0xE7, 0x8F, 0x8F, 0x3C, 0x7C, 0x79, 0xE3, 0xE3, 0xDE,
  0x1F, 0x1E, 0xF0, 0x71, 0xE7, 0x80, 0x0F, 0x3C, 0x00, 0x79, 0xE0, 0x07,
  0x8F, 0x00, 0x3C, 0x78, 0x03, 0xC3, 0xC0, 0x1E, 0x1E, 0x01, 0xE0, 0xF8,
  0x1E, 0x03, 0xC3, 0xE0, 0x1F, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x07, 0xF0, 0x0F, 0xF0,
  0x1F, 0xF8, 0x1F, 0xBC, 0x0F, 0x1E, 0x06, 0x0E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x1F, 0xFF, 0xEF, 0xFF,
  0xEF, 0xFF, 0xF0, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0x00,
  0xF8, 0x3E, 0x03, 0x80, 0x78, 0x04, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0x80, 0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x03, 0x81, 0xF0, 0x10, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x0F, 0xF8, 0x00, 0x7F, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x40, 0x07, 0xC3, 0x80, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3D, 0xE0, 0x01, 0xE7, 0x00,
  0x0F, 0x3C, 0x00, 0x78, 0xF0, 0x03, 0xC3, 0xC0, 0x1E, 0x0E, 0x00, 0xF0,
  0x78, 0x07, 0x81, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1C, 0x07, 0x80, 0xF0,
  0x3C, 0x03, 0xC0, 0xE0, 0x0F, 0x07, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0xFF,
  0xFF, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80,
  0xC0, 0x7F, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x01, 0xFE, 0x00, 0x1F,
  0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0x79, 0xF8, 0x07, 0xFF, 0xF0, 0x3F, 0xFF,
  0xC3, 0xF0, 0x1F, 0x1E, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80, 0x1E, 0x3C,
  0x00, 0xF1, 0xC0, 0x07, 0x8E, 0x00, 0x3C, 0x70, 0x01, 0xE3, 0xC0, 0x1E,
  0x1E, 0x00, 0xF0, 0xF0, 0x0F, 0x03, 0xC1, 0xF8, 0x1F, 0xFF, 0x80, 0x7F,
  0xF0, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFC, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x07, 0xFF, 0x00, 0x7F, 0xFC, 0x07, 0xC1, 0xF0, 0x78, 0x07, 0x87,
  0xC0, 0x3C, 0x3C, 0x01, 0xE1, 0xE0, 0x0F, 0x0F, 0x00, 0x78, 0x78, 0x03,
  0xC3, 0xC0, 0x3C, 0x1F, 0x03, 0xC0, 0x7C, 0x7C, 0x01, 0xFF, 0xC0, 0x1F,
  0xF8, 0x01, 0xF7, 0xE0, 0x3E, 0x0F, 0x83, 0xE0, 0x3E, 0x1E, 0x00, 0xF1,
  0xE0, 0x03, 0xCF, 0x00, 0x1E, 0x78, 0x00, 0xE3, 0xC0, 0x0F, 0x1E, 0x00,
  0x78, 0xF0, 0x07, 0x87, 0xC0, 0xFC, 0x1F, 0xFF, 0xC0, 0x7F, 0xF8, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x00,
  0xFC, 0x3E, 0x07, 0xC0, 0x7C, 0x1E, 0x00, 0xF0, 0xF0, 0x03, 0xC3, 0xC0,
  0x0F, 0x0F, 0x00, 0x3C, 0x78, 0x00, 0xF1, 0xE0, 0x03, 0xC7, 0x80, 0x0F,
  0x1E, 0x00, 0x3C, 0x3C, 0x00, 0xF0, 0xF8, 0x1F, 0x81, 0xFF, 0xFE, 0x03,
  0xFF, 0xF8, 0x07, 0xF3, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00,
  0x0F, 0xF0, 0x07, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0x81, 0xF8, 0x3F, 0x87, 0xF0, 0xFC, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x7E, 0x1F, 0xC3,
  0xF8, 0x7E, 0x07, 0x80, 0x00, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x7F, 0x01,
  0xF8, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x0F, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x0F, 0xC0, 0x0E, 0x00, 0x78, 0x07, 0xC0, 0xFE, 0x03,
  0xE0, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x0F, 0x00, 0x03, 0xF0,
  0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xF0, 0x07, 0xF8, 0x00,
  0xFE, 0x00, 0x0F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0x78, 0x00, 0x01, 0x00, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xF8, 0x0C, 0x00, 0x00, 0x78, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0x80, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x01,
  0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x07, 0x80, 0x00,
  0x20, 0x00, 0x00, 0x07, 0xF8, 0x1F, 0xFE, 0x1F, 0xFF, 0x18, 0x1F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x70,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xF0, 0x07, 0xC1,
  0xF0, 0x1E, 0x01, 0xE0, 0x78, 0x01, 0xC1, 0xE0, 0x03, 0x87, 0x80, 0x07,
  0x0F, 0x00, 0x0E, 0x3C, 0x07, 0xFC, 0x78, 0x3F, 0xF9, 0xE0, 0xFF, 0xF3,
  0xC3, 0xE1, 0xC7, 0x0F, 0x07, 0x9E, 0x3C, 0x0F, 0x3C, 0x78, 0x1E, 0x70,
  0xE0, 0x38, 0xE3, 0xC0, 0xF3, 0xC7, 0x81, 0xE7, 0x8F, 0x03, 0xCF, 0x1E,
  0x07, 0x1E, 0x3C, 0x1E, 0x3C, 0x38, 0x3C, 0x78, 0x78, 0x78, 0xF0, 0x7F,
  0xE1, 0xE0, 0x7F, 0xC1, 0xC0, 0x7F, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x81, 0x00, 0x0F, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3B, 0xC0, 0x00, 0xF7, 0x80,
  0x03, 0xCF, 0x00, 0x07, 0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x38, 0x78, 0x00,
  0xF0, 0x70, 0x01, 0xC0, 0xE0, 0x07, 0x01, 0xC0, 0x1E, 0x03, 0x80, 0x38,
  0x07, 0x00, 0xF0, 0x0E, 0x01, 0xC0, 0x1E, 0x07, 0x80, 0x3C, 0x0F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE1, 0xE0, 0x03, 0xC3, 0x80, 0x07,
  0x8F, 0x00, 0x0F, 0x1C, 0x00, 0x1E, 0x78, 0x00, 0x3C, 0xE0, 0x00, 0x7B,
  0xC0, 0x00, 0xF7, 0x80, 0x01, 0xE0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF0, 0x1E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x70, 0x03, 0xC1,
  0xE0, 0x07, 0x83, 0xC0, 0x0E, 0x07, 0x80, 0x3C, 0x0E, 0x00, 0x78, 0x3C,
  0x01, 0xE0, 0x78, 0x0F, 0x80, 0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x07, 0xFF,
  0xF8, 0x0F, 0x01, 0xF8, 0x1E, 0x00, 0xF0, 0x38, 0x00, 0xF0, 0x70, 0x01,
  0xE1, 0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x87, 0x80, 0x0F, 0x0E, 0x00, 0x3C,
  0x3C, 0x00, 0xF8, 0x78, 0x03, 0xE0, 0xF0, 0x1F, 0x81, 0xFF, 0xFE, 0x07,
  0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xF8,
  0x03, 0xFF, 0xF8, 0x0F, 0xC1, 0xE0, 0x3E, 0x00, 0x80, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x7C, 0x00, 0x80, 0x7C, 0x0F, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0x80,
  0x0F, 0xFF, 0xC0, 0x1C, 0x0F, 0xC0, 0x78, 0x07, 0x80, 0xF0, 0x0F, 0x81,
  0xE0, 0x0F, 0x03, 0xC0, 0x1E, 0x0F, 0x00, 0x1C, 0x1E, 0x00, 0x3C, 0x3C,
  0x00, 0x78, 0x78, 0x00, 0xF0, 0xE0, 0x01, 0xC3, 0xC0, 0x07, 0x87, 0x80,
  0x0F, 0x0F, 0x00, 0x1E, 0x1C, 0x00, 0x3C, 0x78, 0x00, 0xF0, 0xF0, 0x01,
  0xE1, 0xE0, 0x03, 0xC3, 0x80, 0x0F, 0x0F, 0x00, 0x3E, 0x1E, 0x00, 0xF8,
  0x3C, 0x03, 0xE0, 0x78, 0x0F, 0x81, 0xE0, 0x7E, 0x03, 0xFF, 0xF8, 0x07,
  0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFE,
  0x01, 0xFF, 0xFE, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xE0, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0xFC, 0x0E, 0x07,
  0xC0, 0x08, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x78, 0xF0, 0x01, 0xE3, 0xC0,
  0x07, 0x8F, 0x00, 0x1E, 0x3C, 0x00, 0xF0, 0xF0, 0x03, 0xC3, 0xC0, 0x0F,
  0x0F, 0x00, 0x3C, 0x3E, 0x01, 0xE0, 0x7C, 0x07, 0x81, 0xF8, 0x1E, 0x03,
  0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x01, 0xC0, 0x07, 0x81,
  0xE0, 0x03, 0xC0, 0xF0, 0x01, 0xE0, 0x78, 0x01, 0xE0, 0x38, 0x00, 0xF0,
  0x3C, 0x00, 0x78, 0x1E, 0x00, 0x3C, 0x0F, 0x00, 0x3C, 0x07, 0x00, 0x1E,
  0x07, 0x80, 0x0F, 0x03, 0xC0, 0x07, 0x81, 0xE0, 0x07, 0x80, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3C, 0x00, 0xF0, 0x1C, 0x00,
  0x78, 0x1E, 0x00, 0x3C, 0x0F, 0x00, 0x1E, 0x07, 0x80, 0x1E, 0x03, 0x80,
  0x0F, 0x03, 0xC0, 0x07, 0x81, 0xE0, 0x03, 0xC0, 0xF0, 0x01, 0xC0, 0x78,
  0x01, 0xE0, 0x38, 0x00, 0xF0, 0x3C, 0x00, 0x78, 0x1E, 0x00, 0x38, 0x0F,
  0x00, 0x3C, 0x00, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x20, 0x0F, 0x80, 0xF0,
  0x7E, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xE0, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x0F, 0x01, 0xF0,
  0x03, 0xC0, 0xF8, 0x00, 0xF0, 0x7C, 0x00, 0x38, 0x3E, 0x00, 0x1E, 0x1F,
  0x00, 0x07, 0x8F, 0x80, 0x01, 0xE7, 0xC0, 0x00, 0x73, 0xE0, 0x00, 0x3D,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7B, 0xE0, 0x00, 0x1E, 0x7C, 0x00, 0x07, 0x8F, 0x00, 0x01, 0xC1, 0xE0,
  0x00, 0xF0, 0x7C, 0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x03, 0xE0, 0x03, 0x80,
  0x78, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF8, 0x07,
  0x80, 0x1E, 0x03, 0xC0, 0x07, 0x80, 0xF0, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xF0,
  0x00, 0x78, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x01,
  0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0xDC, 0x06, 0xE0, 0xFC, 0x07, 0x70,
  0xEE, 0x03, 0xB8, 0x77, 0x01, 0xDC, 0x73, 0x81, 0xCE, 0x39, 0xC0, 0xE3,
  0x39, 0xE0, 0x71, 0x9C, 0xE0, 0x78, 0xFC, 0x70, 0x38, 0x7C, 0x38, 0x1C,
  0x3E, 0x1C, 0x1E, 0x1E, 0x1E, 0x0F, 0x0F, 0x0F, 0x07, 0x00, 0x07, 0x07,
  0x80, 0x03, 0x83, 0xC0, 0x03, 0xC1, 0xE0, 0x01, 0xE0, 0xE0, 0x00, 0xF0,
  0xF0, 0x00, 0x70, 0x78, 0x00, 0x38, 0x38, 0x00, 0x3C, 0x1C, 0x00, 0x1E,
  0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x03, 0x80, 0xF0,
  0x03, 0xC0, 0xF8, 0x01, 0xE0, 0x7E, 0x00, 0xE0, 0x3F, 0x00, 0x70, 0x1F,
  0x80, 0x78, 0x1F, 0xE0, 0x3C, 0x0F, 0x70, 0x1C, 0x07, 0x38, 0x0E, 0x03,
  0x9C, 0x0F, 0x03, 0xCF, 0x07, 0x81, 0xE3, 0x83, 0x80, 0xE1, 0xC1, 0xC0,
  0x70, 0xE1, 0xE0, 0x78, 0x78, 0xF0, 0x3C, 0x1C, 0x70, 0x1C, 0x0E, 0x38,
  0x0E, 0x07, 0x1C, 0x0F, 0x03, 0xDE, 0x07, 0x80, 0xEF, 0x03, 0x80, 0x77,
  0x01, 0xC0, 0x3B, 0x81, 0xE0, 0x1F, 0xC0, 0xF0, 0x0F, 0xE0, 0x70, 0x03,
  0xE0, 0x38, 0x01, 0xF0, 0x3C, 0x00, 0xF8, 0x1E, 0x00, 0x7C, 0x0F, 0x00,
  0x3C, 0x00, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0x00, 0x7F, 0xFC, 0x07, 0xC3,
  0xE0, 0x78, 0x0F, 0x87, 0x80, 0x3C, 0x3C, 0x01, 0xE3, 0xC0, 0x0F, 0x3C,
  0x00, 0x39, 0xE0, 0x01, 0xCE, 0x00, 0x1E, 0xF0, 0x00, 0xF7, 0x80, 0x07,
  0xBC, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xF7, 0x80,
  0x07, 0xBC, 0x00, 0x3D, 0xE0, 0x03, 0xCF, 0x00, 0x1E, 0x78, 0x01, 0xE3,
  0xC0, 0x0F, 0x1E, 0x00, 0xF0, 0xF8, 0x0F, 0x03, 0xE1, 0xF0, 0x0F, 0xFF,
  0x00, 0x3F, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0xFF,
  0xC0, 0x3F, 0xFF, 0x80, 0xF0, 0x3F, 0x07, 0x80, 0x7C, 0x1E, 0x00, 0xF0,
  0x78, 0x01, 0xC1, 0xE0, 0x07, 0x0F, 0x00, 0x3C, 0x3C, 0x00, 0xF0, 0xF0,
  0x03, 0xC3, 0xC0, 0x0E, 0x0E, 0x00, 0x78, 0x78, 0x03, 0xC1, 0xE0, 0x3E,
  0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0x00, 0x7F, 0xFC, 0x07,
  0xC3, 0xE0, 0x78, 0x0F, 0x87, 0x80, 0x3C, 0x3C, 0x01, 0xE3, 0xC0, 0x0F,
  0x3C, 0x00, 0x39, 0xE0, 0x01, 0xCE, 0x00, 0x1E, 0xF0, 0x00, 0xF7, 0x80,
  0x07, 0xBC, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xF7,
  0x80, 0x07, 0xBC, 0x00, 0x3D, 0xE0, 0x03, 0xCF, 0x00, 0x1E, 0x78, 0x01,
  0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0xF0, 0xF8, 0x0F, 0x03, 0xE1, 0xF0, 0x0F,
  0xFF, 0x00, 0x7F, 0xF0, 0x00, 0xFE, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFC, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x0F,
  0xFF, 0xE0, 0x1E, 0x07, 0xE0, 0x3C, 0x03, 0xC0, 0x78, 0x03, 0xC0, 0xE0,
  0x07, 0x83, 0xC0, 0x0F, 0x07, 0x80, 0x1E, 0x0F, 0x00, 0x3C, 0x1C, 0x00,
  0xF0, 0x78, 0x01, 0xE0, 0xF0, 0x07, 0x81, 0xE0, 0x1F, 0x03, 0xC0, 0xFC,
  0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x70, 0x3C, 0x01,
  0xE0, 0x78, 0x03, 0xC0, 0x78, 0x07, 0x80, 0xF0, 0x0F, 0x01, 0xE0, 0x3C,
  0x01, 0xE0, 0x78, 0x03, 0xC0, 0xF0, 0x07, 0x81, 0xE0, 0x07, 0x87, 0x80,
  0x0F, 0x0F, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xFC, 0x07,
  0xFF, 0xF0, 0x1F, 0x80, 0xC0, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x40, 0x07, 0xC1, 0xE0, 0x3F, 0x03, 0xFF, 0xFC, 0x07, 0xFF,
  0xF0, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFC, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x1E, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x70, 0x78, 0x01, 0xE0, 0xE0, 0x03,
  0xC3, 0xC0, 0x07, 0x87, 0x80, 0x0F, 0x0F, 0x00, 0x3C, 0x1C, 0x00, 0x78,
  0x78, 0x00, 0xF0, 0xF0, 0x01, 0xE1, 0xE0, 0x07, 0x83, 0x80, 0x0F, 0x0F,
  0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0xF0, 0x70, 0x01, 0xE1, 0xE0,
  0x03, 0xC3, 0xC0, 0x07, 0x87, 0x80, 0x1E, 0x0F, 0x00, 0x3C, 0x1E, 0x00,
  0x78, 0x3C, 0x01, 0xE0, 0x78, 0x03, 0xC0, 0xF8, 0x0F, 0x00, 0xF8, 0x7E,
  0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x7B, 0xC0, 0x01, 0xF7, 0x80, 0x03, 0xCF, 0x00, 0x0F,
  0x8E, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0xF0, 0x78, 0x01, 0xC0,
  0xF0, 0x07, 0x81, 0xE0, 0x1E, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0xF0, 0x0F,
  0x01, 0xE0, 0x1E, 0x07, 0x80, 0x3C, 0x0F, 0x00, 0x78, 0x3C, 0x00, 0xF0,
  0x78, 0x01, 0xE1, 0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x8F, 0x00, 0x07, 0x1C,
  0x00, 0x0E, 0x78, 0x00, 0x1C, 0xE0, 0x00, 0x3B, 0xC0, 0x00, 0x77, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x07, 0x87, 0x80, 0x03, 0xC3, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xE0, 0xE0,
  0x00, 0xF0, 0x70, 0x00, 0x78, 0x78, 0x00, 0x38, 0x3C, 0x00, 0x1C, 0x1E,
  0x00, 0x1E, 0x0E, 0x00, 0x0E, 0x07, 0x00, 0x07, 0x07, 0x87, 0x87, 0x83,
  0xC3, 0xC3, 0xC1, 0xC3, 0xE1, 0xC0, 0xE3, 0xF0, 0xE0, 0x71, 0xF8, 0xF0,
  0x39, 0xCC, 0x70, 0x38, 0xE6, 0x38, 0x1C, 0xE3, 0x1C, 0x0E, 0x71, 0x9C,
  0x07, 0x70, 0xEE, 0x03, 0xB8, 0x77, 0x01, 0xB8, 0x3F, 0x01, 0xF8, 0x1F,
  0x80, 0xFC, 0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1E, 0x01,
  0xF0, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x1E, 0x00, 0xF8, 0x00, 0xF8, 0x07, 0x80, 0x03, 0xC0, 0x78, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x1E,
  0x3C, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1F,
  0x78, 0x00, 0x01, 0xF1, 0xC0, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0xF0, 0x78,
  0x00, 0x0F, 0x01, 0xC0, 0x00, 0xF8, 0x0F, 0x00, 0x0F, 0x80, 0x78, 0x00,
  0xF8, 0x03, 0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x78, 0x00, 0x78, 0x07, 0x80,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xEF, 0x00, 0x0F, 0xBC,
  0x00, 0x3C, 0x70, 0x01, 0xE1, 0xE0, 0x0F, 0x87, 0x80, 0x3C, 0x1E, 0x01,
  0xE0, 0x38, 0x0F, 0x00, 0xF0, 0x3C, 0x03, 0xC1, 0xE0, 0x07, 0x0F, 0x00,
  0x1E, 0x78, 0x00, 0x79, 0xC0, 0x00, 0xEF, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0x80,
  0x1F, 0xFC, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xFF, 0xC0,
  0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0xF1, 0xE3, 0xC3, 0x87, 0x8F, 0x1E,
  0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x1C, 0x3C, 0x78, 0xF1, 0xE3,
  0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE1, 0xC3, 0xC7, 0x8F, 0x1E, 0x3C,
  0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0,
  0x1F, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x01, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x03, 0xCE, 0x00, 0xF1, 0xE0, 0x3E,
  0x3C, 0x07, 0x83, 0x81, 0xE0, 0x78, 0x78, 0x0F, 0x1F, 0x00, 0xE7, 0xC0,
  0x1E, 0xF0, 0x03, 0xDC, 0x00, 0x39, 0x00, 0x04, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0x80, 0x20, 0x70, 0xF8, 0x7C, 0x3C, 0x1E, 0x0F,
  0x07, 0x02, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xE0,
  0xF0, 0x7C, 0x0F, 0x07, 0x80, 0x78, 0x78, 0x03, 0xC7, 0xC0, 0x1E, 0x3C,
  0x00, 0xF3, 0xE0, 0x0F, 0x1E, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80, 0x1E,
  0x78, 0x00, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80,
  0x1E, 0x1E, 0x00, 0xE0, 0xF0, 0x0F, 0x07, 0xC1, 0xF8, 0x1F, 0xFF, 0xE0,
  0x7F, 0xEF, 0x00, 0xFC, 0x78, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE7, 0xC0, 0x0F, 0xFF,
  0x80, 0x7F, 0xFE, 0x07, 0xE0, 0xF8, 0x3C, 0x03, 0xC1, 0xE0, 0x1E, 0x0E,
  0x00, 0x78, 0x70, 0x03, 0xC7, 0x80, 0x1E, 0x3C, 0x00, 0xF1, 0xC0, 0x07,
  0x8E, 0x00, 0x38, 0xF0, 0x03, 0xC7, 0x80, 0x1E, 0x3C, 0x00, 0xF1, 0xC0,
  0x0F, 0x1E, 0x00, 0xF8, 0xF0, 0x07, 0x87, 0x80, 0x7C, 0x3C, 0x0F, 0xC1,
  0xC1, 0xFC, 0x1F, 0xFF, 0x80, 0xFF, 0xF8, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xE0, 0x60, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xF0, 0x18, 0x0F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0xE0, 0x07, 0xFF,
  0xC0, 0x3F, 0xFF, 0x00, 0xFC, 0x3E, 0x03, 0xE0, 0x3C, 0x0F, 0x80, 0x78,
  0x3E, 0x01, 0xE0, 0x78, 0x03, 0xC1, 0xE0, 0x07, 0x83, 0xC0, 0x0F, 0x07,
  0x80, 0x1C, 0x1E, 0x00, 0x78, 0x3C, 0x00, 0xF0, 0x78, 0x01, 0xE0, 0xF0,
  0x03, 0x81, 0xE0, 0x07, 0x03, 0xC0, 0x1E, 0x07, 0x80, 0x3C, 0x0F, 0x00,
  0x78, 0x1F, 0x01, 0xF0, 0x1F, 0x0F, 0xE0, 0x3F, 0xFF, 0xC0, 0x3F, 0xF3,
  0x80, 0x1F, 0x87, 0x00, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0x00, 0xFF, 0xFC,
  0x0F, 0xC3, 0xE0, 0xF8, 0x0F, 0x0F, 0x80, 0x3C, 0x78, 0x01, 0xE7, 0x80,
  0x0F, 0x3C, 0x00, 0xF3, 0xC0, 0x0F, 0x9E, 0x00, 0xF8, 0xF0, 0x3F, 0xC7,
  0xFF, 0xF8, 0x7F, 0xFF, 0x03, 0xFF, 0x80, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x18, 0x0F,
  0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0x82, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x04, 0x3E, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x1F,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFC, 0x1E, 0x01, 0xF0, 0x1E, 0x03, 0xE0,
  0x1E, 0x07, 0xC0, 0x1E, 0x07, 0x80, 0x1C, 0x0F, 0x80, 0x3C, 0x0F, 0x00,
  0x3C, 0x0F, 0x00, 0x3C, 0x1E, 0x00, 0x38, 0x1E, 0x00, 0x78, 0x1E, 0x00,
  0x78, 0x1E, 0x00, 0x78, 0x1E, 0x00, 0x70, 0x1E, 0x00, 0xF0, 0x1E, 0x01,
  0xF0, 0x0F, 0x07, 0xF0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x01, 0xF9,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x40, 0x07, 0x80, 0x70, 0x1F, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0xBF, 0x80, 0x7F, 0xFC, 0x07, 0xFF,
  0xE0, 0x78, 0x1F, 0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0xF0, 0xF0,
  0x0F, 0x0E, 0x00, 0xF1, 0xE0, 0x0F, 0x1E, 0x00, 0xF1, 0xE0, 0x0F, 0x1C,
  0x01, 0xE3, 0xC0, 0x1E, 0x3C, 0x01, 0xE3, 0xC0, 0x1E, 0x38, 0x01, 0xE7,
  0x80, 0x3C, 0x78, 0x03, 0xC7, 0x80, 0x3C, 0x78, 0x03, 0xCF, 0x00, 0x38,
  0xF0, 0x07, 0x80, 0x00, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x87, 0xFE, 0x3F, 0xF8,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xE0, 0x07, 0xFC, 0x1F, 0xF0, 0x1F, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x01,
  0x00, 0x78, 0x03, 0x83, 0xE0, 0x0F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x03, 0xE0, 0x78, 0x0F, 0x80, 0xE0, 0x3E, 0x03, 0xC0, 0xF8, 0x07, 0x87,
  0xE0, 0x0F, 0x1F, 0x80, 0x1C, 0x7E, 0x00, 0x7B, 0xF0, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0x7C, 0x00, 0x1E, 0x7C, 0x00,
  0x3C, 0x78, 0x00, 0x78, 0x78, 0x01, 0xE0, 0xF8, 0x03, 0xC0, 0xF8, 0x07,
  0x80, 0xF0, 0x0F, 0x01, 0xF0, 0x1C, 0x01, 0xE0, 0x78, 0x03, 0xE0, 0xF0,
  0x03, 0xC0, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0x03, 0xC0, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x00, 0xF0, 0x67, 0xFF, 0x1F, 0xF8, 0x7F, 0x00, 0x01, 0xF8,
  0x7C, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0x0F, 0x9E, 0x07, 0x0F,
  0x0E, 0x0F, 0x0F, 0x0E, 0x0F, 0x0E, 0x0E, 0x0F, 0x0E, 0x1E, 0x0E, 0x1E,
  0x1E, 0x0E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1C, 0x1E, 0x1C, 0x1C, 0x1C, 0x1C,
  0x3C, 0x1C, 0x3C, 0x3C, 0x3C, 0x00, 0x38, 0x3C, 0x00, 0x38, 0x38, 0x00,
  0x78, 0x38, 0x00, 0x78, 0x78, 0x00, 0x78, 0x78, 0x00, 0x70, 0x78, 0x00,
  0x70, 0x70, 0x00, 0xF0, 0x70, 0x00, 0xF0, 0x00, 0xFF, 0x00, 0x7F, 0xFC,
  0x07, 0xFF, 0xE0, 0xF0, 0x1F, 0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x0F, 0x00,
  0xF0, 0xE0, 0x0F, 0x1E, 0x00, 0xF1, 0xE0, 0x0F, 0x1E, 0x00, 0xF1, 0xC0,
  0x0E, 0x3C, 0x01, 0xE3, 0xC0, 0x1E, 0x3C, 0x01, 0xE3, 0xC0, 0x1E, 0x78,
  0x03, 0xC7, 0x80, 0x3C, 0x78, 0x03, 0xC7, 0x80, 0x3C, 0x70, 0x03, 0x8F,
  0x00, 0x78, 0xF0, 0x07, 0x80, 0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x07, 0xFF,
  0xC0, 0xF8, 0x3E, 0x1F, 0x01, 0xE1, 0xE0, 0x1E, 0x3C, 0x00, 0xF3, 0xC0,
  0x0F, 0x78, 0x00, 0xF7, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1E, 0xF0,
  0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x3C, 0xF0, 0x03, 0xCF,
  0x00, 0x78, 0xF0, 0x0F, 0x8F, 0x80, 0xF0, 0x7C, 0x3E, 0x07, 0xFF, 0xC0,
  0x3F, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0xE0, 0x0F,
  0xFF, 0xE0, 0x1E, 0x07, 0xE0, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0x80, 0xE0,
  0x07, 0x83, 0xC0, 0x0F, 0x07, 0x80, 0x1E, 0x0F, 0x00, 0x3C, 0x1E, 0x00,
  0x78, 0x78, 0x00, 0xE0, 0xF0, 0x03, 0xC1, 0xE0, 0x07, 0x83, 0xC0, 0x0F,
  0x0F, 0x00, 0x3C, 0x1E, 0x00, 0x78, 0x3C, 0x01, 0xE0, 0x78, 0x07, 0xC1,
  0xF0, 0x1F, 0x03, 0xC0, 0xFC, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x1F,
  0xF8, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xC1, 0xE0, 0xF8, 0x0F,
  0x0F, 0x80, 0x78, 0xF8, 0x07, 0x87, 0x80, 0x3C, 0x78, 0x01, 0xE3, 0xC0,
  0x0F, 0x1E, 0x00, 0x71, 0xE0, 0x07, 0x8F, 0x00, 0x3C, 0x78, 0x01, 0xE3,
  0xC0, 0x0F, 0x1E, 0x00, 0xF0, 0xF0, 0x07, 0x87, 0x80, 0x3C, 0x3C, 0x01,
  0xE1, 0xF0, 0x1E, 0x07, 0xC3, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xFC, 0x01,
  0xF9, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0xF8,
  0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x1F, 0xFE, 0x03, 0xFF, 0xE0, 0x7C, 0x04, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x84, 0x00, 0xF0,
  0x70, 0x1F, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x01, 0xFF, 0xFF, 0x7F, 0xFF, 0xDF, 0xFF, 0xE0, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x60, 0x7F,
  0xF8, 0x0F, 0xFE, 0x01, 0xFE, 0x00, 0x1E, 0x00, 0xF1, 0xE0, 0x0F, 0x1E,
  0x00, 0xF3, 0xC0, 0x0E, 0x3C, 0x01, 0xE3, 0xC0, 0x1E, 0x3C, 0x01, 0xE3,
  0x80, 0x1E, 0x78, 0x03, 0xC7, 0x80, 0x3C, 0x78, 0x03, 0xC7, 0x80, 0x3C,
  0xF0, 0x03, 0x8F, 0x00, 0x78, 0xF0, 0x07, 0x8F, 0x00, 0x78, 0xF0, 0x07,
  0x8F, 0x00, 0x70, 0xF0, 0x1F, 0x0F, 0x83, 0xF0, 0x7F, 0xFF, 0x83, 0xFF,
  0x78, 0x1F, 0xC7, 0x80, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0x78,
  0x01, 0xEF, 0x00, 0x78, 0xE0, 0x0F, 0x1E, 0x01, 0xC3, 0xC0, 0x78, 0x78,
  0x0E, 0x0F, 0x03, 0xC1, 0xE0, 0xF0, 0x3C, 0x1E, 0x07, 0x87, 0x80, 0xF0,
  0xF0, 0x0E, 0x3C, 0x01, 0xEF, 0x00, 0x3D, 0xE0, 0x07, 0xF8, 0x00, 0xFE,
  0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x1E,
  0xF0, 0x00, 0x3D, 0xE0, 0x00, 0x73, 0xC0, 0x01, 0xE7, 0x00, 0x03, 0xCE,
  0x07, 0x07, 0x1C, 0x1E, 0x1E, 0x38, 0x7C, 0x3C, 0xF0, 0xF8, 0x71, 0xE3,
  0xF1, 0xE3, 0xC7, 0xE3, 0x87, 0x9D, 0xC7, 0x0F, 0x3B, 0x9E, 0x1C, 0xE7,
  0x38, 0x39, 0xCE, 0xF0, 0x77, 0x1D, 0xC0, 0xEC, 0x1B, 0x81, 0xF8, 0x3F,
  0x03, 0xE0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x01, 0xE0, 0x1C, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x0F, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x3C, 0x01, 0xE0,
  0x7C, 0x00, 0xF0, 0xF8, 0x00, 0xF0, 0xF0, 0x00, 0x79, 0xE0, 0x00, 0x7B,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xF7, 0x80, 0x03, 0xE7,
  0x80, 0x07, 0xC3, 0xC0, 0x0F, 0x83, 0xC0, 0x1F, 0x01, 0xE0, 0x3E, 0x01,
  0xE0, 0x7C, 0x01, 0xF0, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x38,
  0x00, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x03, 0xC0, 0x0F, 0x00, 0xF0, 0x03, 0xC0, 0x3C, 0x00, 0xF0, 0x1E,
  0x00, 0x3C, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x78,
  0x38, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0x87, 0x00, 0x00, 0xF3, 0xC0, 0x00,
  0x3C, 0xE0, 0x00, 0x0F, 0x78, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x04, 0x1F, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xF8,
  0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0E,
  0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x00, 0x1C, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0x00, 0x63, 0xFC, 0x07, 0x7F, 0xE0, 0xF7, 0x1F,
  0x1E, 0xE0, 0x7F, 0xCE, 0x03, 0xF8, 0x40, 0x1F, 0x00,
};

const GFXglyph UbuntuMono_Italic47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 24, 0, -1 },
  { 1, 11, 29, 24, 8, -29 },
  { 41, 14, 12, 24, 10, -32 },
  { 62, 25, 29, 24, 2, -29 },
  { 153, 22, 38, 24, 3, -33 },
  { 258, 28, 29, 24, 0, -29 },
  { 360, 20, 29, 24, 3, -29 },
  { 433, 6, 13, 24, 14, -32 },
  { 443, 18, 41, 24, 7, -33 },
  { 536, 17, 41, 24, 3, -33 },
  { 624, 19, 17, 24, 6, -29 },
  { 665, 20, 21, 24, 4, -23 },
  { 718, 10, 12, 24, 5, -6 },
  { 733, 11, 4, 24, 8, -14 },
  { 739, 7, 6, 24, 8, -6 },
  { 745, 27, 41, 24, -1, -33 },
  { 884, 21, 29, 24, 4, -29 },
  { 961, 17, 29, 24, 4, -29 },
  { 1023, 22, 29, 24, 3, -29 },
  { 1103, 21, 29, 24, 3, -29 },
  { 1180, 22, 29, 24, 2, -29 },
  { 1260, 23, 29, 24, 3, -29 },
  { 1344, 21, 29, 24, 5, -29 },
  { 1421, 21, 29, 24, 7, -29 },
  { 1498, 21, 29, 24, 4, -29 },
  { 1575, 22, 29, 24, 3, -29 },
  { 1655, 11, 21, 24, 8, -21 },
  { 1684, 14, 27, 24, 5, -21 },
  { 1732, 20, 19, 24, 4, -21 },
  { 1780, 22, 12, 24, 3, -19 },
  { 1813, 21, 19, 24, 3, -22 },
  { 1863, 16, 29, 24, 8, -29 },
  { 1921, 23, 35, 24, 3, -29 },
  { 2022, 23, 29, 24, -1, -29 },
  { 2106, 23, 29, 24, 2, -29 },
  { 2190, 23, 29, 24, 4, -29 },
  { 2274, 23, 29, 24, 2, -29 },
  { 2358, 24, 29, 24, 3, -29 },
  { 2445, 24, 29, 24, 3, -29 },
  { 2532, 22, 29, 24, 4, -29 },
  { 2612, 25, 29, 24, 2, -29 },
  { 2703, 22, 29, 24, 3, -29 },
  { 2783, 23, 29, 24, 3, -29 },
  { 2867, 26, 29, 24, 2, -29 },
  { 2962, 17, 29, 24, 3, -29 },
  { 3024, 25, 29, 24, 1, -29 },
  { 3115, 25, 29, 24, 2, -29 },
  { 3206, 21, 29, 24, 4, -29 },
  { 3283, 22, 29, 24, 3, -29 },
  { 3363, 21, 37, 24, 4, -29 },
  { 3461, 23, 29, 24, 2, -29 },
  { 3545, 23, 29, 24, 3, -29 },
  { 3629, 21, 29, 24, 7, -29 },
  { 3706, 23, 29, 24, 4, -29 },
  { 3790, 23, 29, 24, 6, -29 },
  { 3874, 25, 29, 24, 3, -29 },
  { 3965, 29, 29, 24, 0, -29 },
  { 4071, 22, 29, 24, 7, -29 },
  { 4151, 25, 29, 24, 2, -29 },
  { 4242, 21, 41, 24, 5, -33 },
  { 4350, 7, 41, 24, 10, -33 },
  { 4386, 21, 41, 24, 1, -33 },
  { 4494, 19, 16, 24, 5, -29 },
  { 4532, 22, 3, 24, -1, 4 },
  { 4541, 8, 9, 24, 12, -33 },
  { 4550, 21, 24, 24, 3, -23 },
  { 4613, 21, 34, 24, 3, -33 },
  { 4703, 21, 24, 24, 3, -23 },
  { 4766, 23, 34, 24, 4, -33 },
  { 4864, 21, 24, 24, 3, -23 },
  { 4927, 28, 41, 24, 0, -33 },
  { 5071, 24, 31, 24, 1, -23 },
  { 5164, 20, 33, 24, 2, -33 },
  { 5247, 14, 31, 24, 6, -31 },
  { 5302, 23, 39, 24, 1, -31 },
  { 5415, 23, 33, 24, 3, -33 },
  { 5510, 13, 34, 24, 8, -33 },
  { 5566, 24, 23, 24, 1, -23 },
  { 5635, 20, 23, 24, 3, -23 },
  { 5693, 20, 24, 24, 4, -23 },
  { 5753, 23, 31, 24, 1, -23 },
  { 5843, 21, 31, 24, 4, -23 },
  { 5925, 21, 23, 24, 4, -23 },
  { 5986, 20, 24, 24, 4, -23 },
  { 6046, 18, 30, 24, 6, -29 },
  { 6114, 20, 23, 24, 4, -22 },
  { 6172, 19, 22, 24, 6, -22 },
  { 6225, 23, 22, 24, 4, -22 },
  { 6289, 24, 22, 24, 1, -22 },
  { 6355, 26, 30, 24, -1, -22 },
  { 6453, 21, 22, 24, 3, -22 },
  { 6511, 23, 41, 24, 4, -33 },
  { 6629, 14, 41, 24, 7, -33 },
  { 6701, 23, 41, 24, 0, -33 },
  { 6819, 20, 7, 24, 4, -16 },
};

const GFXfont UbuntuMono_Italic47pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Italic47pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Italic47pt7bGlyphs,
  0x20, 0x7E, 47
};

#endif // _UBUNTUMONO_ITALIC47PT7B_H_
