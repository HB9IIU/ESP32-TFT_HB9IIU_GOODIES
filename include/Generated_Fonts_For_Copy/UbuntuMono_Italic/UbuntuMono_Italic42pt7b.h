#ifndef _UBUNTUMONO_ITALIC42PT7B_H_
#define _UBUNTUMONO_ITALIC42PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Italic.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Italic42pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xC0, 0xF0, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0x78, 0x1C, 0x0F,
  0x03, 0xC0, 0xF0, 0x38, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x1F, 0x0F, 0xC3, 0xF0, 0xF8, 0x1C, 0x00, 0x38, 0x73,
  0x87, 0x78, 0xF7, 0x0E, 0x70, 0xE7, 0x0E, 0x60, 0xC6, 0x0C, 0xE1, 0xCC,
  0x18, 0x00, 0x1C, 0x3C, 0x00, 0xE0, 0xE0, 0x03, 0x83, 0x80, 0x1E, 0x1C,
  0x00, 0x70, 0x70, 0x01, 0xC3, 0xC0, 0x0E, 0x0E, 0x07, 0xFF, 0xFF, 0x1F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0x3C, 0x38, 0x00, 0xE0, 0xE0, 0x07, 0x87,
  0x00, 0x1C, 0x1C, 0x00, 0xF0, 0xF0, 0x03, 0x83, 0x80, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x0F, 0x0E, 0x00, 0x38, 0x38, 0x00, 0xE1,
  0xE0, 0x07, 0x07, 0x00, 0x1C, 0x1C, 0x00, 0xE0, 0xE0, 0x03, 0x83, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x3F, 0x80, 0x1F, 0xFE, 0x03, 0xFF, 0xE0, 0x7C, 0x0C, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x04, 0x00,
  0xF0, 0x70, 0x1F, 0x0F, 0xFF, 0xE0, 0x7F, 0xF8, 0x01, 0xFE, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xF0, 0x03, 0x80, 0xFC, 0x03, 0x80, 0xFE, 0x03, 0x80, 0xF3, 0x83,
  0x80, 0x71, 0xC3, 0xC0, 0x30, 0xE1, 0xC0, 0x38, 0x71, 0xC0, 0x1C, 0x31,
  0xC0, 0x0E, 0x39, 0xC0, 0x07, 0x3D, 0xC0, 0x03, 0xFD, 0xC0, 0x00, 0xFC,
  0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x00, 0xE7, 0x80, 0x00, 0xEF, 0xE0, 0x00,
  0xE7, 0xF0, 0x00, 0xE7, 0x38, 0x00, 0xE3, 0x0C, 0x00, 0x73, 0x86, 0x00,
  0x71, 0xC3, 0x00, 0x70, 0xE3, 0x80, 0x70, 0x71, 0xC0, 0x70, 0x39, 0xC0,
  0x70, 0x1F, 0xE0, 0x78, 0x07, 0xE0, 0x38, 0x01, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x1F, 0xF0, 0x07, 0xFE, 0x01, 0xE1, 0xC0, 0x38, 0x38, 0x0F, 0x07,
  0x01, 0xE0, 0xE0, 0x38, 0x3C, 0x07, 0x8F, 0x00, 0x73, 0xC0, 0x0F, 0xF0,
  0x01, 0xF8, 0x00, 0x7E, 0x0E, 0x1F, 0xC3, 0x87, 0xBC, 0x71, 0xE3, 0x9E,
  0x78, 0x7B, 0x8E, 0x07, 0xF1, 0xC0, 0x7C, 0x78, 0x0F, 0x8F, 0x00, 0xE1,
  0xE0, 0x7E, 0x1E, 0x1F, 0xC3, 0xFF, 0xBC, 0x3F, 0xE7, 0x83, 0xF0, 0x70,
  0x7B, 0xDE, 0xEF, 0x7B, 0x9C, 0xE6, 0x30, 0x00, 0x02, 0x00, 0x0E, 0x00,
  0x1F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38,
  0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x0E, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x70, 0x00,
  0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0xF8, 0x00, 0x70, 0x00, 0x60, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0x80, 0x43, 0x82, 0xF1, 0x9E, 0xFD, 0xFF, 0x7F, 0xFC, 0x03,
  0xC0, 0x07, 0xE0, 0x0E, 0x70, 0x1E, 0x78, 0x3C, 0x7C, 0x1C, 0x38, 0x08,
  0x10, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x07, 0x03, 0xE1, 0xF8, 0x7F, 0x0F,
  0x83, 0xE0, 0x78, 0x1C, 0x1F, 0x3F, 0x87, 0x81, 0x80, 0x7F, 0xDF, 0xF7,
  0xFC, 0x39, 0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0xC0, 0x3F,
  0xF8, 0x1E, 0x1E, 0x0F, 0x03, 0xC7, 0x80, 0xF1, 0xC0, 0x3C, 0xF0, 0x0F,
  0x38, 0x03, 0xDE, 0x00, 0xF7, 0x0C, 0x3D, 0xC7, 0x8F, 0xF3, 0xE3, 0xBC,
  0xF8, 0xEE, 0x3E, 0x7B, 0x87, 0x1E, 0xE0, 0x07, 0x38, 0x03, 0xCE, 0x00,
  0xE3, 0x80, 0x78, 0xE0, 0x3C, 0x3C, 0x1F, 0x0F, 0x0F, 0x81, 0xFF, 0xC0,
  0x7F, 0xE0, 0x07, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x3C, 0x01, 0xF8, 0x0F,
  0xE0, 0x7F, 0xC1, 0xFF, 0x83, 0xCF, 0x06, 0x1C, 0x00, 0x38, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0,
  0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xF8, 0x00, 0x7E, 0x00, 0x7F, 0xF0, 0x1F,
  0xFF, 0x03, 0xC1, 0xF0, 0x20, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x07, 0xFF, 0xF8, 0xFF, 0xFE, 0x1F, 0xFF, 0xC0, 0x00, 0x7E, 0x00, 0x7F,
  0xF0, 0x0F, 0xFF, 0x01, 0xC1, 0xE0, 0x20, 0x1C, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7E, 0x00, 0xFF,
  0x00, 0x1F, 0x80, 0x03, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E,
  0x10, 0x0F, 0x87, 0xFF, 0xE0, 0xFF, 0xF8, 0x07, 0xF8, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7B,
  0x80, 0x1E, 0x70, 0x07, 0x9E, 0x01, 0xE3, 0x80, 0x78, 0x70, 0x1E, 0x0E,
  0x07, 0x83, 0xC1, 0xE0, 0x70, 0x38, 0x0E, 0x0E, 0x01, 0xC3, 0xC0, 0x78,
  0x7F, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x00, 0x0F, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00,
  0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00,
  0x1C, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC1, 0x80, 0xFC,
  0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x03, 0xFC, 0x01, 0xFF, 0x80, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xE7, 0xE0, 0x3F,
  0xFF, 0x07, 0xFF, 0xF0, 0xF8, 0x1E, 0x3C, 0x01, 0xE7, 0x80, 0x3C, 0xF0,
  0x07, 0x9E, 0x00, 0xF3, 0x80, 0x1E, 0x78, 0x03, 0x8F, 0x00, 0xF1, 0xE0,
  0x3C, 0x1E, 0x0F, 0x83, 0xFF, 0xE0, 0x3F, 0xF8, 0x01, 0xF8, 0x00, 0x3F,
  0xFF, 0xE7, 0xFF, 0xF8, 0xFF, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0xE0, 0x7C, 0x1E, 0x07,
  0x80, 0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0xF0, 0xE0, 0x0E, 0x0E, 0x01, 0xE0,
  0xF0, 0x1C, 0x07, 0x87, 0xC0, 0x7E, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xE0,
  0x1F, 0x3F, 0x03, 0xC0, 0xF8, 0x78, 0x07, 0x87, 0x00, 0x38, 0x70, 0x03,
  0x8F, 0x00, 0x78, 0xF0, 0x07, 0x8F, 0x00, 0xF0, 0x78, 0x3F, 0x07, 0xFF,
  0xE0, 0x3F, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0xF0, 0x0F,
  0xFF, 0x03, 0xE1, 0xF0, 0xF0, 0x1E, 0x1C, 0x01, 0xC7, 0x80, 0x38, 0xE0,
  0x07, 0x1C, 0x00, 0xE3, 0x80, 0x1C, 0x70, 0x03, 0x8F, 0x00, 0xF1, 0xF0,
  0x3E, 0x1F, 0xFF, 0xC1, 0xFF, 0xF0, 0x1F, 0xDE, 0x00, 0x03, 0x80, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xFC,
  0x03, 0xFF, 0x00, 0xFF, 0x80, 0x1F, 0x80, 0x00, 0x07, 0x83, 0xE0, 0xFC,
  0x3F, 0x0F, 0x81, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x81, 0xF0, 0xFC, 0x3F, 0x0F, 0xC1, 0xE0, 0x00, 0xF0, 0x0F,
  0x80, 0x7E, 0x03, 0xF0, 0x1F, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x01, 0xF0, 0x1F,
  0x80, 0xFE, 0x03, 0xE0, 0x1F, 0x00, 0x78, 0x03, 0x80, 0x7C, 0x1F, 0xC0,
  0x78, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x03, 0xF0, 0x00, 0x70,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x70, 0x00, 0x02, 0x00, 0x3F, 0xFF, 0xE7,
  0xFF, 0xFC, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x9F, 0xFF, 0xF3, 0xFF, 0xFE, 0x00,
  0x18, 0x00, 0x07, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00,
  0x7F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xC0, 0x07, 0xE0, 0x07,
  0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0xC0, 0x03, 0xC0, 0x00,
  0x80, 0x00, 0x00, 0x07, 0xF0, 0x3F, 0xF0, 0x7F, 0xF0, 0xC1, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x00, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x07, 0xFC, 0x01, 0xFF, 0xE0,
  0x3E, 0x0F, 0x07, 0xC0, 0x70, 0xF0, 0x07, 0x0F, 0x00, 0x71, 0xE0, 0x07,
  0x1C, 0x00, 0x73, 0xC0, 0xFF, 0x38, 0x3F, 0xF7, 0x87, 0xFF, 0x70, 0xF8,
  0xE7, 0x1E, 0x0E, 0xF1, 0xC0, 0xEF, 0x1C, 0x1E, 0xE3, 0xC1, 0xCE, 0x3C,
  0x1C, 0xE3, 0x83, 0xCE, 0x3C, 0x3C, 0xE1, 0xE3, 0x8E, 0x1F, 0xF8, 0xE0,
  0xFF, 0x8F, 0x07, 0xF0, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0xEE, 0x00, 0x0F, 0x78, 0x00, 0x73, 0xC0, 0x07, 0x1E, 0x00, 0x38, 0x70,
  0x03, 0x83, 0x80, 0x1C, 0x1C, 0x01, 0xC0, 0xE0, 0x1E, 0x07, 0x00, 0xE0,
  0x38, 0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x83,
  0xFF, 0xFC, 0x1C, 0x00, 0xE1, 0xC0, 0x07, 0x8E, 0x00, 0x3C, 0xF0, 0x01,
  0xE7, 0x00, 0x0F, 0x78, 0x00, 0x7B, 0x80, 0x03, 0xC0, 0x03, 0xFF, 0x00,
  0x3F, 0xFC, 0x07, 0xFF, 0xE0, 0x78, 0x1F, 0x07, 0x00, 0xF0, 0x70, 0x0F,
  0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x0E, 0x00, 0xE0, 0xE0, 0x1E, 0x1E, 0x07,
  0xC1, 0xFF, 0xF8, 0x1F, 0xFE, 0x01, 0xFF, 0xF8, 0x1C, 0x07, 0xC3, 0xC0,
  0x3C, 0x38, 0x01, 0xC3, 0x80, 0x1C, 0x38, 0x01, 0xC7, 0x80, 0x1C, 0x70,
  0x03, 0xC7, 0x00, 0x78, 0x70, 0x1F, 0x8F, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0xFE, 0x03, 0xFF, 0xF0, 0x7E, 0x0E,
  0x0F, 0x80, 0x21, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x20, 0x7C, 0x0E, 0x03,
  0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x7E, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xF0,
  0x07, 0xFF, 0xC0, 0x70, 0x7C, 0x07, 0x01, 0xE0, 0xF0, 0x0E, 0x0F, 0x00,
  0xF0, 0xE0, 0x0F, 0x0E, 0x00, 0xF1, 0xE0, 0x0F, 0x1E, 0x00, 0xF1, 0xC0,
  0x0F, 0x1C, 0x00, 0xF3, 0xC0, 0x0F, 0x3C, 0x00, 0xE3, 0x80, 0x1E, 0x38,
  0x01, 0xE7, 0x80, 0x1C, 0x78, 0x03, 0xC7, 0x00, 0x78, 0x70, 0x0F, 0x8F,
  0x01, 0xF0, 0xF0, 0x7E, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xF8, 0x00,
  0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x0F, 0xFF,
  0x80, 0x70, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00,
  0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8,
  0x1F, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x07, 0xFF, 0x01,
  0xFF, 0xF0, 0x3E, 0x07, 0x07, 0x80, 0x20, 0xF0, 0x00, 0x1E, 0x00, 0x01,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x3C, 0x70, 0x03, 0xCF, 0x00, 0x38, 0xF0, 0x03,
  0x8F, 0x00, 0x78, 0xF0, 0x07, 0x87, 0x00, 0x70, 0x78, 0x07, 0x07, 0x80,
  0xF0, 0x3E, 0x0F, 0x03, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x7F, 0x80, 0x03,
  0x80, 0x1C, 0x1E, 0x00, 0xF0, 0x78, 0x03, 0xC1, 0xC0, 0x0E, 0x07, 0x00,
  0x38, 0x3C, 0x01, 0xE0, 0xF0, 0x07, 0x83, 0x80, 0x1C, 0x0E, 0x00, 0x70,
  0x78, 0x03, 0xC1, 0xE0, 0x0F, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x83, 0xC0, 0x1E, 0x0F, 0x00, 0x78, 0x38, 0x01, 0xC0, 0xE0, 0x07,
  0x07, 0x80, 0x3C, 0x1E, 0x00, 0xF0, 0x70, 0x03, 0x81, 0xC0, 0x0E, 0x0F,
  0x00, 0x78, 0x3C, 0x01, 0xE0, 0xE0, 0x07, 0x03, 0x80, 0x1C, 0x00, 0x03,
  0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x07, 0xFF, 0xC0, 0xFF,
  0xFC, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xF0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x04, 0x03, 0xE0, 0x70,
  0x7C, 0x0F, 0xFF, 0x80, 0x7F, 0xF0, 0x01, 0xFC, 0x00, 0x03, 0x80, 0x3C,
  0x07, 0x00, 0xF0, 0x0E, 0x03, 0xC0, 0x3C, 0x0F, 0x00, 0x70, 0x3C, 0x00,
  0xE0, 0xF0, 0x01, 0xC3, 0xC0, 0x07, 0x8F, 0x00, 0x0F, 0x3C, 0x00, 0x1C,
  0xF0, 0x00, 0x3B, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0x7C, 0x00, 0x1E, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x70, 0x78,
  0x00, 0xE0, 0xF0, 0x03, 0xC0, 0xF0, 0x07, 0x81, 0xE0, 0x0E, 0x01, 0xE0,
  0x1C, 0x03, 0xC0, 0x78, 0x03, 0xC0, 0xF0, 0x07, 0x81, 0xC0, 0x07, 0x00,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7F, 0xFF,
  0x7F, 0xFE, 0xFF, 0xFE, 0x00, 0xE0, 0x1C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x1F, 0x03, 0xE0, 0x7C, 0x0D, 0xC3, 0xF0, 0x37, 0x0D, 0xC1,
  0xDC, 0x76, 0x07, 0x73, 0x98, 0x19, 0xCC, 0xE0, 0xE7, 0x73, 0x83, 0x9D,
  0x8E, 0x0E, 0x3E, 0x38, 0x70, 0xF1, 0xC1, 0xC3, 0xC7, 0x07, 0x0E, 0x1C,
  0x3C, 0x00, 0x70, 0xE0, 0x01, 0xC3, 0x80, 0x0F, 0x0E, 0x00, 0x38, 0x78,
  0x00, 0xE1, 0xC0, 0x03, 0x87, 0x00, 0x1E, 0x3C, 0x00, 0x78, 0xE0, 0x01,
  0xC3, 0x80, 0x07, 0x00, 0x03, 0x80, 0x1C, 0x0F, 0x00, 0x70, 0x7C, 0x01,
  0xC1, 0xF0, 0x0E, 0x07, 0xE0, 0x38, 0x1F, 0x80, 0xE0, 0xEE, 0x03, 0x83,
  0x9C, 0x1E, 0x0E, 0x70, 0x70, 0x39, 0xC1, 0xC1, 0xE7, 0x07, 0x07, 0x0E,
  0x3C, 0x1C, 0x38, 0xE0, 0x70, 0xE3, 0x83, 0xC3, 0x8E, 0x0E, 0x06, 0x78,
  0x38, 0x1D, 0xC0, 0xE0, 0x77, 0x07, 0x81, 0xDC, 0x1C, 0x07, 0x70, 0x70,
  0x0F, 0x81, 0xC0, 0x3E, 0x07, 0x00, 0xF8, 0x38, 0x03, 0xE0, 0xE0, 0x0F,
  0x03, 0x80, 0x1C, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xF8, 0x03, 0xFF, 0xC0,
  0x7C, 0x3E, 0x07, 0x81, 0xE0, 0xF0, 0x0F, 0x1E, 0x00, 0xF1, 0xC0, 0x0F,
  0x3C, 0x00, 0xF3, 0x80, 0x0F, 0x38, 0x00, 0xF7, 0x80, 0x0E, 0x78, 0x00,
  0xE7, 0x00, 0x0E, 0x70, 0x01, 0xE7, 0x00, 0x1C, 0xF0, 0x01, 0xCF, 0x00,
  0x3C, 0xF0, 0x03, 0x8F, 0x00, 0x78, 0x70, 0x0F, 0x07, 0x81, 0xE0, 0x7C,
  0x3E, 0x03, 0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x07, 0x03, 0xE0, 0x78, 0x07, 0x83, 0xC0,
  0x3C, 0x1C, 0x01, 0xE0, 0xE0, 0x0F, 0x0F, 0x00, 0x70, 0x78, 0x03, 0x83,
  0x80, 0x3C, 0x1C, 0x03, 0xC1, 0xE0, 0x7C, 0x0F, 0xFF, 0xC0, 0x7F, 0xFC,
  0x03, 0xFF, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xF8, 0x03,
  0xFF, 0xC0, 0x7C, 0x3E, 0x07, 0x81, 0xE0, 0xF0, 0x0F, 0x1E, 0x00, 0xF1,
  0xC0, 0x0F, 0x3C, 0x00, 0xF3, 0x80, 0x0F, 0x38, 0x00, 0xF7, 0x80, 0x0E,
  0x78, 0x00, 0xE7, 0x00, 0x0E, 0x70, 0x01, 0xE7, 0x00, 0x1C, 0xF0, 0x01,
  0xCF, 0x00, 0x3C, 0xF0, 0x03, 0x8F, 0x00, 0x78, 0x70, 0x0F, 0x07, 0x81,
  0xF0, 0x7C, 0x3E, 0x03, 0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0xFE, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0x18, 0x00, 0x01, 0xFF, 0x00, 0x3F, 0xFC, 0x03, 0xFF,
  0xE0, 0x78, 0x1F, 0x07, 0x80, 0xF0, 0x70, 0x07, 0x07, 0x00, 0x70, 0xF0,
  0x07, 0x0F, 0x00, 0x70, 0xE0, 0x0F, 0x0E, 0x00, 0xE1, 0xE0, 0x1E, 0x1E,
  0x07, 0xC1, 0xFF, 0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0x3C, 0x3C, 0x03,
  0x81, 0xC0, 0x38, 0x1E, 0x07, 0x80, 0xE0, 0x78, 0x0E, 0x07, 0x00, 0xF0,
  0x70, 0x07, 0x0F, 0x00, 0x70, 0xF0, 0x07, 0x8E, 0x00, 0x78, 0x00, 0x3F,
  0xC0, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xC0, 0x60, 0x38, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x38, 0x10, 0x03, 0xC1, 0xE0, 0x7C, 0x0F, 0xFF,
  0xC0, 0x7F, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xF9,
  0xFF, 0xFF, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x38,
  0x78, 0x03, 0xC3, 0xC0, 0x1E, 0x1C, 0x00, 0xE0, 0xE0, 0x07, 0x0F, 0x00,
  0x78, 0x78, 0x03, 0xC3, 0x80, 0x1C, 0x1C, 0x00, 0xE1, 0xE0, 0x0F, 0x0F,
  0x00, 0x78, 0x70, 0x03, 0x83, 0x80, 0x1C, 0x3C, 0x01, 0xE1, 0xE0, 0x0F,
  0x0E, 0x00, 0x70, 0x70, 0x03, 0x87, 0x80, 0x3C, 0x3C, 0x01, 0xE1, 0xE0,
  0x0E, 0x07, 0x00, 0xF0, 0x3C, 0x0F, 0x01, 0xE0, 0xF8, 0x07, 0xFF, 0x80,
  0x1F, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0xE0, 0x00, 0xEE, 0x00, 0x1E, 0xE0,
  0x01, 0xEE, 0x00, 0x3C, 0xE0, 0x03, 0x8E, 0x00, 0x78, 0xE0, 0x07, 0x8E,
  0x00, 0xF0, 0xE0, 0x0E, 0x0E, 0x01, 0xE0, 0xF0, 0x1C, 0x0F, 0x03, 0xC0,
  0xF0, 0x38, 0x0F, 0x07, 0x80, 0xF0, 0x70, 0x0F, 0x0F, 0x00, 0x70, 0xE0,
  0x07, 0x1E, 0x00, 0x71, 0xC0, 0x07, 0x38, 0x00, 0x73, 0x80, 0x07, 0x70,
  0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0x00, 0x0E, 0x0E, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x70, 0x00, 0xE0, 0xE0,
  0x01, 0xC1, 0xC0, 0x07, 0x83, 0x80, 0x0E, 0x0F, 0x00, 0x1C, 0x1C, 0x00,
  0x38, 0x38, 0x00, 0xE0, 0x70, 0xE1, 0xC0, 0xE3, 0xC3, 0x83, 0x87, 0x87,
  0x07, 0x1F, 0x1C, 0x0E, 0x76, 0x38, 0x1C, 0xEC, 0x70, 0x3B, 0x99, 0xC0,
  0x66, 0x3B, 0x81, 0xDC, 0x77, 0x03, 0xB0, 0xEC, 0x07, 0xE1, 0xF8, 0x0D,
  0x83, 0xF0, 0x1F, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x0F, 0x00, 0xE0,
  0x1C, 0x00, 0x00, 0xE0, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x0F, 0x00, 0xF0,
  0x01, 0xC0, 0x78, 0x00, 0x78, 0x3C, 0x00, 0x1E, 0x0E, 0x00, 0x03, 0x87,
  0x00, 0x00, 0xF3, 0xC0, 0x00, 0x3D, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x78, 0xE0,
  0x00, 0x3E, 0x3C, 0x00, 0x0F, 0x07, 0x00, 0x07, 0x81, 0xC0, 0x03, 0xC0,
  0x78, 0x01, 0xE0, 0x1E, 0x00, 0xF8, 0x03, 0x80, 0x3C, 0x00, 0xF0, 0x1E,
  0x00, 0x3C, 0x00, 0xF0, 0x00, 0xFF, 0x00, 0x1E, 0x70, 0x01, 0xC7, 0x00,
  0x3C, 0x70, 0x07, 0x87, 0x80, 0x70, 0x78, 0x0F, 0x03, 0x81, 0xE0, 0x38,
  0x1C, 0x03, 0xC3, 0x80, 0x1C, 0x78, 0x01, 0xCF, 0x00, 0x1F, 0xE0, 0x00,
  0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x1F,
  0xFC, 0x03, 0xFF, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0xF1, 0xE3,
  0xC7, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C,
  0x78, 0x70, 0xE1, 0xC3, 0x87, 0x0F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC3,
  0x87, 0x0E, 0x1C, 0x38, 0x70, 0xF0, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x03,
  0xFF, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03,
  0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x3F, 0x80, 0x3D, 0xC0, 0x3C, 0xE0, 0x3C, 0x78, 0x1C,
  0x1C, 0x1E, 0x0E, 0x1E, 0x07, 0x9E, 0x01, 0xDE, 0x00, 0xEE, 0x00, 0x7B,
  0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x20, 0xE3,
  0xC3, 0xC3, 0xC3, 0xC3, 0x82, 0x00, 0x3F, 0x80, 0x3F, 0xF8, 0x1F, 0xFF,
  0x07, 0xE0, 0xE1, 0xF0, 0x3C, 0x7C, 0x07, 0x0F, 0x00, 0xE3, 0xC0, 0x1C,
  0x78, 0x07, 0x8E, 0x00, 0xF3, 0xC0, 0x1C, 0x78, 0x03, 0x8F, 0x00, 0xF1,
  0xC0, 0x1E, 0x3C, 0x03, 0x87, 0x80, 0x70, 0xF0, 0x1E, 0x0F, 0x0F, 0xC1,
  0xFF, 0xF8, 0x1F, 0xFF, 0x81, 0xF8, 0x70, 0x01, 0xC0, 0x00, 0xF0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x0F, 0x00, 0x03, 0xDF, 0x80, 0xFF, 0xF0, 0x3F, 0xFE, 0x1F, 0x07,
  0xC7, 0x80, 0xF1, 0xC0, 0x1C, 0x70, 0x07, 0x1C, 0x01, 0xCF, 0x00, 0x73,
  0x80, 0x1C, 0xE0, 0x0F, 0x38, 0x03, 0xDE, 0x00, 0xE7, 0x80, 0x79, 0xC0,
  0x3C, 0x70, 0x0F, 0x3C, 0x0F, 0x8F, 0x0F, 0xC3, 0xFF, 0xE0, 0xFF, 0xE0,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0xF0, 0x7F, 0xFC, 0x3F, 0x02,
  0x1F, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x01, 0x83, 0xFF, 0xE0, 0x7F, 0xF8,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xE0, 0x01, 0xFF, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0xFC,
  0x1C, 0x07, 0x80, 0xE0, 0x78, 0x0F, 0x07, 0x80, 0x78, 0x38, 0x03, 0x83,
  0xC0, 0x1C, 0x1E, 0x00, 0xE0, 0xE0, 0x0F, 0x0F, 0x00, 0x70, 0x78, 0x03,
  0x83, 0xC0, 0x1C, 0x1E, 0x01, 0xE0, 0xF0, 0x0F, 0x03, 0x80, 0xF8, 0x1E,
  0x0F, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0x70, 0x07, 0xE3, 0x80, 0x00, 0x7E,
  0x00, 0xFF, 0xE0, 0x7F, 0xF8, 0x3E, 0x0F, 0x1E, 0x01, 0xCF, 0x00, 0x73,
  0x80, 0x3D, 0xE0, 0x0F, 0x70, 0x07, 0xBC, 0x0F, 0xEF, 0xFF, 0xF3, 0xFF,
  0xF0, 0xFF, 0xC0, 0x38, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00,
  0x1F, 0x01, 0x83, 0xFF, 0xE0, 0x7F, 0xF8, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x78, 0x20, 0x00,
  0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x03,
  0xE0, 0xF0, 0x3C, 0x07, 0x03, 0xC0, 0x38, 0x3C, 0x03, 0xC1, 0xE0, 0x1E,
  0x1E, 0x00, 0xE0, 0xF0, 0x07, 0x07, 0x00, 0x78, 0x38, 0x03, 0xC1, 0xC0,
  0x1C, 0x0E, 0x00, 0xE0, 0x70, 0x0F, 0x03, 0xC1, 0xF8, 0x1F, 0xFF, 0x80,
  0x7F, 0xFC, 0x00, 0xFC, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x0C, 0x07, 0xC0, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x0F,
  0xF0, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xDF,
  0x80, 0xFF, 0xF0, 0x3F, 0xFE, 0x0F, 0x07, 0xC3, 0x80, 0xF1, 0xE0, 0x3C,
  0x78, 0x07, 0x1C, 0x03, 0xC7, 0x00, 0xF3, 0xC0, 0x3C, 0xF0, 0x0E, 0x38,
  0x03, 0x8E, 0x01, 0xE7, 0x80, 0x79, 0xE0, 0x1C, 0x70, 0x07, 0x1C, 0x03,
  0xCF, 0x00, 0xF3, 0xC0, 0x38, 0xE0, 0x0E, 0x00, 0x01, 0xC0, 0x3E, 0x07,
  0xE0, 0x7E, 0x03, 0xC0, 0x38, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0xFF,
  0x8F, 0xF8, 0x07, 0x80, 0x70, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x01, 0xE0, 0x1E, 0x01, 0xFF, 0x0F,
  0xF0, 0x3F, 0x00, 0x00, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x06, 0x0F, 0x80, 0xFF, 0xF0,
  0x0F, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x01, 0xE0, 0xE0, 0x3C,
  0x0E, 0x07, 0x81, 0xE1, 0xF0, 0x1E, 0x3E, 0x01, 0xC7, 0x80, 0x1D, 0xF0,
  0x03, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xBC, 0x00, 0x39, 0xE0, 0x07, 0x8F,
  0x00, 0x78, 0x78, 0x07, 0x07, 0x80, 0x70, 0x3C, 0x0F, 0x01, 0xE0, 0xF0,
  0x1E, 0x0E, 0x00, 0xF0, 0xE0, 0x0F, 0x00, 0xFF, 0x9F, 0xF3, 0xFE, 0x03,
  0xC0, 0x70, 0x0E, 0x03, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x78, 0x0F, 0x01,
  0xC0, 0x38, 0x0F, 0x01, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x80,
  0xE0, 0x1C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xE1, 0x3F, 0xE7, 0xFE, 0x3F,
  0x00, 0x03, 0xF1, 0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFE, 0x1C, 0x7C, 0xF0,
  0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0xF1, 0xE3, 0x87, 0x0E, 0x1C, 0x38,
  0x70, 0xE1, 0xC3, 0x87, 0x1E, 0x3C, 0x70, 0xE1, 0xC3, 0x80, 0x0E, 0x1C,
  0x00, 0x70, 0xE0, 0x07, 0x8F, 0x00, 0x38, 0x70, 0x01, 0xC3, 0x80, 0x0E,
  0x1C, 0x00, 0x71, 0xE0, 0x07, 0x00, 0x01, 0xFC, 0x03, 0xFF, 0xC0, 0xFF,
  0xF8, 0x38, 0x1E, 0x1E, 0x03, 0xC7, 0x80, 0xF1, 0xC0, 0x3C, 0x70, 0x0F,
  0x3C, 0x03, 0x8F, 0x00, 0xE3, 0x80, 0x38, 0xE0, 0x1E, 0x78, 0x07, 0x9E,
  0x01, 0xC7, 0x00, 0x71, 0xC0, 0x3C, 0xF0, 0x0F, 0x3C, 0x03, 0x8E, 0x00,
  0xE3, 0x80, 0x78, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x3E, 0x1F,
  0x1E, 0x03, 0xCF, 0x00, 0x73, 0xC0, 0x1C, 0xE0, 0x07, 0x78, 0x01, 0xDC,
  0x00, 0x77, 0x00, 0x3D, 0xC0, 0x0F, 0xF0, 0x03, 0xBC, 0x01, 0xEF, 0x00,
  0x7B, 0xC0, 0x3C, 0x70, 0x1E, 0x1E, 0x0F, 0x83, 0xFF, 0xC0, 0xFF, 0xC0,
  0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x78,
  0x1E, 0x07, 0x80, 0xF0, 0x70, 0x0F, 0x07, 0x00, 0x70, 0xF0, 0x07, 0x0F,
  0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0xF1, 0xE0, 0x0F, 0x1E, 0x00, 0xE1,
  0xE0, 0x1E, 0x1C, 0x01, 0xC3, 0xC0, 0x3C, 0x3C, 0x07, 0x83, 0xC1, 0xF0,
  0x3F, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x07, 0x80, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x3F, 0xFC, 0x0F, 0xFF, 0x83, 0xE0, 0xE0, 0xF0, 0x1C, 0x3C,
  0x07, 0x8F, 0x00, 0xF1, 0xC0, 0x1E, 0x78, 0x03, 0x8F, 0x00, 0x71, 0xC0,
  0x1E, 0x78, 0x03, 0xCF, 0x00, 0x71, 0xE0, 0x0E, 0x3C, 0x03, 0xC7, 0x80,
  0x78, 0x78, 0x0E, 0x0F, 0x87, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0xFD,
  0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xF8, 0x3C,
  0x02, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x7F, 0xF0, 0x7F, 0xF8, 0x1E, 0x06, 0x0F, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00,
  0x38, 0x40, 0x0E, 0x1C, 0x0F, 0x87, 0xFF, 0xC1, 0xFF, 0xE0, 0x1F, 0xE0,
  0x00, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07,
  0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x0E, 0x00, 0x0E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x18, 0x3F,
  0xF0, 0x1F, 0xF0, 0x0F, 0xE0, 0x3C, 0x03, 0xCF, 0x00, 0xE3, 0x80, 0x38,
  0xE0, 0x1E, 0x78, 0x07, 0x9E, 0x01, 0xC7, 0x00, 0x71, 0xC0, 0x3C, 0xF0,
  0x0F, 0x3C, 0x03, 0x8E, 0x00, 0xE3, 0x80, 0x78, 0xE0, 0x1E, 0x38, 0x07,
  0x0E, 0x01, 0xC3, 0x80, 0xF0, 0xF0, 0xFC, 0x3F, 0xFF, 0x07, 0xFD, 0xE0,
  0x7C, 0x38, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x1E,
  0xE0, 0x1C, 0xF0, 0x3C, 0xF0, 0x38, 0xF0, 0x70, 0xF0, 0xF0, 0xF0, 0xE0,
  0x71, 0xE0, 0x71, 0xC0, 0x73, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x39, 0xC0, 0x01, 0xCE, 0x00, 0x1C,
  0xF0, 0x00, 0xE7, 0x00, 0x07, 0x38, 0x38, 0x71, 0xC3, 0xC3, 0x8E, 0x1E,
  0x3C, 0x71, 0xF1, 0xC3, 0x8F, 0x8E, 0x1C, 0xEC, 0xE0, 0xEE, 0x67, 0x07,
  0x73, 0x78, 0x37, 0x1F, 0x83, 0xF0, 0xFC, 0x1F, 0x87, 0xC0, 0xF8, 0x3E,
  0x07, 0x81, 0xE0, 0x3C, 0x07, 0x00, 0x07, 0x80, 0x78, 0x0E, 0x03, 0xC0,
  0x3C, 0x0E, 0x00, 0x70, 0x70, 0x01, 0xE3, 0xC0, 0x03, 0x9E, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x7F, 0x80, 0x03, 0xCE, 0x00, 0x1E, 0x3C, 0x00, 0xF0, 0xF0, 0x07,
  0x81, 0xE0, 0x3C, 0x07, 0x81, 0xE0, 0x0E, 0x0F, 0x00, 0x3C, 0x00, 0x01,
  0xC0, 0x0E, 0x01, 0xC0, 0x1E, 0x01, 0xC0, 0x1E, 0x01, 0xE0, 0x1C, 0x01,
  0xE0, 0x3C, 0x01, 0xE0, 0x3C, 0x01, 0xE0, 0x38, 0x00, 0xE0, 0x78, 0x00,
  0xE0, 0x70, 0x00, 0xE0, 0xF0, 0x00, 0xF0, 0xE0, 0x00, 0xF1, 0xE0, 0x00,
  0x71, 0xC0, 0x00, 0x73, 0xC0, 0x00, 0x7B, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x41, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF,
  0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x7F, 0xFF, 0x0F, 0xFF, 0xC1,
  0xFF, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01,
  0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x3C,
  0x00, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x78, 0x07, 0x00, 0x70,
  0x07, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xC0,
  0x1C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x78, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x00,
  0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3F,
  0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07,
  0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0x0F, 0x00, 0xC7,
  0xF8, 0x18, 0xFF, 0x87, 0x38, 0xFF, 0xCE, 0x07, 0xF0, 0xC0, 0x7C, 0x00,
};

const GFXglyph UbuntuMono_Italic42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 21, 0, -1 },
  { 1, 10, 26, 21, 7, -26 },
  { 34, 12, 10, 21, 9, -29 },
  { 49, 22, 26, 21, 2, -26 },
  { 121, 20, 33, 21, 3, -29 },
  { 204, 25, 26, 21, 0, -26 },
  { 286, 19, 26, 21, 2, -26 },
  { 348, 5, 11, 21, 13, -29 },
  { 355, 16, 36, 21, 6, -29 },
  { 427, 16, 36, 21, 2, -29 },
  { 499, 16, 15, 21, 6, -26 },
  { 529, 17, 19, 21, 4, -21 },
  { 570, 10, 12, 21, 4, -6 },
  { 585, 10, 3, 21, 7, -12 },
  { 589, 6, 6, 21, 7, -6 },
  { 594, 24, 36, 21, -1, -29 },
  { 702, 18, 26, 21, 4, -26 },
  { 761, 15, 26, 21, 4, -26 },
  { 810, 19, 26, 21, 3, -26 },
  { 872, 19, 26, 21, 3, -26 },
  { 934, 19, 26, 21, 2, -26 },
  { 996, 21, 26, 21, 2, -26 },
  { 1065, 19, 26, 21, 4, -26 },
  { 1127, 19, 26, 21, 6, -26 },
  { 1189, 20, 26, 21, 3, -26 },
  { 1254, 19, 26, 21, 3, -26 },
  { 1316, 10, 20, 21, 7, -20 },
  { 1341, 13, 26, 21, 4, -20 },
  { 1384, 19, 17, 21, 3, -19 },
  { 1425, 19, 11, 21, 3, -17 },
  { 1452, 18, 17, 21, 3, -20 },
  { 1491, 15, 26, 21, 7, -26 },
  { 1540, 20, 32, 21, 3, -26 },
  { 1620, 21, 26, 21, -1, -26 },
  { 1689, 20, 26, 21, 2, -26 },
  { 1754, 20, 26, 21, 4, -26 },
  { 1819, 20, 26, 21, 2, -26 },
  { 1884, 21, 26, 21, 3, -26 },
  { 1953, 21, 26, 21, 3, -26 },
  { 2022, 20, 26, 21, 3, -26 },
  { 2087, 22, 26, 21, 2, -26 },
  { 2159, 20, 26, 21, 3, -26 },
  { 2224, 20, 26, 21, 3, -26 },
  { 2289, 23, 26, 21, 2, -26 },
  { 2364, 16, 26, 21, 2, -26 },
  { 2416, 22, 26, 21, 1, -26 },
  { 2488, 22, 26, 21, 2, -26 },
  { 2560, 20, 26, 21, 3, -26 },
  { 2625, 21, 26, 21, 2, -26 },
  { 2694, 20, 33, 21, 3, -26 },
  { 2777, 20, 26, 21, 2, -26 },
  { 2842, 21, 26, 21, 2, -26 },
  { 2911, 19, 26, 21, 6, -26 },
  { 2973, 21, 26, 21, 3, -26 },
  { 3042, 20, 26, 21, 6, -26 },
  { 3107, 23, 26, 21, 2, -26 },
  { 3182, 26, 26, 21, 0, -26 },
  { 3267, 20, 26, 21, 6, -26 },
  { 3332, 22, 26, 21, 2, -26 },
  { 3404, 19, 36, 21, 4, -29 },
  { 3490, 7, 36, 21, 9, -29 },
  { 3522, 19, 36, 21, 1, -29 },
  { 3608, 17, 14, 21, 5, -26 },
  { 3638, 19, 3, 21, -1, 4 },
  { 3646, 7, 8, 21, 11, -29 },
  { 3653, 19, 21, 21, 3, -20 },
  { 3703, 18, 30, 21, 3, -29 },
  { 3771, 18, 21, 21, 3, -20 },
  { 3819, 21, 30, 21, 3, -29 },
  { 3898, 18, 21, 21, 3, -20 },
  { 3946, 25, 36, 21, 0, -29 },
  { 4059, 21, 27, 21, 1, -20 },
  { 4130, 18, 29, 21, 2, -29 },
  { 4196, 12, 28, 21, 6, -28 },
  { 4238, 20, 35, 21, 1, -28 },
  { 4326, 20, 29, 21, 3, -29 },
  { 4399, 11, 30, 21, 8, -29 },
  { 4441, 21, 20, 21, 1, -20 },
  { 4494, 18, 20, 21, 3, -20 },
  { 4539, 18, 21, 21, 3, -20 },
  { 4587, 20, 27, 21, 1, -20 },
  { 4655, 19, 27, 21, 3, -20 },
  { 4720, 18, 20, 21, 4, -20 },
  { 4765, 18, 21, 21, 3, -20 },
  { 4813, 16, 26, 21, 6, -25 },
  { 4865, 18, 20, 21, 4, -19 },
  { 4910, 16, 19, 21, 6, -19 },
  { 4948, 21, 19, 21, 3, -19 },
  { 4998, 22, 19, 21, 1, -19 },
  { 5051, 24, 26, 21, -1, -19 },
  { 5129, 19, 19, 21, 2, -19 },
  { 5175, 20, 36, 21, 4, -29 },
  { 5265, 12, 36, 21, 6, -29 },
  { 5319, 20, 36, 21, 0, -29 },
  { 5409, 19, 6, 21, 3, -14 },
};

const GFXfont UbuntuMono_Italic42pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Italic42pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Italic42pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _UBUNTUMONO_ITALIC42PT7B_H_
