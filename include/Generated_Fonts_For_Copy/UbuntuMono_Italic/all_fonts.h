#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated_Fonts_For_Copy/UbuntuMono_Italic
// Headers: 67

#include "UbuntuMono_Italic6pt7b.h"
#include "UbuntuMono_Italic7pt7b.h"
#include "UbuntuMono_Italic8pt7b.h"
#include "UbuntuMono_Italic9pt7b.h"
#include "UbuntuMono_Italic10pt7b.h"
#include "UbuntuMono_Italic11pt7b.h"
#include "UbuntuMono_Italic12pt7b.h"
#include "UbuntuMono_Italic13pt7b.h"
#include "UbuntuMono_Italic14pt7b.h"
#include "UbuntuMono_Italic15pt7b.h"
#include "UbuntuMono_Italic16pt7b.h"
#include "UbuntuMono_Italic17pt7b.h"
#include "UbuntuMono_Italic18pt7b.h"
#include "UbuntuMono_Italic19pt7b.h"
#include "UbuntuMono_Italic20pt7b.h"
#include "UbuntuMono_Italic21pt7b.h"
#include "UbuntuMono_Italic22pt7b.h"
#include "UbuntuMono_Italic23pt7b.h"
#include "UbuntuMono_Italic24pt7b.h"
#include "UbuntuMono_Italic25pt7b.h"
#include "UbuntuMono_Italic26pt7b.h"
#include "UbuntuMono_Italic27pt7b.h"
#include "UbuntuMono_Italic28pt7b.h"
#include "UbuntuMono_Italic29pt7b.h"
#include "UbuntuMono_Italic30pt7b.h"
#include "UbuntuMono_Italic31pt7b.h"
#include "UbuntuMono_Italic32pt7b.h"
#include "UbuntuMono_Italic33pt7b.h"
#include "UbuntuMono_Italic34pt7b.h"
#include "UbuntuMono_Italic35pt7b.h"
#include "UbuntuMono_Italic36pt7b.h"
#include "UbuntuMono_Italic37pt7b.h"
#include "UbuntuMono_Italic38pt7b.h"
#include "UbuntuMono_Italic39pt7b.h"
#include "UbuntuMono_Italic40pt7b.h"
#include "UbuntuMono_Italic41pt7b.h"
#include "UbuntuMono_Italic42pt7b.h"
#include "UbuntuMono_Italic43pt7b.h"
#include "UbuntuMono_Italic44pt7b.h"
#include "UbuntuMono_Italic45pt7b.h"
#include "UbuntuMono_Italic46pt7b.h"
#include "UbuntuMono_Italic47pt7b.h"
#include "UbuntuMono_Italic48pt7b.h"
#include "UbuntuMono_Italic49pt7b.h"
#include "UbuntuMono_Italic50pt7b.h"
#include "UbuntuMono_Italic51pt7b.h"
#include "UbuntuMono_Italic52pt7b.h"
#include "UbuntuMono_Italic53pt7b.h"
#include "UbuntuMono_Italic54pt7b.h"
#include "UbuntuMono_Italic55pt7b.h"
#include "UbuntuMono_Italic56pt7b.h"
#include "UbuntuMono_Italic57pt7b.h"
#include "UbuntuMono_Italic58pt7b.h"
#include "UbuntuMono_Italic59pt7b.h"
#include "UbuntuMono_Italic60pt7b.h"
#include "UbuntuMono_Italic61pt7b.h"
#include "UbuntuMono_Italic62pt7b.h"
#include "UbuntuMono_Italic63pt7b.h"
#include "UbuntuMono_Italic64pt7b.h"
#include "UbuntuMono_Italic65pt7b.h"
#include "UbuntuMono_Italic66pt7b.h"
#include "UbuntuMono_Italic67pt7b.h"
#include "UbuntuMono_Italic68pt7b.h"
#include "UbuntuMono_Italic69pt7b.h"
#include "UbuntuMono_Italic70pt7b.h"
#include "UbuntuMono_Italic71pt7b.h"
#include "UbuntuMono_Italic72pt7b.h"
