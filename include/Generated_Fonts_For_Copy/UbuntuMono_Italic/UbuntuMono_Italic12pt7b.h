#ifndef _UBUNTUMONO_ITALIC12PT7B_H_
#define _UBUNTUMONO_ITALIC12PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Italic.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Italic12pt7bBitmaps[] PROGMEM = {
  0x00, 0x2D, 0x21, 0xB0, 0xB6, 0x80, 0x12, 0x29, 0xF9, 0x47, 0xCA, 0x14,
  0x00, 0x11, 0xD0, 0x83, 0x04, 0x7E, 0x40, 0x32, 0xA9, 0xA0, 0x82, 0xCA,
  0xA7, 0x00, 0x32, 0x54, 0xCE, 0xCB, 0xC0, 0xE0, 0x12, 0x4C, 0x88, 0x88,
  0x84, 0x21, 0x11, 0x11, 0x22, 0x48, 0x4D, 0x69, 0x11, 0x3E, 0x42, 0x00,
  0x6D, 0xE0, 0xE0, 0xF0, 0x04, 0x08, 0x20, 0x41, 0x04, 0x08, 0x20, 0x41,
  0x00, 0x3A, 0x53, 0x5A, 0xCB, 0x80, 0x13, 0x51, 0x22, 0xF0, 0x3A, 0x42,
  0x26, 0x63, 0xC0, 0x78, 0x42, 0x60, 0x8F, 0xC0, 0x19, 0x55, 0x2F, 0x88,
  0x80, 0x3C, 0x84, 0x1C, 0x18, 0x6F, 0x00, 0x1C, 0x84, 0x3E, 0x8A, 0x27,
  0x00, 0xF8, 0x88, 0x44, 0x42, 0x00, 0x3A, 0x52, 0xE8, 0xC7, 0xC0, 0x3A,
  0x52, 0xF1, 0x9B, 0x80, 0x6C, 0x0D, 0x80, 0x33, 0x00, 0x66, 0x6C, 0x0B,
  0xA0, 0xC1, 0x00, 0xF8, 0x3E, 0x41, 0x82, 0xE8, 0x00, 0x71, 0x24, 0x08,
  0x80, 0x39, 0x14, 0x6F, 0xAA, 0xE8, 0x20, 0x60, 0x08, 0x62, 0x89, 0x7D,
  0x18, 0x40, 0x7A, 0x53, 0xE8, 0xCF, 0xC0, 0x3D, 0x04, 0x20, 0x82, 0x07,
  0x00, 0x38, 0x92, 0x51, 0x45, 0x27, 0x00, 0x3D, 0x04, 0x1E, 0x42, 0x0F,
  0x00, 0x3D, 0x04, 0x1E, 0x42, 0x08, 0x00, 0x3D, 0x08, 0x20, 0x8A, 0x67,
  0x00, 0x22, 0x44, 0x93, 0xE4, 0x48, 0x92, 0x00, 0x38, 0x88, 0x42, 0x13,
  0xC0, 0x3C, 0x20, 0x82, 0x12, 0x4E, 0x00, 0x4D, 0x67, 0x30, 0xA2, 0x49,
  0x00, 0x44, 0x44, 0x88, 0xF0, 0x36, 0x68, 0xF2, 0xA4, 0x48, 0xA1, 0x00,
  0x22, 0x64, 0xD2, 0xA4, 0xC9, 0x92, 0x00, 0x3A, 0x63, 0x18, 0xC9, 0xC0,
  0x7A, 0x52, 0x9F, 0x42, 0x00, 0x3A, 0x63, 0x18, 0xCF, 0xC8, 0x30, 0x7A,
  0x53, 0xE9, 0x4A, 0x40, 0x39, 0x04, 0x0C, 0x08, 0x6F, 0x00, 0xF9, 0x10,
  0x84, 0x22, 0x00, 0x45, 0x28, 0xA2, 0x8A, 0x47, 0x00, 0x8C, 0x65, 0x4A,
  0x63, 0x00, 0x45, 0x18, 0xAA, 0xDB, 0x49, 0x00, 0x22, 0x28, 0x60, 0x82,
  0x8D, 0x11, 0x00, 0x8C, 0xA8, 0x84, 0x22, 0x00, 0x3E, 0x08, 0x20, 0x82,
  0x08, 0x1E, 0x00, 0x18, 0x82, 0x08, 0x21, 0x04, 0x10, 0x83, 0x80, 0xFF,
  0xC0, 0x1C, 0x20, 0x82, 0x08, 0x41, 0x04, 0x13, 0x80, 0x11, 0x53, 0x10,
  0xF8, 0x90, 0x3A, 0x63, 0x29, 0x78, 0x22, 0x1E, 0x94, 0xC6, 0x5C, 0x3A,
  0x21, 0x08, 0x38, 0x04, 0x13, 0x92, 0x8A, 0x29, 0xBE, 0x3A, 0x63, 0xE8,
  0x38, 0x0E, 0x20, 0xF0, 0x81, 0x02, 0x08, 0x10, 0x21, 0x80, 0x1C, 0x94,
  0x51, 0x49, 0xE0, 0xBC, 0x42, 0x1C, 0x98, 0xCA, 0x52, 0x6C, 0x64, 0x92,
  0x60, 0x04, 0x30, 0x0F, 0x08, 0x20, 0x82, 0x10, 0x4E, 0x00, 0x21, 0x04,
  0x9C, 0x42, 0x89, 0x24, 0xE5, 0x25, 0x23, 0x3D, 0x55, 0x55, 0x46, 0x20,
  0x72, 0x53, 0x19, 0x48, 0x3A, 0x63, 0x19, 0x70, 0x38, 0x94, 0x51, 0x49,
  0xC4, 0x20, 0x3A, 0x63, 0x19, 0x78, 0x42, 0x7A, 0x10, 0x88, 0x40, 0x3A,
  0x18, 0x21, 0x78, 0x44, 0xF4, 0x88, 0x8E, 0x4C, 0x63, 0x29, 0x78, 0x99,
  0xAA, 0xCC, 0x86, 0x9A, 0xB6, 0xD2, 0x40, 0x24, 0x50, 0x60, 0x82, 0x89,
  0x00, 0x24, 0x92, 0x4A, 0x28, 0x42, 0x30, 0x78, 0x88, 0x88, 0x78, 0x1C,
  0x42, 0x08, 0xC1, 0x04, 0x10, 0x41, 0x80, 0x24, 0xA4, 0x94, 0x90, 0x38,
  0x20, 0x82, 0x0C, 0x41, 0x04, 0x23, 0x80, 0x6D, 0xC0,
};

const GFXglyph UbuntuMono_Italic12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 3, 7, 6, 2, -7 },
  { 4, 3, 3, 6, 3, -7 },
  { 6, 7, 7, 6, 0, -7 },
  { 13, 5, 9, 6, 1, -8 },
  { 19, 7, 7, 6, 0, -7 },
  { 26, 5, 7, 6, 1, -7 },
  { 31, 1, 3, 6, 4, -8 },
  { 32, 4, 10, 6, 2, -8 },
  { 37, 4, 10, 6, 1, -8 },
  { 42, 4, 4, 6, 2, -7 },
  { 44, 5, 5, 6, 1, -6 },
  { 48, 3, 4, 6, 1, -2 },
  { 50, 3, 1, 6, 2, -4 },
  { 51, 2, 2, 6, 2, -2 },
  { 52, 7, 10, 6, 0, -8 },
  { 61, 5, 7, 6, 1, -7 },
  { 66, 4, 7, 6, 1, -7 },
  { 70, 5, 7, 6, 1, -7 },
  { 75, 5, 7, 6, 1, -7 },
  { 80, 5, 7, 6, 1, -7 },
  { 85, 6, 7, 6, 1, -7 },
  { 91, 6, 7, 6, 1, -7 },
  { 97, 5, 7, 6, 2, -7 },
  { 102, 5, 7, 6, 1, -7 },
  { 107, 5, 7, 6, 1, -7 },
  { 112, 3, 6, 6, 2, -6 },
  { 115, 4, 8, 6, 1, -6 },
  { 119, 5, 5, 6, 1, -6 },
  { 123, 5, 3, 6, 1, -4 },
  { 125, 5, 5, 6, 1, -6 },
  { 129, 4, 7, 6, 2, -7 },
  { 133, 6, 9, 6, 1, -7 },
  { 140, 6, 7, 6, 0, -7 },
  { 146, 5, 7, 6, 1, -7 },
  { 151, 6, 7, 6, 1, -7 },
  { 157, 6, 7, 6, 0, -7 },
  { 163, 6, 7, 6, 1, -7 },
  { 169, 6, 7, 6, 1, -7 },
  { 175, 6, 7, 6, 1, -7 },
  { 181, 7, 7, 6, 0, -7 },
  { 188, 5, 7, 6, 1, -7 },
  { 193, 6, 7, 6, 1, -7 },
  { 199, 6, 7, 6, 1, -7 },
  { 205, 4, 7, 6, 1, -7 },
  { 209, 7, 7, 6, 0, -7 },
  { 216, 7, 7, 6, 0, -7 },
  { 223, 5, 7, 6, 1, -7 },
  { 228, 5, 7, 6, 1, -7 },
  { 233, 5, 9, 6, 1, -7 },
  { 239, 5, 7, 6, 1, -7 },
  { 244, 6, 7, 6, 1, -7 },
  { 250, 5, 7, 6, 2, -7 },
  { 255, 6, 7, 6, 1, -7 },
  { 261, 5, 7, 6, 2, -7 },
  { 266, 6, 7, 6, 1, -7 },
  { 272, 7, 7, 6, 0, -7 },
  { 279, 5, 7, 6, 2, -7 },
  { 284, 7, 7, 6, 0, -7 },
  { 291, 6, 10, 6, 1, -8 },
  { 299, 1, 10, 6, 3, -8 },
  { 301, 6, 10, 6, 0, -8 },
  { 309, 5, 4, 6, 1, -7 },
  { 312, 5, 1, 6, 0, 1 },
  { 313, 2, 2, 6, 3, -8 },
  { 314, 5, 6, 6, 1, -6 },
  { 318, 5, 8, 6, 1, -8 },
  { 323, 5, 6, 6, 1, -6 },
  { 327, 6, 8, 6, 1, -8 },
  { 333, 5, 6, 6, 1, -6 },
  { 337, 7, 10, 6, 0, -8 },
  { 346, 6, 8, 6, 0, -6 },
  { 352, 5, 8, 6, 1, -8 },
  { 357, 3, 9, 6, 2, -9 },
  { 361, 6, 11, 6, 0, -9 },
  { 370, 6, 8, 6, 1, -8 },
  { 376, 3, 8, 6, 2, -8 },
  { 379, 6, 6, 6, 0, -6 },
  { 384, 5, 6, 6, 1, -6 },
  { 388, 5, 6, 6, 1, -6 },
  { 392, 6, 8, 6, 0, -6 },
  { 398, 5, 8, 6, 1, -6 },
  { 403, 5, 6, 6, 1, -6 },
  { 407, 5, 6, 6, 1, -6 },
  { 411, 4, 8, 6, 2, -8 },
  { 415, 5, 6, 6, 1, -6 },
  { 419, 4, 6, 6, 2, -6 },
  { 422, 6, 6, 6, 1, -6 },
  { 427, 7, 6, 6, 0, -6 },
  { 433, 6, 8, 6, 0, -6 },
  { 439, 5, 6, 6, 1, -6 },
  { 443, 6, 10, 6, 1, -8 },
  { 451, 3, 10, 6, 2, -8 },
  { 455, 6, 10, 6, 0, -8 },
  { 463, 5, 2, 6, 1, -5 },
};

const GFXfont UbuntuMono_Italic12pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Italic12pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Italic12pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _UBUNTUMONO_ITALIC12PT7B_H_
