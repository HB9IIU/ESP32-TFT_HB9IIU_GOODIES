#ifndef _UBUNTUMONO_ITALIC36PT7B_H_
#define _UBUNTUMONO_ITALIC36PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Italic.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Italic36pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0x83, 0xC1, 0xC0, 0xE0, 0x70, 0x78, 0x38, 0x1C, 0x0E, 0x0E,
  0x07, 0x03, 0x81, 0x80, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x3E, 0x1F, 0x0F,
  0x83, 0x80, 0x71, 0xDC, 0x77, 0x1D, 0x86, 0x63, 0xB8, 0xEC, 0x33, 0x0C,
  0xC3, 0x00, 0x00, 0x38, 0x60, 0x0E, 0x1C, 0x01, 0xC3, 0x00, 0x30, 0xE0,
  0x0E, 0x1C, 0x01, 0x87, 0x07, 0xFF, 0xF8, 0xFF, 0xFF, 0x1F, 0xFF, 0xE0,
  0x70, 0xE0, 0x0C, 0x38, 0x03, 0x87, 0x00, 0x61, 0xC0, 0x1C, 0x38, 0x1F,
  0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0x83, 0x0E, 0x00, 0xE1, 0xC0, 0x18,
  0x70, 0x07, 0x0E, 0x00, 0xC3, 0x80, 0x00, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x30, 0x00, 0x30, 0x01, 0xFC, 0x07, 0xFF, 0x0F, 0xFF, 0x0F, 0x02, 0x1E,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x03,
  0xF8, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x40,
  0x78, 0xFF, 0xF8, 0xFF, 0xE0, 0x3F, 0x80, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0C, 0x00, 0x01, 0xE0, 0x18, 0x1F, 0x80, 0xC0, 0x7F, 0x07, 0x03,
  0x9C, 0x38, 0x0C, 0x71, 0xC0, 0x31, 0xCE, 0x00, 0xC6, 0x30, 0x03, 0x39,
  0x80, 0x0F, 0xEC, 0x00, 0x3F, 0x70, 0x00, 0x7B, 0x80, 0x00, 0x1D, 0xE0,
  0x00, 0xEF, 0xC0, 0x03, 0x7F, 0x00, 0x19, 0xCC, 0x00, 0xC6, 0x30, 0x07,
  0x38, 0xC0, 0x38, 0xC3, 0x01, 0xC3, 0x9C, 0x0E, 0x0F, 0xE0, 0x70, 0x1F,
  0x81, 0x80, 0x78, 0x00, 0x00, 0xF8, 0x03, 0xFC, 0x07, 0xFE, 0x07, 0x0E,
  0x0E, 0x0E, 0x0E, 0x0C, 0x0E, 0x1C, 0x0E, 0x38, 0x07, 0xF0, 0x07, 0xC0,
  0x0F, 0x87, 0x1F, 0xC6, 0x39, 0xCE, 0x70, 0xEC, 0x60, 0xFC, 0xE0, 0x78,
  0xE0, 0x38, 0xE0, 0x78, 0xF0, 0xF8, 0x7F, 0xDC, 0x7F, 0x9C, 0x1E, 0x1C,
  0x73, 0x9C, 0xEE, 0x73, 0x9C, 0xC6, 0x00, 0x00, 0x08, 0x00, 0xE0, 0x07,
  0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x0E, 0x00, 0x70,
  0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x06, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00,
  0x40, 0x00, 0x00, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x01,
  0xC0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00,
  0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0xF8, 0x03, 0x80, 0x04, 0x00, 0x00, 0x07, 0x00, 0x1C,
  0x00, 0x30, 0x10, 0xC2, 0xF3, 0x7B, 0xFF, 0xF3, 0xFF, 0x01, 0xE0, 0x0F,
  0xC0, 0x73, 0x83, 0xCF, 0x0E, 0x1C, 0x18, 0x40, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x00, 0x06, 0x00, 0x1E, 0x1E, 0x3F, 0x3F, 0x1E, 0x0E, 0x1C, 0x3C,
  0xF0, 0xC0, 0x7F, 0xBF, 0xFF, 0xC0, 0x79, 0xEF, 0xFE, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x03, 0xFC,
  0x07, 0xFE, 0x0F, 0x0F, 0x1E, 0x07, 0x1C, 0x07, 0x38, 0x07, 0x38, 0x07,
  0x71, 0x87, 0x73, 0xC7, 0x73, 0xCE, 0xE3, 0xCE, 0xE3, 0x8E, 0xE0, 0x1E,
  0xE0, 0x1C, 0xE0, 0x3C, 0xE0, 0x38, 0xE0, 0x78, 0xF0, 0xF0, 0x7F, 0xE0,
  0x7F, 0xC0, 0x1F, 0x00, 0x00, 0x18, 0x01, 0xC0, 0x3E, 0x03, 0xF0, 0x7F,
  0x07, 0xB8, 0x39, 0xC1, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0xFF,
  0xF7, 0xFF, 0xFF, 0xF8, 0x00, 0xFC, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0xE0,
  0xF0, 0x40, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0xFF, 0x87, 0xFF,
  0xC3, 0xFF, 0xE0, 0x00, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x41, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0xFE,
  0x00, 0xFC, 0x00, 0x7F, 0x80, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x18, 0x1F, 0x0F, 0xFF, 0x0F, 0xFF, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0xFE,
  0x01, 0xEE, 0x03, 0xCE, 0x07, 0x8E, 0x07, 0x1C, 0x0E, 0x1C, 0x1C, 0x1C,
  0x38, 0x1C, 0x70, 0x38, 0x70, 0x38, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x01, 0xFF,
  0xC0, 0x7F, 0xF0, 0x1F, 0xF8, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0xC0, 0x03, 0xFC, 0x00, 0xFF, 0xC0, 0x03,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E,
  0x00, 0x07, 0x04, 0x07, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x3F, 0xC0, 0x7F, 0xE0, 0x7E, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x38, 0x00, 0x3B, 0xF0, 0x1F, 0xFC, 0x1F, 0xFF, 0x0F,
  0x03, 0xC7, 0x00, 0xE3, 0x80, 0x73, 0x80, 0x39, 0xC0, 0x1C, 0xE0, 0x1C,
  0x38, 0x1E, 0x1E, 0x1E, 0x0F, 0xFF, 0x03, 0xFE, 0x00, 0xFE, 0x00, 0x3F,
  0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x07,
  0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70,
  0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x00, 0xFC, 0x03, 0xFE, 0x07,
  0xFF, 0x0F, 0x0F, 0x1E, 0x07, 0x1C, 0x07, 0x1C, 0x07, 0x1C, 0x07, 0x1E,
  0x1E, 0x0F, 0xBC, 0x07, 0xF0, 0x0F, 0xF8, 0x3C, 0x7C, 0x70, 0x3C, 0x70,
  0x1C, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x3C, 0xF0, 0x78, 0xFF, 0xF8, 0x7F,
  0xE0, 0x1F, 0x80, 0x01, 0xF8, 0x07, 0xFE, 0x0F, 0xFE, 0x1F, 0x0F, 0x1C,
  0x07, 0x3C, 0x07, 0x38, 0x07, 0x38, 0x07, 0x38, 0x07, 0x38, 0x07, 0x3C,
  0x0F, 0x1F, 0xFE, 0x1F, 0xFE, 0x07, 0xEE, 0x00, 0x1C, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x07, 0xE0, 0xFF, 0x80, 0xFF, 0x00, 0xF8, 0x00, 0x0F,
  0x1F, 0x1F, 0x1F, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x78, 0xFC, 0xF8, 0x70, 0x03, 0xC1, 0xF0, 0x7C, 0x1F, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x07, 0x83, 0xF0, 0xFC,
  0x1E, 0x03, 0x81, 0xC0, 0xF0, 0xF0, 0x30, 0x00, 0x00, 0x02, 0x00, 0x0F,
  0x00, 0x7F, 0x01, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0xFC, 0x00, 0xE0, 0x00,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x78,
  0x00, 0x10, 0x3F, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x7F, 0xFE, 0x7F, 0xFF, 0x00,
  0x18, 0x00, 0x1E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x0F, 0x00, 0x3F, 0x01, 0xFC, 0x0F, 0xF0, 0x3F, 0x80,
  0xFE, 0x00, 0xF0, 0x00, 0xC0, 0x00, 0x0F, 0xC1, 0xFF, 0x87, 0xFC, 0x20,
  0xF0, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0x80,
  0x38, 0x01, 0x80, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x3C,
  0x01, 0xF0, 0x0F, 0x00, 0x30, 0x00, 0x00, 0x3E, 0x00, 0x3F, 0xE0, 0x3F,
  0xF8, 0x1F, 0x0F, 0x0F, 0x01, 0xC3, 0x80, 0x71, 0xE0, 0x1C, 0x70, 0x07,
  0x38, 0x1F, 0xCE, 0x1F, 0xF7, 0x8F, 0xF9, 0xC7, 0x8E, 0x73, 0xC3, 0x9C,
  0xE0, 0xC6, 0x38, 0x71, 0x8E, 0x1C, 0xE3, 0x87, 0x38, 0xFF, 0x86, 0x1F,
  0xE1, 0x83, 0xF0, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1E, 0x00, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x0F, 0xC0, 0x06, 0xE0, 0x07, 0x70, 0x07, 0x38, 0x03, 0x9C, 0x03, 0x8E,
  0x01, 0x87, 0x01, 0xC1, 0x80, 0xC0, 0xC0, 0xE0, 0x60, 0xE0, 0x30, 0x70,
  0x1C, 0x7F, 0xFE, 0x3F, 0xFF, 0x3F, 0xFF, 0x9C, 0x01, 0xDC, 0x00, 0xEE,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1C, 0x07, 0xFC, 0x07, 0xFF, 0x83, 0xFF,
  0xC1, 0xC0, 0xF0, 0xE0, 0x38, 0xF0, 0x1C, 0x70, 0x0E, 0x38, 0x0E, 0x1C,
  0x1E, 0x0F, 0xFE, 0x0F, 0xFE, 0x07, 0xFF, 0x83, 0x81, 0xE1, 0xC0, 0x71,
  0xC0, 0x1C, 0xE0, 0x1C, 0x70, 0x0E, 0x30, 0x0F, 0x38, 0x1F, 0x1F, 0xFF,
  0x0F, 0xFF, 0x07, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0xE0, 0x7F, 0xF8,
  0x3E, 0x06, 0x0E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x81, 0x80,
  0xFF, 0xE0, 0x3F, 0xF8, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0x80,
  0x7F, 0xF0, 0x1C, 0x3E, 0x0F, 0x03, 0x83, 0x80, 0xF0, 0xE0, 0x1C, 0x38,
  0x07, 0x1C, 0x01, 0xC7, 0x00, 0x71, 0xC0, 0x1C, 0x70, 0x0E, 0x38, 0x03,
  0x8E, 0x00, 0xE3, 0x80, 0x78, 0xE0, 0x1C, 0x70, 0x0F, 0x1C, 0x0F, 0x87,
  0x0F, 0xC1, 0xFF, 0xE0, 0x7F, 0xE0, 0x3F, 0xE0, 0x00, 0x07, 0xFF, 0x83,
  0xFF, 0xC3, 0xFF, 0xE1, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x03, 0x80,
  0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x1F, 0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0xC0, 0x07, 0xFF, 0x81, 0xFF,
  0xE0, 0xFF, 0xF8, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x38,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0xFF, 0xC1, 0xFF, 0xE1, 0xF0, 0x21, 0xE0, 0x01, 0xE0, 0x00, 0xE0,
  0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x01, 0xCE,
  0x00, 0xE7, 0x00, 0xE3, 0x80, 0x71, 0xC0, 0x38, 0xE0, 0x1C, 0x78, 0x1C,
  0x1E, 0x0E, 0x0F, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0x00, 0x07, 0x00, 0x70,
  0x70, 0x0E, 0x07, 0x00, 0xE0, 0x70, 0x0E, 0x06, 0x00, 0xE0, 0xE0, 0x1C,
  0x0E, 0x01, 0xC0, 0xE0, 0x1C, 0x0C, 0x01, 0xC1, 0xFF, 0xF8, 0x1F, 0xFF,
  0x81, 0xFF, 0xF8, 0x1C, 0x03, 0x83, 0x80, 0x30, 0x38, 0x07, 0x03, 0x80,
  0x70, 0x38, 0x07, 0x07, 0x00, 0x70, 0x70, 0x0E, 0x07, 0x00, 0xE0, 0x70,
  0x0E, 0x0E, 0x00, 0xE0, 0x07, 0xFF, 0x07, 0xFF, 0x0F, 0xFF, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0xE0,
  0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xF8, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x3C, 0x08, 0x0E, 0x07, 0x0F, 0x83, 0xFF, 0xC0, 0x7F, 0xE0, 0x07,
  0xE0, 0x00, 0x07, 0x01, 0xE0, 0xE0, 0x78, 0x38, 0x1E, 0x07, 0x07, 0x80,
  0xE1, 0xE0, 0x1C, 0x78, 0x07, 0x1E, 0x00, 0xE7, 0x80, 0x1D, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xBC, 0x00, 0x73, 0xC0, 0x1C,
  0x38, 0x03, 0x83, 0x80, 0x70, 0x70, 0x0E, 0x07, 0x03, 0x80, 0xE0, 0x70,
  0x0E, 0x0E, 0x01, 0xC1, 0xC0, 0x3C, 0x00, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0x80, 0xE0, 0x70, 0x3C,
  0x0F, 0x07, 0x83, 0xE1, 0xF0, 0x7C, 0x3E, 0x0D, 0x8F, 0x83, 0xB1, 0xB0,
  0x66, 0x66, 0x0C, 0xCD, 0xC3, 0x9B, 0x38, 0x73, 0x67, 0x0C, 0x78, 0xC3,
  0x8F, 0x18, 0x71, 0xC7, 0x0E, 0x00, 0xE3, 0x80, 0x1C, 0x70, 0x03, 0x0E,
  0x00, 0xE1, 0x80, 0x1C, 0x70, 0x03, 0x8E, 0x00, 0x71, 0xC0, 0x0C, 0x00,
  0x03, 0x80, 0x70, 0x78, 0x06, 0x07, 0x80, 0x60, 0x7C, 0x0E, 0x06, 0xC0,
  0xE0, 0xEC, 0x0E, 0x0E, 0xE0, 0xC0, 0xEE, 0x1C, 0x0C, 0x61, 0xC1, 0xC6,
  0x1C, 0x1C, 0x71, 0x81, 0xC7, 0x38, 0x18, 0x33, 0x83, 0x83, 0x38, 0x38,
  0x33, 0x03, 0x83, 0xF0, 0x30, 0x1F, 0x03, 0x01, 0xF0, 0x70, 0x1E, 0x07,
  0x01, 0xE0, 0x70, 0x1E, 0x06, 0x01, 0xE0, 0x00, 0xF8, 0x03, 0xFE, 0x07,
  0xFF, 0x0F, 0x0F, 0x1E, 0x07, 0x3C, 0x07, 0x38, 0x07, 0x78, 0x07, 0x70,
  0x07, 0x70, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0E, 0xE0,
  0x0E, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x38, 0xF0, 0xF8, 0x7F, 0xF0, 0x3F,
  0xC0, 0x1F, 0x80, 0x07, 0xFC, 0x03, 0xFF, 0x81, 0xFF, 0xE1, 0xE0, 0xF0,
  0xE0, 0x38, 0x70, 0x0C, 0x38, 0x0E, 0x38, 0x07, 0x1C, 0x03, 0x8E, 0x03,
  0x87, 0x07, 0xC7, 0xFF, 0xC3, 0xFF, 0x81, 0xFF, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xF8, 0x03, 0xFE, 0x07, 0xFF, 0x0F, 0x0F, 0x1E, 0x07,
  0x3C, 0x07, 0x38, 0x07, 0x78, 0x07, 0x70, 0x07, 0x70, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x1C, 0xE0, 0x1C,
  0xE0, 0x38, 0xF0, 0xF8, 0x7F, 0xF0, 0x3F, 0xE0, 0x1F, 0x80, 0x0E, 0x00,
  0x0F, 0x00, 0x0F, 0x80, 0x07, 0xF0, 0x03, 0xE0, 0x00, 0xE0, 0x07, 0xFC,
  0x03, 0xFF, 0x03, 0xFF, 0xC1, 0xC0, 0xF0, 0xE0, 0x38, 0x70, 0x1C, 0x70,
  0x0E, 0x38, 0x07, 0x1C, 0x07, 0x8E, 0x03, 0x8E, 0x07, 0x87, 0xFF, 0xC3,
  0xFF, 0x81, 0xFF, 0x01, 0xC1, 0xC0, 0xE0, 0xE0, 0x70, 0x38, 0x38, 0x1C,
  0x38, 0x0E, 0x1C, 0x03, 0x8E, 0x01, 0xC7, 0x00, 0xE0, 0x00, 0xFE, 0x00,
  0xFF, 0xF0, 0x7F, 0xF8, 0x1E, 0x06, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0,
  0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x07, 0x06, 0x03, 0xC3, 0xFF, 0xE0, 0xFF, 0xF0, 0x0F, 0xF0, 0x00, 0x7F,
  0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x01, 0xC7, 0x00, 0xE1,
  0xC0, 0x38, 0x70, 0x0E, 0x38, 0x03, 0x8E, 0x01, 0xC3, 0x80, 0x70, 0xE0,
  0x1C, 0x70, 0x07, 0x1C, 0x03, 0x87, 0x00, 0xE1, 0xC0, 0x38, 0xE0, 0x1E,
  0x38, 0x07, 0x0E, 0x01, 0xC3, 0x80, 0x70, 0xE0, 0x38, 0x38, 0x0E, 0x0F,
  0x0F, 0x01, 0xFF, 0xC0, 0x3F, 0xE0, 0x07, 0xE0, 0x00, 0xE0, 0x03, 0xF0,
  0x03, 0xB8, 0x01, 0xDC, 0x01, 0xCE, 0x00, 0xE7, 0x00, 0xE3, 0x80, 0x71,
  0xC0, 0x70, 0xE0, 0x38, 0x70, 0x38, 0x38, 0x1C, 0x1C, 0x1C, 0x0E, 0x0C,
  0x03, 0x0E, 0x01, 0x8E, 0x00, 0xE7, 0x00, 0x77, 0x00, 0x3B, 0x80, 0x1F,
  0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x60, 0xC0,
  0x0E, 0x1C, 0x00, 0xE1, 0xC0, 0x0E, 0x1C, 0x00, 0xC1, 0xC0, 0x1C, 0x18,
  0x01, 0xC3, 0x80, 0x18, 0x38, 0xE3, 0x83, 0x9E, 0x38, 0x31, 0xE3, 0x03,
  0x3E, 0x30, 0x73, 0x67, 0x07, 0x76, 0x70, 0x66, 0x66, 0x06, 0xC6, 0x60,
  0x6C, 0x7E, 0x07, 0x83, 0xC0, 0x78, 0x3C, 0x0F, 0x03, 0x80, 0xF0, 0x38,
  0x0E, 0x03, 0x80, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xE0, 0x1C, 0x07, 0x00,
  0x38, 0x38, 0x00, 0xE1, 0xC0, 0x03, 0xCE, 0x00, 0x07, 0x78, 0x00, 0x1D,
  0xC0, 0x00, 0x7E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0xFC, 0x00, 0x07, 0xB0, 0x00, 0x3C, 0xE0, 0x00, 0xE3, 0x80, 0x07,
  0x06, 0x00, 0x3C, 0x1C, 0x01, 0xE0, 0x70, 0x0F, 0x01, 0xC0, 0x38, 0x03,
  0x81, 0xC0, 0x0E, 0x00, 0xE0, 0x03, 0xB0, 0x03, 0x9C, 0x01, 0xCE, 0x01,
  0xC7, 0x01, 0xC3, 0x80, 0xE0, 0xC0, 0xE0, 0x70, 0xE0, 0x38, 0xE0, 0x1C,
  0x70, 0x07, 0x70, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x78, 0x00, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0x01, 0xFF,
  0x01, 0xFE, 0x03, 0xFE, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x00,
  0xE7, 0x39, 0xCE, 0x73, 0x9C, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C,
  0xE7, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE0, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFE, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x03, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0xE0,
  0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x73, 0x81, 0xC7, 0x07, 0x8E, 0x1E,
  0x0C, 0x38, 0x1C, 0xE0, 0x3B, 0x80, 0x33, 0x00, 0x40, 0x7F, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xC0, 0x20, 0xE1, 0xC1, 0xC1, 0xC1, 0xC1, 0x00, 0x01,
  0xFC, 0x0F, 0xFC, 0x3F, 0xF9, 0xF8, 0x73, 0xC0, 0xEF, 0x03, 0xBC, 0x07,
  0x70, 0x0E, 0xE0, 0x39, 0xC0, 0x73, 0x80, 0xE7, 0x01, 0xCE, 0x07, 0x9E,
  0x1F, 0x3F, 0xFE, 0x3F, 0xFC, 0x3F, 0x38, 0x03, 0x80, 0x03, 0x80, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E,
  0xF8, 0x0F, 0xFE, 0x0F, 0xFE, 0x1F, 0x0F, 0x1C, 0x07, 0x1C, 0x07, 0x1C,
  0x07, 0x38, 0x07, 0x38, 0x07, 0x38, 0x0F, 0x38, 0x0E, 0x30, 0x1E, 0x70,
  0x3C, 0x70, 0xF8, 0x7F, 0xF0, 0x7F, 0xE0, 0xFF, 0x80, 0x01, 0xFC, 0x0F,
  0xFC, 0x7F, 0xF9, 0xF8, 0x27, 0xC0, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1F, 0x03, 0x1F,
  0xFE, 0x1F, 0xFC, 0x0F, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0xFF, 0x01, 0xFF, 0xC0, 0xF0, 0xE0, 0x70, 0x38, 0x38, 0x0E, 0x1E, 0x03,
  0x87, 0x01, 0xC3, 0xC0, 0x70, 0xE0, 0x1C, 0x38, 0x07, 0x0E, 0x03, 0x83,
  0x80, 0xE0, 0xE0, 0x38, 0x38, 0x0E, 0x07, 0x0F, 0x81, 0xFF, 0xE0, 0x1F,
  0x18, 0x00, 0x01, 0xF8, 0x1F, 0xF8, 0x7F, 0xF9, 0xF0, 0xF7, 0x80, 0xEE,
  0x01, 0xFC, 0x07, 0xF0, 0x3E, 0xFF, 0xF9, 0xFF, 0xE3, 0xFC, 0x06, 0x00,
  0x0E, 0x00, 0x1E, 0x03, 0x1F, 0xFE, 0x1F, 0xFC, 0x1F, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x03, 0xFF, 0xF0, 0x0F,
  0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x7F, 0xF0, 0x3C, 0x1C, 0x1E, 0x0E, 0x0F, 0x03, 0x87,
  0x80, 0xE1, 0xC0, 0x38, 0x70, 0x1C, 0x38, 0x07, 0x0E, 0x01, 0xC3, 0x80,
  0x70, 0xE0, 0x38, 0x38, 0x0E, 0x07, 0x0F, 0x81, 0xFF, 0xE0, 0x1F, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x81, 0x03, 0xE0, 0xFF, 0xF0, 0x3F,
  0xF8, 0x03, 0xF8, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0F, 0xF0, 0x3F, 0xF8, 0x7F,
  0xF0, 0xE0, 0xF1, 0xC0, 0xE7, 0x01, 0xCE, 0x03, 0x9C, 0x07, 0x38, 0x0E,
  0xE0, 0x1D, 0xC0, 0x73, 0x80, 0xE7, 0x01, 0xDC, 0x07, 0x38, 0x0E, 0x70,
  0x1C, 0xE0, 0x38, 0x03, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x3F, 0xCF, 0xF0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xFC, 0x3F, 0x07, 0xC0, 0x00,
  0x07, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x08, 0x3C, 0x0F, 0xFC,
  0x07, 0xFC, 0x00, 0xFC, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E,
  0x03, 0x83, 0x83, 0xC0, 0xE1, 0xE0, 0x70, 0xF0, 0x1C, 0xF0, 0x07, 0x78,
  0x01, 0xFC, 0x00, 0x7C, 0x00, 0x3B, 0x80, 0x0E, 0x70, 0x03, 0x9E, 0x00,
  0xC3, 0xC0, 0x70, 0x70, 0x1C, 0x1E, 0x07, 0x03, 0x81, 0xC0, 0x70, 0xE0,
  0x1C, 0x00, 0x7F, 0x9F, 0xC7, 0xF0, 0x1C, 0x07, 0x01, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x01, 0xC0, 0x70, 0x1C, 0x06, 0x03, 0x80, 0xE0, 0x38, 0x0C,
  0x07, 0x01, 0xC0, 0x70, 0x1E, 0x17, 0xFC, 0xFF, 0x1F, 0x80, 0x07, 0xCF,
  0x03, 0xFF, 0xE0, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC6, 0x18, 0x61,
  0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x30, 0xC3, 0x00, 0x71, 0xC0,
  0x1C, 0x70, 0x07, 0x1C, 0x01, 0xC6, 0x00, 0x63, 0x80, 0x38, 0xE0, 0x0E,
  0x00, 0x03, 0xF8, 0x0F, 0xFC, 0x0F, 0xFE, 0x0E, 0x0F, 0x1C, 0x07, 0x1C,
  0x07, 0x1C, 0x07, 0x1C, 0x07, 0x38, 0x0E, 0x38, 0x0E, 0x38, 0x0E, 0x38,
  0x0E, 0x70, 0x1C, 0x70, 0x1C, 0x70, 0x1C, 0x70, 0x1C, 0xE0, 0x38, 0x03,
  0xF0, 0x1F, 0xF8, 0x7F, 0xF1, 0xF0, 0xF3, 0x80, 0xEF, 0x01, 0xDC, 0x03,
  0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x77, 0x01, 0xEE, 0x03, 0x9E,
  0x1F, 0x1F, 0xFC, 0x3F, 0xF0, 0x1F, 0x80, 0x01, 0xFC, 0x03, 0xFF, 0x81,
  0xFF, 0xC1, 0xC0, 0xF0, 0xE0, 0x38, 0x70, 0x1C, 0x38, 0x0E, 0x38, 0x07,
  0x1C, 0x03, 0x8E, 0x01, 0xC7, 0x01, 0xC7, 0x01, 0xE3, 0x81, 0xE1, 0xC3,
  0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xC0, 0x38, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0x00, 0xFE, 0x07, 0xFF,
  0x0F, 0x0F, 0x1C, 0x0E, 0x38, 0x0E, 0x78, 0x0E, 0x70, 0x1E, 0xF0, 0x1C,
  0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x3C, 0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x38,
  0x70, 0xF8, 0x7F, 0xF0, 0x1F, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xFF, 0x0F, 0xFE, 0x0F, 0xFE,
  0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0xE0, 0x00, 0x01, 0xFC, 0x0F, 0xFC, 0x3F, 0xF0, 0xF0, 0x21,
  0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xE0, 0x01,
  0xE0, 0x01, 0xC0, 0x03, 0x88, 0x0F, 0x3F, 0xFC, 0x7F, 0xF0, 0x3F, 0x80,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1E, 0x08, 0x7F, 0xC3, 0xFE, 0x0F, 0xC0,
  0x38, 0x0E, 0x38, 0x0E, 0x38, 0x0E, 0x38, 0x0E, 0x70, 0x1C, 0x70, 0x1C,
  0x70, 0x1C, 0x70, 0x1C, 0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x38,
  0xE0, 0x78, 0xF0, 0xF8, 0x7F, 0xF8, 0x7F, 0xF8, 0x3F, 0x38, 0xE0, 0x1F,
  0x80, 0x7E, 0x03, 0xB8, 0x0E, 0xE0, 0x73, 0x81, 0xCE, 0x0E, 0x38, 0x38,
  0xE1, 0xC1, 0xC7, 0x07, 0x38, 0x1C, 0xE0, 0x77, 0x01, 0xF8, 0x07, 0xE0,
  0x0F, 0x00, 0x38, 0x00, 0x70, 0x01, 0xDC, 0x00, 0x67, 0x00, 0x39, 0x80,
  0x0E, 0x61, 0xC3, 0x18, 0x71, 0xCE, 0x3C, 0x73, 0x8F, 0x18, 0xE6, 0xCE,
  0x39, 0xB3, 0x0E, 0xCD, 0xC3, 0xF3, 0x70, 0xD8, 0xD8, 0x3E, 0x3E, 0x0F,
  0x0F, 0x03, 0x81, 0xC0, 0xE0, 0x60, 0x00, 0x0E, 0x01, 0xC0, 0xE0, 0x70,
  0x1C, 0x1E, 0x01, 0xC7, 0x80, 0x38, 0xE0, 0x03, 0xB8, 0x00, 0x7E, 0x00,
  0x07, 0x80, 0x00, 0xE0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x03, 0xDC, 0x00,
  0xF3, 0x80, 0x3C, 0x38, 0x0F, 0x07, 0x03, 0xC0, 0xF0, 0xF0, 0x0E, 0x00,
  0x03, 0x80, 0x70, 0x38, 0x07, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x1C, 0x01, 0xC1, 0xC0, 0x1C, 0x38, 0x01, 0xC3, 0x80, 0x1C,
  0x38, 0x01, 0xC7, 0x00, 0x0E, 0x60, 0x00, 0xEE, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x04,
  0x3C, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xFF,
  0x0F, 0xFF, 0x0F, 0xFF, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x78, 0x00, 0x7F, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0x00, 0x1F, 0x80, 0x1F,
  0xE0, 0x07, 0xF8, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07,
  0x00, 0x03, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x07, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x3F,
  0xE0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x01, 0xC0, 0x60, 0x38, 0x0E, 0x03,
  0x80, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x81,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x01, 0xC0,
  0x70, 0x1C, 0x06, 0x03, 0x80, 0xE0, 0x38, 0x0C, 0x00, 0x01, 0xF8, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x1C, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x0F, 0xF8, 0x07, 0xF8,
  0x03, 0xF8, 0x00, 0x1E, 0x06, 0x3F, 0x06, 0x7F, 0x8E, 0xE3, 0xFC, 0xC1,
  0xFC, 0xC0, 0x70,
};

const GFXglyph UbuntuMono_Italic36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 9, 22, 18, 6, -22 },
  { 26, 10, 9, 18, 8, -22 },
  { 38, 19, 22, 18, 1, -22 },
  { 91, 16, 28, 18, 3, -25 },
  { 147, 22, 22, 18, 0, -22 },
  { 208, 16, 22, 18, 2, -22 },
  { 252, 5, 10, 18, 11, -24 },
  { 259, 14, 31, 18, 5, -25 },
  { 314, 14, 31, 18, 2, -25 },
  { 369, 14, 13, 18, 5, -22 },
  { 392, 15, 17, 18, 3, -18 },
  { 424, 8, 10, 18, 4, -5 },
  { 434, 9, 3, 18, 6, -11 },
  { 438, 6, 5, 18, 6, -5 },
  { 442, 21, 31, 18, -1, -25 },
  { 524, 16, 22, 18, 3, -22 },
  { 568, 13, 22, 18, 3, -22 },
  { 604, 17, 22, 18, 2, -22 },
  { 651, 17, 22, 18, 2, -22 },
  { 698, 16, 22, 18, 2, -22 },
  { 742, 18, 22, 18, 2, -22 },
  { 792, 17, 22, 18, 3, -22 },
  { 839, 16, 22, 18, 5, -22 },
  { 883, 16, 22, 18, 3, -22 },
  { 927, 16, 22, 18, 3, -22 },
  { 971, 8, 17, 18, 6, -17 },
  { 988, 10, 22, 18, 4, -17 },
  { 1016, 16, 15, 18, 3, -17 },
  { 1046, 17, 10, 18, 2, -14 },
  { 1068, 16, 15, 18, 2, -17 },
  { 1098, 13, 22, 18, 6, -22 },
  { 1134, 18, 27, 18, 2, -22 },
  { 1195, 17, 22, 18, 0, -22 },
  { 1242, 17, 22, 18, 2, -22 },
  { 1289, 18, 22, 18, 3, -22 },
  { 1339, 18, 22, 18, 1, -22 },
  { 1389, 17, 22, 18, 3, -22 },
  { 1436, 18, 22, 18, 3, -22 },
  { 1486, 17, 22, 18, 3, -22 },
  { 1533, 20, 22, 18, 1, -22 },
  { 1588, 16, 22, 18, 3, -22 },
  { 1632, 18, 22, 18, 2, -22 },
  { 1682, 19, 22, 18, 2, -22 },
  { 1735, 13, 22, 18, 2, -22 },
  { 1771, 19, 22, 18, 1, -22 },
  { 1824, 20, 22, 18, 1, -22 },
  { 1879, 16, 22, 18, 3, -22 },
  { 1923, 17, 22, 18, 2, -22 },
  { 1970, 16, 28, 18, 3, -22 },
  { 2026, 17, 22, 18, 2, -22 },
  { 2073, 18, 22, 18, 2, -22 },
  { 2123, 16, 22, 18, 5, -22 },
  { 2167, 18, 22, 18, 3, -22 },
  { 2217, 17, 22, 18, 5, -22 },
  { 2264, 20, 22, 18, 2, -22 },
  { 2319, 22, 22, 18, 0, -22 },
  { 2380, 17, 22, 18, 5, -22 },
  { 2427, 20, 22, 18, 1, -22 },
  { 2482, 16, 31, 18, 4, -25 },
  { 2544, 5, 31, 18, 8, -25 },
  { 2564, 16, 31, 18, 1, -25 },
  { 2626, 15, 12, 18, 4, -22 },
  { 2649, 17, 3, 18, -1, 3 },
  { 2656, 7, 7, 18, 9, -25 },
  { 2663, 15, 17, 18, 3, -17 },
  { 2695, 16, 25, 18, 2, -25 },
  { 2745, 15, 17, 18, 3, -17 },
  { 2777, 18, 25, 18, 3, -25 },
  { 2834, 15, 17, 18, 3, -17 },
  { 2866, 22, 31, 18, 0, -25 },
  { 2952, 18, 23, 18, 1, -17 },
  { 3004, 15, 25, 18, 2, -25 },
  { 3051, 10, 25, 18, 5, -25 },
  { 3083, 17, 31, 18, 1, -25 },
  { 3149, 18, 25, 18, 2, -25 },
  { 3206, 10, 25, 18, 6, -25 },
  { 3238, 18, 17, 18, 1, -17 },
  { 3277, 16, 17, 18, 2, -17 },
  { 3311, 15, 17, 18, 3, -17 },
  { 3343, 17, 23, 18, 1, -17 },
  { 3392, 16, 23, 18, 3, -17 },
  { 3438, 16, 17, 18, 3, -17 },
  { 3472, 15, 17, 18, 3, -17 },
  { 3504, 13, 22, 18, 5, -22 },
  { 3540, 16, 17, 18, 3, -17 },
  { 3574, 14, 17, 18, 5, -17 },
  { 3604, 18, 17, 18, 3, -17 },
  { 3643, 19, 17, 18, 1, -17 },
  { 3684, 20, 23, 18, -1, -17 },
  { 3742, 16, 17, 18, 2, -17 },
  { 3776, 18, 31, 18, 3, -25 },
  { 3846, 10, 31, 18, 6, -25 },
  { 3885, 17, 31, 18, 0, -25 },
  { 3951, 16, 6, 18, 3, -15 },
};

const GFXfont UbuntuMono_Italic36pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Italic36pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Italic36pt7bGlyphs,
  0x20, 0x7E, 36
};

#endif // _UBUNTUMONO_ITALIC36PT7B_H_
