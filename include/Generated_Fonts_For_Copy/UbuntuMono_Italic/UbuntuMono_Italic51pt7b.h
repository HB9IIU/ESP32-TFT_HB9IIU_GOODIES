#ifndef _UBUNTUMONO_ITALIC51PT7B_H_
#define _UBUNTUMONO_ITALIC51PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Italic.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Italic51pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3C, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x80,
  0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x80, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x07,
  0x80, 0x3C, 0x1E, 0x78, 0x78, 0xF0, 0xF1, 0xE1, 0xE7, 0x83, 0xCF, 0x07,
  0x1E, 0x1E, 0x38, 0x3C, 0x70, 0x70, 0xE0, 0xE1, 0x81, 0xC7, 0x03, 0x0E,
  0x06, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x1C, 0x0F,
  0x00, 0x07, 0x81, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x0F, 0x00, 0x07,
  0x83, 0xC0, 0x01, 0xE0, 0x78, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0x03, 0xC0, 0x01, 0xE0,
  0xF0, 0x00, 0x78, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xC0, 0xF0, 0x00,
  0x78, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xC0, 0xF0, 0x07, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0x1E,
  0x07, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x1E, 0x07, 0x00,
  0x03, 0x81, 0xE0, 0x00, 0xF0, 0x38, 0x00, 0x1C, 0x0F, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x7F,
  0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xE0, 0x38, 0x1F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x84, 0x00,
  0x3E, 0x0F, 0x01, 0xFC, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x1C, 0x01, 0xFE, 0x00, 0x78, 0x07, 0xFC, 0x01, 0xE0, 0x0F, 0xF8, 0x07,
  0x80, 0x3C, 0x78, 0x1E, 0x00, 0x70, 0xF0, 0x78, 0x00, 0xE1, 0xE0, 0xE0,
  0x03, 0xC3, 0xC3, 0xC0, 0x07, 0x07, 0x0F, 0x00, 0x0E, 0x0E, 0x3C, 0x00,
  0x1C, 0x3C, 0xF0, 0x00, 0x3C, 0xF3, 0xC0, 0x00, 0x7F, 0xE7, 0x00, 0x00,
  0x7F, 0x9C, 0x00, 0x00, 0xFE, 0x78, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x00,
  0x07, 0x9F, 0x00, 0x00, 0x1E, 0x7F, 0x00, 0x00, 0x39, 0xFF, 0x00, 0x00,
  0xE7, 0xFE, 0x00, 0x03, 0xCF, 0x3C, 0x00, 0x0F, 0x3C, 0x38, 0x00, 0x3C,
  0x70, 0x70, 0x00, 0xF0, 0xE0, 0xE0, 0x01, 0xC1, 0xC3, 0xC0, 0x07, 0x07,
  0x87, 0x80, 0x1E, 0x0F, 0x0E, 0x00, 0x78, 0x1E, 0x3C, 0x01, 0xE0, 0x1F,
  0xF0, 0x07, 0x80, 0x3F, 0xE0, 0x1E, 0x00, 0x7F, 0x80, 0x38, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x3F, 0xFC,
  0x01, 0xF0, 0xF8, 0x0F, 0x81, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1C, 0x03,
  0xC0, 0xF0, 0x0F, 0x07, 0x80, 0x3C, 0x1E, 0x00, 0xF1, 0xF0, 0x03, 0xCF,
  0x80, 0x07, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x0F, 0x07, 0xF8, 0x3C,
  0x3F, 0xF0, 0xE1, 0xE3, 0xC7, 0x8F, 0x0F, 0x9E, 0x78, 0x1F, 0xF1, 0xE0,
  0x3F, 0xCF, 0x00, 0xFE, 0x3C, 0x01, 0xF0, 0xF0, 0x03, 0xC3, 0xC0, 0x1F,
  0x0F, 0x80, 0xFE, 0x3F, 0x0F, 0xF8, 0x7F, 0xFD, 0xE1, 0xFF, 0xE7, 0xC3,
  0xFF, 0x0F, 0x03, 0xF0, 0x3C, 0x1E, 0x7C, 0xF1, 0xE3, 0xCF, 0x9E, 0x3C,
  0x78, 0xE1, 0xC3, 0x8E, 0x1C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x0E, 0x00,
  0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x38, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x03, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x1F, 0xC0, 0x03, 0xE0, 0x00, 0x38, 0x00, 0x04, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x06, 0x0F,
  0x06, 0x78, 0xE1, 0xE7, 0xE6, 0x7E, 0xFF, 0xFF, 0xF3, 0xFF, 0xFC, 0x00,
  0xF0, 0x00, 0x1F, 0x80, 0x03, 0xFC, 0x00, 0x79, 0xE0, 0x0F, 0x9F, 0x01,
  0xF0, 0xF8, 0x3F, 0x0F, 0x80, 0xE0, 0x70, 0x04, 0x04, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x01, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0xFF, 0xFF, 0xF8, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x03,
  0xC0, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC1, 0xF8, 0x0F, 0x03, 0xC0,
  0xF0, 0x7E, 0x7F, 0x07, 0xC0, 0xC0, 0x00, 0x7F, 0xF7, 0xFF, 0xFF, 0xFF,
  0xFE, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xDE, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0,
  0x3F, 0x07, 0xC0, 0x7C, 0x07, 0x81, 0xF0, 0x0F, 0x87, 0xC0, 0x1F, 0x0F,
  0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x78, 0x00, 0xF9, 0xF0, 0x01, 0xF3, 0xC3,
  0x83, 0xE7, 0x8F, 0x87, 0x9F, 0x1F, 0x8F, 0x3C, 0x3F, 0x1E, 0x78, 0x7E,
  0x3C, 0xF0, 0xF8, 0xF9, 0xE0, 0xE1, 0xE7, 0xC0, 0x03, 0xCF, 0x80, 0x0F,
  0x9F, 0x00, 0x1E, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF0, 0xF8, 0x03, 0xE1,
  0xF0, 0x0F, 0x81, 0xE0, 0x3E, 0x03, 0xE0, 0xFC, 0x07, 0xFF, 0xF0, 0x07,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x7F, 0x78,
  0x3F, 0xBE, 0x0F, 0xCF, 0x01, 0xC3, 0xC0, 0x40, 0xF0, 0x00, 0x7C, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0xFF,
  0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0x00, 0x1F, 0xC0, 0x01,
  0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x3E, 0x07, 0xC0, 0x70,
  0x07, 0xC0, 0x80, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0xF0, 0x07, 0xFF, 0xE0, 0x0E, 0x07, 0xE0, 0x10, 0x07, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE1, 0x00, 0x0F, 0xC3, 0xC0, 0x7F,
  0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xDE, 0x00, 0x07, 0xBC, 0x00, 0x0F, 0x3C,
  0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x7C, 0x00, 0xF0, 0x78,
  0x01, 0xE0, 0x78, 0x03, 0xE0, 0x78, 0x07, 0xC0, 0xF8, 0x07, 0x80, 0xF0,
  0x0F, 0x00, 0xF0, 0x1E, 0x00, 0xF0, 0x1E, 0x00, 0xF0, 0x3C, 0x01, 0xE0,
  0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xE0, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x10, 0x00, 0xFC,
  0x0E, 0x03, 0xFC, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x07, 0xFC, 0x00, 0x3F,
  0xF8, 0x01, 0xFF, 0xF0, 0x07, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xE7, 0xF0, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF0, 0x7E, 0x03, 0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x03, 0xC7, 0x80,
  0x07, 0x8F, 0x00, 0x0F, 0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x78, 0x00,
  0xF8, 0xF0, 0x01, 0xE1, 0xF0, 0x07, 0xC3, 0xE0, 0x1F, 0x03, 0xE0, 0xFE,
  0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x3F, 0x07, 0xE0, 0x7C,
  0x03, 0xC1, 0xF0, 0x07, 0x83, 0xC0, 0x0F, 0x07, 0x80, 0x1E, 0x0F, 0x00,
  0x3C, 0x1E, 0x00, 0xF8, 0x3C, 0x03, 0xE0, 0x7C, 0x0F, 0x80, 0xFE, 0x3E,
  0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x1F, 0xBF, 0xC0,
  0x7C, 0x1F, 0xC1, 0xF0, 0x0F, 0x87, 0xC0, 0x0F, 0x0F, 0x00, 0x1E, 0x3E,
  0x00, 0x3C, 0x78, 0x00, 0x78, 0xF0, 0x00, 0xF1, 0xE0, 0x03, 0xE3, 0xE0,
  0x0F, 0x87, 0xE0, 0x7F, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x07, 0xFF,
  0x80, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xE0, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0xE0, 0x7F, 0x07, 0xC0, 0xF8, 0x07, 0xC3, 0xE0, 0x07,
  0x87, 0x80, 0x0F, 0x1F, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x78,
  0xF0, 0x00, 0xF1, 0xE0, 0x01, 0xE3, 0xC0, 0x03, 0xC7, 0xC0, 0x0F, 0x8F,
  0xC0, 0x7F, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07,
  0xE3, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xF0,
  0x0F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xC0, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0x81, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x0F,
  0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x0F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01,
  0xFC, 0x01, 0xF8, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x7E, 0x07, 0xF0,
  0x07, 0xC0, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0xC0, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xF0,
  0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x30,
  0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x04, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFF,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x03, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x3F,
  0xFF, 0x0C, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07,
  0xC0, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x1F,
  0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x1F, 0xC1, 0xF0, 0x1F, 0x80, 0x78, 0x1F,
  0x00, 0x3C, 0x1F, 0x00, 0x0E, 0x0F, 0x80, 0x07, 0x8F, 0x80, 0x03, 0x87,
  0x80, 0x03, 0xC7, 0xC0, 0x3F, 0xE3, 0xC0, 0xFF, 0xF3, 0xE0, 0xFF, 0xF9,
  0xE0, 0xFF, 0xF8, 0xF0, 0xFC, 0x3C, 0x78, 0x78, 0x1E, 0x78, 0x78, 0x0F,
  0x3C, 0x3C, 0x07, 0x1E, 0x3E, 0x07, 0x8F, 0x1E, 0x03, 0xC7, 0x8F, 0x01,
  0xE3, 0xC7, 0x81, 0xE1, 0xC3, 0xC0, 0xF0, 0xE1, 0xF0, 0x78, 0x70, 0x7C,
  0x3C, 0x38, 0x3F, 0xFC, 0x1E, 0x0F, 0xFE, 0x0F, 0x03, 0xFF, 0x07, 0x80,
  0xFE, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1E,
  0xF0, 0x00, 0x0F, 0x38, 0x00, 0x0F, 0x1E, 0x00, 0x07, 0x8F, 0x00, 0x07,
  0x87, 0x80, 0x03, 0x83, 0xC0, 0x03, 0xC1, 0xE0, 0x03, 0xC0, 0xF0, 0x01,
  0xE0, 0x78, 0x01, 0xE0, 0x3C, 0x00, 0xF0, 0x1E, 0x00, 0xF0, 0x0F, 0x00,
  0x78, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x38, 0x01, 0xE0, 0x3F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x0F, 0x00, 0x07,
  0x87, 0x80, 0x03, 0xC7, 0x80, 0x01, 0xE3, 0xC0, 0x00, 0xF3, 0xC0, 0x00,
  0x79, 0xE0, 0x00, 0x3D, 0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x0F, 0x01, 0xFF,
  0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x1E,
  0x03, 0xF0, 0x1F, 0x00, 0x7C, 0x0F, 0x00, 0x3E, 0x07, 0x80, 0x1F, 0x03,
  0xC0, 0x0F, 0x03, 0xE0, 0x07, 0x81, 0xE0, 0x07, 0xC0, 0xF0, 0x07, 0xC0,
  0x78, 0x0F, 0xC0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF8, 0x07, 0x80, 0x7E, 0x07, 0x80, 0x0F, 0x03, 0xC0, 0x07,
  0xC1, 0xE0, 0x03, 0xE0, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xF8, 0x78, 0x00,
  0x7C, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x3E, 0x0E, 0x00, 0x3E, 0x0F, 0x00,
  0xFF, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x03, 0xF8, 0x1E, 0x07, 0xE0, 0x02, 0x0F, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x80, 0x7E,
  0x03, 0x80, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFF, 0x80, 0x3C, 0x0F, 0xE0, 0x1E, 0x01, 0xF8, 0x0F, 0x00, 0x7C,
  0x07, 0x80, 0x1E, 0x07, 0x80, 0x0F, 0x03, 0xC0, 0x07, 0xC1, 0xE0, 0x03,
  0xE0, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x78, 0x00, 0x7C, 0x3C, 0x00,
  0x3C, 0x1E, 0x00, 0x1E, 0x1F, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x87, 0x80,
  0x07, 0xC3, 0xC0, 0x03, 0xC3, 0xE0, 0x01, 0xE1, 0xE0, 0x01, 0xF0, 0xF0,
  0x01, 0xF0, 0x78, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x3C, 0x00, 0xF8, 0x1E,
  0x01, 0xFC, 0x0F, 0x03, 0xFC, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x03,
  0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xFF, 0x00,
  0xFF, 0xFF, 0x01, 0xFC, 0x0E, 0x03, 0xE0, 0x02, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x78, 0xF8, 0x00, 0x78, 0xF0, 0x00, 0x78, 0xF0,
  0x00, 0xF8, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0xF8,
  0x01, 0xF0, 0xF8, 0x01, 0xE0, 0x7C, 0x01, 0xE0, 0x7C, 0x01, 0xE0, 0x7F,
  0x03, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x03,
  0xFE, 0x00, 0x01, 0xE0, 0x01, 0xE0, 0x3C, 0x00, 0x3C, 0x07, 0x80, 0x07,
  0x80, 0xF0, 0x01, 0xF0, 0x3C, 0x00, 0x3C, 0x07, 0x80, 0x07, 0x80, 0xF0,
  0x00, 0xF0, 0x1E, 0x00, 0x3E, 0x07, 0xC0, 0x07, 0x80, 0xF0, 0x00, 0xF0,
  0x1E, 0x00, 0x1E, 0x03, 0xC0, 0x07, 0xC0, 0xF8, 0x00, 0xF0, 0x1F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x03,
  0xC0, 0x03, 0xC0, 0x78, 0x00, 0x78, 0x0F, 0x00, 0x0F, 0x01, 0xE0, 0x03,
  0xE0, 0x78, 0x00, 0x78, 0x0F, 0x00, 0x0F, 0x01, 0xE0, 0x01, 0xE0, 0x3C,
  0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x01, 0xE0, 0x01, 0xE0, 0x3C, 0x00, 0x3C,
  0x07, 0x80, 0x0F, 0x81, 0xF0, 0x01, 0xE0, 0x3C, 0x00, 0x3C, 0x07, 0x80,
  0x07, 0x80, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x03,
  0xFF, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x10, 0x01, 0xF0, 0x0C,
  0x01, 0xF0, 0x0F, 0x83, 0xF8, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00,
  0x7F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xF0, 0x03, 0xF0, 0x1F, 0x00,
  0x7E, 0x01, 0xE0, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x01, 0xE0, 0x1F, 0x00,
  0x1E, 0x03, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x3C, 0x0F, 0x80, 0x03, 0xC1,
  0xF0, 0x00, 0x3C, 0x3E, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x78, 0xF8, 0x00,
  0x07, 0xBF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x1F, 0x3E, 0x00,
  0x01, 0xE1, 0xF0, 0x00, 0x1E, 0x1F, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x1E,
  0x07, 0x80, 0x03, 0xE0, 0x7C, 0x00, 0x3C, 0x03, 0xC0, 0x03, 0xC0, 0x3E,
  0x00, 0x3C, 0x01, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x00, 0xF0, 0x07,
  0x80, 0x0F, 0x80, 0x78, 0x00, 0x78, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C,
  0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF0,
  0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x03, 0xB8, 0x0E, 0xE0,
  0xFF, 0x01, 0xDC, 0x1D, 0xC0, 0x3B, 0x87, 0x38, 0x0F, 0x70, 0xE7, 0x01,
  0xCF, 0x39, 0xE0, 0x38, 0xE7, 0x3C, 0x0F, 0x1D, 0xC7, 0x81, 0xC3, 0xB8,
  0xE0, 0x38, 0x7E, 0x1C, 0x0F, 0x0F, 0xC7, 0x81, 0xE1, 0xF0, 0xF0, 0x38,
  0x3E, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0x00, 0x70, 0x3C, 0x00, 0x1E,
  0x07, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x0F, 0x07, 0x80,
  0x03, 0xC1, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xE0,
  0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0xE0, 0x1F, 0x00, 0x1E, 0x01, 0xF0, 0x01, 0xE0, 0x1F, 0x80, 0x1E,
  0x01, 0xF8, 0x01, 0xC0, 0x3F, 0x80, 0x3C, 0x03, 0xFC, 0x03, 0xC0, 0x3F,
  0xC0, 0x3C, 0x03, 0x9C, 0x03, 0xC0, 0x79, 0xE0, 0x78, 0x07, 0x9E, 0x07,
  0x80, 0x79, 0xE0, 0x78, 0x07, 0x0E, 0x07, 0x80, 0xF0, 0xF0, 0x70, 0x0F,
  0x0F, 0x0F, 0x00, 0xF0, 0x70, 0xF0, 0x0E, 0x07, 0x0F, 0x01, 0xE0, 0x70,
  0xE0, 0x1E, 0x07, 0x9E, 0x01, 0xE0, 0x79, 0xE0, 0x1E, 0x03, 0x9E, 0x01,
  0xC0, 0x39, 0xC0, 0x3C, 0x03, 0xBC, 0x03, 0xC0, 0x3F, 0xC0, 0x3C, 0x03,
  0xFC, 0x03, 0x80, 0x1F, 0x80, 0x78, 0x01, 0xF8, 0x07, 0x80, 0x1F, 0x80,
  0x78, 0x01, 0xF8, 0x07, 0x00, 0x1F, 0x80, 0xF0, 0x00, 0xF0, 0x0F, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xF8, 0x01,
  0xFF, 0xFC, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0x3E, 0x07, 0xC0, 0x1E, 0x0F,
  0x80, 0x1E, 0x1F, 0x00, 0x1F, 0x1E, 0x00, 0x1F, 0x1E, 0x00, 0x1F, 0x3C,
  0x00, 0x1F, 0x3C, 0x00, 0x1E, 0x7C, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78,
  0x00, 0x1E, 0x78, 0x00, 0x1E, 0xF8, 0x00, 0x3C, 0xF8, 0x00, 0x3C, 0xF0,
  0x00, 0x3C, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0xF8, 0xF0,
  0x00, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0x7E,
  0x1F, 0xC0, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00,
  0x7F, 0xFF, 0xC0, 0x3E, 0x07, 0xF0, 0x1E, 0x00, 0xF8, 0x0F, 0x00, 0x3C,
  0x07, 0x80, 0x1F, 0x07, 0xC0, 0x0F, 0x83, 0xC0, 0x07, 0xC1, 0xE0, 0x03,
  0xC0, 0xF0, 0x01, 0xE0, 0xF8, 0x00, 0xF0, 0x78, 0x00, 0xF8, 0x3C, 0x00,
  0xF8, 0x1E, 0x00, 0xF8, 0x1F, 0x01, 0xFC, 0x0F, 0xFF, 0xFC, 0x07, 0xFF,
  0xF8, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x01, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0x3E,
  0x07, 0xC0, 0x1E, 0x0F, 0x80, 0x1E, 0x1F, 0x00, 0x1F, 0x1E, 0x00, 0x1F,
  0x1E, 0x00, 0x1F, 0x3C, 0x00, 0x1F, 0x3C, 0x00, 0x1E, 0x7C, 0x00, 0x1E,
  0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x3E,
  0xF8, 0x00, 0x3C, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x78,
  0xF0, 0x00, 0xF8, 0xF0, 0x00, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x03, 0xE0,
  0x7C, 0x07, 0xC0, 0x7E, 0x1F, 0xC0, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x00,
  0x1F, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x06, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x1E, 0x03, 0xF0, 0x0F, 0x00,
  0x7C, 0x0F, 0x80, 0x3E, 0x07, 0x80, 0x0F, 0x03, 0xC0, 0x07, 0x81, 0xE0,
  0x03, 0xC1, 0xF0, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0x78, 0x00, 0xF0, 0x3C,
  0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x1E, 0x03, 0xF8, 0x0F, 0xFF, 0xF8, 0x07,
  0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x01, 0xE0, 0x78, 0x00,
  0xF0, 0x3E, 0x00, 0x78, 0x0F, 0x00, 0x7C, 0x07, 0xC0, 0x3C, 0x01, 0xE0,
  0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x7C, 0x0F, 0x80, 0x1E, 0x07, 0x80, 0x0F,
  0x03, 0xC0, 0x07, 0x81, 0xE0, 0x03, 0xE1, 0xF0, 0x00, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F,
  0x80, 0xF0, 0x1F, 0x00, 0x10, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x18, 0x00, 0x7C, 0x0F, 0x00,
  0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x03,
  0xC1, 0xE0, 0x01, 0xE0, 0xF0, 0x01, 0xF0, 0xF0, 0x00, 0xF0, 0x78, 0x00,
  0x78, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x3E, 0x1E, 0x00, 0x1E, 0x0F, 0x00,
  0x0F, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x07, 0xC3, 0xC0, 0x03, 0xC1, 0xE0,
  0x01, 0xE0, 0xF0, 0x00, 0xF0, 0x78, 0x00, 0xF8, 0x78, 0x00, 0x78, 0x3C,
  0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x07,
  0x80, 0x07, 0x83, 0xC0, 0x07, 0xC1, 0xE0, 0x03, 0xC0, 0xF0, 0x01, 0xE0,
  0x7C, 0x01, 0xF0, 0x1E, 0x01, 0xF0, 0x0F, 0x81, 0xF8, 0x07, 0xFF, 0xF8,
  0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x3E, 0xF0, 0x00,
  0x3C, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0xF8, 0xF0, 0x00,
  0xF0, 0xF0, 0x01, 0xF0, 0xF0, 0x01, 0xE0, 0xF8, 0x03, 0xC0, 0xF8, 0x03,
  0xC0, 0xF8, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x00, 0x78, 0x0F,
  0x00, 0x78, 0x1E, 0x00, 0x78, 0x1E, 0x00, 0x78, 0x3C, 0x00, 0x78, 0x3C,
  0x00, 0x78, 0x78, 0x00, 0x78, 0x78, 0x00, 0x78, 0xF0, 0x00, 0x79, 0xE0,
  0x00, 0x79, 0xE0, 0x00, 0x7B, 0xC0, 0x00, 0x7B, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x1E,
  0x0F, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x38, 0x0F, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x70, 0x1E, 0x1E, 0x0F, 0x01, 0xC1, 0xE0, 0xF0, 0x1C,
  0x3E, 0x0E, 0x03, 0xC3, 0xE0, 0xE0, 0x3C, 0x76, 0x1E, 0x03, 0xC7, 0x71,
  0xC0, 0x38, 0xE7, 0x1C, 0x03, 0x8E, 0x73, 0xC0, 0x39, 0xC7, 0x3C, 0x07,
  0xBC, 0x73, 0x80, 0x73, 0x87, 0x38, 0x07, 0x70, 0x77, 0x80, 0x77, 0x07,
  0x70, 0x07, 0xE0, 0x77, 0x00, 0x7E, 0x07, 0x70, 0x0F, 0xC0, 0x7E, 0x00,
  0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0,
  0x01, 0xE0, 0x01, 0xF0, 0x07, 0xC0, 0x03, 0xE0, 0x1F, 0x00, 0x03, 0xC0,
  0x7C, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x0F, 0x0F,
  0x80, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x3D, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xE7, 0x80, 0x00,
  0x0F, 0x8F, 0x00, 0x00, 0x3E, 0x1E, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x03,
  0xF0, 0x3C, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x03, 0xE0, 0x0F, 0x80,
  0x07, 0xC0, 0x3E, 0x00, 0x07, 0x80, 0x78, 0x00, 0x0F, 0x3C, 0x00, 0x0F,
  0x9E, 0x00, 0x07, 0x8F, 0x00, 0x07, 0x87, 0x80, 0x07, 0xC3, 0xE0, 0x03,
  0xC0, 0xF0, 0x03, 0xC0, 0x78, 0x03, 0xE0, 0x3C, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x07, 0x81, 0xF0, 0x03, 0xC1, 0xF0, 0x01, 0xE0, 0xF0, 0x00, 0x78,
  0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x1E, 0x78, 0x00, 0x07, 0x78, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xE0, 0x07, 0xFF, 0x80, 0x00, 0xF0, 0xF8, 0xF8, 0xF8, 0x78, 0x78, 0x78,
  0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x7C, 0x7C, 0x7C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3E, 0x3E, 0x3E, 0x3E, 0x1E,
  0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1F, 0x1F, 0x1F, 0x0F,
  0x0F, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x80, 0x1F, 0x78, 0x03,
  0xE7, 0x80, 0x3C, 0x3C, 0x07, 0xC3, 0xC0, 0xF8, 0x3C, 0x1F, 0x01, 0xE3,
  0xE0, 0x1E, 0x3C, 0x01, 0xE7, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F,
  0x20, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x10, 0x1C, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F,
  0x03, 0x00, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x07, 0xF0, 0x78, 0x3F, 0x01, 0xE1, 0xF0, 0x07, 0x8F, 0x80, 0x1E,
  0x3C, 0x00, 0xF1, 0xF0, 0x03, 0xC7, 0x80, 0x0F, 0x3E, 0x00, 0x3C, 0xF0,
  0x01, 0xF3, 0xC0, 0x07, 0x8F, 0x00, 0x1E, 0x3C, 0x00, 0x78, 0xF0, 0x03,
  0xE3, 0xC0, 0x0F, 0x0F, 0x00, 0x3C, 0x3C, 0x00, 0xF0, 0xF8, 0x07, 0xC3,
  0xF0, 0x7F, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xF9, 0xE0, 0x3F,
  0x87, 0x80, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x3F, 0x00, 0x1F, 0xFF,
  0x80, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x81, 0xF8, 0x3F, 0x03, 0xC0, 0x1E,
  0x07, 0x00, 0x3E, 0x1E, 0x00, 0x7C, 0x3C, 0x00, 0x78, 0x78, 0x00, 0xF0,
  0xF0, 0x01, 0xE3, 0xC0, 0x07, 0xC7, 0x80, 0x0F, 0x0F, 0x00, 0x1E, 0x1E,
  0x00, 0x3C, 0x78, 0x00, 0xF8, 0xF0, 0x01, 0xE1, 0xE0, 0x07, 0xC3, 0xC0,
  0x1F, 0x07, 0x00, 0x7E, 0x1E, 0x01, 0xF8, 0x3C, 0x1F, 0xE0, 0x7F, 0xFF,
  0x80, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xF0, 0x18,
  0x7F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x41, 0xF8, 0x07, 0x03, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0xFF, 0xE0, 0x01, 0xFF,
  0xF8, 0x01, 0xFF, 0xFE, 0x00, 0xFE, 0x1F, 0x00, 0x7E, 0x03, 0xC0, 0x3E,
  0x01, 0xF0, 0x1F, 0x00, 0x7C, 0x07, 0x80, 0x1E, 0x03, 0xE0, 0x07, 0x80,
  0xF0, 0x01, 0xE0, 0x7C, 0x00, 0xF8, 0x1E, 0x00, 0x3C, 0x07, 0x80, 0x0F,
  0x03, 0xE0, 0x03, 0xC0, 0xF0, 0x00, 0xF0, 0x3C, 0x00, 0x78, 0x0F, 0x00,
  0x1E, 0x03, 0xC0, 0x07, 0x80, 0xF0, 0x01, 0xE0, 0x3E, 0x00, 0x78, 0x0F,
  0x80, 0x3E, 0x01, 0xE0, 0x1F, 0x80, 0x7E, 0x1F, 0xE0, 0x0F, 0xFF, 0xF8,
  0x01, 0xFF, 0x9E, 0x00, 0x1F, 0x87, 0x80, 0x00, 0x3F, 0xC0, 0x03, 0xFF,
  0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xE0, 0xF8, 0x7E, 0x01, 0xF3,
  0xF0, 0x07, 0xCF, 0x80, 0x1F, 0x7C, 0x00, 0x79, 0xE0, 0x03, 0xE7, 0x80,
  0x1F, 0xBC, 0x07, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0,
  0x3F, 0xF8, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF8, 0x00, 0x41, 0xF8, 0x0F, 0x07, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF0, 0x0F, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x0F, 0xC0, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x10, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF,
  0xF0, 0x01, 0xFF, 0xFC, 0x01, 0xFC, 0x3F, 0x00, 0xFC, 0x07, 0x80, 0x7C,
  0x01, 0xE0, 0x3E, 0x00, 0x78, 0x0F, 0x00, 0x3E, 0x07, 0xC0, 0x0F, 0x01,
  0xE0, 0x03, 0xC0, 0xF8, 0x00, 0xF0, 0x3C, 0x00, 0x7C, 0x0F, 0x00, 0x1E,
  0x03, 0xC0, 0x07, 0x81, 0xF0, 0x01, 0xE0, 0x7C, 0x00, 0x78, 0x1F, 0x00,
  0x3C, 0x07, 0xC0, 0x0F, 0x00, 0xF0, 0x03, 0xC0, 0x3C, 0x03, 0xF0, 0x0F,
  0x83, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xF1, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x78, 0x0F, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3D, 0xFC,
  0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7C, 0x0F, 0xC1,
  0xE0, 0x1F, 0x07, 0x80, 0x3C, 0x1E, 0x00, 0xF0, 0xF0, 0x03, 0xC3, 0xC0,
  0x0F, 0x0F, 0x00, 0x3C, 0x3C, 0x00, 0xF1, 0xE0, 0x07, 0xC7, 0x80, 0x1E,
  0x1E, 0x00, 0x78, 0x78, 0x01, 0xE3, 0xC0, 0x0F, 0x8F, 0x00, 0x3C, 0x3C,
  0x00, 0xF0, 0xF0, 0x03, 0xC7, 0xC0, 0x0F, 0x1E, 0x00, 0x7C, 0x78, 0x01,
  0xE1, 0xE0, 0x07, 0x8F, 0x80, 0x1E, 0x00, 0x00, 0x70, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x8F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x00,
  0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x07, 0xFF, 0x07, 0xFE, 0x07, 0xFC, 0x07,
  0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x01,
  0xC0, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x03, 0xE0, 0x3C, 0x03, 0xE0, 0x3C, 0x03, 0xE0,
  0x1E, 0x07, 0xE0, 0x0F, 0x07, 0xE0, 0x07, 0x8F, 0xC0, 0x07, 0x8F, 0xC0,
  0x03, 0xDF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x3D, 0xF8, 0x00, 0x1E, 0x7C, 0x00, 0x0F, 0x1F,
  0x00, 0x0F, 0x07, 0xC0, 0x07, 0x81, 0xF0, 0x03, 0xC0, 0xF8, 0x01, 0xE0,
  0x3E, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0xC0, 0x78, 0x01, 0xE0, 0x3C,
  0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x00, 0x7F, 0xF1, 0xFF, 0xCF, 0xFE, 0x3F,
  0xF8, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0xC0,
  0x1F, 0x02, 0x7F, 0xF8, 0xFF, 0xE1, 0xFF, 0xC3, 0xF8, 0x01, 0xFC, 0x3C,
  0x03, 0xFF, 0x7F, 0x81, 0xFF, 0xFF, 0xC0, 0xE1, 0xF1, 0xE0, 0xF0, 0xF0,
  0x78, 0x78, 0x78, 0x38, 0x3C, 0x3C, 0x3C, 0x1C, 0x1E, 0x1E, 0x1E, 0x0E,
  0x0F, 0x0F, 0x0F, 0x07, 0x87, 0x87, 0x83, 0x83, 0x83, 0xC3, 0xC3, 0xC1,
  0xE1, 0xE1, 0xE1, 0xE0, 0xF0, 0xF0, 0xF0, 0x78, 0x78, 0x00, 0x78, 0x38,
  0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x07,
  0x00, 0x07, 0x87, 0x80, 0x03, 0xC3, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xF0,
  0xE0, 0x00, 0x70, 0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF,
  0x81, 0xFF, 0xFE, 0x07, 0x80, 0xFC, 0x1E, 0x01, 0xF0, 0xF8, 0x03, 0xC3,
  0xE0, 0x0F, 0x0F, 0x00, 0x3C, 0x3C, 0x00, 0xF0, 0xF0, 0x03, 0xC7, 0xC0,
  0x1F, 0x1E, 0x00, 0x78, 0x78, 0x01, 0xE1, 0xE0, 0x07, 0x8F, 0x80, 0x1E,
  0x3C, 0x00, 0xF8, 0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x1F, 0x00, 0x3C, 0x78,
  0x01, 0xF1, 0xE0, 0x07, 0x87, 0x80, 0x1E, 0x1E, 0x00, 0x78, 0xF8, 0x03,
  0xE0, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFE,
  0x0F, 0xE1, 0xF8, 0x7E, 0x01, 0xE1, 0xF0, 0x07, 0xCF, 0x80, 0x1F, 0x3C,
  0x00, 0x7D, 0xF0, 0x01, 0xF7, 0xC0, 0x07, 0xDE, 0x00, 0x1F, 0x78, 0x00,
  0x7B, 0xE0, 0x01, 0xEF, 0x00, 0x07, 0xBC, 0x00, 0x3E, 0xF0, 0x00, 0xF3,
  0xC0, 0x07, 0xCF, 0x00, 0x1F, 0x3E, 0x00, 0xF8, 0xF8, 0x07, 0xC1, 0xF0,
  0x7F, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x3F,
  0xFF, 0xC0, 0x1E, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x3E, 0x07,
  0x80, 0x1F, 0x03, 0xC0, 0x07, 0x83, 0xE0, 0x03, 0xC1, 0xF0, 0x01, 0xE0,
  0xF0, 0x01, 0xF0, 0x78, 0x00, 0xF0, 0x3C, 0x00, 0x78, 0x3E, 0x00, 0x3C,
  0x1E, 0x00, 0x3E, 0x0F, 0x00, 0x1E, 0x07, 0x80, 0x1F, 0x07, 0xC0, 0x1F,
  0x03, 0xC0, 0x1F, 0x81, 0xE0, 0x1F, 0x80, 0xF0, 0x3F, 0x80, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x1F, 0xC1, 0xE0, 0x7C, 0x03, 0xC1,
  0xF0, 0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0x00, 0x3C, 0x3E, 0x00, 0x78, 0x78,
  0x00, 0xF1, 0xF0, 0x03, 0xE3, 0xC0, 0x07, 0x87, 0x80, 0x0F, 0x1F, 0x00,
  0x1E, 0x3C, 0x00, 0x7C, 0x78, 0x00, 0xF0, 0xF0, 0x01, 0xE1, 0xE0, 0x03,
  0xC3, 0xC0, 0x07, 0x87, 0xC0, 0x1E, 0x0F, 0x80, 0x3C, 0x0F, 0x00, 0xF8,
  0x1F, 0x87, 0xF0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x0F, 0xCF, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0xF8, 0x0F,
  0xFF, 0xE0, 0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x0F, 0xC0, 0x10, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0xFF, 0xFE, 0x07, 0xE0, 0x30, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0,
  0x60, 0x03, 0xC1, 0xE0, 0x3F, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0x7F,
  0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x3E, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x03, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x01, 0x03,
  0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x1F, 0xC0, 0x0F, 0x00, 0x3C,
  0x7C, 0x00, 0xF1, 0xF0, 0x07, 0xC7, 0x80, 0x1E, 0x1E, 0x00, 0x78, 0x78,
  0x01, 0xE3, 0xE0, 0x07, 0x8F, 0x00, 0x3E, 0x3C, 0x00, 0xF0, 0xF0, 0x03,
  0xC7, 0xC0, 0x0F, 0x1E, 0x00, 0x7C, 0x78, 0x01, 0xE1, 0xE0, 0x07, 0x87,
  0x80, 0x1E, 0x3E, 0x00, 0xF8, 0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x0F, 0x80,
  0x3C, 0x3E, 0x01, 0xF0, 0x7C, 0x1F, 0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0xFC,
  0x07, 0xFE, 0x78, 0x0F, 0xE1, 0xE0, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF0,
  0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x03, 0xEF, 0x00, 0x3C, 0xF0, 0x07, 0xCF,
  0x80, 0x78, 0xF8, 0x0F, 0x8F, 0x80, 0xF0, 0x78, 0x1F, 0x07, 0x81, 0xE0,
  0x78, 0x3C, 0x07, 0x83, 0xC0, 0x78, 0x78, 0x07, 0x87, 0x80, 0x78, 0xF0,
  0x03, 0xDE, 0x00, 0x3D, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x3F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x9E, 0x00, 0x03,
  0xCE, 0x00, 0x01, 0xEF, 0x00, 0x01, 0xE7, 0x80, 0x00, 0xF3, 0xC0, 0x00,
  0x79, 0xE0, 0x70, 0x78, 0xF0, 0x78, 0x3C, 0x78, 0x3C, 0x1E, 0x3C, 0x3E,
  0x1E, 0x1C, 0x1F, 0x0F, 0x0E, 0x1F, 0x87, 0x07, 0x1F, 0xC7, 0x83, 0x8E,
  0xE3, 0xC3, 0xCE, 0x79, 0xC1, 0xE7, 0x1D, 0xE0, 0xF7, 0x0E, 0xE0, 0x7F,
  0x87, 0xF0, 0x3F, 0x83, 0xF8, 0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0xFC, 0x07,
  0xC0, 0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xE0, 0x0E, 0x00, 0x03, 0xE0, 0x03,
  0xC0, 0x3C, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0x78, 0x0F, 0x80, 0x0F,
  0x83, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x1F, 0x1E, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xDE, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x7C, 0x3C, 0x00, 0x1F, 0x07,
  0xC0, 0x07, 0xC0, 0x78, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x00, 0xF0, 0x1F,
  0x00, 0x1E, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x0F, 0x00,
  0x1F, 0x00, 0xF0, 0x01, 0xF0, 0x0F, 0x00, 0x1E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3C, 0x00, 0x78, 0x03, 0xC0, 0x07, 0x80, 0x7C, 0x00, 0x78,
  0x07, 0x80, 0x07, 0x80, 0x78, 0x00, 0x78, 0x0F, 0x00, 0x07, 0xC0, 0xF0,
  0x00, 0x3C, 0x1E, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x03,
  0xE3, 0xC0, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x1E, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x04, 0x0F, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x07,
  0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x18, 0x7F, 0x80, 0x73,
  0xFF, 0x03, 0xDF, 0xFF, 0x1E, 0x78, 0xFF, 0xFB, 0xC0, 0xFF, 0xCE, 0x01,
  0xFE, 0x18, 0x01, 0xF0,
};

const GFXglyph UbuntuMono_Italic51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 26, 0, -1 },
  { 1, 12, 32, 26, 9, -32 },
  { 49, 15, 13, 26, 11, -35 },
  { 74, 27, 32, 26, 2, -32 },
  { 182, 23, 40, 26, 4, -35 },
  { 297, 31, 32, 26, 0, -32 },
  { 421, 22, 32, 26, 3, -32 },
  { 509, 7, 14, 26, 15, -35 },
  { 522, 20, 45, 26, 7, -36 },
  { 635, 19, 45, 26, 3, -36 },
  { 742, 20, 19, 26, 7, -32 },
  { 790, 22, 22, 26, 4, -24 },
  { 851, 11, 14, 26, 5, -7 },
  { 871, 12, 4, 26, 9, -15 },
  { 877, 7, 7, 26, 9, -7 },
  { 884, 29, 44, 26, -1, -36 },
  { 1044, 23, 32, 26, 4, -32 },
  { 1136, 18, 32, 26, 5, -32 },
  { 1208, 23, 32, 26, 4, -32 },
  { 1300, 23, 32, 26, 3, -32 },
  { 1392, 24, 32, 26, 2, -32 },
  { 1488, 25, 32, 26, 3, -32 },
  { 1588, 23, 32, 26, 5, -32 },
  { 1680, 23, 32, 26, 7, -32 },
  { 1772, 23, 32, 26, 4, -32 },
  { 1864, 23, 32, 26, 4, -32 },
  { 1956, 11, 23, 26, 9, -23 },
  { 1988, 15, 30, 26, 5, -23 },
  { 2045, 22, 20, 26, 4, -23 },
  { 2100, 24, 14, 26, 3, -20 },
  { 2142, 23, 20, 26, 3, -23 },
  { 2200, 18, 32, 26, 8, -32 },
  { 2272, 25, 39, 26, 4, -32 },
  { 2394, 25, 32, 26, -1, -32 },
  { 2494, 25, 32, 26, 2, -32 },
  { 2594, 24, 32, 26, 5, -32 },
  { 2690, 25, 32, 26, 2, -32 },
  { 2790, 25, 32, 26, 4, -32 },
  { 2890, 25, 32, 26, 4, -32 },
  { 2990, 24, 32, 26, 4, -32 },
  { 3086, 27, 32, 26, 2, -32 },
  { 3194, 24, 32, 26, 4, -32 },
  { 3290, 25, 32, 26, 3, -32 },
  { 3390, 28, 32, 26, 2, -32 },
  { 3502, 18, 32, 26, 3, -32 },
  { 3574, 27, 32, 26, 1, -32 },
  { 3682, 28, 32, 26, 2, -32 },
  { 3794, 24, 32, 26, 4, -32 },
  { 3890, 25, 32, 26, 3, -32 },
  { 3990, 24, 40, 26, 4, -32 },
  { 4110, 25, 32, 26, 2, -32 },
  { 4210, 25, 32, 26, 3, -32 },
  { 4310, 22, 32, 26, 8, -32 },
  { 4398, 25, 32, 26, 4, -32 },
  { 4498, 24, 32, 26, 7, -32 },
  { 4594, 28, 32, 26, 3, -32 },
  { 4706, 31, 32, 26, 0, -32 },
  { 4830, 25, 32, 26, 7, -32 },
  { 4930, 27, 32, 26, 2, -32 },
  { 5038, 23, 44, 26, 5, -36 },
  { 5165, 8, 44, 26, 11, -36 },
  { 5209, 23, 44, 26, 1, -36 },
  { 5336, 20, 17, 26, 6, -32 },
  { 5379, 23, 4, 26, -1, 5 },
  { 5391, 9, 9, 26, 13, -35 },
  { 5402, 22, 26, 26, 4, -25 },
  { 5474, 23, 36, 26, 3, -35 },
  { 5578, 22, 26, 26, 4, -25 },
  { 5650, 26, 36, 26, 4, -35 },
  { 5767, 22, 26, 26, 4, -25 },
  { 5839, 31, 43, 26, 0, -35 },
  { 6006, 26, 33, 26, 1, -25 },
  { 6114, 22, 35, 26, 2, -35 },
  { 6211, 15, 35, 26, 7, -35 },
  { 6277, 25, 43, 26, 1, -35 },
  { 6412, 25, 35, 26, 3, -35 },
  { 6522, 14, 36, 26, 9, -35 },
  { 6585, 25, 25, 26, 2, -25 },
  { 6664, 22, 25, 26, 3, -25 },
  { 6733, 22, 26, 26, 4, -25 },
  { 6805, 25, 33, 26, 1, -25 },
  { 6909, 23, 33, 26, 4, -25 },
  { 7004, 22, 25, 26, 5, -25 },
  { 7073, 22, 26, 26, 4, -25 },
  { 7145, 19, 32, 26, 7, -31 },
  { 7221, 22, 25, 26, 4, -24 },
  { 7290, 20, 24, 26, 7, -24 },
  { 7350, 25, 24, 26, 4, -24 },
  { 7425, 27, 24, 26, 1, -24 },
  { 7506, 28, 32, 26, -1, -24 },
  { 7618, 23, 24, 26, 3, -24 },
  { 7687, 24, 44, 26, 5, -36 },
  { 7819, 14, 44, 26, 8, -36 },
  { 7896, 25, 44, 26, 0, -36 },
  { 8034, 22, 8, 26, 4, -18 },
};

const GFXfont UbuntuMono_Italic51pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Italic51pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Italic51pt7bGlyphs,
  0x20, 0x7E, 51
};

#endif // _UBUNTUMONO_ITALIC51PT7B_H_
