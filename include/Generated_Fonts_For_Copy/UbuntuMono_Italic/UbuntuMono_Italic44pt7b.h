#ifndef _UBUNTUMONO_ITALIC44PT7B_H_
#define _UBUNTUMONO_ITALIC44PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Italic.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Italic44pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xC0, 0xF0, 0x3C, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x3C, 0x0F,
  0x03, 0xC0, 0xE0, 0x38, 0x1E, 0x07, 0x81, 0xC0, 0x70, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1C, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x07, 0x00, 0x78,
  0x77, 0x8F, 0x70, 0xF7, 0x0E, 0x70, 0xEF, 0x0E, 0xE0, 0xCE, 0x1C, 0xE1,
  0xCC, 0x18, 0xC1, 0x80, 0x00, 0x1E, 0x1E, 0x00, 0x38, 0x38, 0x00, 0xF0,
  0x70, 0x01, 0xC1, 0xC0, 0x03, 0x83, 0x80, 0x0E, 0x0F, 0x00, 0x1C, 0x1C,
  0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x07, 0x07, 0x00,
  0x1E, 0x0E, 0x00, 0x38, 0x3C, 0x00, 0x70, 0x70, 0x01, 0xE1, 0xE0, 0x03,
  0x83, 0x80, 0x0F, 0x0F, 0x00, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0x81, 0xC1, 0xC0, 0x07, 0x07, 0x80, 0x0E, 0x0E, 0x00, 0x3C, 0x3C,
  0x00, 0x70, 0x70, 0x01, 0xE0, 0xE0, 0x03, 0x83, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x03, 0xFC, 0x00,
  0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0x7C, 0x0C, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x70, 0x20, 0x07, 0x83, 0xC0, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xF8, 0x01,
  0xFF, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xF8, 0x01, 0xC0, 0x3F, 0x80, 0x70, 0x0F,
  0xF0, 0x1C, 0x01, 0xCE, 0x07, 0x80, 0x70, 0xC0, 0xE0, 0x0E, 0x18, 0x38,
  0x01, 0x87, 0x0E, 0x00, 0x70, 0xE3, 0x80, 0x0E, 0x1C, 0xE0, 0x01, 0xC3,
  0xB8, 0x00, 0x3C, 0xEF, 0x00, 0x03, 0xFD, 0xC0, 0x00, 0x7F, 0x70, 0x00,
  0x07, 0x9D, 0xF0, 0x00, 0x07, 0x7F, 0x00, 0x01, 0xDF, 0xE0, 0x00, 0x73,
  0x9C, 0x00, 0x1E, 0xE1, 0x80, 0x07, 0x9C, 0x30, 0x00, 0xE3, 0x06, 0x00,
  0x38, 0x61, 0xC0, 0x0E, 0x1C, 0x38, 0x03, 0x83, 0x87, 0x00, 0xE0, 0x39,
  0xC0, 0x3C, 0x07, 0xF8, 0x0F, 0x00, 0xFE, 0x01, 0xC0, 0x0F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x1F, 0xE0, 0x07, 0xFE, 0x01, 0xE3, 0xC0, 0x78, 0x38,
  0x0E, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x3C, 0x07, 0x07, 0x00, 0xE1, 0xE0,
  0x1C, 0xF8, 0x03, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x83, 0xC7, 0xF8, 0x71,
  0xE7, 0x8E, 0x78, 0xF3, 0x8E, 0x0F, 0x73, 0xC0, 0xFC, 0x70, 0x1F, 0x8E,
  0x01, 0xE1, 0xC0, 0x3C, 0x3C, 0x0F, 0xC7, 0x87, 0xF8, 0xFF, 0xF7, 0x0F,
  0xFC, 0xF0, 0x7C, 0x1E, 0x00, 0x3C, 0xF3, 0x9E, 0x79, 0xE7, 0x1C, 0x73,
  0x8E, 0x38, 0x00, 0x01, 0x00, 0x03, 0x80, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x70, 0x00, 0x10, 0x00, 0x00,
  0x20, 0x00, 0x18, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x07, 0x00, 0x01, 0x00, 0x00, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x04, 0x1C, 0x13, 0xCE, 0x7B, 0xFF, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFE, 0x00, 0xE0, 0x01, 0xDC, 0x01, 0xEF, 0x01, 0xE3, 0xC1,
  0xF1, 0xF0, 0x70, 0x70, 0x18, 0x30, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70,
  0x00, 0x0F, 0x0F, 0xC7, 0xE3, 0xF1, 0xF8, 0x7C, 0x1C, 0x1E, 0x3E, 0x7E,
  0x3E, 0x18, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x7B, 0xFF, 0xFF, 0xFD, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x1F, 0xF0, 0x0F, 0xFF, 0x03, 0xE1, 0xE0, 0xF8, 0x1E, 0x1E,
  0x03, 0xC7, 0x80, 0x78, 0xE0, 0x0F, 0x3C, 0x01, 0xE7, 0x00, 0x3D, 0xE3,
  0x87, 0xBC, 0xF8, 0xF7, 0x1F, 0x1F, 0xE3, 0xE3, 0xBC, 0x7C, 0xF7, 0x87,
  0x1E, 0xF0, 0x03, 0xDC, 0x00, 0xF3, 0x80, 0x1E, 0x70, 0x07, 0x8E, 0x00,
  0xF1, 0xE0, 0x3C, 0x3C, 0x0F, 0x07, 0xC3, 0xE0, 0x7F, 0xF0, 0x07, 0xFC,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x7E,
  0x01, 0xFE, 0x07, 0xFE, 0x0F, 0xDE, 0x0F, 0x1C, 0x0C, 0x3C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xC0, 0x7F, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x00, 0x3F,
  0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xE0, 0x7C, 0x1F, 0x03, 0x00, 0xF0, 0x20,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x7F, 0xFF,
  0x8F, 0xFF, 0xF0, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xFC, 0x03,
  0xFF, 0xE0, 0x38, 0x3E, 0x02, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x0F, 0xF0,
  0x01, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00,
  0x78, 0x40, 0x0F, 0x8F, 0x03, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xEE, 0x00, 0x3D, 0xE0, 0x07, 0x9E, 0x00, 0xF1,
  0xC0, 0x1E, 0x1C, 0x03, 0xC3, 0xC0, 0x78, 0x3C, 0x0F, 0x03, 0x81, 0xE0,
  0x38, 0x1C, 0x07, 0x83, 0xC0, 0x78, 0x78, 0x07, 0x07, 0xFF, 0xFE, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFE, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x7F,
  0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x00, 0xFE,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x08, 0x07, 0xE0, 0x7F, 0xFF, 0x01, 0xFF, 0xF0, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xE0, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01,
  0xC0, 0x00, 0x3C, 0xFC, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0x87, 0xC0, 0x78,
  0x78, 0x03, 0xC7, 0x00, 0x3C, 0xF0, 0x03, 0xCF, 0x00, 0x3C, 0xF0, 0x03,
  0xCF, 0x00, 0x38, 0xF0, 0x07, 0x8F, 0x00, 0x78, 0x78, 0x0F, 0x07, 0xC3,
  0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0x1F, 0xFF, 0xF1,
  0xFF, 0xFF, 0x3F, 0xFF, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0x00, 0x7F,
  0xFC, 0x07, 0xC1, 0xE0, 0x78, 0x07, 0x83, 0xC0, 0x3C, 0x1C, 0x01, 0xE1,
  0xE0, 0x0E, 0x0F, 0x00, 0xF0, 0x78, 0x07, 0x81, 0xE0, 0x78, 0x0F, 0x8F,
  0x80, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x3E, 0xFC, 0x03, 0xC1, 0xF0, 0x3C,
  0x07, 0xC3, 0xC0, 0x1E, 0x1E, 0x00, 0xF0, 0xE0, 0x07, 0x8F, 0x00, 0x3C,
  0x78, 0x01, 0xE1, 0xE0, 0x1E, 0x0F, 0x83, 0xF0, 0x3F, 0xFF, 0x00, 0xFF,
  0xE0, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xF8,
  0x0F, 0xC3, 0xE0, 0x78, 0x0F, 0x07, 0x80, 0x38, 0x38, 0x01, 0xC3, 0xC0,
  0x0F, 0x1E, 0x00, 0x78, 0xF0, 0x03, 0x87, 0x80, 0x1C, 0x3C, 0x00, 0xE1,
  0xE0, 0x0F, 0x07, 0x81, 0xF8, 0x3F, 0xFF, 0x80, 0xFF, 0xFC, 0x01, 0xF9,
  0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0x00, 0x7F, 0xE0, 0x03, 0xFC, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0x03, 0xE1, 0xFC, 0x7E, 0x1F, 0x83, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x83, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC1, 0xC0, 0x00, 0xE0, 0x0F, 0x80, 0xFE, 0x07, 0xE0, 0x3F,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x1F,
  0x00, 0x70, 0x07, 0x80, 0xF8, 0x1F, 0x80, 0xF8, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x1F, 0x00, 0x07, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0x78, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0x80, 0x00, 0xF0, 0x00, 0x03, 0x00, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x3F,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xC0, 0x08, 0x00,
  0x03, 0xC0, 0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x01, 0xE0, 0x01, 0xF8, 0x01, 0xFF,
  0x01, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x07, 0x80, 0x00,
  0x80, 0x00, 0x00, 0x07, 0xF8, 0x1F, 0xFC, 0x1F, 0xFE, 0x08, 0x1F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1E, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x7C,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x70, 0x00, 0x00, 0x0F, 0xC0,
  0x01, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x7C, 0x1E, 0x03, 0xC0, 0x38, 0x1E,
  0x00, 0xE0, 0xF0, 0x03, 0xC3, 0x80, 0x0F, 0x1E, 0x00, 0x38, 0x70, 0x1F,
  0xE3, 0xC1, 0xFF, 0x8E, 0x1F, 0xFE, 0x78, 0x78, 0x79, 0xE3, 0xC1, 0xC7,
  0x1E, 0x07, 0x1C, 0x78, 0x3C, 0xF1, 0xC0, 0xF3, 0xC7, 0x03, 0x8F, 0x1C,
  0x0E, 0x38, 0x70, 0x78, 0xE1, 0xC1, 0xC3, 0x87, 0x87, 0x0F, 0x0F, 0xFC,
  0x3C, 0x1F, 0xF0, 0xF0, 0x3F, 0x81, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x01, 0xDC, 0x00, 0x07, 0x70, 0x00, 0x39, 0xC0, 0x01, 0xE7, 0x00,
  0x07, 0x1E, 0x00, 0x3C, 0x78, 0x00, 0xE1, 0xE0, 0x07, 0x07, 0x80, 0x1C,
  0x0E, 0x00, 0xE0, 0x38, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0xF0, 0x0E,
  0x03, 0x80, 0x38, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xFF, 0xFE, 0x0E,
  0x00, 0x38, 0x78, 0x00, 0xE1, 0xC0, 0x03, 0x8F, 0x00, 0x0F, 0x38, 0x00,
  0x3D, 0xE0, 0x00, 0xF7, 0x00, 0x03, 0xC0, 0x03, 0xFF, 0x80, 0x1F, 0xFF,
  0x00, 0xFF, 0xFC, 0x0F, 0x03, 0xF0, 0x78, 0x07, 0x83, 0xC0, 0x3C, 0x1C,
  0x01, 0xE1, 0xE0, 0x0F, 0x0F, 0x00, 0x70, 0x78, 0x07, 0x83, 0x80, 0xF8,
  0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x70, 0x1F, 0x83, 0x80,
  0x3C, 0x3C, 0x00, 0xE1, 0xE0, 0x07, 0x0E, 0x00, 0x38, 0x70, 0x01, 0xC7,
  0x80, 0x1E, 0x3C, 0x01, 0xF1, 0xC0, 0x1F, 0x0E, 0x03, 0xF0, 0x7F, 0xFF,
  0x07, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0x80,
  0x7F, 0xFE, 0x07, 0xC0, 0xE0, 0x78, 0x01, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x08, 0x0F, 0xC1, 0xC0, 0x3F, 0xFF, 0x00,
  0xFF, 0xF0, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFC, 0x01, 0xFF,
  0xF8, 0x0F, 0x07, 0xC0, 0x78, 0x0F, 0x03, 0x80, 0x78, 0x3C, 0x01, 0xE1,
  0xE0, 0x0F, 0x0F, 0x00, 0x78, 0x70, 0x03, 0xC7, 0x80, 0x1E, 0x3C, 0x00,
  0xF1, 0xE0, 0x07, 0x8E, 0x00, 0x3C, 0xF0, 0x01, 0xC7, 0x80, 0x0E, 0x3C,
  0x00, 0xF1, 0xC0, 0x07, 0x9E, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80, 0x3C,
  0x38, 0x03, 0xC1, 0xC0, 0x7C, 0x1E, 0x0F, 0xC0, 0xFF, 0xFC, 0x07, 0xFF,
  0x80, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF,
  0x80, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xFF,
  0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7F, 0xFF,
  0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xC0, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x01, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x0F, 0xC1, 0xE0, 0xF8, 0x02, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80,
  0x0F, 0x1C, 0x00, 0x78, 0xE0, 0x03, 0x87, 0x00, 0x3C, 0x38, 0x01, 0xE1,
  0xC0, 0x0F, 0x0F, 0x00, 0x70, 0x78, 0x07, 0x83, 0xE0, 0x3C, 0x0F, 0x81,
  0xE0, 0x3F, 0xFE, 0x00, 0xFF, 0xF0, 0x01, 0xFC, 0x00, 0x03, 0xC0, 0x0E,
  0x07, 0x00, 0x3C, 0x1E, 0x00, 0x78, 0x3C, 0x00, 0xF0, 0x78, 0x01, 0xC0,
  0xE0, 0x07, 0x81, 0xC0, 0x0F, 0x07, 0x80, 0x1E, 0x0F, 0x00, 0x38, 0x1C,
  0x00, 0xF0, 0x38, 0x01, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x03, 0xFF,
  0xFE, 0x07, 0x00, 0x3C, 0x1E, 0x00, 0x78, 0x3C, 0x00, 0xE0, 0x70, 0x03,
  0xC0, 0xE0, 0x07, 0x83, 0xC0, 0x0F, 0x07, 0x80, 0x1C, 0x0E, 0x00, 0x38,
  0x1C, 0x00, 0xF0, 0x78, 0x01, 0xE0, 0xF0, 0x03, 0x81, 0xE0, 0x07, 0x03,
  0x80, 0x1E, 0x00, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x00,
  0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x7F, 0xFE, 0x07, 0xFF, 0xF0, 0x3F,
  0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x81,
  0x00, 0x78, 0x0E, 0x07, 0xC0, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x07, 0xF8,
  0x00, 0x03, 0xC0, 0x1E, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x03, 0x80,
  0xF0, 0x07, 0x81, 0xE0, 0x07, 0x83, 0xC0, 0x07, 0x07, 0x80, 0x07, 0x0F,
  0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x7C, 0x00, 0x0E, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x1C, 0x78,
  0x00, 0x1C, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x38, 0x1E,
  0x00, 0x38, 0x0F, 0x00, 0x78, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x70, 0x07,
  0x80, 0x70, 0x03, 0xC0, 0xF0, 0x03, 0xC0, 0xF0, 0x03, 0xC0, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x7F, 0xFF, 0x3F, 0xFF, 0xBF, 0xFF, 0xC0, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x1E, 0x01, 0xF0, 0x1E, 0x01, 0xF0, 0x3E, 0x01, 0xF0, 0x3E, 0x03,
  0xF0, 0x7E, 0x03, 0xF0, 0x6E, 0x03, 0x30, 0xEE, 0x07, 0x31, 0xCC, 0x07,
  0x31, 0xDC, 0x07, 0x33, 0x9C, 0x0E, 0x3B, 0x9C, 0x0E, 0x3F, 0x1C, 0x0E,
  0x3E, 0x3C, 0x1E, 0x3E, 0x38, 0x1C, 0x3C, 0x38, 0x1C, 0x3C, 0x38, 0x3C,
  0x00, 0x38, 0x3C, 0x00, 0x78, 0x38, 0x00, 0x70, 0x38, 0x00, 0x70, 0x78,
  0x00, 0x70, 0x70, 0x00, 0xF0, 0x70, 0x00, 0xF0, 0xF0, 0x00, 0xE0, 0xF0,
  0x00, 0xE0, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x0E, 0x07, 0x80, 0x1C, 0x0F,
  0x80, 0x38, 0x3F, 0x00, 0xF0, 0x7E, 0x01, 0xC0, 0xFE, 0x03, 0x81, 0xDC,
  0x07, 0x07, 0xB8, 0x1E, 0x0F, 0x70, 0x38, 0x1C, 0x70, 0x70, 0x38, 0xE0,
  0xE0, 0x71, 0xC3, 0xC1, 0xE3, 0x87, 0x03, 0x83, 0x8E, 0x07, 0x07, 0x1C,
  0x0E, 0x0E, 0x78, 0x3C, 0x1C, 0xE0, 0x70, 0x19, 0xC0, 0xE0, 0x3B, 0x81,
  0xC0, 0x7F, 0x07, 0x80, 0xFE, 0x0E, 0x01, 0xF8, 0x1C, 0x01, 0xF0, 0x38,
  0x03, 0xE0, 0xF0, 0x07, 0xC1, 0xC0, 0x0F, 0x03, 0x80, 0x1E, 0x00, 0x00,
  0x3F, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x7C, 0x3E, 0x0F, 0x01, 0xE1,
  0xE0, 0x0F, 0x1E, 0x00, 0xF3, 0xC0, 0x0F, 0x38, 0x00, 0xF7, 0x80, 0x0F,
  0x78, 0x00, 0xF7, 0x00, 0x0F, 0xF0, 0x00, 0xEF, 0x00, 0x0E, 0xF0, 0x01,
  0xEE, 0x00, 0x1E, 0xE0, 0x01, 0xCE, 0x00, 0x3C, 0xE0, 0x03, 0xCE, 0x00,
  0x78, 0xE0, 0x07, 0x8F, 0x00, 0xF0, 0xF0, 0x1E, 0x0F, 0x87, 0xC0, 0x7F,
  0xF8, 0x03, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFF,
  0x80, 0x3F, 0xFF, 0x00, 0xF0, 0x3E, 0x03, 0x80, 0x7C, 0x0E, 0x00, 0xF0,
  0x78, 0x03, 0xC1, 0xE0, 0x0F, 0x07, 0x00, 0x3C, 0x1C, 0x00, 0xE0, 0xF0,
  0x07, 0x83, 0xC0, 0x1E, 0x0F, 0x00, 0xF0, 0x38, 0x0F, 0x81, 0xFF, 0xFC,
  0x07, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x7C, 0x3E, 0x0F, 0x01, 0xE1, 0xE0,
  0x0F, 0x1E, 0x00, 0xF3, 0xC0, 0x0F, 0x38, 0x00, 0xF7, 0x80, 0x0F, 0x78,
  0x00, 0xF7, 0x00, 0x0F, 0xF0, 0x00, 0xEF, 0x00, 0x0E, 0xF0, 0x01, 0xEE,
  0x00, 0x1E, 0xE0, 0x01, 0xCE, 0x00, 0x3C, 0xE0, 0x03, 0xCE, 0x00, 0x78,
  0xE0, 0x07, 0x8F, 0x00, 0xF0, 0xF0, 0x1E, 0x0F, 0x87, 0xC0, 0x7F, 0xF8,
  0x03, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xF8, 0x00, 0x03, 0x80, 0x01,
  0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x07, 0x03, 0xF0, 0x78, 0x07,
  0x83, 0xC0, 0x3C, 0x1E, 0x00, 0xE0, 0xE0, 0x07, 0x0F, 0x00, 0x38, 0x78,
  0x03, 0xC3, 0xC0, 0x1E, 0x1C, 0x01, 0xE1, 0xE0, 0x1F, 0x0F, 0x03, 0xF0,
  0x7F, 0xFF, 0x03, 0xFF, 0xE0, 0x1D, 0xFC, 0x01, 0xE0, 0xF0, 0x0F, 0x07,
  0x80, 0x70, 0x1E, 0x03, 0x80, 0xF0, 0x3C, 0x03, 0x81, 0xE0, 0x1E, 0x0E,
  0x00, 0xF0, 0x70, 0x03, 0x87, 0x80, 0x1C, 0x3C, 0x00, 0xF0, 0x00, 0x1F,
  0xE0, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x7C, 0x06, 0x03, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x02, 0x00,
  0x7C, 0x1E, 0x03, 0xE0, 0x7F, 0xFF, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x38, 0x70, 0x03, 0xC7,
  0x80, 0x1E, 0x3C, 0x00, 0xE1, 0xE0, 0x07, 0x0E, 0x00, 0x78, 0xF0, 0x03,
  0xC7, 0x80, 0x1C, 0x3C, 0x00, 0xE1, 0xC0, 0x0F, 0x1E, 0x00, 0x78, 0xF0,
  0x03, 0x87, 0x80, 0x1C, 0x38, 0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0x70,
  0xF0, 0x03, 0x87, 0x00, 0x3C, 0x38, 0x01, 0xE1, 0xC0, 0x0E, 0x0E, 0x00,
  0xF0, 0x70, 0x07, 0x83, 0xC0, 0x78, 0x1F, 0x07, 0xC0, 0x7F, 0xFC, 0x01,
  0xFF, 0x80, 0x03, 0xF0, 0x00, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xBC, 0x00,
  0x3D, 0xE0, 0x03, 0xCF, 0x00, 0x1E, 0x78, 0x01, 0xE3, 0xC0, 0x0F, 0x1E,
  0x00, 0xF0, 0xF0, 0x07, 0x87, 0x80, 0x78, 0x3C, 0x03, 0xC1, 0xE0, 0x3C,
  0x07, 0x01, 0xC0, 0x38, 0x1E, 0x01, 0xC0, 0xE0, 0x0E, 0x0F, 0x00, 0x70,
  0x70, 0x03, 0x87, 0x80, 0x1C, 0x38, 0x00, 0xE3, 0xC0, 0x07, 0x9C, 0x00,
  0x3D, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x38, 0x00,
  0x78, 0xF0, 0x00, 0xE1, 0xE0, 0x01, 0xC3, 0x80, 0x07, 0x87, 0x00, 0x0F,
  0x0E, 0x00, 0x1C, 0x3C, 0x00, 0x38, 0x78, 0x00, 0xF0, 0xE1, 0xE1, 0xC1,
  0xC3, 0xC3, 0x83, 0x8F, 0x87, 0x07, 0x1F, 0x1C, 0x1C, 0x76, 0x38, 0x38,
  0xCC, 0x70, 0x73, 0x99, 0xC0, 0xEE, 0x33, 0x81, 0xDC, 0x67, 0x03, 0x70,
  0xCC, 0x0E, 0xE1, 0xF8, 0x1F, 0x83, 0xF0, 0x3E, 0x07, 0xC0, 0x7C, 0x0F,
  0x80, 0xF0, 0x1F, 0x01, 0xE0, 0x3C, 0x03, 0x80, 0x78, 0x00, 0x00, 0xF0,
  0x03, 0xC0, 0x1E, 0x00, 0xF8, 0x01, 0xE0, 0x1E, 0x00, 0x3C, 0x07, 0x80,
  0x07, 0x81, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xE3,
  0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x1E, 0x78, 0x00, 0x07,
  0xC7, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x01, 0xC0,
  0x03, 0xC0, 0x3C, 0x00, 0xF8, 0x07, 0x80, 0x3E, 0x00, 0x70, 0x07, 0x80,
  0x0E, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x7B, 0x80, 0x07, 0x9C,
  0x00, 0x3C, 0xF0, 0x03, 0xC7, 0x80, 0x3C, 0x3C, 0x01, 0xE0, 0xE0, 0x1E,
  0x07, 0x01, 0xE0, 0x3C, 0x0F, 0x00, 0xE0, 0xF0, 0x07, 0x0F, 0x00, 0x3C,
  0xF0, 0x01, 0xE7, 0x00, 0x07, 0x78, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0xE3, 0x8E,
  0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x1C, 0x71, 0xC7, 0x1E, 0x79, 0xE7,
  0x9E, 0x79, 0xE7, 0x9E, 0x38, 0xE3, 0x8E, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3,
  0xCF, 0x3C, 0x70, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x00,
  0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x0F,
  0xFE, 0x00, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x01,
  0xFE, 0x00, 0xF3, 0x80, 0x78, 0xE0, 0x3C, 0x3C, 0x0F, 0x07, 0x07, 0x81,
  0xC3, 0xC0, 0x79, 0xE0, 0x0E, 0xF0, 0x03, 0xBC, 0x00, 0xF2, 0x00, 0x10,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x10, 0x70, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x02, 0x00, 0x3F, 0xC0, 0x0F, 0xFE, 0x03, 0xFF, 0xE0,
  0x7E, 0x1E, 0x0F, 0x81, 0xE1, 0xE0, 0x1E, 0x3C, 0x01, 0xC3, 0xC0, 0x1C,
  0x78, 0x03, 0xC7, 0x80, 0x3C, 0x70, 0x03, 0x8F, 0x00, 0x38, 0xF0, 0x07,
  0x8F, 0x00, 0x78, 0xF0, 0x07, 0x0F, 0x00, 0x70, 0xF0, 0x07, 0x07, 0x80,
  0xF0, 0x7C, 0x3F, 0x07, 0xFF, 0xF0, 0x3F, 0xF7, 0x00, 0xFC, 0x78, 0x01,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE7, 0xC0, 0x3F,
  0xFE, 0x07, 0xFF, 0xE0, 0xF8, 0x3C, 0x1C, 0x03, 0xC7, 0x80, 0x78, 0xF0,
  0x07, 0x1C, 0x00, 0xE3, 0x80, 0x1C, 0xF0, 0x07, 0x9E, 0x00, 0xF3, 0x80,
  0x1E, 0x70, 0x03, 0x8E, 0x00, 0xF3, 0xC0, 0x1E, 0x78, 0x07, 0x8E, 0x01,
  0xF1, 0xC0, 0x7C, 0x78, 0x3F, 0x0F, 0xFF, 0xC1, 0xFF, 0xE0, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x3F, 0xFC, 0x0F, 0xFF, 0x87, 0xE0, 0x21, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF8, 0x0C, 0x1F, 0xFF,
  0x81, 0xFF, 0xF0, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0xFF, 0x80, 0x1F, 0xFE,
  0x01, 0xFF, 0xF8, 0x0F, 0xC1, 0xC0, 0x7C, 0x07, 0x03, 0xE0, 0x3C, 0x0F,
  0x00, 0xF0, 0x78, 0x03, 0x81, 0xC0, 0x0E, 0x0F, 0x00, 0x78, 0x3C, 0x01,
  0xE0, 0xE0, 0x07, 0x03, 0x80, 0x1C, 0x0E, 0x00, 0x70, 0x38, 0x03, 0xC0,
  0xE0, 0x0F, 0x03, 0x80, 0x38, 0x0F, 0x01, 0xE0, 0x3E, 0x1F, 0xC0, 0x7F,
  0xFF, 0x00, 0xFF, 0xBC, 0x01, 0xF8, 0x70, 0x00, 0x00, 0x7F, 0x00, 0x3F,
  0xF0, 0x1F, 0xFF, 0x07, 0xE1, 0xF1, 0xF0, 0x1E, 0x3C, 0x01, 0xCF, 0x00,
  0x7B, 0xE0, 0x0F, 0x78, 0x01, 0xEF, 0x00, 0xFB, 0xC0, 0xFE, 0x7F, 0xFF,
  0x8F, 0xFF, 0xC1, 0xFF, 0x80, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x01, 0xF8, 0x0C, 0x1F, 0xFF, 0x81, 0xFF, 0xF0, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0x82, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x7E,
  0x0F, 0x03, 0xE0, 0x38, 0x1F, 0x00, 0xE0, 0x78, 0x07, 0x83, 0xC0, 0x1E,
  0x0F, 0x00, 0x70, 0x78, 0x01, 0xC1, 0xE0, 0x0F, 0x07, 0x80, 0x3C, 0x1C,
  0x00, 0xE0, 0x70, 0x03, 0x81, 0xC0, 0x1E, 0x07, 0x80, 0x78, 0x1F, 0x07,
  0xC0, 0x3F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0xFC, 0xF0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x70, 0x3E, 0x03, 0xFF,
  0xF8, 0x0F, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xEF, 0xC0, 0x1F, 0xFE, 0x07, 0xFF, 0xE0,
  0xF0, 0x3C, 0x1E, 0x03, 0xC3, 0x80, 0x78, 0xF0, 0x0F, 0x1E, 0x01, 0xE3,
  0xC0, 0x3C, 0x70, 0x07, 0x0E, 0x00, 0xE3, 0xC0, 0x3C, 0x78, 0x07, 0x8E,
  0x00, 0xF1, 0xC0, 0x1C, 0x78, 0x07, 0x8F, 0x00, 0xF1, 0xC0, 0x1E, 0x38,
  0x03, 0x8F, 0x00, 0x71, 0xE0, 0x1E, 0x00, 0x01, 0xE0, 0x1F, 0x00, 0xFC,
  0x07, 0xE0, 0x3E, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x3F,
  0xF1, 0xFF, 0x80, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0x78, 0x03, 0xFE, 0x0F, 0xF0, 0x3F, 0x80, 0x00, 0x00, 0x70, 0x00, 0x07,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x3F, 0xFC,
  0x01, 0xFF, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x60, 0x78, 0x07, 0xFF, 0xC0,
  0x3F, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x3C, 0x1E,
  0x03, 0xE0, 0xF0, 0x7C, 0x07, 0x07, 0xC0, 0x38, 0x7C, 0x03, 0xCF, 0xC0,
  0x1E, 0xFC, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFE,
  0x00, 0x1E, 0xF8, 0x00, 0xE3, 0xE0, 0x0F, 0x0F, 0x00, 0x78, 0x3C, 0x03,
  0xC0, 0xF0, 0x1C, 0x07, 0x81, 0xE0, 0x1E, 0x0F, 0x00, 0xF0, 0x78, 0x03,
  0xC0, 0xFF, 0xDF, 0xFB, 0xFF, 0x01, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x38,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x1C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x0E,
  0x01, 0xC0, 0x3C, 0x17, 0xFE, 0x7F, 0xC7, 0xF0, 0x01, 0xF8, 0xF0, 0x1F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xC1, 0xC7, 0x8F, 0x0F, 0x1E, 0x1C, 0x38, 0x78,
  0xF0, 0xE1, 0xC3, 0xC3, 0x87, 0x0E, 0x1E, 0x1C, 0x38, 0x70, 0xF0, 0xE1,
  0xC3, 0x87, 0x87, 0x0E, 0x1C, 0x3C, 0x38, 0x70, 0xE0, 0x01, 0xC3, 0x80,
  0x0F, 0x0E, 0x00, 0x38, 0x78, 0x00, 0xE1, 0xC0, 0x03, 0x87, 0x00, 0x1E,
  0x1C, 0x00, 0x78, 0xF0, 0x01, 0xC0, 0x01, 0xFE, 0x01, 0xFF, 0xF0, 0x3F,
  0xFF, 0x07, 0x81, 0xE0, 0xE0, 0x1E, 0x3C, 0x03, 0xC7, 0x80, 0x78, 0xF0,
  0x0F, 0x1C, 0x01, 0xE7, 0x80, 0x38, 0xF0, 0x0F, 0x1E, 0x01, 0xE3, 0x80,
  0x3C, 0x70, 0x07, 0x1E, 0x00, 0xE3, 0xC0, 0x3C, 0x70, 0x07, 0x8E, 0x00,
  0xE3, 0xC0, 0x1C, 0x78, 0x07, 0x8F, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0xFF,
  0xC0, 0xFF, 0xF8, 0x7C, 0x1E, 0x1E, 0x03, 0xCF, 0x00, 0xF7, 0x80, 0x3D,
  0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x01, 0xEE, 0x00, 0x7B, 0x80, 0x3C, 0xE0, 0x0F, 0x3C, 0x07,
  0x8F, 0x87, 0xC1, 0xFF, 0xE0, 0x3F, 0xF0, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x07, 0x03, 0xE0, 0x78, 0x07, 0x83,
  0xC0, 0x3C, 0x1E, 0x01, 0xE0, 0xE0, 0x07, 0x0F, 0x00, 0x38, 0x78, 0x03,
  0xC3, 0xC0, 0x1E, 0x1E, 0x00, 0xF0, 0xE0, 0x07, 0x8F, 0x00, 0x78, 0x78,
  0x03, 0xC3, 0xC0, 0x3C, 0x1C, 0x03, 0xE1, 0xE0, 0x3E, 0x0F, 0x07, 0xE0,
  0x7F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xF0, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x3F, 0xFC, 0x1F, 0xFF, 0x87, 0xE0, 0xF1, 0xF0, 0x1C,
  0x7C, 0x07, 0x8F, 0x00, 0xF3, 0xC0, 0x1E, 0x70, 0x03, 0x9E, 0x00, 0xF3,
  0xC0, 0x1E, 0x70, 0x03, 0xCE, 0x00, 0x71, 0xC0, 0x1E, 0x38, 0x03, 0xC7,
  0x00, 0x78, 0xE0, 0x0E, 0x1E, 0x03, 0xC3, 0xE0, 0xF8, 0x3F, 0xFF, 0x03,
  0xFF, 0xC0, 0x3F, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0x7F, 0xE0, 0xFF, 0xFC,
  0x3F, 0xFF, 0x07, 0xC0, 0x20, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xE0, 0x60, 0x70, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x04, 0x01, 0xE1, 0xE0, 0x7C, 0x3F, 0xFF, 0x07, 0xFF, 0xC0, 0x1F,
  0xC0, 0x00, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78,
  0x00, 0x3C, 0x01, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF, 0xFF, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xF0, 0x00, 0x78, 0x10, 0x3F, 0xF8, 0x0F, 0xFC, 0x01, 0xF8, 0x00,
  0x1C, 0x01, 0xE7, 0x80, 0x38, 0xF0, 0x0F, 0x1E, 0x01, 0xE3, 0x80, 0x3C,
  0xF0, 0x07, 0x1E, 0x01, 0xE3, 0xC0, 0x3C, 0x70, 0x07, 0x8E, 0x00, 0xE3,
  0xC0, 0x1C, 0x78, 0x07, 0x8E, 0x00, 0xF1, 0xC0, 0x1E, 0x38, 0x03, 0x87,
  0x00, 0x70, 0xF0, 0x1E, 0x1F, 0x0F, 0xC1, 0xFF, 0xF8, 0x3F, 0xF7, 0x01,
  0xF8, 0xF0, 0xF0, 0x03, 0xBC, 0x01, 0xEF, 0x00, 0x7B, 0xC0, 0x3C, 0xF0,
  0x0F, 0x3C, 0x03, 0x8F, 0x01, 0xE3, 0xC0, 0x70, 0xF0, 0x3C, 0x1C, 0x1E,
  0x07, 0x07, 0x81, 0xC3, 0xC0, 0x78, 0xE0, 0x1E, 0x78, 0x07, 0xBC, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x70,
  0x00, 0x3B, 0x80, 0x01, 0xDC, 0x00, 0x1E, 0xE0, 0x00, 0xE7, 0x00, 0x07,
  0x78, 0x30, 0x73, 0xC3, 0xC3, 0x9C, 0x1E, 0x3C, 0xE1, 0xF1, 0xC7, 0x1F,
  0x8E, 0x38, 0xFC, 0xF1, 0xCE, 0xE7, 0x0E, 0x67, 0x38, 0x77, 0x3B, 0x83,
  0xF0, 0xDC, 0x1F, 0x87, 0xC0, 0xF8, 0x3E, 0x07, 0x81, 0xF0, 0x3C, 0x0F,
  0x01, 0xC0, 0x78, 0x00, 0x07, 0x80, 0x3C, 0x07, 0x80, 0xF0, 0x0F, 0x01,
  0xC0, 0x0F, 0x07, 0x80, 0x1E, 0x1E, 0x00, 0x1E, 0x78, 0x00, 0x3D, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x79, 0xE0, 0x01, 0xE1, 0xE0, 0x07,
  0x83, 0xC0, 0x1E, 0x03, 0x80, 0x78, 0x07, 0x81, 0xF0, 0x0F, 0x07, 0xC0,
  0x0F, 0x00, 0x01, 0xE0, 0x07, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x03, 0xC0,
  0x3C, 0x01, 0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x03, 0x80, 0x70,
  0x01, 0xE0, 0x78, 0x00, 0xF0, 0x38, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x1C,
  0x00, 0x0E, 0x1E, 0x00, 0x07, 0x0E, 0x00, 0x03, 0xCF, 0x00, 0x01, 0xE7,
  0x00, 0x00, 0x77, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x83, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0xFF, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8,
  0x7F, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00,
  0x7C, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x70, 0x07, 0x00, 0xF0,
  0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x03, 0xC0,
  0x3C, 0x03, 0x80, 0x38, 0x07, 0x80, 0x78, 0x07, 0x00, 0x70, 0x0F, 0x00,
  0xF0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x3C, 0x03,
  0xC0, 0x38, 0x03, 0x80, 0x38, 0x07, 0x80, 0x70, 0x07, 0x00, 0x70, 0x0F,
  0x00, 0xF0, 0x0E, 0x00, 0x00, 0x7F, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80,
  0x07, 0xC0, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0x80, 0x61, 0xFE,
  0x0E, 0x3F, 0xF1, 0xE7, 0x8F, 0xFC, 0x70, 0x3F, 0x86, 0x01, 0xF0,
};

const GFXglyph UbuntuMono_Italic44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 22, 0, -1 },
  { 1, 10, 27, 22, 8, -27 },
  { 35, 12, 11, 22, 10, -30 },
  { 52, 23, 27, 22, 2, -27 },
  { 130, 21, 34, 22, 3, -30 },
  { 220, 27, 27, 22, 0, -27 },
  { 312, 19, 27, 22, 3, -27 },
  { 377, 6, 12, 22, 13, -30 },
  { 386, 17, 38, 22, 6, -31 },
  { 467, 17, 38, 22, 2, -31 },
  { 548, 17, 16, 22, 6, -27 },
  { 582, 18, 19, 22, 4, -21 },
  { 625, 9, 12, 22, 5, -6 },
  { 639, 10, 3, 22, 8, -12 },
  { 643, 6, 6, 22, 8, -6 },
  { 648, 25, 38, 22, -1, -31 },
  { 767, 19, 27, 22, 4, -27 },
  { 832, 16, 27, 22, 4, -27 },
  { 886, 20, 27, 22, 3, -27 },
  { 954, 20, 27, 22, 3, -27 },
  { 1022, 20, 27, 22, 2, -27 },
  { 1090, 22, 27, 22, 2, -27 },
  { 1165, 20, 27, 22, 4, -27 },
  { 1233, 20, 27, 22, 6, -27 },
  { 1301, 21, 27, 22, 3, -27 },
  { 1372, 21, 27, 22, 3, -27 },
  { 1443, 10, 20, 22, 8, -20 },
  { 1468, 13, 26, 22, 5, -20 },
  { 1511, 20, 17, 22, 3, -20 },
  { 1554, 20, 11, 22, 3, -17 },
  { 1582, 19, 17, 22, 3, -20 },
  { 1623, 16, 27, 22, 7, -27 },
  { 1677, 22, 33, 22, 3, -27 },
  { 1768, 22, 27, 22, -1, -27 },
  { 1843, 21, 27, 22, 2, -27 },
  { 1914, 21, 27, 22, 4, -27 },
  { 1985, 21, 27, 22, 2, -27 },
  { 2056, 22, 27, 22, 3, -27 },
  { 2131, 22, 27, 22, 3, -27 },
  { 2206, 21, 27, 22, 4, -27 },
  { 2277, 23, 27, 22, 2, -27 },
  { 2355, 21, 27, 22, 3, -27 },
  { 2426, 21, 27, 22, 3, -27 },
  { 2497, 24, 27, 22, 2, -27 },
  { 2578, 17, 27, 22, 2, -27 },
  { 2636, 24, 27, 22, 1, -27 },
  { 2717, 23, 27, 22, 2, -27 },
  { 2795, 20, 27, 22, 4, -27 },
  { 2863, 22, 27, 22, 2, -27 },
  { 2938, 20, 34, 22, 4, -27 },
  { 3023, 21, 27, 22, 2, -27 },
  { 3094, 22, 27, 22, 2, -27 },
  { 3169, 19, 27, 22, 7, -27 },
  { 3234, 21, 27, 22, 4, -27 },
  { 3305, 21, 27, 22, 6, -27 },
  { 3376, 23, 27, 22, 3, -27 },
  { 3454, 27, 27, 22, 0, -27 },
  { 3546, 21, 27, 22, 6, -27 },
  { 3617, 23, 27, 22, 2, -27 },
  { 3695, 20, 38, 22, 4, -31 },
  { 3790, 6, 38, 22, 10, -31 },
  { 3819, 20, 38, 22, 1, -31 },
  { 3914, 18, 15, 22, 5, -27 },
  { 3948, 20, 3, 22, -1, 4 },
  { 3956, 8, 8, 22, 11, -30 },
  { 3964, 20, 22, 22, 3, -21 },
  { 4019, 19, 31, 22, 3, -30 },
  { 4093, 19, 22, 22, 3, -21 },
  { 4146, 22, 31, 22, 4, -30 },
  { 4232, 19, 22, 22, 3, -21 },
  { 4285, 26, 37, 22, 0, -30 },
  { 4406, 22, 28, 22, 1, -21 },
  { 4483, 19, 30, 22, 2, -30 },
  { 4555, 13, 29, 22, 6, -29 },
  { 4603, 21, 36, 22, 1, -29 },
  { 4698, 21, 30, 22, 3, -30 },
  { 4777, 11, 31, 22, 8, -30 },
  { 4820, 22, 21, 22, 1, -21 },
  { 4878, 19, 21, 22, 3, -21 },
  { 4928, 18, 22, 22, 4, -21 },
  { 4978, 21, 28, 22, 1, -21 },
  { 5052, 19, 28, 22, 4, -21 },
  { 5119, 19, 21, 22, 4, -21 },
  { 5169, 19, 22, 22, 3, -21 },
  { 5222, 17, 27, 22, 6, -26 },
  { 5280, 19, 21, 22, 4, -20 },
  { 5330, 18, 20, 22, 6, -20 },
  { 5375, 21, 20, 22, 4, -20 },
  { 5428, 23, 20, 22, 1, -20 },
  { 5486, 25, 27, 22, -1, -20 },
  { 5571, 19, 20, 22, 3, -20 },
  { 5619, 21, 38, 22, 4, -31 },
  { 5719, 12, 38, 22, 7, -31 },
  { 5776, 21, 38, 22, 0, -31 },
  { 5876, 20, 6, 22, 3, -14 },
};

const GFXfont UbuntuMono_Italic44pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Italic44pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Italic44pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _UBUNTUMONO_ITALIC44PT7B_H_
