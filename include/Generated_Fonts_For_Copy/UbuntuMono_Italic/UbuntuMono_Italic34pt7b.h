#ifndef _UBUNTUMONO_ITALIC34PT7B_H_
#define _UBUNTUMONO_ITALIC34PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Italic.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Italic34pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x07, 0x0E, 0x0E, 0x0E, 0x0E, 0x1C, 0x1C, 0x1C, 0x18, 0x18,
  0x38, 0x30, 0x00, 0x00, 0x00, 0x70, 0xF0, 0xF0, 0xF0, 0x60, 0x63, 0xB1,
  0xF8, 0xFC, 0x6C, 0x36, 0x3B, 0x19, 0x0C, 0x00, 0x70, 0xC0, 0x18, 0x70,
  0x0E, 0x18, 0x03, 0x8E, 0x00, 0xC3, 0x80, 0x70, 0xC1, 0xFF, 0xFC, 0x7F,
  0xFF, 0x3F, 0xFF, 0xC0, 0xC3, 0x80, 0x71, 0xC0, 0x18, 0x60, 0x0E, 0x38,
  0x1F, 0xFF, 0xC7, 0xFF, 0xF1, 0xFF, 0xFC, 0x38, 0x60, 0x0E, 0x38, 0x03,
  0x0C, 0x01, 0xC7, 0x00, 0x61, 0x80, 0x00, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x30, 0x00, 0xFC, 0x03, 0xFF, 0x07, 0xFF, 0x0F, 0x02, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x60, 0x78, 0x7F,
  0xF8, 0xFF, 0xF0, 0x1F, 0xC0, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E,
  0x00, 0x03, 0xC0, 0x30, 0x3F, 0x03, 0x03, 0xF8, 0x30, 0x1C, 0xC3, 0x80,
  0xC6, 0x38, 0x0E, 0x33, 0x80, 0x63, 0x98, 0x03, 0x99, 0x80, 0x1F, 0xD8,
  0x00, 0x7D, 0x80, 0x01, 0xDD, 0xC0, 0x01, 0xFF, 0x00, 0x1D, 0xF8, 0x00,
  0xDC, 0xC0, 0x0C, 0xC6, 0x00, 0xC6, 0x30, 0x0C, 0x31, 0x80, 0xE1, 0x9C,
  0x0E, 0x0F, 0xC0, 0xE0, 0x7E, 0x06, 0x01, 0xC0, 0x00, 0x01, 0xF0, 0x07,
  0xF0, 0x1F, 0xF0, 0x78, 0xE0, 0xE1, 0xC1, 0x83, 0x03, 0x8C, 0x07, 0x70,
  0x07, 0xC0, 0x1E, 0x1C, 0x7E, 0x31, 0xCC, 0xE7, 0x1D, 0xDC, 0x1F, 0x38,
  0x3E, 0x70, 0x38, 0xE0, 0xF1, 0xE3, 0xF3, 0xFE, 0xE3, 0xF9, 0xC3, 0xE1,
  0x80, 0x3B, 0x9C, 0xE6, 0x33, 0x98, 0xC0, 0x00, 0x10, 0x03, 0x80, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x01, 0xC0, 0x1C, 0x01, 0xE0, 0x0E,
  0x00, 0x60, 0x07, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x04, 0x00, 0x00, 0x80, 0x0C, 0x00,
  0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xF0, 0x0F, 0x01, 0xE0, 0x0E, 0x00, 0x20, 0x00, 0x07, 0x00, 0x38,
  0x01, 0xC1, 0x8C, 0x2F, 0x67, 0x7F, 0xFD, 0xFF, 0x80, 0xE0, 0x0F, 0x80,
  0xEE, 0x0E, 0x78, 0x71, 0xC1, 0x08, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x60, 0x03, 0x80, 0x0E, 0x0F, 0xFF, 0xFF, 0xFF, 0x07, 0x00, 0x1C,
  0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x1C, 0x7C, 0xF9, 0xF1,
  0xE1, 0x87, 0x3C, 0xF1, 0x80, 0x7F, 0xFF, 0xFF, 0x77, 0xFF, 0xF7, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xF0, 0x0F, 0xF8, 0x3F, 0xF0, 0xF8, 0xF1, 0xC0,
  0xE7, 0x81, 0xCE, 0x03, 0xB8, 0x07, 0x73, 0x8E, 0xEF, 0x1B, 0x9E, 0x77,
  0x1C, 0xEE, 0x01, 0xDC, 0x07, 0x38, 0x0E, 0x70, 0x38, 0xE0, 0xF1, 0xE3,
  0xC3, 0xFF, 0x03, 0xFC, 0x03, 0xF0, 0x00, 0x00, 0x30, 0x03, 0x80, 0x7C,
  0x0F, 0xE1, 0xF6, 0x0F, 0x70, 0x23, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x38,
  0x1F, 0xFD, 0xFF, 0xEF, 0xFF, 0x00, 0x00, 0xF8, 0x03, 0xFE, 0x0F, 0xFE,
  0x07, 0x0F, 0x04, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x7F, 0xF8, 0x7F, 0xF8, 0xFF, 0xF8,
  0x01, 0xF8, 0x0F, 0xF8, 0x1F, 0xF8, 0x30, 0x70, 0x00, 0x60, 0x00, 0xC0,
  0x03, 0x80, 0x1E, 0x03, 0xF8, 0x07, 0xC0, 0x0F, 0xE0, 0x03, 0xC0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x80, 0xF3, 0xFF, 0xC7,
  0xFF, 0x03, 0xF8, 0x00, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0xF8, 0x07, 0xF0,
  0x1E, 0xC0, 0x7B, 0x81, 0xE7, 0x03, 0x8E, 0x0E, 0x18, 0x38, 0x70, 0xE0,
  0xE3, 0x81, 0xC6, 0x03, 0x1F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFE, 0x00, 0x60,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x01, 0xFF, 0x80, 0xFF,
  0x80, 0xFF, 0xC0, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C,
  0x00, 0x0F, 0x80, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x20, 0x7C, 0x3F, 0xFC,
  0x1F, 0xFC, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x7F, 0x01, 0xFE, 0x07,
  0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x3B, 0xE0, 0x7F,
  0xF8, 0x7F, 0xF8, 0x70, 0x3C, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0,
  0x38, 0xE0, 0x38, 0x70, 0xF8, 0x7F, 0xF0, 0x3F, 0xE0, 0x1F, 0x80, 0x3F,
  0xFE, 0x7F, 0xFD, 0xFF, 0xF8, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x03,
  0x80, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xF8, 0x0F, 0xF8, 0x3F, 0xF8, 0xF0, 0x71, 0xC0,
  0xE3, 0x81, 0xC6, 0x03, 0x8E, 0x0E, 0x1E, 0x38, 0x1F, 0xE0, 0x3F, 0x80,
  0xFF, 0x87, 0x87, 0x8C, 0x07, 0x38, 0x0E, 0x60, 0x1C, 0xE0, 0x39, 0xC1,
  0xF3, 0xFF, 0xC3, 0xFF, 0x03, 0xF8, 0x00, 0x01, 0xF0, 0x0F, 0xF8, 0x3F,
  0xF0, 0xF0, 0xF3, 0xC0, 0xE7, 0x01, 0xCE, 0x03, 0x98, 0x07, 0x38, 0x0E,
  0x70, 0x3C, 0xFF, 0xF8, 0xFF, 0xE0, 0xFD, 0xC0, 0x07, 0x00, 0x0E, 0x00,
  0x78, 0x01, 0xE0, 0x0F, 0x83, 0xFE, 0x07, 0xF0, 0x0F, 0x00, 0x00, 0x0E,
  0x1E, 0x1F, 0x1E, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0xF8,
  0xF8, 0xF8, 0x70, 0x03, 0x81, 0xE0, 0x7C, 0x1E, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x3E, 0x0F, 0x83, 0xE0, 0x78, 0x0C,
  0x07, 0x07, 0x83, 0xC0, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x7C, 0x03, 0xF8,
  0x3F, 0xC3, 0xFC, 0x1F, 0x80, 0x38, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0x00, 0x3F, 0xFF, 0x3F, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0xFF, 0xFC, 0x18,
  0x00, 0x3C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03,
  0x80, 0x7F, 0x07, 0xF8, 0x7F, 0x83, 0xF8, 0x07, 0x80, 0x0C, 0x00, 0x00,
  0x0F, 0x83, 0xFE, 0x3F, 0xE2, 0x0F, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x1C,
  0x03, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0xFF,
  0x80, 0xFF, 0xC0, 0xF0, 0xF0, 0xF0, 0x38, 0xF0, 0x1C, 0x70, 0x0E, 0x70,
  0x07, 0x38, 0x3F, 0xB8, 0x7F, 0xDC, 0x7F, 0xCE, 0x78, 0x66, 0x38, 0x73,
  0x18, 0x33, 0x9C, 0x39, 0xCE, 0x1C, 0xE3, 0x8E, 0x71, 0xFE, 0x38, 0x7F,
  0x0C, 0x1F, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1F,
  0xE0, 0x03, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E,
  0x00, 0xEE, 0x00, 0xCE, 0x01, 0xC6, 0x01, 0x86, 0x03, 0x86, 0x03, 0x06,
  0x07, 0x06, 0x0E, 0x07, 0x0C, 0x07, 0x1F, 0xFF, 0x1F, 0xFF, 0x3F, 0xFF,
  0x38, 0x07, 0x70, 0x07, 0x70, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0x0F, 0xF8,
  0x0F, 0xFE, 0x0F, 0xFE, 0x0E, 0x0F, 0x1C, 0x07, 0x1C, 0x07, 0x1C, 0x06,
  0x1C, 0x0E, 0x38, 0x1C, 0x3F, 0xF8, 0x3F, 0xF0, 0x3F, 0xF8, 0x70, 0x1C,
  0x70, 0x0E, 0x70, 0x0E, 0x60, 0x1C, 0x60, 0x1C, 0xE0, 0x7C, 0xFF, 0xF8,
  0xFF, 0xF0, 0xFF, 0x80, 0x00, 0xFE, 0x01, 0xFF, 0x81, 0xFF, 0xC1, 0xE0,
  0x41, 0xE0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x18, 0x1F, 0xFC, 0x07, 0xFE, 0x00, 0xFC,
  0x00, 0x07, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x81, 0xC1, 0xE0, 0xE0, 0x70,
  0x70, 0x1C, 0x30, 0x0E, 0x38, 0x07, 0x1C, 0x03, 0x8E, 0x01, 0xC6, 0x00,
  0xE7, 0x00, 0xE3, 0x80, 0x71, 0xC0, 0x38, 0xC0, 0x38, 0xE0, 0x3C, 0x70,
  0x3C, 0x38, 0x7C, 0x1F, 0xFC, 0x1F, 0xFC, 0x0F, 0xF0, 0x00, 0x07, 0xFF,
  0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x83,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x83, 0xFF, 0xC1,
  0xFF, 0xE0, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x83, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xFC, 0x03, 0xFF, 0x07, 0xFE, 0x1F, 0x02,
  0x1C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x38,
  0xE0, 0x38, 0xF8, 0x70, 0x7F, 0xF0, 0x3F, 0xF0, 0x1F, 0xC0, 0x07, 0x00,
  0xE0, 0xE0, 0x38, 0x18, 0x07, 0x07, 0x00, 0xE0, 0xE0, 0x1C, 0x1C, 0x03,
  0x03, 0x80, 0xE0, 0xE0, 0x1C, 0x1C, 0x03, 0x83, 0xFF, 0xE0, 0x7F, 0xFC,
  0x1F, 0xFF, 0x83, 0x80, 0x70, 0x70, 0x0C, 0x0E, 0x03, 0x81, 0x80, 0x70,
  0x70, 0x0E, 0x0E, 0x01, 0x81, 0xC0, 0x70, 0x30, 0x0E, 0x0E, 0x01, 0xC0,
  0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00,
  0x7F, 0xF0, 0x7F, 0xF0, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0xFF,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x40, 0x70, 0x38, 0x78, 0x3F, 0xF8, 0x0F, 0xF8,
  0x01, 0xF8, 0x00, 0x0E, 0x03, 0xC3, 0x81, 0xE0, 0xE0, 0xF0, 0x38, 0x78,
  0x1C, 0x3C, 0x07, 0x1E, 0x01, 0xCF, 0x00, 0x77, 0x80, 0x1B, 0xC0, 0x0F,
  0xE0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x33, 0x80, 0x1C, 0x70, 0x07, 0x0E,
  0x01, 0xC3, 0x80, 0x60, 0x70, 0x38, 0x1C, 0x0E, 0x03, 0x83, 0x80, 0xE0,
  0xC0, 0x1C, 0x00, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x78, 0x3C, 0x1E, 0x1F, 0x07, 0x87, 0x83, 0x63,
  0x60, 0xD8, 0xD8, 0x36, 0x66, 0x1D, 0x9B, 0x86, 0x6C, 0xE1, 0x8F, 0x30,
  0xE3, 0x8C, 0x38, 0xC3, 0x0C, 0x01, 0xC7, 0x00, 0x71, 0xC0, 0x1C, 0x60,
  0x06, 0x18, 0x03, 0x8E, 0x00, 0xE3, 0x80, 0x38, 0xC0, 0x0E, 0x00, 0x07,
  0x00, 0xE0, 0xF0, 0x18, 0x1E, 0x03, 0x03, 0xC0, 0xE0, 0xFC, 0x1C, 0x1F,
  0x83, 0x03, 0x30, 0x60, 0x66, 0x1C, 0x1C, 0xE3, 0x83, 0x9C, 0x60, 0x61,
  0x8C, 0x0C, 0x33, 0x83, 0x86, 0x70, 0x70, 0xEC, 0x0C, 0x0D, 0x81, 0x81,
  0xF0, 0x70, 0x3E, 0x0E, 0x07, 0x81, 0xC0, 0xF0, 0x30, 0x0E, 0x0E, 0x01,
  0xC0, 0x01, 0xF0, 0x0F, 0xF8, 0x3F, 0xF8, 0xF8, 0xF1, 0xC0, 0xE7, 0x01,
  0xCE, 0x01, 0xB8, 0x03, 0x70, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xDC, 0x03, 0xB8, 0x07, 0x70, 0x1C, 0xE0, 0x79, 0xE1, 0xE1, 0xFF,
  0x83, 0xFE, 0x01, 0xF0, 0x00, 0x07, 0xF8, 0x07, 0xFE, 0x0F, 0xFF, 0x0E,
  0x0F, 0x0E, 0x07, 0x0E, 0x03, 0x1C, 0x03, 0x1C, 0x07, 0x1C, 0x07, 0x18,
  0x0E, 0x38, 0x3E, 0x3F, 0xFC, 0x3F, 0xF8, 0x3F, 0xC0, 0x70, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x01,
  0xF0, 0x0F, 0xF8, 0x3F, 0xF8, 0xF8, 0xF1, 0xC0, 0xE7, 0x01, 0xCE, 0x01,
  0xB8, 0x03, 0x70, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xDC,
  0x03, 0xB8, 0x07, 0x70, 0x1C, 0xE0, 0x79, 0xE1, 0xE1, 0xFF, 0x83, 0xFE,
  0x01, 0xF0, 0x03, 0x80, 0x03, 0x80, 0x07, 0xC0, 0x0F, 0xE0, 0x07, 0x80,
  0x03, 0x00, 0x07, 0xF8, 0x0F, 0xFC, 0x0F, 0xFE, 0x0E, 0x0F, 0x1C, 0x07,
  0x1C, 0x07, 0x1C, 0x07, 0x1C, 0x07, 0x18, 0x07, 0x38, 0x0E, 0x38, 0x3E,
  0x3F, 0xFC, 0x3F, 0xF0, 0x73, 0xC0, 0x70, 0xE0, 0x70, 0x60, 0x60, 0x70,
  0xE0, 0x70, 0xE0, 0x38, 0xE0, 0x38, 0xC0, 0x38, 0x00, 0xFC, 0x01, 0xFF,
  0xC1, 0xFF, 0xC1, 0xE0, 0x40, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x30, 0x3C, 0x3F, 0xFE,
  0x1F, 0xFC, 0x03, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1C,
  0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x00, 0x1C, 0x03, 0x0E,
  0x03, 0x86, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0x61, 0xC0, 0x70, 0xC0, 0x38,
  0xE0, 0x1C, 0x70, 0x0C, 0x38, 0x0E, 0x18, 0x07, 0x1C, 0x03, 0x8E, 0x01,
  0x87, 0x01, 0xC3, 0x80, 0xE1, 0xC0, 0x70, 0xE0, 0x70, 0x78, 0x78, 0x1F,
  0xF8, 0x0F, 0xF8, 0x01, 0xF0, 0x00, 0xE0, 0x07, 0xE0, 0x0E, 0xE0, 0x0E,
  0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x70, 0xE0, 0x60,
  0xE0, 0xE0, 0xE0, 0xC0, 0xE1, 0xC0, 0xE1, 0x80, 0xE3, 0x80, 0xE7, 0x00,
  0xE7, 0x00, 0x6E, 0x00, 0x6E, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x1C, 0x00, 0xC7, 0x00, 0x71, 0xC0, 0x1C, 0x60, 0x06, 0x18, 0x01, 0x8E,
  0x00, 0xE3, 0x80, 0x38, 0xE0, 0x0C, 0x31, 0xC7, 0x0C, 0x71, 0xC3, 0x3C,
  0x61, 0xCF, 0x18, 0x66, 0x4E, 0x19, 0x9B, 0x06, 0xC6, 0xC1, 0xB1, 0xB0,
  0x78, 0x78, 0x3E, 0x1E, 0x0F, 0x07, 0x83, 0x81, 0xC0, 0xE0, 0x70, 0x00,
  0x03, 0x80, 0x70, 0x1E, 0x07, 0x80, 0x70, 0x38, 0x03, 0x83, 0x80, 0x0E,
  0x38, 0x00, 0x73, 0x80, 0x03, 0x9C, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xEE,
  0x00, 0x0E, 0x70, 0x00, 0xE1, 0xC0, 0x0E, 0x0E, 0x00, 0xE0, 0x70, 0x0F,
  0x01, 0x80, 0x70, 0x0E, 0x07, 0x00, 0x70, 0x00, 0xE0, 0x07, 0xE0, 0x0E,
  0xE0, 0x1E, 0x60, 0x1C, 0x70, 0x38, 0x70, 0x70, 0x70, 0x70, 0x30, 0xE0,
  0x39, 0xC0, 0x3B, 0x80, 0x1B, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x03, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x7F, 0x80, 0x7F, 0x80,
  0xFF, 0x80, 0xE1, 0x86, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x70,
  0xC3, 0x0C, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE1, 0x86, 0x1C,
  0x70, 0x01, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x60, 0x00, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80,
  0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03,
  0x80, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80,
  0x07, 0x00, 0x0E, 0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x01, 0xC0,
  0x07, 0x80, 0x3E, 0x01, 0xD8, 0x0E, 0x70, 0x71, 0xC3, 0xC3, 0x0E, 0x0E,
  0x70, 0x3B, 0x80, 0x64, 0x01, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x43, 0x87,
  0x0E, 0x1C, 0x20, 0x00, 0xFC, 0x0F, 0xFC, 0x3F, 0xF8, 0xF8, 0x73, 0xC0,
  0xC7, 0x01, 0x9C, 0x07, 0x38, 0x0E, 0x60, 0x19, 0xC0, 0x73, 0x80, 0xE7,
  0x01, 0xC7, 0x0F, 0x8F, 0xFF, 0x0F, 0xFE, 0x0F, 0x8C, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0F, 0xF0, 0x3F, 0xF8, 0x7F, 0xF8, 0xF0, 0xF1, 0xC0, 0xE3, 0x01, 0xCE,
  0x03, 0x9C, 0x07, 0x38, 0x0E, 0x60, 0x39, 0xC0, 0x73, 0x81, 0xC6, 0x0F,
  0x8F, 0xFE, 0x3F, 0xF0, 0x7F, 0x80, 0x01, 0xFC, 0x0F, 0xFC, 0x3F, 0xF8,
  0xF8, 0x33, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0,
  0x03, 0x80, 0x03, 0x80, 0x07, 0x81, 0x8F, 0xFF, 0x0F, 0xFE, 0x07, 0xF0,
  0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x30, 0x00, 0x38, 0x00, 0x1C, 0x01, 0xFE, 0x03, 0xFE, 0x07, 0xC3, 0x07,
  0x83, 0x87, 0x81, 0xC3, 0x80, 0xE3, 0x80, 0x61, 0xC0, 0x70, 0xE0, 0x38,
  0x70, 0x1C, 0x38, 0x0C, 0x1C, 0x0E, 0x0E, 0x07, 0x07, 0x87, 0x81, 0xFE,
  0xC0, 0x7E, 0x70, 0x01, 0xF8, 0x0F, 0xF8, 0x3F, 0xF8, 0xF0, 0x73, 0x80,
  0xEE, 0x01, 0xDC, 0x0F, 0xBF, 0xFE, 0x7F, 0xF1, 0xFF, 0x03, 0x80, 0x03,
  0x00, 0x07, 0x81, 0x8F, 0xFF, 0x0F, 0xFE, 0x07, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x00, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0xFF, 0xC1, 0xF0, 0xE1, 0xE0, 0xE0, 0xE0, 0x70, 0xE0,
  0x38, 0x70, 0x1C, 0x70, 0x1C, 0x38, 0x0E, 0x1C, 0x07, 0x0E, 0x03, 0x07,
  0x03, 0x83, 0xC3, 0xC0, 0xFF, 0xE0, 0x3F, 0x60, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x38, 0x10, 0x3C, 0x1F, 0xFC, 0x0F, 0xFC, 0x01, 0xF8, 0x00, 0x07,
  0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07,
  0x00, 0x1F, 0xF0, 0x7F, 0xE1, 0xFF, 0xCF, 0x0F, 0x38, 0x1C, 0xE0, 0x73,
  0x81, 0xDC, 0x07, 0x70, 0x1D, 0xC0, 0x67, 0x03, 0x98, 0x0E, 0xE0, 0x3B,
  0x80, 0xCE, 0x07, 0x30, 0x1C, 0x07, 0x07, 0xC3, 0xE1, 0xE0, 0x70, 0x00,
  0x01, 0xFC, 0xFE, 0x7F, 0x03, 0x81, 0x81, 0xC0, 0xE0, 0x70, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x83, 0xF8, 0xFC, 0x3E, 0x00, 0x06, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x03,
  0xFE, 0x03, 0xFE, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x41, 0xC0, 0xFF,
  0xC0, 0xFF, 0x80, 0x3E, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x07,
  0x06, 0x07, 0x07, 0x0F, 0x03, 0x8F, 0x01, 0xCF, 0x00, 0xCE, 0x00, 0xFE,
  0x00, 0x7E, 0x00, 0x3F, 0x80, 0x1D, 0xE0, 0x1C, 0x70, 0x0E, 0x1C, 0x07,
  0x07, 0x03, 0x83, 0x83, 0x80, 0xE1, 0xC0, 0x70, 0x7F, 0x7F, 0xBF, 0x81,
  0xC0, 0xE0, 0x70, 0x30, 0x38, 0x1C, 0x0E, 0x06, 0x07, 0x03, 0x81, 0xC0,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x0B, 0xFD, 0xFE, 0x3E, 0x07,
  0xCF, 0x07, 0xFF, 0x87, 0x38, 0xE3, 0x8C, 0x71, 0x8E, 0x38, 0xC7, 0x18,
  0xE3, 0x1C, 0x71, 0x8E, 0x31, 0xC7, 0x18, 0xE3, 0x1C, 0x01, 0x8E, 0x01,
  0xC6, 0x00, 0xE3, 0x00, 0x63, 0x80, 0x31, 0xC0, 0x38, 0x07, 0xF0, 0x1F,
  0xF8, 0x7F, 0xF0, 0xE0, 0xF1, 0xC0, 0xE3, 0x81, 0xCE, 0x03, 0x9C, 0x07,
  0x38, 0x0C, 0x70, 0x39, 0xC0, 0x73, 0x80, 0xE7, 0x03, 0x8E, 0x07, 0x38,
  0x0E, 0x70, 0x1C, 0x03, 0xE0, 0x3F, 0xE1, 0xFF, 0xCF, 0x0F, 0x78, 0x1D,
  0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0xFE, 0x03, 0xB8, 0x1E,
  0xF0, 0xF3, 0xFF, 0x87, 0xFC, 0x0F, 0xC0, 0x03, 0xF8, 0x0F, 0xFE, 0x0F,
  0xFE, 0x0E, 0x0F, 0x0E, 0x07, 0x0C, 0x07, 0x1C, 0x07, 0x1C, 0x07, 0x1C,
  0x07, 0x18, 0x0E, 0x38, 0x0E, 0x38, 0x1C, 0x30, 0x7C, 0x3F, 0xF8, 0x7F,
  0xE0, 0x7F, 0x80, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0x01, 0xFC, 0x0F, 0xFC, 0x78, 0x31, 0xE0, 0xE7, 0x81,
  0xCE, 0x03, 0xB8, 0x07, 0x70, 0x1C, 0xE0, 0x39, 0xC0, 0x73, 0x80, 0xE7,
  0x03, 0x8E, 0x07, 0x1E, 0x1E, 0x1F, 0xFC, 0x1F, 0xF0, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x03, 0xFE, 0x1F,
  0xF8, 0x7F, 0xF0, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0x03, 0xF8, 0x3F, 0xF1, 0xFF, 0xC7, 0x02, 0x18, 0x00,
  0x70, 0x01, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0x00, 0x1C,
  0x40, 0xF3, 0xFF, 0x8F, 0xFC, 0x0F, 0xE0, 0x06, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x1C, 0x01, 0x80, 0x38, 0x03,
  0x80, 0x38, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x04, 0x7F, 0xC3,
  0xFC, 0x1F, 0x80, 0x38, 0x0C, 0x70, 0x38, 0xC0, 0x73, 0x80, 0xE7, 0x01,
  0x8E, 0x07, 0x18, 0x0E, 0x70, 0x1C, 0xE0, 0x71, 0xC0, 0xE3, 0x81, 0xC7,
  0x03, 0x8E, 0x1F, 0x1F, 0xFE, 0x1F, 0xFC, 0x1F, 0x18, 0xC0, 0x3E, 0x01,
  0xF0, 0x1D, 0xC0, 0xEE, 0x06, 0x70, 0x73, 0x83, 0x1C, 0x38, 0xE3, 0x87,
  0x1C, 0x19, 0xC0, 0xCC, 0x07, 0xE0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x70,
  0x03, 0x30, 0x01, 0x98, 0x01, 0xDC, 0x00, 0xCE, 0x18, 0x67, 0x1C, 0x73,
  0x8E, 0x31, 0xCF, 0x18, 0xCF, 0x9C, 0x66, 0xCC, 0x36, 0x6E, 0x1B, 0x3E,
  0x0F, 0x0F, 0x07, 0x87, 0x83, 0x83, 0x81, 0x81, 0xC0, 0x0E, 0x03, 0x87,
  0x03, 0x81, 0xC3, 0x80, 0xE3, 0xC0, 0x39, 0xC0, 0x1D, 0xC0, 0x07, 0xC0,
  0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF8, 0x01, 0xDC, 0x01, 0xCE, 0x01, 0xC3,
  0x81, 0xC1, 0xC1, 0xC0, 0x71, 0xC0, 0x38, 0x03, 0x80, 0xE0, 0x70, 0x1C,
  0x0E, 0x03, 0x01, 0xC0, 0xE0, 0x38, 0x1C, 0x07, 0x07, 0x00, 0xE0, 0xE0,
  0x0C, 0x18, 0x01, 0xC7, 0x00, 0x38, 0xC0, 0x07, 0x38, 0x00, 0xE6, 0x00,
  0x0D, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x3C, 0x01, 0x0F, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF8, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0xFF,
  0x01, 0xE0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0xFC, 0x00,
  0xF8, 0x00, 0xFC, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x3F, 0xC0, 0x3F, 0xC0, 0x0F, 0xC0, 0x01, 0xC0, 0x70, 0x18, 0x0E, 0x03,
  0x80, 0xE0, 0x30, 0x0C, 0x07, 0x01, 0xC0, 0x60, 0x18, 0x0E, 0x03, 0x80,
  0xE0, 0x30, 0x1C, 0x07, 0x01, 0xC0, 0x60, 0x38, 0x0E, 0x03, 0x80, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0x80, 0x60, 0x38, 0x00, 0x01, 0xF8, 0x01, 0xFC,
  0x01, 0xFC, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x3C,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80,
  0x03, 0x80, 0xFF, 0x80, 0xFF, 0x00, 0xFC, 0x00, 0x3C, 0x0C, 0xFE, 0x1B,
  0x9E, 0x76, 0x0F, 0xCC, 0x0F, 0x00,
};

const GFXglyph UbuntuMono_Italic34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 8, 21, 17, 6, -21 },
  { 22, 9, 8, 17, 8, -21 },
  { 31, 18, 21, 17, 1, -21 },
  { 79, 16, 27, 17, 2, -24 },
  { 133, 21, 21, 17, 0, -21 },
  { 189, 15, 21, 17, 2, -21 },
  { 229, 5, 9, 17, 10, -23 },
  { 235, 13, 30, 17, 5, -24 },
  { 284, 13, 30, 17, 2, -24 },
  { 333, 13, 13, 17, 5, -21 },
  { 355, 14, 14, 17, 3, -16 },
  { 380, 7, 10, 17, 4, -5 },
  { 389, 8, 3, 17, 6, -10 },
  { 392, 5, 5, 17, 6, -5 },
  { 396, 20, 30, 17, -1, -24 },
  { 471, 15, 21, 17, 3, -21 },
  { 511, 13, 21, 17, 3, -21 },
  { 546, 16, 21, 17, 2, -21 },
  { 588, 15, 21, 17, 2, -21 },
  { 628, 15, 21, 17, 2, -21 },
  { 668, 17, 21, 17, 2, -21 },
  { 713, 16, 21, 17, 3, -21 },
  { 755, 15, 21, 17, 5, -21 },
  { 795, 15, 21, 17, 3, -21 },
  { 835, 15, 21, 17, 3, -21 },
  { 875, 8, 16, 17, 6, -16 },
  { 891, 10, 21, 17, 4, -16 },
  { 918, 15, 13, 17, 3, -15 },
  { 943, 16, 8, 17, 2, -13 },
  { 959, 15, 13, 17, 2, -16 },
  { 984, 12, 21, 17, 6, -21 },
  { 1016, 17, 26, 17, 2, -21 },
  { 1072, 16, 21, 17, 0, -21 },
  { 1114, 16, 21, 17, 2, -21 },
  { 1156, 17, 21, 17, 3, -21 },
  { 1201, 17, 21, 17, 1, -21 },
  { 1246, 17, 21, 17, 2, -21 },
  { 1291, 17, 21, 17, 2, -21 },
  { 1336, 16, 21, 17, 3, -21 },
  { 1378, 19, 21, 17, 1, -21 },
  { 1428, 16, 21, 17, 2, -21 },
  { 1470, 17, 21, 17, 2, -21 },
  { 1515, 18, 21, 17, 2, -21 },
  { 1563, 12, 21, 17, 2, -21 },
  { 1595, 18, 21, 17, 1, -21 },
  { 1643, 19, 21, 17, 1, -21 },
  { 1693, 15, 21, 17, 3, -21 },
  { 1733, 16, 21, 17, 2, -21 },
  { 1775, 15, 27, 17, 3, -21 },
  { 1826, 16, 21, 17, 2, -21 },
  { 1868, 17, 21, 17, 2, -21 },
  { 1913, 15, 21, 17, 5, -21 },
  { 1953, 17, 21, 17, 3, -21 },
  { 1998, 16, 21, 17, 5, -21 },
  { 2040, 18, 21, 17, 2, -21 },
  { 2088, 21, 21, 17, 0, -21 },
  { 2144, 16, 21, 17, 5, -21 },
  { 2186, 18, 21, 17, 1, -21 },
  { 2234, 16, 30, 17, 3, -24 },
  { 2294, 6, 30, 17, 7, -24 },
  { 2317, 15, 30, 17, 1, -24 },
  { 2374, 14, 11, 17, 4, -21 },
  { 2394, 16, 2, 17, -1, 3 },
  { 2398, 6, 6, 17, 9, -23 },
  { 2403, 15, 16, 17, 2, -16 },
  { 2433, 15, 24, 17, 2, -24 },
  { 2478, 15, 16, 17, 2, -16 },
  { 2508, 17, 24, 17, 3, -24 },
  { 2559, 15, 16, 17, 2, -16 },
  { 2589, 20, 30, 17, 0, -24 },
  { 2664, 17, 22, 17, 1, -16 },
  { 2711, 14, 24, 17, 2, -24 },
  { 2753, 9, 23, 17, 5, -23 },
  { 2779, 16, 29, 17, 1, -23 },
  { 2837, 17, 24, 17, 2, -24 },
  { 2888, 9, 24, 17, 6, -24 },
  { 2915, 17, 16, 17, 1, -16 },
  { 2949, 15, 16, 17, 2, -16 },
  { 2979, 14, 16, 17, 3, -16 },
  { 3007, 16, 22, 17, 1, -16 },
  { 3051, 15, 22, 17, 3, -16 },
  { 3093, 15, 16, 17, 3, -16 },
  { 3123, 14, 16, 17, 3, -16 },
  { 3151, 12, 21, 17, 5, -21 },
  { 3183, 15, 16, 17, 3, -16 },
  { 3213, 13, 16, 17, 5, -16 },
  { 3239, 17, 16, 17, 3, -16 },
  { 3273, 17, 16, 17, 1, -16 },
  { 3307, 19, 22, 17, -1, -16 },
  { 3360, 15, 16, 17, 2, -16 },
  { 3390, 16, 30, 17, 3, -24 },
  { 3450, 10, 30, 17, 5, -24 },
  { 3488, 16, 30, 17, 0, -24 },
  { 3548, 15, 5, 17, 3, -14 },
};

const GFXfont UbuntuMono_Italic34pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Italic34pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Italic34pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _UBUNTUMONO_ITALIC34PT7B_H_
