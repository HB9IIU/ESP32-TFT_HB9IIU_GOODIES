#ifndef _ROBOTOCONDENSED_MEDIUMITALIC15PT7B_H_
#define _ROBOTOCONDENSED_MEDIUMITALIC15PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-MediumItalic.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_MediumItalic15pt7bBitmaps[] PROGMEM = {
  0x00, 0x33, 0x22, 0x66, 0x64, 0x0C, 0xC0, 0x55, 0xDA, 0x0B, 0x0A, 0x1A,
  0x3F, 0x14, 0x14, 0x24, 0x7E, 0x28, 0x48, 0x50, 0x0C, 0x10, 0x71, 0xB2,
  0x64, 0x0C, 0x0C, 0x0C, 0x09, 0x13, 0x67, 0x84, 0x00, 0x70, 0xA7, 0x56,
  0xA6, 0x82, 0x07, 0x95, 0x5A, 0x94, 0x30, 0x1C, 0x34, 0x26, 0x24, 0x38,
  0x30, 0x7A, 0xCA, 0xCE, 0x6C, 0x7E, 0x7E, 0x13, 0x24, 0x4C, 0xC8, 0x88,
  0x88, 0x84, 0x40, 0x20, 0x84, 0x31, 0x8C, 0x63, 0x18, 0x84, 0x62, 0x22,
  0x00, 0x10, 0x4F, 0xCC, 0x52, 0x40, 0x18, 0x30, 0x63, 0xF7, 0xE2, 0x0C,
  0x18, 0x6D, 0x60, 0xE0, 0xF0, 0x06, 0x08, 0x30, 0x40, 0x82, 0x04, 0x18,
  0x20, 0xC1, 0x06, 0x00, 0x39, 0xB4, 0xF3, 0xCF, 0x38, 0xE2, 0x9B, 0x67,
  0x00, 0x3F, 0xA2, 0x26, 0x66, 0x64, 0x40, 0x1C, 0x6D, 0x98, 0x30, 0x41,
  0x86, 0x18, 0x61, 0x83, 0xF0, 0x1C, 0x6D, 0x98, 0x30, 0xC3, 0x03, 0x02,
  0xCC, 0xF9, 0xE0, 0x06, 0x1C, 0x30, 0xA3, 0xC5, 0x9B, 0x66, 0xFE, 0x10,
  0x60, 0x7D, 0xF4, 0x10, 0x7B, 0x60, 0xC3, 0x8B, 0x67, 0x00, 0x18, 0xE6,
  0x10, 0xFB, 0x6C, 0xE3, 0x8B, 0x67, 0x00, 0xFE, 0x08, 0x30, 0x41, 0x82,
  0x0C, 0x10, 0x60, 0x83, 0x00, 0x1C, 0x6C, 0x99, 0x33, 0xC7, 0x1B, 0x22,
  0xCC, 0xD9, 0xE0, 0x39, 0xAC, 0xF3, 0xCF, 0x77, 0x86, 0x19, 0xCE, 0x00,
  0x24, 0x00, 0x36, 0x33, 0x00, 0x00, 0x26, 0x6C, 0x04, 0x77, 0x90, 0xF0,
  0x60, 0x80, 0xFC, 0x00, 0x3E, 0x41, 0xC1, 0xC3, 0x39, 0x88, 0x00, 0x7B,
  0xF2, 0x31, 0x99, 0x8C, 0x02, 0x10, 0x07, 0x83, 0x18, 0xC1, 0x13, 0xB4,
  0x92, 0xB2, 0xD6, 0x96, 0x92, 0xD6, 0x5B, 0xF1, 0x00, 0x30, 0x03, 0xC0,
  0x06, 0x03, 0x03, 0x81, 0xE1, 0xB0, 0xD8, 0x7C, 0x7E, 0x21, 0x30, 0x98,
  0x40, 0x3E, 0x3F, 0x23, 0x63, 0x66, 0x7C, 0x66, 0x66, 0x46, 0xCE, 0xFC,
  0x3C, 0xFD, 0x1E, 0x1C, 0x18, 0x30, 0x42, 0xCD, 0xB9, 0xE0, 0x3C, 0x3E,
  0x23, 0x63, 0x63, 0x63, 0x62, 0x62, 0x46, 0xDC, 0xF8, 0x3F, 0x3F, 0x20,
  0x60, 0x60, 0x7C, 0x60, 0x60, 0x40, 0xC0, 0xFC, 0x3F, 0x3E, 0x20, 0x60,
  0x7C, 0x7C, 0x60, 0x60, 0x40, 0xC0, 0xC0, 0x3C, 0xFD, 0x0E, 0x0C, 0x18,
  0x37, 0xC3, 0xC5, 0xF9, 0xE0, 0x31, 0x98, 0xC8, 0x6C, 0x36, 0x13, 0xF9,
  0x8C, 0xC6, 0x43, 0x61, 0x30, 0x80, 0x33, 0x22, 0x66, 0x66, 0x44, 0xC0,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0x83, 0x06, 0xCD, 0xF1, 0xC0, 0x33, 0x99,
  0x89, 0x8D, 0x87, 0x83, 0xC1, 0xF0, 0xD8, 0x4C, 0x63, 0x31, 0x80, 0x30,
  0xC2, 0x18, 0x61, 0x86, 0x18, 0x43, 0x0F, 0xC0, 0x30, 0x66, 0x1C, 0xE3,
  0xBC, 0xF7, 0x94, 0xF6, 0x9A, 0xB3, 0x56, 0x4E, 0xD9, 0x9B, 0x32, 0x00,
  0x31, 0x98, 0xCC, 0x6F, 0x26, 0x93, 0x59, 0xBC, 0xCE, 0x47, 0x63, 0x31,
  0x80, 0x3C, 0xFD, 0x0E, 0x1C, 0x38, 0xF1, 0xC3, 0xC5, 0xF9, 0xE0, 0x3E,
  0x3F, 0x23, 0x63, 0x63, 0x66, 0x7C, 0x60, 0x40, 0xC0, 0xC0, 0x3C, 0xFD,
  0x1E, 0x1C, 0x38, 0xE1, 0xC3, 0xC5, 0xF9, 0xE0, 0x60, 0x80, 0x3E, 0x3F,
  0x23, 0x63, 0x63, 0x6E, 0x7C, 0x6C, 0x4C, 0xC6, 0xC6, 0x1E, 0x3E, 0x23,
  0x60, 0x30, 0x1C, 0x0E, 0x06, 0xC6, 0x6C, 0x38, 0xFF, 0xFC, 0x40, 0x83,
  0x06, 0x0C, 0x18, 0x20, 0xC1, 0x80, 0x62, 0x42, 0x46, 0xC6, 0xC6, 0xC6,
  0xC4, 0x84, 0x8C, 0xFC, 0x78, 0xC3, 0xC2, 0x46, 0x46, 0x4C, 0x6C, 0x68,
  0x78, 0x70, 0x70, 0x30, 0xC4, 0x59, 0x9B, 0x33, 0x66, 0x45, 0xC8, 0xAB,
  0x15, 0x63, 0xB8, 0x67, 0x0C, 0xE1, 0x98, 0x00, 0x23, 0x19, 0x8D, 0x82,
  0xC1, 0xC0, 0xC0, 0xF0, 0x78, 0x6C, 0x33, 0x31, 0x80, 0xC6, 0x46, 0x6C,
  0x6C, 0x78, 0x38, 0x30, 0x30, 0x20, 0x20, 0x60, 0x3F, 0x7F, 0x06, 0x0C,
  0x0C, 0x18, 0x30, 0x30, 0x60, 0xC0, 0xFC, 0x39, 0x88, 0x46, 0x31, 0x8C,
  0x42, 0x31, 0x8C, 0x60, 0xC4, 0x44, 0x66, 0x66, 0x62, 0x22, 0x38, 0xC6,
  0x21, 0x18, 0xC6, 0x31, 0x08, 0xC6, 0x70, 0x37, 0x5D, 0x90, 0xFC, 0xD0,
  0x3D, 0xB0, 0x4F, 0x6F, 0x3D, 0xDF, 0x30, 0x40, 0x83, 0x07, 0xCF, 0xD9,
  0xA3, 0x45, 0x8B, 0xB7, 0xC0, 0x3D, 0xB4, 0x50, 0xC3, 0x37, 0x9E, 0x02,
  0x02, 0x06, 0x06, 0x3E, 0x6E, 0x44, 0x44, 0xCC, 0xCC, 0x7C, 0x7C, 0x3D,
  0xB6, 0x51, 0xFF, 0x06, 0xDE, 0x3B, 0xD8, 0xCF, 0x23, 0x18, 0xC6, 0x21,
  0x00, 0x3E, 0xDD, 0x9A, 0x2C, 0x59, 0x9B, 0x3E, 0x0D, 0xB1, 0xC0, 0x30,
  0x82, 0x18, 0x7D, 0xF6, 0x51, 0x4F, 0x3C, 0xF3, 0x33, 0x06, 0x66, 0x64,
  0x4C, 0xC0, 0x08, 0x20, 0x06, 0x18, 0x61, 0x84, 0x10, 0xC3, 0x0C, 0x61,
  0x80, 0x30, 0x40, 0x83, 0x06, 0x6D, 0x9E, 0x38, 0x79, 0xB3, 0x26, 0x60,
  0x33, 0x22, 0x66, 0x66, 0x44, 0xCC, 0x7D, 0xDB, 0xB6, 0x4D, 0x93, 0x4C,
  0xD3, 0x3C, 0xCF, 0x32, 0x7D, 0xF6, 0x51, 0x4F, 0x3C, 0xF3, 0x3C, 0xD9,
  0x9A, 0x3C, 0x78, 0x9B, 0x3C, 0x7C, 0xF9, 0x9B, 0x34, 0x58, 0xBB, 0x7C,
  0xC1, 0x02, 0x00, 0x3E, 0xDD, 0x1A, 0x2C, 0x59, 0x9B, 0x3E, 0x08, 0x10,
  0x60, 0x7B, 0xD8, 0xC4, 0x63, 0x18, 0x39, 0xB6, 0x1C, 0x1B, 0x3C, 0x9E,
  0x66, 0xE4, 0xCC, 0xCC, 0xCC, 0x66, 0xCD, 0x92, 0x24, 0xC9, 0x9F, 0x3E,
  0xCB, 0x6D, 0xB4, 0xF3, 0x86, 0x10, 0xD9, 0x6D, 0xB6, 0xDF, 0x4E, 0xE7,
  0x73, 0x31, 0x98, 0x64, 0xD8, 0xE1, 0xC3, 0x0F, 0x16, 0x64, 0x33, 0x36,
  0x36, 0x3C, 0x3C, 0x38, 0x18, 0x10, 0x30, 0x60, 0x60, 0x7C, 0x31, 0x84,
  0x31, 0x8C, 0x3E, 0x08, 0x8C, 0x63, 0x11, 0x98, 0x63, 0x18, 0xC4, 0x30,
  0x80, 0x24, 0x92, 0xD2, 0x49, 0x68, 0x30, 0x84, 0x21, 0x08, 0x63, 0x31,
  0x88, 0x42, 0x31, 0x00, 0x67, 0xEA, 0x70,
};

const GFXglyph RobotoCondensed_MediumItalic15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 4, 11, 4, 0, -11 },
  { 7, 4, 4, 5, 1, -11 },
  { 9, 8, 11, 8, 0, -11 },
  { 20, 7, 14, 7, 0, -13 },
  { 33, 7, 11, 9, 1, -11 },
  { 43, 8, 11, 8, 0, -11 },
  { 54, 2, 4, 2, 1, -11 },
  { 55, 4, 15, 5, 1, -12 },
  { 63, 5, 15, 5, -1, -12 },
  { 73, 6, 6, 6, 1, -11 },
  { 78, 7, 8, 7, 0, -9 },
  { 85, 3, 4, 3, -1, -2 },
  { 87, 3, 1, 5, 1, -5 },
  { 88, 2, 2, 4, 0, -2 },
  { 89, 7, 12, 5, -1, -11 },
  { 100, 6, 11, 7, 1, -11 },
  { 109, 4, 11, 7, 2, -11 },
  { 115, 7, 11, 7, 0, -11 },
  { 125, 7, 11, 7, 0, -11 },
  { 135, 7, 11, 7, 0, -11 },
  { 145, 6, 11, 7, 1, -11 },
  { 154, 6, 11, 7, 1, -11 },
  { 163, 7, 11, 7, 1, -11 },
  { 173, 7, 11, 7, 0, -11 },
  { 183, 6, 11, 7, 1, -11 },
  { 192, 3, 8, 4, 0, -8 },
  { 195, 4, 10, 3, -1, -8 },
  { 200, 6, 7, 7, 0, -8 },
  { 206, 6, 4, 7, 1, -7 },
  { 209, 6, 7, 7, 0, -8 },
  { 215, 5, 11, 6, 1, -11 },
  { 222, 11, 13, 11, 0, -10 },
  { 240, 9, 11, 9, -1, -11 },
  { 253, 8, 11, 8, 0, -11 },
  { 264, 7, 11, 8, 1, -11 },
  { 274, 8, 11, 8, 0, -11 },
  { 285, 8, 11, 7, 0, -11 },
  { 296, 8, 11, 7, 0, -11 },
  { 307, 7, 11, 9, 1, -11 },
  { 317, 9, 11, 9, 0, -11 },
  { 330, 4, 11, 4, 0, -11 },
  { 336, 7, 11, 7, 0, -11 },
  { 346, 9, 11, 8, 0, -11 },
  { 359, 6, 11, 7, 0, -11 },
  { 368, 11, 11, 11, 0, -11 },
  { 384, 9, 11, 9, 0, -11 },
  { 397, 7, 11, 9, 1, -11 },
  { 407, 8, 11, 8, 0, -11 },
  { 418, 7, 13, 9, 1, -11 },
  { 430, 8, 11, 8, 0, -11 },
  { 441, 8, 11, 8, 0, -11 },
  { 452, 7, 11, 8, 1, -11 },
  { 462, 8, 11, 8, 1, -11 },
  { 473, 8, 11, 8, 1, -11 },
  { 484, 11, 11, 11, 1, -11 },
  { 500, 9, 11, 8, 0, -11 },
  { 513, 8, 11, 8, 1, -11 },
  { 524, 8, 11, 8, 0, -11 },
  { 535, 5, 14, 4, 0, -12 },
  { 544, 4, 12, 5, 1, -11 },
  { 550, 5, 14, 4, -1, -12 },
  { 559, 4, 5, 6, 1, -11 },
  { 562, 6, 1, 6, -1, 0 },
  { 563, 2, 2, 5, 2, -11 },
  { 564, 6, 8, 7, 0, -8 },
  { 570, 7, 12, 7, 0, -12 },
  { 581, 6, 8, 7, 0, -8 },
  { 587, 8, 12, 7, 0, -12 },
  { 599, 6, 8, 7, 0, -8 },
  { 605, 5, 12, 5, 1, -12 },
  { 613, 7, 11, 7, 0, -8 },
  { 623, 6, 12, 7, 0, -12 },
  { 632, 4, 11, 4, 0, -11 },
  { 638, 6, 14, 3, -2, -11 },
  { 649, 7, 12, 7, 0, -12 },
  { 660, 4, 12, 4, 0, -12 },
  { 666, 10, 8, 11, 0, -8 },
  { 676, 6, 8, 7, 0, -8 },
  { 682, 7, 8, 7, 0, -8 },
  { 689, 7, 11, 7, 0, -8 },
  { 699, 7, 11, 7, 0, -8 },
  { 709, 5, 8, 5, 0, -8 },
  { 714, 6, 8, 7, 0, -8 },
  { 720, 4, 10, 4, 1, -10 },
  { 725, 7, 8, 7, 0, -8 },
  { 732, 6, 8, 6, 1, -8 },
  { 738, 9, 8, 9, 1, -8 },
  { 747, 7, 8, 6, 0, -8 },
  { 754, 8, 11, 6, -1, -8 },
  { 765, 6, 8, 6, 0, -8 },
  { 771, 5, 15, 4, 0, -12 },
  { 781, 3, 13, 4, 0, -11 },
  { 786, 5, 15, 4, -1, -12 },
  { 796, 7, 3, 8, 1, -6 },
};

const GFXfont RobotoCondensed_MediumItalic15pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_MediumItalic15pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_MediumItalic15pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _ROBOTOCONDENSED_MEDIUMITALIC15PT7B_H_
