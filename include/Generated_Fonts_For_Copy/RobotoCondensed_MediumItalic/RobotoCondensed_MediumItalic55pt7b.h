#ifndef _ROBOTOCONDENSED_MEDIUMITALIC55PT7B_H_
#define _ROBOTOCONDENSED_MEDIUMITALIC55PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-MediumItalic.ttf
// Size: 55pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_MediumItalic55pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x1F, 0x81, 0xFC, 0x0F,
  0xE0, 0x3F, 0x01, 0xF0, 0x02, 0x00, 0x3E, 0x3E, 0x7C, 0x7C, 0xF8, 0xF1,
  0xF1, 0xE3, 0xC3, 0xC7, 0x8F, 0x9F, 0x1F, 0x3E, 0x3C, 0x78, 0x78, 0xF0,
  0xF1, 0xE1, 0xE3, 0xC7, 0x8F, 0x0F, 0x1E, 0x1E, 0x00, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0xF0, 0x78, 0x00, 0x1E, 0x1F, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0xF0, 0x78, 0x00, 0x1E, 0x1F, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF8, 0x78,
  0x00, 0x1E, 0x1F, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF8, 0x78, 0x07, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8,
  0x03, 0xC3, 0xC0, 0x00, 0xF8, 0x78, 0x00, 0x1E, 0x1F, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0xF8, 0x78, 0x00, 0x1E, 0x1F, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0xF8, 0x78, 0x00, 0x1E, 0x1F, 0x00, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x00, 0xF8, 0x78, 0x00, 0x1E,
  0x0F, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF8, 0x78, 0x00, 0x1E, 0x0F, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0xF8, 0x78, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC3,
  0xE0, 0x00, 0xF8, 0x78, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xF8,
  0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xF0, 0xFE,
  0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0x7E, 0x0F, 0xC0, 0x7F, 0x0F, 0xC0, 0x3F,
  0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8,
  0xFC, 0x01, 0xF8, 0xFC, 0x03, 0xF8, 0xFE, 0x07, 0xF0, 0x7F, 0x0F, 0xF0,
  0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7E, 0xF8,
  0x00, 0x1F, 0x1F, 0x01, 0x07, 0x83, 0xC0, 0xF3, 0xE0, 0xF0, 0x7C, 0xF0,
  0x3C, 0x1E, 0x3C, 0x0F, 0x0F, 0x8F, 0x03, 0xC7, 0xC3, 0xC1, 0xF1, 0xE0,
  0xF0, 0x7C, 0xF8, 0x3E, 0x1E, 0x7C, 0x07, 0xDF, 0x9E, 0x01, 0xFF, 0xCF,
  0x00, 0x3F, 0xE7, 0xC0, 0x07, 0xF1, 0xE0, 0x00, 0x20, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE7, 0xF8, 0x00, 0xF3, 0xFF, 0x00, 0x7D, 0xFF, 0xC0, 0x3E, 0x7C,
  0xF8, 0x0F, 0x3E, 0x1E, 0x07, 0x8F, 0x07, 0x83, 0xE3, 0xC1, 0xE0, 0xF0,
  0xF0, 0x78, 0x78, 0x7C, 0x1E, 0x3E, 0x1F, 0x07, 0x8F, 0x07, 0xC1, 0xE7,
  0x81, 0xF0, 0xF8, 0xE0, 0x3C, 0x3C, 0x10, 0x0F, 0x9F, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFE,
  0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x0F,
  0x83, 0xF0, 0x03, 0xF0, 0x3E, 0x00, 0x7E, 0x07, 0xC0, 0x0F, 0x81, 0xF8,
  0x01, 0xF0, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE3, 0xF8, 0x00, 0xFC,
  0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFE,
  0x0F, 0x83, 0xFF, 0xC1, 0xF0, 0xFF, 0xFC, 0x3E, 0x3F, 0x9F, 0x87, 0xC7,
  0xE3, 0xF9, 0xF9, 0xFC, 0x3F, 0xBE, 0x3F, 0x07, 0xF7, 0xC7, 0xE0, 0x7F,
  0xF9, 0xFC, 0x07, 0xFE, 0x3F, 0x80, 0xFF, 0xC7, 0xF0, 0x0F, 0xF0, 0xFE,
  0x01, 0xFE, 0x0F, 0xC0, 0x3F, 0x81, 0xFC, 0x0F, 0xF8, 0x3F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xEF, 0xE0, 0x3F,
  0xF0, 0xFC, 0x00, 0x60, 0x00, 0x00, 0x3E, 0x7C, 0xF1, 0xE7, 0xCF, 0x9F,
  0x3C, 0x78, 0xF3, 0xE7, 0xCF, 0x1E, 0x00, 0x00, 0x01, 0x00, 0x07, 0x00,
  0x0F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x01,
  0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F,
  0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0,
  0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01,
  0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F,
  0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x02, 0x03, 0xC0, 0xDE, 0x0F, 0x0F, 0x7F, 0x39, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFC, 0x01, 0xFF, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x80, 0x0F, 0x9E, 0x00, 0x7C, 0x7C, 0x03,
  0xF0, 0xF8, 0x1F, 0x83, 0xE0, 0x3C, 0x07, 0xC0, 0x60, 0x1C, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x03, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFC, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xC1, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xE0, 0xF8, 0x7E,
  0x1F, 0x0F, 0xC3, 0xE1, 0xF8, 0xFC, 0x1E, 0x03, 0x00, 0x7F, 0xFB, 0xFF,
  0xBF, 0xFD, 0xFF, 0xEF, 0xFF, 0x00, 0x1C, 0x7E, 0x7E, 0xFF, 0xFF, 0x7E,
  0x7E, 0x10, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x81, 0xFC, 0x3F, 0x83, 0xF0, 0x3F, 0x0F, 0xC0, 0x7E, 0x1F, 0x80,
  0xFC, 0x7E, 0x00, 0xF8, 0xFC, 0x01, 0xF1, 0xF8, 0x07, 0xE7, 0xE0, 0x0F,
  0xCF, 0xC0, 0x1F, 0x9F, 0x80, 0x3F, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0xFC,
  0xFC, 0x01, 0xFB, 0xF8, 0x03, 0xF7, 0xE0, 0x0F, 0xEF, 0xC0, 0x1F, 0x9F,
  0x80, 0x3F, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0xFC, 0xFC, 0x01, 0xF9, 0xF8,
  0x03, 0xF3, 0xF0, 0x0F, 0xCF, 0xC0, 0x1F, 0x8F, 0x80, 0x3F, 0x1F, 0x00,
  0x7E, 0x3E, 0x01, 0xF8, 0x7E, 0x03, 0xF0, 0xFC, 0x0F, 0xC1, 0xFC, 0x3F,
  0x81, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x03, 0xFE, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x1E, 0x00, 0x7E,
  0x03, 0xFE, 0x1F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFC, 0x7E, 0xFC,
  0xF0, 0xFC, 0xC0, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF8,
  0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xF0,
  0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x03, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x3F, 0x83, 0xF8, 0x1F,
  0xC0, 0x7E, 0x07, 0xE0, 0x1F, 0x81, 0xF8, 0x07, 0xE0, 0xFE, 0x01, 0xF8,
  0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF,
  0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xF0, 0x7F, 0x0F, 0xE0, 0x7F, 0x0F, 0xC0,
  0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x01, 0xF8, 0xFE, 0x01,
  0xF8, 0x7E, 0x03, 0xF8, 0x7F, 0x07, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07,
  0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3E,
  0xFC, 0x00, 0x7E, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xF8, 0xFC, 0x01, 0xF9,
  0xFC, 0x03, 0xF1, 0xF8, 0x03, 0xE1, 0xF8, 0x07, 0xE1, 0xF8, 0x0F, 0xC1,
  0xF8, 0x0F, 0x81, 0xF8, 0x1F, 0x83, 0xF8, 0x3F, 0x03, 0xF0, 0x3E, 0x03,
  0xF0, 0x7E, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x01, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x07, 0xF1, 0xFE, 0x01, 0xF0, 0x3F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x8F, 0xC0, 0x1F, 0xC7, 0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xE0, 0xFC,
  0x07, 0xF0, 0x7E, 0x03, 0xF0, 0x3F, 0x87, 0xF8, 0x0F, 0xFF, 0xF8, 0x07,
  0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0x80, 0x0F, 0xFC, 0x00,
  0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xF0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x1F, 0x9F, 0x80, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE3,
  0xFF, 0xFF, 0x9F, 0xF1, 0xFC, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFB, 0xF0, 0x0F,
  0xDF, 0x80, 0xFE, 0xFE, 0x07, 0xE3, 0xF0, 0x7F, 0x1F, 0xFF, 0xF0, 0x7F,
  0xFF, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x18, 0x00,
  0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xF0, 0xFE, 0x07,
  0xE0, 0x7E, 0x0F, 0xE0, 0x7E, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x7E, 0x0F,
  0xC0, 0x7E, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x7E, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC1, 0xFC, 0x07, 0xE3, 0xF8, 0x03, 0xFF, 0xF0, 0x03,
  0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x3F,
  0x87, 0xF0, 0x3F, 0x03, 0xF0, 0x7E, 0x01, 0xF0, 0x7E, 0x01, 0xF8, 0xFC,
  0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC,
  0x03, 0xF8, 0xFC, 0x03, 0xF0, 0xFE, 0x07, 0xF0, 0xFE, 0x0F, 0xE0, 0x7F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0xFF,
  0xE0, 0x0F, 0xFF, 0x80, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0xFE, 0x1F, 0xC7,
  0xE0, 0x7E, 0x7F, 0x01, 0xF3, 0xF0, 0x0F, 0xDF, 0x80, 0x7F, 0xFC, 0x03,
  0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC,
  0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFD, 0xFC, 0x0F, 0xEF, 0xE0, 0x7F,
  0x3F, 0x8F, 0xF9, 0xFF, 0xFF, 0xC7, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF,
  0xBF, 0x01, 0xF9, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x07, 0xFF,
  0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFE, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0x80, 0x7E, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x07,
  0xC0, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x7E, 0x0F, 0xE0, 0xFF, 0x0F, 0xF0, 0x7E, 0x07, 0xC0, 0x10,
  0x00, 0x00, 0x38, 0x00, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80,
  0x04, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x07, 0x80,
  0x00, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0xFF,
  0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x70, 0x00, 0x00, 0x80,
  0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x04, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x3F,
  0xE0, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x07,
  0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x7F, 0xC0, 0x01, 0xFC, 0x00, 0x07, 0xC0,
  0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x0F, 0xFF, 0x81, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xFE, 0x7F, 0x0F,
  0xE7, 0xF0, 0x7E, 0x7E, 0x07, 0xEF, 0xE0, 0x7E, 0xFC, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xF0,
  0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x1E, 0x00,
  0x1F, 0x00, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x07, 0xC0, 0x00,
  0x01, 0xE0, 0x1F, 0x00, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x00, 0x1E, 0x07,
  0xC0, 0x1F, 0x80, 0x38, 0x1F, 0x01, 0xFF, 0x80, 0xE0, 0xF8, 0x0F, 0xFF,
  0x03, 0xC3, 0xC0, 0x7F, 0xFE, 0x0F, 0x1F, 0x03, 0xF0, 0xF8, 0x3C, 0x7C,
  0x0F, 0x83, 0xC0, 0xF1, 0xE0, 0x7C, 0x0F, 0x03, 0xCF, 0x81, 0xF0, 0x7C,
  0x0F, 0x3E, 0x0F, 0x81, 0xF0, 0x3C, 0xF0, 0x3E, 0x07, 0x80, 0xF7, 0xC1,
  0xF0, 0x1E, 0x03, 0xDF, 0x07, 0xC0, 0xF8, 0x1E, 0x78, 0x1F, 0x03, 0xE0,
  0x79, 0xE0, 0x78, 0x0F, 0x01, 0xE7, 0x83, 0xE0, 0x3C, 0x07, 0x9E, 0x0F,
  0x81, 0xF0, 0x1C, 0xF8, 0x3E, 0x07, 0xC0, 0xF3, 0xE0, 0xF8, 0x1E, 0x03,
  0xCF, 0x83, 0xE0, 0xF8, 0x0E, 0x3E, 0x0F, 0x83, 0xE0, 0x78, 0xF8, 0x3E,
  0x1F, 0x81, 0xE3, 0xE0, 0xF8, 0x7E, 0x0F, 0x0F, 0x83, 0xFF, 0xFC, 0xF8,
  0x3E, 0x07, 0xFD, 0xFF, 0xE0, 0x78, 0x1F, 0xE3, 0xFF, 0x01, 0xE0, 0x3F,
  0x07, 0xF0, 0x07, 0x80, 0x10, 0x06, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x04, 0x00, 0x00,
  0x3F, 0xC0, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x07, 0xE7,
  0xC0, 0x00, 0x3F, 0x1F, 0x00, 0x00, 0xFC, 0x7C, 0x00, 0x07, 0xE1, 0xF8,
  0x00, 0x1F, 0x87, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x03, 0xF0, 0x7E, 0x00,
  0x1F, 0x81, 0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xF8, 0x1F, 0x80, 0x0F,
  0xC0, 0x3E, 0x00, 0x7F, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFE, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0xFE,
  0x1F, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x1F, 0x8F,
  0xC0, 0x00, 0x7E, 0x7F, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x07, 0xEF, 0xE0,
  0x00, 0x1F, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xDF, 0xFE,
  0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x7E,
  0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x0F, 0xE0, 0x0F,
  0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xC0, 0x1F, 0xC0, 0xFC, 0x07, 0xF8, 0x0F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFE, 0x01, 0xF8, 0x07, 0xF0, 0x1F, 0x80, 0x3F, 0x03,
  0xF8, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0x83, 0xF0, 0x01, 0xF8, 0x3F, 0x00,
  0x1F, 0x83, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x87, 0xF0, 0x03, 0xF8,
  0x7F, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xF0, 0x7E, 0x00, 0xFF, 0x07, 0xE0,
  0x7F, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x03, 0xFC, 0x0F, 0xE0, 0x7F, 0x00, 0x7E,
  0x07, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF1, 0xFC,
  0x00, 0x3F, 0x1F, 0x80, 0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x7E, 0x00,
  0x1F, 0x87, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x87, 0xE0, 0x03, 0xF8,
  0x7F, 0x00, 0x7F, 0x03, 0xF0, 0x07, 0xF0, 0x3F, 0x81, 0xFE, 0x03, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x00, 0xFE,
  0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x7E,
  0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xC0, 0x07,
  0xF0, 0xFC, 0x00, 0x7F, 0x0F, 0xC0, 0x07, 0xF1, 0xFC, 0x00, 0x7E, 0x1F,
  0xC0, 0x07, 0xE1, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x07, 0xE1, 0xF8, 0x00,
  0xFE, 0x1F, 0x80, 0x0F, 0xE3, 0xF8, 0x00, 0xFC, 0x3F, 0x80, 0x0F, 0xC3,
  0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0xC3, 0xF0, 0x01, 0xF8, 0x3F, 0x00,
  0x3F, 0x87, 0xF0, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x07, 0xE0, 0x0F, 0xE0,
  0x7E, 0x01, 0xFE, 0x07, 0xE1, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x07, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFE, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x00, 0x7F, 0x07, 0xE0,
  0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF1, 0xFC, 0x00, 0x3F,
  0x1F, 0x80, 0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7F, 0x01, 0xFF, 0xE7, 0xF0, 0x3F, 0xFE, 0x7F,
  0x03, 0xFF, 0xE7, 0xE0, 0x3F, 0xFE, 0x7E, 0x03, 0xFF, 0xC7, 0xE0, 0x00,
  0xFC, 0x7E, 0x00, 0x0F, 0xC7, 0xE0, 0x01, 0xFC, 0x7E, 0x00, 0x1F, 0xC7,
  0xE0, 0x01, 0xFC, 0x7E, 0x00, 0x1F, 0x87, 0xF0, 0x01, 0xF8, 0x7F, 0x00,
  0x3F, 0x83, 0xF8, 0x03, 0xF8, 0x3F, 0xC0, 0xFF, 0x81, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x03, 0xF8,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x7F, 0x03, 0xF0,
  0x00, 0x7F, 0x03, 0xF0, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x7E, 0x07, 0xF0,
  0x00, 0x7E, 0x07, 0xE0, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0xFE, 0x07, 0xE0,
  0x00, 0xFE, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0xFC, 0x0F, 0xE0,
  0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xFC, 0x0F, 0xC0, 0x01, 0xFC, 0x0F, 0xC0,
  0x01, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0x80,
  0x03, 0xF0, 0x3F, 0x80, 0x03, 0xF0, 0x3F, 0x80, 0x03, 0xF0, 0x3F, 0x00,
  0x03, 0xF0, 0x3F, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x07, 0xF0, 0x3F, 0x00,
  0x07, 0xE0, 0x7F, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x07, 0xE0, 0x7E, 0x00,
  0x0F, 0xE0, 0x7E, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x0F, 0xC0, 0xFE, 0x00,
  0x0F, 0xC0, 0xFE, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x0F, 0xC0, 0xFC, 0x00,
  0x1F, 0xC0, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x0F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xF8,
  0x0F, 0xC0, 0x7E, 0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x81, 0xFC,
  0x0F, 0xE0, 0x7E, 0x03, 0xF0, 0x1F, 0x81, 0xFC, 0x0F, 0xE0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x0F, 0xE0, 0x1F, 0xC1,
  0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x7E, 0x03, 0xF0, 0x1F, 0xC0, 0x7E, 0x03,
  0xF0, 0x0F, 0xE1, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0xFF, 0x03, 0xF8, 0x01, 0xFE, 0x03, 0xF0, 0x03,
  0xFC, 0x03, 0xF0, 0x07, 0xF8, 0x03, 0xF0, 0x0F, 0xF0, 0x03, 0xF0, 0x0F,
  0xE0, 0x07, 0xF0, 0x1F, 0xE0, 0x07, 0xF0, 0x3F, 0xC0, 0x07, 0xE0, 0x7F,
  0x80, 0x07, 0xE0, 0xFF, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x07, 0xE1, 0xFC,
  0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x0F, 0xCF, 0xF0,
  0x00, 0x0F, 0xDF, 0xE0, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xF7, 0xF0,
  0x00, 0x3F, 0xE7, 0xF0, 0x00, 0x3F, 0xC3, 0xF0, 0x00, 0x3F, 0x83, 0xF8,
  0x00, 0x3F, 0x03, 0xF8, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x7F, 0x01, 0xFC,
  0x00, 0x7F, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0xFE,
  0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x03,
  0xFE, 0x00, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x03, 0xFE, 0x00,
  0x07, 0xFE, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x0F, 0xFE,
  0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x07, 0xDF,
  0x00, 0x1F, 0xFC, 0x07, 0xDF, 0x00, 0x3F, 0xFC, 0x0F, 0xDF, 0x00, 0x3E,
  0xFC, 0x0F, 0xDF, 0x00, 0x7E, 0xF8, 0x0F, 0xDF, 0x00, 0x7D, 0xF8, 0x0F,
  0xDF, 0x00, 0xFD, 0xF8, 0x0F, 0xDF, 0x00, 0xF9, 0xF8, 0x1F, 0xDF, 0x81,
  0xF9, 0xF8, 0x1F, 0x8F, 0x81, 0xF9, 0xF8, 0x1F, 0x8F, 0x81, 0xF3, 0xF0,
  0x1F, 0x8F, 0x83, 0xF3, 0xF0, 0x1F, 0x8F, 0x83, 0xE3, 0xF0, 0x1F, 0x8F,
  0x87, 0xE3, 0xF0, 0x3F, 0x8F, 0x87, 0xC7, 0xF0, 0x3F, 0x8F, 0x8F, 0xC7,
  0xF0, 0x3F, 0x0F, 0x8F, 0x87, 0xE0, 0x3F, 0x07, 0xDF, 0x87, 0xE0, 0x3F,
  0x07, 0xDF, 0x07, 0xE0, 0x3F, 0x07, 0xFF, 0x07, 0xE0, 0x7F, 0x07, 0xFE,
  0x0F, 0xE0, 0x7F, 0x07, 0xFE, 0x0F, 0xE0, 0x7E, 0x07, 0xFC, 0x0F, 0xC0,
  0x7E, 0x07, 0xFC, 0x0F, 0xC0, 0x7E, 0x03, 0xF8, 0x0F, 0xC0, 0xFE, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x03, 0xF0, 0x1F, 0xC0, 0xFE, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x03, 0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xE0, 0x1F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x3F, 0x03,
  0xFC, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x7E, 0x07,
  0xFE, 0x00, 0x7E, 0x07, 0xFE, 0x00, 0x7E, 0x07, 0xFE, 0x00, 0xFE, 0x07,
  0xFF, 0x00, 0xFE, 0x07, 0xFF, 0x00, 0xFC, 0x07, 0xFF, 0x00, 0xFC, 0x0F,
  0xFF, 0x00, 0xFC, 0x0F, 0xEF, 0x80, 0xFC, 0x0F, 0xCF, 0x81, 0xFC, 0x0F,
  0xCF, 0x81, 0xFC, 0x0F, 0xC7, 0xC1, 0xF8, 0x1F, 0xC7, 0xC1, 0xF8, 0x1F,
  0xC7, 0xC1, 0xF8, 0x1F, 0xC7, 0xE1, 0xF8, 0x1F, 0x83, 0xE3, 0xF8, 0x1F,
  0x83, 0xE3, 0xF8, 0x1F, 0x83, 0xE3, 0xF0, 0x3F, 0x81, 0xF3, 0xF0, 0x3F,
  0x81, 0xF3, 0xF0, 0x3F, 0x01, 0xF7, 0xF0, 0x3F, 0x00, 0xFF, 0xF0, 0x3F,
  0x00, 0xFF, 0xF0, 0x3F, 0x00, 0xFF, 0xE0, 0x7F, 0x00, 0xFF, 0xE0, 0x7F,
  0x00, 0x7F, 0xE0, 0x7E, 0x00, 0x7F, 0xE0, 0x7E, 0x00, 0x7F, 0xE0, 0x7E,
  0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x3F, 0xC0, 0xFE,
  0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xF0, 0x7F,
  0x80, 0xFF, 0x00, 0xFE, 0x07, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x1F, 0x83,
  0xF0, 0x00, 0xFC, 0x3F, 0x80, 0x07, 0xE1, 0xF8, 0x00, 0x3F, 0x8F, 0xC0,
  0x01, 0xFC, 0xFE, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x7F, 0x3F, 0x00, 0x03,
  0xF1, 0xF8, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0xFC, 0x7E, 0x00, 0x07, 0xE7,
  0xF0, 0x00, 0x3F, 0x3F, 0x80, 0x03, 0xF9, 0xF8, 0x00, 0x1F, 0xCF, 0xC0,
  0x00, 0xFC, 0x7E, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x3F, 0x1F, 0x80, 0x01,
  0xF8, 0xFC, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x07, 0xE1,
  0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF0, 0x7F, 0x00, 0x3F, 0x81, 0xFC,
  0x03, 0xF8, 0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x01, 0xFB,
  0xFF, 0xF8, 0x1F, 0xC0, 0x1F, 0xC0, 0xFE, 0x00, 0x7E, 0x07, 0xE0, 0x03,
  0xF8, 0x3F, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0xFE, 0x0F, 0xC0, 0x07, 0xF0,
  0xFE, 0x00, 0x3F, 0x87, 0xF0, 0x01, 0xFC, 0x3F, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x87, 0xF0, 0x07,
  0xF8, 0x3F, 0x81, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0,
  0x0F, 0xF0, 0x7F, 0x80, 0xFE, 0x00, 0xFC, 0x07, 0xE0, 0x07, 0xF0, 0x7F,
  0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x3F, 0x80, 0x07, 0xE1, 0xF8, 0x00,
  0x3F, 0x0F, 0xC0, 0x01, 0xF8, 0xFE, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x7E,
  0x3F, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0xFC, 0xFE,
  0x00, 0x07, 0xE7, 0xF0, 0x00, 0x7F, 0x3F, 0x00, 0x03, 0xF9, 0xF8, 0x00,
  0x1F, 0x8F, 0xC0, 0x00, 0xFC, 0x7E, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x3F,
  0x1F, 0x80, 0x03, 0xF8, 0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0xFC, 0x3F,
  0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xF0, 0x7F, 0x00,
  0x3F, 0x01, 0xF8, 0x03, 0xF8, 0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x1B, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F,
  0xDF, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0x7E, 0x07, 0xE0, 0x07,
  0xF0, 0x7E, 0x00, 0x7F, 0x07, 0xE0, 0x07, 0xF0, 0x7E, 0x00, 0x7F, 0x0F,
  0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00,
  0xFE, 0x0F, 0xC0, 0x1F, 0xC1, 0xFC, 0x03, 0xFC, 0x1F, 0xC1, 0xFF, 0x81,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0x83, 0xF8, 0x03, 0xF0, 0x3F, 0x80,
  0x3F, 0x01, 0xF8, 0x03, 0xF0, 0x1F, 0x80, 0x3F, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x7F, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0x7E, 0x00, 0xFE,
  0x07, 0xE0, 0x0F, 0xE0, 0x7E, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0xFE,
  0x00, 0x7F, 0x0F, 0xC0, 0x07, 0xF0, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x03, 0xFC, 0x1F, 0xC0, 0x7F,
  0x00, 0xFE, 0x07, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x0F, 0xE0, 0x07,
  0xE0, 0xFE, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0,
  0xFE, 0x00, 0x3F, 0x0F, 0xE0, 0x03, 0xF0, 0xFE, 0x00, 0x3F, 0x0F, 0xE0,
  0x07, 0xF0, 0x7E, 0x00, 0x7F, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x81, 0xFE,
  0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x18, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x07,
  0xF0, 0xFE, 0x00, 0x3F, 0x87, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xC1,
  0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x87, 0xF0,
  0x01, 0xFC, 0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x03,
  0xF0, 0x7E, 0x00, 0x3F, 0x87, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xC1,
  0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x83, 0xF0,
  0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xE1, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x03,
  0xF0, 0x7E, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x0F, 0xE1,
  0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF0, 0x7F, 0x00, 0x1F, 0x83, 0xF8,
  0x01, 0xFC, 0x0F, 0xC0, 0x0F, 0xC0, 0x7F, 0x00, 0xFE, 0x03, 0xFC, 0x1F,
  0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x06, 0x00, 0x00, 0x7E,
  0x00, 0x03, 0xFB, 0xF0, 0x00, 0x3F, 0xDF, 0xC0, 0x01, 0xFC, 0xFE, 0x00,
  0x0F, 0xE7, 0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x07, 0xF1, 0xFC, 0x00, 0x7F,
  0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0x00, 0x1F, 0xC1, 0xF8, 0x01, 0xFC, 0x0F,
  0xC0, 0x0F, 0xE0, 0x7E, 0x00, 0xFE, 0x03, 0xF0, 0x07, 0xF0, 0x1F, 0xC0,
  0x3F, 0x00, 0xFE, 0x03, 0xF8, 0x03, 0xF0, 0x1F, 0x80, 0x1F, 0x81, 0xFC,
  0x00, 0xFC, 0x0F, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x3F, 0x07, 0xF0, 0x01,
  0xF8, 0x3F, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x01, 0xF0,
  0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x7E, 0x7E, 0x00, 0x03, 0xF7, 0xE0,
  0x00, 0x1F, 0xBF, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0xFC,
  0x01, 0xFF, 0xF0, 0x03, 0xF0, 0x07, 0xEF, 0xC0, 0x1F, 0xC0, 0x1F, 0xBF,
  0x00, 0x7F, 0x00, 0xFE, 0xFC, 0x01, 0xFC, 0x03, 0xF3, 0xF0, 0x0F, 0xF0,
  0x0F, 0xCF, 0xC0, 0x3F, 0xC0, 0x7F, 0x3F, 0x00, 0xFF, 0x01, 0xF8, 0xFC,
  0x07, 0xFC, 0x07, 0xE3, 0xF0, 0x1F, 0xF0, 0x3F, 0x0F, 0xC0, 0xFF, 0xC0,
  0xFC, 0x3F, 0x03, 0xFF, 0x03, 0xF0, 0xFC, 0x0F, 0xFC, 0x1F, 0x83, 0xF0,
  0x7F, 0xF0, 0x7E, 0x07, 0xC1, 0xF7, 0xC1, 0xF8, 0x1F, 0x07, 0xDF, 0x0F,
  0xC0, 0x7C, 0x3F, 0x7C, 0x3F, 0x01, 0xF0, 0xF9, 0xF0, 0xFC, 0x07, 0xC3,
  0xE7, 0xC7, 0xE0, 0x1F, 0x1F, 0x1F, 0x1F, 0x80, 0x7C, 0x7C, 0x7C, 0x7E,
  0x01, 0xF1, 0xF0, 0xF1, 0xF0, 0x07, 0xCF, 0x83, 0xCF, 0xC0, 0x1F, 0x3E,
  0x0F, 0x3F, 0x00, 0x7D, 0xF8, 0x3C, 0xF8, 0x01, 0xF7, 0xC0, 0xFF, 0xE0,
  0x07, 0xDF, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x0F, 0xFC, 0x00, 0x7F, 0xE0,
  0x3F, 0xF0, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x07, 0xFC, 0x03, 0xFE, 0x00,
  0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x7F, 0x80,
  0x7F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0xC0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x07, 0xF0, 0x1F, 0xC0, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0xFC, 0x0F, 0xE0,
  0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x0F, 0xC7, 0xF0,
  0x00, 0x07, 0xE3, 0xF8, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F,
  0x7E, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0x3F,
  0xC7, 0xE0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x1F,
  0xE0, 0x7E, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x0F, 0xF0, 0x1F, 0xC0, 0x07,
  0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x07, 0xF8, 0x01, 0xFC, 0x03,
  0xF8, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x1F, 0xFF,
  0xC0, 0x03, 0xFB, 0xF8, 0x00, 0xFF, 0x3F, 0x00, 0x1F, 0xC7, 0xE0, 0x07,
  0xF0, 0xFC, 0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0x81, 0xF8, 0x07, 0xF0, 0x3F,
  0x01, 0xFC, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x0F, 0xE0, 0x0F, 0xC1, 0xF8,
  0x01, 0xF8, 0x7F, 0x00, 0x3F, 0x1F, 0xC0, 0x07, 0xE3, 0xF0, 0x00, 0x7C,
  0xFE, 0x00, 0x0F, 0xDF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x0F, 0xFC, 0x03,
  0xFF, 0x00, 0xFF, 0x80, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07,
  0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x07, 0xC0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x3E, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x01, 0xF0,
  0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x0F, 0x80, 0xFC,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x03, 0xE0, 0x3F, 0x00, 0xFF, 0xC0,
  0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x1F,
  0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x07, 0xFC, 0x03, 0xFF, 0x03, 0xEF, 0x81, 0xF7, 0xC1, 0xF1,
  0xE0, 0xF8, 0xF0, 0xF8, 0x78, 0x7C, 0x3E, 0x7C, 0x1F, 0x3E, 0x0F, 0xBE,
  0x07, 0xDF, 0x03, 0xFF, 0x81, 0xF0, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x00, 0xFE, 0x1F, 0x87, 0xF0,
  0xFC, 0x1F, 0x07, 0xE0, 0xF8, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFC,
  0x1F, 0xC7, 0xF0, 0x3F, 0x1F, 0x80, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x7F, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x87,
  0xFF, 0xFE, 0x3F, 0xC1, 0xF9, 0xFE, 0x0F, 0xE7, 0xE0, 0x3F, 0x3F, 0x80,
  0xFC, 0xFC, 0x03, 0xF3, 0xF0, 0x0F, 0xCF, 0xC0, 0x3F, 0x3F, 0x01, 0xFC,
  0xFE, 0x0F, 0xE3, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x3F,
  0xF7, 0xE0, 0x7F, 0x9F, 0xC0, 0x10, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE7, 0xF8, 0x07,
  0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x0F,
  0xF0, 0x7F, 0x0F, 0xE0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F,
  0xC0, 0x3F, 0x1F, 0xC0, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x1F,
  0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x3F, 0x80, 0x3F, 0x3F,
  0x00, 0x7F, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3F,
  0x00, 0xFE, 0x7F, 0x80, 0xFC, 0x7F, 0x81, 0xFC, 0x7F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xF8, 0x7E, 0xFF, 0xF0, 0xFC, 0xFF, 0xE0, 0xFC, 0x7F, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x1F,
  0xFF, 0x80, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x87, 0xF0, 0x7F, 0x0F, 0xC0,
  0x7E, 0x3F, 0x80, 0xFC, 0x7E, 0x00, 0xF8, 0xFC, 0x01, 0xF1, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x1F, 0x8F, 0xC0, 0x3E, 0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF8, 0x7F,
  0x07, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0xFF,
  0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x1F, 0xE3, 0xF0, 0x07, 0xFF, 0x7E, 0x01, 0xFF, 0xEF, 0xC0, 0x7F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x03, 0xF8, 0x3F, 0xE0, 0x7E, 0x03, 0xF8,
  0x1F, 0xC0, 0x3F, 0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x1F, 0xC0,
  0x1F, 0x83, 0xF0, 0x07, 0xF0, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x81,
  0xF8, 0x03, 0xF0, 0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xC1, 0xFC, 0x03,
  0xF8, 0x3F, 0x80, 0x7E, 0x07, 0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x0F,
  0xC0, 0x3F, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x07, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xDF, 0x80, 0x0F,
  0xF3, 0xF0, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x83,
  0xF8, 0x3F, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0x7C, 0x7E, 0x00, 0xFC, 0xFC,
  0x01, 0xF9, 0xF8, 0x03, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x80, 0x60, 0x7F, 0x81, 0xE0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFC,
  0x03, 0xFF, 0x80, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x7F, 0xFE, 0x1F, 0xFF, 0xC3,
  0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC0, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x1F, 0xE3, 0xF0, 0x1F,
  0xFC, 0xFC, 0x0F, 0xFF, 0xBE, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0,
  0xFF, 0x07, 0xF8, 0x3F, 0x80, 0xFE, 0x1F, 0xC0, 0x3F, 0x87, 0xE0, 0x0F,
  0xC1, 0xF8, 0x03, 0xF0, 0xFE, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0xC0,
  0x0F, 0xC3, 0xF0, 0x07, 0xF0, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x0F,
  0xC0, 0x1F, 0x83, 0xF0, 0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0xFC,
  0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x07, 0xF0, 0x3F, 0x83,
  0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF8, 0x01, 0xFE, 0x7E, 0x00, 0x04, 0x1F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF0, 0x08, 0x01, 0xFC, 0x03, 0x00, 0x7F, 0x01, 0xF0, 0x7F,
  0x80, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x00, 0x7F,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE7, 0xF8, 0x07, 0xFF, 0xFC,
  0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xF0, 0xFE,
  0x0F, 0xE0, 0x7E, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x7F, 0x0F, 0xC0, 0x7E,
  0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7E,
  0x1F, 0x80, 0x7E, 0x3F, 0x80, 0xFE, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC,
  0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x7F, 0x01, 0xFC,
  0x7E, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x7E, 0x01, 0xF8,
  0x7E, 0x01, 0xF8, 0xFE, 0x03, 0xF8, 0xFC, 0x03, 0xF0, 0x01, 0xE0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x83, 0xF8, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x0F, 0xE0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x9F, 0xC0, 0x1F, 0xF8,
  0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xE0, 0x3F, 0xC1, 0xF8, 0x1F, 0xE0, 0x7E, 0x0F, 0xF0,
  0x1F, 0x83, 0xF8, 0x07, 0xE1, 0xFC, 0x03, 0xF0, 0xFE, 0x00, 0xFC, 0x7F,
  0x00, 0x3F, 0x3F, 0xC0, 0x0F, 0xCF, 0xE0, 0x03, 0xF7, 0xF0, 0x01, 0xFF,
  0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x01,
  0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xF7, 0xE0,
  0x03, 0xF9, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC3,
  0xF8, 0x07, 0xF0, 0x7E, 0x01, 0xF8, 0x1F, 0xC0, 0x7E, 0x07, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x83, 0xF8, 0x07, 0xE0, 0xFC, 0x01, 0xFC,
  0x00, 0x01, 0xF8, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xF0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x3F, 0x81, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x81, 0xFC, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x0F,
  0xE0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x00, 0x40, 0x02,
  0x00, 0x3F, 0x3F, 0xC1, 0xFE, 0x01, 0xFF, 0xFF, 0x1F, 0xF8, 0x0F, 0xFF,
  0xF9, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFC,
  0x3F, 0xC3, 0xFF, 0x0F, 0xE1, 0xFC, 0x0F, 0xF0, 0x3F, 0x0F, 0xC0, 0x7F,
  0x01, 0xF8, 0x7E, 0x03, 0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0x80, 0x7E, 0x3F,
  0x80, 0xFC, 0x03, 0xF1, 0xF8, 0x07, 0xE0, 0x1F, 0x8F, 0xC0, 0x3F, 0x00,
  0xFC, 0x7E, 0x01, 0xF8, 0x0F, 0xE3, 0xF0, 0x1F, 0xC0, 0x7E, 0x1F, 0x80,
  0xFC, 0x03, 0xF1, 0xFC, 0x07, 0xE0, 0x1F, 0x8F, 0xC0, 0x3F, 0x00, 0xFC,
  0x7E, 0x01, 0xF8, 0x07, 0xE3, 0xF0, 0x0F, 0xC0, 0x7F, 0x1F, 0x80, 0xFE,
  0x03, 0xF0, 0xFC, 0x07, 0xE0, 0x1F, 0x8F, 0xE0, 0x3F, 0x00, 0xFC, 0x7E,
  0x01, 0xF8, 0x07, 0xE3, 0xF0, 0x0F, 0xC0, 0x3F, 0x1F, 0x80, 0x7E, 0x03,
  0xF8, 0xFC, 0x07, 0xF0, 0x1F, 0x87, 0xE0, 0x3F, 0x00, 0xFC, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xE7, 0xF8, 0x07, 0xFF, 0xFC,
  0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xF0, 0xFE,
  0x0F, 0xE0, 0x7E, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x7F, 0x0F, 0xC0, 0x7E,
  0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7E,
  0x1F, 0x80, 0x7E, 0x3F, 0x80, 0xFE, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC,
  0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x7F, 0x01, 0xFC,
  0x7E, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x7E, 0x01, 0xF8,
  0x7E, 0x01, 0xF8, 0xFE, 0x03, 0xF8, 0xFC, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFC, 0x0F, 0xE0, 0xFE, 0x1F, 0xC0, 0x7E, 0x1F, 0x80, 0x7E,
  0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0x7E,
  0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E,
  0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0xFE, 0x7E, 0x00, 0xFC,
  0x7E, 0x00, 0xFC, 0x7E, 0x01, 0xFC, 0x7F, 0x01, 0xF8, 0x3F, 0x07, 0xF0,
  0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x7F,
  0x80, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xF0, 0x3F, 0xC1, 0xFC, 0x0F, 0xE0, 0x3F, 0x03, 0xF0, 0x0F, 0xC0,
  0xFC, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x1F, 0xC0, 0x3F, 0x07, 0xE0, 0x0F,
  0xC1, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x07, 0xE0,
  0x0F, 0xC3, 0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xFC, 0x3F, 0x00, 0x7E, 0x0F,
  0xC0, 0x1F, 0x83, 0xF0, 0x07, 0xE0, 0xFC, 0x03, 0xF8, 0x7F, 0x01, 0xFC,
  0x1F, 0xE0, 0xFF, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF0, 0x3F, 0xBF, 0xF8, 0x0F, 0xC7, 0xF8, 0x03, 0xF0, 0x30, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x8F, 0x80, 0xFF, 0xE7, 0xC0, 0xFF, 0xF7, 0xE0, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xF8, 0x7F, 0x03, 0xFC, 0x3F, 0x01, 0xFC, 0x3F, 0x80, 0x7E,
  0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x8F, 0xE0, 0x0F, 0xC7, 0xE0, 0x0F,
  0xE3, 0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x7E, 0x00,
  0xFC, 0x3F, 0x00, 0x7E, 0x3F, 0x80, 0x7F, 0x1F, 0xC0, 0x3F, 0x0F, 0xE0,
  0x1F, 0x83, 0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0xFC, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0x00, 0x7F, 0xBF, 0x80, 0x02, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFB, 0xF0, 0x7F, 0xFC,
  0x1F, 0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xC0, 0x0F,
  0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF8, 0x3F, 0xDF, 0xE1, 0xFC, 0x1F, 0x87, 0xE0, 0x7F, 0x1F,
  0x80, 0xFC, 0x7E, 0x03, 0xF1, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF3, 0xF0,
  0x0F, 0xCF, 0xC0, 0x3F, 0x3F, 0x01, 0xF8, 0xFC, 0x0F, 0xE1, 0xFC, 0xFF,
  0x87, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x1F, 0xF0, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x3F, 0xFF, 0x7F, 0xFD, 0xFF, 0xFB, 0xFF, 0xF7,
  0xFF, 0xE0, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0xE0, 0x7F, 0xC0, 0x7F, 0x80, 0xFF, 0x00, 0xFE, 0x00, 0x20,
  0x00, 0x1F, 0x80, 0x7E, 0x3F, 0x00, 0xFC, 0x7E, 0x01, 0xF8, 0xFC, 0x03,
  0xF3, 0xF8, 0x0F, 0xE7, 0xE0, 0x1F, 0x8F, 0xC0, 0x3F, 0x1F, 0x80, 0x7E,
  0x3F, 0x00, 0xFC, 0x7E, 0x01, 0xF9, 0xFC, 0x07, 0xF3, 0xF0, 0x0F, 0xC7,
  0xE0, 0x1F, 0x8F, 0xC0, 0x3F, 0x1F, 0x80, 0x7E, 0x3F, 0x01, 0xFC, 0xFE,
  0x03, 0xF1, 0xF8, 0x07, 0xE3, 0xF0, 0x0F, 0xC7, 0xE0, 0x1F, 0x8F, 0xC0,
  0x3F, 0x1F, 0x80, 0xFE, 0x3F, 0x01, 0xF8, 0x7F, 0x0F, 0xF0, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x81, 0xFF, 0xBF, 0x01, 0xFE, 0x7C,
  0x00, 0x60, 0x00, 0x00, 0xFC, 0x01, 0xFB, 0xF0, 0x0F, 0xEF, 0xC0, 0x3F,
  0x3F, 0x00, 0xFC, 0x7C, 0x07, 0xF1, 0xF8, 0x1F, 0x87, 0xE0, 0x7E, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x7E, 0x07, 0xE1, 0xF8, 0x1F, 0x87,
  0xE0, 0x3E, 0x3F, 0x00, 0xF8, 0xFC, 0x03, 0xE3, 0xE0, 0x0F, 0x9F, 0x80,
  0x3E, 0x7C, 0x00, 0xFB, 0xF0, 0x03, 0xEF, 0xC0, 0x0F, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x03, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0x7C, 0x07, 0xE0, 0x7E,
  0x7C, 0x0F, 0xE0, 0x7E, 0x7C, 0x0F, 0xE0, 0x7E, 0x7C, 0x0F, 0xE0, 0xFC,
  0x7C, 0x1F, 0xE0, 0xFC, 0x7C, 0x1F, 0xE0, 0xF8, 0x7C, 0x3F, 0xE1, 0xF8,
  0x7C, 0x3F, 0xE1, 0xF8, 0x7C, 0x3F, 0xE1, 0xF0, 0x7C, 0x7D, 0xE3, 0xF0,
  0x7C, 0x7D, 0xE3, 0xF0, 0x7C, 0xF9, 0xE3, 0xE0, 0x7C, 0xF9, 0xF7, 0xE0,
  0x7D, 0xF1, 0xF7, 0xC0, 0x7D, 0xF1, 0xFF, 0xC0, 0x7D, 0xF1, 0xFF, 0xC0,
  0x7F, 0xE1, 0xFF, 0x80, 0x7F, 0xE1, 0xFF, 0x80, 0x7F, 0xC1, 0xFF, 0x00,
  0x7F, 0xC1, 0xFF, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x7F, 0x80, 0xFE, 0x00,
  0x3F, 0x80, 0xFE, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0xFC, 0x00,
  0x3E, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x1F, 0xC0,
  0x7E, 0x03, 0xF8, 0x0F, 0xE0, 0xFE, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x87,
  0xF0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x3F, 0x80, 0x07, 0xEF, 0xE0, 0x00,
  0xFD, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xE7, 0xE0, 0x01, 0xF8,
  0xFC, 0x00, 0x7F, 0x1F, 0x80, 0x1F, 0xC1, 0xF8, 0x03, 0xF0, 0x3F, 0x00,
  0xFE, 0x07, 0xE0, 0x3F, 0x80, 0xFE, 0x07, 0xF0, 0x0F, 0xC0, 0x07, 0xE0,
  0x0F, 0xC0, 0xFC, 0x03, 0xF8, 0x1F, 0xC0, 0x7F, 0x03, 0xF8, 0x0F, 0xC0,
  0x3F, 0x03, 0xF8, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x1F, 0xC0, 0x1F, 0x83,
  0xF0, 0x03, 0xF0, 0xFE, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x01,
  0xF8, 0xFC, 0x00, 0x3F, 0x1F, 0x80, 0x03, 0xE7, 0xF0, 0x00, 0x7C, 0xFC,
  0x00, 0x0F, 0x9F, 0x80, 0x01, 0xF7, 0xE0, 0x00, 0x3E, 0xFC, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0x80, 0x03,
  0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x7F,
  0x80, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xF0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x08,
  0x00, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x1F, 0x03, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x81, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0xF8, 0x1F, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x07, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x03, 0xE0,
  0x7C, 0x0F, 0x01, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x70, 0x00, 0x7C, 0x00,
  0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x07, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x04, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0xF1, 0xFF, 0xC0, 0x7C, 0x7F, 0xF0, 0x1F, 0x3F,
  0xFE, 0x07, 0xCF, 0xDF, 0xC3, 0xE7, 0xE1, 0xFD, 0xF9, 0xF0, 0x7F, 0xFC,
  0x7C, 0x0F, 0xFF, 0x3E, 0x01, 0xFF, 0x8F, 0x80, 0x3F, 0xC0, 0x00, 0x03,
  0xE0,
};

const GFXglyph RobotoCondensed_MediumItalic55pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 13, 40, 14, 1, -39 },
  { 66, 15, 14, 17, 4, -41 },
  { 93, 27, 39, 29, 2, -39 },
  { 225, 24, 52, 27, 2, -46 },
  { 381, 26, 41, 34, 5, -40 },
  { 515, 27, 41, 30, 1, -40 },
  { 654, 7, 14, 9, 4, -41 },
  { 667, 16, 56, 17, 3, -44 },
  { 779, 17, 56, 17, -3, -44 },
  { 898, 22, 23, 24, 3, -39 },
  { 962, 23, 29, 26, 2, -33 },
  { 1046, 10, 15, 12, -3, -6 },
  { 1065, 13, 5, 16, 2, -19 },
  { 1074, 8, 8, 15, 1, -7 },
  { 1082, 24, 42, 19, -3, -39 },
  { 1208, 23, 41, 27, 2, -40 },
  { 1326, 16, 39, 27, 6, -39 },
  { 1404, 26, 40, 27, 0, -40 },
  { 1534, 24, 41, 27, 1, -40 },
  { 1657, 24, 39, 27, 1, -39 },
  { 1774, 25, 40, 27, 2, -39 },
  { 1899, 21, 40, 27, 3, -39 },
  { 2004, 25, 39, 27, 3, -39 },
  { 2126, 24, 41, 27, 2, -40 },
  { 2249, 21, 40, 27, 4, -40 },
  { 2354, 12, 31, 14, 1, -30 },
  { 2401, 15, 39, 13, -3, -30 },
  { 2475, 22, 25, 24, 1, -30 },
  { 2544, 23, 16, 26, 2, -26 },
  { 2590, 22, 25, 24, 1, -29 },
  { 2659, 20, 41, 23, 4, -40 },
  { 2762, 38, 50, 41, 1, -38 },
  { 3000, 30, 39, 31, -2, -39 },
  { 3147, 28, 39, 30, 1, -39 },
  { 3284, 28, 41, 30, 2, -40 },
  { 3428, 28, 39, 30, 1, -39 },
  { 3565, 28, 39, 26, 1, -39 },
  { 3702, 27, 39, 26, 1, -39 },
  { 3834, 28, 41, 31, 2, -40 },
  { 3978, 32, 39, 33, 1, -39 },
  { 4134, 13, 39, 14, 1, -39 },
  { 4198, 27, 40, 26, 0, -39 },
  { 4333, 32, 39, 29, 1, -39 },
  { 4489, 21, 39, 25, 1, -39 },
  { 4592, 40, 39, 40, 1, -39 },
  { 4787, 32, 39, 33, 1, -39 },
  { 4943, 29, 41, 32, 2, -40 },
  { 5092, 29, 39, 30, 1, -39 },
  { 5234, 29, 47, 32, 2, -40 },
  { 5405, 28, 39, 29, 1, -39 },
  { 5542, 28, 41, 28, 1, -40 },
  { 5686, 27, 39, 28, 4, -39 },
  { 5818, 29, 40, 30, 2, -39 },
  { 5963, 29, 39, 30, 4, -39 },
  { 6105, 38, 39, 40, 5, -39 },
  { 6291, 33, 39, 30, -1, -39 },
  { 6452, 27, 39, 29, 5, -39 },
  { 6584, 31, 39, 28, -1, -39 },
  { 6736, 18, 54, 14, -1, -45 },
  { 6858, 12, 42, 20, 5, -39 },
  { 6921, 18, 54, 14, -3, -45 },
  { 7043, 17, 20, 20, 2, -39 },
  { 7086, 21, 5, 21, -3, 0 },
  { 7100, 10, 8, 17, 6, -41 },
  { 7110, 22, 31, 25, 1, -30 },
  { 7196, 24, 42, 26, 0, -41 },
  { 7322, 23, 31, 25, 1, -30 },
  { 7412, 27, 42, 26, 1, -41 },
  { 7554, 23, 31, 25, 1, -30 },
  { 7644, 19, 42, 17, 2, -42 },
  { 7744, 26, 41, 27, 0, -30 },
  { 7878, 24, 41, 26, 0, -41 },
  { 8001, 12, 40, 13, 1, -40 },
  { 8061, 19, 51, 13, -6, -40 },
  { 8183, 26, 41, 25, 0, -41 },
  { 8317, 13, 41, 13, 1, -41 },
  { 8384, 37, 30, 40, 0, -30 },
  { 8523, 24, 30, 26, 0, -30 },
  { 8613, 24, 31, 27, 1, -30 },
  { 8706, 26, 41, 26, -2, -30 },
  { 8840, 25, 41, 27, 1, -30 },
  { 8969, 18, 30, 17, 0, -30 },
  { 9037, 22, 31, 24, 1, -30 },
  { 9123, 15, 37, 16, 2, -36 },
  { 9193, 23, 30, 26, 2, -29 },
  { 9280, 22, 29, 23, 3, -29 },
  { 9360, 32, 29, 34, 3, -29 },
  { 9476, 27, 29, 24, -2, -29 },
  { 9574, 27, 40, 23, -2, -29 },
  { 9709, 25, 29, 24, -1, -29 },
  { 9800, 17, 53, 16, 1, -43 },
  { 9913, 11, 46, 13, 1, -39 },
  { 9977, 17, 53, 16, -2, -43 },
  { 10090, 26, 12, 31, 2, -22 },
};

const GFXfont RobotoCondensed_MediumItalic55pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_MediumItalic55pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_MediumItalic55pt7bGlyphs,
  0x20, 0x7E, 64
};

#endif // _ROBOTOCONDENSED_MEDIUMITALIC55PT7B_H_
