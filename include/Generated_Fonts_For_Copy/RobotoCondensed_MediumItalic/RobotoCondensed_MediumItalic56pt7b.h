#ifndef _ROBOTOCONDENSED_MEDIUMITALIC56PT7B_H_
#define _ROBOTOCONDENSED_MEDIUMITALIC56PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-MediumItalic.ttf
// Size: 56pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_MediumItalic56pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xF8, 0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x3F, 0x81, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x07,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0xFC, 0x0F,
  0xE0, 0x7F, 0x01, 0xF8, 0x0F, 0x80, 0x10, 0x00, 0x3E, 0x3E, 0x7C, 0x7C,
  0xF8, 0xF9, 0xF1, 0xF3, 0xC3, 0xC7, 0x87, 0x8F, 0x1F, 0x3E, 0x3E, 0x78,
  0x78, 0xF0, 0xF1, 0xE1, 0xE3, 0xC3, 0xC7, 0x07, 0x1E, 0x1E, 0x00, 0x00,
  0x03, 0xC3, 0xE0, 0x00, 0x7C, 0x3C, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x78,
  0x7C, 0x00, 0x07, 0x87, 0x80, 0x00, 0xF8, 0x78, 0x00, 0x0F, 0x0F, 0x80,
  0x00, 0xF0, 0xF0, 0x00, 0x1F, 0x0F, 0x00, 0x01, 0xE1, 0xF0, 0x00, 0x1E,
  0x1F, 0x00, 0x03, 0xE1, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x00, 0x78, 0x7C, 0x00, 0x0F,
  0x87, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x0F, 0x80, 0x01, 0xF0, 0xF0,
  0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE1, 0xF0, 0x00, 0x3E, 0x1E, 0x00, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xE0, 0x07, 0x87, 0xC0, 0x00, 0xF8, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x00,
  0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x1E, 0x1F,
  0x00, 0x01, 0xE1, 0xE0, 0x00, 0x3E, 0x1E, 0x00, 0x03, 0xC3, 0xE0, 0x00,
  0x3C, 0x3C, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xFC, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xF8, 0xFE, 0x07, 0xF0,
  0x7F, 0x07, 0xE0, 0x3F, 0x0F, 0xE0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0,
  0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xFC, 0xFC, 0x01, 0xFC, 0xFC, 0x01, 0xFC, 0xFC, 0x01,
  0xF8, 0xFC, 0x01, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0x7F, 0x0F,
  0xF0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0x0F, 0x01, 0x87, 0x83, 0xC0, 0x71, 0xE0, 0xF0, 0x3E,
  0xF8, 0x3C, 0x1F, 0x3E, 0x0F, 0x07, 0x8F, 0x83, 0xC3, 0xE3, 0xC0, 0xF1,
  0xF0, 0xF0, 0x3C, 0x78, 0x3E, 0x1F, 0x3C, 0x0F, 0x87, 0x9F, 0x01, 0xF7,
  0xE7, 0x80, 0x7F, 0xF3, 0xC0, 0x0F, 0xF9, 0xF0, 0x01, 0xFC, 0x78, 0x00,
  0x08, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xF3, 0xF8, 0x00, 0xF9, 0xFF, 0x00, 0x3C, 0xFF, 0xE0, 0x1F,
  0x7E, 0xF8, 0x0F, 0x9E, 0x1F, 0x03, 0xCF, 0x83, 0xC1, 0xF3, 0xC0, 0xF0,
  0xF8, 0xF0, 0x3C, 0x3C, 0x3C, 0x0F, 0x1E, 0x0F, 0x03, 0xCF, 0x83, 0xC1,
  0xF3, 0xC0, 0xF0, 0x7D, 0xE0, 0x3C, 0x1E, 0x38, 0x0F, 0x0F, 0x84, 0x03,
  0xF7, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00,
  0x7F, 0x1F, 0x80, 0x0F, 0xC1, 0xF0, 0x03, 0xF0, 0x3E, 0x00, 0x7E, 0x07,
  0xC0, 0x0F, 0xC0, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x07,
  0xE1, 0xF8, 0x00, 0xFC, 0x7F, 0x00, 0x0F, 0xDF, 0xC0, 0x01, 0xFF, 0xF0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0xF8, 0x7F, 0xFC, 0x3F,
  0x1F, 0xDF, 0x87, 0xE7, 0xF3, 0xF8, 0xF9, 0xFC, 0x3F, 0x9F, 0x3F, 0x87,
  0xF7, 0xE7, 0xE0, 0x7F, 0xFD, 0xFC, 0x0F, 0xFF, 0x3F, 0x80, 0xFF, 0xE7,
  0xF0, 0x1F, 0xF8, 0xFE, 0x01, 0xFF, 0x0F, 0xC0, 0x3F, 0xC1, 0xFC, 0x03,
  0xF8, 0x3F, 0x81, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFC, 0xFC, 0x07, 0xFE, 0x1F, 0xC0, 0x0C, 0x00,
  0x00, 0x3E, 0x7C, 0xF9, 0xF7, 0xCF, 0x9F, 0x3E, 0x78, 0xF3, 0xE7, 0xCF,
  0x9E, 0x00, 0x00, 0x01, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x03, 0xF0, 0x03,
  0xF0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00,
  0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0E,
  0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x07,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00,
  0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xF8,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xE0, 0x00,
  0x70, 0x00, 0x10, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x3C, 0x1E, 0x0E, 0x7E, 0x3C, 0xFD, 0xFF, 0x7F, 0xFB, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xE0, 0x7F, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x07, 0xDE, 0x00, 0x1F, 0x3E, 0x00, 0x7E, 0x3C, 0x01,
  0xF8, 0x7C, 0x07, 0xE0, 0xFC, 0x07, 0x80, 0xF8, 0x06, 0x01, 0xC0, 0x04,
  0x01, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x03, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFC, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xC0, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xE0,
  0xFC, 0x1F, 0x87, 0xE0, 0xF8, 0x3F, 0x0F, 0xC0, 0xF0, 0x0C, 0x00, 0x7F,
  0xFB, 0xFF, 0xFF, 0xFD, 0xFF, 0xEF, 0xFF, 0x00, 0x3C, 0x7E, 0x7F, 0xFF,
  0xFF, 0x7E, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0xFF, 0xFF,
  0x83, 0xF8, 0x7F, 0x07, 0xE0, 0x7E, 0x1F, 0x80, 0x7C, 0x3F, 0x00, 0xFC,
  0xFC, 0x01, 0xF9, 0xF8, 0x03, 0xF3, 0xF0, 0x07, 0xE7, 0xE0, 0x0F, 0xDF,
  0xC0, 0x1F, 0xBF, 0x00, 0x3F, 0x7E, 0x00, 0xFE, 0xFC, 0x01, 0xFD, 0xF8,
  0x03, 0xF3, 0xF0, 0x07, 0xEF, 0xE0, 0x0F, 0xDF, 0xC0, 0x1F, 0xBF, 0x00,
  0x3F, 0x7E, 0x00, 0xFE, 0xFC, 0x01, 0xF9, 0xF8, 0x03, 0xF3, 0xF0, 0x07,
  0xE7, 0xE0, 0x0F, 0xCF, 0xC0, 0x1F, 0x9F, 0x80, 0x7E, 0x3F, 0x00, 0xFC,
  0x7E, 0x01, 0xF8, 0xFC, 0x03, 0xE1, 0xF8, 0x0F, 0xC3, 0xF0, 0x3F, 0x87,
  0xF0, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0x00, 0x00, 0x00, 0x03, 0x00, 0x1F,
  0x00, 0x7F, 0x03, 0xFE, 0x0F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE,
  0x7F, 0x7E, 0x78, 0xFC, 0xE0, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x01, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8,
  0x03, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0,
  0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x1F, 0xC0, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0,
  0x3F, 0x83, 0xF8, 0x0F, 0xC0, 0x7F, 0x07, 0xF0, 0x1F, 0xC1, 0xF8, 0x07,
  0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x0F, 0xC0, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xF8, 0x1F, 0xC1, 0xFC, 0x1F, 0xC0, 0x7E, 0x0F, 0xE0, 0x3F, 0x87, 0xE0,
  0x1F, 0xC3, 0xF0, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE3, 0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xF8, 0xFE, 0x01,
  0xFC, 0x7F, 0x00, 0xFC, 0x1F, 0x80, 0xFE, 0x0F, 0xE0, 0xFE, 0x07, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07,
  0xFF, 0x00, 0x07, 0xDF, 0x80, 0x07, 0xEF, 0xC0, 0x03, 0xEF, 0xE0, 0x03,
  0xF7, 0xE0, 0x03, 0xF3, 0xF0, 0x01, 0xF1, 0xF8, 0x01, 0xF8, 0xFC, 0x01,
  0xF8, 0xFE, 0x00, 0xF8, 0x7F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x1F, 0x80,
  0x7C, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xF0, 0x7F, 0x03, 0xF8,
  0x3F, 0x01, 0xF8, 0x3F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFC,
  0xFF, 0x00, 0xF8, 0x1F, 0xC0, 0x08, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC7, 0xE0, 0x07, 0xE3, 0xF0, 0x07, 0xF1,
  0xFC, 0x03, 0xF0, 0x7E, 0x03, 0xF8, 0x3F, 0x01, 0xFC, 0x1F, 0xC1, 0xFC,
  0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0xC0, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF3,
  0xF0, 0x0F, 0xDF, 0xF0, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0x1F, 0xF1, 0xFE, 0xFF, 0x03, 0xFB, 0xFC, 0x07, 0xEF, 0xE0, 0x1F, 0xBF,
  0x00, 0x7E, 0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xEF, 0xC0, 0x1F, 0xBF, 0x00,
  0x7E, 0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xEF, 0xC0, 0x3F, 0xBF, 0x00, 0xFC,
  0xFC, 0x03, 0xF1, 0xF8, 0x1F, 0xC7, 0xF0, 0xFE, 0x1F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xC0, 0x7F, 0xFE, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0xC0,
  0x00, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xFC, 0x03,
  0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xE0, 0x7F, 0x0F,
  0xE0, 0x7F, 0x0F, 0xE0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F,
  0xC0, 0x7F, 0x0F, 0xC0, 0x7F, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0xFE, 0x07,
  0xE0, 0xFC, 0x07, 0xF3, 0xFC, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x3F, 0xC7, 0xF0, 0x3F,
  0x03, 0xF0, 0x7F, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0xFE, 0x01, 0xF8, 0xFC,
  0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC,
  0x03, 0xF8, 0xFC, 0x03, 0xF8, 0xFE, 0x07, 0xF0, 0x7F, 0x0F, 0xF0, 0x7F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x3F,
  0xFC, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC1, 0xFC, 0x3F,
  0x0F, 0xE0, 0xFE, 0x3F, 0x01, 0xF9, 0xFC, 0x07, 0xE7, 0xE0, 0x1F, 0x9F,
  0x80, 0x7E, 0xFE, 0x01, 0xFB, 0xF0, 0x07, 0xEF, 0xC0, 0x1F, 0xBF, 0x00,
  0x7E, 0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xEF, 0xC0, 0x1F, 0xBF, 0x80, 0xFE,
  0xFE, 0x03, 0xF9, 0xF8, 0x1F, 0xC7, 0xF1, 0xFF, 0x1F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFE, 0x01, 0xF9, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x1F, 0xFF, 0x00, 0x7F, 0xF8, 0x01, 0xFF,
  0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0,
  0x7E, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0x7E, 0x07, 0xE0, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x7E, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0x7E, 0x07, 0xE0, 0x10, 0x00, 0x00, 0x38, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x04, 0x00, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x01, 0xC0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFF,
  0x00, 0x1F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF,
  0xE0, 0x3F, 0xF8, 0x01, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x80, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xE0, 0x04, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xF0, 0x00,
  0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xC0, 0x1F, 0xFE,
  0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x7F,
  0xF0, 0x01, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0x60, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x81,
  0xFF, 0xFC, 0x1F, 0xFF, 0xE3, 0xFF, 0xFE, 0x7F, 0x8F, 0xE7, 0xF0, 0x7F,
  0x7E, 0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x01,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00,
  0x3F, 0x00, 0x00, 0x78, 0x00, 0xFC, 0x00, 0x00, 0x78, 0x01, 0xF0, 0x00,
  0x00, 0xF0, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x1F, 0x00, 0x00, 0x01, 0xE0,
  0x3C, 0x00, 0xFC, 0x03, 0xC0, 0xF8, 0x07, 0xFC, 0x07, 0x81, 0xE0, 0x1F,
  0xFE, 0x0F, 0x07, 0xC0, 0x7F, 0xFC, 0x0E, 0x0F, 0x01, 0xF8, 0xF8, 0x1C,
  0x3E, 0x07, 0xE1, 0xF0, 0x38, 0x78, 0x0F, 0x83, 0xE0, 0x70, 0xF0, 0x3E,
  0x07, 0xC0, 0xE3, 0xE0, 0x78, 0x0F, 0x03, 0xC7, 0x81, 0xF0, 0x3E, 0x07,
  0x8F, 0x03, 0xE0, 0x7C, 0x0F, 0x3E, 0x0F, 0x80, 0xF8, 0x1E, 0x7C, 0x1F,
  0x01, 0xE0, 0x3C, 0xF0, 0x3E, 0x07, 0xC0, 0x79, 0xE0, 0x7C, 0x0F, 0x80,
  0xF3, 0xC1, 0xF8, 0x1F, 0x03, 0xC7, 0x83, 0xE0, 0x3C, 0x07, 0x9F, 0x07,
  0xC0, 0x78, 0x0F, 0x3E, 0x0F, 0x81, 0xF0, 0x1C, 0x7C, 0x1F, 0x03, 0xE0,
  0x78, 0xF8, 0x3E, 0x0F, 0xC0, 0xF1, 0xF0, 0x7C, 0x1F, 0x83, 0xC3, 0xE0,
  0xFC, 0x7F, 0x0F, 0x87, 0xC0, 0xFF, 0xFF, 0x3E, 0x07, 0x81, 0xFF, 0xBF,
  0xF8, 0x0F, 0x03, 0xFE, 0x7F, 0xE0, 0x1E, 0x03, 0xF8, 0x7F, 0x80, 0x3C,
  0x00, 0x80, 0x10, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0xC0, 0x00, 0x03, 0xFC, 0x0F,
  0x80, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xDF, 0x00,
  0x00, 0x3F, 0x7C, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x07, 0xE7, 0xC0, 0x00,
  0x1F, 0x9F, 0x80, 0x00, 0xFC, 0x7E, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x1F,
  0x87, 0xE0, 0x00, 0x7E, 0x1F, 0x80, 0x03, 0xF0, 0x7E, 0x00, 0x0F, 0xC0,
  0xF8, 0x00, 0x7F, 0x03, 0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0xE0, 0x3F,
  0x00, 0x3F, 0x00, 0xFC, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x83, 0xF8, 0x00, 0x7E, 0x1F, 0xC0,
  0x01, 0xF8, 0x7F, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x1F, 0x8F, 0xE0, 0x00,
  0x7F, 0x3F, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x3F, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFE, 0x03, 0xF0, 0x0F, 0xF0, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xF0,
  0x7F, 0x00, 0x7F, 0x07, 0xE0, 0x07, 0xF0, 0x7E, 0x00, 0x7F, 0x0F, 0xE0,
  0x07, 0xF0, 0xFE, 0x00, 0x7E, 0x0F, 0xE0, 0x0F, 0xE0, 0xFC, 0x01, 0xFC,
  0x0F, 0xC0, 0x7F, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0x80, 0x7F,
  0x01, 0xF8, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0x83, 0xF8, 0x01, 0xF8, 0x3F,
  0x80, 0x1F, 0x83, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0x83, 0xF0, 0x01,
  0xF8, 0x7F, 0x00, 0x3F, 0x87, 0xF0, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x07,
  0xE0, 0x0F, 0xF0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xF0,
  0x3F, 0x80, 0xFF, 0x00, 0xFE, 0x07, 0xF0, 0x03, 0xF0, 0x7F, 0x00, 0x1F,
  0x83, 0xF0, 0x00, 0xFC, 0x3F, 0x80, 0x07, 0xF1, 0xFC, 0x00, 0x3F, 0x8F,
  0xC0, 0x01, 0xFC, 0x7E, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x01, 0xFC, 0x3F, 0x00, 0x0F,
  0xE1, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x83,
  0xF8, 0x01, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x83, 0xFC, 0x01, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xF0, 0x1F, 0xE0, 0x7F, 0x00,
  0xFE, 0x07, 0xF0, 0x07, 0xE0, 0x7F, 0x00, 0x7F, 0x07, 0xE0, 0x03, 0xF0,
  0x7E, 0x00, 0x3F, 0x0F, 0xE0, 0x03, 0xF0, 0xFE, 0x00, 0x3F, 0x0F, 0xE0,
  0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x7F,
  0x1F, 0xC0, 0x07, 0xF1, 0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xF1, 0xF8,
  0x00, 0x7E, 0x1F, 0x80, 0x07, 0xE1, 0xF8, 0x00, 0x7E, 0x3F, 0x80, 0x0F,
  0xE3, 0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x3F,
  0x00, 0x1F, 0xC3, 0xF0, 0x01, 0xF8, 0x7F, 0x00, 0x3F, 0x87, 0xF0, 0x07,
  0xF0, 0x7F, 0x00, 0xFF, 0x07, 0xE0, 0x1F, 0xE0, 0x7F, 0xDF, 0xFC, 0x07,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFE, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xE1,
  0xFC, 0x00, 0x7F, 0x1F, 0x80, 0x07, 0xF3, 0xF8, 0x00, 0x7F, 0x3F, 0x80,
  0x03, 0xF3, 0xF0, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x3F, 0xFC, 0xFE, 0x03, 0xFF,
  0xCF, 0xE0, 0x7F, 0xFC, 0xFC, 0x07, 0xFF, 0xCF, 0xC0, 0x7F, 0xFC, 0xFC,
  0x00, 0x1F, 0xCF, 0xC0, 0x01, 0xFC, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x01,
  0xF8, 0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x87,
  0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x07, 0xFC, 0x1F, 0xF0, 0x3F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0x81,
  0xFC, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x07, 0xE0,
  0x3F, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x0F, 0xC0, 0x01, 0xFC,
  0x0F, 0xE0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x3F,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F,
  0xE0, 0x7F, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x03, 0xF0, 0x1F, 0x80, 0x01,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7E, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x07, 0xF0, 0x3F, 0x80,
  0x03, 0xF8, 0x1F, 0xC0, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0xFC, 0x07, 0xE0,
  0x00, 0x7E, 0x03, 0xF0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3F, 0x81, 0xFC,
  0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x07, 0xE0, 0x3F,
  0x00, 0x03, 0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x0F, 0xC0, 0x01, 0xFC, 0x0F,
  0xE0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x3F, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F,
  0x81, 0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7E, 0x03, 0xF0, 0x1F,
  0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x0F, 0xE0, 0x0F, 0xC1, 0xFC,
  0x01, 0xF8, 0x3F, 0x80, 0x7F, 0x03, 0xF0, 0x0F, 0xE0, 0x7E, 0x03, 0xF8,
  0x0F, 0xE0, 0x7F, 0x01, 0xFE, 0x3F, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0xFF,
  0x00, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0x00, 0x7F, 0x80, 0x3F, 0x00, 0x7F,
  0x80, 0x1F, 0x80, 0x7F, 0x80, 0x0F, 0xC0, 0x7F, 0x80, 0x0F, 0xE0, 0x7F,
  0x80, 0x07, 0xF0, 0x3F, 0xC0, 0x03, 0xF8, 0x3F, 0xC0, 0x01, 0xF8, 0x3F,
  0xC0, 0x00, 0xFC, 0x3F, 0xC0, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0x7F, 0x1F,
  0xC0, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x1F, 0x9F, 0xE0, 0x00, 0x0F, 0xDF,
  0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x3F, 0xEF, 0xE0, 0x00, 0x3F, 0xE7, 0xF0, 0x00, 0x1F,
  0xF1, 0xF8, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x03,
  0xF0, 0x1F, 0xC0, 0x01, 0xF8, 0x0F, 0xE0, 0x01, 0xFC, 0x07, 0xF0, 0x00,
  0xFE, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x7F, 0x00,
  0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF8,
  0x07, 0xF0, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x7F,
  0x80, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x00, 0x7F, 0xE0,
  0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x0F, 0xFC,
  0x00, 0x1F, 0xF8, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x07, 0xFF, 0x00, 0x0F,
  0xFE, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x80,
  0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0xFD, 0xF0, 0x03, 0xFF, 0xC0, 0x7E, 0xF8,
  0x01, 0xFF, 0xE0, 0x3F, 0x7C, 0x00, 0xFB, 0xF0, 0x1F, 0xBF, 0x00, 0xFD,
  0xF8, 0x0F, 0xDF, 0x80, 0x7C, 0xFC, 0x07, 0xE7, 0xC0, 0x7E, 0xFE, 0x07,
  0xF3, 0xE0, 0x3E, 0x7E, 0x03, 0xF1, 0xF0, 0x3F, 0x3F, 0x01, 0xF8, 0xF8,
  0x1F, 0x1F, 0x80, 0xFC, 0x7C, 0x1F, 0x8F, 0xC0, 0x7E, 0x3E, 0x0F, 0x8F,
  0xE0, 0x3F, 0x1F, 0x0F, 0xC7, 0xF0, 0x3F, 0x87, 0xC7, 0xC3, 0xF0, 0x1F,
  0xC3, 0xE3, 0xE1, 0xF8, 0x0F, 0xE1, 0xF3, 0xF0, 0xFC, 0x07, 0xE0, 0xF9,
  0xF0, 0xFE, 0x03, 0xF0, 0x7D, 0xF8, 0x7F, 0x01, 0xF8, 0x3E, 0xF8, 0x3F,
  0x01, 0xFC, 0x1F, 0xFC, 0x1F, 0x80, 0xFE, 0x0F, 0xFC, 0x0F, 0xC0, 0x7F,
  0x03, 0xFE, 0x0F, 0xE0, 0x3F, 0x01, 0xFE, 0x07, 0xF0, 0x1F, 0x80, 0xFF,
  0x03, 0xF8, 0x0F, 0xC0, 0x7F, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFC,
  0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0x01, 0xF8,
  0x07, 0xC0, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x1F,
  0xC0, 0xFF, 0x00, 0x0F, 0xC0, 0x7F, 0x80, 0x07, 0xE0, 0x3F, 0xC0, 0x03,
  0xF0, 0x1F, 0xF0, 0x03, 0xF8, 0x0F, 0xF8, 0x01, 0xFC, 0x0F, 0xFC, 0x00,
  0xFE, 0x07, 0xFE, 0x00, 0x7E, 0x03, 0xFF, 0x80, 0x3F, 0x01, 0xFF, 0xC0,
  0x1F, 0x80, 0xFF, 0xE0, 0x1F, 0xC0, 0xFE, 0xF8, 0x0F, 0xE0, 0x7F, 0x7C,
  0x07, 0xF0, 0x3F, 0xBE, 0x03, 0xF0, 0x1F, 0x9F, 0x81, 0xF8, 0x0F, 0xC7,
  0xC0, 0xFC, 0x07, 0xE3, 0xE0, 0xFE, 0x07, 0xF1, 0xF0, 0x7F, 0x03, 0xF8,
  0x7C, 0x3F, 0x81, 0xFC, 0x3E, 0x1F, 0x80, 0xFC, 0x1F, 0x0F, 0xC0, 0x7E,
  0x0F, 0xC7, 0xE0, 0x3F, 0x03, 0xE7, 0xF0, 0x3F, 0x81, 0xF3, 0xF8, 0x1F,
  0xC0, 0xFD, 0xF8, 0x0F, 0xE0, 0x3E, 0xFC, 0x07, 0xE0, 0x1F, 0x7E, 0x03,
  0xF0, 0x0F, 0xBF, 0x01, 0xF8, 0x03, 0xFF, 0x81, 0xFC, 0x01, 0xFF, 0xC0,
  0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0x00, 0x7F, 0xE0, 0x3F, 0x00, 0x1F, 0xF0,
  0x1F, 0x80, 0x0F, 0xF8, 0x0F, 0xC0, 0x07, 0xFC, 0x0F, 0xE0, 0x01, 0xFE,
  0x07, 0xF0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00,
  0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x07, 0xFC,
  0x1F, 0xE0, 0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xE1, 0xFC, 0x00, 0x7F,
  0x1F, 0xC0, 0x07, 0xF1, 0xF8, 0x00, 0x3F, 0x3F, 0x80, 0x03, 0xF3, 0xF0,
  0x00, 0x3F, 0x3F, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x3F, 0x7F, 0x00, 0x03,
  0xF7, 0xE0, 0x00, 0x7F, 0x7E, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x7F, 0x7E,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7E, 0xFE, 0x00, 0x07, 0xEF, 0xE0, 0x00,
  0x7E, 0xFC, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0xFE, 0xFC, 0x00, 0x0F, 0xEF,
  0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xFC, 0xFC, 0x00,
  0x1F, 0x8F, 0xC0, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x87, 0xE0, 0x07, 0xF0,
  0x7F, 0x00, 0xFF, 0x07, 0xF8, 0x3F, 0xE0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x3F, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0xFE, 0x07, 0xF0,
  0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xE0, 0x7E, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0x7E, 0x0F, 0xE0, 0x01, 0xF8, 0x3F, 0x80, 0x07, 0xE0, 0xFE, 0x00, 0x3F,
  0x83, 0xF0, 0x00, 0xFE, 0x0F, 0xC0, 0x07, 0xF0, 0x3F, 0x00, 0x1F, 0xC1,
  0xFC, 0x01, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xF8, 0x7F, 0xC0,
  0xFF, 0x00, 0xFE, 0x07, 0xF0, 0x03, 0xF0, 0x7F, 0x00, 0x1F, 0xC3, 0xF0,
  0x00, 0xFE, 0x3F, 0x80, 0x03, 0xF1, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x00,
  0xFC, 0xFE, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x3F, 0x3F, 0x00, 0x03, 0xF9,
  0xF8, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0xFE, 0x7E, 0x00, 0x07, 0xF7, 0xF0,
  0x00, 0x3F, 0x3F, 0x80, 0x01, 0xF9, 0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0x00,
  0x7E, 0x7E, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x3F, 0x9F, 0x80, 0x01, 0xF8,
  0xFC, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0xFE, 0x3F, 0x00, 0x07, 0xF1, 0xF8,
  0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0x83, 0xF8, 0x01,
  0xFC, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x83, 0xFE, 0x01, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0xDF, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFE, 0x03, 0xF0, 0x0F, 0xF0, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xF0,
  0x7F, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x07, 0xE0,
  0x03, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7F,
  0x0F, 0xC0, 0x0F, 0xE0, 0xFC, 0x01, 0xFE, 0x1F, 0xC0, 0x3F, 0xC1, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x03, 0xF8, 0x3F, 0x80, 0x3F,
  0x81, 0xF8, 0x03, 0xF0, 0x1F, 0xC0, 0x3F, 0x01, 0xFC, 0x03, 0xF0, 0x1F,
  0xC0, 0x7F, 0x00, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x07,
  0xE0, 0x0F, 0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xF0, 0xFE, 0x00,
  0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x8F, 0xC0, 0x03, 0xF8,
  0x00, 0x00, 0x40, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x07,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x03, 0xFC, 0x1F,
  0xE0, 0x7F, 0x80, 0xFE, 0x07, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0x7F, 0x0F,
  0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x3F,
  0x8F, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xF0, 0x7F,
  0x00, 0xFF, 0x07, 0xFC, 0x1F, 0xE0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x01, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x01, 0xFC, 0x1F, 0x80,
  0x07, 0xF0, 0x7E, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x7E, 0x0F, 0xE0, 0x01,
  0xF8, 0x3F, 0x80, 0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0xFE,
  0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x3F, 0x07,
  0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0x7E, 0x00, 0x1F, 0xC1, 0xF8,
  0x00, 0x7E, 0x07, 0xE0, 0x01, 0xF8, 0x3F, 0x80, 0x07, 0xE0, 0xFE, 0x00,
  0x3F, 0x83, 0xF8, 0x00, 0xFE, 0x0F, 0xC0, 0x03, 0xF8, 0x3F, 0x00, 0x0F,
  0xC0, 0xFC, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0xFC, 0x1F, 0xC0, 0x07, 0xF0,
  0x7F, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x7F, 0x07, 0xE0, 0x01, 0xF8, 0x3F,
  0x80, 0x07, 0xE0, 0xFE, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0xFE, 0x0F, 0xE0,
  0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xC0, 0x7E, 0x00, 0x7F, 0x01, 0xFC, 0x03,
  0xF8, 0x07, 0xF8, 0x3F, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xBF,
  0x80, 0x01, 0xFD, 0xFC, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0xFE, 0x7F, 0x00,
  0x0F, 0xF3, 0xF8, 0x00, 0x7F, 0x0F, 0xC0, 0x03, 0xF8, 0x7E, 0x00, 0x3F,
  0x83, 0xF0, 0x01, 0xFC, 0x1F, 0x80, 0x1F, 0xC0, 0xFE, 0x00, 0xFE, 0x07,
  0xF0, 0x07, 0xE0, 0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xE0,
  0x3F, 0x80, 0x3F, 0x01, 0xFC, 0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0xFE,
  0x00, 0x7E, 0x07, 0xE0, 0x03, 0xF0, 0x7F, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0x7E, 0x1F, 0x80, 0x03, 0xF1, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0xFC,
  0xFE, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x3F, 0x3F, 0x00, 0x01, 0xFB, 0xF0,
  0x00, 0x0F, 0xDF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFF, 0xF8, 0x03,
  0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xC0, 0x1F, 0xFF, 0x80, 0x7F, 0x00, 0x7E,
  0xFE, 0x01, 0xFC, 0x01, 0xFB, 0xF8, 0x07, 0xF0, 0x0F, 0xEF, 0xE0, 0x3F,
  0xC0, 0x3F, 0x3F, 0x80, 0xFF, 0x00, 0xFC, 0xFE, 0x03, 0xFC, 0x07, 0xF3,
  0xF8, 0x1F, 0xF0, 0x1F, 0x8F, 0xE0, 0x7F, 0xC0, 0x7E, 0x1F, 0x81, 0xFF,
  0x03, 0xF8, 0x7E, 0x0F, 0xFC, 0x0F, 0xC1, 0xF8, 0x3E, 0xF8, 0x3F, 0x07,
  0xE1, 0xFB, 0xE1, 0xFC, 0x1F, 0x87, 0xCF, 0x87, 0xE0, 0x7E, 0x1F, 0x3E,
  0x1F, 0x81, 0xF8, 0xFC, 0xF8, 0xFE, 0x07, 0xE3, 0xE3, 0xE3, 0xF0, 0x1F,
  0x8F, 0x8F, 0x8F, 0xC0, 0x7E, 0x7E, 0x3E, 0x3F, 0x01, 0xF9, 0xF0, 0xF9,
  0xF8, 0x07, 0xE7, 0xC3, 0xE7, 0xE0, 0x1F, 0xBF, 0x0F, 0x9F, 0x80, 0x7E,
  0xF8, 0x3E, 0xFC, 0x01, 0xFB, 0xE0, 0xFB, 0xF0, 0x07, 0xFF, 0x03, 0xEF,
  0xC0, 0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x01, 0xFF,
  0x80, 0xFF, 0xE0, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x0F, 0xFC,
  0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x07, 0xFC,
  0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x1F, 0xC0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x07, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x1F, 0xE0,
  0x1F, 0xC0, 0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x01, 0xFE,
  0x00, 0x3F, 0x80, 0x7F, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x01, 0xFC, 0x1F,
  0xE0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x03, 0xF0,
  0xFE, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x07,
  0xEF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x03, 0xF9,
  0xF8, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x00, 0xFF, 0x1F, 0xC0, 0x00, 0x3F,
  0x87, 0xF0, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x03,
  0xF8, 0x0F, 0xE0, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0xFE,
  0x03, 0xFC, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x01, 0xFE,
  0xFE, 0x00, 0x1F, 0xC7, 0xE0, 0x03, 0xFC, 0x7F, 0x00, 0x3F, 0x87, 0xF0,
  0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x03, 0xF0, 0x0F, 0xE0, 0x3F, 0x00, 0xFE,
  0x03, 0xF0, 0x1F, 0xC0, 0x3F, 0x81, 0xF8, 0x01, 0xF8, 0x3F, 0x80, 0x1F,
  0x83, 0xF0, 0x01, 0xF8, 0x7F, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0xFC, 0xFC,
  0x00, 0x0F, 0xDF, 0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F,
  0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xFF,
  0x80, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0xFC,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F,
  0x80, 0xF8, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x07,
  0xC0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03,
  0xFF, 0x00, 0xFF, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F,
  0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x07, 0xFC, 0x03, 0xFF,
  0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xF0,
  0x0F, 0xFC, 0x03, 0xFF, 0x01, 0xF3, 0xC0, 0x7C, 0xF0, 0x3E, 0x3C, 0x0F,
  0x8F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0xFC, 0x3E, 0x3E, 0x0F, 0x9F, 0x81,
  0xE7, 0xC0, 0x7F, 0xF0, 0x1F, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFE, 0x1F, 0x87, 0xF0, 0xFC,
  0x1F, 0x83, 0xE0, 0xFC, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x07,
  0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x83, 0xF8,
  0x7F, 0x0F, 0xE0, 0x7E, 0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x0F, 0xFF, 0x80, 0xFF, 0xFF,
  0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x7F, 0xC3, 0xF1, 0xFE, 0x07, 0xE3,
  0xF8, 0x1F, 0xCF, 0xE0, 0x3F, 0x9F, 0xC0, 0x7E, 0x3F, 0x00, 0xFC, 0x7E,
  0x01, 0xF8, 0xFE, 0x07, 0xF1, 0xFC, 0x1F, 0xE3, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x03, 0xF8, 0xFC, 0x00, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7F, 0x7F, 0x80, 0x3F, 0x7F, 0xE0, 0x1F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x07, 0xFC, 0x3F, 0x83, 0xF8, 0x0F,
  0xE1, 0xF8, 0x07, 0xF0, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x3F, 0x00,
  0x7E, 0x3F, 0x80, 0x3F, 0x1F, 0xC0, 0x1F, 0x8F, 0xC0, 0x1F, 0xC7, 0xE0,
  0x0F, 0xE3, 0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xF1, 0xFC, 0x01, 0xF8, 0xFC,
  0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x7F, 0x1F, 0x80, 0x3F, 0x0F,
  0xC0, 0x3F, 0x8F, 0xF0, 0x1F, 0xC7, 0xFC, 0x1F, 0xC3, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xE0, 0xFD, 0xFF, 0xE0, 0x7C, 0x7F, 0xE0, 0x7E, 0x1F, 0xE0,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFF,
  0xC0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x83, 0xF8, 0x3F,
  0x0F, 0xE0, 0x7E, 0x1F, 0x80, 0x7E, 0x7E, 0x00, 0xFC, 0xFC, 0x01, 0xF9,
  0xF8, 0x03, 0xF7, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x3F, 0x1F, 0x80, 0x7E, 0x3F, 0x01,
  0xFC, 0x7E, 0x03, 0xF0, 0xFE, 0x0F, 0xE0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x04, 0x0F, 0xC0, 0x0F, 0xF1, 0xF8, 0x07, 0xFF, 0x3F, 0x01,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x03, 0xFC, 0x3F,
  0xE0, 0x7F, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x83, 0xF0, 0x07, 0xF0, 0x7E,
  0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x83, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0x7E,
  0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x03, 0xF8, 0x3F, 0x00, 0x7E, 0x07, 0xE0,
  0x0F, 0xC0, 0xFC, 0x01, 0xF8, 0x3F, 0x80, 0x3F, 0x07, 0xF0, 0x0F, 0xE0,
  0x7E, 0x01, 0xFC, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x01,
  0xFC, 0x07, 0xF0, 0x7F, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x01, 0xFE, 0x7E, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE1, 0xFC, 0x1F, 0x8F, 0xE0, 0x3F,
  0x3F, 0x00, 0xFD, 0xFC, 0x03, 0xF7, 0xE0, 0x0F, 0xDF, 0x80, 0x3F, 0x7E,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xEF, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x01, 0xC1, 0xFC,
  0x0F, 0x87, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0x7F, 0xFE,
  0x00, 0x7F, 0xE0, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x7F, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF,
  0xC0, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE3, 0xF0, 0x1F, 0xFC, 0xFC, 0x0F,
  0xFF, 0xBF, 0x03, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0xFF, 0x07, 0xF8,
  0x3F, 0x80, 0xFE, 0x1F, 0xC0, 0x3F, 0x87, 0xF0, 0x07, 0xE1, 0xF8, 0x03,
  0xF8, 0x7E, 0x00, 0xFE, 0x3F, 0x80, 0x3F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0,
  0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x7F, 0x0F, 0xC0, 0x1F, 0xC3,
  0xF0, 0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x1F,
  0x83, 0xF0, 0x0F, 0xE0, 0xFC, 0x03, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xF0,
  0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFE, 0x00, 0x3F, 0xDF, 0x80, 0x01, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFE, 0x02, 0x00, 0x3F, 0x00, 0xC0, 0x1F, 0xC0, 0x7E, 0x1F,
  0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x1F,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xF0, 0x40, 0x07, 0xE7, 0xF8, 0x07, 0xEF, 0xFC,
  0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xF0, 0x7F,
  0x0F, 0xE0, 0x7F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F,
  0x0F, 0xC0, 0x3F, 0x1F, 0xC0, 0x7F, 0x1F, 0x80, 0x7F, 0x1F, 0x80, 0x7E,
  0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x3F, 0x80, 0x7E, 0x3F, 0x80, 0xFE,
  0x3F, 0x00, 0xFE, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC,
  0x7F, 0x00, 0xFC, 0x7F, 0x01, 0xFC, 0x7E, 0x01, 0xFC, 0x7E, 0x01, 0xF8,
  0x7E, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0xFE, 0x01, 0xF8, 0xFC, 0x01, 0xF8,
  0x01, 0xE0, 0x1F, 0x80, 0xFE, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x81, 0xFC, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0xE0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x17, 0xF8, 0x03, 0xFF,
  0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7F, 0x03, 0xFC, 0x0F, 0xC0, 0x7F, 0x01, 0xF8,
  0x1F, 0xE0, 0x3F, 0x07, 0xF8, 0x07, 0xE1, 0xFE, 0x01, 0xFC, 0x7F, 0x80,
  0x3F, 0x8F, 0xE0, 0x07, 0xE3, 0xF8, 0x00, 0xFC, 0xFE, 0x00, 0x1F, 0xBF,
  0x80, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xF7, 0xF0, 0x01, 0xFC, 0x7E, 0x00, 0x3F,
  0x0F, 0xE0, 0x07, 0xE1, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x83, 0xF8,
  0x07, 0xE0, 0x7F, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xFE, 0x03, 0xF0,
  0x1F, 0xC0, 0x7E, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x80, 0x01, 0xF8, 0x0F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xF0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x3F, 0x81, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x81, 0xFC, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x81, 0xFC, 0x0F, 0xE0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x0F,
  0xE0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x7F, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x9F, 0xE0, 0x7F, 0x80, 0x7E, 0xFF, 0xC7, 0xFF, 0x01, 0xFF, 0xFF, 0xBF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0x0F, 0xFC, 0x1F, 0xC3, 0xF8, 0x1F, 0xE0, 0x7F, 0x0F, 0xC0, 0x7F, 0x80,
  0xFC, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0x0F, 0xC3, 0xF0,
  0x0F, 0xC0, 0x3F, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x7F, 0x01, 0xF8, 0x07,
  0xF1, 0xF8, 0x07, 0xE0, 0x1F, 0x87, 0xE0, 0x1F, 0x80, 0x7E, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x07, 0xE3, 0xF8, 0x0F, 0xE0, 0x3F,
  0x8F, 0xC0, 0x3F, 0x00, 0xFE, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0xFC, 0x03,
  0xF0, 0x0F, 0xC3, 0xF0, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x7F, 0x01, 0xFC, 0x07, 0xF1, 0xF8, 0x07, 0xE0, 0x1F, 0xC7, 0xE0, 0x1F,
  0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x07, 0xE1,
  0xF8, 0x07, 0xE0, 0x1F, 0x8F, 0xE0, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xE7, 0xF8, 0x07, 0xEF, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0x0F, 0xF0, 0x7F, 0x0F, 0xE0, 0x7F, 0x0F, 0xC0,
  0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x1F, 0xC0, 0x3F, 0x1F, 0xC0,
  0x7F, 0x1F, 0x80, 0x7F, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x80,
  0x7E, 0x3F, 0x80, 0x7E, 0x3F, 0x80, 0xFE, 0x3F, 0x00, 0xFE, 0x3F, 0x00,
  0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x7F, 0x00, 0xFC, 0x7F, 0x01,
  0xFC, 0x7E, 0x01, 0xFC, 0x7E, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x7E, 0x01,
  0xF8, 0xFE, 0x01, 0xF8, 0xFE, 0x01, 0xF8, 0x00, 0x02, 0x00, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFE, 0x0F, 0xE0, 0xFE, 0x1F, 0xC0, 0x7E, 0x1F, 0x80, 0x7F, 0x3F, 0x80,
  0x7F, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x7F, 0x00, 0x3F, 0x7F, 0x00,
  0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x7F, 0x7E, 0x00,
  0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00,
  0xFE, 0x7E, 0x00, 0xFC, 0x7E, 0x01, 0xFC, 0x7F, 0x01, 0xF8, 0x3F, 0x83,
  0xF8, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x3F, 0xC0, 0x07, 0xEF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0x80, 0xFF, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x03, 0xF0,
  0x0F, 0xE0, 0x7E, 0x01, 0xFC, 0x0F, 0xC0, 0x1F, 0x81, 0xF8, 0x03, 0xF0,
  0x7F, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0xC1, 0xF8, 0x03, 0xF8, 0x3F, 0x00,
  0x7F, 0x07, 0xE0, 0x0F, 0xC0, 0xFC, 0x01, 0xF8, 0x3F, 0x80, 0x3F, 0x07,
  0xE0, 0x07, 0xE0, 0xFC, 0x01, 0xFC, 0x1F, 0x80, 0x3F, 0x03, 0xF0, 0x07,
  0xE0, 0xFE, 0x01, 0xFC, 0x1F, 0xE0, 0x3F, 0x03, 0xFC, 0x1F, 0xE0, 0x7F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xFB, 0xFF, 0xC0, 0x7F, 0x7F, 0xF0,
  0x0F, 0xE3, 0xFC, 0x01, 0xF8, 0x08, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x7F, 0x8F, 0xC0,
  0xFF, 0xE7, 0xE0, 0xFF, 0xFB, 0xF0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8,
  0x7F, 0x83, 0xFC, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0x7F, 0x1F, 0xC0, 0x3F,
  0x8F, 0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0xC7, 0xF0, 0x07, 0xE3, 0xF0, 0x03,
  0xF1, 0xF8, 0x03, 0xF8, 0xFC, 0x01, 0xFC, 0x7E, 0x00, 0xFC, 0x3F, 0x00,
  0x7E, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x1F, 0xC3, 0xF0,
  0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x7E, 0x03, 0xF8, 0x3F,
  0x83, 0xFC, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x80, 0x3F, 0xCF, 0xC0, 0x01, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xF9, 0xF0, 0x7F, 0xFC,
  0x1F, 0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0xE0, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFE, 0x01,
  0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFC, 0x1F, 0xC7, 0xE0,
  0x3F, 0x1F, 0x80, 0xFC, 0x7E, 0x03, 0xF1, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03,
  0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xCF, 0xC0, 0x3F, 0x3F, 0x00, 0xFC, 0xFC, 0x07, 0xF3,
  0xF8, 0x1F, 0x87, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x7F,
  0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x10, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x3F, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xE0, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x0F,
  0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xF0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xF8, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x7F, 0xE0, 0xFF, 0xC0, 0xFF,
  0x01, 0xFE, 0x01, 0xFC, 0x00, 0x40, 0x00, 0x1F, 0x80, 0x7F, 0x1F, 0x80,
  0x7F, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x3F, 0x80,
  0x7E, 0x3F, 0x00, 0xFE, 0x3F, 0x00, 0xFE, 0x3F, 0x00, 0xFC, 0x3F, 0x00,
  0xFC, 0x3F, 0x00, 0xFC, 0x7F, 0x00, 0xFC, 0x7E, 0x01, 0xFC, 0x7E, 0x01,
  0xF8, 0x7E, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0xFE, 0x01,
  0xF8, 0xFC, 0x03, 0xF8, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x03,
  0xF0, 0xFC, 0x03, 0xF0, 0xFE, 0x07, 0xF0, 0xFE, 0x1F, 0xF0, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xF7, 0xE0, 0x1F, 0xE7,
  0xE0, 0x03, 0x00, 0x00, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xEF, 0xE0, 0x3F,
  0xBF, 0x80, 0xFE, 0x7E, 0x03, 0xF1, 0xF8, 0x1F, 0xC7, 0xE0, 0x7E, 0x1F,
  0x81, 0xF8, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE1, 0xFC, 0x1F, 0x87,
  0xE0, 0x3E, 0x1F, 0x80, 0xF8, 0xFC, 0x03, 0xE3, 0xF0, 0x0F, 0x8F, 0x80,
  0x3E, 0x7E, 0x00, 0xFD, 0xF8, 0x03, 0xF7, 0xC0, 0x0F, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x3E, 0x00, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0xBE, 0x01, 0xF0, 0x1F, 0x9F,
  0x01, 0xF8, 0x0F, 0xCF, 0x80, 0xFC, 0x07, 0xE7, 0xC0, 0xFE, 0x07, 0xE3,
  0xE0, 0x7F, 0x03, 0xF1, 0xF0, 0x3F, 0x81, 0xF8, 0xF8, 0x3F, 0xC1, 0xF8,
  0x7C, 0x1F, 0xE0, 0xFC, 0x3E, 0x1F, 0xF8, 0x7C, 0x1F, 0x0F, 0xFC, 0x7E,
  0x0F, 0x87, 0xFE, 0x3F, 0x07, 0xE7, 0xDF, 0x3F, 0x03, 0xF3, 0xEF, 0x9F,
  0x81, 0xFB, 0xE7, 0xCF, 0x80, 0xFD, 0xF3, 0xEF, 0xC0, 0x7F, 0xF9, 0xF7,
  0xE0, 0x3F, 0xF8, 0xFB, 0xE0, 0x1F, 0xFC, 0x7F, 0xF0, 0x0F, 0xFC, 0x1F,
  0xF8, 0x07, 0xFE, 0x0F, 0xF8, 0x03, 0xFE, 0x07, 0xFC, 0x01, 0xFF, 0x03,
  0xFC, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x1F, 0xC0,
  0x7F, 0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x07, 0xE0, 0x1F, 0x80, 0x03, 0xF0,
  0x0F, 0xC0, 0x01, 0xF0, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x0F, 0xE0, 0x7E,
  0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x00, 0xFC, 0x1F, 0xC0, 0x1F, 0x87, 0xF0,
  0x03, 0xF0, 0xFE, 0x00, 0x3F, 0x3F, 0x80, 0x07, 0xE7, 0xE0, 0x00, 0xFD,
  0xFC, 0x00, 0x0F, 0xBF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0xBE, 0x00, 0x07, 0xE7, 0xE0, 0x01, 0xFC, 0xFC,
  0x00, 0x7F, 0x1F, 0x80, 0x0F, 0xE1, 0xF8, 0x03, 0xF8, 0x3F, 0x00, 0x7F,
  0x07, 0xE0, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x0F, 0xC0, 0xFE, 0x01, 0xF8,
  0x00, 0x07, 0xF0, 0x0F, 0xE0, 0xFE, 0x01, 0xF8, 0x1F, 0xC0, 0x7F, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x03, 0xF8, 0x07, 0xE0, 0x7F, 0x00, 0xFC, 0x0F,
  0xC0, 0x1F, 0x83, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0x7E, 0x1F, 0xC0, 0x0F,
  0xC3, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x03, 0xE3, 0xF0,
  0x00, 0x7C, 0xFE, 0x00, 0x0F, 0x9F, 0x80, 0x01, 0xF7, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x80, 0x00, 0xE0, 0x00,
  0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F,
  0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x1F, 0x00, 0x01, 0xC0, 0x00, 0x20, 0x00, 0x01, 0xF0, 0x1E, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x0F,
  0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x00, 0x00, 0x80, 0x00, 0x70, 0x00,
  0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x0F, 0xF8, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x02,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x7C, 0x7F, 0xF0, 0x0F,
  0x8F, 0xFF, 0x03, 0xE3, 0xFF, 0xF0, 0x7C, 0x7F, 0xFE, 0x1F, 0x9F, 0x87,
  0xFF, 0xE3, 0xE0, 0x7F, 0xFC, 0x7C, 0x0F, 0xFF, 0x0F, 0x00, 0xFF, 0xE3,
  0xE0, 0x0F, 0xF8, 0x00, 0x00, 0x7C, 0x00,
};

const GFXglyph RobotoCondensed_MediumItalic56pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 13, 41, 14, 1, -40 },
  { 68, 15, 14, 17, 4, -42 },
  { 95, 28, 40, 29, 2, -40 },
  { 235, 24, 53, 27, 2, -47 },
  { 394, 26, 42, 35, 5, -41 },
  { 531, 27, 42, 31, 1, -41 },
  { 673, 7, 14, 9, 4, -42 },
  { 686, 17, 58, 17, 3, -45 },
  { 810, 18, 58, 17, -3, -45 },
  { 941, 23, 24, 24, 3, -40 },
  { 1010, 23, 29, 26, 2, -33 },
  { 1094, 11, 15, 12, -3, -6 },
  { 1115, 13, 5, 17, 2, -19 },
  { 1124, 8, 8, 15, 1, -7 },
  { 1132, 25, 43, 19, -3, -40 },
  { 1267, 23, 42, 27, 3, -41 },
  { 1388, 16, 40, 27, 6, -40 },
  { 1468, 26, 41, 27, 0, -41 },
  { 1602, 25, 42, 27, 1, -41 },
  { 1734, 25, 40, 27, 1, -40 },
  { 1859, 25, 41, 27, 2, -40 },
  { 1988, 22, 41, 27, 3, -40 },
  { 2101, 26, 40, 27, 3, -40 },
  { 2231, 24, 42, 27, 2, -41 },
  { 2357, 22, 41, 27, 4, -41 },
  { 2470, 12, 31, 14, 1, -30 },
  { 2517, 15, 39, 13, -3, -30 },
  { 2591, 21, 25, 24, 2, -30 },
  { 2657, 22, 17, 27, 3, -26 },
  { 2704, 22, 26, 25, 1, -30 },
  { 2776, 20, 42, 24, 4, -41 },
  { 2881, 39, 51, 42, 1, -39 },
  { 3130, 30, 40, 32, -2, -40 },
  { 3280, 28, 40, 30, 1, -40 },
  { 3420, 29, 42, 31, 2, -41 },
  { 3573, 28, 40, 31, 1, -40 },
  { 3713, 28, 40, 27, 1, -40 },
  { 3853, 27, 40, 26, 1, -40 },
  { 3988, 28, 42, 32, 3, -41 },
  { 4135, 33, 40, 34, 1, -40 },
  { 4300, 13, 40, 14, 1, -40 },
  { 4365, 27, 41, 26, 0, -40 },
  { 4504, 33, 40, 30, 1, -40 },
  { 4669, 22, 40, 26, 1, -40 },
  { 4779, 41, 40, 41, 1, -40 },
  { 4984, 33, 40, 33, 1, -40 },
  { 5149, 28, 42, 33, 3, -41 },
  { 5296, 30, 40, 31, 1, -40 },
  { 5446, 29, 48, 33, 2, -41 },
  { 5620, 28, 40, 29, 1, -40 },
  { 5760, 28, 42, 29, 1, -41 },
  { 5907, 27, 40, 29, 5, -40 },
  { 6042, 30, 41, 31, 2, -40 },
  { 6196, 29, 40, 31, 5, -40 },
  { 6341, 38, 40, 41, 5, -40 },
  { 6531, 34, 40, 30, -1, -40 },
  { 6701, 28, 40, 29, 5, -40 },
  { 6841, 31, 40, 29, -1, -40 },
  { 6996, 19, 55, 14, -1, -46 },
  { 7127, 12, 43, 20, 5, -40 },
  { 7192, 18, 55, 14, -3, -46 },
  { 7316, 18, 20, 21, 2, -40 },
  { 7361, 21, 5, 22, -3, 0 },
  { 7375, 10, 8, 17, 6, -42 },
  { 7385, 23, 32, 26, 1, -31 },
  { 7477, 25, 43, 27, 0, -42 },
  { 7612, 23, 32, 25, 1, -31 },
  { 7704, 27, 43, 27, 1, -42 },
  { 7850, 22, 32, 26, 2, -31 },
  { 7938, 19, 43, 18, 2, -43 },
  { 8041, 26, 42, 27, 0, -31 },
  { 8178, 24, 42, 27, 0, -42 },
  { 8304, 13, 41, 13, 1, -41 },
  { 8371, 19, 52, 13, -6, -41 },
  { 8495, 27, 42, 25, 0, -42 },
  { 8637, 13, 42, 13, 1, -42 },
  { 8706, 38, 31, 41, 0, -31 },
  { 8854, 24, 31, 27, 0, -31 },
  { 8947, 24, 32, 27, 1, -31 },
  { 9043, 27, 42, 27, -2, -31 },
  { 9185, 25, 42, 27, 1, -31 },
  { 9317, 18, 31, 17, 0, -31 },
  { 9387, 22, 32, 25, 1, -31 },
  { 9475, 15, 38, 16, 2, -37 },
  { 9547, 24, 31, 27, 2, -30 },
  { 9640, 22, 30, 24, 3, -30 },
  { 9723, 33, 30, 35, 3, -30 },
  { 9847, 27, 30, 24, -2, -30 },
  { 9949, 27, 41, 23, -2, -30 },
  { 10088, 25, 30, 24, -1, -30 },
  { 10182, 18, 54, 16, 1, -44 },
  { 10304, 12, 47, 14, 1, -40 },
  { 10375, 17, 54, 16, -2, -44 },
  { 10490, 27, 12, 31, 2, -23 },
};

const GFXfont RobotoCondensed_MediumItalic56pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_MediumItalic56pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_MediumItalic56pt7bGlyphs,
  0x20, 0x7E, 66
};

#endif // _ROBOTOCONDENSED_MEDIUMITALIC56PT7B_H_
