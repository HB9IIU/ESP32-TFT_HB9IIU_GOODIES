#ifndef _ROBOTOCONDENSED_MEDIUMITALIC21PT7B_H_
#define _ROBOTOCONDENSED_MEDIUMITALIC21PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-MediumItalic.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_MediumItalic21pt7bBitmaps[] PROGMEM = {
  0x00, 0x18, 0xC6, 0x73, 0x18, 0xC6, 0x33, 0x00, 0x06, 0x31, 0x80, 0xDE,
  0xF7, 0x29, 0x00, 0x04, 0xC1, 0x20, 0xD8, 0x26, 0x7F, 0xDF, 0xF1, 0xB0,
  0x48, 0x36, 0x3F, 0xEF, 0xF1, 0x90, 0x6C, 0x12, 0x0C, 0x80, 0x06, 0x03,
  0x07, 0x87, 0xE3, 0x3B, 0x9D, 0xCE, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xEC,
  0x36, 0x3B, 0x99, 0xFC, 0x7C, 0x18, 0x0C, 0x00, 0x70, 0x3E, 0x0C, 0x9B,
  0x24, 0xDB, 0x3F, 0x87, 0x40, 0x30, 0x1B, 0x85, 0xE3, 0xCD, 0xB3, 0xCC,
  0x83, 0xE0, 0x70, 0x0F, 0x03, 0xF0, 0x66, 0x0C, 0xC1, 0x98, 0x3E, 0x07,
  0x80, 0xE0, 0x3E, 0xCC, 0xD9, 0x9F, 0x31, 0xC6, 0x38, 0xFF, 0x0F, 0x70,
  0x6D, 0xA4, 0x04, 0x31, 0x86, 0x30, 0xC6, 0x18, 0x63, 0x8C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x04, 0x18, 0x20, 0x80, 0x10, 0x30, 0x20, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x87, 0x0C, 0x18, 0x60, 0xC3,
  0x0C, 0x10, 0x00, 0x0C, 0x06, 0x02, 0x1D, 0xF3, 0xF0, 0xC0, 0xF0, 0xCC,
  0x44, 0x00, 0x0C, 0x0C, 0x1C, 0x18, 0xFF, 0xFF, 0x18, 0x38, 0x38, 0x30,
  0x37, 0x66, 0xCC, 0xFF, 0x80, 0x6D, 0x80, 0x01, 0x80, 0x80, 0xC0, 0x60,
  0x60, 0x30, 0x30, 0x18, 0x18, 0x0C, 0x0C, 0x06, 0x06, 0x03, 0x01, 0x01,
  0x80, 0x1E, 0x1F, 0x8C, 0xCC, 0x76, 0x3B, 0x1F, 0x8F, 0xC6, 0xC3, 0x61,
  0xB0, 0xD8, 0xEE, 0x63, 0xE1, 0xE0, 0x04, 0xF7, 0xD7, 0x1C, 0x61, 0x86,
  0x18, 0xE3, 0x0C, 0x30, 0xC7, 0x00, 0x0F, 0x07, 0xE3, 0x9C, 0xC7, 0x31,
  0xC0, 0x60, 0x38, 0x0C, 0x06, 0x03, 0x01, 0xC0, 0xE0, 0x70, 0x3F, 0xEF,
  0xF8, 0x0F, 0x07, 0xE3, 0x9C, 0xC7, 0x01, 0xC0, 0xE0, 0xF0, 0x3C, 0x03,
  0x00, 0xE0, 0x3B, 0x8E, 0x63, 0x1F, 0xC3, 0xC0, 0x01, 0xC0, 0xE0, 0x38,
  0x1E, 0x0D, 0x83, 0xE1, 0xB8, 0xCC, 0x33, 0x18, 0xCF, 0xFB, 0xFE, 0x06,
  0x01, 0x80, 0x60, 0x3F, 0x9F, 0xCC, 0x06, 0x07, 0x03, 0xF1, 0xFC, 0xCE,
  0x03, 0x01, 0x80, 0xD8, 0xEE, 0x63, 0xF0, 0xF0, 0x07, 0x1F, 0x38, 0x30,
  0x70, 0x7E, 0x7F, 0xE7, 0xE3, 0xC3, 0xC3, 0xC7, 0xE6, 0x7E, 0x3C, 0x7F,
  0xDF, 0xE0, 0x18, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x30, 0x1C, 0x06, 0x03,
  0x80, 0xC0, 0x70, 0x18, 0x0E, 0x00, 0x1E, 0x1F, 0x8C, 0xEE, 0x76, 0x3B,
  0x98, 0xF8, 0xFC, 0xE6, 0x63, 0xB1, 0xD8, 0xEC, 0x67, 0xF1, 0xE0, 0x1E,
  0x1F, 0x9C, 0xCC, 0x66, 0x3B, 0x1D, 0x8C, 0xCE, 0x7F, 0x1D, 0x81, 0x81,
  0xC1, 0xC3, 0xC1, 0xC0, 0x11, 0xCC, 0x00, 0x00, 0x00, 0x03, 0x38, 0xC0,
  0x18, 0x71, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0x0C, 0x71, 0x8E, 0x10,
  0x01, 0x0E, 0x3E, 0xF8, 0xC0, 0xF0, 0x3C, 0x1C, 0x04, 0x7F, 0x7F, 0x00,
  0x00, 0xFF, 0xFE, 0x20, 0x1C, 0x0F, 0x80, 0xF0, 0x38, 0x79, 0xF0, 0xE0,
  0x40, 0x00, 0x3D, 0xFF, 0xBE, 0x30, 0xE1, 0x86, 0x18, 0x60, 0xC0, 0x00,
  0x04, 0x1C, 0x30, 0x00, 0x01, 0xF0, 0x0F, 0xF0, 0x30, 0x30, 0xC0, 0x21,
  0x9E, 0x66, 0x7C, 0xC8, 0x99, 0xB3, 0x33, 0x66, 0x66, 0xD8, 0x8D, 0x31,
  0x12, 0x66, 0x24, 0xCC, 0xC9, 0xFB, 0x11, 0xDC, 0x20, 0x00, 0x60, 0x00,
  0x40, 0x00, 0xFE, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x3C,
  0x07, 0xC0, 0x6C, 0x0E, 0xC0, 0xCE, 0x1C, 0xE1, 0x86, 0x3F, 0xE3, 0xFE,
  0x70, 0x66, 0x06, 0xE0, 0x70, 0x1F, 0x83, 0xF8, 0xE3, 0x9C, 0x73, 0x8E,
  0x61, 0x8F, 0xE1, 0xFC, 0x71, 0xCE, 0x19, 0x87, 0x30, 0xE6, 0x38, 0xFF,
  0x3F, 0x80, 0x0F, 0x83, 0xF8, 0xE3, 0x38, 0x66, 0x0E, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x18, 0x03, 0x06, 0x70, 0xCE, 0x38, 0xFE, 0x0F, 0x80, 0x1F,
  0x83, 0xF8, 0xE3, 0x1C, 0x73, 0x86, 0x60, 0xCC, 0x39, 0x87, 0x70, 0xEE,
  0x19, 0x83, 0x30, 0xE6, 0x38, 0xFE, 0x3F, 0x80, 0x1F, 0xE3, 0xFC, 0xE0,
  0x1C, 0x03, 0x80, 0x60, 0x0F, 0xE1, 0xFC, 0x70, 0x0E, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xFF, 0x3F, 0xC0, 0x1F, 0xE3, 0xF8, 0xE0, 0x1C, 0x03, 0x80,
  0x60, 0x0C, 0x01, 0xFC, 0x7F, 0x8E, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x38, 0x00, 0x0F, 0x83, 0xF8, 0xE3, 0x38, 0x66, 0x0E, 0xC0, 0x38, 0x07,
  0x3E, 0xE7, 0xD8, 0x3B, 0x07, 0x70, 0xCE, 0x38, 0xFF, 0x0F, 0x80, 0x18,
  0x38, 0xC1, 0x8E, 0x0C, 0x70, 0x63, 0x83, 0x18, 0x38, 0xFF, 0xC7, 0xFC,
  0x70, 0x63, 0x83, 0x18, 0x38, 0xC1, 0xC6, 0x0E, 0x30, 0x63, 0x83, 0x00,
  0x18, 0xC6, 0x73, 0x98, 0xC6, 0x73, 0x9C, 0xC6, 0x33, 0x80, 0x00, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0x80, 0x60, 0x18, 0x0E, 0x03, 0x80, 0xEE, 0x33,
  0x8C, 0xE7, 0x1F, 0x83, 0xC0, 0x18, 0x70, 0xC7, 0x0E, 0x38, 0x73, 0x83,
  0xB8, 0x1B, 0x80, 0xF8, 0x07, 0xC0, 0x7F, 0x03, 0xB8, 0x18, 0xC0, 0xC7,
  0x06, 0x38, 0x30, 0xE3, 0x87, 0x00, 0x18, 0x18, 0x38, 0x38, 0x38, 0x30,
  0x30, 0x30, 0x70, 0x70, 0x60, 0x60, 0x60, 0x7F, 0xFF, 0x1C, 0x0F, 0x1C,
  0x0E, 0x3C, 0x1E, 0x3C, 0x1E, 0x3C, 0x3E, 0x36, 0x3E, 0x36, 0x7C, 0x36,
  0x6C, 0x76, 0x6C, 0x76, 0xCC, 0x66, 0xDC, 0x67, 0x9C, 0x67, 0x98, 0x63,
  0x18, 0xE3, 0x18, 0x18, 0x38, 0xE1, 0x8F, 0x0C, 0x78, 0x63, 0xE3, 0x1B,
  0x38, 0xD9, 0xC6, 0x4C, 0x73, 0x63, 0x9B, 0x18, 0xF8, 0xC3, 0xC6, 0x1E,
  0x30, 0xE3, 0x83, 0x00, 0x0F, 0x83, 0xF8, 0xE3, 0x38, 0x76, 0x0E, 0xC1,
  0xF8, 0x3F, 0x06, 0xE0, 0xD8, 0x1B, 0x07, 0x70, 0xCE, 0x38, 0xFE, 0x0F,
  0x80, 0x1F, 0xC3, 0xFC, 0xE3, 0x9C, 0x33, 0x86, 0x60, 0xCC, 0x39, 0xFE,
  0x7F, 0x8E, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x00, 0x0F, 0x83,
  0xF8, 0xE7, 0x38, 0x66, 0x0E, 0xC1, 0xF8, 0x3F, 0x06, 0xE0, 0xD8, 0x1B,
  0x07, 0x70, 0xCE, 0x38, 0xFE, 0x0F, 0x80, 0x38, 0x03, 0x80, 0x20, 0x1F,
  0x83, 0xF8, 0xE3, 0x9C, 0x33, 0x8E, 0x61, 0xCC, 0x71, 0xFC, 0x7F, 0x0E,
  0x61, 0x8E, 0x31, 0xC6, 0x18, 0xC3, 0x38, 0x70, 0x07, 0x83, 0xF8, 0xE3,
  0x1C, 0x73, 0x0E, 0x70, 0x07, 0x00, 0x78, 0x07, 0x80, 0x3B, 0x87, 0x30,
  0xE7, 0x38, 0xFF, 0x07, 0x80, 0xFF, 0xFF, 0xF1, 0xC0, 0x70, 0x18, 0x06,
  0x01, 0x80, 0xE0, 0x38, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x1C, 0x07, 0x00,
  0x30, 0xEE, 0x1D, 0xC3, 0xB8, 0x66, 0x0C, 0xC1, 0x98, 0x77, 0x0E, 0xE1,
  0x98, 0x33, 0x06, 0x61, 0xCE, 0x30, 0xFE, 0x0F, 0x00, 0xC0, 0xF8, 0x3B,
  0x87, 0x70, 0xCE, 0x39, 0xC6, 0x19, 0xC3, 0x30, 0x66, 0x0D, 0xC1, 0xB0,
  0x3E, 0x07, 0x80, 0x70, 0x0C, 0x00, 0xC3, 0x0F, 0x0C, 0x7C, 0x71, 0xB1,
  0xC6, 0xC7, 0x3B, 0x3C, 0xCC, 0xD3, 0x36, 0x4C, 0xD9, 0x63, 0x67, 0x8F,
  0x1E, 0x3C, 0x70, 0xF1, 0xC3, 0x87, 0x0E, 0x18, 0x00, 0x1C, 0x38, 0xE3,
  0x83, 0x1C, 0x1D, 0xC0, 0xEC, 0x03, 0xE0, 0x1E, 0x00, 0xE0, 0x07, 0x80,
  0x7C, 0x07, 0x60, 0x33, 0x83, 0x9C, 0x38, 0x61, 0xC3, 0x80, 0xC1, 0xF8,
  0x6E, 0x39, 0x8C, 0x67, 0x19, 0x87, 0xC0, 0xF0, 0x38, 0x0E, 0x03, 0x00,
  0xC0, 0x30, 0x1C, 0x07, 0x00, 0x3F, 0xE7, 0xFC, 0x03, 0x00, 0xE0, 0x38,
  0x06, 0x01, 0xC0, 0x70, 0x0C, 0x03, 0x00, 0xE0, 0x38, 0x06, 0x01, 0xFF,
  0x3F, 0xE0, 0x1C, 0x38, 0x61, 0xC3, 0x86, 0x0C, 0x18, 0x30, 0xE1, 0xC3,
  0x06, 0x0C, 0x18, 0x70, 0xE1, 0x83, 0xC7, 0x00, 0xCC, 0xCE, 0xE6, 0x66,
  0x66, 0x77, 0x33, 0x33, 0x1E, 0x38, 0x30, 0x60, 0xC3, 0x87, 0x0C, 0x18,
  0x30, 0x61, 0xC3, 0x87, 0x0C, 0x18, 0x30, 0x63, 0xC7, 0x80, 0x18, 0x63,
  0xCF, 0x6D, 0xBC, 0xC0, 0xFF, 0xFF, 0xE6, 0x30, 0x1E, 0x1F, 0x8C, 0xE0,
  0x71, 0xFB, 0xF9, 0x8D, 0xC6, 0xE7, 0x3F, 0x8F, 0xC0, 0x18, 0x0C, 0x0E,
  0x07, 0x03, 0x01, 0xB8, 0xFE, 0x63, 0x71, 0xB8, 0xD8, 0x6C, 0x36, 0x3B,
  0x1B, 0xFD, 0xBC, 0x3E, 0x7E, 0x67, 0xC3, 0xC0, 0xC0, 0xC0, 0xC6, 0xCE,
  0xFC, 0x78, 0x01, 0x80, 0x60, 0x18, 0x06, 0x03, 0x8E, 0xE7, 0xF3, 0x8C,
  0xC3, 0x30, 0xCC, 0x73, 0x1C, 0xC6, 0x31, 0x8F, 0xE1, 0xD8, 0x3E, 0x7F,
  0x63, 0xE3, 0xFF, 0xFF, 0xC0, 0xC0, 0xC6, 0xFE, 0x7C, 0x0E, 0x3C, 0xE1,
  0x83, 0x1F, 0xBF, 0x38, 0x60, 0xC1, 0x83, 0x0E, 0x1C, 0x30, 0x60, 0x1E,
  0xCF, 0xF7, 0x19, 0x86, 0x61, 0x98, 0x66, 0x39, 0x8E, 0x63, 0x1F, 0xC3,
  0xB0, 0x1C, 0x46, 0x3F, 0x87, 0xC0, 0x18, 0x0C, 0x0E, 0x07, 0x03, 0x01,
  0xB8, 0xFE, 0x67, 0x71, 0xB0, 0xD8, 0xEC, 0x76, 0x37, 0x1B, 0x8D, 0x86,
  0x18, 0xC6, 0x00, 0x18, 0xC6, 0x33, 0x9C, 0xC6, 0x33, 0x9C, 0x04, 0x1C,
  0x18, 0x00, 0x01, 0x83, 0x06, 0x1C, 0x38, 0x60, 0xC1, 0x83, 0x0E, 0x1C,
  0x30, 0x63, 0xC7, 0x00, 0x18, 0x06, 0x03, 0x80, 0xE0, 0x30, 0x0C, 0x73,
  0x38, 0xDC, 0x7E, 0x1F, 0x07, 0xC1, 0xF8, 0x66, 0x19, 0x8E, 0x73, 0x8C,
  0x18, 0xC6, 0x73, 0x98, 0xC6, 0x33, 0x9C, 0xC6, 0x33, 0x9C, 0x37, 0x38,
  0xFF, 0xF3, 0x3C, 0xDC, 0x63, 0x73, 0x8D, 0x8E, 0x36, 0x31, 0xD8, 0xC7,
  0x63, 0x1B, 0x8C, 0x6E, 0x71, 0x80, 0x37, 0x1F, 0xCC, 0xEE, 0x37, 0x1B,
  0x1D, 0x8E, 0xC6, 0xE3, 0x71, 0xB0, 0xC0, 0x1E, 0x7F, 0x63, 0xE3, 0xC3,
  0xC3, 0xC3, 0xC7, 0xC6, 0xFE, 0x78, 0x1B, 0x87, 0xF1, 0x8C, 0xE3, 0x38,
  0xCC, 0x33, 0x0C, 0xC7, 0x31, 0x9F, 0xE6, 0xF1, 0x80, 0x60, 0x18, 0x0E,
  0x00, 0x3D, 0xBF, 0xB8, 0xD8, 0x6C, 0x36, 0x3B, 0x1D, 0x8C, 0xC6, 0x7F,
  0x1D, 0x81, 0xC0, 0xE0, 0x60, 0x30, 0x36, 0x7C, 0xE3, 0x87, 0x0C, 0x18,
  0x30, 0x61, 0xC3, 0x80, 0x1E, 0x1F, 0x8C, 0xEE, 0x03, 0x80, 0xF0, 0x3D,
  0xC6, 0xE7, 0x3F, 0x0F, 0x00, 0x31, 0x8D, 0xFF, 0xB1, 0x8C, 0x67, 0x39,
  0x8F, 0x38, 0x63, 0xB1, 0x98, 0xDC, 0x6E, 0x36, 0x3B, 0x1D, 0x8C, 0xCE,
  0x7F, 0x1D, 0x80, 0xE3, 0xE7, 0xE6, 0x66, 0x6C, 0x6C, 0x7C, 0x78, 0x78,
  0x70, 0x70, 0xE6, 0x37, 0x31, 0xBB, 0x9D, 0xDC, 0xC6, 0xB6, 0x3D, 0xE1,
  0xEF, 0x0E, 0x78, 0x73, 0x83, 0x1C, 0x18, 0xC0, 0x39, 0xC6, 0x61, 0xB8,
  0x3C, 0x0F, 0x03, 0x81, 0xE0, 0x7C, 0x3B, 0x1C, 0xC6, 0x38, 0x38, 0xCE,
  0x73, 0x98, 0x6E, 0x1B, 0x06, 0xC1, 0xE0, 0x78, 0x1C, 0x07, 0x01, 0xC0,
  0x60, 0x38, 0x3C, 0x0E, 0x00, 0x3F, 0x9F, 0xC1, 0xC0, 0xC0, 0xE0, 0xE0,
  0xE0, 0xE0, 0x60, 0x7F, 0x3F, 0x80, 0x04, 0x71, 0x8C, 0x30, 0xC3, 0x0C,
  0x63, 0x8C, 0x38, 0x61, 0x8E, 0x38, 0xC1, 0x86, 0x08, 0x18, 0xC4, 0x23,
  0x18, 0xC6, 0x21, 0x18, 0xC6, 0x31, 0x88, 0x46, 0x00, 0x10, 0x30, 0x30,
  0x60, 0xC1, 0x87, 0x0C, 0x0C, 0x1C, 0x38, 0xC3, 0x86, 0x0C, 0x18, 0x30,
  0xE3, 0x86, 0x00, 0x38, 0xDF, 0x6C, 0xFB, 0x1C,
};

const GFXglyph RobotoCondensed_MediumItalic21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 5, 15, 5, 0, -15 },
  { 11, 5, 5, 7, 2, -16 },
  { 15, 10, 15, 11, 1, -15 },
  { 34, 9, 19, 10, 1, -17 },
  { 56, 10, 15, 13, 2, -15 },
  { 75, 11, 15, 11, 0, -15 },
  { 96, 3, 5, 3, 1, -16 },
  { 98, 6, 22, 6, 1, -17 },
  { 115, 7, 22, 7, -1, -17 },
  { 135, 9, 9, 9, 1, -15 },
  { 146, 8, 10, 10, 1, -12 },
  { 156, 4, 6, 5, -1, -2 },
  { 159, 5, 2, 6, 1, -7 },
  { 161, 3, 3, 6, 0, -3 },
  { 163, 9, 16, 7, -1, -15 },
  { 181, 9, 15, 10, 1, -15 },
  { 198, 6, 15, 10, 2, -15 },
  { 210, 10, 15, 10, 0, -15 },
  { 229, 10, 15, 10, 0, -15 },
  { 248, 10, 15, 10, 0, -15 },
  { 267, 9, 15, 10, 1, -15 },
  { 284, 8, 15, 10, 1, -15 },
  { 299, 10, 15, 10, 1, -15 },
  { 318, 9, 15, 10, 1, -15 },
  { 335, 9, 15, 10, 1, -15 },
  { 352, 5, 12, 5, 0, -12 },
  { 360, 6, 16, 5, -1, -12 },
  { 372, 8, 9, 9, 1, -11 },
  { 381, 8, 6, 10, 1, -10 },
  { 387, 9, 9, 9, 0, -11 },
  { 398, 7, 15, 9, 2, -15 },
  { 412, 15, 20, 16, 0, -15 },
  { 450, 12, 15, 12, -1, -15 },
  { 473, 11, 15, 11, 0, -15 },
  { 494, 11, 15, 12, 1, -15 },
  { 515, 11, 15, 12, 0, -15 },
  { 536, 11, 15, 10, 0, -15 },
  { 557, 11, 15, 10, 0, -15 },
  { 578, 11, 15, 12, 1, -15 },
  { 599, 13, 15, 13, 0, -15 },
  { 624, 5, 15, 5, 0, -15 },
  { 634, 10, 15, 10, 0, -15 },
  { 653, 13, 15, 11, 0, -15 },
  { 678, 8, 15, 10, 0, -15 },
  { 693, 16, 15, 15, 0, -15 },
  { 723, 13, 15, 13, 0, -15 },
  { 748, 11, 15, 12, 1, -15 },
  { 769, 11, 15, 11, 0, -15 },
  { 790, 11, 18, 12, 1, -15 },
  { 815, 11, 15, 11, 0, -15 },
  { 836, 11, 15, 11, 0, -15 },
  { 857, 10, 15, 11, 2, -15 },
  { 876, 11, 15, 12, 1, -15 },
  { 897, 11, 15, 12, 2, -15 },
  { 918, 14, 15, 15, 2, -15 },
  { 945, 13, 15, 11, -1, -15 },
  { 970, 10, 15, 11, 2, -15 },
  { 989, 11, 15, 11, 0, -15 },
  { 1010, 7, 20, 5, 0, -17 },
  { 1028, 4, 16, 8, 2, -15 },
  { 1036, 7, 20, 5, -1, -17 },
  { 1054, 6, 7, 8, 1, -15 },
  { 1060, 8, 2, 8, -1, 0 },
  { 1062, 4, 3, 7, 2, -16 },
  { 1064, 9, 11, 10, 0, -11 },
  { 1077, 9, 16, 10, 0, -16 },
  { 1095, 8, 11, 9, 1, -11 },
  { 1106, 10, 16, 10, 1, -16 },
  { 1126, 8, 11, 10, 1, -11 },
  { 1137, 7, 16, 7, 1, -16 },
  { 1151, 10, 15, 10, 0, -11 },
  { 1170, 9, 16, 10, 0, -16 },
  { 1188, 5, 16, 5, 0, -16 },
  { 1198, 7, 20, 5, -2, -16 },
  { 1216, 10, 16, 9, 0, -16 },
  { 1236, 5, 16, 5, 0, -16 },
  { 1246, 14, 11, 15, 0, -11 },
  { 1266, 9, 11, 10, 0, -11 },
  { 1279, 8, 11, 10, 1, -11 },
  { 1290, 10, 15, 10, -1, -11 },
  { 1309, 9, 15, 10, 1, -11 },
  { 1326, 7, 11, 6, 0, -11 },
  { 1336, 9, 11, 9, 0, -11 },
  { 1349, 5, 14, 6, 1, -14 },
  { 1358, 9, 11, 10, 1, -11 },
  { 1371, 8, 11, 9, 1, -11 },
  { 1382, 13, 11, 13, 1, -11 },
  { 1400, 10, 11, 9, -1, -11 },
  { 1414, 10, 15, 9, -1, -11 },
  { 1433, 9, 11, 9, 0, -11 },
  { 1446, 6, 20, 6, 1, -16 },
  { 1461, 5, 18, 5, 0, -15 },
  { 1473, 7, 20, 6, -1, -16 },
  { 1491, 10, 4, 12, 1, -8 },
};

const GFXfont RobotoCondensed_MediumItalic21pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_MediumItalic21pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_MediumItalic21pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _ROBOTOCONDENSED_MEDIUMITALIC21PT7B_H_
