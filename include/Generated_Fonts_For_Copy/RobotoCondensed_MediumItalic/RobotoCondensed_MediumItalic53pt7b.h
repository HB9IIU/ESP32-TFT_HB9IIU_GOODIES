#ifndef _ROBOTOCONDENSED_MEDIUMITALIC53PT7B_H_
#define _ROBOTOCONDENSED_MEDIUMITALIC53PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-MediumItalic.ttf
// Size: 53pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_MediumItalic53pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x03, 0xF0, 0x3F, 0x81, 0xFC, 0x07,
  0xC0, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x3C, 0xF0, 0xF3, 0xC7, 0xCF, 0x1F,
  0x3C, 0x79, 0xF1, 0xE7, 0x87, 0x9E, 0x1E, 0x78, 0xF1, 0xE3, 0xC7, 0x8F,
  0x3C, 0x3C, 0xF0, 0xF3, 0xC3, 0x80, 0x00, 0x07, 0x87, 0x80, 0x01, 0xE1,
  0xE0, 0x00, 0xF0, 0xF8, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x07,
  0x87, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x3C, 0x1E, 0x00,
  0x0F, 0x0F, 0x00, 0x03, 0xC3, 0xC0, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0x03, 0xC3, 0xC0, 0x00, 0xF0,
  0xF0, 0x00, 0x7C, 0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0x87, 0x80, 0x01,
  0xE1, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x3C, 0x03, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC0, 0x3C, 0x3E,
  0x00, 0x0F, 0x0F, 0x00, 0x03, 0xC3, 0xC0, 0x01, 0xE1, 0xF0, 0x00, 0x78,
  0x78, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x0F, 0x80, 0x03, 0xC3, 0xC0, 0x00,
  0xF0, 0xF0, 0x00, 0x78, 0x7C, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x7E, 0x0F, 0xC1,
  0xFC, 0x1F, 0x83, 0xF0, 0x1F, 0x87, 0xE0, 0x3F, 0x0F, 0xC0, 0x7E, 0x1F,
  0x00, 0xFC, 0x3E, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF1, 0xF8, 0x07, 0xE3,
  0xF0, 0x0F, 0xC7, 0xE0, 0x1F, 0x8F, 0xC0, 0x3F, 0x1F, 0x80, 0x7E, 0x3F,
  0x01, 0xF8, 0x3F, 0x07, 0xF0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF,
  0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x38, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0,
  0x00, 0x7C, 0xF8, 0x00, 0x78, 0x78, 0x0C, 0xF8, 0x78, 0x1E, 0xF0, 0x78,
  0x3E, 0xF0, 0x78, 0x3C, 0xF0, 0x78, 0x78, 0xF0, 0x78, 0xF8, 0xF0, 0x78,
  0xF0, 0xF0, 0x79, 0xE0, 0xF0, 0xFB, 0xE0, 0xF9, 0xF3, 0xC0, 0x7F, 0xE7,
  0x80, 0x7F, 0xEF, 0x80, 0x1F, 0x8F, 0x00, 0x06, 0x1E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF9, 0xFC, 0x00, 0xF7,
  0xFE, 0x01, 0xE7, 0xFE, 0x03, 0xEF, 0x9F, 0x03, 0xCF, 0x0F, 0x07, 0x9F,
  0x0F, 0x0F, 0x1E, 0x0F, 0x0F, 0x1E, 0x0F, 0x1E, 0x1E, 0x0F, 0x3C, 0x1E,
  0x0F, 0x7C, 0x1E, 0x0F, 0x78, 0x1E, 0x0F, 0x70, 0x1E, 0x1E, 0x10, 0x1F,
  0x3E, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0x8F, 0xC0,
  0x0F, 0xC1, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x1F, 0x00, 0x3E, 0x07,
  0xC0, 0x0F, 0x83, 0xF0, 0x03, 0xE1, 0xF8, 0x00, 0xFC, 0xFE, 0x00, 0x3F,
  0x7F, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0xC3,
  0xE1, 0xFF, 0xF0, 0xF8, 0xFE, 0xFE, 0x3E, 0x3F, 0x1F, 0x8F, 0x9F, 0xC7,
  0xF7, 0xE7, 0xE0, 0xFD, 0xF1, 0xF8, 0x3F, 0xFC, 0xFC, 0x07, 0xFF, 0x3F,
  0x01, 0xFF, 0x8F, 0xC0, 0x3F, 0xE3, 0xF8, 0x0F, 0xF0, 0x7E, 0x01, 0xF8,
  0x1F, 0xC0, 0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFE, 0x03, 0xFF, 0xDF, 0xC0, 0x7F, 0xC3, 0xF0, 0x01, 0x00, 0x00, 0x3C,
  0xF7, 0xDF, 0x7D, 0xE7, 0x9E, 0xFB, 0xEF, 0x3C, 0xF0, 0x00, 0x02, 0x00,
  0x0E, 0x00, 0x1E, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F,
  0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00,
  0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x1E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x01,
  0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07,
  0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7C,
  0x00, 0xF8, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x01, 0x81, 0xE0, 0x6F, 0x8F, 0x1F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFE, 0x0F, 0xFF, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xF0,
  0x01, 0xF7, 0xC0, 0x1F, 0x1E, 0x01, 0xF0, 0xF8, 0x1F, 0x83, 0xC0, 0xF8,
  0x1F, 0x01, 0x80, 0xE0, 0x00, 0x02, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x1F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF8, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0x83, 0xE1, 0xF8, 0x7E, 0x1F, 0x0F,
  0xC3, 0xE1, 0xF8, 0xFC, 0x1E, 0x03, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x08, 0xF9, 0xFF, 0xFF, 0xFF, 0xDF, 0x08, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xF8, 0x3F, 0x07, 0xE0, 0x7E,
  0x0F, 0x80, 0x7C, 0x3F, 0x00, 0xF8, 0x7E, 0x01, 0xF0, 0xF8, 0x03, 0xE3,
  0xF0, 0x07, 0xC7, 0xE0, 0x0F, 0x8F, 0xC0, 0x1F, 0x1F, 0x80, 0x7E, 0x3F,
  0x00, 0xFC, 0x7C, 0x01, 0xF9, 0xF8, 0x03, 0xF3, 0xF0, 0x07, 0xE7, 0xE0,
  0x0F, 0xCF, 0xC0, 0x1F, 0x1F, 0x80, 0x7E, 0x3F, 0x00, 0xFC, 0x7C, 0x01,
  0xF9, 0xF8, 0x03, 0xF3, 0xF0, 0x07, 0xE7, 0xE0, 0x0F, 0x8F, 0xC0, 0x3F,
  0x1F, 0x80, 0x7E, 0x1F, 0x00, 0xF8, 0x3E, 0x03, 0xF0, 0x7E, 0x07, 0xE0,
  0xFC, 0x1F, 0x81, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x7C,
  0x03, 0xF0, 0x3F, 0xE1, 0xFF, 0xCF, 0xFF, 0x9F, 0xFF, 0x3F, 0xFE, 0xFC,
  0xF9, 0xC1, 0xF2, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF8, 0x0F, 0xC1, 0xFC, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x3F,
  0x07, 0xE0, 0x1F, 0xC3, 0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xE0, 0x00, 0x02,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xFF,
  0xFC, 0x07, 0xFF, 0xFC, 0x07, 0xE0, 0xFE, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0,
  0x7E, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x03, 0xF0, 0xFE, 0x03,
  0xF0, 0x7E, 0x07, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF,
  0x80, 0x1F, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F,
  0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0x7E, 0x00, 0x3E, 0xFC, 0x00, 0x3E,
  0xFC, 0x00, 0x7C, 0xFC, 0x00, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF0,
  0xFC, 0x03, 0xF1, 0xF8, 0x07, 0xE1, 0xF8, 0x07, 0xC1, 0xF8, 0x0F, 0xC1,
  0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x01, 0xF0, 0x3F, 0x03, 0xF0, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFE, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x9F, 0x00, 0x1F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x3F, 0x87,
  0xF0, 0x0F, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x03, 0xF0, 0xFC, 0x03,
  0xF0, 0x7E, 0x07, 0xF0, 0x7E, 0x0F, 0xE0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xC0, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xCF, 0x80, 0x7D, 0xFF, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF,
  0x9F, 0xF1, 0xFC, 0xFF, 0x07, 0xF7, 0xF0, 0x1F, 0xBF, 0x00, 0xFD, 0xF8,
  0x07, 0xEF, 0xC0, 0x3F, 0x7E, 0x01, 0xFB, 0xF0, 0x0F, 0xDF, 0x00, 0x7E,
  0xF8, 0x03, 0xF7, 0xC0, 0x1F, 0xBF, 0x01, 0xF9, 0xF8, 0x0F, 0xCF, 0xC0,
  0xFC, 0x3F, 0x0F, 0xE1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x00,
  0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x01, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x81, 0xF8, 0x3F, 0x07, 0xF0,
  0x7E, 0x0F, 0xC0, 0xFC, 0x1F, 0x80, 0xFC, 0x3E, 0x01, 0xF8, 0xFC, 0x07,
  0xE1, 0xF8, 0x0F, 0xC1, 0xF0, 0x1F, 0x83, 0xE0, 0x3F, 0x07, 0xE0, 0xFC,
  0x07, 0xE3, 0xF8, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x1F, 0xFC, 0x00,
  0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x0F, 0xE1, 0xF8, 0x3F, 0x81, 0xF0, 0x7E,
  0x03, 0xF1, 0xF8, 0x07, 0xE3, 0xF0, 0x0F, 0xC7, 0xE0, 0x1F, 0x8F, 0xC0,
  0x3F, 0x1F, 0x80, 0x7E, 0x3F, 0x00, 0xFC, 0x7E, 0x03, 0xF8, 0xFC, 0x07,
  0xE1, 0xFC, 0x1F, 0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x07, 0xFF, 0x80, 0xFF, 0xFC, 0x1F, 0xFF, 0xC1, 0xFF, 0xFE,
  0x3F, 0x87, 0xE3, 0xF0, 0x3E, 0x7E, 0x03, 0xF7, 0xE0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0xFE, 0x7E,
  0x1F, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE3, 0xFF, 0xFC, 0x1F, 0xF7, 0xC0,
  0x7C, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xF8,
  0x07, 0xFF, 0x00, 0x7F, 0xC0, 0x07, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x01,
  0x00, 0xF8, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC1, 0xF0, 0x08, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x03, 0xE0, 0xFE, 0x1F, 0xC3, 0xF8,
  0x7F, 0x07, 0xC0, 0x20, 0x00, 0x00, 0x20, 0x07, 0xE0, 0x1F, 0x80, 0xFF,
  0x03, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x0F,
  0xC0, 0x3E, 0x01, 0xF8, 0x0F, 0xC0, 0x3E, 0x00, 0xF0, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xE0, 0x00,
  0xFF, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01,
  0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80,
  0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x00,
  0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x80, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE1,
  0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x1F,
  0xFF, 0xF8, 0x08, 0x00, 0x00, 0x70, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x7F,
  0x80, 0x0F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF,
  0xE0, 0x1F, 0xFC, 0x00, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0x3C, 0x00, 0x03,
  0x80, 0x00, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00, 0xFF, 0xC0, 0x3F, 0xFC,
  0x0F, 0xFF, 0xC3, 0xFF, 0xF8, 0xFF, 0xFF, 0x9F, 0xC3, 0xF7, 0xF0, 0x7E,
  0xFC, 0x0F, 0xFF, 0x80, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F,
  0xC0, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x78, 0x00, 0x7E, 0x00, 0x03, 0xC0,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x1F, 0x00, 0x00,
  0x0E, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x3C, 0x03, 0xF0, 0x0F, 0x07, 0xC0,
  0x7F, 0xC0, 0xF0, 0x78, 0x1F, 0xFE, 0x07, 0x0F, 0x01, 0xFF, 0xF0, 0x70,
  0xF0, 0x3E, 0x1F, 0x07, 0x1F, 0x07, 0xC1, 0xE0, 0x71, 0xE0, 0x78, 0x1E,
  0x07, 0x3E, 0x0F, 0x81, 0xE0, 0x73, 0xC0, 0xF0, 0x3E, 0x07, 0x3C, 0x1F,
  0x03, 0xC0, 0xF3, 0xC1, 0xF0, 0x3C, 0x0F, 0x7C, 0x1E, 0x03, 0xC0, 0xF7,
  0x83, 0xE0, 0x7C, 0x0F, 0x78, 0x3E, 0x07, 0x80, 0xF7, 0x83, 0xE0, 0x78,
  0x0E, 0x78, 0x3E, 0x07, 0x81, 0xEF, 0x83, 0xC0, 0xF8, 0x1E, 0xF8, 0x7C,
  0x0F, 0x81, 0xEF, 0x07, 0xC0, 0xF0, 0x1C, 0xF0, 0x7C, 0x1F, 0x03, 0xCF,
  0x03, 0xC1, 0xF0, 0x38, 0xF0, 0x3E, 0x3F, 0x07, 0x8F, 0x03, 0xFF, 0xF8,
  0xF0, 0xF0, 0x3F, 0xF7, 0xFE, 0x07, 0x81, 0xFE, 0x7F, 0xC0, 0x78, 0x0F,
  0xC3, 0xF8, 0x07, 0x80, 0x20, 0x0C, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x3C, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0x7C, 0x00, 0x01, 0xFB,
  0xE0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x07, 0xC7, 0xC0,
  0x00, 0x7E, 0x3F, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x01,
  0xF8, 0x7E, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0xFC, 0x0F, 0x80, 0x0F, 0xC0,
  0x7C, 0x00, 0x7E, 0x03, 0xE0, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0xFC,
  0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x07, 0xE0, 0x01, 0xF8, 0x3F, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x03, 0xF1, 0xFC, 0x00, 0x1F,
  0x8F, 0xC0, 0x00, 0xFC, 0xFE, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x3F, 0x7F,
  0x00, 0x01, 0xFC, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xF8, 0x0F, 0xF0, 0x7E,
  0x01, 0xFC, 0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x0F, 0xC1, 0xF8, 0x03, 0xF0,
  0xFE, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x07,
  0xF0, 0xFC, 0x03, 0xF8, 0x3F, 0x01, 0xFC, 0x1F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07,
  0xE0, 0x3F, 0x83, 0xF8, 0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x3F,
  0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x7E, 0x00,
  0x3F, 0x1F, 0x80, 0x1F, 0xC7, 0xE0, 0x07, 0xE1, 0xF8, 0x03, 0xF8, 0x7E,
  0x03, 0xFC, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0x81, 0xFE, 0x07, 0xF0, 0x3F, 0x00, 0x7E, 0x0F, 0xE0,
  0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF1,
  0xF8, 0x00, 0x7E, 0x7F, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x7E,
  0x1F, 0x80, 0x1F, 0xC3, 0xF0, 0x03, 0xF0, 0x7F, 0x00, 0xFE, 0x07, 0xF0,
  0x3F, 0x80, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xF0, 0x0F, 0xC1, 0xFF, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00,
  0x7E, 0x07, 0xE0, 0x0F, 0xC0, 0xFC, 0x01, 0xF8, 0x3F, 0x80, 0x1F, 0x07,
  0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x01,
  0xF8, 0x7E, 0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x7E,
  0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F,
  0x8F, 0xE0, 0x07, 0xF1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x87, 0xE0,
  0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x87, 0xE0, 0x07, 0xF0,
  0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x83, 0xF0, 0x0F, 0xE0, 0x7E, 0x0F,
  0xF8, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC1,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF8, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0x81, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x03, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x81,
  0xFE, 0x07, 0xF0, 0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x07, 0xE1, 0xF8, 0x00,
  0xFC, 0x7F, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x7E, 0x7F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x81, 0xFF, 0xE7, 0xE0,
  0x3F, 0xFC, 0xFC, 0x07, 0xFF, 0x9F, 0x81, 0xFF, 0xF3, 0xF0, 0x3F, 0xFC,
  0x7E, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x7E, 0x3F, 0x00,
  0x1F, 0xC7, 0xE0, 0x03, 0xF8, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC3,
  0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x7F, 0x07, 0xF0, 0x3F, 0xE0, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x07, 0xE0,
  0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x07, 0xF0, 0x7F, 0x00,
  0x0F, 0xC0, 0xFC, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x3F, 0x03, 0xF0, 0x00,
  0x7E, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0x80, 0x07,
  0xE0, 0x7E, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x3F,
  0x03, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x01, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFF, 0x03, 0xF0, 0x00, 0xFC, 0x0F, 0xE0, 0x01, 0xF8, 0x1F,
  0x80, 0x03, 0xF0, 0x3F, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xC0, 0xFC,
  0x00, 0x3F, 0x81, 0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xC0,
  0x01, 0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x3F, 0x00, 0x07, 0xE0, 0x7E, 0x00,
  0x1F, 0xC1, 0xFC, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x00,
  0xFC, 0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x03, 0xF8,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x1F, 0xC0, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x07,
  0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x3F, 0x81, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x81, 0xFC, 0x0F, 0xC0, 0x7E, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x83, 0xF8, 0x07, 0xE0, 0xFE, 0x01, 0xF8, 0x3F, 0x80,
  0xFE, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x1F, 0xC0, 0x7F, 0x0F, 0xE0, 0x1F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0xF0, 0x01, 0xFC, 0x07,
  0xE0, 0x07, 0xF8, 0x0F, 0xC0, 0x1F, 0xE0, 0x1F, 0x80, 0x7F, 0x80, 0x7F,
  0x01, 0xFE, 0x00, 0xFC, 0x03, 0xF8, 0x01, 0xF8, 0x0F, 0xE0, 0x03, 0xF0,
  0x3F, 0xC0, 0x07, 0xE0, 0xFF, 0x00, 0x0F, 0xC3, 0xFC, 0x00, 0x3F, 0x87,
  0xF0, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0xFC, 0x7F, 0x00, 0x01, 0xF9, 0xFE,
  0x00, 0x03, 0xF7, 0xF8, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x1F, 0xF3, 0xF0, 0x00, 0x3F, 0xC7, 0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0x00,
  0xFC, 0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x07, 0xE0, 0x3F, 0x80, 0x0F,
  0xC0, 0x3F, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xF0, 0x03, 0xF8, 0x07, 0xE0,
  0x03, 0xF0, 0x0F, 0xC0, 0x07, 0xF0, 0x1F, 0x80, 0x0F, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFC,
  0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x7F,
  0xC0, 0xFF, 0x00, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x1F, 0xF8,
  0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x07, 0xFE,
  0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0xFF, 0xE0,
  0x03, 0xFF, 0x83, 0xFF, 0x80, 0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0x7D, 0xF0,
  0x3F, 0x7C, 0x03, 0xFF, 0xC0, 0xF9, 0xF0, 0x0F, 0xBF, 0x03, 0xE7, 0xC0,
  0x7E, 0xFC, 0x1F, 0x9F, 0x01, 0xF3, 0xF0, 0x7E, 0x7C, 0x0F, 0xDF, 0x81,
  0xF9, 0xF0, 0x3E, 0x7E, 0x07, 0xE7, 0xC1, 0xF9, 0xF8, 0x1F, 0x9F, 0x07,
  0xC7, 0xE0, 0x7E, 0x3C, 0x1F, 0x1F, 0x83, 0xF0, 0xF8, 0xF8, 0xFC, 0x0F,
  0xC3, 0xE3, 0xE3, 0xF0, 0x3F, 0x0F, 0x9F, 0x0F, 0xC0, 0xFC, 0x3E, 0x7C,
  0x3F, 0x03, 0xF0, 0xFB, 0xE0, 0xFC, 0x0F, 0xC3, 0xEF, 0x87, 0xF0, 0x7E,
  0x0F, 0xFE, 0x1F, 0x81, 0xF8, 0x1F, 0xF0, 0x7E, 0x07, 0xE0, 0x7F, 0xC1,
  0xF8, 0x1F, 0x81, 0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xF8, 0x1F, 0x83, 0xF8,
  0x1F, 0xC0, 0xFE, 0x0F, 0xC0, 0x7F, 0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x0F, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0xFC, 0x0F, 0xE0, 0x01, 0xF8, 0x1F,
  0xC0, 0x07, 0xE0, 0x7F, 0xC0, 0x0F, 0xC0, 0xFF, 0x80, 0x1F, 0x81, 0xFF,
  0x00, 0x3F, 0x03, 0xFE, 0x00, 0x7E, 0x07, 0xFE, 0x01, 0xFC, 0x0F, 0xFC,
  0x03, 0xF0, 0x3F, 0xF8, 0x07, 0xE0, 0x7E, 0xF8, 0x0F, 0xC0, 0xFD, 0xF0,
  0x1F, 0x81, 0xFB, 0xE0, 0x3F, 0x03, 0xF3, 0xE0, 0xFE, 0x07, 0xE7, 0xC1,
  0xF8, 0x1F, 0xCF, 0x83, 0xF0, 0x3F, 0x0F, 0x07, 0xE0, 0x7E, 0x1F, 0x0F,
  0xC0, 0xFC, 0x3E, 0x1F, 0x81, 0xF8, 0x7C, 0x7F, 0x03, 0xF0, 0x7C, 0xFC,
  0x0F, 0xE0, 0xF9, 0xF8, 0x1F, 0x81, 0xF3, 0xF0, 0x3F, 0x01, 0xE7, 0xE0,
  0x7E, 0x03, 0xEF, 0xC0, 0xFC, 0x07, 0xFF, 0x81, 0xF8, 0x0F, 0xFE, 0x07,
  0xF0, 0x0F, 0xFC, 0x0F, 0xC0, 0x1F, 0xF8, 0x1F, 0x80, 0x3F, 0xF0, 0x3F,
  0x00, 0x3F, 0xE0, 0x7E, 0x00, 0x7F, 0xC1, 0xFC, 0x00, 0xFF, 0x03, 0xF0,
  0x00, 0xFE, 0x07, 0xE0, 0x01, 0xFC, 0x0F, 0xC0, 0x03, 0xF8, 0x1F, 0x80,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F,
  0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC,
  0x03, 0xF8, 0x1F, 0xC0, 0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xE0, 0xFC,
  0x00, 0x7E, 0x1F, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x07,
  0xE3, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x7E, 0x3F,
  0x00, 0x07, 0xE3, 0xF0, 0x00, 0x7E, 0x7F, 0x00, 0x07, 0xE7, 0xE0, 0x00,
  0x7E, 0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0xFE, 0x7E, 0x00, 0x0F, 0xC7,
  0xE0, 0x00, 0xFC, 0x7E, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0xFC, 0x7E, 0x00,
  0x0F, 0xC7, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x87, 0xE0, 0x01, 0xF8,
  0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xF0, 0x3F, 0x00, 0xFE, 0x03, 0xF8,
  0x1F, 0xE0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x7E, 0x01, 0xFE, 0x07, 0xE0, 0x0F, 0xE0,
  0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xF0, 0x7E, 0x00, 0x3F, 0x0F, 0xE0,
  0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xF0, 0xFC, 0x00, 0x7E,
  0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xE1, 0xF8,
  0x01, 0xFC, 0x1F, 0x80, 0x7F, 0xC1, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x0F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x07, 0xF8, 0x1F,
  0xC0, 0x7F, 0x00, 0xFC, 0x0F, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x1F,
  0xC0, 0x07, 0xE1, 0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x07, 0xE3, 0xF0, 0x00,
  0x7E, 0x3F, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x7E, 0x3F, 0x00, 0x07, 0xE3,
  0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7E, 0x7E, 0x00,
  0x07, 0xE7, 0xE0, 0x00, 0xFC, 0x7E, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0xFC,
  0x7E, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0xFC, 0xFE, 0x00, 0x1F, 0xC7, 0xE0,
  0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF8, 0x7E, 0x00, 0x3F,
  0x07, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0x3F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFE,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x02, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xC0,
  0x7F, 0x81, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xE0,
  0xFC, 0x00, 0xFC, 0x3F, 0x80, 0x1F, 0x87, 0xE0, 0x07, 0xF0, 0xFC, 0x00,
  0xFC, 0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x07, 0xF0, 0x7E, 0x00, 0xFE, 0x1F,
  0xC0, 0x3F, 0x83, 0xF0, 0x1F, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x01, 0xF8,
  0x1F, 0x80, 0x3F, 0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x0F, 0xE0,
  0x1F, 0x81, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x1F, 0x80,
  0x7F, 0x03, 0xF0, 0x0F, 0xE0, 0x7E, 0x00, 0xFC, 0x1F, 0xC0, 0x1F, 0x83,
  0xF0, 0x03, 0xF8, 0x7E, 0x00, 0x7F, 0x0F, 0xC0, 0x07, 0xE1, 0xF8, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x7F, 0x83,
  0xF8, 0x1F, 0xC0, 0x7F, 0x07, 0xE0, 0x0F, 0xC3, 0xF8, 0x03, 0xF0, 0xFC,
  0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x7E,
  0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xE3, 0xF8, 0x03, 0xF8, 0x7E, 0x00,
  0xFC, 0x1F, 0xC0, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xC0, 0x00,
  0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x0F,
  0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x7F, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00,
  0x7E, 0x0F, 0xC0, 0x07, 0xE1, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x07, 0xE1,
  0xF8, 0x00, 0xFE, 0x1F, 0x80, 0x0F, 0xC1, 0xF8, 0x00, 0xFC, 0x1F, 0x80,
  0x0F, 0xC3, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC3, 0xF0, 0x01, 0xFC,
  0x3F, 0x00, 0x1F, 0x83, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0x87, 0xF0,
  0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF8, 0x7E, 0x00, 0x3F,
  0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x0F, 0xE0, 0x03, 0xF0, 0xFC,
  0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xF0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x07,
  0xE0, 0xFE, 0x00, 0xFE, 0x07, 0xE0, 0x0F, 0xC0, 0x7F, 0x03, 0xFC, 0x07,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x30, 0x00, 0x00, 0xFE, 0x00, 0x07,
  0xF7, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0xFE, 0x7E,
  0x00, 0x1F, 0xC7, 0xE0, 0x01, 0xFC, 0x7E, 0x00, 0x1F, 0x87, 0xF0, 0x03,
  0xF8, 0x7F, 0x00, 0x3F, 0x03, 0xF0, 0x07, 0xF0, 0x3F, 0x00, 0x7F, 0x03,
  0xF0, 0x07, 0xE0, 0x3F, 0x00, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x01,
  0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x1F, 0x01, 0xF8, 0x01, 0xF0, 0x3F, 0x00,
  0x1F, 0x83, 0xF0, 0x01, 0xF8, 0x7F, 0x00, 0x1F, 0x87, 0xE0, 0x01, 0xF8,
  0x7E, 0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x0F, 0x9F, 0x80,
  0x00, 0xF9, 0xF8, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x0F,
  0xBF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0x80, 0x3F, 0xFC, 0x01, 0xF8, 0x07, 0xEF,
  0xC0, 0x3F, 0x80, 0x7E, 0xFC, 0x03, 0xF8, 0x07, 0xEF, 0xC0, 0x7F, 0x80,
  0xFC, 0xFC, 0x07, 0xF8, 0x0F, 0xCF, 0xC0, 0x7F, 0x80, 0xFC, 0xFC, 0x0F,
  0xF8, 0x1F, 0x8F, 0xC0, 0xFF, 0x81, 0xF8, 0xFC, 0x0F, 0xF8, 0x1F, 0x8F,
  0xC1, 0xFF, 0x83, 0xF0, 0xFC, 0x1F, 0xF8, 0x3F, 0x0F, 0xC1, 0xFF, 0x83,
  0xF0, 0xFC, 0x3E, 0xF8, 0x7E, 0x0F, 0xC3, 0xEF, 0x87, 0xE0, 0xFC, 0x3E,
  0xF8, 0x7E, 0x0F, 0xC7, 0xC7, 0x87, 0xC0, 0xFC, 0x7C, 0x78, 0xFC, 0x0F,
  0xC7, 0xC7, 0x8F, 0xC0, 0xFC, 0xF8, 0x78, 0xF8, 0x07, 0xCF, 0x87, 0x9F,
  0x80, 0x7C, 0xF0, 0x79, 0xF8, 0x07, 0xDF, 0x07, 0x9F, 0x00, 0x7D, 0xF0,
  0x7F, 0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x07,
  0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x07, 0xFC, 0x07, 0xFC,
  0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x07, 0xF8, 0x07, 0xFC, 0x00, 0x7F, 0x80,
  0x7F, 0x80, 0x07, 0xF0, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x07,
  0xF0, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0xFE, 0x01, 0xFC, 0x01,
  0xFC, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0xFC, 0x07,
  0xF0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x7E, 0x0F,
  0xC0, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x3F, 0x3F,
  0x80, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x01, 0xFC, 0xFC,
  0x00, 0x03, 0xF8, 0xFC, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x07, 0xF0, 0x7E,
  0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0xC0, 0x7F,
  0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x80, 0x3F,
  0x80, 0x7F, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x1F,
  0xFF, 0x00, 0x0F, 0xEF, 0xE0, 0x03, 0xF3, 0xF8, 0x01, 0xFC, 0x7E, 0x00,
  0xFE, 0x1F, 0x80, 0x3F, 0x87, 0xE0, 0x1F, 0xC1, 0xF8, 0x07, 0xE0, 0x3F,
  0x03, 0xF8, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x7F, 0x00, 0xFC, 0x1F, 0x80,
  0x1F, 0x0F, 0xE0, 0x07, 0xE3, 0xF0, 0x01, 0xF9, 0xF8, 0x00, 0x7E, 0x7E,
  0x00, 0x0F, 0xBF, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80,
  0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xFF, 0x00,
  0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0xF8, 0x1F, 0x03,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x03, 0xE0, 0x7C,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F,
  0xE0, 0x1F, 0xF0, 0x1F, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x7F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xF0, 0x0F, 0xF8,
  0x07, 0xBC, 0x07, 0xDE, 0x03, 0xCF, 0x03, 0xE7, 0x81, 0xE3, 0xC1, 0xF1,
  0xF0, 0xF8, 0xF8, 0xF8, 0x7C, 0x7C, 0x1E, 0x7C, 0x0F, 0x3E, 0x07, 0xBE,
  0x03, 0xE0, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x7E, 0x0F, 0xE0, 0xFC, 0x0F, 0xC1, 0xF8, 0x1F, 0x01,
  0xF0, 0x1E, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x07, 0xF3, 0xFC, 0x7F, 0x07, 0xE3, 0xF0, 0x3F, 0x1F,
  0x81, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x0F, 0xFF,
  0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0x83, 0xF3, 0xF8,
  0x1F, 0x9F, 0x80, 0xFD, 0xF8, 0x0F, 0xCF, 0xC0, 0x7E, 0x7E, 0x03, 0xF3,
  0xF0, 0x1F, 0x9F, 0x81, 0xFC, 0xFF, 0x7F, 0xE3, 0xFF, 0xFF, 0x1F, 0xFF,
  0xF8, 0x7F, 0xEF, 0xC1, 0xFE, 0x7E, 0x01, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xEF, 0xF0,
  0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE,
  0x0F, 0xE0, 0x7E, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x7E, 0x0F, 0x80, 0x3E,
  0x1F, 0x80, 0x3E, 0x1F, 0x80, 0x3E, 0x1F, 0x80, 0x3E, 0x1F, 0x80, 0x7E,
  0x1F, 0x80, 0x7E, 0x1F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7E,
  0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7C, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC,
  0x7F, 0x01, 0xFC, 0x7F, 0x83, 0xF8, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0,
  0x7D, 0xFF, 0xE0, 0xFC, 0xFF, 0xC0, 0xFC, 0x7F, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x04, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xE1, 0xFC, 0x1F, 0x87, 0xE0, 0x3E, 0x3F, 0x00,
  0xF8, 0xFC, 0x03, 0xF3, 0xE0, 0x0F, 0xDF, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x03, 0xF1, 0xF0, 0x0F,
  0xC7, 0xE0, 0x7E, 0x1F, 0x81, 0xF8, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x01,
  0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x01, 0xFE, 0x3F, 0x00, 0xFF, 0xDF, 0x80, 0x7F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xF0, 0x7F, 0x83, 0xF8, 0x0F,
  0xC0, 0xFC, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x07, 0xE0,
  0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0xF8, 0x1F, 0x80, 0x7E, 0x07,
  0xE0, 0x1F, 0x81, 0xF0, 0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x7E,
  0x0F, 0xC0, 0x1F, 0x03, 0xF0, 0x0F, 0xC0, 0x7C, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xF0, 0x7F, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF8, 0x01, 0xFF, 0xBE, 0x00, 0x3F, 0xDF, 0x80, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC,
  0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xE1, 0xFC, 0x1F, 0x87, 0xE0, 0x3E, 0x3F,
  0x00, 0xFC, 0xFC, 0x03, 0xF3, 0xF0, 0x0F, 0xDF, 0x80, 0x3F, 0x7F, 0xFF,
  0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF9,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x0C, 0x1F, 0xC0, 0x70, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x81, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x07, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0xC0,
  0x7F, 0xF0, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8,
  0x7F, 0xFE, 0x1F, 0xFF, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x7F, 0x8F, 0xC0, 0x7F, 0xE7, 0xE0, 0x7F, 0xFB, 0xE0, 0x7F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0x83, 0xFC, 0x3F, 0x80, 0xFE, 0x1F, 0x80,
  0x3F, 0x0F, 0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0xC3, 0xF0,
  0x07, 0xE1, 0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0xF8, 0x3F,
  0x00, 0xFC, 0x1F, 0x00, 0x7E, 0x0F, 0x80, 0x3F, 0x07, 0xC0, 0x1F, 0x83,
  0xE0, 0x0F, 0xC1, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x7F, 0x07, 0xF0,
  0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFE,
  0x00, 0x7F, 0xBF, 0x00, 0x06, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x20, 0x07, 0xE0, 0x18, 0x07, 0xF0, 0x1E, 0x07, 0xF0, 0x1F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x04,
  0x00, 0x7E, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x07, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFC, 0x1F, 0xC1, 0xF8, 0x3F, 0x01, 0xF8, 0x7E, 0x03, 0xF1,
  0xF8, 0x07, 0xE3, 0xF0, 0x0F, 0xC7, 0xE0, 0x1F, 0x0F, 0xC0, 0x7E, 0x1F,
  0x80, 0xFC, 0x3F, 0x01, 0xF8, 0xFC, 0x03, 0xF1, 0xF8, 0x07, 0xE3, 0xF0,
  0x0F, 0x87, 0xE0, 0x3F, 0x0F, 0xC0, 0x7E, 0x1F, 0x00, 0xFC, 0x7E, 0x01,
  0xF8, 0xFC, 0x03, 0xF1, 0xF8, 0x07, 0xC3, 0xF0, 0x1F, 0x87, 0xE0, 0x3F,
  0x0F, 0x80, 0x7E, 0x3F, 0x00, 0xFC, 0x7E, 0x01, 0xF8, 0x01, 0xC0, 0x3E,
  0x03, 0xF0, 0x7F, 0x07, 0xF0, 0x3E, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x1F, 0x81, 0xF8,
  0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x07, 0x00, 0x03,
  0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xE0, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x07, 0xF8, 0x3F, 0x03, 0xF8, 0x1F, 0x83, 0xF8,
  0x1F, 0x83, 0xF8, 0x0F, 0xC3, 0xF8, 0x07, 0xE3, 0xF8, 0x03, 0xF3, 0xFC,
  0x01, 0xF9, 0xFC, 0x00, 0xFD, 0xFC, 0x00, 0xFD, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF,
  0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFD, 0xF8, 0x01, 0xFC, 0xFC, 0x00, 0xFC,
  0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x3E, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x1F,
  0x81, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x7F, 0x03, 0xF0, 0x1F, 0x83,
  0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xF0, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFC,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC1, 0xF8, 0x1F, 0x81, 0xF8,
  0x1F, 0x81, 0xF8, 0x1F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7C, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x04, 0x00, 0x7E,
  0xFF, 0x07, 0xF8, 0x07, 0xDF, 0xF8, 0xFF, 0xC0, 0x7F, 0xFF, 0xDF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xE0, 0xFF,
  0x87, 0xF0, 0xFC, 0x0F, 0xF0, 0x3F, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0xFC,
  0x07, 0xE0, 0x3F, 0x1F, 0x80, 0x7E, 0x03, 0xF1, 0xF8, 0x0F, 0xC0, 0x3F,
  0x1F, 0x80, 0xFC, 0x03, 0xF1, 0xF8, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0xFC,
  0x07, 0xE1, 0xF8, 0x0F, 0xC0, 0x7E, 0x3F, 0x00, 0xFC, 0x07, 0xE3, 0xF0,
  0x1F, 0x80, 0x7E, 0x3F, 0x01, 0xF8, 0x07, 0xE3, 0xF0, 0x1F, 0x80, 0xFC,
  0x3F, 0x01, 0xF8, 0x0F, 0xC3, 0xE0, 0x1F, 0x80, 0xFC, 0x7E, 0x01, 0xF8,
  0x0F, 0xC7, 0xE0, 0x3F, 0x00, 0xFC, 0x7E, 0x03, 0xF0, 0x0F, 0xC7, 0xE0,
  0x3F, 0x01, 0xF8, 0x7E, 0x03, 0xF0, 0x1F, 0x87, 0xC0, 0x3F, 0x01, 0xF8,
  0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x9F, 0xE0, 0x1F,
  0x7F, 0xE0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xF8,
  0x3F, 0x87, 0xE0, 0x3F, 0x0F, 0xC0, 0x7E, 0x1F, 0x00, 0xFC, 0x7E, 0x01,
  0xF8, 0xFC, 0x03, 0xE1, 0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0x87, 0xE0, 0x3F,
  0x1F, 0x80, 0x7E, 0x3F, 0x00, 0xFC, 0x7E, 0x01, 0xF0, 0xFC, 0x07, 0xE1,
  0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0x8F, 0xC0, 0x3F, 0x1F, 0x80, 0x7E, 0x3F,
  0x00, 0xF8, 0x7E, 0x03, 0xF0, 0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0xC7, 0xE0,
  0x1F, 0x8F, 0xC0, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x07,
  0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x07, 0xF0,
  0x7F, 0x0F, 0xC0, 0x7E, 0x3F, 0x00, 0xFC, 0x7E, 0x00, 0xF8, 0xFC, 0x01,
  0xFB, 0xF0, 0x03, 0xF7, 0xE0, 0x07, 0xEF, 0xC0, 0x0F, 0xDF, 0x80, 0x1F,
  0x3F, 0x00, 0x7E, 0x7E, 0x00, 0xFC, 0xFC, 0x01, 0xF9, 0xF0, 0x03, 0xF3,
  0xE0, 0x07, 0xE7, 0xE0, 0x1F, 0x8F, 0xC0, 0x3F, 0x1F, 0x80, 0xFC, 0x3F,
  0x83, 0xF8, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x7F,
  0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0xFF, 0x00, 0x1F, 0x7F, 0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0x83, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x03, 0xE0, 0x7E, 0x00, 0xF8, 0x1F, 0x80, 0x3E, 0x07,
  0xE0, 0x1F, 0x81, 0xF8, 0x07, 0xE0, 0x7E, 0x01, 0xF8, 0x1F, 0x00, 0x7E,
  0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x3F, 0x00,
  0xFC, 0x0F, 0xC0, 0x3F, 0x03, 0xE0, 0x0F, 0xC1, 0xFC, 0x07, 0xE0, 0x7F,
  0x83, 0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80,
  0x7C, 0xFF, 0xC0, 0x3F, 0x1F, 0xE0, 0x0F, 0xC0, 0xC0, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x10, 0x00, 0x01, 0xFE, 0x3F,
  0x03, 0xFF, 0x3E, 0x07, 0xFF, 0xBE, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE,
  0x1F, 0xC1, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC,
  0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xF8,
  0x7E, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x7C, 0x01, 0xF8, 0xFC, 0x01, 0xF8,
  0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF0, 0xFC, 0x03, 0xF0, 0x7E, 0x03, 0xF0,
  0x7E, 0x03, 0xF0, 0x7E, 0x07, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x0F, 0xF7, 0xE0, 0x01, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF7, 0xC1, 0xFF,
  0xE0, 0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0xFC, 0x3F, 0xFE, 0x1F, 0xC0, 0x0F,
  0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x07,
  0xFC, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x0F, 0xF3, 0xF8,
  0x7E, 0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0x01, 0xF8, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xCF, 0x80, 0x7E, 0x7C, 0x03, 0xF3, 0xF0, 0x1F, 0x9F, 0x81, 0xF8, 0xFE,
  0x1F, 0xC3, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0xFF, 0xC0,
  0x00, 0x60, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFE,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xFC, 0x1F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x01, 0xFC, 0x00, 0x80, 0x1F, 0x80, 0xFC, 0x7E, 0x03, 0xF1,
  0xF0, 0x0F, 0xCF, 0xC0, 0x3F, 0x3F, 0x00, 0xFC, 0xFC, 0x03, 0xE3, 0xF0,
  0x1F, 0x8F, 0xC0, 0x7E, 0x3E, 0x01, 0xF9, 0xF8, 0x07, 0xE7, 0xE0, 0x1F,
  0x9F, 0x80, 0xFC, 0x7E, 0x03, 0xF1, 0xF8, 0x0F, 0xC7, 0xC0, 0x3F, 0x3F,
  0x00, 0xFC, 0xFC, 0x03, 0xF3, 0xF0, 0x1F, 0x8F, 0xC0, 0x7E, 0x3F, 0x01,
  0xF8, 0xFC, 0x07, 0xE3, 0xF0, 0x3F, 0x8F, 0xC1, 0xFC, 0x3F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x07, 0xFB, 0xF0, 0x02,
  0x00, 0x00, 0xFC, 0x03, 0xF7, 0xE0, 0x1F, 0xBF, 0x01, 0xFD, 0xF8, 0x0F,
  0xCF, 0xC0, 0x7E, 0x3E, 0x07, 0xE1, 0xF0, 0x3F, 0x0F, 0x81, 0xF0, 0x7C,
  0x1F, 0x83, 0xE0, 0xFC, 0x1F, 0x8F, 0xC0, 0xFC, 0x7E, 0x07, 0xE3, 0xE0,
  0x1F, 0x3F, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0xFC, 0x01, 0xF7,
  0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x07, 0xC0, 0x7F, 0xF8, 0x0F, 0x80, 0xFF,
  0xF0, 0x3F, 0x03, 0xF7, 0xE0, 0x7E, 0x07, 0xEF, 0xC1, 0xFC, 0x0F, 0x8F,
  0x83, 0xF8, 0x3F, 0x1F, 0x07, 0xF0, 0x7E, 0x3E, 0x1F, 0xE0, 0xF8, 0x7C,
  0x3F, 0xC3, 0xF0, 0xF8, 0xFF, 0x87, 0xC1, 0xF1, 0xFF, 0x0F, 0x83, 0xE3,
  0xDF, 0x3F, 0x07, 0xCF, 0xBE, 0x7C, 0x0F, 0x9E, 0x7D, 0xF8, 0x1F, 0x7C,
  0xFB, 0xE0, 0x3E, 0xF9, 0xF7, 0xC0, 0x7F, 0xE3, 0xFF, 0x80, 0xFF, 0xC3,
  0xFE, 0x01, 0xFF, 0x07, 0xFC, 0x03, 0xFE, 0x0F, 0xF0, 0x07, 0xFC, 0x1F,
  0xE0, 0x0F, 0xF0, 0x3F, 0xC0, 0x1F, 0xE0, 0x7F, 0x00, 0x3F, 0x80, 0xFE,
  0x00, 0x7F, 0x01, 0xFC, 0x00, 0xFC, 0x03, 0xF0, 0x01, 0xF8, 0x07, 0xE0,
  0x01, 0xF0, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0xE0,
  0x3F, 0x03, 0xF0, 0x07, 0xC1, 0xFC, 0x01, 0xF8, 0xFE, 0x00, 0x7E, 0x3F,
  0x00, 0x0F, 0x9F, 0xC0, 0x03, 0xE7, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x1F,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xDF, 0x80, 0x07, 0xF7,
  0xE0, 0x01, 0xF8, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x7F, 0x0F, 0xC0, 0x1F,
  0x83, 0xF0, 0x0F, 0xE0, 0x7E, 0x07, 0xF0, 0x1F, 0x81, 0xFC, 0x07, 0xE0,
  0x07, 0xE0, 0x1F, 0xC1, 0xF8, 0x07, 0xE0, 0x7E, 0x03, 0xF8, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x7F, 0x00, 0xF8, 0x1F, 0x80, 0x3E, 0x07, 0xE0, 0x0F,
  0x83, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x7F, 0x00, 0x3F, 0x1F, 0x80,
  0x0F, 0xC7, 0xE0, 0x03, 0xF3, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x3F, 0x7E,
  0x00, 0x07, 0xDF, 0x80, 0x01, 0xF7, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x00, 0x01, 0x00, 0x03, 0x80,
  0x07, 0xE0, 0x07, 0xF0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F,
  0x80, 0x03, 0x80, 0x00, 0x40, 0x00, 0x01, 0xE0, 0x3C, 0x0F, 0x81, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x3E,
  0x07, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x03, 0xE0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x81, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x1F, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0x00, 0x80, 0x01, 0xE0,
  0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x7F,
  0x00, 0xFF, 0x01, 0xFC, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x40, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xF8, 0x03, 0xC7, 0xFE, 0x03, 0xE7, 0xFF, 0x81,
  0xF3, 0xFF, 0xE0, 0xF3, 0xF3, 0xF9, 0xF9, 0xF0, 0xFF, 0xFC, 0xF0, 0x3F,
  0xFC, 0xF8, 0x0F, 0xFC, 0x7C, 0x03, 0xFC, 0x00, 0x00, 0x7C, 0x00,
};

const GFXglyph RobotoCondensed_MediumItalic53pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 13, 39, 13, 1, -38 },
  { 65, 14, 14, 16, 4, -40 },
  { 90, 26, 38, 28, 2, -38 },
  { 214, 23, 51, 26, 2, -45 },
  { 361, 24, 40, 33, 5, -39 },
  { 481, 26, 40, 29, 1, -39 },
  { 611, 6, 13, 9, 4, -40 },
  { 621, 16, 54, 16, 3, -42 },
  { 729, 16, 54, 17, -2, -42 },
  { 837, 21, 22, 23, 3, -38 },
  { 895, 22, 28, 25, 2, -32 },
  { 972, 10, 15, 11, -3, -6 },
  { 991, 12, 5, 16, 2, -19 },
  { 999, 7, 8, 14, 1, -7 },
  { 1006, 24, 41, 18, -3, -38 },
  { 1129, 23, 40, 26, 2, -39 },
  { 1244, 15, 38, 26, 6, -38 },
  { 1316, 25, 39, 26, 0, -39 },
  { 1438, 24, 40, 26, 1, -39 },
  { 1558, 24, 38, 26, 0, -38 },
  { 1672, 24, 39, 26, 2, -38 },
  { 1789, 21, 39, 26, 2, -38 },
  { 1892, 24, 38, 26, 3, -38 },
  { 2006, 23, 40, 26, 2, -39 },
  { 2121, 20, 39, 26, 4, -39 },
  { 2219, 11, 30, 13, 1, -29 },
  { 2261, 14, 38, 12, -2, -29 },
  { 2328, 21, 25, 23, 1, -29 },
  { 2394, 22, 16, 25, 2, -25 },
  { 2438, 21, 24, 24, 1, -28 },
  { 2501, 19, 40, 22, 4, -39 },
  { 2596, 36, 49, 39, 1, -37 },
  { 2817, 29, 38, 30, -2, -38 },
  { 2955, 26, 38, 29, 1, -38 },
  { 3079, 27, 40, 29, 2, -39 },
  { 3214, 27, 38, 29, 1, -38 },
  { 3343, 26, 38, 25, 1, -38 },
  { 3467, 26, 38, 25, 1, -38 },
  { 3591, 27, 40, 30, 2, -39 },
  { 3726, 31, 38, 32, 1, -38 },
  { 3874, 13, 38, 13, 1, -38 },
  { 3936, 26, 39, 25, 0, -38 },
  { 4063, 31, 38, 28, 1, -38 },
  { 4211, 20, 38, 25, 1, -38 },
  { 4306, 38, 38, 39, 1, -38 },
  { 4487, 31, 38, 32, 1, -38 },
  { 4635, 28, 40, 31, 2, -39 },
  { 4775, 28, 38, 29, 1, -38 },
  { 4908, 28, 46, 31, 2, -39 },
  { 5069, 27, 38, 28, 1, -38 },
  { 5198, 26, 40, 27, 1, -39 },
  { 5328, 26, 38, 27, 4, -38 },
  { 5452, 28, 39, 29, 2, -38 },
  { 5589, 28, 38, 29, 4, -38 },
  { 5722, 36, 38, 39, 5, -38 },
  { 5893, 32, 38, 29, -1, -38 },
  { 6045, 26, 38, 27, 5, -38 },
  { 6169, 30, 38, 27, -1, -38 },
  { 6312, 18, 52, 13, -1, -44 },
  { 6429, 11, 41, 19, 5, -38 },
  { 6486, 17, 52, 13, -3, -44 },
  { 6597, 17, 19, 20, 2, -38 },
  { 6638, 20, 5, 21, -3, 0 },
  { 6651, 11, 8, 17, 5, -40 },
  { 6662, 21, 30, 24, 1, -29 },
  { 6741, 24, 41, 25, 0, -40 },
  { 6864, 22, 30, 24, 1, -29 },
  { 6947, 26, 41, 25, 1, -40 },
  { 7081, 22, 30, 24, 1, -29 },
  { 7164, 18, 41, 17, 2, -41 },
  { 7257, 25, 40, 26, 0, -29 },
  { 7382, 23, 40, 25, 0, -40 },
  { 7497, 12, 39, 12, 1, -39 },
  { 7556, 18, 50, 12, -5, -39 },
  { 7669, 25, 40, 24, 0, -40 },
  { 7794, 12, 40, 12, 1, -40 },
  { 7854, 36, 29, 38, 0, -29 },
  { 7985, 23, 29, 25, 0, -29 },
  { 8069, 23, 30, 26, 1, -29 },
  { 8156, 26, 40, 25, -2, -29 },
  { 8286, 24, 40, 26, 1, -29 },
  { 8406, 17, 29, 16, 0, -29 },
  { 8468, 21, 30, 23, 1, -29 },
  { 8547, 14, 36, 16, 2, -35 },
  { 8610, 22, 29, 25, 2, -28 },
  { 8690, 21, 28, 23, 3, -28 },
  { 8764, 31, 28, 33, 3, -28 },
  { 8873, 26, 28, 23, -2, -28 },
  { 8964, 26, 39, 22, -2, -28 },
  { 9091, 24, 28, 23, -1, -28 },
  { 9175, 17, 50, 16, 1, -41 },
  { 9282, 11, 45, 13, 1, -38 },
  { 9344, 16, 50, 16, -2, -41 },
  { 9444, 25, 11, 29, 2, -21 },
};

const GFXfont RobotoCondensed_MediumItalic53pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_MediumItalic53pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_MediumItalic53pt7bGlyphs,
  0x20, 0x7E, 62
};

#endif // _ROBOTOCONDENSED_MEDIUMITALIC53PT7B_H_
