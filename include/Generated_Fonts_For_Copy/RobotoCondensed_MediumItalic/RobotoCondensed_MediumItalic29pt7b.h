#ifndef _ROBOTOCONDENSED_MEDIUMITALIC29PT7B_H_
#define _ROBOTOCONDENSED_MEDIUMITALIC29PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-MediumItalic.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_MediumItalic29pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0x71, 0xCF, 0x3C, 0xE3, 0x8E, 0x38, 0xE7, 0x1C, 0x71, 0xC0,
  0x00, 0x03, 0x8E, 0x38, 0xE0, 0x77, 0x77, 0x66, 0x66, 0x66, 0xE6, 0xCC,
  0x01, 0x8C, 0x06, 0x60, 0x39, 0x80, 0xC6, 0x03, 0x38, 0x0C, 0xC3, 0xFF,
  0xCF, 0xFF, 0x06, 0x60, 0x31, 0x80, 0xCE, 0x03, 0x30, 0x1C, 0xC3, 0xFF,
  0xCF, 0xFF, 0x0E, 0x60, 0x33, 0x80, 0xCC, 0x07, 0x30, 0x19, 0xC0, 0x66,
  0x00, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x0F, 0x80, 0xFE, 0x0F, 0xF8, 0x71,
  0xC7, 0x8E, 0x38, 0x79, 0xC3, 0xCF, 0x00, 0x78, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x3C, 0x00, 0xE7, 0x07, 0x38, 0x39, 0xC1, 0xCF, 0x1E, 0x3F,
  0xE1, 0xFE, 0x03, 0xE0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x38, 0x03, 0xE0,
  0x39, 0x81, 0x8C, 0x6C, 0x67, 0x63, 0x33, 0x1B, 0x19, 0xB8, 0xFD, 0x83,
  0xD8, 0x01, 0xC0, 0x1D, 0xC0, 0xDF, 0x0D, 0xCC, 0xEC, 0x66, 0x63, 0x63,
  0x1F, 0x19, 0xD0, 0xCC, 0x07, 0xE0, 0x1E, 0x00, 0x03, 0xC0, 0x3F, 0x81,
  0xFE, 0x07, 0x1C, 0x1C, 0x70, 0x71, 0xC1, 0xCE, 0x07, 0x70, 0x1F, 0xC0,
  0x3C, 0x01, 0xF0, 0x0F, 0xC6, 0x77, 0xBB, 0xCE, 0xEE, 0x3F, 0xB8, 0x7C,
  0xE1, 0xF3, 0x87, 0x8F, 0xFF, 0x1F, 0xFC, 0x3E, 0x78, 0x77, 0x66, 0xEE,
  0xC0, 0x00, 0x80, 0xC0, 0xE0, 0xE0, 0xE0, 0x70, 0x70, 0x38, 0x38, 0x1C,
  0x0C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x60, 0x70, 0x38, 0x1C, 0x0E,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x38, 0x0C, 0x07, 0x01, 0x80, 0x40, 0x08,
  0x06, 0x03, 0x80, 0xC0, 0x70, 0x38, 0x0C, 0x06, 0x03, 0x01, 0xC0, 0xE0,
  0x70, 0x38, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC1, 0xC0, 0xE0, 0x70,
  0x70, 0x38, 0x38, 0x1C, 0x1C, 0x1C, 0x0C, 0x04, 0x00, 0x03, 0x80, 0x30,
  0x03, 0x04, 0x31, 0x7B, 0xF7, 0xFF, 0x0F, 0x80, 0xF0, 0x1F, 0x83, 0x98,
  0x71, 0xC2, 0x08, 0x03, 0x80, 0x78, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xE0,
  0x1C, 0x00, 0x1C, 0x71, 0xCE, 0x39, 0xC7, 0x18, 0xFF, 0xFF, 0xF0, 0xEE,
  0xFE, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03,
  0x00, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x00,
  0x38, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x38,
  0x01, 0x80, 0x00, 0x07, 0xC0, 0xFE, 0x1F, 0xF1, 0xC7, 0x38, 0x73, 0x87,
  0x78, 0x77, 0x07, 0x70, 0x77, 0x07, 0x70, 0x77, 0x07, 0xF0, 0xFF, 0x0E,
  0xE0, 0xEE, 0x0E, 0xE1, 0xE7, 0x1C, 0x7F, 0xC3, 0xF8, 0x1E, 0x00, 0x01,
  0x0F, 0x3F, 0x7F, 0x77, 0xCF, 0x0E, 0x0E, 0x0E, 0x0E, 0x1E, 0x1E, 0x1C,
  0x1C, 0x1C, 0x1C, 0x3C, 0x3C, 0x38, 0x38, 0x38, 0x03, 0xE0, 0x1F, 0xC0,
  0xFF, 0x87, 0x8E, 0x1C, 0x38, 0xF0, 0xE3, 0x83, 0x80, 0x0E, 0x00, 0x78,
  0x03, 0xC0, 0x0E, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0xFF, 0x3F, 0xFC, 0xFF, 0xF0, 0x07, 0xC1, 0xFE,
  0x1F, 0xF3, 0xC7, 0x38, 0x77, 0x87, 0x00, 0x70, 0x07, 0x00, 0xE0, 0xFE,
  0x0F, 0x80, 0xFC, 0x01, 0xE0, 0x0E, 0x00, 0xEE, 0x0E, 0xE1, 0xEE, 0x1C,
  0xFF, 0xC7, 0xF8, 0x3E, 0x00, 0x00, 0x38, 0x03, 0xC0, 0x3E, 0x01, 0xF0,
  0x1F, 0x81, 0xF8, 0x1D, 0xC0, 0xEE, 0x0E, 0x70, 0xE7, 0x87, 0x3C, 0x71,
  0xC7, 0x8E, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0x0F, 0xF8, 0x7F, 0xC7, 0xFE, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0xE0, 0x07, 0xF0, 0x3F, 0xC1, 0xFF, 0x0C, 0x38, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xDC, 0x1C, 0xE0, 0xE3, 0x8F, 0x1F, 0xF0, 0x7F,
  0x01, 0xF0, 0x00, 0x00, 0xE0, 0x3E, 0x0F, 0xE0, 0xF0, 0x1E, 0x03, 0xC0,
  0x38, 0x03, 0xFC, 0x7F, 0xE7, 0xFE, 0x78, 0xE7, 0x0F, 0x70, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0E, 0x70, 0xE7, 0x1E, 0x7F, 0xC3, 0xF8, 0x1F, 0x00, 0x3F,
  0xFC, 0xFF, 0xF3, 0xFF, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00,
  0x78, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00,
  0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x00,
  0x07, 0xC0, 0x7F, 0x07, 0xFC, 0x38, 0xE3, 0xC7, 0x1C, 0x38, 0xE1, 0xC7,
  0x0E, 0x3C, 0xF0, 0xFF, 0x07, 0xF0, 0x7F, 0x87, 0x9E, 0x78, 0x73, 0x83,
  0x9C, 0x1C, 0xE0, 0xE7, 0x8F, 0x3F, 0xF0, 0xFF, 0x01, 0xF0, 0x00, 0x0F,
  0x83, 0xF8, 0xFF, 0x3C, 0xF7, 0x0F, 0xE1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0xC7, 0xBF, 0xF7, 0xFC, 0x7B, 0x80, 0x70, 0x1C, 0x07, 0x81, 0xE1,
  0xF8, 0x3E, 0x07, 0x00, 0x18, 0xF3, 0xCE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x63, 0x8E, 0x38, 0x0E, 0x1C, 0x78, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x0E, 0x1C, 0x38, 0xE1, 0xC7, 0x04, 0x00, 0x00,
  0x20, 0x1C, 0x0F, 0x87, 0xE3, 0xF9, 0xFC, 0x3E, 0x07, 0x80, 0xFC, 0x0F,
  0xC0, 0x7E, 0x03, 0xC0, 0x38, 0x01, 0x00, 0x3F, 0xF3, 0xFF, 0x7F, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xE7, 0xFE, 0xFF, 0xC0, 0x20, 0x06, 0x00,
  0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0x78, 0x1F, 0x0F, 0xE7, 0xF3, 0xF8,
  0x7C, 0x0E, 0x01, 0x00, 0x00, 0x1F, 0x0F, 0xE7, 0xFF, 0xC7, 0xF1, 0xC0,
  0x70, 0x1C, 0x0F, 0x07, 0x83, 0xC0, 0xF0, 0x78, 0x3C, 0x0E, 0x03, 0x80,
  0x00, 0x00, 0x0C, 0x07, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x7E, 0x00, 0x3F,
  0xF0, 0x0F, 0x0F, 0x03, 0x80, 0x60, 0xC0, 0x06, 0x38, 0x00, 0xCE, 0x1E,
  0x19, 0x87, 0xF3, 0x71, 0xCE, 0x6C, 0x71, 0x8D, 0x8C, 0x31, 0xF1, 0x86,
  0x3C, 0x71, 0xC7, 0x8E, 0x30, 0xF1, 0x86, 0x1E, 0x31, 0xC6, 0xC6, 0x38,
  0xD8, 0xEF, 0x33, 0x1F, 0x7E, 0x61, 0xC7, 0x0C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC3, 0x00, 0x1F, 0xF0, 0x01, 0xF8, 0x00, 0x00, 0x38,
  0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xDC, 0x01, 0xDC,
  0x03, 0x9C, 0x03, 0x9C, 0x07, 0x9C, 0x07, 0x1C, 0x0F, 0x1C, 0x0E, 0x1C,
  0x1F, 0xFE, 0x1F, 0xFE, 0x3F, 0xFE, 0x38, 0x0E, 0x38, 0x0E, 0x78, 0x0E,
  0x70, 0x0E, 0xF0, 0x0F, 0x0F, 0xF0, 0x1F, 0xF8, 0x3F, 0xF0, 0xF0, 0xF1,
  0xE0, 0xE3, 0x81, 0xC7, 0x07, 0x8E, 0x0F, 0x3C, 0x3C, 0x7F, 0xF0, 0xFF,
  0xC1, 0xFF, 0xC3, 0x83, 0x87, 0x07, 0x9E, 0x0F, 0x3C, 0x1E, 0x78, 0x38,
  0xE0, 0xF1, 0xFF, 0xC3, 0xFF, 0x8F, 0xFC, 0x00, 0x03, 0xF0, 0x0F, 0xF0,
  0x3F, 0xF0, 0xF0, 0xE3, 0xC1, 0xE7, 0x01, 0xCE, 0x03, 0xBC, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x0E,
  0x78, 0x1C, 0x70, 0x78, 0xF0, 0xE1, 0xFF, 0xC1, 0xFF, 0x00, 0xF8, 0x00,
  0x0F, 0xE0, 0x1F, 0xF0, 0x3F, 0xF0, 0xF0, 0xE1, 0xE1, 0xE3, 0x81, 0xC7,
  0x03, 0x8E, 0x07, 0x3C, 0x0E, 0x78, 0x1C, 0xF0, 0x79, 0xC0, 0xF3, 0x81,
  0xE7, 0x03, 0x9E, 0x07, 0x3C, 0x1E, 0x78, 0x38, 0xE1, 0xF1, 0xFF, 0xC3,
  0xFF, 0x0F, 0xF8, 0x00, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0xF0, 0x01,
  0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x7F, 0xE0, 0xFF,
  0xC1, 0xFF, 0x83, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xE0, 0x01, 0xFF, 0xC3, 0xFF, 0x8F, 0xFF, 0x00, 0x0F, 0xFE, 0x1F, 0xF8,
  0x3F, 0xF0, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x3C,
  0x00, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0x80, 0x07, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x00,
  0x03, 0xF0, 0x0F, 0xF0, 0x3F, 0xF0, 0xF0, 0xE3, 0xC1, 0xE7, 0x01, 0xCE,
  0x03, 0xBC, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC3, 0xF3, 0x87, 0xEF, 0x1F,
  0xDE, 0x07, 0xBC, 0x0F, 0x38, 0x1E, 0x70, 0x38, 0xF0, 0xF0, 0xFF, 0xE1,
  0xFF, 0x80, 0xFC, 0x00, 0x0E, 0x03, 0xC3, 0x80, 0xE0, 0xE0, 0x38, 0x78,
  0x0E, 0x1E, 0x07, 0x87, 0x01, 0xE1, 0xC0, 0x70, 0x70, 0x1C, 0x3C, 0x07,
  0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xFC, 0x38, 0x0E, 0x0E, 0x03, 0x87,
  0x80, 0xE1, 0xE0, 0x38, 0x78, 0x1E, 0x1C, 0x07, 0x87, 0x01, 0xC1, 0xC0,
  0x70, 0xF0, 0x1C, 0x00, 0x1C, 0x71, 0xCF, 0x3C, 0xF3, 0x8E, 0x39, 0xE7,
  0x9C, 0x71, 0xC7, 0x3C, 0xF3, 0x8E, 0x38, 0xE0, 0x00, 0x1C, 0x00, 0xF0,
  0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x3C, 0x38,
  0xF0, 0xE3, 0xC7, 0x87, 0xFC, 0x1F, 0xE0, 0x1F, 0x00, 0x0E, 0x07, 0x87,
  0x07, 0x83, 0x87, 0x83, 0xC7, 0xC1, 0xE3, 0xC0, 0xE3, 0xC0, 0x73, 0xC0,
  0x3B, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFE,
  0x01, 0xE7, 0x01, 0xE3, 0xC0, 0xF1, 0xE0, 0x78, 0x70, 0x38, 0x3C, 0x1C,
  0x1E, 0x0E, 0x07, 0x0F, 0x03, 0xC0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xE0,
  0x1E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x00, 0x7F, 0xF7, 0xFE,
  0xFF, 0xE0, 0x0F, 0x00, 0x78, 0x3C, 0x03, 0xE0, 0xF0, 0x0F, 0x87, 0xE0,
  0x3E, 0x1F, 0x81, 0xF8, 0x7E, 0x07, 0xE1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x3F, 0x87, 0x70, 0xF6, 0x1D, 0xC3, 0x98, 0xEF, 0x0E, 0x63, 0xBC, 0x39,
  0xCC, 0xE0, 0xE7, 0x73, 0x87, 0x9D, 0x8E, 0x1E, 0x7E, 0x38, 0x79, 0xF9,
  0xE1, 0xC3, 0xC7, 0x87, 0x0F, 0x1C, 0x1C, 0x38, 0x70, 0xF0, 0xE1, 0xC0,
  0x0E, 0x03, 0x83, 0xC0, 0xE0, 0xF0, 0x38, 0x7C, 0x0E, 0x1F, 0x87, 0x87,
  0xE1, 0xE1, 0xF8, 0x70, 0x76, 0x1C, 0x3D, 0xC7, 0x0F, 0x71, 0xC3, 0xCC,
  0xF0, 0xE3, 0xBC, 0x38, 0xEE, 0x0E, 0x1B, 0x87, 0x86, 0xE1, 0xE1, 0xF8,
  0x78, 0x7E, 0x1C, 0x0F, 0x87, 0x03, 0xC1, 0xC0, 0xF0, 0xF0, 0x1C, 0x00,
  0x03, 0xF0, 0x0F, 0xF0, 0x3F, 0xF0, 0xF0, 0xF3, 0xC1, 0xE7, 0x01, 0xCE,
  0x03, 0xBC, 0x07, 0x70, 0x0E, 0xE0, 0x1D, 0xC0, 0x7B, 0x80, 0xFF, 0x01,
  0xDE, 0x03, 0xBC, 0x07, 0x38, 0x1E, 0x70, 0x38, 0xF0, 0xF0, 0xFF, 0xC1,
  0xFF, 0x00, 0xF8, 0x00, 0x0F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFE, 0x1E, 0x0E,
  0x1E, 0x0F, 0x1C, 0x0F, 0x1C, 0x0F, 0x1C, 0x0F, 0x3C, 0x0E, 0x3C, 0x1E,
  0x3F, 0xFC, 0x3F, 0xF8, 0x3F, 0xE0, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0x03, 0xF0,
  0x0F, 0xF0, 0x3F, 0xF0, 0xF0, 0xE3, 0xC1, 0xE7, 0x01, 0xDE, 0x03, 0xBC,
  0x07, 0x70, 0x0E, 0xE0, 0x3D, 0xC0, 0x7B, 0x80, 0xFF, 0x01, 0xDE, 0x03,
  0xBC, 0x07, 0x78, 0x1E, 0x70, 0x38, 0xF0, 0xF1, 0xFF, 0xC1, 0xFF, 0x00,
  0xFE, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x20, 0x0F, 0xF0, 0x1F,
  0xF8, 0x3F, 0xF0, 0xF0, 0xF1, 0xE0, 0xE3, 0x81, 0xC7, 0x03, 0x8E, 0x0F,
  0x1C, 0x1E, 0x78, 0x78, 0xFF, 0xE1, 0xFF, 0x83, 0xFE, 0x07, 0x1C, 0x1E,
  0x3C, 0x3C, 0x78, 0x78, 0x70, 0xE0, 0xF1, 0xC1, 0xE3, 0x83, 0xCF, 0x03,
  0x80, 0x03, 0xE0, 0x3F, 0xC1, 0xFF, 0x8F, 0x0F, 0x3C, 0x3C, 0xE0, 0x73,
  0x80, 0x0F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF0,
  0x01, 0xCE, 0x07, 0x38, 0x1C, 0xE0, 0x73, 0xC3, 0xC7, 0xFE, 0x0F, 0xF0,
  0x1F, 0x00, 0x7F, 0xFD, 0xFF, 0xFF, 0xFF, 0xC1, 0xE0, 0x07, 0x80, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x3C, 0x00, 0x1C, 0x0E, 0x3C, 0x0E, 0x3C, 0x0E, 0x38, 0x0E, 0x38,
  0x1E, 0x38, 0x1E, 0x38, 0x1C, 0x78, 0x1C, 0x78, 0x1C, 0x70, 0x1C, 0x70,
  0x3C, 0x70, 0x3C, 0x70, 0x38, 0xF0, 0x38, 0xF0, 0x38, 0xF0, 0x78, 0xF0,
  0x78, 0xF0, 0xF0, 0x7F, 0xE0, 0x3F, 0xC0, 0x1F, 0x80, 0xF0, 0x0E, 0x70,
  0x1E, 0x70, 0x1E, 0x70, 0x3C, 0x70, 0x3C, 0x70, 0x38, 0x78, 0x78, 0x78,
  0x70, 0x78, 0xF0, 0x38, 0xE0, 0x38, 0xE0, 0x39, 0xE0, 0x39, 0xC0, 0x3B,
  0xC0, 0x3B, 0x80, 0x3B, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0xE0, 0xE0, 0xEE, 0x0E, 0x0E, 0xE1, 0xE1, 0xEE, 0x1E,
  0x1C, 0xE1, 0xE1, 0xCE, 0x3E, 0x3C, 0xE3, 0xE3, 0x8E, 0x36, 0x38, 0xE7,
  0x63, 0x8E, 0x76, 0x70, 0xEE, 0x67, 0x0E, 0xE6, 0x70, 0xEE, 0x6E, 0x0F,
  0xC6, 0xE0, 0xFC, 0x7E, 0x0F, 0x87, 0xC0, 0xF8, 0x7C, 0x0F, 0x87, 0xC0,
  0xF0, 0x78, 0x0F, 0x07, 0x80, 0xF0, 0x78, 0x00, 0x0F, 0x03, 0xC3, 0xC1,
  0xE0, 0x70, 0xF0, 0x1C, 0x3C, 0x07, 0x9E, 0x00, 0xE7, 0x00, 0x3B, 0xC0,
  0x0E, 0xE0, 0x03, 0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x01, 0xFC, 0x00, 0xF7, 0x00, 0x3D, 0xE0, 0x1E, 0x38, 0x0F, 0x0E,
  0x03, 0xC3, 0xC1, 0xE0, 0xF0, 0x78, 0x1C, 0x00, 0x70, 0x1E, 0xE0, 0x79,
  0xE0, 0xE3, 0xC3, 0xC3, 0x87, 0x07, 0x1E, 0x0E, 0x38, 0x1C, 0xF0, 0x1D,
  0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x00,
  0x1F, 0xFF, 0x1F, 0xFE, 0x1F, 0xFE, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0x70, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00,
  0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xF0, 0x0F, 0x87, 0xC3, 0xE1, 0xC1, 0xE0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x0F, 0x07, 0x83, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x3C, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC1, 0xE0, 0xF0, 0x70, 0x3E,
  0x1F, 0x0F, 0x80, 0xE3, 0x8E, 0x38, 0xE3, 0x8F, 0x1C, 0x71, 0xC7, 0x1C,
  0x71, 0xC3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xF1, 0xC0, 0x07, 0xC1, 0xF0,
  0xF8, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x1E, 0x07, 0x81, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0xF0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x1E, 0x07,
  0x81, 0xC0, 0x70, 0x1C, 0x07, 0x07, 0xC1, 0xF0, 0xF8, 0x00, 0x07, 0x03,
  0x83, 0xC3, 0xE1, 0xB1, 0xD8, 0xEE, 0xE7, 0x73, 0xF0, 0xC0, 0x7F, 0xE7,
  0xFE, 0xFF, 0xE0, 0xF1, 0xC3, 0x86, 0x07, 0xC0, 0xFE, 0x1F, 0xF3, 0xC7,
  0x38, 0x70, 0x07, 0x0F, 0xF3, 0xFF, 0x7C, 0xE7, 0x0E, 0x70, 0xE7, 0x0E,
  0x71, 0xE7, 0xFE, 0x7F, 0xE3, 0xCE, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x3C,
  0x01, 0xC0, 0x0E, 0x00, 0x77, 0x83, 0xFE, 0x3F, 0xF1, 0xE3, 0xCE, 0x0E,
  0x70, 0x73, 0x83, 0x9C, 0x1D, 0xE1, 0xEE, 0x0E, 0x70, 0x73, 0x83, 0x9E,
  0x3C, 0xFF, 0xCF, 0xFC, 0x73, 0xC0, 0x0F, 0x83, 0xF8, 0xFF, 0xBC, 0x77,
  0x0F, 0xE1, 0xF8, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0xEE, 0x1D,
  0xFF, 0x9F, 0xE1, 0xF0, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x01, 0xE0, 0xF7, 0x0F, 0xFC, 0x3F, 0xF1, 0xE3, 0xC7, 0x0F, 0x3C,
  0x3C, 0xE0, 0xE3, 0x83, 0x8E, 0x0E, 0x38, 0x38, 0xE0, 0xE3, 0x87, 0x8E,
  0x1C, 0x3F, 0xF0, 0x7F, 0xC0, 0xF7, 0x00, 0x0F, 0x83, 0xF8, 0xFF, 0xBC,
  0x77, 0x0F, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0x80, 0x70, 0x0F,
  0x08, 0xFF, 0x9F, 0xE0, 0xF8, 0x03, 0xC1, 0xF0, 0xFC, 0x78, 0x1C, 0x07,
  0x07, 0xF1, 0xFC, 0xFF, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x07, 0x81,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0xF0, 0x38, 0x00, 0x07, 0x9C, 0x7F,
  0xE1, 0xFF, 0x8F, 0x1E, 0x38, 0x39, 0xE1, 0xE7, 0x07, 0x9C, 0x1C, 0x70,
  0x71, 0xC1, 0xC7, 0x07, 0x1C, 0x3C, 0x78, 0xF1, 0xFF, 0x83, 0xFE, 0x07,
  0xB8, 0x00, 0xE0, 0x07, 0x84, 0x1C, 0x3F, 0xF0, 0xFF, 0x80, 0xF8, 0x00,
  0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1D, 0xE1, 0xFF,
  0x3F, 0xF3, 0xC7, 0x38, 0x73, 0x87, 0x38, 0x73, 0x87, 0x78, 0x77, 0x07,
  0x70, 0xF7, 0x0E, 0x70, 0xE7, 0x0E, 0xF0, 0xEE, 0x0E, 0x0C, 0x1C, 0x38,
  0x70, 0x00, 0x07, 0x0E, 0x1C, 0x78, 0xE1, 0xC3, 0x87, 0x0E, 0x3C, 0x70,
  0xE1, 0xC3, 0x87, 0x1E, 0x00, 0x01, 0x80, 0xF0, 0x3C, 0x06, 0x00, 0x00,
  0x00, 0x38, 0x0E, 0x07, 0x81, 0xE0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0xF0,
  0x3C, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x1E, 0x07, 0x81, 0xC0, 0x70, 0x1C,
  0x3F, 0x0F, 0x83, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1C,
  0x00, 0x70, 0x01, 0xC7, 0x87, 0x1E, 0x3C, 0xF0, 0xF7, 0x83, 0xBC, 0x0F,
  0xE0, 0x3F, 0x00, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0x7B, 0x81, 0xCF, 0x07,
  0x1C, 0x1C, 0x78, 0xF1, 0xE3, 0x83, 0x80, 0x0E, 0x1C, 0x38, 0xF1, 0xE3,
  0x87, 0x0E, 0x1C, 0x78, 0xF1, 0xC3, 0x87, 0x0E, 0x3C, 0x78, 0xE1, 0xC3,
  0x87, 0x1E, 0x00, 0x1D, 0xE3, 0xC1, 0xFF, 0x7E, 0x3F, 0xFF, 0xE3, 0xC7,
  0x8F, 0x38, 0x78, 0xF3, 0x87, 0x0F, 0x38, 0x70, 0xE3, 0x87, 0x0E, 0x78,
  0x70, 0xE7, 0x0F, 0x0E, 0x70, 0xF0, 0xE7, 0x0E, 0x1E, 0x70, 0xE1, 0xC7,
  0x0E, 0x1C, 0xF0, 0xE1, 0xCE, 0x1E, 0x1C, 0x1D, 0xE3, 0xFF, 0x3F, 0xF3,
  0xC7, 0x38, 0x73, 0x87, 0x38, 0x77, 0x87, 0x78, 0x77, 0x07, 0x70, 0xF7,
  0x0E, 0x70, 0xEF, 0x0E, 0xF0, 0xEE, 0x0E, 0x0F, 0x81, 0xFC, 0x3F, 0xE7,
  0x8F, 0x70, 0x7F, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0xEE,
  0x0E, 0xF1, 0xE7, 0xFC, 0x7F, 0x81, 0xE0, 0x0E, 0xF0, 0x3F, 0xE1, 0xFF,
  0x87, 0x8F, 0x1C, 0x1C, 0x70, 0x71, 0xC1, 0xC7, 0x0F, 0x3C, 0x3C, 0xE0,
  0xE3, 0x83, 0x8E, 0x0E, 0x3C, 0x78, 0xFF, 0xC7, 0xFE, 0x1C, 0xF0, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x00, 0x0F, 0x73,
  0xFF, 0x7F, 0xF7, 0x8F, 0x70, 0xFF, 0x0F, 0xE0, 0xEE, 0x0E, 0xE0, 0xEE,
  0x0E, 0xE1, 0xEE, 0x1E, 0xE1, 0xCF, 0xFC, 0x7F, 0xC3, 0xDC, 0x03, 0xC0,
  0x3C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x1D, 0xC7, 0xE3, 0xF8, 0xF8,
  0x3C, 0x0E, 0x03, 0x80, 0xE0, 0x78, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x0F, 0x03, 0x80, 0x07, 0x81, 0xFE, 0x1F, 0xF3, 0x87, 0x38, 0x73, 0x80,
  0x3E, 0x01, 0xF8, 0x0F, 0xC0, 0x3E, 0x01, 0xEE, 0x0E, 0x71, 0xE7, 0xFC,
  0x3F, 0x81, 0xF0, 0x1C, 0x1C, 0x1C, 0xFF, 0xFF, 0xFE, 0x38, 0x38, 0x38,
  0x78, 0x78, 0x70, 0x70, 0x70, 0x70, 0x70, 0x7C, 0x78, 0x38, 0x38, 0x77,
  0x87, 0x78, 0x77, 0x07, 0x70, 0xF7, 0x0E, 0x70, 0xEF, 0x0E, 0xF0, 0xEE,
  0x0E, 0xE1, 0xEE, 0x1C, 0xE1, 0xCF, 0xFC, 0x7F, 0xC3, 0xDC, 0xE1, 0xFC,
  0x3B, 0x87, 0x71, 0xEE, 0x39, 0xC7, 0x39, 0xC7, 0x38, 0x6E, 0x0D, 0xC1,
  0xF8, 0x3E, 0x07, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0xE1, 0x87, 0x71, 0xC3,
  0xB8, 0xF1, 0xDC, 0x79, 0xCE, 0x7C, 0xE7, 0x3E, 0x73, 0xBF, 0x71, 0xDF,
  0xB8, 0xED, 0xD8, 0x7E, 0x7C, 0x3E, 0x3E, 0x1F, 0x1E, 0x0F, 0x8F, 0x07,
  0x87, 0x83, 0xC3, 0x81, 0xC1, 0xC0, 0x1C, 0x3C, 0x78, 0xE0, 0xE7, 0x83,
  0xBC, 0x0E, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x3F, 0x00,
  0xFC, 0x07, 0x70, 0x3D, 0xE0, 0xE3, 0x87, 0x8E, 0x3C, 0x38, 0x1C, 0x3C,
  0x70, 0xE1, 0xC7, 0x87, 0x1E, 0x1C, 0x70, 0x73, 0xC1, 0xCE, 0x07, 0x38,
  0x1D, 0xC0, 0x37, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0,
  0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xC0,
  0x00, 0x3F, 0xF3, 0xFF, 0x3F, 0xF0, 0x0E, 0x01, 0xC0, 0x3C, 0x07, 0x80,
  0x70, 0x0E, 0x01, 0xE0, 0x3C, 0x03, 0x80, 0x78, 0x0F, 0xFC, 0xFF, 0xCF,
  0xFC, 0x01, 0x01, 0xC1, 0xC1, 0xC0, 0xE0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x0F, 0x07, 0x0F, 0x87, 0x03, 0x80, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x18, 0x0E, 0x03, 0x00, 0x0C, 0x18, 0x30,
  0x60, 0xC3, 0x87, 0x0C, 0x18, 0x30, 0x60, 0xC3, 0x87, 0x0C, 0x18, 0x30,
  0x61, 0xC3, 0x86, 0x0C, 0x18, 0x30, 0x60, 0x08, 0x06, 0x03, 0x80, 0xC0,
  0x70, 0x38, 0x1C, 0x0E, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0x78, 0x1C, 0x1E,
  0x1C, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC1, 0xC0, 0xE0, 0x70, 0x70, 0x38,
  0x38, 0x18, 0x00, 0x1C, 0x1C, 0xFC, 0x77, 0xF1, 0x98, 0xFE, 0xE1, 0xF0,
  0x03, 0x80,
};

const GFXglyph RobotoCondensed_MediumItalic29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 6, 21, 7, 1, -21 },
  { 17, 8, 7, 9, 2, -22 },
  { 24, 14, 21, 15, 1, -21 },
  { 61, 13, 27, 14, 1, -24 },
  { 105, 13, 21, 18, 3, -21 },
  { 140, 14, 21, 16, 1, -21 },
  { 177, 4, 7, 5, 2, -22 },
  { 181, 9, 30, 9, 1, -23 },
  { 215, 9, 30, 9, -1, -23 },
  { 249, 12, 12, 12, 1, -21 },
  { 267, 12, 15, 14, 1, -17 },
  { 290, 6, 8, 6, -2, -3 },
  { 296, 7, 3, 9, 1, -10 },
  { 299, 4, 4, 8, 1, -4 },
  { 301, 13, 23, 10, -2, -21 },
  { 339, 12, 21, 14, 1, -21 },
  { 371, 8, 21, 14, 3, -21 },
  { 392, 14, 21, 14, 0, -21 },
  { 429, 12, 21, 14, 1, -21 },
  { 461, 13, 21, 14, 0, -21 },
  { 496, 13, 21, 14, 1, -21 },
  { 531, 12, 21, 14, 1, -21 },
  { 563, 14, 21, 14, 1, -21 },
  { 600, 13, 21, 14, 1, -21 },
  { 635, 11, 21, 14, 2, -21 },
  { 664, 6, 16, 7, 1, -16 },
  { 676, 7, 21, 7, -1, -16 },
  { 695, 11, 14, 13, 1, -16 },
  { 715, 12, 9, 14, 1, -14 },
  { 729, 11, 14, 13, 1, -16 },
  { 749, 10, 21, 12, 2, -21 },
  { 776, 19, 26, 22, 1, -20 },
  { 838, 16, 21, 17, -1, -21 },
  { 880, 15, 21, 16, 0, -21 },
  { 920, 15, 21, 16, 1, -21 },
  { 960, 15, 21, 16, 0, -21 },
  { 1000, 15, 21, 14, 0, -21 },
  { 1040, 15, 21, 13, 0, -21 },
  { 1080, 15, 21, 17, 1, -21 },
  { 1120, 18, 21, 17, 0, -21 },
  { 1168, 6, 21, 7, 1, -21 },
  { 1184, 14, 21, 14, 0, -21 },
  { 1221, 17, 21, 15, 0, -21 },
  { 1266, 12, 21, 13, 0, -21 },
  { 1298, 22, 21, 21, 0, -21 },
  { 1356, 18, 21, 17, 0, -21 },
  { 1404, 15, 21, 17, 1, -21 },
  { 1444, 16, 21, 16, 0, -21 },
  { 1486, 15, 25, 17, 1, -21 },
  { 1533, 15, 21, 15, 0, -21 },
  { 1573, 14, 21, 15, 1, -21 },
  { 1610, 14, 21, 15, 2, -21 },
  { 1647, 16, 21, 16, 1, -21 },
  { 1689, 16, 21, 16, 2, -21 },
  { 1731, 20, 21, 21, 3, -21 },
  { 1784, 18, 21, 16, -1, -21 },
  { 1832, 15, 21, 15, 2, -21 },
  { 1872, 16, 21, 15, 0, -21 },
  { 1914, 9, 29, 7, 0, -24 },
  { 1947, 6, 23, 11, 3, -21 },
  { 1965, 10, 29, 7, -2, -24 },
  { 2002, 9, 10, 11, 1, -21 },
  { 2014, 12, 3, 11, -2, 0 },
  { 2019, 6, 4, 9, 3, -21 },
  { 2022, 12, 16, 13, 0, -16 },
  { 2046, 13, 22, 14, 0, -22 },
  { 2082, 11, 16, 13, 1, -16 },
  { 2104, 14, 22, 14, 1, -22 },
  { 2143, 11, 16, 13, 1, -16 },
  { 2165, 10, 22, 9, 1, -22 },
  { 2193, 14, 22, 14, 0, -16 },
  { 2232, 12, 22, 14, 0, -22 },
  { 2265, 7, 22, 7, 0, -22 },
  { 2285, 10, 28, 7, -3, -22 },
  { 2320, 14, 22, 13, 0, -22 },
  { 2359, 7, 22, 7, 0, -22 },
  { 2379, 20, 16, 21, 0, -16 },
  { 2419, 12, 16, 14, 0, -16 },
  { 2443, 12, 16, 14, 1, -16 },
  { 2467, 14, 22, 14, -1, -16 },
  { 2506, 12, 22, 14, 1, -16 },
  { 2539, 10, 16, 9, 0, -16 },
  { 2559, 12, 16, 13, 0, -16 },
  { 2583, 8, 19, 9, 1, -19 },
  { 2602, 12, 16, 14, 1, -16 },
  { 2626, 11, 16, 12, 2, -16 },
  { 2648, 17, 16, 18, 2, -16 },
  { 2682, 14, 16, 13, -1, -16 },
  { 2710, 14, 22, 12, -1, -16 },
  { 2749, 12, 16, 13, 0, -16 },
  { 2773, 9, 28, 9, 1, -23 },
  { 2805, 7, 25, 7, 0, -21 },
  { 2827, 9, 28, 9, -1, -23 },
  { 2859, 14, 6, 16, 1, -11 },
};

const GFXfont RobotoCondensed_MediumItalic29pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_MediumItalic29pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_MediumItalic29pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _ROBOTOCONDENSED_MEDIUMITALIC29PT7B_H_
