#ifndef _ROBOTOCONDENSED_MEDIUMITALIC32PT7B_H_
#define _ROBOTOCONDENSED_MEDIUMITALIC32PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-MediumItalic.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_MediumItalic32pt7bBitmaps[] PROGMEM = {
  0x00, 0x1E, 0x3C, 0x78, 0xF1, 0xC3, 0x8F, 0x1E, 0x3C, 0x70, 0xE1, 0xC3,
  0x8F, 0x1C, 0x38, 0x00, 0x00, 0x07, 0x0F, 0x1E, 0x38, 0x00, 0x33, 0x99,
  0xDC, 0xEE, 0x67, 0x33, 0x39, 0x9C, 0xCC, 0x00, 0xC6, 0x00, 0xC6, 0x01,
  0xCE, 0x01, 0x8C, 0x01, 0x8C, 0x03, 0x9C, 0x03, 0x98, 0x1F, 0xFF, 0x3F,
  0xFF, 0x07, 0x30, 0x06, 0x30, 0x0E, 0x70, 0x0E, 0x70, 0x0C, 0x60, 0xFF,
  0xFC, 0xFF, 0xF8, 0x18, 0xC0, 0x19, 0xC0, 0x39, 0xC0, 0x31, 0x80, 0x33,
  0x80, 0x73, 0x80, 0x63, 0x00, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0xF8,
  0x07, 0xF0, 0x3F, 0xE1, 0xE3, 0xC7, 0x0F, 0x3C, 0x3C, 0xF0, 0xF3, 0xC0,
  0x07, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF0, 0x03,
  0xC0, 0x07, 0x3C, 0x1C, 0xF0, 0x73, 0xC3, 0xC7, 0x9F, 0x1F, 0xF8, 0x3F,
  0xC0, 0x7C, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x3C, 0x00, 0xFC, 0x01,
  0xDC, 0x07, 0x18, 0x6E, 0x31, 0xD8, 0x67, 0x31, 0xCC, 0x63, 0xB0, 0xEE,
  0xE0, 0xFF, 0x80, 0xF6, 0x00, 0x1C, 0x00, 0x77, 0x80, 0xDF, 0x83, 0xF7,
  0x0E, 0xC7, 0x19, 0x8E, 0x63, 0x1D, 0xC6, 0x3F, 0x0C, 0x64, 0x1D, 0xC0,
  0x3F, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x0F, 0xE0, 0x3F, 0xE0, 0x73, 0xC1,
  0xE3, 0x83, 0x87, 0x07, 0x1E, 0x0E, 0x78, 0x1F, 0xE0, 0x1F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xF8, 0xEF, 0x79, 0xFC, 0xF7, 0xF8, 0xFE, 0xE1, 0xFD,
  0xC1, 0xF3, 0xC3, 0xE7, 0x87, 0xC7, 0xFF, 0x8F, 0xFF, 0x87, 0xCF, 0x00,
  0x77, 0x77, 0x66, 0xEE, 0x00, 0x80, 0xC0, 0xE0, 0xE0, 0xE0, 0xF0, 0x70,
  0x70, 0x38, 0x3C, 0x1C, 0x0E, 0x07, 0x07, 0x83, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x0C, 0x07,
  0x01, 0x80, 0xE0, 0x20, 0x04, 0x06, 0x03, 0x80, 0xE0, 0x70, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x83,
  0xC1, 0xE0, 0xE0, 0x70, 0x38, 0x38, 0x1C, 0x1E, 0x0E, 0x0F, 0x07, 0x07,
  0x07, 0x03, 0x01, 0x00, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x0E, 0x73,
  0x7F, 0xFB, 0xFF, 0xE3, 0xF8, 0x1F, 0x01, 0xF8, 0x0E, 0xE0, 0xE3, 0x06,
  0x1C, 0x00, 0x80, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03,
  0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x1C, 0x71, 0xCF, 0x38, 0xE7, 0x3C, 0x60,
  0x7E, 0xFE, 0xFE, 0xFF, 0xFE, 0x00, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E,
  0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C,
  0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x30,
  0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0,
  0x00, 0x03, 0xE0, 0x1F, 0xC0, 0xFF, 0x87, 0x8E, 0x1C, 0x3C, 0xF0, 0xF3,
  0x83, 0xCE, 0x0F, 0x78, 0x3D, 0xE0, 0xF7, 0x83, 0x9E, 0x0E, 0x70, 0x39,
  0xC1, 0xE7, 0x07, 0xBC, 0x1E, 0xF0, 0x71, 0xC1, 0xC7, 0x0F, 0x1E, 0x78,
  0x7F, 0xE0, 0xFF, 0x01, 0xF0, 0x00, 0x01, 0x87, 0x8F, 0xDF, 0xEF, 0xF6,
  0x78, 0x3C, 0x1C, 0x0E, 0x07, 0x07, 0x83, 0xC1, 0xE0, 0xE0, 0x70, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x03, 0x83, 0xC1, 0xE0, 0x01, 0xF0, 0x0F, 0xF0,
  0x3F, 0xF0, 0xF9, 0xF1, 0xE1, 0xE3, 0x83, 0xCF, 0x07, 0x80, 0x0F, 0x00,
  0x3C, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xFF, 0x9F,
  0xFF, 0x3F, 0xFE, 0x00, 0x03, 0xE0, 0x3F, 0xC1, 0xFF, 0x8F, 0x9E, 0x3C,
  0x3C, 0xE0, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x03, 0xE0, 0x7F, 0x01,
  0xF0, 0x0F, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x73, 0x81, 0xCE,
  0x0F, 0x3C, 0x78, 0xFF, 0xE1, 0xFF, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x78, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x7F, 0x01, 0xDC,
  0x07, 0x38, 0x0E, 0x70, 0x39, 0xE0, 0xF3, 0xC1, 0xC7, 0x87, 0x0E, 0x1E,
  0x1C, 0x3F, 0xFE, 0xFF, 0xFD, 0xFF, 0xF8, 0x03, 0xC0, 0x07, 0x00, 0x0E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0x0F, 0xFE, 0x1F, 0xF8, 0x3F, 0xF0, 0x70,
  0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x3F, 0xC0, 0x7F, 0xE0,
  0xFF, 0xC1, 0xC7, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0xF0,
  0x79, 0xE0, 0xE1, 0xC3, 0xC3, 0xCF, 0x87, 0xFE, 0x07, 0xF8, 0x07, 0xC0,
  0x00, 0x00, 0x70, 0x0F, 0x81, 0xFC, 0x1F, 0x80, 0xF0, 0x0F, 0x00, 0x70,
  0x07, 0x80, 0x3B, 0xE3, 0xFF, 0x9F, 0xFC, 0xF8, 0xF7, 0x87, 0xB8, 0x3D,
  0xC1, 0xEE, 0x0F, 0x70, 0x7B, 0x83, 0xDC, 0x3C, 0xF1, 0xE3, 0xFE, 0x1F,
  0xE0, 0x3E, 0x00, 0x7F, 0xFD, 0xFF, 0xF7, 0xFF, 0xC0, 0x0E, 0x00, 0x78,
  0x01, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0,
  0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0,
  0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x1F, 0xC0,
  0xFF, 0x87, 0x8E, 0x1C, 0x3C, 0xF0, 0xF3, 0xC3, 0xCF, 0x0F, 0x3C, 0x38,
  0x71, 0xE1, 0xFF, 0x03, 0xF8, 0x3F, 0xE1, 0xE3, 0xC7, 0x07, 0x3C, 0x1C,
  0xF0, 0x73, 0xC1, 0xCF, 0x0F, 0x3C, 0x7C, 0x7F, 0xE0, 0xFF, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0xFF, 0x0F, 0xF8, 0x79, 0xE7, 0x87, 0x38, 0x39, 0xC1,
  0xDE, 0x0F, 0xF0, 0x77, 0x83, 0xBC, 0x3C, 0xF3, 0xE7, 0xFF, 0x1F, 0xF8,
  0x7B, 0x80, 0x1C, 0x01, 0xE0, 0x1E, 0x01, 0xF0, 0x1F, 0x07, 0xF0, 0x3F,
  0x01, 0xC0, 0x00, 0x3C, 0xF3, 0xC7, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xCF, 0x3C, 0xE0, 0x07, 0x83, 0xC1, 0xE0, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x70, 0x38, 0x1C, 0x1E,
  0x0E, 0x0F, 0x07, 0x01, 0x00, 0x00, 0x10, 0x07, 0x01, 0xF0, 0x7F, 0x1F,
  0xCF, 0xF0, 0xF8, 0x0F, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0x7C, 0x01,
  0xC0, 0x04, 0x3F, 0xF9, 0xFF, 0xCF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xCF, 0xFE, 0x7F, 0xF0, 0x20, 0x03, 0x80, 0x3E, 0x03, 0xF0, 0x1F,
  0xC0, 0x7F, 0x01, 0xF0, 0x0F, 0x03, 0xF0, 0xFE, 0x3F, 0x8F, 0xE0, 0xF8,
  0x0E, 0x00, 0x80, 0x00, 0x0F, 0x83, 0xFC, 0x3F, 0xE7, 0x9E, 0x70, 0xFF,
  0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x01,
  0xC0, 0x1C, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x78, 0x07,
  0x80, 0x30, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0x00, 0x1F, 0x1E, 0x01,
  0xE0, 0x1C, 0x07, 0x00, 0x38, 0x38, 0x00, 0x61, 0xC0, 0x01, 0x86, 0x0F,
  0x86, 0x38, 0x7F, 0x18, 0xC3, 0xDC, 0x77, 0x1C, 0x71, 0xDC, 0x71, 0xC7,
  0x63, 0x87, 0x1B, 0x8E, 0x18, 0x6E, 0x38, 0xE1, 0xB8, 0xC3, 0x86, 0xC7,
  0x0C, 0x3B, 0x1C, 0x70, 0xCC, 0x71, 0xC7, 0x30, 0xFF, 0xB8, 0xC3, 0xEF,
  0xC3, 0x07, 0x1E, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xE0, 0x20, 0x03, 0xE7, 0x80, 0x07, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0,
  0x03, 0xB8, 0x03, 0xDC, 0x01, 0xCE, 0x01, 0xE7, 0x00, 0xE3, 0x80, 0xF1,
  0xE0, 0x70, 0xF0, 0x78, 0x78, 0x3C, 0x1C, 0x3F, 0xFE, 0x1F, 0xFF, 0x1F,
  0xFF, 0x8F, 0x01, 0xEF, 0x00, 0xF7, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x1E,
  0x0F, 0xF8, 0x07, 0xFF, 0x03, 0xFF, 0xC1, 0xC1, 0xE0, 0xE0, 0x70, 0xF0,
  0x3C, 0x78, 0x1C, 0x3C, 0x1E, 0x1E, 0x0F, 0x0E, 0x0F, 0x07, 0xFF, 0x07,
  0xFF, 0x03, 0xFF, 0xC1, 0xE0, 0xF0, 0xF0, 0x78, 0x70, 0x3C, 0x38, 0x1E,
  0x3C, 0x0F, 0x1E, 0x07, 0x8F, 0x0F, 0x87, 0xFF, 0xC3, 0xFF, 0xC1, 0xFF,
  0x80, 0x01, 0xF8, 0x03, 0xFE, 0x03, 0xFF, 0x81, 0xE3, 0xE1, 0xE0, 0xF1,
  0xE0, 0x38, 0xF0, 0x1E, 0x70, 0x0F, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x3C, 0x70,
  0x1E, 0x38, 0x0E, 0x1E, 0x0F, 0x0F, 0x8F, 0x03, 0xFF, 0x80, 0xFF, 0x80,
  0x3F, 0x00, 0x0F, 0xF0, 0x07, 0xFE, 0x03, 0xFF, 0x81, 0xC3, 0xE0, 0xE0,
  0xF0, 0xF0, 0x38, 0x78, 0x1E, 0x3C, 0x0F, 0x1E, 0x07, 0x8E, 0x03, 0xC7,
  0x01, 0xC7, 0x80, 0xE3, 0xC0, 0xF1, 0xE0, 0x78, 0xF0, 0x3C, 0x70, 0x1E,
  0x38, 0x1E, 0x3C, 0x0F, 0x1E, 0x0F, 0x0F, 0x1F, 0x87, 0xFF, 0x83, 0xFF,
  0x01, 0xFE, 0x00, 0x0F, 0xFF, 0x87, 0xFF, 0x83, 0xFF, 0xC1, 0xC0, 0x00,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00,
  0x07, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xE0, 0x00, 0xF0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0xFF, 0x83,
  0xFF, 0xC1, 0xFF, 0xE0, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x0E, 0x00,
  0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00,
  0x1F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x01, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0xC3, 0xE1, 0xE1, 0xE0,
  0x71, 0xE0, 0x3C, 0xF0, 0x1E, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x0F, 0xE7, 0x8F, 0xF3, 0x87, 0xF9, 0xC0, 0x38, 0xE0, 0x3C,
  0x70, 0x1E, 0x38, 0x0F, 0x1E, 0x07, 0x8F, 0x8F, 0xC3, 0xFF, 0xC0, 0xFF,
  0xC0, 0x3F, 0x80, 0x0F, 0x00, 0xE1, 0xE0, 0x3C, 0x3C, 0x07, 0x87, 0x00,
  0xF0, 0xE0, 0x1E, 0x3C, 0x03, 0x87, 0x80, 0x70, 0xF0, 0x1E, 0x1E, 0x03,
  0xC3, 0x80, 0x78, 0x7F, 0xFF, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x78, 0x0F,
  0x0F, 0x01, 0xE1, 0xC0, 0x3C, 0x38, 0x07, 0x8F, 0x00, 0xE1, 0xE0, 0x1C,
  0x3C, 0x07, 0x87, 0x80, 0xF0, 0xE0, 0x1E, 0x1C, 0x03, 0xC0, 0x1E, 0x3C,
  0x78, 0xF1, 0xC3, 0x8F, 0x1E, 0x3C, 0x78, 0xE1, 0xC7, 0x8F, 0x1E, 0x3C,
  0x70, 0xE3, 0xC7, 0x8F, 0x1E, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0xF0, 0x78, 0xF0, 0x70, 0xF0, 0xF0, 0x79, 0xF0, 0x7F,
  0xE0, 0x3F, 0xC0, 0x1F, 0x00, 0x0F, 0x03, 0xE1, 0xE0, 0xF8, 0x3C, 0x1E,
  0x07, 0x07, 0x80, 0xE1, 0xE0, 0x3C, 0x7C, 0x07, 0x9F, 0x00, 0xF3, 0xC0,
  0x1E, 0xF0, 0x03, 0xBC, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00,
  0x7F, 0xE0, 0x0F, 0xBC, 0x01, 0xE3, 0xC0, 0x38, 0x78, 0x0F, 0x0F, 0x01,
  0xE0, 0xF0, 0x3C, 0x1E, 0x07, 0x83, 0xC0, 0xE0, 0x3C, 0x1C, 0x07, 0x80,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xFF, 0xBF, 0xFD,
  0xFF, 0xC0, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x0F,
  0x80, 0x7E, 0x0F, 0xC0, 0x7E, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F,
  0xC0, 0xFC, 0x1D, 0xC1, 0xDC, 0x1D, 0xC1, 0xDC, 0x1D, 0xC3, 0xBC, 0x3D,
  0xC3, 0xBC, 0x3C, 0xC7, 0x3C, 0x3C, 0xE7, 0x38, 0x3C, 0xEF, 0x38, 0x38,
  0xEE, 0x78, 0x38, 0xFE, 0x78, 0x78, 0xFC, 0x78, 0x78, 0xFC, 0x78, 0x78,
  0xF8, 0x70, 0x78, 0x78, 0x70, 0x70, 0x70, 0xF0, 0x70, 0x70, 0xF0, 0x0F,
  0x00, 0xE1, 0xE0, 0x3C, 0x3E, 0x07, 0x87, 0xC0, 0xF0, 0xF8, 0x1E, 0x3F,
  0x83, 0x87, 0xF0, 0x70, 0xFE, 0x1E, 0x1E, 0xC3, 0xC3, 0x9C, 0x78, 0x73,
  0x8F, 0x1E, 0x71, 0xC3, 0xC7, 0x38, 0x78, 0xEF, 0x0F, 0x1D, 0xE1, 0xC1,
  0xFC, 0x38, 0x3F, 0x8F, 0x07, 0xE1, 0xE0, 0xFC, 0x3C, 0x0F, 0x87, 0x81,
  0xF0, 0xE0, 0x3E, 0x1C, 0x03, 0xC0, 0x01, 0xF8, 0x03, 0xFF, 0x03, 0xFF,
  0x81, 0xF3, 0xE1, 0xE0, 0x71, 0xE0, 0x3C, 0xF0, 0x1E, 0x70, 0x0F, 0x78,
  0x07, 0xBC, 0x03, 0xDE, 0x01, 0xEF, 0x00, 0xE7, 0x80, 0x73, 0x80, 0x79,
  0xC0, 0x3C, 0xE0, 0x1E, 0x70, 0x0E, 0x38, 0x0F, 0x1E, 0x0F, 0x0F, 0x8F,
  0x83, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0x00, 0x0F, 0xFC, 0x07, 0xFF, 0x03,
  0xFF, 0xC1, 0xC1, 0xF0, 0xE0, 0x78, 0xF0, 0x1C, 0x78, 0x0E, 0x3C, 0x0F,
  0x1E, 0x07, 0x8E, 0x03, 0xC7, 0x07, 0xC7, 0xFF, 0xE3, 0xFF, 0xC1, 0xFF,
  0xC0, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x01, 0xF8, 0x03, 0xFF,
  0x03, 0xFF, 0x81, 0xE3, 0xE1, 0xE0, 0xF1, 0xE0, 0x3C, 0xF0, 0x1E, 0x70,
  0x0F, 0x78, 0x07, 0xBC, 0x03, 0xDE, 0x01, 0xCF, 0x00, 0xE7, 0x00, 0xF3,
  0x80, 0x7B, 0xC0, 0x3C, 0xE0, 0x1E, 0x70, 0x0E, 0x38, 0x0F, 0x1E, 0x0F,
  0x0F, 0x8F, 0x83, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x1C, 0x00, 0x04, 0x00, 0x0F, 0xF8, 0x07, 0xFF, 0x03, 0xFF,
  0xC1, 0xE1, 0xE0, 0xE0, 0x78, 0xF0, 0x3C, 0x78, 0x1E, 0x3C, 0x0F, 0x1E,
  0x0F, 0x0E, 0x07, 0x87, 0x0F, 0x87, 0xFF, 0xC3, 0xFF, 0x81, 0xFF, 0x80,
  0xF1, 0xE0, 0x70, 0xF0, 0x38, 0x78, 0x3C, 0x1C, 0x1E, 0x0F, 0x0F, 0x07,
  0x87, 0x83, 0xC3, 0x81, 0xE1, 0xC0, 0x78, 0x01, 0xF0, 0x07, 0xFC, 0x0F,
  0xFC, 0x1F, 0x3E, 0x3C, 0x1E, 0x3C, 0x0E, 0x3C, 0x0E, 0x3C, 0x00, 0x3C,
  0x00, 0x1F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x00,
  0x78, 0x00, 0x3C, 0xE0, 0x3C, 0xF0, 0x3C, 0xF0, 0x78, 0xF8, 0xF8, 0x7F,
  0xF0, 0x3F, 0xE0, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3C,
  0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x00, 0x1E, 0x07, 0x8F, 0x03, 0xC7, 0x01, 0xE7, 0x80, 0xF3, 0xC0, 0x71,
  0xE0, 0x38, 0xF0, 0x3C, 0x78, 0x1E, 0x38, 0x0F, 0x3C, 0x07, 0x9E, 0x03,
  0x8F, 0x01, 0xC7, 0x81, 0xE3, 0xC0, 0xF1, 0xC0, 0x79, 0xE0, 0x3C, 0xF0,
  0x1C, 0x78, 0x1E, 0x3C, 0x0F, 0x0F, 0x1F, 0x07, 0xFF, 0x81, 0xFF, 0x00,
  0x3F, 0x00, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x3C,
  0xF0, 0x3C, 0xF0, 0x3C, 0x70, 0x78, 0x70, 0x78, 0x70, 0xF0, 0x78, 0xF0,
  0x78, 0xE0, 0x79, 0xE0, 0x79, 0xC0, 0x3B, 0xC0, 0x3B, 0xC0, 0x3B, 0x80,
  0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1C, 0x00,
  0xF0, 0x70, 0x3F, 0xC1, 0xC0, 0xEF, 0x0F, 0x87, 0xBC, 0x3E, 0x1E, 0xF0,
  0xF8, 0x73, 0xC7, 0xE3, 0xCF, 0x1F, 0x8F, 0x3C, 0x7E, 0x38, 0xF3, 0xB9,
  0xE3, 0xCE, 0xE7, 0x8F, 0x3B, 0x9C, 0x3D, 0xCE, 0x70, 0xF7, 0x3B, 0xC3,
  0xDC, 0xEE, 0x0F, 0xE3, 0xB8, 0x3F, 0x8F, 0xE0, 0xFE, 0x3F, 0x03, 0xF0,
  0xFC, 0x0F, 0xC3, 0xF0, 0x3E, 0x0F, 0x80, 0x78, 0x3E, 0x01, 0xE0, 0x78,
  0x07, 0x01, 0xC0, 0x00, 0x0F, 0x01, 0xE0, 0x78, 0x3E, 0x07, 0x83, 0xC0,
  0x78, 0x78, 0x07, 0x87, 0x80, 0x3C, 0xF0, 0x03, 0xDF, 0x00, 0x3D, 0xE0,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7B, 0xC0, 0x0F, 0x3C, 0x00, 0xF3,
  0xC0, 0x1E, 0x1E, 0x03, 0xE1, 0xE0, 0x3C, 0x1E, 0x07, 0xC1, 0xF0, 0x78,
  0x0F, 0x00, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x3C, 0x70, 0x3C, 0x70, 0x78,
  0x78, 0xF0, 0x78, 0xF0, 0x39, 0xE0, 0x39, 0xE0, 0x3B, 0xC0, 0x3F, 0x80,
  0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF,
  0xF0, 0x0F, 0xC3, 0xF0, 0xFC, 0x3C, 0x0E, 0x03, 0x81, 0xE0, 0x78, 0x1E,
  0x07, 0x81, 0xC0, 0x70, 0x1C, 0x0F, 0x03, 0xC0, 0xF0, 0x38, 0x0E, 0x03,
  0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xC0, 0x70, 0x3C, 0x0F, 0x03, 0xC0,
  0xF8, 0x3E, 0x0F, 0x80, 0xE1, 0xC3, 0xC7, 0x8F, 0x0E, 0x1C, 0x38, 0x70,
  0xF1, 0xE3, 0xC3, 0x87, 0x0E, 0x1C, 0x3C, 0x78, 0xF0, 0xE1, 0xC3, 0x87,
  0x0E, 0x1E, 0x07, 0xE0, 0xF8, 0x1F, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1C, 0x03, 0x80, 0x70, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x38,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x70, 0x0E, 0x07, 0xC1, 0xF8, 0x3F, 0x00, 0x03, 0x81, 0xE0,
  0x78, 0x3E, 0x0D, 0x87, 0x61, 0x9C, 0xE7, 0x71, 0xDC, 0x7F, 0x1C, 0x7F,
  0xF7, 0xFF, 0xBF, 0xFC, 0x71, 0xE3, 0x87, 0x1C, 0x07, 0xC1, 0xFE, 0x3F,
  0xF3, 0xCF, 0x78, 0x70, 0x07, 0x00, 0x70, 0xFF, 0x3F, 0xF7, 0xCF, 0xF0,
  0xEE, 0x0E, 0xE0, 0xEF, 0x3E, 0xFF, 0xEF, 0xFE, 0x3D, 0xE0, 0x0F, 0x00,
  0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0xBC,
  0x1F, 0xF8, 0x7F, 0xF3, 0xE3, 0xCF, 0x0F, 0x3C, 0x1C, 0xF0, 0x73, 0x81,
  0xCE, 0x0F, 0x78, 0x3D, 0xE0, 0xF7, 0x83, 0x9E, 0x1E, 0x7C, 0xF9, 0xFF,
  0xCF, 0x7E, 0x3C, 0xF0, 0x07, 0xC0, 0xFF, 0x0F, 0xFC, 0xF8, 0xE7, 0x87,
  0xB8, 0x3F, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x01, 0xC1, 0xEF,
  0x0E, 0x78, 0xF1, 0xFF, 0x0F, 0xF0, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x07, 0x9E, 0x1F,
  0xBC, 0x7F, 0xF1, 0xF1, 0xE3, 0xC3, 0xC7, 0x07, 0x9E, 0x0F, 0x3C, 0x1E,
  0x78, 0x38, 0xF0, 0x71, 0xC0, 0xE3, 0x83, 0xC7, 0x87, 0x8F, 0x1F, 0x1F,
  0xFC, 0x1F, 0xF8, 0x1F, 0x70, 0x07, 0xC0, 0xFF, 0x0F, 0xFC, 0x78, 0xE7,
  0x87, 0xB8, 0x3F, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBC, 0x01, 0xE0,
  0x0F, 0x00, 0x7C, 0x71, 0xFF, 0x87, 0xF8, 0x1F, 0x80, 0x01, 0xE0, 0xFC,
  0x3F, 0x87, 0x80, 0xE0, 0x3C, 0x07, 0x83, 0xFC, 0x7F, 0x8F, 0xF0, 0x70,
  0x1E, 0x03, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0x07, 0xCE, 0x1F, 0xFC, 0x7F, 0xF9,
  0xF1, 0xE3, 0xC1, 0xC7, 0x03, 0x9E, 0x0F, 0x3C, 0x1E, 0x78, 0x3C, 0xF0,
  0x71, 0xC0, 0xE3, 0x81, 0xC7, 0x87, 0x8F, 0x1F, 0x0F, 0xFE, 0x1F, 0xF8,
  0x1F, 0x70, 0x00, 0xE0, 0x03, 0xC2, 0x07, 0x86, 0x1E, 0x1F, 0xFC, 0x1F,
  0xF0, 0x1F, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0xBC, 0x1F, 0xF8, 0x7F, 0xE3, 0xE3, 0xCF, 0x0F,
  0x3C, 0x3C, 0xE0, 0xF3, 0x83, 0x8E, 0x0E, 0x78, 0x79, 0xE1, 0xE7, 0x87,
  0x9C, 0x1E, 0x70, 0x71, 0xC1, 0xCF, 0x0F, 0x3C, 0x3C, 0x0E, 0x0F, 0x0F,
  0x0E, 0x00, 0x00, 0x1E, 0x1E, 0x1C, 0x1C, 0x3C, 0x3C, 0x3C, 0x3C, 0x38,
  0x38, 0x78, 0x78, 0x78, 0x78, 0x70, 0x70, 0xF0, 0x01, 0xC0, 0x3C, 0x07,
  0x80, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x1E, 0x03, 0x80, 0x70, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xE0, 0x1C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0xF0, 0x7E, 0x0F, 0x81,
  0xE0, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x1F, 0x1C, 0x3C, 0x38, 0xF0, 0xF3, 0xC1, 0xEF,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0xC0, 0xFB, 0x81,
  0xE7, 0x83, 0x8F, 0x07, 0x0E, 0x0E, 0x1E, 0x3C, 0x3C, 0x78, 0x38, 0x0F,
  0x0F, 0x0F, 0x0E, 0x0E, 0x0E, 0x1E, 0x1E, 0x1E, 0x1C, 0x1C, 0x1C, 0x3C,
  0x3C, 0x3C, 0x38, 0x38, 0x78, 0x78, 0x78, 0x78, 0x70, 0x70, 0xF0, 0x1C,
  0xF1, 0xF0, 0x7F, 0xEF, 0xE1, 0xFF, 0xFF, 0x8F, 0x9F, 0x9F, 0x3C, 0x3C,
  0x3C, 0xF0, 0xF0, 0xF3, 0xC3, 0xC3, 0xCE, 0x0E, 0x0E, 0x38, 0x38, 0x39,
  0xE1, 0xE1, 0xE7, 0x87, 0x87, 0x9E, 0x1E, 0x1E, 0x78, 0x78, 0x79, 0xC1,
  0xC1, 0xC7, 0x07, 0x07, 0x3C, 0x3C, 0x3C, 0xF0, 0xF0, 0xF0, 0x1C, 0xF0,
  0x7F, 0xE1, 0xFF, 0x8F, 0x8F, 0x3C, 0x3C, 0xF0, 0xF3, 0x83, 0xCE, 0x0E,
  0x38, 0x39, 0xE1, 0xE7, 0x87, 0x9E, 0x1E, 0x70, 0x79, 0xC1, 0xC7, 0x07,
  0x3C, 0x3C, 0xF0, 0xF0, 0x07, 0xC0, 0xFF, 0x8F, 0xFC, 0x78, 0xF7, 0x87,
  0xB8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x83, 0xFC, 0x1F, 0xE0, 0xEF,
  0x0F, 0x78, 0xF9, 0xFF, 0x87, 0xF8, 0x1F, 0x00, 0x0E, 0x78, 0x1F, 0xF8,
  0x3F, 0xF8, 0xF8, 0xF1, 0xE1, 0xE3, 0xC1, 0xC7, 0x83, 0x8E, 0x07, 0x1C,
  0x1E, 0x78, 0x3C, 0xF0, 0x79, 0xE0, 0xE3, 0xC3, 0xC7, 0x8F, 0x8F, 0xFE,
  0x3F, 0xF8, 0x79, 0xE0, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0x0F, 0x9C, 0x7F, 0xF3, 0xFF, 0x9F, 0x1E,
  0x78, 0x79, 0xC1, 0xEF, 0x07, 0xBC, 0x1E, 0xF0, 0x73, 0xC1, 0xCE, 0x0F,
  0x38, 0x3C, 0xF0, 0xF3, 0xC7, 0xCF, 0xFE, 0x1F, 0xF8, 0x3F, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x1D,
  0xC3, 0xF8, 0x7F, 0x1F, 0xE3, 0xE0, 0x78, 0x0F, 0x01, 0xC0, 0x38, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x80, 0xF0, 0x00, 0x03,
  0xC0, 0x7F, 0x87, 0xFE, 0x78, 0xF3, 0xC3, 0x9E, 0x00, 0xF8, 0x03, 0xF0,
  0x0F, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xEF, 0x0F, 0x38, 0x79, 0xFF, 0x87,
  0xF8, 0x1F, 0x80, 0x1E, 0x0F, 0x07, 0x83, 0xC7, 0xFF, 0xFB, 0xFC, 0x78,
  0x3C, 0x1C, 0x0E, 0x07, 0x07, 0x83, 0xC1, 0xE0, 0xE0, 0x70, 0x38, 0x1F,
  0x0F, 0x83, 0xC0, 0x38, 0x3C, 0xE0, 0xE3, 0x83, 0x9E, 0x0E, 0x78, 0x79,
  0xE1, 0xE7, 0x07, 0x9C, 0x1C, 0x70, 0x73, 0xC1, 0xCF, 0x0F, 0x3C, 0x3C,
  0xF0, 0xF3, 0xC7, 0x8F, 0xFE, 0x1F, 0xF8, 0x3C, 0xE0, 0xE0, 0xFE, 0x0F,
  0xF0, 0xEF, 0x1E, 0xF1, 0xCF, 0x3C, 0x73, 0x87, 0x38, 0x77, 0x87, 0x70,
  0x77, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x00, 0xE0,
  0xE1, 0xDC, 0x3C, 0x3B, 0x87, 0x8F, 0x71, 0xF1, 0xCE, 0x3E, 0x79, 0xC7,
  0xCE, 0x39, 0xF9, 0xC7, 0x3F, 0x78, 0xEE, 0xEE, 0x1D, 0xDD, 0xC3, 0xF1,
  0xF8, 0x7E, 0x3E, 0x07, 0xC7, 0xC0, 0xF0, 0xF0, 0x1E, 0x1E, 0x03, 0x83,
  0xC0, 0x70, 0x70, 0x00, 0x1E, 0x1E, 0x1C, 0x78, 0x38, 0xF0, 0x7B, 0xC0,
  0x77, 0x00, 0xFE, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x3F,
  0x80, 0x77, 0x01, 0xEE, 0x07, 0x9E, 0x0F, 0x3C, 0x3C, 0x38, 0xF0, 0x78,
  0x1E, 0x1E, 0x3C, 0x3C, 0x78, 0xF0, 0xF1, 0xE1, 0xE3, 0x83, 0xCF, 0x07,
  0x9E, 0x07, 0x78, 0x0E, 0xF0, 0x1D, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xFC,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00,
  0xF0, 0x03, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x78, 0x00, 0x1F, 0xFC, 0xFF,
  0xE3, 0xFF, 0x80, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0xFE, 0x3F,
  0xF8, 0xFF, 0xE0, 0x00, 0x80, 0xF0, 0x78, 0x1C, 0x0F, 0x03, 0x80, 0xE0,
  0x38, 0x1E, 0x07, 0x81, 0xC0, 0x70, 0x1C, 0x0F, 0x0F, 0x83, 0xC0, 0xF0,
  0x1C, 0x03, 0x80, 0xE0, 0x38, 0x1E, 0x07, 0x81, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xE0, 0x38, 0x06, 0x00, 0x80, 0x0C, 0x71, 0xC7, 0x1C, 0x61, 0x86,
  0x38, 0xE3, 0x8C, 0x30, 0xC7, 0x1C, 0x71, 0xC6, 0x18, 0x63, 0x8E, 0x38,
  0xC3, 0x0C, 0x00, 0x0C, 0x03, 0x80, 0xF0, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x7C, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0x78, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x3C, 0x0F, 0x03,
  0x81, 0xE0, 0xF0, 0x38, 0x08, 0x00, 0x1E, 0x06, 0x7E, 0x1D, 0xFE, 0x3B,
  0x9E, 0x77, 0x1F, 0xDC, 0x1F, 0x80, 0x1C, 0x00,
};

const GFXglyph RobotoCondensed_MediumItalic32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 7, 23, 8, 1, -23 },
  { 22, 9, 8, 10, 2, -24 },
  { 31, 16, 23, 17, 1, -23 },
  { 77, 14, 29, 16, 1, -26 },
  { 128, 15, 23, 20, 3, -23 },
  { 172, 15, 23, 17, 1, -23 },
  { 216, 4, 8, 5, 2, -24 },
  { 220, 9, 32, 10, 2, -25 },
  { 256, 9, 32, 10, -1, -25 },
  { 292, 13, 14, 14, 2, -23 },
  { 315, 13, 16, 15, 1, -18 },
  { 341, 6, 9, 7, -2, -4 },
  { 348, 8, 3, 10, 1, -11 },
  { 351, 4, 4, 9, 1, -4 },
  { 353, 14, 25, 11, -2, -23 },
  { 397, 14, 23, 16, 1, -23 },
  { 438, 9, 23, 16, 4, -23 },
  { 464, 15, 23, 16, 0, -23 },
  { 508, 14, 23, 16, 1, -23 },
  { 549, 15, 23, 16, 0, -23 },
  { 593, 15, 23, 16, 1, -23 },
  { 637, 13, 23, 16, 1, -23 },
  { 675, 14, 23, 16, 2, -23 },
  { 716, 14, 23, 16, 1, -23 },
  { 757, 13, 23, 16, 2, -23 },
  { 795, 6, 17, 8, 1, -17 },
  { 808, 9, 22, 7, -2, -17 },
  { 833, 12, 14, 14, 1, -17 },
  { 854, 13, 9, 15, 1, -15 },
  { 869, 12, 15, 14, 1, -17 },
  { 892, 12, 23, 14, 2, -23 },
  { 927, 22, 29, 24, 1, -22 },
  { 1007, 17, 23, 18, -1, -23 },
  { 1056, 17, 23, 17, 0, -23 },
  { 1105, 17, 23, 18, 1, -23 },
  { 1154, 17, 23, 18, 0, -23 },
  { 1203, 17, 23, 15, 0, -23 },
  { 1252, 16, 23, 15, 0, -23 },
  { 1298, 17, 23, 18, 1, -23 },
  { 1347, 19, 23, 19, 0, -23 },
  { 1402, 7, 23, 8, 1, -23 },
  { 1423, 16, 23, 15, 0, -23 },
  { 1469, 19, 23, 17, 0, -23 },
  { 1524, 13, 23, 15, 0, -23 },
  { 1562, 24, 23, 24, 0, -23 },
  { 1631, 19, 23, 19, 0, -23 },
  { 1686, 17, 23, 19, 1, -23 },
  { 1735, 17, 23, 17, 0, -23 },
  { 1784, 17, 27, 19, 1, -23 },
  { 1842, 17, 23, 17, 0, -23 },
  { 1891, 16, 23, 16, 1, -23 },
  { 1937, 15, 23, 17, 3, -23 },
  { 1981, 17, 23, 18, 1, -23 },
  { 2030, 16, 23, 18, 3, -23 },
  { 2076, 22, 23, 23, 3, -23 },
  { 2140, 20, 23, 17, -1, -23 },
  { 2198, 16, 23, 17, 3, -23 },
  { 2244, 17, 23, 16, 0, -23 },
  { 2293, 10, 31, 8, 0, -26 },
  { 2332, 7, 25, 12, 3, -23 },
  { 2354, 11, 31, 8, -2, -26 },
  { 2397, 10, 11, 12, 1, -23 },
  { 2411, 13, 3, 12, -2, 0 },
  { 2416, 6, 5, 10, 3, -24 },
  { 2420, 12, 17, 15, 1, -17 },
  { 2446, 14, 24, 15, 0, -24 },
  { 2488, 13, 17, 14, 1, -17 },
  { 2516, 15, 24, 15, 1, -24 },
  { 2561, 13, 17, 15, 1, -17 },
  { 2589, 11, 24, 10, 1, -24 },
  { 2622, 15, 24, 15, 0, -17 },
  { 2667, 14, 24, 15, 0, -24 },
  { 2709, 8, 23, 8, 0, -23 },
  { 2732, 11, 30, 7, -3, -23 },
  { 2774, 15, 24, 14, 0, -24 },
  { 2819, 8, 24, 8, 0, -24 },
  { 2843, 22, 17, 23, 0, -17 },
  { 2890, 14, 17, 15, 0, -17 },
  { 2920, 13, 17, 16, 1, -17 },
  { 2948, 15, 24, 15, -1, -17 },
  { 2993, 14, 24, 15, 1, -17 },
  { 3035, 11, 17, 10, 0, -17 },
  { 3059, 13, 17, 14, 0, -17 },
  { 3087, 9, 21, 9, 1, -21 },
  { 3111, 14, 17, 15, 1, -17 },
  { 3141, 12, 17, 14, 2, -17 },
  { 3167, 19, 17, 20, 2, -17 },
  { 3208, 15, 17, 14, -1, -17 },
  { 3240, 15, 24, 13, -1, -17 },
  { 3285, 14, 17, 14, 0, -17 },
  { 3315, 10, 31, 9, 1, -25 },
  { 3354, 6, 27, 8, 1, -23 },
  { 3375, 10, 31, 9, -1, -25 },
  { 3414, 15, 7, 18, 1, -13 },
};

const GFXfont RobotoCondensed_MediumItalic32pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_MediumItalic32pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_MediumItalic32pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _ROBOTOCONDENSED_MEDIUMITALIC32PT7B_H_
