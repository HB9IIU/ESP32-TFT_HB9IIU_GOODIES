#ifndef _ROBOTOCONDENSED_MEDIUMITALIC65PT7B_H_
#define _ROBOTOCONDENSED_MEDIUMITALIC65PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-MediumItalic.ttf
// Size: 65pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_MediumItalic65pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x1F,
  0xC0, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xFC, 0x07, 0xF0, 0x0F,
  0xE0, 0x0F, 0x80, 0x0E, 0x00, 0x00, 0x1F, 0x0F, 0x9F, 0x87, 0xCF, 0xC7,
  0xE7, 0xE3, 0xF3, 0xE1, 0xF9, 0xF0, 0xF8, 0xF8, 0x7C, 0xFC, 0x3E, 0x7C,
  0x1F, 0x3E, 0x1F, 0x1F, 0x0F, 0x8F, 0x87, 0xC7, 0x83, 0xE3, 0xC1, 0xE3,
  0xE0, 0xF1, 0xF0, 0xF8, 0xF8, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x3E, 0x00,
  0x00, 0xF8, 0x3E, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x01, 0xF0, 0x7C, 0x00,
  0x01, 0xF0, 0x7C, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0xF8, 0x00,
  0x03, 0xE0, 0xF8, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0x07, 0xC1, 0xF0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x07,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x0F, 0xC0, 0x00,
  0x3E, 0x0F, 0x80, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3E, 0x1F, 0x80, 0x00,
  0x7C, 0x1F, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00,
  0xF8, 0x3E, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x7F,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xE0, 0xF8, 0x00, 0x07,
  0xC1, 0xF0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x0F,
  0x83, 0xE0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x1F,
  0x07, 0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x3E,
  0x0F, 0x80, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF0, 0x0F, 0xF8, 0x3F, 0xC0, 0x7F, 0x81, 0xFE, 0x03, 0xF8, 0x07,
  0xF0, 0x3F, 0xC0, 0x3F, 0x81, 0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0,
  0x7F, 0x00, 0x7F, 0x03, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0xFE, 0x00, 0x3F, 0x87, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xE1, 0xFE,
  0x00, 0x7F, 0x0F, 0xF0, 0x07, 0xF8, 0x3F, 0x80, 0x3F, 0xC1, 0xFC, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xE0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x01,
  0xF8, 0x7C, 0x00, 0x07, 0xC1, 0xF0, 0x0E, 0x1F, 0x07, 0xC0, 0x3C, 0xF8,
  0x0F, 0x01, 0xF3, 0xE0, 0x3E, 0x0F, 0xCF, 0x81, 0xF0, 0x3E, 0x3E, 0x07,
  0xC1, 0xF0, 0xF8, 0x1F, 0x0F, 0xC3, 0xE0, 0x7C, 0x3E, 0x0F, 0x81, 0xF1,
  0xF0, 0x3E, 0x0F, 0xCF, 0x80, 0xFC, 0x3E, 0x7E, 0x01, 0xFB, 0xF9, 0xF0,
  0x07, 0xFF, 0xCF, 0x80, 0x0F, 0xFF, 0x7E, 0x00, 0x1F, 0xF1, 0xF0, 0x00,
  0x3F, 0x8F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF1, 0xFC, 0x00, 0x0F,
  0x9F, 0xF8, 0x00, 0x7E, 0xFF, 0xF0, 0x01, 0xF3, 0xFF, 0xE0, 0x0F, 0x9F,
  0xDF, 0x80, 0x7C, 0x7C, 0x3F, 0x01, 0xF3, 0xE0, 0x7C, 0x0F, 0x8F, 0x81,
  0xF0, 0x7C, 0x3E, 0x07, 0xC3, 0xF0, 0xF8, 0x1F, 0x0F, 0x87, 0xC0, 0x7C,
  0x7C, 0x1F, 0x01, 0xF3, 0xF0, 0x7C, 0x07, 0xCF, 0x81, 0xF0, 0x3E, 0x7C,
  0x07, 0xC0, 0xF9, 0xF0, 0x0F, 0x83, 0xE1, 0x80, 0x3E, 0x1F, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xDF, 0xE0, 0x00, 0xFF, 0x0F,
  0xE0, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0xFC, 0x07, 0xE0, 0x01, 0xFC, 0x07,
  0xE0, 0x01, 0xFC, 0x07, 0xE0, 0x01, 0xFC, 0x07, 0xE0, 0x01, 0xFC, 0x0F,
  0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0xFC, 0x7F,
  0x80, 0x00, 0xFE, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0,
  0x7F, 0x07, 0xFF, 0xF0, 0x7E, 0x0F, 0xFF, 0xF0, 0x7E, 0x1F, 0xE7, 0xF8,
  0x7E, 0x3F, 0xC7, 0xF8, 0xFE, 0x3F, 0xC3, 0xFC, 0xFE, 0x7F, 0x81, 0xFC,
  0xFC, 0x7F, 0x81, 0xFF, 0xFC, 0x7F, 0x00, 0xFF, 0xFC, 0x7F, 0x00, 0xFF,
  0xF8, 0x7F, 0x00, 0x7F, 0xF8, 0x7F, 0x00, 0x7F, 0xF0, 0x7F, 0x00, 0x3F,
  0xE0, 0x7F, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x3F, 0xE0, 0x7F, 0xC0, 0x7F,
  0xE0, 0x3F, 0xF3, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xF3, 0xFC, 0x03, 0xFF, 0xC3,
  0xFC, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x3F, 0x3E, 0x3E, 0x7E, 0x7E, 0x7E,
  0x7C, 0x7C, 0x7C, 0xFC, 0xFC, 0xF8, 0xF8, 0xF8, 0xF8, 0x00, 0x00, 0x20,
  0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00,
  0x03, 0x80, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0,
  0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x38, 0x0F, 0x81, 0xC7, 0xC1, 0xF0, 0xF9, 0xFF, 0x3C, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF,
  0x00, 0x01, 0xFB, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x1F, 0x87, 0xE0, 0x07,
  0xF0, 0xFC, 0x01, 0xFC, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x03, 0xC0, 0x1E,
  0x00, 0x30, 0x03, 0x80, 0x02, 0x00, 0x40, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x7F, 0x03,
  0xF8, 0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0x3F, 0x83, 0xF8,
  0x1F, 0xC1, 0xFC, 0x1F, 0xC0, 0x3C, 0x00, 0xC0, 0x00, 0x7F, 0xFE, 0xFF,
  0xFD, 0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x80, 0x1E, 0x1F, 0x9F,
  0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0x7E, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80,
  0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0x9F, 0xF0, 0x3F, 0xC0,
  0xFE, 0x07, 0xF0, 0x1F, 0xC1, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x87,
  0xE0, 0x07, 0xF1, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0xC7, 0xF0, 0x03,
  0xF9, 0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xE7, 0xF0, 0x01, 0xFC, 0xFE,
  0x00, 0x3F, 0x9F, 0xC0, 0x0F, 0xF7, 0xF8, 0x01, 0xFE, 0xFF, 0x00, 0x3F,
  0x9F, 0xC0, 0x07, 0xF3, 0xF8, 0x00, 0xFE, 0x7F, 0x00, 0x1F, 0xCF, 0xE0,
  0x03, 0xF9, 0xFC, 0x00, 0xFF, 0x7F, 0x80, 0x1F, 0xEF, 0xF0, 0x03, 0xF9,
  0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xE7, 0xF0, 0x01, 0xFC, 0xFE, 0x00,
  0x3F, 0x9F, 0xC0, 0x0F, 0xE3, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x8F,
  0xE0, 0x0F, 0xE1, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x83, 0xF8, 0x0F,
  0xE0, 0x7F, 0x03, 0xFC, 0x0F, 0xF9, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x7F, 0x00,
  0x3F, 0xE0, 0x3F, 0xFC, 0x1F, 0xFF, 0x9F, 0xFF, 0xF3, 0xFF, 0xFC, 0x7F,
  0xFF, 0x8F, 0xFF, 0xF1, 0xF8, 0xFE, 0x3C, 0x1F, 0xCC, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F,
  0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFD, 0xFF, 0x80, 0x7F, 0x81, 0xFF,
  0x01, 0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0x3F, 0x80, 0x1F, 0xC1,
  0xFE, 0x00, 0x7F, 0x07, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0x7F,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFC, 0xFF, 0xC0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x07, 0xF0,
  0x3F, 0xC0, 0x3F, 0xC1, 0xFC, 0x01, 0xFE, 0x0F, 0xE0, 0x0F, 0xF0, 0xFF,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF1, 0xFE, 0x00,
  0x3F, 0x8F, 0xF0, 0x03, 0xFC, 0x7F, 0x80, 0x1F, 0xC1, 0xFC, 0x01, 0xFE,
  0x0F, 0xE0, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x01, 0xFF, 0xBF, 0xF8, 0x0F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xEF, 0xF0,
  0x00, 0x7F, 0x7F, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x3F, 0x9F, 0xC0, 0x03,
  0xF8, 0xFE, 0x00, 0x1F, 0x8F, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x1F, 0xC3,
  0xF8, 0x00, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x07, 0xF0,
  0x07, 0xE0, 0x7F, 0x80, 0x7F, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x3F,
  0x00, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x3F, 0x80, 0x7F, 0x81, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x7E, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0x87, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x01,
  0x80, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x3F,
  0x80, 0x1F, 0xE1, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x00,
  0x7F, 0x83, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x7F, 0xC0, 0x7F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC7, 0xE0, 0x07, 0xF7, 0xFE, 0x03, 0xFB, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xC7, 0xFF,
  0x0F, 0xF1, 0xFF, 0x01, 0xFE, 0x7F, 0x80, 0x7F, 0x9F, 0xE0, 0x0F, 0xE7,
  0xF0, 0x03, 0xF9, 0xFC, 0x00, 0xFE, 0xFF, 0x00, 0x3F, 0xBF, 0xC0, 0x0F,
  0xEF, 0xE0, 0x03, 0xFB, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x3F, 0xBF, 0x80,
  0x0F, 0xEF, 0xE0, 0x07, 0xFB, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x7F, 0x1F,
  0xC0, 0x3F, 0xC7, 0xF0, 0x0F, 0xE1, 0xFE, 0x07, 0xF8, 0x3F, 0xEF, 0xFC,
  0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x07, 0xFF,
  0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF,
  0x3F, 0xE0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x7F, 0x80, 0x7F,
  0x07, 0xF8, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0x7F,
  0x00, 0x7F, 0x07, 0xF0, 0x0F, 0xF0, 0x7F, 0x00, 0xFF, 0x07, 0xF0, 0x0F,
  0xE0, 0x7F, 0x01, 0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0x3F, 0xC7, 0xFC, 0x01,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0x80, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xF0, 0xFE, 0x03,
  0xFC, 0x07, 0xF0, 0x3F, 0x80, 0x7F, 0x07, 0xF8, 0x03, 0xF8, 0x7F, 0x00,
  0x3F, 0x87, 0xF0, 0x03, 0xF8, 0xFF, 0x00, 0x3F, 0x8F, 0xF0, 0x03, 0xF8,
  0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x7F, 0x8F, 0xF0,
  0x07, 0xF0, 0xFF, 0x00, 0x7F, 0x07, 0xF0, 0x0F, 0xF0, 0x7F, 0x81, 0xFE,
  0x07, 0xFE, 0x7F, 0xE0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x7F, 0xEF, 0xF8, 0x3F,
  0xC1, 0xFC, 0x3F, 0xC0, 0xFF, 0x1F, 0xC0, 0x3F, 0x9F, 0xC0, 0x1F, 0xCF,
  0xE0, 0x0F, 0xE7, 0xF0, 0x07, 0xF7, 0xF8, 0x03, 0xFB, 0xF8, 0x01, 0xFD,
  0xFC, 0x00, 0xFE, 0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x3F, 0xBF, 0x80, 0x1F,
  0xDF, 0xC0, 0x0F, 0xEF, 0xE0, 0x07, 0xF7, 0xF0, 0x03, 0xFB, 0xF8, 0x03,
  0xFD, 0xFE, 0x03, 0xFE, 0xFF, 0x01, 0xFE, 0x3F, 0xC3, 0xFF, 0x1F, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F,
  0xF7, 0xF0, 0x07, 0xE3, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x00,
  0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x0F, 0xE0, 0x3F, 0x81, 0xFF, 0x07,
  0xFC, 0x1F, 0xF0, 0x7F, 0x80, 0xFE, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x3F, 0x01, 0xFE, 0x07, 0xF8, 0x3F, 0xE0,
  0x7F, 0x81, 0xFE, 0x03, 0xF0, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x1F, 0x80,
  0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x7E,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x3F, 0x80,
  0x1F, 0x80, 0x1F, 0xC0, 0x07, 0xC0, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF,
  0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x07, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x80, 0x1F, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE0, 0x02, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x01,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x07,
  0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00,
  0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x81, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x3F, 0xC1, 0xFE, 0x7F, 0x01,
  0xFD, 0xFE, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x00, 0x00, 0x1E, 0x03, 0xE0,
  0x03, 0xF8, 0x01, 0xE0, 0x7E, 0x00, 0xFF, 0xE0, 0x1E, 0x07, 0xC0, 0x1F,
  0xFF, 0x01, 0xF0, 0xFC, 0x03, 0xFF, 0xF8, 0x1F, 0x0F, 0x80, 0x7F, 0xFF,
  0x81, 0xF1, 0xF8, 0x0F, 0xE0, 0xF8, 0x1F, 0x1F, 0x01, 0xFC, 0x1F, 0x81,
  0xF1, 0xF0, 0x1F, 0x81, 0xF8, 0x1F, 0x3E, 0x03, 0xF0, 0x1F, 0x01, 0xF3,
  0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x3E, 0x07, 0xE0, 0x3F, 0x01, 0xF7, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x7C, 0x07, 0xC0, 0x3E, 0x01, 0xF7, 0xC0, 0xFC,
  0x03, 0xE0, 0x1E, 0x7C, 0x0F, 0xC0, 0x3E, 0x01, 0xEF, 0xC0, 0xFC, 0x07,
  0xE0, 0x3E, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xEF, 0x81, 0xF8, 0x07, 0xC0,
  0x3E, 0xF8, 0x1F, 0x80, 0x7C, 0x03, 0xCF, 0x81, 0xF8, 0x0F, 0xC0, 0x3C,
  0xF8, 0x1F, 0x80, 0xF8, 0x07, 0xCF, 0x81, 0xF8, 0x0F, 0x80, 0x78, 0xF8,
  0x1F, 0x81, 0xF8, 0x0F, 0x8F, 0x81, 0xF8, 0x1F, 0x80, 0xF8, 0xF8, 0x1F,
  0x83, 0xF8, 0x1F, 0x0F, 0x81, 0xF8, 0x7F, 0x81, 0xF0, 0xF8, 0x1F, 0xEF,
  0xF8, 0x3E, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x0F, 0xFE, 0x7F,
  0xF8, 0x0F, 0x80, 0x7F, 0xC7, 0xFF, 0x00, 0xF8, 0x07, 0xF8, 0x3F, 0xE0,
  0x0F, 0x80, 0x0E, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00,
  0x0F, 0xEF, 0xC0, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x00, 0x7F, 0x3F, 0x00,
  0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00, 0xFE, 0x1F,
  0xC0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0xFE,
  0x07, 0xE0, 0x00, 0x3F, 0xC0, 0xFC, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x01,
  0xFE, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x0F, 0xF0, 0x0F, 0xE0,
  0x01, 0xFC, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x0F, 0xE0, 0x07,
  0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFE, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x03, 0xF8,
  0x1F, 0xC0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x01,
  0xFE, 0x3F, 0xC0, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x03, 0xF9, 0xFE, 0x00,
  0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xF8, 0x01,
  0xFE, 0x03, 0xFC, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0xFF, 0x00,
  0x1F, 0xE0, 0x7F, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x07, 0xF0, 0x1F, 0xC0,
  0x03, 0xF8, 0x1F, 0xE0, 0x03, 0xFC, 0x0F, 0xF0, 0x01, 0xFE, 0x07, 0xF8,
  0x01, 0xFE, 0x03, 0xF8, 0x01, 0xFF, 0x01, 0xFC, 0x01, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xF0, 0x07, 0xF8, 0x07, 0xF8, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x0F, 0xF0,
  0x7F, 0x80, 0x07, 0xF8, 0x3F, 0xC0, 0x03, 0xFC, 0x1F, 0xE0, 0x01, 0xFC,
  0x0F, 0xE0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x7F,
  0x83, 0xFC, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0x01, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x03,
  0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x1F, 0xC1,
  0xFE, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x03, 0xFC,
  0x7F, 0x00, 0x01, 0xFE, 0x3F, 0x80, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x01, 0xFC, 0x3F, 0xC0,
  0x00, 0xFE, 0x1F, 0xE0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x7F, 0x03, 0xF8,
  0x00, 0x7F, 0x81, 0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x3F, 0xC0, 0x3F,
  0xC0, 0x3F, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xF8, 0x03, 0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0xFF, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0xFF, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x0F, 0xE0, 0x3F, 0x80,
  0x07, 0xF8, 0x1F, 0xC0, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0xFE, 0x0F, 0xF0,
  0x00, 0xFF, 0x07, 0xF8, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x3F, 0xC1, 0xFC,
  0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x07, 0xF8, 0x7F,
  0x80, 0x03, 0xF8, 0x3F, 0x80, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0xFE, 0x0F,
  0xE0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x3F, 0xC3,
  0xFC, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x07, 0xF0,
  0x7F, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x03, 0xF8, 0x3F, 0xC0, 0x01, 0xFC,
  0x1F, 0xE0, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFF,
  0x03, 0xF8, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x81, 0xFE, 0x01, 0xFF,
  0x80, 0xFF, 0x07, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80,
  0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x00,
  0x3F, 0x83, 0xFC, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x0F, 0xF0, 0xFE, 0x00,
  0x07, 0xF8, 0xFF, 0x00, 0x03, 0xFC, 0x7F, 0x00, 0x00, 0xFE, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0xFC, 0x7F,
  0x80, 0xFF, 0xFE, 0x3F, 0x80, 0x7F, 0xFF, 0x1F, 0xC0, 0x3F, 0xFF, 0x8F,
  0xE0, 0x1F, 0xFF, 0xCF, 0xF0, 0x0F, 0xFF, 0xE7, 0xF8, 0x00, 0x0F, 0xE3,
  0xFC, 0x00, 0x07, 0xF1, 0xFE, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x03, 0xFC,
  0x7F, 0x80, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x7F,
  0x07, 0xF0, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x1F,
  0xE0, 0xFF, 0x80, 0x1F, 0xF0, 0x3F, 0xE0, 0x3F, 0xF8, 0x1F, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x00, 0xFF, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x7F, 0x00, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x01, 0xFC, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x00,
  0xFF, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x00, 0xFE,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0xFF, 0x00, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0x7F, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x7F, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x01, 0xFE, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x01,
  0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x07,
  0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F,
  0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F,
  0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x80, 0x7F,
  0x80, 0x7F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x7F,
  0x83, 0xFC, 0x00, 0xFF, 0x03, 0xF8, 0x01, 0xFC, 0x07, 0xF0, 0x07, 0xF8,
  0x0F, 0xE0, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x3F, 0xE0, 0xFF, 0x80,
  0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFC, 0x03, 0xF8, 0x00,
  0x7F, 0xE0, 0x1F, 0xE0, 0x03, 0xFF, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x01,
  0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xF0, 0x03, 0xFE, 0x00, 0x1F, 0xC0, 0x1F,
  0xF8, 0x00, 0x7F, 0x00, 0xFF, 0xC0, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0x0F,
  0xF0, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x00, 0xFE, 0x07, 0xFC,
  0x00, 0x03, 0xF8, 0x3F, 0xE0, 0x00, 0x0F, 0xE0, 0xFF, 0x80, 0x00, 0x7F,
  0x87, 0xFC, 0x00, 0x01, 0xFE, 0x3F, 0xE0, 0x00, 0x07, 0xF9, 0xFF, 0x00,
  0x00, 0x1F, 0xCF, 0xF8, 0x00, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x03, 0xFD,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0x7F, 0x80, 0x00, 0x1F, 0xF8, 0xFF, 0x00, 0x00, 0x7F, 0xC3,
  0xFC, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x7F, 0x80, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x03,
  0xFC, 0x00, 0x0F, 0xE0, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x3F, 0xE0, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x07,
  0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0xE0, 0x0F,
  0xF0, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x07,
  0xFC, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x07, 0xFF, 0x00, 0x00, 0x3F,
  0xF8, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x1F, 0xFC, 0x00, 0x01, 0xFF,
  0xC0, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0x0F, 0xFF,
  0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFC,
  0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xE0,
  0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80,
  0x7E, 0xFC, 0x00, 0x3F, 0xFF, 0x01, 0xFD, 0xF8, 0x00, 0x7E, 0xFE, 0x03,
  0xFB, 0xF0, 0x01, 0xFD, 0xFC, 0x07, 0xF7, 0xE0, 0x03, 0xF7, 0xF0, 0x0F,
  0xEF, 0xC0, 0x0F, 0xEF, 0xE0, 0x1F, 0xDF, 0xC0, 0x1F, 0xDF, 0xC0, 0x7F,
  0x9F, 0x80, 0x7F, 0x3F, 0x80, 0xFE, 0x3F, 0x00, 0xFE, 0x7F, 0x01, 0xFC,
  0x7E, 0x01, 0xF9, 0xFE, 0x03, 0xF8, 0xFC, 0x07, 0xF3, 0xF8, 0x07, 0xF1,
  0xF8, 0x0F, 0xC7, 0xF0, 0x0F, 0xE3, 0xF0, 0x3F, 0x8F, 0xE0, 0x3F, 0xC7,
  0xE0, 0x7E, 0x3F, 0xC0, 0x7F, 0x8F, 0xC1, 0xFC, 0x7F, 0x80, 0xFE, 0x0F,
  0xC3, 0xF0, 0xFE, 0x01, 0xFC, 0x1F, 0x8F, 0xE1, 0xFC, 0x03, 0xF8, 0x3F,
  0x1F, 0x83, 0xF8, 0x07, 0xF0, 0x7E, 0x7F, 0x0F, 0xF0, 0x1F, 0xE0, 0xFC,
  0xFC, 0x1F, 0xE0, 0x3F, 0xC1, 0xF9, 0xF8, 0x3F, 0xC0, 0x7F, 0x83, 0xF7,
  0xE0, 0x7F, 0x00, 0xFE, 0x03, 0xEF, 0xC0, 0xFE, 0x01, 0xFC, 0x07, 0xFF,
  0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFF, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFF, 0x01,
  0xFE, 0x03, 0xFC, 0x01, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x03, 0xF8, 0x07,
  0xF8, 0x0F, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x0F, 0xC0, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0x07, 0xF0,
  0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x00, 0xFF, 0x01, 0xFF, 0x80,
  0x03, 0xFC, 0x07, 0xFE, 0x00, 0x0F, 0xE0, 0x1F, 0xF8, 0x00, 0x3F, 0x80,
  0x7F, 0xE0, 0x00, 0xFE, 0x03, 0xFF, 0xC0, 0x07, 0xF8, 0x0F, 0xFF, 0x00,
  0x1F, 0xE0, 0x3F, 0xFC, 0x00, 0x7F, 0x80, 0xFF, 0xF8, 0x01, 0xFC, 0x03,
  0xFF, 0xE0, 0x07, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xC0, 0x7F, 0xBF, 0x00,
  0xFF, 0x01, 0xFE, 0xFC, 0x03, 0xFC, 0x07, 0xFB, 0xF0, 0x0F, 0xE0, 0x1F,
  0xCF, 0xC0, 0x3F, 0x80, 0x7F, 0x1F, 0x80, 0xFE, 0x03, 0xFC, 0x7E, 0x07,
  0xF8, 0x0F, 0xF1, 0xF8, 0x1F, 0xE0, 0x3F, 0xC3, 0xF0, 0x7F, 0x80, 0xFF,
  0x0F, 0xC1, 0xFC, 0x03, 0xF8, 0x3F, 0x07, 0xF0, 0x0F, 0xE0, 0x7E, 0x1F,
  0xC0, 0x7F, 0x81, 0xF8, 0xFF, 0x01, 0xFE, 0x07, 0xE3, 0xFC, 0x07, 0xF8,
  0x1F, 0x8F, 0xF0, 0x1F, 0xC0, 0x3F, 0x3F, 0x80, 0x7F, 0x00, 0xFC, 0xFE,
  0x01, 0xFC, 0x03, 0xF3, 0xF8, 0x0F, 0xF0, 0x07, 0xFF, 0xE0, 0x3F, 0xC0,
  0x1F, 0xFF, 0x80, 0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xF8, 0x00, 0xFF, 0xF0,
  0x0F, 0xE0, 0x03, 0xFF, 0xC0, 0x3F, 0x80, 0x0F, 0xFF, 0x01, 0xFE, 0x00,
  0x3F, 0xFC, 0x07, 0xF8, 0x00, 0x7F, 0xF0, 0x1F, 0xE0, 0x01, 0xFF, 0x80,
  0x7F, 0x00, 0x07, 0xFE, 0x01, 0xFC, 0x00, 0x0F, 0xF8, 0x0F, 0xF0, 0x00,
  0x3F, 0xE0, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x01, 0xFE, 0x03,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFE,
  0x03, 0xFC, 0x03, 0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x3F, 0x81, 0xFC,
  0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x03, 0xF8, 0xFF,
  0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x7F, 0x3F,
  0xC0, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x0F, 0xE7,
  0xF0, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x03, 0xFD,
  0xFE, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x7F,
  0x3F, 0x80, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x1F,
  0xEF, 0xF0, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x03,
  0xF9, 0xFE, 0x00, 0x01, 0xFC, 0xFF, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00,
  0xFE, 0x3F, 0xC0, 0x00, 0x7F, 0x1F, 0xE0, 0x00, 0x7F, 0x87, 0xF0, 0x00,
  0x3F, 0x83, 0xF8, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0x80,
  0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xE0, 0x03, 0xFC, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0xFF, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x3F,
  0x81, 0xFE, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x01, 0xFE, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0xFE, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x01, 0xFE, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x0F, 0xF8, 0x1F, 0xE0, 0x03, 0xFE, 0x03,
  0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xF8, 0x07, 0xFE, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0xFF, 0x03, 0xFC,
  0x00, 0x7F, 0x83, 0xFC, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x0F, 0xF1, 0xFE,
  0x00, 0x07, 0xF8, 0xFF, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0xFE, 0x7F,
  0x80, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x1F, 0xCF,
  0xE0, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x07, 0xFB,
  0xFC, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0xFE,
  0x7F, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0x3F,
  0xDF, 0xE0, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x07,
  0xF3, 0xFC, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x01,
  0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0xFF, 0x1F, 0xE0, 0x00,
  0x7F, 0x8F, 0xF0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x3F, 0xC1, 0xFE, 0x00,
  0x3F, 0xC0, 0xFF, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x1F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFE, 0xFF,
  0xFC, 0x03, 0xF8, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0x81, 0xFE, 0x00,
  0x3F, 0xC0, 0xFF, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x0F, 0xF0, 0x3F, 0x80,
  0x07, 0xF8, 0x1F, 0xC0, 0x03, 0xFC, 0x1F, 0xE0, 0x01, 0xFE, 0x0F, 0xF0,
  0x00, 0xFF, 0x07, 0xF8, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x7F, 0x81, 0xFC,
  0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x7F, 0xE0, 0x7F,
  0x81, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xE0, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0xFE, 0x03, 0xFC, 0x00,
  0x7F, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x3F, 0xC0, 0x3F, 0xC0,
  0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF8,
  0x03, 0xF8, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0xFF, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x07,
  0xF8, 0x3F, 0xC0, 0x03, 0xFC, 0x1F, 0xE0, 0x01, 0xFE, 0x0F, 0xF0, 0x00,
  0x7F, 0x87, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x03,
  0xFE, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x7F, 0x80,
  0xFF, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x07, 0xF0,
  0x3F, 0xC0, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x7F, 0x80,
  0x03, 0xFC, 0x3F, 0xC0, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0xFF, 0x07, 0xF0,
  0x00, 0x7F, 0x83, 0xF8, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x3F, 0xC0, 0xFF,
  0x80, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x03,
  0xFC, 0x0F, 0xE0, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0x80,
  0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x0F, 0xF0, 0x3F,
  0xC0, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x07, 0xF0,
  0x1F, 0xC0, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x07,
  0xF8, 0x1F, 0xE0, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0x00,
  0x03, 0xF8, 0x1F, 0xE0, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x7F,
  0x80, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x0F, 0xE0,
  0x3F, 0x80, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x0F,
  0xF0, 0x3F, 0xC0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0xFE, 0x00,
  0x07, 0xF0, 0x1F, 0xC0, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0xFF,
  0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x7F, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x1F,
  0xE0, 0x3F, 0x80, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x1F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xDF, 0xC0,
  0x00, 0x1F, 0xF7, 0xF8, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x03, 0xFE, 0x7F,
  0x80, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x1F, 0xF1,
  0xFE, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x03, 0xFE, 0x0F, 0xE0, 0x00, 0xFF,
  0x03, 0xF8, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x07,
  0xF8, 0x0F, 0xF0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x01, 0xFC,
  0x03, 0xFC, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x07,
  0xF0, 0x1F, 0xE0, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x7F, 0x83, 0xFC, 0x00,
  0x0F, 0xE0, 0xFE, 0x00, 0x03, 0xF8, 0x7F, 0x80, 0x00, 0xFE, 0x1F, 0xE0,
  0x00, 0x3F, 0x87, 0xF0, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x03, 0xF8, 0xFE,
  0x00, 0x00, 0xFE, 0x7F, 0x80, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0x07, 0xE7,
  0xF0, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x1F, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x7F, 0xC0,
  0x1F, 0xEF, 0xE0, 0x07, 0xFC, 0x01, 0xFE, 0xFE, 0x00, 0x7F, 0xC0, 0x1F,
  0xCF, 0xE0, 0x0F, 0xFC, 0x01, 0xFC, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xCF,
  0xE0, 0x0F, 0xFC, 0x03, 0xF8, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0x8F, 0xE0,
  0x1F, 0xFC, 0x07, 0xF8, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0x0F, 0xE0, 0x3F,
  0xFC, 0x07, 0xF0, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0x0F, 0xE0, 0x3F, 0xFC,
  0x0F, 0xE0, 0x7E, 0x07, 0xEF, 0xC0, 0xFE, 0x07, 0xE0, 0x7E, 0xFC, 0x1F,
  0xE0, 0x7E, 0x0F, 0xEF, 0xC1, 0xFC, 0x07, 0xE0, 0xFC, 0xFC, 0x1F, 0xC0,
  0x7E, 0x0F, 0xCF, 0xC3, 0xFC, 0x07, 0xE1, 0xFC, 0xFC, 0x3F, 0x80, 0x7E,
  0x1F, 0x8F, 0xC3, 0xF8, 0x07, 0xE1, 0xF8, 0x7C, 0x7F, 0x00, 0x7E, 0x3F,
  0x07, 0xC7, 0xF0, 0x07, 0xE3, 0xF0, 0x7C, 0x7F, 0x00, 0x7E, 0x3F, 0x07,
  0xC7, 0xE0, 0x07, 0xE7, 0xE0, 0x7C, 0xFE, 0x00, 0x7E, 0x7E, 0x07, 0xCF,
  0xE0, 0x07, 0xE7, 0xE0, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x07, 0xFF, 0xC0,
  0x07, 0xEF, 0xC0, 0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x07,
  0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00,
  0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x7F,
  0xE0, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0x80, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x7F, 0x80,
  0x07, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x0F, 0xF8,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x00, 0x1F,
  0xE0, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x7F,
  0xC0, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00,
  0x0F, 0xF1, 0xFF, 0x00, 0x00, 0x07, 0xF1, 0xFE, 0x00, 0x00, 0x07, 0xF3,
  0xFC, 0x00, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x00, 0x3F, 0xEF, 0xE0, 0x00, 0x00, 0x3F,
  0xCF, 0xF0, 0x00, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x00, 0xFF, 0x87, 0xF0,
  0x00, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x01, 0xFE, 0x00,
  0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x03,
  0xFC, 0xFF, 0x00, 0x07, 0xFC, 0x7F, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x0F,
  0xF8, 0x7F, 0x80, 0x0F, 0xF0, 0x7F, 0x80, 0x1F, 0xE0, 0x3F, 0x80, 0x1F,
  0xE0, 0x3F, 0x80, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x7F,
  0x80, 0x1F, 0xC0, 0x7F, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x1F, 0xC1, 0xFE,
  0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x0F, 0xE3, 0xF8,
  0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x07, 0xEF, 0xF0,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x01,
  0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xF8,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x00, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00,
  0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x00, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0xFE, 0x01, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x3F, 0x00, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80,
  0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0x7E, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x01, 0xF8, 0x07, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8,
  0x00, 0xFF, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x01, 0xFF,
  0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0xE0, 0x0F, 0xDF, 0x00, 0x7C, 0xF8, 0x07, 0xE7, 0xC0,
  0x3F, 0x3E, 0x03, 0xF1, 0xF0, 0x1F, 0x8F, 0xC1, 0xF8, 0x7E, 0x0F, 0xC3,
  0xF0, 0xFC, 0x0F, 0x87, 0xE0, 0x7C, 0x7E, 0x03, 0xE3, 0xF0, 0x1F, 0xBF,
  0x00, 0xFD, 0xF8, 0x07, 0xE0, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFF, 0x07, 0xF0, 0x7F, 0x83, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0x7E,
  0x07, 0xE0, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF,
  0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F,
  0xC7, 0xFC, 0x3F, 0xC0, 0xFF, 0x0F, 0xF0, 0x1F, 0xC3, 0xF8, 0x07, 0xF0,
  0xFE, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0xFF, 0xC1, 0xFE, 0x3F, 0xC0, 0x7F, 0x1F,
  0xE0, 0x1F, 0xC7, 0xF0, 0x07, 0xF3, 0xFC, 0x01, 0xFC, 0xFF, 0x00, 0x7F,
  0x3F, 0xC0, 0x3F, 0xCF, 0xF0, 0x0F, 0xE3, 0xFC, 0x07, 0xF8, 0xFF, 0x03,
  0xFE, 0x1F, 0xF3, 0xFF, 0x87, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFE, 0x07, 0xFF, 0xBF, 0x80, 0xFF, 0x8F, 0xE0, 0x07, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xE1, 0xF0, 0x00, 0x7F, 0x3F, 0xF0, 0x03, 0xFB,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x1F, 0xE0,
  0xFE, 0x00, 0xFF, 0x07, 0xF0, 0x03, 0xF8, 0x7F, 0x80, 0x1F, 0xC3, 0xF8,
  0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x87, 0xF0, 0x03,
  0xFC, 0x7F, 0x80, 0x1F, 0xE3, 0xFC, 0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xF0,
  0xFE, 0x00, 0x3F, 0x87, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xE3, 0xFC,
  0x00, 0x7F, 0x1F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x87, 0xF0, 0x01,
  0xFC, 0x3F, 0xC0, 0x1F, 0xE1, 0xFE, 0x01, 0xFE, 0x1F, 0xF8, 0x1F, 0xF0,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0xBF, 0xFF, 0x81, 0xFD,
  0xFF, 0xF8, 0x0F, 0xC7, 0xFF, 0x80, 0xFE, 0x1F, 0xF8, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xDF,
  0xF8, 0x7F, 0x80, 0xFE, 0x1F, 0xC0, 0x3F, 0x8F, 0xE0, 0x07, 0xF3, 0xF8,
  0x01, 0xFD, 0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0x3F,
  0x80, 0x3F, 0x8F, 0xE0, 0x0F, 0xE3, 0xFC, 0x07, 0xF8, 0x7F, 0x01, 0xFC,
  0x1F, 0xFB, 0xFF, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x07, 0x81, 0xFC, 0x00, 0x7F, 0xE3,
  0xF8, 0x03, 0xFF, 0xE7, 0xF0, 0x0F, 0xFF, 0xDF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFC, 0x07, 0xFC,
  0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0xE0, 0x0F, 0xF0, 0x3F, 0x80, 0x1F, 0xC0,
  0xFF, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0xFE, 0x07,
  0xF0, 0x01, 0xFC, 0x1F, 0xE0, 0x07, 0xF8, 0x3F, 0xC0, 0x0F, 0xE0, 0x7F,
  0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x7F, 0x03, 0xF8,
  0x00, 0xFE, 0x07, 0xF0, 0x03, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x1F, 0xC0,
  0x0F, 0xE0, 0x3F, 0x80, 0x1F, 0xC0, 0x7F, 0x00, 0x3F, 0x80, 0xFE, 0x00,
  0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x03, 0xFE, 0x07, 0xF8, 0x03, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0x7F, 0x00, 0x0F, 0xFC, 0xFC, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x07,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xDF, 0xF8,
  0x7F, 0x80, 0xFE, 0x1F, 0xC0, 0x3F, 0x8F, 0xF0, 0x07, 0xF3, 0xF8, 0x01,
  0xFC, 0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x1F, 0xDF, 0xC0, 0x07, 0xF7, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0xE0, 0x7F, 0x80, 0x7C, 0x1F,
  0xFD, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF8, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x7F, 0xE1, 0xF8, 0x01, 0xFF, 0xE3, 0xF0, 0x07, 0xFF,
  0xEF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF0, 0x07, 0xF8, 0x1F, 0xE0, 0x0F,
  0xF0, 0x3F, 0x80, 0x0F, 0xE0, 0xFF, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x7F,
  0x83, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xF8,
  0x3F, 0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x3F, 0xC1,
  0xFC, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x01, 0xFC, 0x0F,
  0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0x0F, 0xF0, 0x3F, 0x80, 0x1F, 0xC0, 0x7F,
  0x00, 0x3F, 0x80, 0xFF, 0x00, 0x7F, 0x01, 0xFE, 0x01, 0xFE, 0x03, 0xFE,
  0x07, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0x7F, 0x00, 0x0F, 0xFD,
  0xFE, 0x00, 0x03, 0xE3, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x18, 0x00, 0x7F, 0x00, 0x38, 0x01, 0xFE,
  0x00, 0xFC, 0x0F, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x7C, 0x00, 0x3F, 0x9F, 0xF0,
  0x03, 0xFB, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xC0, 0xFF, 0x07, 0xF8, 0x0F,
  0xF0, 0x7F, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0xFE, 0x00, 0x7F, 0x0F,
  0xE0, 0x0F, 0xF0, 0xFE, 0x00, 0xFF, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00,
  0xFE, 0x1F, 0xE0, 0x0F, 0xE1, 0xFC, 0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xE1,
  0xFC, 0x01, 0xFE, 0x1F, 0xC0, 0x1F, 0xC3, 0xFC, 0x01, 0xFC, 0x3F, 0xC0,
  0x1F, 0xC3, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0xC3, 0xF8, 0x03, 0xFC,
  0x3F, 0x80, 0x3F, 0x87, 0xF8, 0x03, 0xF8, 0x7F, 0x80, 0x3F, 0x87, 0xF0,
  0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x87, 0xF0, 0x07, 0xF8, 0x7F, 0x00, 0x7F,
  0x0F, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x78, 0x01, 0xF8,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x3F, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x01, 0xFE,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0xFF, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFE,
  0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0x7F, 0x00,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F,
  0x00, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x09, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x03,
  0xFF, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x03, 0xFF, 0x03, 0xF8, 0x07, 0xFC,
  0x07, 0xF0, 0x1F, 0xF0, 0x0F, 0xE0, 0x7F, 0xC0, 0x3F, 0xC1, 0xFF, 0x00,
  0x7F, 0x07, 0xFC, 0x00, 0xFE, 0x1F, 0xF0, 0x01, 0xFC, 0x3F, 0xC0, 0x03,
  0xF8, 0xFF, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x3F,
  0xBF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xBF,
  0x80, 0x03, 0xFE, 0x7F, 0x80, 0x07, 0xF8, 0x7F, 0x00, 0x0F, 0xE0, 0xFF,
  0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x7F, 0x03, 0xFC,
  0x01, 0xFE, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x0F, 0xF0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0xE0, 0x3F, 0x80, 0x3F, 0xC0,
  0xFF, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x1F, 0xE0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x0F,
  0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x01, 0xFE, 0x03, 0xFC, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0xFF, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x80, 0xFE, 0x01, 0xFC, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x00, 0xFE, 0x01, 0xFC,
  0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x3F, 0x9F, 0xF8, 0x1F, 0xF8, 0x03,
  0xFF, 0xFF, 0xC7, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xEF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0x7F,
  0xFF, 0xFF, 0xF0, 0x7F, 0xC1, 0xFF, 0xC0, 0xFF, 0x07, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF0, 0x7F, 0x00, 0xFF, 0x80, 0x7F, 0x07, 0xF0, 0x0F, 0xF0, 0x07,
  0xF0, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0,
  0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE1, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE1, 0xFC, 0x01, 0xFC,
  0x01, 0xFE, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xE1, 0xFC, 0x01, 0xFC, 0x01,
  0xFC, 0x3F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC3, 0xFC, 0x01, 0xFC, 0x01, 0xFC,
  0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xC3, 0xF8, 0x03, 0xF8, 0x03, 0xFC, 0x3F,
  0x80, 0x3F, 0x80, 0x3F, 0xC3, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x7F, 0x80,
  0x3F, 0x80, 0x3F, 0x87, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x7F, 0x00, 0x7F,
  0x80, 0x3F, 0x87, 0xF0, 0x07, 0xF0, 0x07, 0xF8, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x87, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0xFF, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x3F, 0x9F, 0xF8, 0x03, 0xFB, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xE0, 0x7F, 0xC0, 0xFF, 0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0x00, 0xFF,
  0x0F, 0xF0, 0x07, 0xF0, 0xFF, 0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xF0, 0xFE,
  0x00, 0xFF, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x1F, 0xE0, 0x0F,
  0xE1, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xE1, 0xFC, 0x01, 0xFE, 0x1F,
  0xC0, 0x1F, 0xC1, 0xFC, 0x01, 0xFC, 0x3F, 0xC0, 0x1F, 0xC3, 0xF8, 0x01,
  0xFC, 0x3F, 0x80, 0x3F, 0xC3, 0xF8, 0x03, 0xFC, 0x3F, 0x80, 0x3F, 0x87,
  0xF8, 0x03, 0xF8, 0x7F, 0x80, 0x3F, 0x87, 0xF0, 0x03, 0xF8, 0x7F, 0x00,
  0x7F, 0x87, 0xF0, 0x07, 0xF8, 0x7F, 0x00, 0x7F, 0x0F, 0xF0, 0x07, 0xF0,
  0xFF, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x03, 0xFF, 0x3F, 0xF0, 0xFF, 0x81, 0xFE, 0x1F, 0xE0, 0x1F, 0xC7, 0xF8,
  0x03, 0xF8, 0xFE, 0x00, 0x7F, 0x9F, 0xC0, 0x07, 0xF7, 0xF8, 0x00, 0xFE,
  0xFE, 0x00, 0x1F, 0xDF, 0xC0, 0x03, 0xFB, 0xF8, 0x00, 0x7F, 0xFF, 0x00,
  0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xEF,
  0xE0, 0x01, 0xFD, 0xFC, 0x00, 0x3F, 0xBF, 0x80, 0x07, 0xF7, 0xF0, 0x01,
  0xFE, 0xFE, 0x00, 0x3F, 0x9F, 0xC0, 0x07, 0xF3, 0xFC, 0x01, 0xFE, 0x3F,
  0x80, 0x7F, 0x87, 0xF8, 0x1F, 0xF0, 0xFF, 0xCF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x01, 0xFC,
  0xFF, 0xC0, 0x03, 0xFB, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0x81,
  0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xFC, 0x07, 0xF0, 0x07,
  0xF8, 0x1F, 0xE0, 0x0F, 0xF0, 0x3F, 0x80, 0x0F, 0xE0, 0x7F, 0x00, 0x1F,
  0xC0, 0xFE, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0xFF, 0x03, 0xF8, 0x01, 0xFE,
  0x0F, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xF0, 0x3F, 0x80, 0x0F, 0xE0,
  0x7F, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0xFF, 0x07,
  0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0x0F, 0xF0, 0x3F,
  0x80, 0x1F, 0xE0, 0x7F, 0x80, 0x7F, 0x81, 0xFF, 0x81, 0xFF, 0x03, 0xFF,
  0xCF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xDF,
  0xFF, 0x80, 0x3F, 0x9F, 0xFE, 0x00, 0xFF, 0x1F, 0xF8, 0x01, 0xFC, 0x07,
  0x80, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0xFC, 0x3F, 0x03, 0xFF, 0xE7, 0xF0, 0x7F,
  0xFF, 0x7F, 0x0F, 0xFF, 0xF7, 0xF0, 0xFF, 0xFF, 0xFE, 0x1F, 0xFD, 0xFF,
  0xE1, 0xFE, 0x03, 0xFE, 0x3F, 0xC0, 0x1F, 0xE3, 0xFC, 0x01, 0xFE, 0x3F,
  0x80, 0x1F, 0xE7, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x1F, 0xC7, 0xF0, 0x01,
  0xFC, 0x7F, 0x00, 0x1F, 0xCF, 0xF0, 0x03, 0xFC, 0xFF, 0x00, 0x3F, 0xCF,
  0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF8, 0xFE, 0x00,
  0x3F, 0x8F, 0xE0, 0x07, 0xF8, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0,
  0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0xFF, 0x0F, 0xF0,
  0x0F, 0xF0, 0xFF, 0x01, 0xFE, 0x07, 0xFE, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFD, 0xFC, 0x00, 0x1E, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x70, 0x1F, 0xCF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F,
  0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFE, 0x00,
  0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xE0, 0xFF, 0x87, 0xF8, 0x3F, 0xC0, 0xFF, 0x0F, 0xE0,
  0x3F, 0xC7, 0xF0, 0x07, 0xF1, 0xFC, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF,
  0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x3F, 0x8F, 0xE0, 0x0F, 0xE3,
  0xF8, 0x03, 0xF8, 0xFF, 0x01, 0xFE, 0x1F, 0xE0, 0xFF, 0x07, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x7F,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x1F, 0xFF, 0xF7, 0xFF, 0xF9, 0xFF, 0xFE, 0x7F, 0xFF, 0x9F, 0xFF,
  0xEF, 0xFF, 0xF8, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x1F,
  0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0x80, 0x0F, 0xE0, 0x07, 0xF0,
  0xFE, 0x00, 0xFF, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x1F, 0xE0,
  0x0F, 0xE1, 0xFC, 0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xE1, 0xFC, 0x01, 0xFE,
  0x1F, 0xC0, 0x1F, 0xC1, 0xFC, 0x01, 0xFC, 0x3F, 0xC0, 0x1F, 0xC3, 0xF8,
  0x01, 0xFC, 0x3F, 0x80, 0x3F, 0xC3, 0xF8, 0x03, 0xFC, 0x3F, 0x80, 0x3F,
  0x87, 0xF8, 0x03, 0xF8, 0x7F, 0x80, 0x3F, 0x87, 0xF0, 0x03, 0xF8, 0x7F,
  0x00, 0x7F, 0x87, 0xF0, 0x07, 0xF8, 0x7F, 0x00, 0x7F, 0x0F, 0xF0, 0x07,
  0xF0, 0xFF, 0x00, 0x7F, 0x0F, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0xFF, 0x0F,
  0xF0, 0x0F, 0xE0, 0xFF, 0x01, 0xFE, 0x0F, 0xF0, 0x3F, 0xE0, 0x7F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0x9F, 0xC0, 0x03, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xBF, 0x80, 0x3F, 0xDF, 0xC0, 0x1F, 0xEF,
  0xE0, 0x0F, 0xE7, 0xF0, 0x0F, 0xF3, 0xF8, 0x07, 0xF1, 0xFC, 0x07, 0xF8,
  0x7E, 0x03, 0xF8, 0x3F, 0x81, 0xFC, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFE,
  0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x7F, 0x01, 0xFC, 0x3F, 0x80, 0xFE, 0x3F,
  0x80, 0x3F, 0x1F, 0xC0, 0x1F, 0x8F, 0xC0, 0x0F, 0xCF, 0xE0, 0x07, 0xE7,
  0xF0, 0x03, 0xF3, 0xF0, 0x01, 0xFB, 0xF8, 0x00, 0xFD, 0xF8, 0x00, 0x7F,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0xF8, 0x03, 0xFF, 0xF8, 0x07, 0xF0, 0x0F, 0xEF, 0xE0, 0x1F, 0xC0, 0x3F,
  0xBF, 0x80, 0x7F, 0x01, 0xFC, 0xFE, 0x03, 0xFC, 0x07, 0xF3, 0xF8, 0x0F,
  0xF0, 0x1F, 0xCF, 0xE0, 0x7F, 0xC0, 0xFE, 0x3F, 0x81, 0xFF, 0x03, 0xF8,
  0xFE, 0x0F, 0xFC, 0x0F, 0xC3, 0xF8, 0x3F, 0xF0, 0x7F, 0x0F, 0xE0, 0xFF,
  0xC1, 0xFC, 0x1F, 0x87, 0xFF, 0x07, 0xE0, 0x7E, 0x1F, 0xFC, 0x3F, 0x81,
  0xF8, 0xFD, 0xF0, 0xFE, 0x07, 0xE3, 0xF7, 0xC7, 0xF0, 0x1F, 0x9F, 0x9F,
  0x9F, 0xC0, 0x7E, 0x7E, 0x7E, 0x7E, 0x01, 0xF9, 0xF9, 0xFB, 0xF8, 0x07,
  0xEF, 0xC7, 0xEF, 0xE0, 0x1F, 0xBF, 0x1F, 0xBF, 0x00, 0x7F, 0xF8, 0x7F,
  0xFC, 0x01, 0xFF, 0xE1, 0xFF, 0xE0, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x1F,
  0xFC, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0x07, 0xFE, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x7F,
  0xC0, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x00, 0xFC,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF8,
  0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x3F, 0xC0, 0x0F, 0xE0, 0xFF, 0x00,
  0x1F, 0xC1, 0xFE, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0x3F, 0x8F, 0xE0, 0x00,
  0x7F, 0x3F, 0xC0, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0xFD, 0xFC, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x03, 0xFC, 0xFE, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x1F, 0xE3, 0xF8,
  0x00, 0x7F, 0x83, 0xF8, 0x00, 0xFF, 0x07, 0xF0, 0x03, 0xFC, 0x0F, 0xE0,
  0x0F, 0xF0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x7F, 0x80, 0x3F, 0x81,
  0xFF, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x01, 0xFE, 0x07, 0xF0, 0x03, 0xFC,
  0x0F, 0xE0, 0x0F, 0xF0, 0x1F, 0xC0, 0x1F, 0xE0, 0x3F, 0x80, 0x7F, 0x80,
  0x7F, 0x00, 0xFF, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xFE, 0x07, 0xF8, 0x01,
  0xFC, 0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x0F,
  0xE1, 0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x7F,
  0x1F, 0xE0, 0x00, 0xFE, 0x3F, 0x80, 0x01, 0xFC, 0xFF, 0x00, 0x01, 0xF9,
  0xFC, 0x00, 0x03, 0xF7, 0xF8, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x0F, 0xDF,
  0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x9F, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0x00, 0x0F, 0xF0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0xFF, 0xC0, 0x0F,
  0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x7C,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7E,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x00,
  0x20, 0x00, 0x01, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00,
  0x0F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0xFC, 0x00,
  0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0xF0, 0x01, 0xF0, 0xFF, 0xE0, 0x07, 0xC7, 0xFF, 0xC0, 0x3F,
  0x3F, 0xFF, 0x80, 0xFC, 0xFF, 0xFF, 0x03, 0xE7, 0xFB, 0xFC, 0x1F, 0x9F,
  0x83, 0xFD, 0xFE, 0x7E, 0x07, 0xFF, 0xF3, 0xF0, 0x1F, 0xFF, 0xCF, 0xC0,
  0x3F, 0xFE, 0x3F, 0x00, 0x7F, 0xF0, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFC, 0x00,
};

const GFXglyph RobotoCondensed_MediumItalic65pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 15, 47, 16, 2, -46 },
  { 90, 17, 17, 20, 5, -49 },
  { 127, 32, 46, 34, 2, -46 },
  { 311, 29, 61, 32, 2, -54 },
  { 533, 30, 48, 40, 6, -47 },
  { 713, 32, 48, 35, 1, -47 },
  { 905, 8, 16, 11, 5, -49 },
  { 921, 20, 67, 20, 3, -52 },
  { 1089, 20, 67, 20, -3, -52 },
  { 1257, 27, 28, 28, 3, -46 },
  { 1352, 27, 34, 31, 2, -38 },
  { 1467, 13, 18, 14, -4, -7 },
  { 1497, 15, 6, 19, 2, -23 },
  { 1509, 9, 9, 18, 1, -8 },
  { 1520, 29, 50, 22, -4, -46 },
  { 1702, 27, 48, 32, 3, -47 },
  { 1864, 19, 46, 32, 7, -46 },
  { 1974, 30, 47, 32, 0, -47 },
  { 2151, 29, 48, 32, 1, -47 },
  { 2325, 29, 46, 32, 1, -46 },
  { 2492, 29, 47, 32, 3, -46 },
  { 2663, 26, 47, 32, 3, -46 },
  { 2816, 30, 46, 32, 3, -46 },
  { 2989, 28, 48, 32, 2, -47 },
  { 3157, 25, 47, 32, 5, -47 },
  { 3304, 14, 36, 16, 1, -35 },
  { 3367, 17, 46, 15, -3, -35 },
  { 3465, 25, 30, 28, 2, -35 },
  { 3559, 26, 19, 31, 3, -31 },
  { 3621, 26, 30, 29, 1, -35 },
  { 3719, 23, 48, 27, 5, -47 },
  { 3857, 44, 59, 48, 2, -45 },
  { 4182, 35, 46, 37, -2, -46 },
  { 4384, 33, 46, 35, 1, -46 },
  { 4574, 33, 48, 36, 3, -47 },
  { 4772, 33, 46, 36, 1, -46 },
  { 4962, 33, 46, 31, 1, -46 },
  { 5152, 32, 46, 30, 1, -46 },
  { 5336, 33, 48, 37, 3, -47 },
  { 5534, 38, 46, 39, 1, -46 },
  { 5753, 16, 46, 16, 1, -46 },
  { 5845, 31, 47, 31, 0, -46 },
  { 6028, 38, 46, 35, 1, -46 },
  { 6247, 25, 46, 30, 1, -46 },
  { 6391, 47, 46, 48, 1, -46 },
  { 6662, 38, 46, 39, 1, -46 },
  { 6881, 33, 48, 38, 3, -47 },
  { 7079, 35, 46, 35, 1, -46 },
  { 7281, 33, 55, 38, 3, -47 },
  { 7508, 33, 46, 34, 1, -46 },
  { 7698, 33, 48, 33, 1, -47 },
  { 7896, 32, 46, 34, 5, -46 },
  { 8080, 35, 47, 36, 2, -46 },
  { 8286, 34, 46, 36, 5, -46 },
  { 8482, 44, 46, 48, 6, -46 },
  { 8735, 40, 46, 35, -2, -46 },
  { 8965, 32, 46, 34, 6, -46 },
  { 9149, 36, 46, 33, -1, -46 },
  { 9356, 21, 63, 16, -1, -53 },
  { 9522, 14, 50, 24, 6, -46 },
  { 9610, 22, 63, 16, -4, -53 },
  { 9784, 21, 23, 24, 2, -46 },
  { 9845, 25, 6, 25, -4, 0 },
  { 9864, 12, 10, 20, 7, -49 },
  { 9879, 26, 36, 30, 1, -35 },
  { 9996, 29, 50, 31, 0, -49 },
  { 10178, 26, 36, 29, 2, -35 },
  { 10295, 31, 50, 31, 2, -49 },
  { 10489, 26, 36, 30, 2, -35 },
  { 10606, 23, 50, 20, 2, -50 },
  { 10750, 31, 48, 31, 0, -35 },
  { 10936, 28, 49, 31, 0, -49 },
  { 11108, 15, 47, 15, 1, -47 },
  { 11197, 23, 60, 15, -7, -47 },
  { 11370, 31, 49, 29, 0, -49 },
  { 11560, 15, 49, 15, 1, -49 },
  { 11652, 44, 35, 47, 0, -35 },
  { 11845, 28, 35, 31, 0, -35 },
  { 11968, 27, 36, 31, 2, -35 },
  { 12090, 31, 48, 31, -2, -35 },
  { 12276, 28, 48, 31, 2, -35 },
  { 12444, 21, 35, 20, 0, -35 },
  { 12536, 26, 36, 29, 1, -35 },
  { 12653, 18, 44, 19, 2, -43 },
  { 12752, 28, 35, 31, 2, -34 },
  { 12875, 25, 34, 28, 4, -34 },
  { 12982, 38, 34, 40, 4, -34 },
  { 13144, 31, 34, 28, -2, -34 },
  { 13276, 31, 47, 27, -2, -34 },
  { 13459, 29, 34, 28, -1, -34 },
  { 13583, 20, 62, 19, 2, -51 },
  { 13738, 14, 55, 16, 1, -46 },
  { 13835, 21, 63, 19, -3, -51 },
  { 14001, 30, 14, 36, 3, -26 },
};

const GFXfont RobotoCondensed_MediumItalic65pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_MediumItalic65pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_MediumItalic65pt7bGlyphs,
  0x20, 0x7E, 76
};

#endif // _ROBOTOCONDENSED_MEDIUMITALIC65PT7B_H_
