#ifndef _ROBOTOCONDENSED_MEDIUMITALIC45PT7B_H_
#define _ROBOTOCONDENSED_MEDIUMITALIC45PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-MediumItalic.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_MediumItalic45pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x1E,
  0x03, 0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x7C, 0x0F, 0xC1, 0xF8, 0x3E, 0x03, 0x80, 0x3C, 0x73, 0xCF,
  0x3C, 0xF3, 0x8F, 0x38, 0xF7, 0x8E, 0x78, 0xE7, 0x1E, 0x71, 0xE7, 0x1C,
  0x71, 0xC0, 0x00, 0x0E, 0x1C, 0x00, 0x3C, 0x78, 0x00, 0x78, 0xE0, 0x00,
  0xE1, 0xC0, 0x03, 0xC7, 0x80, 0x07, 0x8E, 0x00, 0x0E, 0x1C, 0x00, 0x3C,
  0x78, 0x00, 0x78, 0xE0, 0x00, 0xE1, 0xC0, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xF0, 0xFF, 0xFF, 0xC0, 0x3C, 0x78, 0x00, 0x78, 0xF0, 0x00, 0xE1, 0xC0,
  0x03, 0xC7, 0x80, 0x07, 0x8F, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x78, 0x07,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x07, 0x8F, 0x00, 0x0E,
  0x1C, 0x00, 0x1C, 0x78, 0x00, 0x78, 0xF0, 0x00, 0xE1, 0xC0, 0x01, 0xC7,
  0x80, 0x07, 0x8F, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x03,
  0xF0, 0x00, 0xFF, 0x80, 0x1F, 0xFC, 0x03, 0xFF, 0xE0, 0x7F, 0x7E, 0x07,
  0xC3, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF0,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x07, 0xC7, 0xC0, 0x7C, 0x7C, 0x07, 0xC7, 0xC0,
  0x7C, 0x7C, 0x0F, 0x87, 0xC1, 0xF8, 0x7F, 0x3F, 0x83, 0xFF, 0xF0, 0x1F,
  0xFE, 0x00, 0xFF, 0xC0, 0x07, 0xF0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x80, 0x00, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0xF3, 0xC0, 0x07, 0x0E, 0x06, 0x78, 0x78, 0x7B, 0xC3, 0xC7, 0x9E,
  0x1E, 0x38, 0xF0, 0xE3, 0xC7, 0x87, 0x3C, 0x3C, 0x79, 0xC0, 0xE7, 0xDE,
  0x07, 0xFD, 0xE0, 0x1F, 0xDE, 0x00, 0x7C, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x3E, 0x00, 0x7B, 0xF8, 0x07, 0xBF, 0xE0, 0x3B, 0xE7,
  0x03, 0x9E, 0x3C, 0x3C, 0xE1, 0xE3, 0xC7, 0x0F, 0x1C, 0x78, 0x79, 0xE3,
  0xC3, 0xDE, 0x1E, 0x1E, 0xE0, 0x70, 0xE3, 0x03, 0xCF, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xE7, 0xC0, 0x1F, 0x0F, 0x80, 0x7C, 0x3E,
  0x01, 0xE0, 0xF8, 0x07, 0x83, 0xC0, 0x1E, 0x1F, 0x00, 0x7C, 0xF8, 0x01,
  0xF7, 0xE0, 0x07, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xF8, 0x78, 0x7F, 0xE1, 0xE3, 0xFF, 0xC7, 0x9F, 0x9F, 0x3E,
  0x7C, 0x7E, 0xFB, 0xF0, 0xFB, 0xCF, 0x83, 0xFF, 0x3E, 0x07, 0xF8, 0xF8,
  0x1F, 0xE3, 0xE0, 0x3F, 0x0F, 0xC0, 0xFC, 0x1F, 0x8F, 0xF0, 0x7F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x81, 0xFF, 0x9F, 0x01, 0xF8, 0x7E, 0x3C, 0xF3, 0xDE,
  0x79, 0xE7, 0x9C, 0x73, 0xCF, 0x00, 0x00, 0x08, 0x00, 0x60, 0x03, 0xC0,
  0x1F, 0x00, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00,
  0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x00,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x06,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x06, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0,
  0x03, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x03,
  0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x3C, 0x00, 0xE0, 0x01, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x41, 0xE0, 0x9E, 0x3C, 0xF3, 0xFF, 0x7E, 0xFF, 0xFF, 0xE3, 0xFF, 0xF0,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x1E, 0xF0, 0x07, 0x8F, 0x01,
  0xF1, 0xE0, 0x7C, 0x1E, 0x07, 0x03, 0x80, 0x00, 0x40, 0x00, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x87, 0xC3, 0xE1, 0xE0, 0xF0, 0xF8, 0x7C,
  0x7C, 0x3E, 0x3E, 0x1E, 0x06, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7B,
  0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x3F, 0xE0, 0x1F, 0xFE, 0x03, 0xFF, 0xE0, 0xFC, 0xFC,
  0x3E, 0x0F, 0x87, 0xC0, 0xF8, 0xF0, 0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0x7C,
  0xF8, 0x0F, 0xBE, 0x01, 0xF7, 0xC0, 0x3E, 0xF8, 0x0F, 0x9F, 0x01, 0xF3,
  0xE0, 0x3E, 0x7C, 0x07, 0xDF, 0x80, 0xFB, 0xE0, 0x1F, 0x7C, 0x03, 0xEF,
  0x80, 0xF9, 0xF0, 0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0x7C, 0xF8, 0x1F, 0x1F,
  0x03, 0xE3, 0xE0, 0xF8, 0x3E, 0x3F, 0x07, 0xFF, 0xC0, 0x7F, 0xF0, 0x07,
  0xFC, 0x00, 0x7F, 0x00, 0x00, 0x18, 0x07, 0xC0, 0xFC, 0x3F, 0xE7, 0xFF,
  0x3F, 0xF9, 0xFF, 0xDE, 0x3C, 0xC3, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x07,
  0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x7E, 0x3F, 0x03, 0xE0, 0xFC,
  0x3E, 0x07, 0xE1, 0xF0, 0x1F, 0x1F, 0x80, 0xF8, 0xF8, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xFF, 0xFE,
  0x3F, 0xFF, 0xE3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x0F, 0xC7, 0xE0, 0xF8, 0x3E, 0x1F,
  0x03, 0xF1, 0xF0, 0x1F, 0x1F, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xE0,
  0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x0F, 0x8F, 0x80,
  0xF8, 0xFC, 0x1F, 0x87, 0xE3, 0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x1F,
  0xF8, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x07,
  0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xDF, 0x00, 0x3E, 0xF8, 0x01, 0xE7, 0xC0,
  0x1E, 0x3E, 0x01, 0xF3, 0xE0, 0x0F, 0x1F, 0x00, 0xF8, 0xF8, 0x0F, 0x87,
  0xC0, 0x78, 0x3E, 0x07, 0xC3, 0xE0, 0x7C, 0x1F, 0x03, 0xC0, 0xF8, 0x3F,
  0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF0, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0,
  0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE7, 0xC0, 0x1F, 0xFE,
  0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x83, 0xF1, 0xF8, 0x1C, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0x8F, 0x80, 0xF8, 0xF8, 0x0F, 0x8F, 0x81, 0xF8, 0xFC, 0x1F, 0x07,
  0xE7, 0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0x80, 0x0F, 0xE0, 0x0F, 0xF8, 0x07, 0xFE, 0x03, 0xFE, 0x01,
  0xFC, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0,
  0x00, 0xF9, 0xF0, 0x3F, 0xFE, 0x1F, 0xFF, 0xC7, 0xFF, 0xF9, 0xFC, 0x7E,
  0x7E, 0x0F, 0x9F, 0x03, 0xEF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0xFB, 0xE0, 0x3E, 0xF8, 0x0F, 0x9E, 0x07, 0xE7, 0xC1,
  0xF1, 0xF9, 0xFC, 0x3F, 0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0x80, 0x1F, 0x80,
  0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xE0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x0F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x07, 0xE7,
  0xE0, 0xFC, 0x3F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xF8,
  0x1F, 0x0F, 0x83, 0xF0, 0xF8, 0x3E, 0x0F, 0x87, 0xE0, 0x7C, 0xFC, 0x07,
  0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xF0, 0x3F, 0x0F, 0x83,
  0xE0, 0xF8, 0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0x7C, 0x07, 0xCF, 0xC0, 0x7C,
  0xFC, 0x0F, 0xC7, 0xC0, 0xF8, 0x7C, 0x1F, 0x87, 0xE3, 0xF0, 0x3F, 0xFF,
  0x03, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x01, 0xFF,
  0x00, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0x9F, 0x0F, 0x83, 0xE7, 0xE0, 0xF9,
  0xF0, 0x3E, 0x7C, 0x0F, 0xBE, 0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x3E, 0xF8,
  0x0F, 0xBE, 0x03, 0xEF, 0x80, 0xF9, 0xF0, 0x7E, 0x7E, 0x7F, 0x9F, 0xFF,
  0xC3, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0x9F, 0x00, 0x07, 0x80, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x80, 0x7F, 0xC0, 0x7F,
  0xE0, 0x1F, 0xF0, 0x07, 0xF0, 0x01, 0xE0, 0x00, 0x07, 0x07, 0xC7, 0xE3,
  0xF0, 0xF8, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x0F, 0xC7, 0xE3, 0xF1, 0xF8, 0x78,
  0x00, 0x01, 0xE0, 0x3E, 0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x7C, 0x0F, 0x80, 0xF0, 0x02,
  0x00, 0x00, 0x00, 0x80, 0x00, 0xE0, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0xFF,
  0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0x80, 0x1F, 0x80, 0x07,
  0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x0F,
  0xF8, 0x00, 0xFE, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x10, 0x3F, 0xFF,
  0xCF, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC7, 0xFF, 0xF3, 0xFF,
  0xFC, 0xFF, 0xFF, 0x00, 0x08, 0x00, 0x07, 0x00, 0x01, 0xF0, 0x00, 0x7F,
  0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x7F,
  0xC0, 0x07, 0xF0, 0x00, 0xF8, 0x00, 0xFE, 0x01, 0xFF, 0x81, 0xFF, 0x81,
  0xFF, 0x81, 0xFF, 0x80, 0x7F, 0x80, 0x1F, 0x80, 0x0F, 0x80, 0x03, 0x80,
  0x00, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x0F, 0xFC, 0x1F, 0xFE, 0x3F, 0xFE,
  0x7F, 0x7F, 0x7C, 0x1F, 0x7C, 0x1F, 0xF8, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x3E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFC, 0x3F, 0x80,
  0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x0E, 0x01,
  0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x1C, 0x0F, 0x03, 0xF0, 0x38, 0x3C,
  0x0F, 0xF0, 0x70, 0x70, 0x3F, 0xF8, 0xF1, 0xE0, 0xF9, 0xE0, 0xE3, 0x83,
  0xC3, 0xC1, 0xCF, 0x0F, 0x87, 0x83, 0x9E, 0x1E, 0x0F, 0x07, 0x38, 0x3C,
  0x1C, 0x1E, 0xF0, 0xF0, 0x78, 0x3D, 0xE1, 0xE0, 0xF0, 0x73, 0x83, 0xC1,
  0xE0, 0xE7, 0x0F, 0x03, 0x81, 0xDE, 0x1E, 0x0F, 0x03, 0xBC, 0x3C, 0x1E,
  0x0F, 0x78, 0x78, 0x3C, 0x1C, 0xF0, 0xF0, 0x70, 0x39, 0xE1, 0xE1, 0xE0,
  0xE3, 0xC3, 0xC7, 0xC1, 0xC7, 0x87, 0xFF, 0xCF, 0x0F, 0x07, 0xFF, 0xFE,
  0x1E, 0x0F, 0xE7, 0xF0, 0x3C, 0x0F, 0x07, 0xC0, 0x38, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xE0, 0x04, 0x00, 0x03, 0xFC, 0x78, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0x78, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xDF, 0x00, 0x07, 0xCF,
  0x80, 0x03, 0xE7, 0xC0, 0x03, 0xE1, 0xE0, 0x01, 0xF0, 0xF0, 0x01, 0xF0,
  0x78, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x7C,
  0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x0F, 0xC0, 0x0F, 0x87, 0xC0, 0x07, 0xC7,
  0xE0, 0x03, 0xE3, 0xE0, 0x01, 0xF3, 0xF0, 0x00, 0xF9, 0xF8, 0x00, 0x7C,
  0xF8, 0x00, 0x3F, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x01,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3E, 0x03, 0xF0, 0xF8, 0x07, 0xC3, 0xE0,
  0x1F, 0x0F, 0x80, 0x7C, 0x7E, 0x01, 0xF1, 0xF8, 0x07, 0xC7, 0xC0, 0x3F,
  0x1F, 0x01, 0xF8, 0x7C, 0x0F, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x83, 0xE0, 0x3F, 0x0F, 0x80, 0x7C, 0x3E, 0x01,
  0xF1, 0xF8, 0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xF1,
  0xF0, 0x0F, 0xC7, 0xC0, 0x7E, 0x3F, 0x07, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xFF,
  0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x7F, 0x3F, 0xC1, 0xF8, 0x1F,
  0x87, 0xE0, 0x1F, 0x0F, 0x80, 0x3E, 0x3F, 0x00, 0x7E, 0x7C, 0x00, 0x7C,
  0xF8, 0x00, 0xFB, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x3E, 0x3E, 0x00,
  0x7C, 0x7C, 0x00, 0xF8, 0xFC, 0x03, 0xF0, 0xF8, 0x07, 0xC1, 0xF8, 0x1F,
  0x83, 0xFC, 0xFE, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0x80,
  0x01, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x80,
  0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x81, 0xF0, 0x1F, 0x03, 0xE0, 0x3F, 0x07,
  0xC0, 0x3E, 0x0F, 0x80, 0x7C, 0x3F, 0x00, 0xF8, 0x7E, 0x01, 0xF0, 0xF8,
  0x03, 0xE1, 0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x1F, 0x80,
  0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x03, 0xF1, 0xF0, 0x07,
  0xC3, 0xE0, 0x0F, 0x8F, 0xC0, 0x1F, 0x1F, 0x00, 0x7E, 0x3E, 0x00, 0xF8,
  0x7C, 0x03, 0xF0, 0xF8, 0x0F, 0xC1, 0xF0, 0x3F, 0x87, 0xE3, 0xFE, 0x0F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x07,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xC0,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x81,
  0xFF, 0xFE, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F,
  0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xFF,
  0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFF, 0xBF, 0xC1, 0xF8, 0x1F,
  0x87, 0xE0, 0x1F, 0x0F, 0x80, 0x1F, 0x3F, 0x00, 0x3E, 0x7C, 0x00, 0x7C,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x1F, 0xFC, 0xF8, 0x3F, 0xFB, 0xF0,
  0x7F, 0xE7, 0xC0, 0xFF, 0xCF, 0x80, 0x0F, 0x9F, 0x00, 0x1F, 0x3E, 0x00,
  0x7E, 0x7E, 0x00, 0xFC, 0xFC, 0x01, 0xF0, 0xF8, 0x03, 0xE1, 0xF8, 0x0F,
  0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xE0,
  0x01, 0xFE, 0x00, 0x07, 0xC0, 0x07, 0xC1, 0xF0, 0x01, 0xF0, 0x7C, 0x00,
  0x7C, 0x1F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0x83, 0xE0, 0x03, 0xE0, 0xF8,
  0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x87, 0xE0, 0x07, 0xE1,
  0xF8, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x07, 0xC0, 0x07,
  0xC1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0x83, 0xE0, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x1F,
  0x80, 0x1F, 0x87, 0xC0, 0x07, 0xC1, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x7C,
  0x1F, 0x00, 0x1F, 0x07, 0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xE0, 0xF8, 0x00,
  0xF8, 0x3E, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x03, 0xE0, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x1F, 0x83, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x0F, 0xC1, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x3F, 0x07, 0xE0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x1F, 0x83, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x0F, 0xC1, 0xF0, 0x3E, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x0F, 0xC0, 0x7C, 0x3F, 0x03,
  0xF0, 0xFC, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC1, 0xF8, 0x1F, 0xDF, 0xC0,
  0x3F, 0xFE, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x01, 0xF8, 0x00, 0x07,
  0xC0, 0x1F, 0xC1, 0xF0, 0x0F, 0xE0, 0x7C, 0x07, 0xF0, 0x1F, 0x01, 0xF8,
  0x0F, 0xC0, 0xFC, 0x03, 0xE0, 0x7E, 0x00, 0xF8, 0x3F, 0x80, 0x3E, 0x1F,
  0xC0, 0x0F, 0x87, 0xE0, 0x07, 0xE3, 0xF0, 0x01, 0xF9, 0xF8, 0x00, 0x7C,
  0xFC, 0x00, 0x1F, 0x7E, 0x00, 0x07, 0xDF, 0x80, 0x01, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xF0,
  0x00, 0xFE, 0xFC, 0x00, 0x3F, 0x1F, 0x00, 0x1F, 0x87, 0xE0, 0x07, 0xC1,
  0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x7C, 0x0F, 0xC0, 0x1F, 0x03, 0xF0, 0x07,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x03, 0xE0, 0x3E, 0x00, 0xFC,
  0x0F, 0x80, 0x3F, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x07, 0xF0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x7F, 0x07,
  0xF0, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0xFF, 0x0F,
  0xF0, 0x01, 0xFE, 0x0F, 0xF8, 0x01, 0xFE, 0x0F, 0xF8, 0x03, 0xFE, 0x0F,
  0xF8, 0x03, 0xFE, 0x1F, 0x78, 0x07, 0xFE, 0x1F, 0x78, 0x07, 0xBE, 0x1F,
  0x78, 0x0F, 0xBC, 0x1F, 0x78, 0x0F, 0x7C, 0x1F, 0x78, 0x1F, 0x7C, 0x1F,
  0x78, 0x1E, 0x7C, 0x3E, 0x78, 0x1E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E,
  0x3C, 0x3C, 0xF8, 0x3E, 0x3C, 0x7C, 0xF8, 0x3E, 0x3C, 0x78, 0xF8, 0x3E,
  0x3C, 0xF8, 0xF8, 0x7E, 0x3C, 0xF1, 0xF8, 0x7C, 0x3D, 0xF1, 0xF8, 0x7C,
  0x3D, 0xE1, 0xF0, 0x7C, 0x3F, 0xE1, 0xF0, 0x7C, 0x1F, 0xC1, 0xF0, 0x7C,
  0x1F, 0xC1, 0xF0, 0xFC, 0x1F, 0x83, 0xF0, 0xF8, 0x1F, 0x83, 0xE0, 0xF8,
  0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0xF8, 0x1E, 0x03, 0xE0, 0x07,
  0xC0, 0x07, 0xC1, 0xF8, 0x01, 0xF0, 0x7E, 0x00, 0x7C, 0x1F, 0x80, 0x3F,
  0x0F, 0xF0, 0x0F, 0x83, 0xFC, 0x03, 0xE0, 0xFF, 0x00, 0xF8, 0x3F, 0xC0,
  0x3E, 0x0F, 0xF8, 0x0F, 0x87, 0xFE, 0x07, 0xE1, 0xFF, 0x81, 0xF0, 0x7C,
  0xF0, 0x7C, 0x1F, 0x3C, 0x1F, 0x07, 0xCF, 0x07, 0xC1, 0xF3, 0xE1, 0xF0,
  0xFC, 0x78, 0xFC, 0x3F, 0x1E, 0x3E, 0x0F, 0x87, 0x8F, 0x83, 0xE0, 0xF3,
  0xE0, 0xF8, 0x3C, 0xF8, 0x3E, 0x0F, 0x7E, 0x1F, 0x83, 0xFF, 0x87, 0xC0,
  0x7F, 0xC1, 0xF0, 0x1F, 0xF0, 0x7C, 0x07, 0xFC, 0x1F, 0x00, 0xFF, 0x07,
  0xC0, 0x3F, 0xC3, 0xF0, 0x0F, 0xE0, 0xF8, 0x01, 0xF8, 0x3E, 0x00, 0x7E,
  0x0F, 0x80, 0x1F, 0x83, 0xE0, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFF,
  0xC0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC1, 0xF8, 0x1F,
  0x87, 0xE0, 0x1F, 0x0F, 0x80, 0x1F, 0x3F, 0x00, 0x3E, 0x7C, 0x00, 0x7C,
  0xF8, 0x00, 0xF9, 0xF0, 0x01, 0xF7, 0xE0, 0x03, 0xEF, 0x80, 0x07, 0xDF,
  0x00, 0x0F, 0xBE, 0x00, 0x3F, 0x7C, 0x00, 0x7C, 0xF8, 0x00, 0xFB, 0xF0,
  0x01, 0xF7, 0xC0, 0x03, 0xEF, 0x80, 0x07, 0xDF, 0x00, 0x1F, 0x3E, 0x00,
  0x3E, 0x7C, 0x00, 0x7C, 0x7C, 0x01, 0xF0, 0xF8, 0x07, 0xE1, 0xF8, 0x1F,
  0x81, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0x80,
  0x01, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xF8,
  0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x0F, 0x80, 0x7E, 0x0F, 0x80, 0x3E,
  0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x1F, 0x80, 0x3E, 0x1F, 0x80, 0x3E,
  0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x7E, 0x1F, 0x00, 0x7E, 0x1F, 0x00, 0xFC,
  0x3F, 0x07, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0,
  0x3F, 0xFF, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0,
  0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC1, 0xF8, 0x1F, 0x87, 0xE0, 0x1F, 0x0F,
  0x80, 0x3F, 0x3F, 0x00, 0x3E, 0x7C, 0x00, 0x7C, 0xF8, 0x00, 0xFB, 0xF0,
  0x01, 0xF7, 0xC0, 0x03, 0xEF, 0x80, 0x07, 0xDF, 0x00, 0x1F, 0xBE, 0x00,
  0x3E, 0x7C, 0x00, 0x7D, 0xF8, 0x00, 0xFB, 0xF0, 0x01, 0xF7, 0xC0, 0x03,
  0xEF, 0x80, 0x0F, 0xDF, 0x00, 0x1F, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0xFC,
  0xFC, 0x01, 0xF0, 0xF8, 0x07, 0xE1, 0xF8, 0x1F, 0x83, 0xFF, 0xFE, 0x03,
  0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x20, 0x00, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC1, 0xF0, 0x1F, 0x83, 0xE0,
  0x1F, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x7C, 0x1F, 0x00, 0xF8, 0x7E, 0x01,
  0xF0, 0xF8, 0x03, 0xE1, 0xF0, 0x0F, 0xC3, 0xE0, 0x1F, 0x87, 0xC0, 0x7E,
  0x1F, 0x87, 0xF8, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0xFE, 0x01,
  0xFF, 0xF8, 0x03, 0xE1, 0xF8, 0x0F, 0xC1, 0xF0, 0x1F, 0x03, 0xE0, 0x3E,
  0x07, 0xE0, 0x7C, 0x0F, 0xC0, 0xF8, 0x0F, 0x81, 0xF0, 0x1F, 0x07, 0xE0,
  0x3F, 0x0F, 0x80, 0x7E, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x7C, 0x01,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFE,
  0x07, 0xFB, 0xF8, 0x3F, 0x03, 0xF0, 0xF8, 0x07, 0xC7, 0xE0, 0x1F, 0x1F,
  0x80, 0x7C, 0x7C, 0x01, 0xF1, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0xCF, 0x80, 0x3F, 0x3E, 0x00, 0xFC, 0xF8, 0x03, 0xE3, 0xF0, 0x0F,
  0x87, 0xC0, 0x7E, 0x1F, 0xE7, 0xF0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFE, 0x00,
  0xFF, 0xE0, 0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07,
  0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x3F, 0x1F, 0x80, 0x3E, 0x1F,
  0x80, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x7E, 0x1F,
  0x00, 0x7C, 0x3F, 0x00, 0x7C, 0x3F, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E,
  0x00, 0x7C, 0x3E, 0x00, 0xFC, 0x3E, 0x00, 0xF8, 0x7E, 0x00, 0xF8, 0x7C,
  0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x01, 0xF8, 0x7C,
  0x01, 0xF0, 0xFC, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xF8,
  0x03, 0xF0, 0xF8, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0xF8, 0x07, 0xE0, 0xFC,
  0x0F, 0xC0, 0x7F, 0xBF, 0xC0, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0,
  0x03, 0xF7, 0xE0, 0x07, 0xEF, 0xC0, 0x0F, 0x9F, 0x80, 0x3F, 0x1F, 0x00,
  0x7C, 0x3E, 0x01, 0xF8, 0x7C, 0x03, 0xF0, 0xF8, 0x07, 0xC1, 0xF0, 0x1F,
  0x83, 0xE0, 0x3E, 0x07, 0xC0, 0xFC, 0x0F, 0x81, 0xF0, 0x0F, 0x87, 0xE0,
  0x1F, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x01,
  0xF3, 0xF0, 0x03, 0xE7, 0xC0, 0x03, 0xCF, 0x80, 0x07, 0xBE, 0x00, 0x0F,
  0x7C, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x07, 0xC0, 0x3F, 0xF0, 0x0F, 0x80, 0xFB, 0xE0, 0x3F, 0x01,
  0xF7, 0xC0, 0x7E, 0x03, 0xEF, 0x80, 0xFC, 0x0F, 0x9F, 0x03, 0xF8, 0x1F,
  0x3E, 0x07, 0xF0, 0x3E, 0x7C, 0x0F, 0xE0, 0xF8, 0xF8, 0x3F, 0xC1, 0xF1,
  0xF0, 0x7F, 0x83, 0xE3, 0xE0, 0xFF, 0x0F, 0x83, 0xC3, 0xFE, 0x1F, 0x07,
  0x87, 0xBC, 0x3E, 0x0F, 0x0F, 0x78, 0xF8, 0x1E, 0x3C, 0xF1, 0xF0, 0x3C,
  0x79, 0xE3, 0xE0, 0x79, 0xF3, 0xC7, 0x80, 0xF3, 0xC7, 0x9F, 0x01, 0xE7,
  0x8F, 0x3E, 0x03, 0xDF, 0x0E, 0x78, 0x07, 0xBC, 0x1F, 0xF0, 0x0F, 0x78,
  0x3F, 0xE0, 0x1F, 0xF0, 0x7F, 0x80, 0x3F, 0xC0, 0xFF, 0x00, 0x7F, 0x81,
  0xFE, 0x00, 0xFE, 0x03, 0xF8, 0x01, 0xFC, 0x07, 0xF0, 0x03, 0xF8, 0x0F,
  0xE0, 0x07, 0xE0, 0x1F, 0x80, 0x0F, 0xC0, 0x3F, 0x00, 0x1F, 0x80, 0x7E,
  0x00, 0x3E, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x7C, 0x01, 0xF8,
  0x0F, 0xC0, 0x7F, 0x01, 0xF8, 0x0F, 0xC0, 0x1F, 0x03, 0xF0, 0x03, 0xF0,
  0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x07, 0xC3, 0xE0, 0x00, 0xF8, 0xFC, 0x00,
  0x1F, 0xBF, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xFC, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0xFC, 0xF8, 0x00, 0x3F,
  0x1F, 0x00, 0x07, 0xE3, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x07, 0xC0,
  0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0xFE, 0x01, 0xF0, 0x1F, 0x80,
  0x3F, 0x07, 0xE0, 0x07, 0xE0, 0xF8, 0x00, 0xFF, 0xF0, 0x07, 0xEF, 0xC0,
  0x1F, 0x9F, 0x00, 0xFC, 0x7C, 0x03, 0xF1, 0xF0, 0x1F, 0x87, 0xE0, 0x7C,
  0x0F, 0x83, 0xF0, 0x3E, 0x0F, 0x80, 0xF8, 0x7E, 0x03, 0xE1, 0xF0, 0x07,
  0xCF, 0x80, 0x1F, 0x3E, 0x00, 0x7D, 0xF0, 0x01, 0xFF, 0xC0, 0x03, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xE0, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7F, 0x80, 0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x00,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0x78, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC0, 0xF0, 0x3C, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x81, 0xE0,
  0x78, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x03, 0xC0, 0xF0, 0x3E, 0x0F,
  0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x81, 0xE0, 0x7C, 0x01, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x00, 0xE0, 0x07, 0xC0, 0x3F,
  0x00, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0xF7, 0x03, 0xDE, 0x1E, 0x78, 0x79,
  0xE3, 0xE7, 0x8F, 0x1E, 0x7C, 0x79, 0xE0, 0xEF, 0x83, 0xFC, 0x0F, 0x7F,
  0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xF9, 0xFF, 0xFE, 0xF8, 0x7C, 0x7C, 0x3E,
  0x1E, 0x1F, 0x0F, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0xF8, 0x3F, 0xFE,
  0x1F, 0x8F, 0x8F, 0xC1, 0xF3, 0xE0, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0,
  0xFF, 0xE0, 0xFF, 0xF8, 0xFF, 0xFE, 0x7F, 0x8F, 0x9F, 0x83, 0xEF, 0xC1,
  0xFB, 0xE0, 0x7C, 0xF8, 0x1F, 0x3E, 0x07, 0xCF, 0x83, 0xF3, 0xF3, 0xFC,
  0xFF, 0xFF, 0x1F, 0xFF, 0xC3, 0xFD, 0xF0, 0x7C, 0x7C, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x9F,
  0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xE7, 0xF1, 0xF8,
  0x3F, 0x1F, 0x01, 0xF1, 0xF0, 0x1F, 0x1F, 0x01, 0xF1, 0xF0, 0x1F, 0x1F,
  0x01, 0xF3, 0xE0, 0x1F, 0x3E, 0x01, 0xF3, 0xE0, 0x3E, 0x3E, 0x03, 0xE3,
  0xE0, 0x3E, 0x7E, 0x03, 0xE7, 0xE0, 0x7E, 0x7E, 0x07, 0xC7, 0xF9, 0xFC,
  0x7F, 0xFF, 0x87, 0xBF, 0xF0, 0xF9, 0xFE, 0x0F, 0x8F, 0xC0, 0x00, 0xFC,
  0x00, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0x8F, 0xCF, 0xC1, 0xF3,
  0xE0, 0x7D, 0xF0, 0x1F, 0x7C, 0x07, 0xDF, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x0F,
  0xBE, 0x03, 0xC7, 0xC1, 0xF1, 0xF8, 0xFC, 0x7F, 0xFE, 0x0F, 0xFF, 0x01,
  0xFF, 0x80, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x1F, 0x1F, 0x01, 0xFE,
  0x7C, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xF8, 0xFE, 0x0F, 0xC1, 0xF8,
  0x3E, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x7C, 0x1F, 0x01, 0xF0, 0x7C,
  0x07, 0xC3, 0xF0, 0x1F, 0x0F, 0x80, 0x7C, 0x3E, 0x01, 0xF0, 0xF8, 0x0F,
  0x83, 0xE0, 0x3E, 0x0F, 0x80, 0xF8, 0x3E, 0x03, 0xE0, 0xFC, 0x1F, 0x81,
  0xF9, 0xFE, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x3E,
  0x7C, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFE, 0x1F,
  0x8F, 0xCF, 0xC1, 0xF3, 0xE0, 0x7C, 0xF8, 0x0F, 0x7C, 0x03, 0xDF, 0x01,
  0xF7, 0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x61, 0xFC, 0x7C, 0x3F,
  0xFF, 0x0F, 0xFF, 0x81, 0xFF, 0xC0, 0x1F, 0xC0, 0x00, 0x7E, 0x01, 0xFC,
  0x0F, 0xF8, 0x1F, 0xF0, 0x7F, 0x20, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x01, 0xFF, 0xE3, 0xFF, 0x87, 0xFF, 0x1F, 0xFE, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0xF8, 0x1F, 0xF7, 0xC1, 0xFF, 0xBE, 0x1F, 0xFF, 0xF0, 0xFE,
  0x7F, 0x0F, 0xC1, 0xF8, 0x7C, 0x07, 0xC7, 0xE0, 0x3E, 0x3E, 0x01, 0xF1,
  0xF0, 0x1F, 0x8F, 0x80, 0xF8, 0x7C, 0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x01,
  0xF1, 0xF0, 0x0F, 0x8F, 0x80, 0xFC, 0x7C, 0x07, 0xC3, 0xF0, 0x3E, 0x0F,
  0x83, 0xF0, 0x7F, 0x3F, 0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x3F, 0xFE,
  0x00, 0xF9, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0xC0,
  0x7E, 0x07, 0x87, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x3E, 0x7C, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF,
  0xC7, 0xF9, 0xF8, 0xFC, 0x1F, 0x1F, 0x03, 0xE3, 0xE0, 0x7C, 0x7C, 0x0F,
  0x8F, 0x81, 0xF3, 0xE0, 0x3E, 0x7C, 0x07, 0xCF, 0x80, 0xF9, 0xF0, 0x3E,
  0x3E, 0x07, 0xC7, 0xC0, 0xF9, 0xF0, 0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0x7C,
  0xF8, 0x1F, 0x1F, 0x03, 0xE3, 0xE0, 0x7C, 0xF8, 0x0F, 0x9F, 0x01, 0xF0,
  0x01, 0x80, 0x7C, 0x0F, 0x83, 0xF0, 0x3E, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0xFC, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0x0C,
  0x00, 0x1E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0,
  0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0,
  0x5F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x7E, 0x1F, 0x07, 0xE0, 0xF8, 0x7E, 0x07, 0xC7, 0xE0, 0x3E,
  0x7F, 0x03, 0xE3, 0xF0, 0x1F, 0x3F, 0x00, 0xFB, 0xF0, 0x07, 0xFF, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF,
  0x80, 0x3F, 0x7C, 0x01, 0xF3, 0xF0, 0x1F, 0x8F, 0x80, 0xF8, 0x7C, 0x07,
  0xC3, 0xF0, 0x3E, 0x0F, 0x81, 0xF0, 0x7C, 0x0F, 0x83, 0xF0, 0xF8, 0x0F,
  0x87, 0xC0, 0x7E, 0x00, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x1F, 0x83, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x80, 0x0F, 0x9F, 0x03, 0xF0, 0x1F, 0xFF, 0x9F, 0xF0, 0x3F,
  0xFF, 0x7F, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0xFC, 0x7F, 0xCF, 0xC3, 0xF0,
  0x7E, 0x0F, 0x87, 0xC0, 0xFC, 0x1F, 0x0F, 0x81, 0xF0, 0x3E, 0x1F, 0x03,
  0xE0, 0x7C, 0x3E, 0x07, 0xC0, 0xF8, 0x7C, 0x0F, 0x81, 0xF1, 0xF0, 0x1F,
  0x03, 0xE3, 0xE0, 0x7C, 0x07, 0xC7, 0xC0, 0xF8, 0x0F, 0x8F, 0x81, 0xF0,
  0x3E, 0x1F, 0x03, 0xE0, 0x7C, 0x3E, 0x07, 0xC0, 0xF8, 0xF8, 0x0F, 0x81,
  0xF1, 0xF0, 0x3E, 0x03, 0xE3, 0xE0, 0x7C, 0x07, 0xC7, 0xC0, 0xF8, 0x1F,
  0x0F, 0x81, 0xF0, 0x3E, 0x3E, 0x03, 0xE0, 0x7C, 0x7C, 0x07, 0xC0, 0xF8,
  0x0F, 0x9F, 0x01, 0xF7, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xF1, 0xFE, 0x7E,
  0x3F, 0x07, 0xC7, 0xC0, 0xF8, 0xF8, 0x1F, 0x1F, 0x03, 0xE3, 0xE0, 0x7C,
  0xF8, 0x0F, 0x9F, 0x01, 0xF3, 0xE0, 0x3E, 0x7C, 0x0F, 0x8F, 0x81, 0xF1,
  0xF0, 0x3E, 0x7C, 0x07, 0xCF, 0x80, 0xF9, 0xF0, 0x1F, 0x3E, 0x07, 0xC7,
  0xC0, 0xF8, 0xF8, 0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0x7C, 0x00, 0xFC, 0x00,
  0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xE1, 0xF8, 0xFC, 0x7E, 0x0F, 0xCF,
  0x80, 0xFB, 0xF0, 0x1F, 0x7C, 0x03, 0xEF, 0x80, 0x7D, 0xF0, 0x0F, 0xBE,
  0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFE, 0x01, 0xF7, 0xC0, 0x3E, 0xF8,
  0x07, 0xCF, 0x81, 0xF1, 0xF0, 0x3E, 0x3F, 0x1F, 0x83, 0xFF, 0xF0, 0x7F,
  0xFC, 0x07, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xCF, 0x80, 0x3F, 0xFF, 0x01,
  0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0x3F, 0x07, 0xE0, 0xFC, 0x3E, 0x03,
  0xE1, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x3E, 0x3E,
  0x01, 0xF1, 0xF0, 0x0F, 0x8F, 0x80, 0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x3E,
  0x3E, 0x01, 0xF1, 0xF0, 0x1F, 0x0F, 0xC1, 0xF8, 0x7F, 0x1F, 0xC3, 0xFF,
  0xFC, 0x1F, 0xFF, 0xC1, 0xF3, 0xFC, 0x0F, 0x8F, 0xC0, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF1, 0xF0,
  0x7F, 0x9F, 0x0F, 0xFD, 0xE1, 0xFF, 0xFE, 0x3F, 0x8F, 0xE3, 0xF0, 0x7E,
  0x3E, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0x7C, 0x07,
  0xC7, 0xC0, 0x7C, 0xF8, 0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x0F, 0x8F, 0x80,
  0xF8, 0xF8, 0x0F, 0x8F, 0x80, 0xF8, 0xFC, 0x1F, 0x87, 0xE3, 0xF8, 0x7F,
  0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0xF9, 0xF0, 0x00, 0x1F, 0x00,
  0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x9E, 0x1F, 0xFC,
  0x3F, 0xF8, 0x7F, 0xE0, 0xFF, 0xC3, 0xFC, 0x07, 0xE0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x3E, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x01, 0xFF, 0x80, 0xFF, 0xF0,
  0x7F, 0xFE, 0x1F, 0x0F, 0x8F, 0x83, 0xE3, 0xE0, 0x7C, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x7F,
  0x80, 0x07, 0xF0, 0x00, 0xFC, 0xF0, 0x1F, 0x3C, 0x07, 0xCF, 0x81, 0xF3,
  0xF1, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x03, 0xFF, 0x80, 0x3F, 0x80, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x81, 0xF0, 0xFF, 0xFF, 0xFE, 0xFF,
  0xEF, 0xFE, 0x1F, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E,
  0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0xF8,
  0x07, 0xE0, 0x7F, 0x07, 0xF0, 0x3F, 0x01, 0xF0, 0x1F, 0x01, 0xF1, 0xF0,
  0x3E, 0x1F, 0x03, 0xE1, 0xF0, 0x3E, 0x3E, 0x03, 0xE3, 0xE0, 0x3E, 0x3E,
  0x03, 0xE3, 0xE0, 0x7C, 0x3E, 0x07, 0xC3, 0xE0, 0x7C, 0x7C, 0x07, 0xC7,
  0xC0, 0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0xF8, 0x7C, 0x0F, 0x87, 0xC0, 0xF8,
  0x7C, 0x0F, 0x87, 0xC0, 0xF8, 0x7C, 0x1F, 0x87, 0xE7, 0xF0, 0x7F, 0xFF,
  0x03, 0xFF, 0xF0, 0x3F, 0xDF, 0x00, 0xF9, 0xF0, 0x7C, 0x07, 0xDF, 0x03,
  0xE7, 0xC0, 0xF9, 0xF0, 0x7E, 0x7C, 0x1F, 0x1F, 0x07, 0xC7, 0xC3, 0xE1,
  0xF0, 0xF8, 0x7C, 0x3C, 0x0F, 0x1F, 0x03, 0xC7, 0xC0, 0xF3, 0xE0, 0x3C,
  0xF8, 0x0F, 0x3C, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xF8,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0xF8, 0x1E, 0x07, 0xFE, 0x0F, 0x83, 0xEF, 0x83, 0xE0, 0xFB,
  0xE1, 0xF8, 0x3E, 0xF8, 0x7E, 0x1F, 0x3E, 0x1F, 0x87, 0xCF, 0x8F, 0xE1,
  0xE3, 0xE3, 0xF8, 0xF8, 0xF9, 0xFE, 0x3E, 0x3E, 0x7F, 0x8F, 0x0F, 0x9E,
  0xE7, 0xC3, 0xEF, 0x39, 0xF0, 0xFB, 0xCE, 0x78, 0x3F, 0xE3, 0xFE, 0x0F,
  0xF8, 0xFF, 0x03, 0xFE, 0x3F, 0xC0, 0x7F, 0x0F, 0xF0, 0x1F, 0xC3, 0xF8,
  0x07, 0xE0, 0xFE, 0x01, 0xF8, 0x3F, 0x00, 0x7C, 0x0F, 0xC0, 0x1F, 0x03,
  0xF0, 0x07, 0xC0, 0xF8, 0x01, 0xE0, 0x1E, 0x00, 0x0F, 0x81, 0xF8, 0x7C,
  0x0F, 0x81, 0xF0, 0xFC, 0x0F, 0x87, 0xC0, 0x7C, 0x7C, 0x01, 0xE7, 0xE0,
  0x0F, 0xBE, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7C, 0xF0, 0x07, 0xE7, 0xC0, 0x3E, 0x3E,
  0x03, 0xE1, 0xF0, 0x3F, 0x07, 0xC1, 0xF0, 0x3E, 0x1F, 0x81, 0xF0, 0x07,
  0xC0, 0x7C, 0x1F, 0x03, 0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0x7E, 0x07, 0xC1,
  0xF0, 0x1F, 0x0F, 0xC0, 0x7C, 0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC7, 0xC0,
  0x0F, 0x1F, 0x00, 0x3C, 0xF8, 0x00, 0xF3, 0xE0, 0x03, 0xCF, 0x80, 0x0F,
  0x7C, 0x00, 0x3D, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x7F,
  0xFF, 0x8F, 0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xFF, 0xF1, 0xFF, 0xFE, 0x3F, 0xFF,
  0xC7, 0xFF, 0xF8, 0x00, 0x0C, 0x00, 0xF0, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x0F, 0x80, 0x3F, 0x00, 0x3E, 0x00, 0xF8,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x07,
  0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x20, 0x00, 0x03, 0x83, 0xC1, 0xE0, 0xF0,
  0x70, 0x38, 0x1C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xC0, 0xE0, 0x70, 0x78,
  0x3C, 0x1E, 0x0E, 0x07, 0x03, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x38, 0x1C,
  0x0E, 0x0F, 0x07, 0x83, 0xC1, 0xC0, 0xE0, 0x70, 0x78, 0x3C, 0x1E, 0x0E,
  0x07, 0x00, 0x01, 0x00, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80,
  0x3F, 0x00, 0x7C, 0x01, 0xF0, 0x1F, 0xC0, 0xFC, 0x03, 0xE0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x01, 0xC0, 0x04, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xFE, 0x03, 0xCF,
  0xFC, 0x1E, 0xFF, 0xE1, 0xF7, 0xDF, 0xDF, 0x7C, 0x3F, 0xFB, 0xC1, 0xFF,
  0x9E, 0x03, 0xF8, 0x00, 0x0F, 0x80,
};

const GFXglyph RobotoCondensed_MediumItalic45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 11, 32, 11, 1, -32 },
  { 45, 12, 11, 14, 3, -34 },
  { 62, 23, 32, 23, 1, -32 },
  { 154, 20, 41, 22, 1, -37 },
  { 257, 21, 32, 28, 4, -32 },
  { 341, 22, 32, 25, 1, -32 },
  { 429, 6, 11, 7, 3, -34 },
  { 438, 14, 46, 14, 2, -36 },
  { 519, 14, 46, 14, -2, -36 },
  { 600, 19, 19, 19, 2, -32 },
  { 646, 18, 24, 21, 2, -27 },
  { 700, 9, 12, 10, -3, -5 },
  { 714, 10, 4, 13, 2, -16 },
  { 719, 6, 6, 12, 1, -6 },
  { 724, 21, 35, 15, -3, -32 },
  { 816, 19, 32, 22, 2, -32 },
  { 892, 13, 32, 22, 5, -32 },
  { 944, 21, 32, 22, 0, -32 },
  { 1028, 20, 32, 22, 1, -32 },
  { 1108, 21, 32, 22, 0, -32 },
  { 1192, 20, 32, 22, 2, -32 },
  { 1272, 18, 32, 22, 2, -32 },
  { 1344, 21, 32, 22, 2, -32 },
  { 1428, 20, 32, 22, 1, -32 },
  { 1508, 18, 32, 22, 3, -32 },
  { 1580, 9, 25, 11, 1, -25 },
  { 1609, 12, 32, 10, -2, -25 },
  { 1657, 18, 20, 19, 1, -24 },
  { 1702, 18, 13, 21, 2, -21 },
  { 1732, 18, 21, 20, 1, -24 },
  { 1780, 16, 32, 19, 3, -32 },
  { 1844, 31, 41, 34, 1, -31 },
  { 2003, 25, 32, 26, -2, -32 },
  { 2103, 22, 32, 24, 1, -32 },
  { 2191, 23, 32, 25, 2, -32 },
  { 2283, 23, 32, 25, 1, -32 },
  { 2375, 22, 32, 22, 1, -32 },
  { 2463, 22, 32, 21, 1, -32 },
  { 2551, 23, 32, 26, 2, -32 },
  { 2643, 26, 32, 27, 1, -32 },
  { 2747, 11, 32, 11, 1, -32 },
  { 2791, 22, 32, 21, 0, -32 },
  { 2879, 26, 32, 24, 1, -32 },
  { 2983, 17, 32, 21, 1, -32 },
  { 3051, 32, 32, 33, 1, -32 },
  { 3179, 26, 32, 27, 1, -32 },
  { 3283, 23, 32, 26, 2, -32 },
  { 3375, 24, 32, 25, 1, -32 },
  { 3471, 23, 38, 26, 2, -32 },
  { 3581, 23, 32, 24, 1, -32 },
  { 3673, 22, 32, 23, 1, -32 },
  { 3761, 21, 32, 23, 4, -32 },
  { 3845, 24, 32, 25, 2, -32 },
  { 3941, 23, 32, 25, 4, -32 },
  { 4033, 31, 32, 33, 4, -32 },
  { 4157, 27, 32, 24, -1, -32 },
  { 4265, 22, 32, 23, 4, -32 },
  { 4353, 25, 32, 23, -1, -32 },
  { 4453, 15, 44, 11, -1, -37 },
  { 4536, 10, 35, 16, 4, -32 },
  { 4580, 15, 44, 11, -3, -37 },
  { 4663, 14, 16, 17, 2, -32 },
  { 4691, 18, 4, 18, -3, 0 },
  { 4700, 8, 7, 14, 5, -34 },
  { 4707, 18, 24, 21, 1, -24 },
  { 4761, 20, 34, 22, 0, -34 },
  { 4846, 18, 24, 20, 1, -24 },
  { 4900, 22, 34, 22, 1, -34 },
  { 4994, 18, 24, 21, 1, -24 },
  { 5048, 15, 34, 14, 2, -34 },
  { 5112, 21, 33, 22, 0, -24 },
  { 5199, 19, 34, 21, 0, -34 },
  { 5280, 11, 33, 11, 0, -33 },
  { 5326, 16, 42, 10, -5, -33 },
  { 5410, 21, 34, 20, 0, -34 },
  { 5500, 11, 34, 11, 0, -34 },
  { 5547, 31, 24, 33, 0, -24 },
  { 5640, 19, 24, 21, 0, -24 },
  { 5697, 19, 24, 22, 1, -24 },
  { 5754, 21, 33, 22, -1, -24 },
  { 5841, 20, 33, 22, 1, -24 },
  { 5924, 15, 24, 14, 0, -24 },
  { 5969, 18, 24, 20, 1, -24 },
  { 6023, 12, 30, 13, 2, -30 },
  { 6068, 20, 24, 21, 1, -24 },
  { 6128, 18, 24, 19, 2, -24 },
  { 6182, 26, 24, 28, 3, -24 },
  { 6260, 21, 24, 19, -1, -24 },
  { 6323, 22, 33, 19, -2, -24 },
  { 6414, 19, 24, 19, 0, -24 },
  { 6471, 14, 43, 13, 1, -35 },
  { 6547, 9, 38, 11, 1, -32 },
  { 6590, 14, 43, 13, -2, -35 },
  { 6666, 21, 9, 25, 2, -18 },
};

const GFXfont RobotoCondensed_MediumItalic45pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_MediumItalic45pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_MediumItalic45pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _ROBOTOCONDENSED_MEDIUMITALIC45PT7B_H_
