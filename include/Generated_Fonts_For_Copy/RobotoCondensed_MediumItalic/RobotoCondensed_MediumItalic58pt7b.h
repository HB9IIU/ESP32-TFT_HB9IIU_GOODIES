#ifndef _ROBOTOCONDENSED_MEDIUMITALIC58PT7B_H_
#define _ROBOTOCONDENSED_MEDIUMITALIC58PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-MediumItalic.ttf
// Size: 58pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_MediumItalic58pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x1F, 0x80, 0xFE, 0x03, 0xFC, 0x0F, 0xE0, 0x1F, 0x80, 0x7C,
  0x00, 0x40, 0x00, 0x1F, 0x1F, 0x1E, 0x1F, 0x3E, 0x1E, 0x3E, 0x1E, 0x3E,
  0x3E, 0x3E, 0x3E, 0x3C, 0x3E, 0x3C, 0x3C, 0x7C, 0x3C, 0x7C, 0x3C, 0x78,
  0x7C, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x00, 0x03, 0xE1,
  0xF0, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x87, 0xC0,
  0x00, 0x7C, 0x3C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x01,
  0xF0, 0xF0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x07, 0xC3,
  0xE0, 0x00, 0x3C, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x00, 0x7C, 0x3E, 0x00, 0x03,
  0xC1, 0xE0, 0x00, 0x1E, 0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0x78, 0x7C, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3C, 0x1E, 0x00,
  0x01, 0xE1, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xC1, 0xE0, 0x00, 0x1E, 0x1F,
  0x00, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x78, 0x7C, 0x00,
  0x07, 0xC3, 0xE0, 0x00, 0x3C, 0x1E, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1F,
  0x0F, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x7C, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF,
  0x80, 0x7F, 0xFF, 0xE0, 0x3F, 0xC7, 0xF0, 0x3F, 0x81, 0xFC, 0x1F, 0xC0,
  0xFE, 0x0F, 0xC0, 0x7F, 0x0F, 0xE0, 0x1F, 0x87, 0xF0, 0x0F, 0xC3, 0xF0,
  0x07, 0xE1, 0xFC, 0x03, 0xF0, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0x0F, 0xC7, 0xE0, 0x07,
  0xE3, 0xF8, 0x03, 0xF1, 0xFC, 0x03, 0xF8, 0xFE, 0x01, 0xFC, 0x3F, 0x81,
  0xFC, 0x1F, 0xE3, 0xFE, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x00, 0xFF,
  0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xF8, 0x7C, 0x04, 0x1F,
  0x07, 0x80, 0xE3, 0xC0, 0xF0, 0x3E, 0x78, 0x1E, 0x0F, 0x9F, 0x03, 0xC1,
  0xE3, 0xE0, 0xF8, 0x7C, 0x7C, 0x1F, 0x1F, 0x0F, 0x83, 0xE3, 0xC1, 0xF0,
  0x78, 0xF8, 0x1E, 0x1F, 0x3E, 0x03, 0xFF, 0xE7, 0x80, 0x7F, 0xF9, 0xF0,
  0x07, 0xFE, 0x7C, 0x00, 0x7F, 0x9F, 0x00, 0x01, 0x03, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x7F, 0x00, 0x0F, 0x3F, 0xF0, 0x03, 0xEF, 0xFF, 0x00, 0xF9,
  0xFF, 0xE0, 0x1E, 0x7C, 0x3E, 0x07, 0xCF, 0x87, 0xC1, 0xF1, 0xE0, 0x78,
  0x7C, 0x7C, 0x0F, 0x0F, 0x0F, 0x81, 0xE3, 0xE1, 0xF0, 0x7C, 0xF8, 0x3E,
  0x0F, 0x9E, 0x07, 0xC1, 0xF7, 0xC0, 0xF8, 0x3C, 0x70, 0x0F, 0x0F, 0x80,
  0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x0F,
  0xFF, 0xF0, 0x01, 0xFC, 0x3F, 0x00, 0x1F, 0x83, 0xF0, 0x01, 0xF8, 0x1F,
  0x00, 0x1F, 0x01, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x03, 0xF0, 0x03,
  0xF0, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF8, 0xFE, 0x00, 0x1F, 0x9F,
  0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF,
  0x83, 0xF0, 0xFF, 0xF8, 0x3F, 0x1F, 0xFF, 0xC3, 0xF1, 0xFD, 0xFC, 0x3E,
  0x3F, 0x8F, 0xE7, 0xE7, 0xF0, 0xFE, 0x7E, 0x7F, 0x07, 0xF7, 0xE7, 0xE0,
  0x3F, 0xFC, 0xFE, 0x03, 0xFF, 0xCF, 0xE0, 0x1F, 0xF8, 0xFE, 0x01, 0xFF,
  0x8F, 0xE0, 0x0F, 0xF0, 0x7E, 0x00, 0xFF, 0x07, 0xF0, 0x0F, 0xF0, 0x7F,
  0x83, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0x9F, 0xC0, 0x3F, 0xE0, 0xFE, 0x00, 0x20, 0x00, 0x00,
  0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xDF, 0x3E, 0x7C, 0xF9, 0xE3, 0xCF, 0x9F,
  0x3E, 0x00, 0x00, 0x00, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x01,
  0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x07, 0x80, 0x01, 0x80, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x1C,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x04, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x30, 0x3E, 0x06, 0x7C, 0x3E, 0x3E,
  0x7F, 0xBD, 0xFE, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8,
  0x01, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x07, 0xDF, 0x00, 0x0F, 0xCF, 0x80, 0x1F, 0x8F, 0x80, 0x3F, 0x07, 0xC0,
  0x7E, 0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x1C, 0x03, 0x80, 0x08, 0x02, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0xFC, 0x1F, 0x87, 0xF0, 0xFC, 0x3F, 0x07, 0xE1,
  0xF8, 0x1E, 0x01, 0x80, 0x7F, 0xFB, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x3E, 0x7F, 0x7F, 0xFF, 0xFF, 0x7F, 0x7E, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x07, 0xF0, 0xFE, 0x0F, 0xE0,
  0x7E, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0x7F, 0x1F, 0x80, 0x3F, 0x3F, 0x80,
  0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x7F, 0x7F, 0x00,
  0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7E, 0x00, 0x7E, 0x7E, 0x00,
  0x7E, 0x7E, 0x00, 0x7E, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00,
  0xFE, 0xFE, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00,
  0xFC, 0xFC, 0x01, 0xFC, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01,
  0xF8, 0xFC, 0x03, 0xF8, 0xFC, 0x03, 0xF0, 0xFC, 0x07, 0xF0, 0xFE, 0x07,
  0xE0, 0x7F, 0x0F, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x3F, 0xFF,
  0x80, 0x1F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x1F, 0x00, 0x7E, 0x03, 0xFE, 0x0F, 0xFE, 0x7F, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFC, 0xF8, 0xFC, 0xE0, 0xFC, 0x00, 0xFC, 0x01, 0xFC,
  0x01, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF8,
  0x03, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0x0F, 0xF0, 0x1F, 0xC0, 0xFF, 0x03,
  0xF0, 0x0F, 0xE0, 0xFE, 0x01, 0xFC, 0x1F, 0x80, 0x3F, 0x83, 0xF0, 0x07,
  0xF0, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xC0, 0x7F, 0x87, 0xF8, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x1F, 0x83,
  0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xF0, 0x00,
  0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE3, 0xF8,
  0x01, 0xF8, 0xFE, 0x00, 0xFE, 0x3F, 0x80, 0x3F, 0x07, 0xE0, 0x1F, 0xC1,
  0xFC, 0x0F, 0xF0, 0x7F, 0x87, 0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x0F, 0x9F, 0x80,
  0x07, 0xE7, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0xF8, 0xFE, 0x00, 0x7E, 0x3F,
  0x80, 0x3F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x07, 0xE0, 0xFC, 0x03, 0xF0,
  0x7F, 0x01, 0xFC, 0x1F, 0xC0, 0x7E, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x1F,
  0xC0, 0x7E, 0x07, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xDF, 0xF0, 0x1F, 0x81, 0xFE,
  0x00, 0x40, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x8F, 0xE0, 0x0F, 0xE3, 0xF8, 0x03, 0xF0,
  0xFE, 0x01, 0xFC, 0x1F, 0x80, 0x7F, 0x07, 0xF0, 0x3F, 0x81, 0xFE, 0x1F,
  0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x3F,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF9, 0xF8, 0x0F, 0xDF, 0xF8, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFE, 0x7F, 0x83, 0xFD, 0xFC, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00,
  0x7E, 0xFC, 0x01, 0xFB, 0xF8, 0x0F, 0xE7, 0xE0, 0x7F, 0x1F, 0xC3, 0xFC,
  0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x07,
  0xFC, 0x00, 0x01, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x0F, 0xE1, 0xFC, 0x0F, 0xE0,
  0x7E, 0x07, 0xE0, 0x3F, 0x87, 0xF0, 0x1F, 0xC3, 0xF8, 0x0F, 0xE1, 0xFC,
  0x07, 0xF0, 0xFC, 0x03, 0xF8, 0x7E, 0x01, 0xFC, 0x3F, 0x00, 0xFC, 0x1F,
  0xC0, 0xFE, 0x07, 0xE0, 0x7F, 0x03, 0xF0, 0x7F, 0x01, 0xFE, 0xFF, 0x00,
  0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x80,
  0x3F, 0xFF, 0xE0, 0x3F, 0xC3, 0xF8, 0x1F, 0xC0, 0xFC, 0x1F, 0xC0, 0x7F,
  0x0F, 0xC0, 0x1F, 0x8F, 0xE0, 0x0F, 0xC7, 0xF0, 0x07, 0xE3, 0xF8, 0x03,
  0xF1, 0xF8, 0x01, 0xF8, 0xFC, 0x01, 0xFC, 0x7F, 0x00, 0xFE, 0x3F, 0x80,
  0xFE, 0x1F, 0xC0, 0x7F, 0x07, 0xF0, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xFE, 0x01,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE1, 0xFE, 0x3F, 0x8F, 0xE0,
  0x7E, 0x3F, 0x81, 0xFD, 0xFC, 0x03, 0xF7, 0xF0, 0x0F, 0xDF, 0x80, 0x3F,
  0x7E, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE,
  0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0x7E, 0x03,
  0xFD, 0xFC, 0x1F, 0xE7, 0xFD, 0xFF, 0x8F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xE0, 0xFF, 0xBF, 0x00, 0xF8, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0xC0, 0x3F, 0xFE, 0x00, 0xFF, 0xF0, 0x07,
  0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x7F, 0x80, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x7F, 0x07, 0xF0, 0xFF, 0x0F, 0xF0, 0x7F, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x07, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x07, 0xF0, 0x7E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x7E, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00,
  0x7C, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x00, 0x78, 0x00, 0x10, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x80, 0x00, 0x7E, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xE0,
  0x0F, 0xFF, 0x80, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x07, 0xFF,
  0x80, 0x3F, 0xF8, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF0, 0x00,
  0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xC0, 0x00, 0x02, 0x00, 0x1F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE0, 0x04,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF,
  0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7F, 0xFC,
  0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x78, 0x00, 0x00, 0xC0,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x01, 0xFF,
  0xF0, 0x1F, 0xFF, 0xC1, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0xFF, 0x1F, 0xCF,
  0xE0, 0x7E, 0x7F, 0x03, 0xFB, 0xF0, 0x1F, 0xFF, 0x80, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFC, 0x0F, 0xF0, 0x00,
  0x0F, 0xE0, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x3F, 0x00,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0xFC, 0x00, 0x00, 0x3C,
  0x01, 0xF8, 0x00, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x03, 0xE0,
  0x0F, 0xC0, 0x1E, 0x03, 0xE0, 0x1F, 0xF0, 0x0E, 0x07, 0xC0, 0x7F, 0xFC,
  0x0F, 0x07, 0x80, 0xFF, 0xFE, 0x0F, 0x0F, 0x81, 0xFC, 0x7C, 0x0F, 0x0F,
  0x01, 0xF0, 0x7C, 0x0F, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x1E, 0x07, 0xC0, 0x78, 0x0F, 0x3E, 0x07, 0xC0, 0xF8, 0x0F,
  0x3E, 0x0F, 0x80, 0xF8, 0x0F, 0x3C, 0x0F, 0x80, 0xF8, 0x1F, 0x7C, 0x0F,
  0x80, 0xF0, 0x1E, 0x7C, 0x1F, 0x81, 0xF0, 0x1E, 0x7C, 0x1F, 0x01, 0xF0,
  0x1E, 0x7C, 0x1F, 0x01, 0xF0, 0x1E, 0x78, 0x1F, 0x01, 0xE0, 0x1E, 0x78,
  0x1F, 0x03, 0xE0, 0x3C, 0x78, 0x1F, 0x03, 0xE0, 0x3C, 0xF8, 0x3F, 0x03,
  0xE0, 0x3C, 0xF8, 0x3F, 0x07, 0xE0, 0x78, 0xF8, 0x3F, 0x07, 0xE0, 0x78,
  0xF8, 0x1F, 0x0F, 0xE0, 0xF0, 0xF8, 0x1F, 0x9F, 0xE1, 0xF0, 0xF8, 0x1F,
  0xFF, 0xFF, 0xE0, 0x78, 0x1F, 0xF9, 0xFF, 0xC0, 0x78, 0x0F, 0xF9, 0xFF,
  0x80, 0x78, 0x07, 0xE0, 0xFF, 0x00, 0x7C, 0x01, 0x80, 0x10, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x03, 0x00, 0x00, 0x07, 0xFC,
  0x3F, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x3F,
  0x3E, 0x00, 0x00, 0xFC, 0x7C, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x07, 0xE1,
  0xF8, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x7E, 0x0F,
  0xC0, 0x01, 0xFC, 0x1F, 0x80, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xE0, 0x7F,
  0x00, 0x1F, 0x80, 0x7E, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF8, 0x03, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFE, 0x0F, 0xE0, 0x00, 0xFC, 0x3F, 0x80, 0x01, 0xF8, 0x7F,
  0x00, 0x03, 0xF1, 0xFC, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x0F, 0xEF, 0xF0,
  0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0xFE, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8,
  0x0F, 0xE0, 0x1F, 0xC0, 0x7E, 0x00, 0x7F, 0x07, 0xF0, 0x03, 0xF8, 0x3F,
  0x80, 0x1F, 0xC1, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0x7E, 0x00,
  0x3F, 0x83, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x1F, 0xC1, 0xFC, 0x01, 0xFE,
  0x0F, 0xE0, 0x1F, 0xE0, 0x7F, 0x03, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0x80, 0x1F, 0xC1, 0xFC, 0x00, 0x7E,
  0x0F, 0xE0, 0x03, 0xF0, 0x7F, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0xFC, 0x1F,
  0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF8, 0x7F, 0x00,
  0x3F, 0xC3, 0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0xE0, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xF8, 0x7F, 0x80, 0xFF, 0x00, 0xFE,
  0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0xFE, 0x3F,
  0x00, 0x07, 0xF3, 0xF8, 0x00, 0x3F, 0x9F, 0xC0, 0x01, 0xFC, 0xFC, 0x00,
  0x0F, 0xE7, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x01, 0xFC, 0x7E, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x7F, 0x1F,
  0x80, 0x03, 0xF0, 0xFE, 0x00, 0x3F, 0x87, 0xF0, 0x01, 0xFC, 0x1F, 0x80,
  0x1F, 0xC0, 0xFE, 0x01, 0xFE, 0x07, 0xFC, 0x3F, 0xE0, 0x1F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0x80, 0xFF, 0x00, 0xFC, 0x01,
  0xFC, 0x07, 0xF0, 0x03, 0xF0, 0x1F, 0xC0, 0x0F, 0xE0, 0x7F, 0x00, 0x3F,
  0x81, 0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x07, 0xE0,
  0xFE, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x7E, 0x0F, 0xE0, 0x03, 0xF8, 0x3F,
  0x80, 0x0F, 0xE0, 0xFC, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0xFE, 0x1F, 0xC0,
  0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x3F, 0x07, 0xF0, 0x01,
  0xFC, 0x1F, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7F,
  0x0F, 0xE0, 0x01, 0xF8, 0x3F, 0x80, 0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0x83,
  0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x81, 0xFC,
  0x01, 0xFE, 0x07, 0xF0, 0x1F, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xF8, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xF8, 0x7F, 0xC0,
  0xFF, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x1F, 0xC7, 0xF0,
  0x00, 0xFE, 0x3F, 0x80, 0x07, 0xF3, 0xF8, 0x00, 0x3F, 0x9F, 0xC0, 0x01,
  0xFC, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x01, 0xFF, 0xFB, 0xF8, 0x0F, 0xFF, 0x9F, 0xC0, 0x7F,
  0xFC, 0xFE, 0x03, 0xFF, 0xE7, 0xF0, 0x1F, 0xFF, 0x3F, 0x80, 0x03, 0xF9,
  0xFC, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0xFC, 0x7F, 0x00, 0x0F, 0xE3, 0xF8,
  0x00, 0x7F, 0x1F, 0xC0, 0x03, 0xF8, 0xFE, 0x00, 0x1F, 0xC7, 0xF0, 0x00,
  0xFE, 0x1F, 0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x07, 0xFE, 0x3F, 0xF8,
  0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x01, 0xFC, 0x0F,
  0xE0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x0F, 0xE0,
  0x3F, 0x80, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x3F,
  0x81, 0xFC, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x01,
  0xFC, 0x07, 0xE0, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0xFE, 0x00,
  0x07, 0xF0, 0x3F, 0x80, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x7E, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x7F,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x03,
  0xF8, 0x0F, 0xE0, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x3F, 0x81, 0xFC, 0x00,
  0x0F, 0xE0, 0x7F, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x00, 0xFC, 0x07, 0xF0,
  0x00, 0x7F, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x07, 0xF0, 0x3F,
  0x80, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x1F, 0x80,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7E,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F,
  0xC0, 0x3F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x0F,
  0xE0, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x0F, 0xE0,
  0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0x7E, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x03, 0xF8, 0x07, 0xFC, 0xFF, 0x80, 0x3F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x7F,
  0x80, 0x7E, 0x00, 0x3F, 0xE0, 0x3F, 0x80, 0x1F, 0xF0, 0x0F, 0xE0, 0x0F,
  0xF8, 0x03, 0xF8, 0x03, 0xFC, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0x3F, 0x80,
  0xFF, 0x00, 0x0F, 0xC0, 0x7F, 0x80, 0x07, 0xF0, 0x3F, 0xE0, 0x01, 0xFC,
  0x0F, 0xF0, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x07,
  0xE1, 0xFE, 0x00, 0x01, 0xF8, 0xFF, 0x00, 0x00, 0xFE, 0x3F, 0xC0, 0x00,
  0x3F, 0x9F, 0xE0, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x1F, 0xFB, 0xF8, 0x00, 0x0F, 0xFC, 0xFE, 0x00, 0x03, 0xFE,
  0x3F, 0x80, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x0F,
  0xE0, 0x7F, 0x00, 0x03, 0xF0, 0x0F, 0xE0, 0x01, 0xFC, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x07, 0xF0, 0x07, 0xF0,
  0x01, 0xF8, 0x01, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x0F,
  0xF0, 0x0F, 0xE0, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0xFE, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x3F, 0xF0, 0x00, 0x0F, 0xFC,
  0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0x0F, 0xFC, 0x00,
  0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x01, 0xFF,
  0xC0, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x07,
  0xFF, 0x80, 0x0F, 0xBF, 0x01, 0xFF, 0xE0, 0x07, 0xEF, 0xC0, 0xFE, 0xF8,
  0x01, 0xFF, 0xF0, 0x3F, 0x3E, 0x00, 0xFD, 0xF8, 0x0F, 0xCF, 0x80, 0x3F,
  0x7E, 0x03, 0xF3, 0xE0, 0x1F, 0x9F, 0x80, 0xFC, 0xFC, 0x07, 0xEF, 0xE0,
  0x3F, 0x3F, 0x03, 0xF3, 0xF8, 0x1F, 0xCF, 0xC0, 0xFC, 0xFC, 0x07, 0xF1,
  0xF0, 0x7E, 0x3F, 0x01, 0xFC, 0x7C, 0x1F, 0x8F, 0xC0, 0x7E, 0x1F, 0x0F,
  0xC7, 0xF0, 0x1F, 0x87, 0xC3, 0xF1, 0xFC, 0x0F, 0xE1, 0xF0, 0xF8, 0x7F,
  0x03, 0xF8, 0x7C, 0x7E, 0x1F, 0x80, 0xFE, 0x1F, 0x9F, 0x07, 0xE0, 0x3F,
  0x87, 0xEF, 0xC3, 0xF8, 0x0F, 0xC0, 0xFB, 0xE0, 0xFE, 0x03, 0xF0, 0x3F,
  0xF8, 0x3F, 0x81, 0xFC, 0x0F, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xFF, 0x03,
  0xF0, 0x1F, 0xC0, 0xFF, 0x81, 0xFC, 0x07, 0xF0, 0x3F, 0xE0, 0x7F, 0x01,
  0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x7E, 0x03, 0xFC, 0x07, 0xF0, 0x3F, 0x80,
  0x7F, 0x01, 0xF8, 0x0F, 0xE0, 0x1F, 0x80, 0x7E, 0x03, 0xF8, 0x07, 0xE0,
  0x3F, 0x80, 0xFE, 0x01, 0xF0, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x7F, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x01, 0xFC, 0x0F, 0xF8, 0x00,
  0x7E, 0x03, 0xFE, 0x00, 0x1F, 0x80, 0xFF, 0x80, 0x0F, 0xE0, 0x3F, 0xE0,
  0x03, 0xF8, 0x0F, 0xFC, 0x00, 0xFE, 0x07, 0xFF, 0x00, 0x3F, 0x81, 0xFF,
  0xC0, 0x0F, 0xC0, 0x7F, 0xF8, 0x03, 0xF0, 0x1F, 0xFE, 0x01, 0xFC, 0x07,
  0xEF, 0x80, 0x7F, 0x01, 0xFB, 0xF0, 0x1F, 0xC0, 0xFE, 0xFC, 0x07, 0xF0,
  0x3F, 0x9F, 0x01, 0xF8, 0x0F, 0xE7, 0xC0, 0x7E, 0x03, 0xF9, 0xF8, 0x3F,
  0x80, 0xFC, 0x3E, 0x0F, 0xE0, 0x3F, 0x0F, 0x83, 0xF8, 0x1F, 0xC3, 0xF0,
  0xFE, 0x07, 0xF0, 0x7C, 0x3F, 0x01, 0xFC, 0x1F, 0x1F, 0xC0, 0x7F, 0x07,
  0xE7, 0xF0, 0x1F, 0x81, 0xF9, 0xFC, 0x0F, 0xE0, 0x3E, 0x7F, 0x03, 0xF8,
  0x0F, 0x9F, 0x80, 0xFE, 0x03, 0xF7, 0xE0, 0x3F, 0x80, 0x7F, 0xF8, 0x0F,
  0xE0, 0x1F, 0xFE, 0x03, 0xF0, 0x07, 0xFF, 0x81, 0xFC, 0x00, 0xFF, 0xE0,
  0x7F, 0x00, 0x3F, 0xF0, 0x1F, 0xC0, 0x0F, 0xFC, 0x07, 0xF0, 0x03, 0xFF,
  0x01, 0xF8, 0x00, 0x7F, 0xC0, 0x7E, 0x00, 0x1F, 0xF0, 0x3F, 0x80, 0x07,
  0xFC, 0x0F, 0xE0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xF0, 0x0F, 0xF8, 0xFF, 0xC0, 0xFF, 0x00, 0xFE, 0x0F, 0xF0, 0x07, 0xF0,
  0x7F, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x07, 0xF3, 0xF8,
  0x00, 0x1F, 0x9F, 0xC0, 0x00, 0xFC, 0xFE, 0x00, 0x07, 0xE7, 0xE0, 0x00,
  0x3F, 0x7F, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0xFE,
  0xFE, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x3F, 0xBF, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x7E, 0xFE, 0x00, 0x07, 0xF7, 0xF0, 0x00,
  0x3F, 0xBF, 0x80, 0x01, 0xFD, 0xFC, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x7E,
  0x7E, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x3F, 0x9F, 0xC0, 0x01, 0xF8, 0xFE,
  0x00, 0x1F, 0xC7, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0xFF, 0x01,
  0xFE, 0x03, 0xFE, 0x3F, 0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0xFE, 0x00, 0xFF, 0x01, 0xF8, 0x00, 0xFE, 0x07, 0xF0,
  0x01, 0xFC, 0x0F, 0xE0, 0x01, 0xF8, 0x1F, 0xC0, 0x03, 0xF0, 0x3F, 0x80,
  0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x1F, 0x83, 0xF8, 0x00,
  0x7F, 0x07, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x07,
  0xF0, 0x3F, 0x00, 0x1F, 0xE0, 0x7E, 0x00, 0x7F, 0x81, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xF8, 0xFF, 0x80, 0xFF, 0x01, 0xFE, 0x0F,
  0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0xFE, 0x3F, 0x80,
  0x07, 0xF3, 0xF8, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x07,
  0xEF, 0xE0, 0x00, 0x7F, 0x7F, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x1F, 0xDF,
  0xC0, 0x00, 0xFE, 0xFC, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x3F, 0xFF, 0x00,
  0x01, 0xFB, 0xF8, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0xFE, 0xFE, 0x00, 0x07,
  0xF7, 0xF0, 0x00, 0x3F, 0xBF, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x0F, 0xCF,
  0xC0, 0x00, 0xFE, 0x7E, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x3F, 0x1F, 0xC0,
  0x03, 0xF8, 0xFE, 0x00, 0x1F, 0xC7, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x1F,
  0xE0, 0xFE, 0x01, 0xFE, 0x07, 0xFE, 0x3F, 0xE0, 0x1F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x06, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x3F, 0x80, 0x7F, 0x80, 0xFC, 0x00, 0xFE, 0x07, 0xF0,
  0x03, 0xF8, 0x1F, 0xC0, 0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0x81, 0xFC, 0x00,
  0x7E, 0x07, 0xF0, 0x03, 0xF8, 0x1F, 0x80, 0x0F, 0xE0, 0xFE, 0x00, 0x3F,
  0x83, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0x80, 0x3F, 0xC0,
  0xFC, 0x01, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x0F, 0xE0, 0x7F,
  0x00, 0x3F, 0x80, 0xFE, 0x00, 0xFE, 0x03, 0xF8, 0x03, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0x7F, 0x01, 0xFC, 0x01, 0xFC, 0x07,
  0xF0, 0x07, 0xF0, 0x1F, 0x80, 0x1F, 0xC0, 0x7E, 0x00, 0x3F, 0x83, 0xF8,
  0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xE0, 0xFE, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0,
  0x0F, 0xF8, 0x7F, 0xC0, 0x7F, 0x80, 0xFE, 0x07, 0xF8, 0x07, 0xF0, 0x3F,
  0x80, 0x1F, 0xC1, 0xFC, 0x00, 0xFE, 0x0F, 0xC0, 0x07, 0xF0, 0xFE, 0x00,
  0x3F, 0x83, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x7F,
  0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x7F, 0x1F, 0xC0, 0x03, 0xF0, 0x7E, 0x00,
  0x1F, 0x83, 0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0xFF, 0x00, 0xFE,
  0x03, 0xFE, 0x1F, 0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0xC0,
  0x03, 0xF8, 0x3F, 0x80, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xC1, 0xFC, 0x00,
  0x3F, 0x83, 0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x01,
  0xFC, 0x1F, 0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x1F,
  0xC1, 0xFC, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0xFE,
  0x0F, 0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xE0,
  0xFE, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x7F, 0x07,
  0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x07, 0xF0, 0x7F,
  0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0x7E, 0x07, 0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0x80,
  0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x3F, 0x80, 0xFE, 0x00,
  0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xFF, 0x1F, 0xF8, 0x03, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0xFE, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xBF, 0x80, 0x01, 0xFE,
  0xFE, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x3F, 0xC7, 0xF0, 0x00, 0xFE, 0x1F,
  0xC0, 0x07, 0xF8, 0x7F, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x7F, 0x07, 0xF0,
  0x03, 0xF8, 0x1F, 0xC0, 0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0x80, 0xFC, 0x01,
  0xFC, 0x03, 0xF0, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0x3F, 0x00, 0xFE,
  0x00, 0xFE, 0x07, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x0F, 0xE0, 0x7E, 0x00,
  0x3F, 0x83, 0xF8, 0x00, 0x7E, 0x0F, 0xE0, 0x01, 0xF8, 0x7F, 0x00, 0x07,
  0xE1, 0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x7E, 0x3F, 0x80, 0x01, 0xF8,
  0xFC, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x3F, 0x7E,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7F,
  0xFE, 0x00, 0x7E, 0x00, 0x7F, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x7E, 0x01, 0xFE, 0x00,
  0xFC, 0x7E, 0x01, 0xFE, 0x01, 0xFC, 0x7E, 0x01, 0xFE, 0x01, 0xF8, 0x7E,
  0x03, 0xFE, 0x01, 0xF8, 0x7E, 0x03, 0xFE, 0x03, 0xF8, 0x7E, 0x03, 0xFE,
  0x03, 0xF0, 0x7E, 0x07, 0xFE, 0x03, 0xF0, 0x7E, 0x07, 0xFE, 0x07, 0xF0,
  0x7E, 0x07, 0xFE, 0x07, 0xE0, 0x7E, 0x0F, 0xFF, 0x07, 0xE0, 0x7E, 0x0F,
  0xBF, 0x0F, 0xE0, 0x7E, 0x1F, 0xBF, 0x0F, 0xC0, 0x7E, 0x1F, 0xBF, 0x0F,
  0xC0, 0x7E, 0x1F, 0x1F, 0x1F, 0xC0, 0x7E, 0x3F, 0x1F, 0x1F, 0x80, 0x7E,
  0x3E, 0x1F, 0x1F, 0x80, 0x7E, 0x3E, 0x1F, 0x3F, 0x80, 0x7E, 0x7E, 0x1F,
  0x3F, 0x00, 0x7E, 0x7C, 0x1F, 0x3F, 0x00, 0x7E, 0x7C, 0x1F, 0x3F, 0x00,
  0x7E, 0xFC, 0x1F, 0x7E, 0x00, 0x7E, 0xF8, 0x1F, 0x7E, 0x00, 0x7E, 0xF8,
  0x1F, 0x7E, 0x00, 0x7F, 0xF8, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x1F, 0xFC,
  0x00, 0x7F, 0xF0, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x1F,
  0xF0, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x00,
  0x7F, 0x80, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x00, 0x7F, 0x80,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x3F,
  0xC0, 0x3F, 0x80, 0x07, 0xF8, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x0F, 0xF0, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0x1F,
  0xC0, 0x7F, 0x80, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0x7F, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0xFF, 0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x1F, 0xC7, 0xF0,
  0x00, 0x01, 0xF9, 0xFE, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x00, 0x7F, 0xBF, 0x80, 0x00, 0x0F,
  0xE7, 0xF0, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x00, 0xFF, 0x0F, 0xE0, 0x00,
  0x1F, 0xC1, 0xFC, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x01, 0xFE, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x7F, 0x00, 0x0F, 0xF0, 0x0F, 0xE0, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x03, 0xF8, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x7F, 0x9F, 0xC0, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0xC7, 0xF0,
  0x01, 0xFC, 0x3F, 0x80, 0x1F, 0xE0, 0xFC, 0x00, 0xFE, 0x07, 0xE0, 0x0F,
  0xE0, 0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x07, 0xE0, 0x7F, 0x80,
  0x3F, 0x03, 0xF8, 0x01, 0xF8, 0x3F, 0x80, 0x0F, 0xE1, 0xFC, 0x00, 0x3F,
  0x1F, 0xC0, 0x01, 0xF8, 0xFE, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x7E, 0x7E,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFC, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0xC0,
  0x00, 0xFC, 0x07, 0xE0, 0x3F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF8, 0x1F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x00, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0x0F, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x07,
  0xFC, 0x03, 0xEF, 0x00, 0xFB, 0xE0, 0x7C, 0xF8, 0x1F, 0x3E, 0x0F, 0xCF,
  0x83, 0xE3, 0xE1, 0xF8, 0x78, 0x7C, 0x1F, 0x3F, 0x07, 0xCF, 0x81, 0xF7,
  0xE0, 0x7D, 0xF0, 0x1F, 0xFC, 0x07, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF8, 0xFE, 0x0F, 0xE0,
  0xFC, 0x1F, 0xC1, 0xF8, 0x1F, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x00, 0x02,
  0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF,
  0xC1, 0xFF, 0xFF, 0xC3, 0xF8, 0x3F, 0x8F, 0xE0, 0x7F, 0x1F, 0xC0, 0x7E,
  0x3F, 0x80, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x7F,
  0xE3, 0xF8, 0xFE, 0x07, 0xF3, 0xF8, 0x0F, 0xE7, 0xF0, 0x1F, 0x9F, 0xC0,
  0x3F, 0x3F, 0x80, 0x7E, 0x7F, 0x01, 0xFC, 0xFE, 0x03, 0xF9, 0xFC, 0x0F,
  0xF3, 0xFC, 0x3F, 0xE3, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x07, 0xFF, 0xFE,
  0x0F, 0xFE, 0xFE, 0x07, 0xF9, 0xFC, 0x01, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xFC, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xC7, 0xF8, 0x3F,
  0xC0, 0xFE, 0x0F, 0xE0, 0x1F, 0xC3, 0xF8, 0x07, 0xF0, 0xFC, 0x01, 0xFC,
  0x3F, 0x00, 0x7F, 0x0F, 0xC0, 0x1F, 0xC7, 0xF0, 0x07, 0xF1, 0xFC, 0x01,
  0xFC, 0x7F, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x87, 0xE0, 0x07, 0xE1, 0xF8,
  0x01, 0xF8, 0xFE, 0x00, 0x7E, 0x3F, 0x80, 0x3F, 0x8F, 0xE0, 0x0F, 0xE3,
  0xF0, 0x03, 0xF0, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x1F, 0xE0, 0x3F,
  0x87, 0xFE, 0x1F, 0xE1, 0xFF, 0xFF, 0xF0, 0x7E, 0xFF, 0xFC, 0x1F, 0xBF,
  0xFE, 0x07, 0xE7, 0xFF, 0x03, 0xF0, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xF8,
  0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x0F, 0xF0, 0xFE, 0x1F, 0xC0, 0x7E,
  0x1F, 0x80, 0x7E, 0x3F, 0x80, 0x3F, 0x3F, 0x80, 0x3F, 0x3F, 0x00, 0x3F,
  0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x7E, 0x01, 0xFC,
  0x7E, 0x01, 0xF8, 0x7F, 0x03, 0xF8, 0x3F, 0x87, 0xF8, 0x3F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x08, 0x0F,
  0xC0, 0x0F, 0xF1, 0xFC, 0x01, 0xFF, 0x9F, 0xC0, 0x3F, 0xFD, 0xFC, 0x07,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x1F, 0xF0, 0xFF, 0x81, 0xFC, 0x07,
  0xF8, 0x1F, 0x80, 0x3F, 0x83, 0xF8, 0x03, 0xF8, 0x3F, 0x80, 0x3F, 0x03,
  0xF0, 0x03, 0xF0, 0x7F, 0x00, 0x3F, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x00,
  0x7F, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0,
  0x7E, 0x00, 0xFE, 0x07, 0xE0, 0x0F, 0xE0, 0x7E, 0x00, 0xFE, 0x07, 0xE0,
  0x0F, 0xC0, 0x7E, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0x7E, 0x01, 0xFC,
  0x07, 0xF0, 0x3F, 0xC0, 0x7F, 0x87, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFD, 0xF8, 0x00, 0x7F, 0x9F,
  0x80, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x07,
  0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x87, 0xF8,
  0x7F, 0x0F, 0xC0, 0x7E, 0x3F, 0x80, 0xFE, 0x7E, 0x00, 0xFD, 0xFC, 0x01,
  0xFB, 0xF0, 0x03, 0xF7, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFE, 0x00, 0x41, 0xFC, 0x01, 0xC1, 0xFE, 0x0F, 0x83, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x03, 0xFF,
  0x80, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xF0,
  0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x01, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x3F, 0xFF, 0x83, 0xFF, 0xF8, 0x7F, 0xFF, 0x07, 0xFF,
  0xF0, 0x7F, 0xFF, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x0F, 0xF8, 0xFC, 0x03, 0xFF, 0x9F, 0x80, 0xFF, 0xFB, 0xF0, 0x3F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC1, 0xFE, 0x1F, 0xF0, 0x7F, 0x01, 0xFE,
  0x0F, 0xE0, 0x1F, 0xC3, 0xF8, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x0F, 0xC0,
  0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x7F, 0x00, 0x3F, 0x0F, 0xE0, 0x0F, 0xE1,
  0xFC, 0x01, 0xFC, 0x3F, 0x00, 0x3F, 0x87, 0xE0, 0x07, 0xE0, 0xFC, 0x00,
  0xFC, 0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x07, 0xF0, 0x7E, 0x00, 0xFE, 0x0F,
  0xC0, 0x1F, 0xC1, 0xF8, 0x03, 0xF0, 0x3F, 0x80, 0x7E, 0x07, 0xF0, 0x1F,
  0xC0, 0xFF, 0x0F, 0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF8, 0x01, 0xFF, 0xBF, 0x00, 0x1F, 0xE7, 0xE0, 0x00, 0x41, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x02, 0x00,
  0x3F, 0x80, 0x70, 0x0F, 0xE0, 0x1F, 0xCF, 0xFC, 0x07, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x04, 0x00, 0x3F, 0xBF, 0xE0, 0x1F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x81, 0xFE,
  0x1F, 0xE1, 0xFE, 0x07, 0xF0, 0xFE, 0x03, 0xF8, 0x7E, 0x01, 0xFC, 0x3F,
  0x00, 0xFE, 0x1F, 0x80, 0x7F, 0x1F, 0xC0, 0x3F, 0x8F, 0xE0, 0x1F, 0x87,
  0xF0, 0x0F, 0xC3, 0xF0, 0x07, 0xE1, 0xF8, 0x07, 0xF0, 0xFC, 0x03, 0xF8,
  0xFE, 0x01, 0xFC, 0x7F, 0x00, 0xFC, 0x3F, 0x80, 0x7E, 0x1F, 0x80, 0x3F,
  0x0F, 0xC0, 0x3F, 0x87, 0xE0, 0x1F, 0xC7, 0xF0, 0x0F, 0xE3, 0xF8, 0x07,
  0xE1, 0xFC, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x3F, 0x00,
  0xFE, 0x3F, 0x80, 0x7F, 0x1F, 0xC0, 0x3F, 0x00, 0x01, 0xF0, 0x1F, 0xC0,
  0xFE, 0x07, 0xF0, 0x3F, 0x80, 0xF8, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7E, 0x03, 0xF0, 0x1F,
  0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFC, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0,
  0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x01, 0xFE, 0x07, 0xF0, 0x3F,
  0xC0, 0x7F, 0x07, 0xF8, 0x07, 0xE0, 0x7F, 0x80, 0x7E, 0x0F, 0xF0, 0x07,
  0xE1, 0xFE, 0x00, 0xFE, 0x3F, 0xC0, 0x0F, 0xE7, 0xF8, 0x00, 0xFE, 0x7F,
  0x00, 0x0F, 0xCF, 0xE0, 0x00, 0xFD, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x01,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0x80, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFE, 0xFC, 0x00,
  0x3F, 0xCF, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0,
  0x7F, 0x00, 0x3F, 0x07, 0xF0, 0x07, 0xF0, 0x3F, 0x00, 0x7F, 0x03, 0xF8,
  0x07, 0xE0, 0x3F, 0x80, 0x7E, 0x01, 0xFC, 0x07, 0xE0, 0x1F, 0xC0, 0x7E,
  0x01, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0x01, 0xFC, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x7F, 0x01, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0x00,
  0x00, 0x20, 0x01, 0x80, 0x07, 0xE7, 0xF8, 0x1F, 0xE0, 0x1F, 0xBF, 0xF8,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFB, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFE, 0x1F, 0xFC, 0x7F, 0x87, 0xF0, 0x1F,
  0xE0, 0x7F, 0x0F, 0xE0, 0x3F, 0xC0, 0x7E, 0x1F, 0xC0, 0x7F, 0x00, 0xFC,
  0x3F, 0x00, 0xFE, 0x01, 0xF8, 0x7E, 0x01, 0xFC, 0x03, 0xF0, 0xFC, 0x03,
  0xF8, 0x07, 0xE3, 0xF8, 0x07, 0xE0, 0x1F, 0xC7, 0xF0, 0x0F, 0xC0, 0x3F,
  0x8F, 0xE0, 0x1F, 0x80, 0x7F, 0x1F, 0x80, 0x7F, 0x00, 0xFC, 0x3F, 0x00,
  0xFE, 0x01, 0xF8, 0x7E, 0x01, 0xFC, 0x03, 0xF1, 0xFC, 0x03, 0xF0, 0x0F,
  0xE3, 0xF8, 0x07, 0xE0, 0x1F, 0xC7, 0xF0, 0x0F, 0xC0, 0x3F, 0x8F, 0xC0,
  0x3F, 0x80, 0x7E, 0x1F, 0x80, 0x7F, 0x00, 0xFC, 0x3F, 0x00, 0xFE, 0x01,
  0xF8, 0xFE, 0x01, 0xF8, 0x07, 0xF1, 0xFC, 0x03, 0xF0, 0x0F, 0xE3, 0xF8,
  0x07, 0xE0, 0x1F, 0xC7, 0xE0, 0x1F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x80,
  0x7E, 0x1F, 0x80, 0x7F, 0x00, 0xFC, 0x7F, 0x00, 0xFC, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x03, 0xF1, 0xFE, 0x01, 0xFB, 0xFF, 0x80, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xE1, 0xFE, 0x1F, 0xE0, 0x7F,
  0x0F, 0xE0, 0x3F, 0x87, 0xE0, 0x1F, 0xC3, 0xF0, 0x0F, 0xE1, 0xF8, 0x07,
  0xF1, 0xFC, 0x03, 0xF8, 0xFE, 0x01, 0xF8, 0x7F, 0x00, 0xFC, 0x3F, 0x00,
  0x7E, 0x1F, 0x80, 0x7F, 0x0F, 0xC0, 0x3F, 0x8F, 0xE0, 0x1F, 0xC7, 0xF0,
  0x0F, 0xC3, 0xF8, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0xFC, 0x03, 0xF8, 0x7E,
  0x01, 0xFC, 0x7F, 0x00, 0xFE, 0x3F, 0x80, 0x7E, 0x1F, 0xC0, 0x3F, 0x0F,
  0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0xC3, 0xF0, 0x0F, 0xE3, 0xF8, 0x07, 0xF1,
  0xFC, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xF0,
  0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x1F, 0xE1, 0xFE,
  0x1F, 0xC0, 0xFE, 0x3F, 0x80, 0x7E, 0x3F, 0x00, 0x7F, 0x7F, 0x00, 0x7F,
  0x7E, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E,
  0xFC, 0x00, 0x7E, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0xFC,
  0xFC, 0x01, 0xFC, 0xFE, 0x01, 0xFC, 0xFE, 0x03, 0xF8, 0x7F, 0x07, 0xF0,
  0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x9F,
  0xF0, 0x01, 0xFB, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFE, 0x01, 0xFE, 0x1F, 0xE0, 0x3F, 0xC0, 0xFE, 0x03, 0xF8,
  0x07, 0xE0, 0x3F, 0x80, 0x7F, 0x03, 0xF0, 0x07, 0xF0, 0x3F, 0x00, 0x7F,
  0x03, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0x7F,
  0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x07,
  0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0xFC, 0x0F,
  0xC0, 0x0F, 0xC0, 0xFC, 0x01, 0xFC, 0x0F, 0xC0, 0x1F, 0xC1, 0xFE, 0x03,
  0xF8, 0x1F, 0xF0, 0x7F, 0x81, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01,
  0xFB, 0xFF, 0xE0, 0x1F, 0x9F, 0xFC, 0x03, 0xF8, 0xFF, 0x00, 0x3F, 0x81,
  0x80, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x3F, 0xC3, 0xF0, 0x1F,
  0xFC, 0xFC, 0x1F, 0xFF, 0x7F, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE1,
  0xFF, 0x0F, 0xF8, 0x7F, 0x01, 0xFE, 0x1F, 0xC0, 0x3F, 0x8F, 0xE0, 0x0F,
  0xE3, 0xF8, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x7F, 0x00, 0x7F, 0x1F, 0xC0,
  0x1F, 0xC7, 0xF0, 0x07, 0xF1, 0xF8, 0x01, 0xFC, 0x7E, 0x00, 0x7E, 0x1F,
  0x80, 0x1F, 0x87, 0xE0, 0x0F, 0xE1, 0xF8, 0x03, 0xF8, 0x7E, 0x00, 0xFE,
  0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0x7E, 0x01,
  0xFC, 0x1F, 0xC0, 0x7F, 0x07, 0xF8, 0x7F, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xEF, 0xE0,
  0x00, 0x83, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0xFC, 0x1F, 0xFF, 0x83, 0xFF,
  0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xE0, 0x0F, 0xF0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF,
  0x83, 0xF8, 0x3F, 0x8F, 0xE0, 0x7F, 0x1F, 0x80, 0xFE, 0x3F, 0x00, 0xFC,
  0x7E, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x03,
  0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x01,
  0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x7E, 0x00, 0xFC, 0xFC, 0x03, 0xF9, 0xF8, 0x07, 0xE3, 0xF8, 0x1F,
  0xC3, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x03, 0xFF, 0x00, 0x00, 0x40, 0x00, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xF0,
  0x03, 0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0xFF, 0x7F, 0xFE,
  0x7F, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x03, 0x00,
  0x1F, 0xC0, 0x3F, 0x8F, 0xE0, 0x1F, 0x87, 0xE0, 0x0F, 0xC3, 0xF0, 0x07,
  0xE1, 0xF8, 0x07, 0xF0, 0xFC, 0x03, 0xF8, 0xFE, 0x01, 0xFC, 0x7F, 0x00,
  0xFC, 0x3F, 0x80, 0x7E, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x3F, 0x87, 0xE0,
  0x1F, 0xC7, 0xF0, 0x0F, 0xE3, 0xF8, 0x07, 0xE1, 0xFC, 0x03, 0xF0, 0xFC,
  0x01, 0xF8, 0x7E, 0x01, 0xFC, 0x3F, 0x00, 0xFE, 0x3F, 0x80, 0x7F, 0x1F,
  0xC0, 0x3F, 0x0F, 0xE0, 0x1F, 0x87, 0xE0, 0x0F, 0xC3, 0xF0, 0x0F, 0xE1,
  0xFC, 0x07, 0xF0, 0xFE, 0x07, 0xF0, 0x7F, 0x8F, 0xF8, 0x1F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xDF,
  0x80, 0x06, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xFC, 0x03, 0xFB, 0xF8, 0x07,
  0xF3, 0xF0, 0x0F, 0xC7, 0xE0, 0x3F, 0x8F, 0xC0, 0x7F, 0x1F, 0x80, 0xFC,
  0x3F, 0x03, 0xF8, 0x7E, 0x07, 0xE0, 0xFC, 0x1F, 0xC1, 0xF8, 0x3F, 0x01,
  0xF0, 0x7E, 0x03, 0xF1, 0xFC, 0x07, 0xE3, 0xF0, 0x0F, 0xC7, 0xE0, 0x1F,
  0x9F, 0x80, 0x3F, 0x3F, 0x00, 0x7E, 0x7C, 0x00, 0xFD, 0xF8, 0x00, 0xFB,
  0xF0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x03,
  0xE0, 0x1F, 0xFE, 0x03, 0xF0, 0x1F, 0xFF, 0x01, 0xF8, 0x0F, 0xDF, 0x81,
  0xFC, 0x07, 0xEF, 0xC0, 0xFE, 0x07, 0xF7, 0xE0, 0x7F, 0x03, 0xF3, 0xF0,
  0x7F, 0x81, 0xF9, 0xF8, 0x3F, 0xC1, 0xF8, 0xFC, 0x3F, 0xE0, 0xFC, 0x7E,
  0x1F, 0xF0, 0x7E, 0x3F, 0x0F, 0xF8, 0x7E, 0x1F, 0x8F, 0xBC, 0x3F, 0x0F,
  0xC7, 0xDF, 0x1F, 0x87, 0xE7, 0xEF, 0x9F, 0x83, 0xF3, 0xE7, 0xCF, 0xC1,
  0xFB, 0xF3, 0xEF, 0xC0, 0xFD, 0xF1, 0xF7, 0xE0, 0x7E, 0xF8, 0xFB, 0xF0,
  0x3F, 0xF8, 0x7F, 0xF0, 0x1F, 0xFC, 0x3F, 0xF8, 0x0F, 0xFE, 0x1F, 0xF8,
  0x03, 0xFE, 0x0F, 0xFC, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0xFF, 0x03, 0xFE,
  0x00, 0x7F, 0x80, 0xFF, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x1F, 0xC0, 0x3F,
  0x80, 0x0F, 0xE0, 0x1F, 0xC0, 0x07, 0xE0, 0x0F, 0xC0, 0x03, 0xF0, 0x07,
  0xE0, 0x01, 0xF0, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0x80,
  0xFE, 0x01, 0xF8, 0x1F, 0xC0, 0x1F, 0x81, 0xFC, 0x01, 0xFC, 0x3F, 0x80,
  0x1F, 0xC3, 0xF8, 0x00, 0xFC, 0x7F, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0xFE,
  0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xBF, 0x00, 0x03,
  0xFB, 0xF0, 0x00, 0x7F, 0x1F, 0x80, 0x0F, 0xE1, 0xF8, 0x00, 0xFE, 0x1F,
  0x80, 0x1F, 0xC1, 0xFC, 0x01, 0xFC, 0x0F, 0xC0, 0x3F, 0x80, 0xFC, 0x07,
  0xF8, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x7F,
  0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x00, 0xFE, 0x03, 0xF0, 0x1F,
  0xC0, 0x3F, 0x01, 0xFC, 0x03, 0xF0, 0x3F, 0x80, 0x3F, 0x03, 0xF8, 0x03,
  0xF0, 0x3F, 0x00, 0x3F, 0x07, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x8F,
  0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x1F, 0x9F, 0xC0, 0x01, 0xF9, 0xFC, 0x00,
  0x1F, 0x9F, 0x80, 0x01, 0xFB, 0xF8, 0x00, 0x1F, 0xBF, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xC0, 0x00, 0xF0,
  0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0x80, 0x1F, 0xC0, 0x1F, 0xF0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3E, 0x03,
  0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07,
  0xC0, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x0F,
  0x00, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x3E,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x7C,
  0x07, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xF0,
  0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x0F, 0xE0, 0x07,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xF8, 0x00,
  0x3C, 0x00, 0x0C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x1F,
  0x0F, 0xFE, 0x01, 0xF1, 0xFF, 0xE0, 0x3E, 0x3F, 0xFF, 0x03, 0xE3, 0xFF,
  0xF8, 0x7E, 0x7E, 0x1F, 0xFF, 0xC7, 0xC0, 0xFF, 0xFC, 0x7C, 0x07, 0xFF,
  0x87, 0xC0, 0x3F, 0xF0, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xC0,
};

const GFXglyph RobotoCondensed_MediumItalic58pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 14, 42, 14, 1, -41 },
  { 75, 16, 15, 18, 4, -44 },
  { 105, 29, 41, 30, 2, -41 },
  { 254, 25, 54, 28, 2, -48 },
  { 423, 27, 43, 36, 5, -42 },
  { 569, 28, 43, 32, 1, -42 },
  { 720, 7, 15, 9, 4, -44 },
  { 734, 17, 59, 18, 3, -46 },
  { 860, 18, 59, 18, -3, -46 },
  { 993, 24, 25, 25, 3, -41 },
  { 1068, 24, 30, 27, 2, -34 },
  { 1158, 11, 16, 13, -3, -7 },
  { 1180, 13, 6, 17, 2, -21 },
  { 1190, 8, 8, 16, 1, -7 },
  { 1198, 26, 45, 20, -3, -41 },
  { 1345, 24, 43, 28, 3, -42 },
  { 1474, 16, 41, 28, 7, -41 },
  { 1556, 27, 42, 28, 0, -42 },
  { 1698, 26, 43, 28, 1, -42 },
  { 1838, 26, 41, 28, 1, -41 },
  { 1972, 26, 42, 28, 2, -41 },
  { 2109, 22, 42, 28, 3, -41 },
  { 2225, 27, 41, 28, 3, -41 },
  { 2364, 25, 43, 28, 2, -42 },
  { 2499, 22, 42, 28, 4, -42 },
  { 2615, 12, 32, 15, 1, -31 },
  { 2663, 16, 40, 13, -3, -31 },
  { 2743, 22, 26, 25, 2, -31 },
  { 2815, 23, 18, 28, 3, -28 },
  { 2867, 23, 27, 26, 1, -31 },
  { 2945, 21, 43, 25, 4, -42 },
  { 3058, 40, 53, 43, 1, -40 },
  { 3323, 31, 41, 33, -2, -41 },
  { 3482, 29, 41, 31, 1, -41 },
  { 3631, 29, 43, 32, 3, -42 },
  { 3787, 30, 41, 32, 1, -41 },
  { 3941, 29, 41, 28, 1, -41 },
  { 4090, 28, 41, 27, 1, -41 },
  { 4234, 29, 43, 33, 3, -42 },
  { 4390, 34, 41, 35, 1, -41 },
  { 4565, 14, 41, 15, 1, -41 },
  { 4637, 28, 42, 27, 0, -41 },
  { 4784, 34, 41, 31, 1, -41 },
  { 4959, 22, 41, 27, 1, -41 },
  { 5072, 42, 41, 43, 1, -41 },
  { 5288, 34, 41, 35, 1, -41 },
  { 5463, 29, 43, 34, 3, -42 },
  { 5619, 31, 41, 32, 1, -41 },
  { 5778, 29, 49, 34, 3, -42 },
  { 5956, 30, 41, 31, 1, -41 },
  { 6110, 29, 43, 30, 1, -42 },
  { 6266, 28, 41, 30, 5, -41 },
  { 6410, 31, 42, 32, 2, -41 },
  { 6573, 30, 41, 32, 5, -41 },
  { 6727, 40, 41, 42, 5, -41 },
  { 6932, 35, 41, 31, -1, -41 },
  { 7112, 29, 41, 30, 5, -41 },
  { 7261, 32, 41, 30, -1, -41 },
  { 7425, 19, 57, 15, -1, -48 },
  { 7561, 13, 45, 21, 5, -41 },
  { 7635, 19, 57, 15, -3, -48 },
  { 7771, 18, 21, 21, 2, -41 },
  { 7819, 22, 5, 23, -3, 0 },
  { 7833, 11, 9, 18, 6, -44 },
  { 7846, 23, 33, 27, 1, -32 },
  { 7941, 26, 45, 28, 0, -44 },
  { 8088, 24, 33, 26, 1, -32 },
  { 8187, 28, 45, 28, 1, -44 },
  { 8345, 23, 33, 27, 2, -32 },
  { 8440, 20, 45, 18, 2, -45 },
  { 8553, 27, 44, 28, 0, -32 },
  { 8702, 25, 44, 27, 0, -44 },
  { 8840, 13, 42, 14, 1, -42 },
  { 8909, 20, 54, 13, -6, -42 },
  { 9044, 28, 44, 26, 0, -44 },
  { 9198, 14, 44, 14, 1, -44 },
  { 9275, 39, 32, 42, 0, -32 },
  { 9431, 25, 32, 27, 0, -32 },
  { 9531, 24, 33, 28, 2, -32 },
  { 9630, 28, 44, 28, -2, -32 },
  { 9784, 26, 44, 28, 1, -32 },
  { 9927, 19, 32, 18, 0, -32 },
  { 10003, 23, 33, 26, 1, -32 },
  { 10098, 16, 39, 17, 2, -38 },
  { 10176, 25, 32, 27, 2, -31 },
  { 10276, 23, 31, 25, 3, -31 },
  { 10366, 33, 31, 36, 4, -31 },
  { 10494, 28, 31, 25, -2, -31 },
  { 10603, 28, 43, 24, -2, -31 },
  { 10754, 26, 31, 25, -1, -31 },
  { 10855, 18, 55, 17, 1, -45 },
  { 10979, 12, 49, 14, 1, -41 },
  { 11053, 18, 55, 17, -2, -45 },
  { 11177, 28, 12, 32, 2, -23 },
};

const GFXfont RobotoCondensed_MediumItalic58pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_MediumItalic58pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_MediumItalic58pt7bGlyphs,
  0x20, 0x7E, 68
};

#endif // _ROBOTOCONDENSED_MEDIUMITALIC58PT7B_H_
