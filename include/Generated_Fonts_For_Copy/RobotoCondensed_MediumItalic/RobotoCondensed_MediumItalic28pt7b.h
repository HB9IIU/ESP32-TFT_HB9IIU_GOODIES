#ifndef _ROBOTOCONDENSED_MEDIUMITALIC28PT7B_H_
#define _ROBOTOCONDENSED_MEDIUMITALIC28PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-MediumItalic.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_MediumItalic28pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0x71, 0xCF, 0x38, 0xE3, 0x8E, 0x39, 0xC7, 0x1C, 0x71, 0xC0,
  0x00, 0xE3, 0x8E, 0x38, 0x77, 0x66, 0x66, 0x66, 0x66, 0xCC, 0xCC, 0x01,
  0x98, 0x0E, 0x60, 0x33, 0x80, 0xCC, 0x03, 0x30, 0x19, 0xC3, 0xFF, 0xCF,
  0xFF, 0x0C, 0x60, 0x33, 0x00, 0xCC, 0x06, 0x30, 0xFF, 0xF3, 0xFF, 0xC3,
  0x18, 0x0C, 0xC0, 0x33, 0x01, 0xCC, 0x06, 0x60, 0x19, 0x80, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x7C, 0x0F, 0xE1, 0xFF, 0x3C, 0x73, 0x87, 0x38, 0x73,
  0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0xEE,
  0x0E, 0xE1, 0xEE, 0x1C, 0x7F, 0xC7, 0xF8, 0x1E, 0x00, 0x80, 0x18, 0x01,
  0x80, 0x1C, 0x00, 0xF8, 0x06, 0x71, 0x18, 0xCE, 0x63, 0x31, 0x9D, 0x86,
  0x6E, 0x1F, 0xB0, 0x3D, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xBC, 0x0D, 0xF8,
  0x76, 0x61, 0xB9, 0x8C, 0xE6, 0x73, 0x19, 0x8E, 0x60, 0x1F, 0x00, 0x38,
  0x07, 0x80, 0x7E, 0x07, 0xF8, 0x39, 0xC1, 0x8E, 0x0C, 0x70, 0x77, 0x83,
  0xF8, 0x1F, 0x80, 0xF0, 0x0F, 0xCE, 0xFE, 0x7F, 0x7B, 0xF1, 0xFB, 0x8F,
  0xDC, 0x3C, 0xE1, 0xE7, 0xFF, 0x1F, 0xFC, 0x7C, 0xE0, 0x66, 0x66, 0xEC,
  0xC0, 0x00, 0x81, 0xC1, 0xC0, 0xC0, 0xE0, 0xE0, 0x70, 0x70, 0x38, 0x18,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x06, 0x01, 0x00, 0x08, 0x0C, 0x0E,
  0x06, 0x06, 0x07, 0x07, 0x03, 0x03, 0x03, 0x03, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x0E, 0x0E, 0x0E, 0x1C, 0x1C, 0x18, 0x38, 0x70, 0xE0, 0xC0,
  0x80, 0x03, 0x00, 0x30, 0x03, 0x04, 0x31, 0x7E, 0xF7, 0xFF, 0x0F, 0x81,
  0xF0, 0x1B, 0x03, 0xB8, 0x71, 0x82, 0x10, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0xFF, 0xFF, 0xFE, 0xFF, 0xE0, 0xE0, 0x0E, 0x00,
  0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x00, 0x1C, 0x73, 0x8E, 0x39, 0xC7, 0x18,
  0xFF, 0xFF, 0xC0, 0x5F, 0xF0, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xC0,
  0x0E, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0E,
  0x00, 0x60, 0x07, 0x00, 0x30, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0E, 0x00,
  0x60, 0x07, 0x00, 0x30, 0x00, 0x07, 0xC0, 0xFE, 0x1F, 0xE3, 0x87, 0x38,
  0x73, 0x87, 0x70, 0x77, 0x07, 0x70, 0x77, 0x0F, 0x70, 0xEF, 0x0E, 0xE0,
  0xEE, 0x0E, 0xE0, 0xEE, 0x1C, 0x71, 0xC7, 0xF8, 0x7F, 0x81, 0xE0, 0x03,
  0x0F, 0x7F, 0x7E, 0xEE, 0x8E, 0x0E, 0x0E, 0x0E, 0x1C, 0x1C, 0x1C, 0x1C,
  0x1C, 0x3C, 0x38, 0x38, 0x38, 0x38, 0x38, 0x03, 0xE0, 0x7F, 0x87, 0xFE,
  0x38, 0xF3, 0xC3, 0x9C, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00,
  0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x03, 0xFF,
  0xBF, 0xF9, 0xFF, 0xC0, 0x07, 0x81, 0xFE, 0x3F, 0xE3, 0x8F, 0x78, 0x70,
  0x07, 0x00, 0xF0, 0x0E, 0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0x1C, 0x01, 0xE0,
  0x0E, 0xE0, 0xEE, 0x1C, 0xE1, 0xCF, 0xF8, 0x7F, 0x83, 0xE0, 0x00, 0x78,
  0x03, 0xC0, 0x3C, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x1D, 0xC0, 0xDE, 0x0E,
  0xE0, 0xE7, 0x07, 0x38, 0x71, 0xC7, 0x0E, 0x3F, 0xFF, 0xFF, 0xDF, 0xFE,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x0F, 0xF8, 0xFF, 0x87, 0xFC,
  0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0xF0, 0x3F, 0xC3, 0xFF, 0x04,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x73, 0x83, 0x9C, 0x1C, 0xF1, 0xC3, 0xFE,
  0x0F, 0xE0, 0x3C, 0x00, 0x01, 0xE0, 0xFC, 0x3F, 0x8F, 0x01, 0xC0, 0x70,
  0x0E, 0x03, 0xBC, 0x7F, 0xCF, 0xFD, 0xC3, 0xB8, 0x7F, 0x0F, 0xC1, 0xF8,
  0x3B, 0x87, 0x71, 0xCF, 0xF8, 0xFE, 0x0F, 0x00, 0x3F, 0xF9, 0xFF, 0xDF,
  0xFE, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x38, 0x03, 0xC0, 0x1C,
  0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x01,
  0xC0, 0x1E, 0x00, 0xE0, 0x00, 0x07, 0xC0, 0xFE, 0x1F, 0xF3, 0xC7, 0x38,
  0x73, 0x87, 0x38, 0x73, 0x8E, 0x1F, 0xE1, 0xFC, 0x3F, 0x87, 0x1C, 0xF0,
  0xEE, 0x0E, 0xE0, 0xEE, 0x1C, 0xE1, 0xCF, 0xFC, 0x7F, 0x83, 0xE0, 0x0F,
  0x07, 0xF0, 0xFF, 0x38, 0xE7, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE1, 0xFC,
  0x39, 0xFF, 0x3F, 0xE3, 0xDC, 0x07, 0x00, 0xE0, 0x38, 0x0F, 0x0F, 0xC1,
  0xF0, 0x38, 0x00, 0x11, 0xCE, 0x70, 0x00, 0x00, 0x00, 0x00, 0x04, 0x73,
  0x9C, 0x0C, 0x3C, 0x78, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x0E, 0x1C, 0x30, 0xE1, 0xC7, 0x04, 0x00, 0x00, 0x40, 0x18, 0x0F,
  0x07, 0xE3, 0xF1, 0xF8, 0x38, 0x07, 0xC0, 0x7C, 0x07, 0xE0, 0x3E, 0x01,
  0xC0, 0x10, 0x3F, 0xE3, 0xFE, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xCF, 0xFC, 0xFF, 0xC0, 0x20, 0x06, 0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xC0, 0x70, 0x3E, 0x1F, 0x9F, 0xC3, 0xE0, 0x70, 0x08, 0x00, 0x1F, 0x0F,
  0xE7, 0xFF, 0xC7, 0xE1, 0xC0, 0x70, 0x3C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xF0, 0x38, 0x0E, 0x00, 0x00, 0x00, 0x20, 0x1C, 0x07, 0x01, 0xC0, 0x00,
  0xFC, 0x00, 0x7F, 0xE0, 0x1E, 0x0E, 0x07, 0x00, 0xE1, 0xC0, 0x0C, 0x30,
  0x01, 0x8E, 0x1E, 0x19, 0x8F, 0xE3, 0x61, 0xCC, 0x6C, 0x73, 0x8F, 0x8C,
  0x71, 0xE3, 0x8C, 0x3C, 0x61, 0x8D, 0x8C, 0x71, 0xB1, 0x8C, 0x36, 0x31,
  0x8C, 0xC7, 0x71, 0x98, 0xFF, 0xE3, 0x0E, 0x78, 0x60, 0x00, 0x0E, 0x00,
  0x00, 0xC0, 0x00, 0x1E, 0x18, 0x01, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xEE,
  0x01, 0xCC, 0x07, 0x9C, 0x0E, 0x38, 0x3C, 0x70, 0x70, 0xE0, 0xFF, 0xC3,
  0xFF, 0x87, 0xFF, 0x1C, 0x0E, 0x38, 0x1E, 0xF0, 0x1D, 0xC0, 0x3F, 0x80,
  0x70, 0x0F, 0xF0, 0x1F, 0xF0, 0x7F, 0xF0, 0xE0, 0xE1, 0xC1, 0xC3, 0x83,
  0x87, 0x07, 0x0E, 0x1E, 0x3F, 0xF8, 0x7F, 0xE0, 0xFF, 0xC1, 0xC3, 0xC3,
  0x83, 0x8F, 0x07, 0x1E, 0x0E, 0x38, 0x1C, 0x70, 0x78, 0xFF, 0xE1, 0xFF,
  0x87, 0xFE, 0x00, 0x03, 0xE0, 0x3F, 0xE1, 0xFF, 0x87, 0x0F, 0x38, 0x1C,
  0xE0, 0x77, 0x81, 0xDC, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0xEF, 0x07, 0x9C, 0x1C, 0x70, 0xF1, 0xFF, 0x83, 0xFC,
  0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0xF0, 0x7F, 0xE0, 0xE1, 0xE1, 0xC1, 0xC3,
  0x83, 0x87, 0x07, 0x8E, 0x0F, 0x3C, 0x1E, 0x70, 0x38, 0xE0, 0x71, 0xC0,
  0xE3, 0x81, 0xCF, 0x07, 0x9E, 0x0E, 0x38, 0x3C, 0x70, 0xF0, 0xFF, 0xC1,
  0xFF, 0x07, 0xF8, 0x00, 0x0F, 0xFC, 0x1F, 0xF8, 0x7F, 0xF0, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF,
  0xC1, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xFF, 0xE1, 0xFF, 0x87, 0xFF, 0x00, 0x0F, 0xFC, 0x3F, 0xF1, 0xFF, 0xC7,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xFF, 0xC3,
  0xFF, 0x0F, 0xF8, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x3C, 0x00, 0x03, 0xF0, 0x3F, 0xE1, 0xFF, 0xC7, 0x07,
  0x38, 0x1C, 0xE0, 0x77, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC7, 0xF7, 0x1F,
  0xDC, 0x7E, 0xF0, 0x3B, 0xC0, 0xEF, 0x03, 0x9C, 0x1E, 0x78, 0x79, 0xFF,
  0xC3, 0xFE, 0x03, 0xE0, 0x0E, 0x03, 0x87, 0x03, 0xC7, 0x81, 0xE3, 0x80,
  0xE1, 0xC0, 0x70, 0xE0, 0x38, 0x70, 0x1C, 0x38, 0x1E, 0x3F, 0xFF, 0x1F,
  0xFF, 0x0F, 0xFF, 0x87, 0x01, 0xC3, 0x80, 0xE3, 0xC0, 0xF1, 0xE0, 0x70,
  0xE0, 0x38, 0x70, 0x1C, 0x38, 0x0E, 0x1C, 0x07, 0x1E, 0x07, 0x80, 0x0E,
  0x1C, 0x38, 0xF1, 0xC3, 0x87, 0x0E, 0x3C, 0x78, 0xE1, 0xC3, 0x87, 0x1E,
  0x3C, 0x70, 0xE1, 0xC3, 0x80, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x3C, 0x00, 0xE0, 0x03, 0x8E, 0x0E, 0x3C, 0x78, 0xF1, 0xC1, 0xFF,
  0x07, 0xF8, 0x07, 0x80, 0x0E, 0x0F, 0x07, 0x0F, 0x87, 0x87, 0x83, 0x87,
  0x81, 0xC7, 0x80, 0xE7, 0x80, 0x73, 0x80, 0x3B, 0xC0, 0x3F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xDE, 0x03, 0xC7, 0x01, 0xE3, 0x80,
  0xE1, 0xE0, 0x70, 0x70, 0x38, 0x3C, 0x1C, 0x1E, 0x1E, 0x07, 0x00, 0x0E,
  0x01, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x3C, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0x70, 0x0F, 0xFD,
  0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0xF8, 0x78, 0x07, 0xC7, 0xC0, 0x7C, 0x3E,
  0x03, 0xE1, 0xF0, 0x3F, 0x0F, 0xC1, 0xF8, 0x7E, 0x0D, 0xC3, 0xF0, 0xFC,
  0x3B, 0x87, 0xE1, 0xDC, 0x77, 0x0E, 0x63, 0xB8, 0x73, 0x39, 0xC3, 0x99,
  0xDE, 0x3C, 0xDC, 0xE1, 0xE7, 0xE7, 0x0E, 0x3E, 0x38, 0x71, 0xF1, 0xC3,
  0x8F, 0x0E, 0x1C, 0x38, 0xF1, 0xE1, 0x87, 0x00, 0x0E, 0x03, 0x87, 0x03,
  0xC7, 0xC1, 0xE3, 0xE0, 0xE1, 0xF0, 0x70, 0xFC, 0x38, 0x7E, 0x1C, 0x3B,
  0x1E, 0x3D, 0x8E, 0x1C, 0xE7, 0x0E, 0x33, 0x87, 0x19, 0xC3, 0x8E, 0xE3,
  0xC7, 0xF1, 0xE1, 0xF0, 0xE0, 0xF8, 0x70, 0x7C, 0x38, 0x1E, 0x1C, 0x0F,
  0x1E, 0x07, 0x80, 0x03, 0xE0, 0x1F, 0xF0, 0x7F, 0xF0, 0xE1, 0xE3, 0xC1,
  0xC7, 0x03, 0xDE, 0x07, 0xB8, 0x0F, 0x70, 0x1C, 0xE0, 0x39, 0xC0, 0x77,
  0x80, 0xEF, 0x01, 0xDE, 0x07, 0xBC, 0x0E, 0x38, 0x3C, 0x70, 0x70, 0xFF,
  0xE0, 0xFF, 0x80, 0xFC, 0x00, 0x0F, 0xF0, 0x1F, 0xF8, 0x7F, 0xF0, 0xE0,
  0xF1, 0xC0, 0xE3, 0x81, 0xC7, 0x03, 0x8E, 0x07, 0x3C, 0x1E, 0x70, 0x78,
  0xFF, 0xF1, 0xFF, 0xC3, 0xFE, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x1F, 0xF0, 0x7F,
  0xF0, 0xE1, 0xE3, 0x81, 0xC7, 0x03, 0x9E, 0x07, 0x38, 0x0E, 0x70, 0x1C,
  0xE0, 0x39, 0xC0, 0x77, 0x80, 0xEF, 0x01, 0xDE, 0x07, 0x3C, 0x0E, 0x38,
  0x3C, 0x70, 0xF0, 0xFF, 0xE0, 0xFF, 0x80, 0xFF, 0x00, 0x0F, 0x00, 0x0E,
  0x00, 0x08, 0x00, 0x0F, 0xF0, 0x1F, 0xF0, 0x7F, 0xF0, 0xE0, 0xE1, 0xC1,
  0xE3, 0x83, 0xC7, 0x07, 0x8E, 0x0E, 0x3C, 0x3C, 0x7F, 0xF0, 0xFF, 0xC1,
  0xFF, 0x03, 0x8E, 0x07, 0x1C, 0x1E, 0x3C, 0x38, 0x78, 0x70, 0x70, 0xE0,
  0xE1, 0xC1, 0xE7, 0x83, 0xC0, 0x07, 0xE0, 0x3F, 0xC1, 0xFF, 0x8F, 0x0E,
  0x38, 0x38, 0xE0, 0xE3, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xCE, 0x07, 0x38, 0x3C, 0xF0, 0xE3, 0xFF,
  0x87, 0xFC, 0x07, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03,
  0xC0, 0x0E, 0x00, 0x3C, 0x0E, 0x78, 0x3C, 0xE0, 0x79, 0xC0, 0xE3, 0x81,
  0xC7, 0x03, 0x9E, 0x07, 0x3C, 0x1E, 0x70, 0x38, 0xE0, 0x71, 0xC0, 0xE3,
  0x81, 0xCF, 0x03, 0x9E, 0x0F, 0x38, 0x1C, 0x78, 0x38, 0xF0, 0xF0, 0xFF,
  0xC0, 0xFF, 0x00, 0xFC, 0x00, 0xF0, 0x1F, 0xE0, 0x39, 0xC0, 0xF3, 0x81,
  0xC7, 0x07, 0x8E, 0x0F, 0x1C, 0x1C, 0x38, 0x78, 0x78, 0xE0, 0x73, 0xC0,
  0xE7, 0x01, 0xCE, 0x03, 0xB8, 0x07, 0x70, 0x0F, 0xE0, 0x1F, 0x80, 0x3F,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x00, 0xE0, 0xE1, 0xFC, 0x3C, 0x3B,
  0x87, 0x87, 0x70, 0xF1, 0xEE, 0x3E, 0x39, 0xC7, 0xC7, 0x39, 0xF9, 0xE7,
  0x3F, 0x38, 0xE6, 0xE7, 0x1D, 0xDC, 0xE3, 0xBB, 0xB8, 0x76, 0x77, 0x0F,
  0xC6, 0xE1, 0xF8, 0xF8, 0x3E, 0x1F, 0x07, 0xC3, 0xE0, 0xF8, 0x78, 0x1E,
  0x0F, 0x03, 0xC1, 0xE0, 0x70, 0x38, 0x00, 0x0E, 0x07, 0x87, 0x83, 0x83,
  0xC3, 0xC0, 0xE3, 0xC0, 0x71, 0xC0, 0x3D, 0xE0, 0x0E, 0xE0, 0x07, 0xF0,
  0x03, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x7B,
  0x80, 0x39, 0xC0, 0x3C, 0xF0, 0x1C, 0x38, 0x1E, 0x1C, 0x1E, 0x0F, 0x0F,
  0x07, 0x80, 0x70, 0x3D, 0xC0, 0xE7, 0x07, 0x9C, 0x1C, 0x38, 0xF0, 0xE3,
  0x83, 0x9C, 0x0E, 0x70, 0x1B, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x0E,
  0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F,
  0x00, 0x1F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF8, 0x01, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x3C, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x01, 0xFF, 0xE3, 0xFF,
  0xC7, 0xFF, 0x80, 0x0F, 0x87, 0xC3, 0xC3, 0xC1, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x1E, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0xF0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x83, 0x81, 0xC0, 0xF8, 0x7C, 0x3E, 0x00, 0x71, 0xC7,
  0x1C, 0x71, 0xC7, 0x1C, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x87, 0x1C, 0x71,
  0xC7, 0x1C, 0x70, 0x07, 0xC3, 0xE0, 0xF8, 0x0E, 0x03, 0x80, 0xE0, 0x78,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x0F, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x81, 0xE0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x7C, 0x1F, 0x07,
  0x80, 0x06, 0x07, 0x83, 0xC3, 0xE1, 0xB1, 0xD8, 0xCC, 0xE6, 0x63, 0xF1,
  0xC0, 0x7F, 0xEF, 0xFF, 0xFF, 0x80, 0xF3, 0x8E, 0x70, 0x07, 0xC1, 0xFE,
  0x1F, 0xE3, 0x8F, 0x38, 0xF0, 0x0E, 0x0F, 0xE3, 0xFE, 0x78, 0xE7, 0x0E,
  0x70, 0xE7, 0x1E, 0x7F, 0xC7, 0xFC, 0x3D, 0xC0, 0x0E, 0x00, 0xE0, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1D, 0xE3, 0xFF, 0x3F, 0xF3, 0xC7, 0x38,
  0x73, 0x87, 0x38, 0x77, 0x87, 0x70, 0x77, 0x07, 0x70, 0xF7, 0x0E, 0x7F,
  0xEE, 0xFC, 0xE7, 0x80, 0x0F, 0x87, 0xF8, 0xFF, 0x38, 0x77, 0x0F, 0xC1,
  0xF8, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x87, 0x71, 0xEF, 0xF8, 0xFE, 0x0F,
  0x80, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x79,
  0xC7, 0xEE, 0x7F, 0xF3, 0x87, 0x3C, 0x39, 0xC1, 0xCE, 0x0E, 0x70, 0x73,
  0x87, 0x9C, 0x38, 0xE1, 0xC7, 0x0E, 0x3F, 0xF0, 0xFF, 0x83, 0xDC, 0x00,
  0x0F, 0x83, 0xF8, 0xFF, 0xB8, 0x77, 0x0F, 0xC1, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x4F, 0xFC, 0xFF, 0x07, 0xC0, 0x03, 0xC3, 0xE0,
  0xF8, 0x78, 0x1C, 0x07, 0x07, 0xF1, 0xFC, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x1E, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x0F, 0x03, 0x80, 0xE0, 0x00,
  0x0F, 0xB8, 0xFF, 0xCF, 0xFE, 0x70, 0xF3, 0x87, 0x38, 0x39, 0xC1, 0xCE,
  0x0E, 0x70, 0x73, 0x87, 0x9C, 0x38, 0xE1, 0xC7, 0xFE, 0x1F, 0xF0, 0x7B,
  0x80, 0x3C, 0x01, 0xC2, 0x0E, 0x3F, 0xE1, 0xFF, 0x03, 0xE0, 0x00, 0x0E,
  0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1F, 0xC3, 0xFE, 0x3F,
  0xF3, 0x87, 0x38, 0x73, 0x87, 0x38, 0x77, 0x0F, 0x70, 0xE7, 0x0E, 0x70,
  0xE7, 0x0E, 0xF0, 0xEE, 0x1E, 0xE1, 0xC0, 0x00, 0x1C, 0x78, 0x60, 0x00,
  0x07, 0x0E, 0x3C, 0x70, 0xE1, 0xC3, 0x87, 0x1E, 0x38, 0x70, 0xE1, 0xC3,
  0x8F, 0x00, 0x00, 0x80, 0xF0, 0x3C, 0x06, 0x00, 0x00, 0x00, 0x38, 0x0E,
  0x07, 0x81, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0xF0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x1E, 0x07, 0x01, 0xC0, 0x70, 0xFC, 0x3E, 0x0F, 0x00,
  0x0E, 0x00, 0x70, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x71, 0xE7,
  0x9E, 0x39, 0xE1, 0xCE, 0x0E, 0xE0, 0x7F, 0x03, 0xF0, 0x3F, 0x81, 0xFE,
  0x0F, 0x70, 0x73, 0x83, 0x9E, 0x1C, 0x71, 0xE3, 0xCE, 0x1E, 0x00, 0x0E,
  0x1C, 0x38, 0xE1, 0xC3, 0x87, 0x0E, 0x3C, 0x70, 0xE1, 0xC3, 0x87, 0x1E,
  0x38, 0x70, 0xE1, 0xC3, 0x8F, 0x00, 0x1F, 0xE7, 0x87, 0xFD, 0xF8, 0xFF,
  0xFF, 0x9C, 0x3C, 0x73, 0x87, 0x0E, 0x70, 0xE1, 0xCE, 0x1C, 0x3B, 0xC7,
  0x8F, 0x70, 0xE1, 0xCE, 0x1C, 0x39, 0xC3, 0x87, 0x38, 0x70, 0xE7, 0x0E,
  0x1D, 0xE3, 0xC7, 0xB8, 0x70, 0xE0, 0x1D, 0xC3, 0xFE, 0x3F, 0xF3, 0xC7,
  0x38, 0x73, 0x87, 0x38, 0x77, 0x8F, 0x70, 0xE7, 0x0E, 0x70, 0xE7, 0x0E,
  0xF0, 0xEE, 0x1E, 0xE1, 0xC0, 0x0F, 0x81, 0xFC, 0x3F, 0xE7, 0x0E, 0x70,
  0xEE, 0x0E, 0xE0, 0xEE, 0x0E, 0xE0, 0xEE, 0x0E, 0xE0, 0xEE, 0x1C, 0xFF,
  0xC7, 0xF8, 0x3E, 0x00, 0x0C, 0xF0, 0xFF, 0xC7, 0xFE, 0x3C, 0x71, 0xC3,
  0x8E, 0x1C, 0x70, 0xE7, 0x87, 0x38, 0x39, 0xC1, 0xCE, 0x1E, 0x70, 0xE3,
  0xFF, 0x3F, 0xF1, 0xCF, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0,
  0x0E, 0x00, 0x00, 0x1E, 0x73, 0xF7, 0x7F, 0xF7, 0x0E, 0xF0, 0xEE, 0x0E,
  0xE0, 0xEE, 0x0E, 0xE1, 0xEE, 0x1C, 0xE1, 0xCE, 0x1C, 0xFF, 0xC7, 0xFC,
  0x3F, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x07, 0x80, 0x1F,
  0x9F, 0xCF, 0xE7, 0x83, 0x81, 0xC0, 0xE0, 0xF0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x07, 0x83, 0x80, 0x07, 0x81, 0xFE, 0x3F, 0xE3, 0x8E, 0x38, 0xF3,
  0x80, 0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x1C, 0xE1, 0xEF, 0x1C, 0x7F, 0xC7,
  0xF8, 0x1F, 0x00, 0x1C, 0x1C, 0x1C, 0xFE, 0xFE, 0x38, 0x38, 0x38, 0x78,
  0x70, 0x70, 0x70, 0x70, 0x70, 0x70, 0x78, 0x78, 0x38, 0x38, 0x77, 0x8F,
  0x70, 0xE7, 0x0E, 0x70, 0xE7, 0x0E, 0x70, 0xEF, 0x1E, 0xE1, 0xCE, 0x1C,
  0xE1, 0xCE, 0x3C, 0xFF, 0xC7, 0xFC, 0x7F, 0x80, 0xE1, 0xDC, 0x3B, 0x8E,
  0x71, 0xCE, 0x39, 0xCE, 0x39, 0xC7, 0x70, 0x6E, 0x0D, 0x81, 0xF0, 0x3E,
  0x07, 0x80, 0xF0, 0x1C, 0x00, 0xE3, 0x87, 0xE3, 0x8E, 0xE3, 0x8E, 0xE7,
  0x8E, 0xE7, 0x9C, 0xEF, 0x9C, 0xED, 0x9C, 0xED, 0xB8, 0xFD, 0xF8, 0xF9,
  0xF0, 0xF9, 0xF0, 0xF1, 0xF0, 0xF0, 0xE0, 0xF0, 0xE0, 0xE0, 0xC0, 0x1C,
  0x38, 0x71, 0xE0, 0xE7, 0x03, 0xB8, 0x0F, 0xE0, 0x1F, 0x00, 0x78, 0x01,
  0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xDC, 0x0F, 0x70, 0x39, 0xC1, 0xE3, 0x8F,
  0x0E, 0x00, 0x1C, 0x38, 0x70, 0xE1, 0xC7, 0x07, 0x1C, 0x1C, 0xF0, 0x73,
  0x81, 0xCE, 0x07, 0x70, 0x1D, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x0F, 0x80, 0x3E,
  0x00, 0xE0, 0x00, 0x3F, 0xF3, 0xFF, 0x3F, 0xE0, 0x1E, 0x03, 0xC0, 0x38,
  0x07, 0x00, 0xF0, 0x1E, 0x01, 0xC0, 0x38, 0x07, 0x80, 0xFF, 0xCF, 0xFC,
  0xFF, 0xC0, 0x01, 0x07, 0x0F, 0x0E, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C,
  0x38, 0x38, 0xF0, 0xE0, 0xE0, 0x70, 0x70, 0x70, 0x70, 0x70, 0x70, 0x70,
  0x70, 0x70, 0x70, 0x38, 0x10, 0x0C, 0x30, 0xC3, 0x1C, 0x61, 0x86, 0x18,
  0x61, 0x8E, 0x30, 0xC3, 0x0C, 0x31, 0xC6, 0x18, 0x61, 0x86, 0x18, 0x08,
  0x06, 0x03, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0x70, 0x18, 0x3C, 0x1C, 0x1C, 0x0E, 0x07, 0x03, 0x03, 0x81, 0xC0,
  0xE0, 0x60, 0x70, 0x70, 0x20, 0x00, 0x1C, 0x1B, 0xF0, 0xDF, 0xCF, 0xC7,
  0xEE, 0x3F, 0x00, 0xF0,
};

const GFXglyph RobotoCondensed_MediumItalic28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 6, 20, 7, 1, -20 },
  { 16, 8, 7, 9, 2, -21 },
  { 23, 14, 20, 15, 1, -20 },
  { 58, 12, 26, 14, 1, -23 },
  { 97, 14, 20, 17, 2, -20 },
  { 132, 13, 20, 15, 1, -20 },
  { 165, 4, 7, 5, 2, -21 },
  { 169, 9, 28, 9, 1, -22 },
  { 201, 8, 28, 9, -1, -22 },
  { 229, 12, 12, 12, 1, -20 },
  { 247, 12, 15, 13, 1, -17 },
  { 270, 6, 8, 6, -2, -3 },
  { 276, 6, 3, 8, 1, -10 },
  { 279, 3, 4, 8, 1, -4 },
  { 281, 13, 22, 10, -2, -20 },
  { 317, 12, 20, 14, 1, -20 },
  { 347, 8, 20, 14, 3, -20 },
  { 367, 13, 20, 14, 0, -20 },
  { 400, 12, 20, 14, 1, -20 },
  { 430, 13, 20, 14, 0, -20 },
  { 463, 13, 20, 14, 1, -20 },
  { 496, 11, 20, 14, 1, -20 },
  { 524, 13, 20, 14, 1, -20 },
  { 557, 12, 20, 14, 1, -20 },
  { 587, 11, 20, 14, 2, -20 },
  { 615, 5, 16, 7, 1, -16 },
  { 625, 7, 21, 6, -1, -16 },
  { 644, 11, 13, 12, 1, -15 },
  { 662, 12, 9, 13, 1, -14 },
  { 676, 11, 13, 12, 1, -15 },
  { 694, 10, 20, 12, 2, -20 },
  { 719, 19, 25, 21, 1, -19 },
  { 779, 15, 20, 16, -1, -20 },
  { 817, 15, 20, 15, 0, -20 },
  { 855, 14, 20, 15, 1, -20 },
  { 890, 15, 20, 15, 0, -20 },
  { 928, 15, 20, 13, 0, -20 },
  { 966, 14, 20, 13, 0, -20 },
  { 1001, 14, 20, 16, 1, -20 },
  { 1036, 17, 20, 17, 0, -20 },
  { 1079, 7, 20, 7, 0, -20 },
  { 1097, 14, 20, 13, 0, -20 },
  { 1132, 17, 20, 15, 0, -20 },
  { 1175, 11, 20, 13, 0, -20 },
  { 1203, 21, 20, 21, 0, -20 },
  { 1256, 17, 20, 17, 0, -20 },
  { 1299, 15, 20, 16, 1, -20 },
  { 1337, 15, 20, 15, 0, -20 },
  { 1375, 15, 23, 16, 1, -20 },
  { 1419, 15, 20, 15, 0, -20 },
  { 1457, 14, 20, 14, 1, -20 },
  { 1492, 14, 20, 14, 2, -20 },
  { 1527, 15, 20, 15, 1, -20 },
  { 1565, 15, 20, 15, 2, -20 },
  { 1603, 19, 20, 21, 3, -20 },
  { 1651, 17, 20, 15, -1, -20 },
  { 1694, 14, 20, 15, 2, -20 },
  { 1729, 15, 20, 14, 0, -20 },
  { 1767, 9, 27, 7, 0, -23 },
  { 1798, 6, 22, 10, 2, -20 },
  { 1815, 10, 27, 7, -2, -23 },
  { 1849, 9, 10, 10, 1, -20 },
  { 1861, 11, 3, 11, -2, 0 },
  { 1866, 5, 4, 9, 3, -21 },
  { 1869, 12, 15, 13, 0, -15 },
  { 1892, 12, 21, 13, 0, -21 },
  { 1924, 11, 15, 13, 1, -15 },
  { 1945, 13, 21, 13, 1, -21 },
  { 1980, 11, 15, 13, 1, -15 },
  { 2001, 10, 21, 9, 1, -21 },
  { 2028, 13, 21, 14, 0, -15 },
  { 2063, 12, 21, 13, 0, -21 },
  { 2095, 7, 21, 7, 0, -21 },
  { 2114, 10, 27, 6, -3, -21 },
  { 2148, 13, 21, 13, 0, -21 },
  { 2183, 7, 21, 7, 0, -21 },
  { 2202, 19, 15, 20, 0, -15 },
  { 2238, 12, 15, 13, 0, -15 },
  { 2261, 12, 15, 14, 1, -15 },
  { 2284, 13, 21, 13, -1, -15 },
  { 2319, 12, 21, 14, 1, -15 },
  { 2351, 9, 15, 9, 0, -15 },
  { 2368, 12, 15, 12, 0, -15 },
  { 2391, 8, 18, 8, 1, -18 },
  { 2409, 12, 15, 13, 1, -15 },
  { 2432, 11, 15, 12, 2, -15 },
  { 2453, 16, 15, 17, 2, -15 },
  { 2483, 14, 15, 12, -1, -15 },
  { 2510, 14, 21, 12, -1, -15 },
  { 2547, 12, 15, 12, 0, -15 },
  { 2570, 8, 27, 8, 1, -22 },
  { 2597, 6, 24, 7, 0, -20 },
  { 2615, 9, 27, 8, -1, -22 },
  { 2646, 13, 6, 16, 1, -11 },
};

const GFXfont RobotoCondensed_MediumItalic28pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_MediumItalic28pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_MediumItalic28pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _ROBOTOCONDENSED_MEDIUMITALIC28PT7B_H_
