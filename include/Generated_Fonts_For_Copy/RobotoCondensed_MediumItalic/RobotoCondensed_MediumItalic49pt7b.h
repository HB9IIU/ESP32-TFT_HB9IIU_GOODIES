#ifndef _ROBOTOCONDENSED_MEDIUMITALIC49PT7B_H_
#define _ROBOTOCONDENSED_MEDIUMITALIC49PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-MediumItalic.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_MediumItalic49pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xE0, 0x3E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xC0,
  0x7C, 0x07, 0xC0, 0xFC, 0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x3E, 0x03,
  0xE0, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x7C, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0x78, 0x00, 0x3C, 0x79, 0xE7, 0xDE, 0x3C, 0xF1,
  0xE7, 0x8F, 0x3C, 0x79, 0xE3, 0xCE, 0x1C, 0xF1, 0xE7, 0x8F, 0x3C, 0x79,
  0xC3, 0x8E, 0x1C, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1E,
  0x1C, 0x00, 0x1E, 0x3C, 0x00, 0x1C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C,
  0x78, 0x00, 0x38, 0x78, 0x00, 0x78, 0x78, 0x00, 0x78, 0xF0, 0x0F, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x01, 0xE1,
  0xE0, 0x01, 0xE3, 0xC0, 0x01, 0xC3, 0xC0, 0x03, 0xC3, 0xC0, 0x03, 0xC3,
  0x80, 0x03, 0x87, 0x80, 0x07, 0x87, 0x80, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x0F, 0x1E, 0x00, 0x1E, 0x1E,
  0x00, 0x1E, 0x1C, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x38,
  0x00, 0x3C, 0x78, 0x00, 0x78, 0x78, 0x00, 0x78, 0x70, 0x00, 0x78, 0xF0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0x00, 0x7F, 0xFC, 0x07, 0xFF,
  0xE0, 0x3F, 0xFF, 0x83, 0xF0, 0xFC, 0x1F, 0x83, 0xF0, 0xF8, 0x1F, 0x8F,
  0xC0, 0xFC, 0x7E, 0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7E, 0x7C, 0x03, 0xF3, 0xE0, 0x1F, 0x9F, 0x00,
  0xF8, 0xF8, 0x07, 0xC7, 0xE0, 0x7E, 0x3F, 0x87, 0xE0, 0xFF, 0xFF, 0x07,
  0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0xFE, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x07,
  0x87, 0x81, 0x0F, 0x0F, 0x07, 0x9E, 0x1E, 0x0F, 0x38, 0x3C, 0x3C, 0x70,
  0x78, 0xF1, 0xE0, 0xF3, 0xC1, 0xC1, 0xE7, 0x83, 0xC7, 0x9E, 0x07, 0xDF,
  0x78, 0x0F, 0xFC, 0xF0, 0x0F, 0xF3, 0xC0, 0x07, 0xCF, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x8F, 0x80, 0x0F, 0x7F,
  0x80, 0x3D, 0xFF, 0x80, 0xF3, 0xEF, 0x81, 0xEF, 0x8F, 0x07, 0x9E, 0x1E,
  0x1E, 0x3C, 0x3C, 0x38, 0x70, 0x78, 0xF0, 0xE0, 0xF3, 0xC1, 0xC1, 0xEF,
  0x03, 0x83, 0xCE, 0x07, 0x8F, 0x08, 0x0F, 0xBE, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x03, 0xF1, 0xF0, 0x03,
  0xE1, 0xF0, 0x07, 0xC0, 0xF0, 0x07, 0xC1, 0xF0, 0x07, 0xC1, 0xF0, 0x07,
  0xC1, 0xF0, 0x07, 0xC3, 0xE0, 0x03, 0xEF, 0xE0, 0x03, 0xFF, 0xC0, 0x03,
  0xFF, 0x80, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xFC, 0x1E, 0x1F, 0xFC, 0x1E, 0x3F, 0xFE, 0x3E, 0x3F, 0x3F, 0x3E, 0x7E,
  0x3F, 0x3E, 0x7C, 0x1F, 0xFC, 0xFC, 0x1F, 0xFC, 0xFC, 0x0F, 0xFC, 0xFC,
  0x0F, 0xF8, 0xFC, 0x07, 0xF0, 0xFC, 0x07, 0xF0, 0x7E, 0x07, 0xF0, 0x7F,
  0x1F, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x1F, 0xFE, 0xFC, 0x0F,
  0xF8, 0x7C, 0x00, 0x80, 0x00, 0x3E, 0x78, 0xF1, 0xE3, 0xCF, 0x9E, 0x3C,
  0x78, 0xF1, 0xE3, 0x80, 0x00, 0x02, 0x00, 0x1C, 0x00, 0x78, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F,
  0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x03, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00,
  0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x78, 0x00, 0xE0, 0x01, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x80, 0x38, 0x78, 0x37, 0xE7, 0x9F, 0x7F, 0xFF, 0xF7, 0xFF,
  0xFF, 0x0F, 0xFF, 0xC0, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x07,
  0xBC, 0x00, 0xFB, 0xE0, 0x1F, 0x1E, 0x03, 0xE1, 0xF0, 0x3C, 0x0F, 0x01,
  0x80, 0xE0, 0x08, 0x04, 0x00, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x1F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC3, 0xE0, 0xF8,
  0x3E, 0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x3F, 0x0F, 0x87, 0xC1, 0xF0, 0x78,
  0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x10, 0xFB, 0xFF,
  0xFF, 0xEF, 0x9E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0,
  0x7F, 0xFF, 0x07, 0xE1, 0xF8, 0x3E, 0x07, 0xC3, 0xF0, 0x3E, 0x1F, 0x01,
  0xF8, 0xF8, 0x0F, 0xCF, 0xC0, 0x7E, 0x7C, 0x03, 0xF3, 0xE0, 0x1F, 0x9F,
  0x00, 0xF9, 0xF8, 0x07, 0xCF, 0xC0, 0x3E, 0x7E, 0x01, 0xF3, 0xE0, 0x1F,
  0x9F, 0x00, 0xFC, 0xF8, 0x07, 0xEF, 0xC0, 0x3E, 0x7E, 0x01, 0xF3, 0xF0,
  0x0F, 0x9F, 0x80, 0xFC, 0xFC, 0x07, 0xE7, 0xC0, 0x3E, 0x3E, 0x01, 0xF1,
  0xF8, 0x1F, 0x87, 0xC0, 0xF8, 0x3E, 0x0F, 0xC1, 0xFF, 0xFC, 0x07, 0xFF,
  0xC0, 0x3F, 0xFE, 0x00, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x00, 0x18, 0x03,
  0xC0, 0xFE, 0x1F, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xDF, 0xBE, 0xE1, 0xF4,
  0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xE0,
  0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFC, 0x1F, 0x81,
  0xF8, 0x1F, 0x87, 0xE0, 0x3F, 0x0F, 0xC0, 0x7E, 0x1F, 0x00, 0xFC, 0x3E,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF,
  0xF8, 0x3F, 0x87, 0xE0, 0xFC, 0x0F, 0x87, 0xE0, 0x3E, 0x1F, 0x80, 0xF8,
  0x7E, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x1F, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0xC0,
  0x3E, 0x3F, 0x01, 0xF8, 0xFC, 0x07, 0xC1, 0xF8, 0x3F, 0x07, 0xFF, 0xF8,
  0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xF7, 0xE0, 0x03, 0xEF, 0xC0, 0x0F,
  0x9F, 0x00, 0x1E, 0x3E, 0x00, 0x7C, 0x7C, 0x01, 0xF1, 0xF8, 0x07, 0xE3,
  0xF0, 0x0F, 0x87, 0xE0, 0x3E, 0x0F, 0x80, 0xFC, 0x1F, 0x01, 0xF0, 0x3E,
  0x07, 0xC0, 0xFC, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE0, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x3E, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xC0, 0xFC, 0x1F, 0x80, 0x20, 0x7E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE3, 0xE0, 0x1F, 0x8F, 0x80, 0x7E, 0x3F, 0x01, 0xF0, 0xFC, 0x0F,
  0xC1, 0xF8, 0x7E, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x03, 0xF8, 0x01,
  0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF3,
  0xE0, 0x7D, 0xFF, 0x0F, 0xFF, 0xF1, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF, 0xE0,
  0xFD, 0xF8, 0x1F, 0xBF, 0x01, 0xF7, 0xC0, 0x3E, 0xF8, 0x07, 0xFF, 0x00,
  0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0xFD, 0xF0, 0x1F, 0xBE, 0x03,
  0xE7, 0xC0, 0xFC, 0xFC, 0x3F, 0x0F, 0xFF, 0xE1, 0xFF, 0xF8, 0x1F, 0xFE,
  0x01, 0xFF, 0x80, 0x0F, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x01, 0xFF,
  0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x1F, 0x87, 0xE0,
  0x7C, 0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x3F, 0x03, 0xF0, 0xF8,
  0x0F, 0x83, 0xE0, 0x3E, 0x0F, 0xC1, 0xF8, 0x1F, 0x0F, 0xC0, 0x7F, 0xFF,
  0x00, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07,
  0xE1, 0xF0, 0x3F, 0x07, 0xE0, 0xF8, 0x0F, 0x87, 0xE0, 0x3E, 0x1F, 0x00,
  0xF8, 0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x3E, 0x1F, 0x01, 0xF8,
  0x7E, 0x07, 0xE1, 0xF8, 0x3F, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x1F,
  0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x7F,
  0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0x0F, 0x8F, 0xC1,
  0xF9, 0xF0, 0x1F, 0x7E, 0x03, 0xEF, 0xC0, 0x7D, 0xF0, 0x0F, 0xBE, 0x01,
  0xF7, 0xC0, 0x3E, 0xF8, 0x07, 0xDF, 0x00, 0xFB, 0xE0, 0x3F, 0x7C, 0x07,
  0xEF, 0x81, 0xFD, 0xF8, 0x3F, 0x3F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0xFF,
  0x87, 0xFF, 0xE0, 0x3E, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0x80,
  0x3F, 0xC0, 0x0F, 0xF0, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x0F,
  0xC3, 0xF8, 0xFE, 0x3F, 0x07, 0x80, 0x00, 0x40, 0x0F, 0x80, 0xFE, 0x07,
  0xF0, 0x3F, 0x80, 0xF8, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x80, 0xF8,
  0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x01, 0xF8, 0x0F, 0x80, 0xF8, 0x07,
  0x80, 0x08, 0x00, 0x00, 0x00, 0x20, 0x00, 0x1C, 0x00, 0x0F, 0x80, 0x07,
  0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF0,
  0x0F, 0xF8, 0x01, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFC,
  0x00, 0x0F, 0x80, 0x00, 0x70, 0x00, 0x04, 0x00, 0x1F, 0xFF, 0xF1, 0xFF,
  0xFF, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8,
  0x08, 0x00, 0x01, 0xC0, 0x00, 0x3E, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0x00,
  0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFC,
  0x00, 0x1F, 0x80, 0x07, 0xF0, 0x03, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xC0,
  0xFF, 0xE0, 0x7F, 0xF0, 0x0F, 0xF8, 0x01, 0xFC, 0x00, 0x3C, 0x00, 0x0E,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x87,
  0xFF, 0xE7, 0xFF, 0xF3, 0xF0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xF8, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x03,
  0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF0, 0x01,
  0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3E, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x0F, 0x80,
  0x00, 0xF0, 0x07, 0xC0, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x07, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x78, 0x07, 0xC0, 0x38, 0x1E, 0x07, 0xFC, 0x0E, 0x0F,
  0x03, 0xFF, 0x83, 0x83, 0xC1, 0xFF, 0xF0, 0xE1, 0xE0, 0xF8, 0x78, 0x3C,
  0x78, 0x3C, 0x1E, 0x0F, 0x3C, 0x1F, 0x07, 0x83, 0xCF, 0x07, 0x81, 0xE0,
  0xF3, 0xC3, 0xE0, 0xF0, 0x39, 0xE0, 0xF0, 0x3C, 0x0E, 0x78, 0x3C, 0x0F,
  0x03, 0x9E, 0x0F, 0x03, 0xC0, 0xE7, 0x87, 0xC1, 0xE0, 0x79, 0xC1, 0xE0,
  0x78, 0x1E, 0xF0, 0x78, 0x1E, 0x07, 0x3C, 0x1E, 0x07, 0x81, 0xCF, 0x07,
  0x83, 0xE0, 0xF3, 0xC1, 0xE0, 0xF0, 0x38, 0xF0, 0x78, 0x3C, 0x0E, 0x3C,
  0x1E, 0x1F, 0x07, 0x0F, 0x07, 0xCF, 0xE3, 0xC3, 0xC1, 0xFF, 0x7F, 0xE0,
  0xF0, 0x3F, 0x9F, 0xF0, 0x1C, 0x07, 0xC3, 0xF8, 0x07, 0x80, 0x40, 0x10,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x30, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xCF,
  0x80, 0x01, 0xF1, 0xF0, 0x00, 0x7E, 0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x03,
  0xF0, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x03, 0xF0, 0x7C,
  0x00, 0x7C, 0x0F, 0xC0, 0x1F, 0x81, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0x07, 0xE0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x3F, 0x00,
  0x1F, 0x8F, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x3E, 0x7E, 0x00, 0x07, 0xCF,
  0xC0, 0x00, 0xFB, 0xF0, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0xE0, 0x07, 0xFF,
  0xF8, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x07, 0xC0,
  0x7F, 0x07, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x1F, 0x0F, 0xC0,
  0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0x80, 0x3F, 0x0F, 0x80, 0x7E, 0x1F, 0x80,
  0xFE, 0x1F, 0x83, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xF8, 0x3F, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x3F, 0x00,
  0xFC, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x7E, 0x00, 0xFC, 0x7E, 0x00,
  0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7C, 0x01, 0xF8, 0x7C, 0x03,
  0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0x80, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x3F, 0x83, 0xF8, 0x3F,
  0x00, 0xFC, 0x1F, 0x80, 0x3E, 0x1F, 0x80, 0x1F, 0x8F, 0x80, 0x0F, 0xCF,
  0xC0, 0x07, 0xE7, 0xE0, 0x03, 0xF3, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0xF8, 0xFC, 0x00, 0x7C, 0x7E, 0x00,
  0x7E, 0x1F, 0x00, 0x3F, 0x0F, 0x80, 0x3F, 0x07, 0xE0, 0x1F, 0x83, 0xF8,
  0x1F, 0x80, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x03,
  0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xF0,
  0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x3E, 0x07,
  0xF0, 0x1F, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x1F, 0x07, 0xE0,
  0x0F, 0x83, 0xF0, 0x07, 0xC1, 0xF0, 0x03, 0xF0, 0xF8, 0x01, 0xF8, 0xFC,
  0x00, 0xFC, 0x7E, 0x00, 0x7C, 0x3F, 0x00, 0x3E, 0x1F, 0x80, 0x3F, 0x0F,
  0x80, 0x1F, 0x8F, 0xC0, 0x0F, 0xC7, 0xE0, 0x07, 0xE3, 0xF0, 0x03, 0xF1,
  0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF8, 0x7C, 0x00, 0xFC, 0x7E, 0x00, 0x7E,
  0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x3F, 0x07, 0xC0, 0x3F,
  0x83, 0xE0, 0x7F, 0x83, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07,
  0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFF, 0x00,
  0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x3F, 0x81, 0xF8, 0x3F, 0x00, 0x7C,
  0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x1F, 0x8F, 0x80, 0x0F, 0xCF, 0xC0, 0x07,
  0xE7, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x03, 0xFF, 0x9F, 0x81,
  0xFF, 0xCF, 0x81, 0xFF, 0xE7, 0xC0, 0xFF, 0xE7, 0xE0, 0x7F, 0xF3, 0xF0,
  0x01, 0xF9, 0xF8, 0x00, 0xFC, 0xFC, 0x00, 0x7E, 0x3E, 0x00, 0x3F, 0x1F,
  0x00, 0x1F, 0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0xC1, 0xF8, 0x1F, 0xE0,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xE0,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0x81,
  0xF8, 0x00, 0x7C, 0x0F, 0xC0, 0x07, 0xE0, 0x7E, 0x00, 0x3F, 0x03, 0xE0,
  0x01, 0xF8, 0x1F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7C, 0x0F, 0xC0, 0x03,
  0xE0, 0x7E, 0x00, 0x3F, 0x03, 0xF0, 0x01, 0xF8, 0x1F, 0x00, 0x0F, 0xC0,
  0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xE0, 0x7E, 0x00, 0x1F, 0x03, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xC0,
  0xF8, 0x00, 0x7E, 0x07, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x03, 0xF0,
  0x00, 0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0xFC, 0x00, 0x7E, 0x07, 0xC0, 0x03,
  0xF0, 0x3E, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xF8, 0x1F, 0x80, 0x07, 0xC0,
  0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xF0, 0x3E, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x3E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0x7C, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0xF8, 0x1F, 0x81, 0xF8, 0x1F,
  0x81, 0xF8, 0x1F, 0x01, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3E,
  0x03, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0x7C, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xE0, 0xFC, 0x07,
  0xE0, 0x7C, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0x7E, 0x1F, 0xC0, 0x7F, 0xFF,
  0x80, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xE0, 0x07, 0xF0, 0x7E, 0x00, 0xFE, 0x07, 0xE0, 0x1F, 0xC0,
  0x7E, 0x03, 0xF8, 0x07, 0xE0, 0x3F, 0x80, 0x7C, 0x07, 0xF0, 0x07, 0xC0,
  0xFE, 0x00, 0xFC, 0x1F, 0xC0, 0x0F, 0xC3, 0xF8, 0x00, 0xFC, 0x3F, 0x00,
  0x0F, 0xC7, 0xF0, 0x00, 0xF8, 0xFE, 0x00, 0x0F, 0x9F, 0xC0, 0x01, 0xFB,
  0xF8, 0x00, 0x1F, 0xBF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0x80, 0x03, 0xFD, 0xF8, 0x00, 0x3F, 0x8F, 0xC0, 0x03, 0xF0, 0xFC,
  0x00, 0x7E, 0x0F, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x07,
  0xE0, 0x3F, 0x00, 0x7C, 0x03, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x01,
  0xF8, 0x0F, 0xC0, 0x1F, 0x80, 0xFC, 0x01, 0xFC, 0x0F, 0xC0, 0x0F, 0xC0,
  0xF8, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFB, 0xFF, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x03,
  0xFC, 0x1F, 0xE0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x1F, 0xF0, 0x7F, 0x80,
  0x03, 0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x1F, 0xF0, 0x7F,
  0xE0, 0x03, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x1F, 0xF8,
  0x3F, 0xF0, 0x07, 0xFF, 0x07, 0xDE, 0x00, 0xFF, 0xC0, 0xFB, 0xC0, 0x3E,
  0xF8, 0x3F, 0x78, 0x07, 0xDF, 0x07, 0xEF, 0x01, 0xF3, 0xE0, 0xF9, 0xF0,
  0x3E, 0xFC, 0x1F, 0x3E, 0x0F, 0x9F, 0x83, 0xE7, 0xC1, 0xF3, 0xE0, 0xFC,
  0xF8, 0x3C, 0x7C, 0x1F, 0x8F, 0x0F, 0x9F, 0x83, 0xF1, 0xE1, 0xE3, 0xF0,
  0x7E, 0x3C, 0x7C, 0x7E, 0x0F, 0x87, 0x8F, 0x8F, 0x81, 0xF0, 0xF3, 0xE1,
  0xF0, 0x7E, 0x1F, 0x7C, 0x7E, 0x0F, 0xC3, 0xFF, 0x0F, 0xC1, 0xF8, 0x7F,
  0xE1, 0xF8, 0x3F, 0x07, 0xF8, 0x3F, 0x07, 0xC0, 0xFF, 0x07, 0xC0, 0xF8,
  0x1F, 0xC0, 0xF8, 0x3F, 0x03, 0xF8, 0x3F, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x1F, 0x81, 0xF0, 0x1F, 0x83, 0xE0, 0x3E, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x01, 0xF8, 0x3F, 0x80, 0x0F, 0x81, 0xFC, 0x00,
  0x7C, 0x0F, 0xE0, 0x07, 0xE0, 0x7F, 0x80, 0x3F, 0x03, 0xFC, 0x01, 0xF8,
  0x1F, 0xE0, 0x0F, 0xC1, 0xFF, 0x00, 0x7C, 0x0F, 0xFC, 0x03, 0xE0, 0x7F,
  0xE0, 0x3F, 0x03, 0xFF, 0x01, 0xF8, 0x1F, 0x7C, 0x0F, 0xC0, 0xFB, 0xE0,
  0x7C, 0x0F, 0xCF, 0x03, 0xE0, 0x7E, 0x7C, 0x3F, 0x03, 0xF3, 0xE1, 0xF8,
  0x1F, 0x8F, 0x0F, 0xC0, 0xF8, 0x78, 0x7E, 0x0F, 0xC3, 0xE3, 0xE0, 0x7E,
  0x0F, 0x1F, 0x03, 0xF0, 0x79, 0xF8, 0x1F, 0x83, 0xEF, 0xC0, 0xFC, 0x1F,
  0x7E, 0x07, 0xC0, 0x7B, 0xF0, 0x7E, 0x03, 0xDF, 0x03, 0xF0, 0x1F, 0xF8,
  0x1F, 0x80, 0x7F, 0xC0, 0xFC, 0x03, 0xFE, 0x07, 0xC0, 0x1F, 0xF0, 0x3E,
  0x00, 0xFF, 0x83, 0xF0, 0x03, 0xF8, 0x1F, 0x80, 0x1F, 0xC0, 0xFC, 0x00,
  0xFE, 0x07, 0xE0, 0x03, 0xF0, 0x3E, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF0, 0x3F, 0x83, 0xF8, 0x3F, 0x80, 0xFC, 0x1F, 0x80, 0x3F, 0x1F, 0x80,
  0x1F, 0x8F, 0xC0, 0x07, 0xCF, 0xC0, 0x03, 0xE7, 0xE0, 0x01, 0xF3, 0xF0,
  0x00, 0xF9, 0xF0, 0x00, 0x7D, 0xF8, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0x7E,
  0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xDF, 0x80, 0x07, 0xCF, 0x80, 0x03, 0xE7,
  0xC0, 0x01, 0xF7, 0xE0, 0x01, 0xFB, 0xF0, 0x00, 0xFD, 0xF8, 0x00, 0x7E,
  0xFC, 0x00, 0x3E, 0x3E, 0x00, 0x3F, 0x1F, 0x00, 0x1F, 0x0F, 0xC0, 0x1F,
  0x87, 0xE0, 0x1F, 0x81, 0xF8, 0x1F, 0xC0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0x01, 0xF0, 0x0F, 0xE0, 0x7C, 0x01, 0xF8, 0x3F, 0x00,
  0x3E, 0x0F, 0xC0, 0x0F, 0x83, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x3E,
  0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x87, 0xE0, 0x07, 0xE1, 0xF8, 0x01, 0xF8,
  0x7E, 0x00, 0xFC, 0x1F, 0x80, 0xFF, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x3F, 0x83, 0xF8,
  0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x1F, 0x8F, 0x80, 0x0F,
  0xCF, 0xC0, 0x03, 0xE7, 0xE0, 0x01, 0xF3, 0xE0, 0x00, 0xF9, 0xF0, 0x00,
  0xFD, 0xF8, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xBF, 0x00,
  0x0F, 0xDF, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xEF, 0xC0, 0x03, 0xF7, 0xE0,
  0x01, 0xFB, 0xF0, 0x00, 0xFD, 0xF8, 0x00, 0x7C, 0xFC, 0x00, 0x7E, 0x7E,
  0x00, 0x3F, 0x1F, 0x00, 0x1F, 0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x1F, 0x83,
  0xF8, 0x1F, 0xC0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0,
  0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x40, 0x00, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x3E, 0x03, 0xF8, 0x1F, 0x00, 0xFC,
  0x1F, 0x80, 0x3E, 0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0xC3, 0xF0, 0x07,
  0xE1, 0xF0, 0x03, 0xE0, 0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x7E, 0x00,
  0xFC, 0x3F, 0x00, 0xFC, 0x1F, 0x81, 0xFE, 0x0F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFE, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFC,
  0x3F, 0x00, 0x7C, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x1F,
  0x81, 0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xC0, 0x3F, 0x03, 0xE0, 0x1F, 0x83,
  0xF0, 0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0xFC,
  0x3E, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0xF8, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xF0, 0x7E, 0x0F, 0xE0,
  0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0x80, 0x1F, 0x0F, 0x80,
  0x1F, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0xF8, 0xFC, 0x00, 0xF8, 0xFC, 0x00,
  0xF8, 0xFC, 0x01, 0xF8, 0x7E, 0x03, 0xF8, 0x7F, 0x07, 0xF0, 0x3F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x01, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x1F,
  0x80, 0x1F, 0x87, 0xE0, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x7E,
  0x1F, 0x00, 0x1F, 0x07, 0xC0, 0x07, 0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x00,
  0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC3, 0xE0, 0x03, 0xE0, 0xF8,
  0x00, 0xF8, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x87, 0xE0, 0x07, 0xE1,
  0xF8, 0x01, 0xF8, 0x7C, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x0F, 0xC0, 0x0F,
  0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x3E, 0x0F, 0xC0,
  0x1F, 0x83, 0xF0, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x1F, 0x81, 0xFC, 0x07,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xEF, 0xC0,
  0x03, 0xFB, 0xF0, 0x00, 0xFC, 0x7C, 0x00, 0x7F, 0x1F, 0x80, 0x1F, 0x87,
  0xE0, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x7F,
  0x07, 0xE0, 0x1F, 0x80, 0xF8, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x0F, 0x80,
  0xFC, 0x03, 0xE0, 0x7E, 0x00, 0xF8, 0x1F, 0x80, 0x3F, 0x07, 0xC0, 0x0F,
  0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0x7C, 0x7E, 0x00, 0x1F, 0x1F, 0x80,
  0x07, 0xC7, 0xC0, 0x01, 0xF3, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x7E,
  0x00, 0x07, 0xDF, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x03,
  0xE0, 0x1F, 0xFC, 0x03, 0xF0, 0x0F, 0xFE, 0x01, 0xF8, 0x07, 0xDF, 0x00,
  0xFC, 0x07, 0xEF, 0x80, 0xFE, 0x03, 0xF7, 0xC0, 0x7F, 0x01, 0xF3, 0xE0,
  0x3F, 0x81, 0xF9, 0xF0, 0x3F, 0xC0, 0xFC, 0xF8, 0x1F, 0xE0, 0x7C, 0x7C,
  0x0F, 0xF0, 0x7E, 0x3E, 0x0F, 0xF8, 0x3F, 0x1F, 0x07, 0xBC, 0x1F, 0x0F,
  0x87, 0xDE, 0x1F, 0x87, 0xC3, 0xEF, 0x0F, 0xC3, 0xE1, 0xE7, 0x87, 0xC1,
  0xF1, 0xF3, 0xC7, 0xE0, 0xF8, 0xF9, 0xE3, 0xF0, 0x7C, 0x78, 0xF1, 0xF0,
  0x3E, 0x7C, 0x78, 0xF8, 0x1F, 0x3E, 0x3C, 0xF8, 0x0F, 0x9E, 0x1E, 0x7C,
  0x07, 0xDF, 0x0F, 0x3E, 0x03, 0xEF, 0x87, 0xFE, 0x01, 0xF7, 0x83, 0xFF,
  0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x7F, 0xC0, 0xFF, 0x80, 0x3F, 0xE0, 0x7F,
  0xC0, 0x1F, 0xF0, 0x3F, 0xE0, 0x0F, 0xF0, 0x1F, 0xE0, 0x07, 0xF8, 0x07,
  0xF0, 0x03, 0xFC, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0xFE, 0x00,
  0xFC, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xF0, 0x03, 0xF8, 0x1F, 0x80, 0x1F, 0xC0, 0xFE, 0x01, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x1F, 0x80, 0xFE, 0x00, 0xFC, 0x07, 0xE0, 0x03, 0xF0, 0x7E,
  0x00, 0x1F, 0x87, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF3, 0xF0, 0x00,
  0x1F, 0x9F, 0x80, 0x00, 0xFD, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0x3E, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xFC, 0x7E,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0xE0, 0x7E, 0x00,
  0x7E, 0x03, 0xF0, 0x07, 0xF0, 0x0F, 0xC0, 0x7F, 0x00, 0x7E, 0x03, 0xF0,
  0x03, 0xF0, 0x3F, 0x80, 0x1F, 0xC0, 0xFC, 0x00, 0x3F, 0x3E, 0x00, 0x3F,
  0x9F, 0x80, 0x1F, 0x8F, 0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0xC1, 0xF0, 0x0F,
  0xC0, 0xF8, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x0F, 0x83,
  0xF0, 0x07, 0xC3, 0xF0, 0x03, 0xE1, 0xF8, 0x01, 0xF9, 0xF8, 0x00, 0x7C,
  0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01,
  0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7F, 0xC0, 0x7F,
  0x80, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x80, 0xFC, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0xC1, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3F, 0x07, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xFC, 0x1F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7E, 0x07, 0xC0,
  0x00, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8,
  0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x80, 0xFF, 0x80,
  0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x7F, 0x01,
  0xEF, 0x03, 0xDE, 0x0F, 0xBC, 0x1E, 0x78, 0x7C, 0xF0, 0xF1, 0xE3, 0xE3,
  0xE7, 0x83, 0xDF, 0x07, 0xBC, 0x0F, 0xF8, 0x1E, 0x7F, 0xFF, 0xEF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0x3F, 0x0F, 0x87,
  0xE1, 0xF0, 0x7C, 0x1E, 0x00, 0x7E, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0,
  0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xF8, 0x3E, 0x1F, 0x03, 0xE3, 0xF0, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x01, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0xFF,
  0xE3, 0xFF, 0xFC, 0x7F, 0x07, 0xC7, 0xE0, 0x7C, 0xFC, 0x0F, 0xCF, 0xC0,
  0xFC, 0xF8, 0x0F, 0xCF, 0xC0, 0xF8, 0xFC, 0x1F, 0x8F, 0xFF, 0xF8, 0x7F,
  0xFF, 0x87, 0xFF, 0xF8, 0x3F, 0xEF, 0x80, 0xF8, 0xF8, 0x01, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF3, 0xF0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xE1, 0xF8, 0x3E, 0x03, 0xF1, 0xF8,
  0x0F, 0xC7, 0xE0, 0x3F, 0x1F, 0x80, 0xFC, 0x7C, 0x03, 0xF1, 0xF0, 0x0F,
  0xC7, 0xC0, 0x3E, 0x3F, 0x00, 0xF8, 0xFC, 0x03, 0xE3, 0xE0, 0x0F, 0x8F,
  0x80, 0x7E, 0x3E, 0x01, 0xF8, 0xF8, 0x07, 0xC7, 0xE0, 0x3F, 0x1F, 0xC1,
  0xFC, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x07, 0xDF, 0xFC, 0x3F, 0x3F, 0xE0,
  0xF8, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF,
  0xFE, 0x1F, 0xFF, 0xE1, 0xF8, 0x3E, 0x3F, 0x03, 0xF3, 0xE0, 0x1F, 0x3E,
  0x01, 0xF7, 0xE0, 0x1F, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x7C,
  0x7C, 0x07, 0xC7, 0xC0, 0xFC, 0x7E, 0x1F, 0x87, 0xFF, 0xF8, 0x3F, 0xFF,
  0x01, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0xFC, 0x03, 0xFC, 0xF8, 0x0F,
  0xFE, 0xF8, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x3F, 0x83, 0xF8, 0x3F,
  0x01, 0xF8, 0x3E, 0x01, 0xF0, 0x7E, 0x01, 0xF0, 0x7E, 0x01, 0xF0, 0x7C,
  0x03, 0xF0, 0x7C, 0x03, 0xF0, 0x7C, 0x03, 0xF0, 0x7C, 0x03, 0xE0, 0xFC,
  0x03, 0xE0, 0xFC, 0x03, 0xE0, 0xFC, 0x07, 0xE0, 0xFC, 0x07, 0xE0, 0xFC,
  0x07, 0xE0, 0xFC, 0x07, 0xC0, 0x7E, 0x0F, 0xC0, 0x7F, 0xFF, 0xC0, 0x7F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x0F, 0xCF, 0x80, 0x00,
  0x7E, 0x00, 0x1F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE1,
  0xF8, 0x3E, 0x3F, 0x01, 0xF3, 0xE0, 0x1F, 0x3E, 0x01, 0xF7, 0xE0, 0x1F,
  0x7E, 0x01, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x10, 0x7E, 0x07, 0x87, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F,
  0xFE, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F,
  0xE0, 0x3F, 0xF0, 0x1F, 0xC0, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x07, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xE0,
  0xFF, 0xF0, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0,
  0x00, 0x00, 0xFC, 0x3E, 0x03, 0xFE, 0x7C, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xE0, 0xFF, 0xFF, 0xC1, 0xF8, 0x3F, 0x87, 0xE0, 0x3F, 0x0F, 0x80, 0x7E,
  0x3F, 0x00, 0xFC, 0x7E, 0x01, 0xF0, 0xF8, 0x03, 0xE1, 0xF0, 0x07, 0xC3,
  0xE0, 0x1F, 0x87, 0xC0, 0x3F, 0x1F, 0x80, 0x7E, 0x3F, 0x00, 0xF8, 0x7E,
  0x01, 0xF0, 0xFC, 0x03, 0xE1, 0xF8, 0x0F, 0xC1, 0xF0, 0x1F, 0x83, 0xF0,
  0x7F, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xE0, 0x07, 0xCF, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC,
  0x04, 0x01, 0xF8, 0x1C, 0x07, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x00,
  0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x9F, 0x80, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0xFF,
  0xC1, 0xFF, 0xFF, 0x0F, 0xC1, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x7E, 0x3F,
  0x03, 0xF1, 0xF0, 0x1F, 0x8F, 0x80, 0xFC, 0x7C, 0x07, 0xE7, 0xE0, 0x3E,
  0x3F, 0x01, 0xF1, 0xF8, 0x0F, 0x8F, 0x80, 0xFC, 0x7C, 0x07, 0xE3, 0xE0,
  0x3F, 0x3F, 0x01, 0xF1, 0xF8, 0x0F, 0x8F, 0xC0, 0x7C, 0x7C, 0x07, 0xE3,
  0xE0, 0x3F, 0x1F, 0x01, 0xF1, 0xF8, 0x0F, 0x8F, 0xC0, 0x7C, 0x00, 0x03,
  0xC0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x07, 0xC0, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x03, 0xE0,
  0x7C, 0x1F, 0x83, 0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x0F, 0xC1, 0xF8,
  0x3E, 0x07, 0xC0, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x03, 0xE0, 0x7C,
  0x00, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x0F, 0xC0, 0x7F, 0xE0, 0x3F, 0xE0, 0x1F, 0xE0, 0x0F, 0xE0,
  0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x07, 0xF0, 0xFC, 0x1F, 0xC1, 0xF8, 0x7F, 0x03, 0xF0, 0xFC, 0x07, 0xC3,
  0xF0, 0x0F, 0x8F, 0xE0, 0x1F, 0x3F, 0x80, 0x7E, 0xFE, 0x00, 0xFD, 0xF8,
  0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFE, 0xF8, 0x01, 0xF9, 0xF8, 0x03,
  0xE1, 0xF0, 0x07, 0xC3, 0xE0, 0x1F, 0x87, 0xE0, 0x3F, 0x07, 0xC0, 0x7C,
  0x0F, 0xC0, 0xF8, 0x1F, 0x81, 0xF0, 0x1F, 0x07, 0xE0, 0x3F, 0x0F, 0xC0,
  0x7E, 0x00, 0x03, 0xE0, 0x7C, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0x81, 0xF0,
  0x3E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xC0, 0xF8, 0x1F, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xE0, 0x7C, 0x0F, 0x83, 0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC1, 0xF8, 0x3F, 0x07, 0xC0, 0xF8, 0x1F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xE0, 0x7C, 0x0F, 0x80, 0x07, 0xCF, 0xC0, 0xFC, 0x07, 0xFF, 0xF1,
  0xFF, 0x03, 0xFF, 0xFD, 0xFF, 0xC1, 0xFF, 0xFE, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xF8, 0x7E, 0x0F, 0xF0, 0xFC, 0x3E, 0x07, 0xF0, 0x7E, 0x3F, 0x03,
  0xF0, 0x1F, 0x1F, 0x81, 0xF8, 0x0F, 0x8F, 0xC0, 0xFC, 0x07, 0xC7, 0xC0,
  0x7E, 0x07, 0xE3, 0xE0, 0x3E, 0x03, 0xF1, 0xF0, 0x1F, 0x01, 0xF9, 0xF8,
  0x0F, 0x80, 0xF8, 0xFC, 0x0F, 0xC0, 0x7C, 0x7E, 0x07, 0xE0, 0x3E, 0x3E,
  0x03, 0xF0, 0x3F, 0x1F, 0x01, 0xF0, 0x1F, 0x8F, 0x80, 0xF8, 0x0F, 0xCF,
  0xC0, 0x7C, 0x07, 0xC7, 0xE0, 0x7E, 0x03, 0xE3, 0xE0, 0x3F, 0x01, 0xF1,
  0xF0, 0x1F, 0x81, 0xF8, 0xF8, 0x0F, 0x80, 0xFC, 0xFC, 0x07, 0xC0, 0x7E,
  0x7E, 0x03, 0xE0, 0x3E, 0x00, 0x07, 0xCF, 0xC0, 0x7E, 0xFF, 0x03, 0xFF,
  0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x87, 0xE0, 0xFC, 0x7E, 0x07, 0xE3,
  0xF0, 0x3F, 0x1F, 0x81, 0xF8, 0xF8, 0x0F, 0xC7, 0xC0, 0x7E, 0x3E, 0x03,
  0xF3, 0xF0, 0x1F, 0x1F, 0x80, 0xF8, 0xFC, 0x07, 0xC7, 0xC0, 0x7E, 0x3E,
  0x03, 0xF1, 0xF0, 0x1F, 0x9F, 0x80, 0xF8, 0xFC, 0x07, 0xC7, 0xE0, 0x3E,
  0x3E, 0x03, 0xF1, 0xF0, 0x1F, 0x8F, 0x80, 0xFC, 0xFC, 0x07, 0xC7, 0xE0,
  0x3E, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xF0, 0x1F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x0F, 0xC1, 0xF8, 0xFC, 0x07, 0xC7, 0xE0, 0x3F, 0x3E,
  0x01, 0xFB, 0xF0, 0x0F, 0xDF, 0x80, 0x7E, 0xF8, 0x03, 0xF7, 0xC0, 0x1F,
  0xBE, 0x00, 0xFF, 0xF0, 0x07, 0xDF, 0x80, 0x3E, 0xFC, 0x01, 0xF3, 0xE0,
  0x1F, 0x9F, 0x00, 0xF8, 0xF8, 0x0F, 0xC7, 0xE0, 0xFC, 0x1F, 0xFF, 0xE0,
  0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xF3, 0xF0, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x03,
  0xFF, 0xFE, 0x03, 0xF0, 0x7E, 0x03, 0xE0, 0x3F, 0x07, 0xE0, 0x3F, 0x07,
  0xE0, 0x3F, 0x07, 0xE0, 0x3F, 0x07, 0xC0, 0x3F, 0x07, 0xC0, 0x3F, 0x07,
  0xC0, 0x3E, 0x0F, 0xC0, 0x3E, 0x0F, 0xC0, 0x3E, 0x0F, 0x80, 0x3E, 0x0F,
  0x80, 0x7E, 0x0F, 0x80, 0x7E, 0x0F, 0x80, 0x7C, 0x1F, 0x80, 0xFC, 0x1F,
  0xC1, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x1F, 0x7F, 0xF0, 0x3F,
  0x3F, 0xE0, 0x3F, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF8, 0x7C, 0x0F, 0xFB, 0xF0, 0xFF, 0xEF, 0x83, 0xFF, 0xFE, 0x1F, 0xFF,
  0xF8, 0xFE, 0x0F, 0xE3, 0xF0, 0x1F, 0x8F, 0x80, 0x7C, 0x7E, 0x01, 0xF1,
  0xF8, 0x07, 0xC7, 0xC0, 0x3F, 0x1F, 0x00, 0xFC, 0x7C, 0x03, 0xF1, 0xF0,
  0x0F, 0x8F, 0xC0, 0x3E, 0x3F, 0x00, 0xF8, 0xFC, 0x07, 0xE3, 0xF0, 0x1F,
  0x8F, 0xC0, 0x7E, 0x3F, 0x01, 0xF0, 0x7E, 0x0F, 0xC1, 0xFF, 0xFF, 0x07,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x3F, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x07, 0xCF, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF,
  0x0F, 0xFE, 0x0F, 0xE0, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x1F,
  0xFE, 0x07, 0xFF, 0xE1, 0xFE, 0xFE, 0x3E, 0x0F, 0xCF, 0xC0, 0xF9, 0xF8,
  0x1F, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF8, 0x00, 0xFF,
  0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0x80, 0x01,
  0xF3, 0xE0, 0x3E, 0x7C, 0x07, 0xCF, 0xC1, 0xF9, 0xFC, 0xFF, 0x1F, 0xFF,
  0xC1, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0xFE, 0x00, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0x87, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xFF, 0x07, 0xF8, 0x3F, 0xC0, 0xFE, 0x03, 0xF0,
  0x1F, 0x01, 0xF1, 0xF8, 0x0F, 0x8F, 0xC0, 0x7C, 0x7C, 0x07, 0xE3, 0xE0,
  0x3F, 0x1F, 0x01, 0xF8, 0xF8, 0x0F, 0x8F, 0xC0, 0x7C, 0x7E, 0x03, 0xE3,
  0xE0, 0x3F, 0x1F, 0x01, 0xF8, 0xF8, 0x0F, 0xCF, 0xC0, 0x7C, 0x7E, 0x03,
  0xE3, 0xF0, 0x3F, 0x1F, 0x01, 0xF8, 0xF8, 0x0F, 0xC7, 0xC0, 0x7C, 0x3E,
  0x03, 0xE1, 0xF0, 0x3F, 0x0F, 0xC3, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE,
  0x0F, 0xFF, 0xE0, 0x3F, 0xDF, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x07, 0xFF,
  0x00, 0xFB, 0xE0, 0x3F, 0x7C, 0x07, 0xCF, 0x81, 0xF9, 0xF8, 0x3F, 0x3F,
  0x07, 0xC3, 0xE1, 0xF8, 0x7C, 0x3E, 0x0F, 0x87, 0xC1, 0xF1, 0xF0, 0x3E,
  0x3E, 0x07, 0xCF, 0xC0, 0xF9, 0xF0, 0x1F, 0x3E, 0x01, 0xEF, 0x80, 0x3D,
  0xF0, 0x07, 0xBC, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8,
  0x0F, 0x01, 0xF7, 0xC0, 0xF8, 0x0F, 0xBE, 0x07, 0xC0, 0xFD, 0xF0, 0x3E,
  0x07, 0xCF, 0x83, 0xF0, 0x3E, 0x7C, 0x1F, 0xC3, 0xE3, 0xE1, 0xFE, 0x1F,
  0x1F, 0x0F, 0xF1, 0xF8, 0xF8, 0x7F, 0x8F, 0x87, 0xC7, 0xFC, 0x7C, 0x3E,
  0x3D, 0xE7, 0xC0, 0xF3, 0xEF, 0x3E, 0x07, 0x9E, 0x79, 0xF0, 0x3D, 0xF3,
  0xDF, 0x01, 0xEF, 0x1E, 0xF8, 0x0F, 0x78, 0xF7, 0xC0, 0x7F, 0xC7, 0xFC,
  0x03, 0xFC, 0x3F, 0xE0, 0x1F, 0xE1, 0xFE, 0x00, 0xFE, 0x0F, 0xF0, 0x07,
  0xF0, 0x3F, 0x80, 0x3F, 0x81, 0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0,
  0x7C, 0x00, 0x7C, 0x03, 0xE0, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x0F, 0xC0,
  0x7E, 0x0F, 0x81, 0xF8, 0x1F, 0x07, 0xE0, 0x3F, 0x0F, 0xC0, 0x3E, 0x3F,
  0x00, 0x7C, 0x7C, 0x00, 0xF9, 0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0,
  0x03, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x0F,
  0xFE, 0x00, 0x3F, 0x7C, 0x00, 0x7E, 0x7C, 0x01, 0xF8, 0xF8, 0x07, 0xE1,
  0xF0, 0x0F, 0xC3, 0xF0, 0x3F, 0x03, 0xE0, 0x7E, 0x07, 0xC1, 0xF8, 0x0F,
  0xC0, 0x07, 0xC0, 0x3F, 0x07, 0xC0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7C, 0x07, 0xE0, 0xFC, 0x07, 0xE0, 0xFC, 0x07, 0xE1, 0xF8, 0x03, 0xE1,
  0xF8, 0x03, 0xE1, 0xF0, 0x03, 0xE3, 0xF0, 0x03, 0xE3, 0xE0, 0x03, 0xE7,
  0xE0, 0x03, 0xE7, 0xC0, 0x03, 0xEF, 0xC0, 0x03, 0xEF, 0x80, 0x03, 0xEF,
  0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFF,
  0xFF, 0x87, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF,
  0x00, 0x00, 0x06, 0x00, 0x1C, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x7E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x7E, 0x00, 0xFC, 0x01,
  0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0xF8, 0x00, 0xF0, 0x00, 0x40, 0x00, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x70, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x70,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0E, 0x07, 0x81, 0xE0, 0x78, 0x1E,
  0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x00, 0x01, 0x80,
  0x03, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x7E, 0x01, 0xFC, 0x07,
  0xE0, 0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x1E, 0x00,
  0x10, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0xC0, 0x3C, 0xFF, 0xC0, 0x79,
  0xFF, 0xC1, 0xF7, 0xFF, 0xC3, 0xCF, 0x8F, 0xFF, 0xBE, 0x0F, 0xFE, 0x7C,
  0x0F, 0xFC, 0xF0, 0x0F, 0xF0, 0x00, 0x0F, 0x80,
};

const GFXglyph RobotoCondensed_MediumItalic49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 12, 35, 12, 1, -35 },
  { 54, 13, 13, 15, 4, -37 },
  { 76, 24, 35, 26, 2, -35 },
  { 181, 21, 45, 24, 2, -40 },
  { 300, 23, 35, 30, 4, -35 },
  { 401, 24, 36, 27, 1, -35 },
  { 509, 7, 12, 8, 3, -37 },
  { 520, 15, 50, 15, 2, -39 },
  { 614, 15, 50, 15, -2, -39 },
  { 708, 20, 21, 21, 2, -35 },
  { 761, 20, 25, 23, 2, -29 },
  { 824, 10, 14, 11, -3, -6 },
  { 842, 11, 5, 15, 2, -18 },
  { 849, 7, 7, 13, 1, -7 },
  { 856, 22, 38, 17, -3, -35 },
  { 961, 21, 35, 24, 2, -35 },
  { 1053, 13, 35, 24, 6, -35 },
  { 1110, 23, 35, 24, 0, -35 },
  { 1211, 22, 35, 24, 1, -35 },
  { 1308, 23, 35, 24, 0, -35 },
  { 1409, 22, 35, 24, 2, -35 },
  { 1506, 19, 35, 24, 2, -35 },
  { 1590, 22, 35, 24, 3, -35 },
  { 1687, 22, 35, 24, 1, -35 },
  { 1784, 19, 35, 24, 3, -35 },
  { 1868, 10, 27, 12, 1, -27 },
  { 1902, 13, 35, 11, -2, -27 },
  { 1959, 19, 22, 21, 1, -26 },
  { 2012, 20, 16, 23, 2, -24 },
  { 2052, 19, 22, 22, 1, -26 },
  { 2105, 17, 35, 21, 4, -35 },
  { 2180, 34, 45, 36, 1, -34 },
  { 2372, 27, 35, 28, -2, -35 },
  { 2491, 24, 35, 26, 1, -35 },
  { 2596, 25, 35, 27, 2, -35 },
  { 2706, 25, 35, 27, 1, -35 },
  { 2816, 24, 35, 23, 1, -35 },
  { 2921, 24, 35, 23, 1, -35 },
  { 3026, 25, 35, 28, 2, -35 },
  { 3136, 29, 35, 29, 1, -35 },
  { 3263, 12, 35, 12, 1, -35 },
  { 3316, 24, 35, 23, 0, -35 },
  { 3421, 28, 35, 26, 1, -35 },
  { 3544, 19, 35, 23, 1, -35 },
  { 3628, 35, 35, 36, 1, -35 },
  { 3782, 29, 35, 29, 1, -35 },
  { 3909, 25, 35, 29, 2, -35 },
  { 4019, 26, 35, 27, 1, -35 },
  { 4133, 25, 41, 29, 2, -35 },
  { 4262, 25, 35, 26, 1, -35 },
  { 4372, 24, 35, 25, 1, -35 },
  { 4477, 24, 35, 25, 4, -35 },
  { 4582, 26, 35, 27, 2, -35 },
  { 4696, 26, 35, 27, 4, -35 },
  { 4810, 33, 35, 36, 5, -35 },
  { 4955, 29, 35, 26, -1, -35 },
  { 5082, 25, 35, 25, 4, -35 },
  { 5192, 27, 35, 25, -1, -35 },
  { 5311, 16, 48, 12, -1, -40 },
  { 5407, 11, 38, 18, 4, -35 },
  { 5460, 16, 48, 12, -3, -40 },
  { 5556, 15, 17, 18, 2, -35 },
  { 5588, 19, 5, 19, -3, 0 },
  { 5600, 9, 7, 15, 5, -37 },
  { 5608, 20, 26, 23, 1, -26 },
  { 5673, 22, 37, 24, 0, -37 },
  { 5775, 20, 26, 22, 1, -26 },
  { 5840, 24, 37, 24, 1, -37 },
  { 5951, 20, 26, 23, 1, -26 },
  { 6016, 17, 38, 15, 2, -38 },
  { 6097, 23, 36, 24, 0, -26 },
  { 6201, 21, 37, 23, 0, -37 },
  { 6299, 11, 36, 11, 1, -36 },
  { 6349, 17, 46, 11, -5, -36 },
  { 6447, 23, 37, 22, 0, -37 },
  { 6554, 11, 37, 11, 1, -37 },
  { 6605, 33, 26, 36, 0, -26 },
  { 6713, 21, 26, 23, 0, -26 },
  { 6782, 21, 26, 24, 1, -26 },
  { 6851, 24, 36, 24, -2, -26 },
  { 6959, 22, 36, 24, 1, -26 },
  { 7058, 16, 26, 15, 0, -26 },
  { 7110, 19, 26, 22, 1, -26 },
  { 7172, 13, 32, 14, 2, -32 },
  { 7224, 21, 26, 23, 2, -26 },
  { 7293, 19, 26, 21, 3, -26 },
  { 7355, 29, 26, 30, 3, -26 },
  { 7450, 23, 26, 21, -1, -26 },
  { 7525, 24, 36, 21, -2, -26 },
  { 7633, 22, 26, 21, -1, -26 },
  { 7705, 15, 47, 14, 1, -38 },
  { 7794, 10, 41, 12, 1, -35 },
  { 7846, 15, 47, 14, -2, -38 },
  { 7935, 23, 10, 27, 2, -19 },
};

const GFXfont RobotoCondensed_MediumItalic49pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_MediumItalic49pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_MediumItalic49pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _ROBOTOCONDENSED_MEDIUMITALIC49PT7B_H_
