#ifndef _ROBOTOCONDENSED_MEDIUMITALIC33PT7B_H_
#define _ROBOTOCONDENSED_MEDIUMITALIC33PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-MediumItalic.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_MediumItalic33pt7bBitmaps[] PROGMEM = {
  0x00, 0x0E, 0x3C, 0x78, 0xF1, 0xE3, 0x87, 0x1E, 0x3C, 0x78, 0xE1, 0xC3,
  0x8F, 0x1E, 0x38, 0x00, 0x00, 0x03, 0x0F, 0x1E, 0x38, 0x00, 0x77, 0x67,
  0xE7, 0xE7, 0xE6, 0xC6, 0xCE, 0xCE, 0x00, 0xE7, 0x00, 0xC7, 0x00, 0xC6,
  0x01, 0xCE, 0x01, 0x8E, 0x01, 0x8C, 0x1F, 0xFF, 0x1F, 0xFF, 0x3F, 0xFF,
  0x07, 0x38, 0x06, 0x38, 0x06, 0x30, 0x0E, 0x70, 0x0C, 0x70, 0xFF, 0xFC,
  0xFF, 0xFC, 0xFF, 0xFC, 0x18, 0xC0, 0x39, 0xC0, 0x39, 0xC0, 0x31, 0x80,
  0x73, 0x80, 0x73, 0x80, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x1F, 0x00,
  0x7F, 0x81, 0xFF, 0x07, 0xCF, 0x0F, 0x1E, 0x1C, 0x1C, 0x38, 0x38, 0x70,
  0x70, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xF0,
  0x00, 0xF3, 0xC1, 0xE7, 0x83, 0xCF, 0x07, 0x9E, 0x0F, 0x1E, 0x7C, 0x3F,
  0xF0, 0x3F, 0xC0, 0x3F, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x1E,
  0x00, 0xFE, 0x01, 0xDC, 0x07, 0x18, 0x6E, 0x31, 0xDC, 0x63, 0x38, 0xCE,
  0x73, 0xB8, 0xF7, 0x60, 0xFD, 0x80, 0xF7, 0x00, 0x1C, 0x00, 0x37, 0x80,
  0xFF, 0x83, 0xBB, 0x8E, 0xE3, 0x19, 0xC6, 0x73, 0x0D, 0xC6, 0x1B, 0x0C,
  0x70, 0x1D, 0xC0, 0x1F, 0x80, 0x1E, 0x00, 0x01, 0xE0, 0x07, 0xF0, 0x0F,
  0xF8, 0x0F, 0x38, 0x1E, 0x38, 0x1E, 0x38, 0x1C, 0x38, 0x1E, 0x78, 0x0F,
  0xF0, 0x0F, 0xE0, 0x0F, 0x80, 0x1F, 0x8E, 0x3F, 0x8E, 0x7B, 0xCE, 0xF3,
  0xCE, 0xF1, 0xFC, 0xF0, 0xFC, 0xF0, 0xF8, 0xF0, 0x78, 0xF8, 0xF8, 0x7F,
  0xFC, 0x7F, 0xFC, 0x1F, 0x1E, 0x33, 0x9C, 0xE7, 0x31, 0x9C, 0x00, 0x80,
  0x60, 0x38, 0x1C, 0x0F, 0x03, 0x81, 0xC0, 0x70, 0x38, 0x0E, 0x07, 0x81,
  0xC0, 0x70, 0x3C, 0x0F, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0x70, 0x1C, 0x03,
  0x80, 0x60, 0x10, 0x00, 0x02, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x18, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xE0, 0x38, 0x07, 0x00, 0xE0,
  0x3C, 0x07, 0x01, 0xE0, 0x38, 0x0F, 0x01, 0xC0, 0x70, 0x1C, 0x03, 0x00,
  0x40, 0x00, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x06, 0x31, 0xFF, 0xFF,
  0xFF, 0xE3, 0xF8, 0x0F, 0x00, 0xFC, 0x0E, 0xE0, 0xE3, 0x86, 0x1C, 0x10,
  0x40, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00,
  0x38, 0x1F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xC0, 0x07, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0x1C, 0x71, 0xCF,
  0x3C, 0xE7, 0xBC, 0x60, 0x7F, 0xFF, 0xFE, 0xFF, 0xF6, 0x00, 0x0E, 0x00,
  0x38, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x70,
  0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01,
  0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80,
  0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x03, 0xE0, 0x1F, 0xE0,
  0xFF, 0x87, 0x8F, 0x1C, 0x3C, 0xF0, 0x73, 0xC1, 0xCE, 0x07, 0x78, 0x1D,
  0xE0, 0xF7, 0x83, 0xDE, 0x0F, 0x78, 0x3D, 0xC0, 0xE7, 0x03, 0x9C, 0x1E,
  0x70, 0x79, 0xC1, 0xC7, 0x0F, 0x1E, 0x7C, 0x7F, 0xE0, 0xFF, 0x01, 0xF0,
  0x00, 0x01, 0x83, 0xCF, 0xFF, 0xEF, 0xF7, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x03, 0x83, 0xC1, 0xE0, 0xF0, 0x70, 0x38, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0x81, 0xC1, 0xE0, 0x01, 0xF0, 0x0F, 0xF8, 0x3F, 0xF8, 0x78, 0xF1, 0xE1,
  0xE3, 0x83, 0xCF, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF8, 0x03, 0xE0, 0x07, 0xFF, 0xDF, 0xFF, 0x3F, 0xFE, 0x00, 0x03,
  0xE0, 0x3F, 0xE1, 0xFF, 0x8F, 0x8F, 0x3C, 0x3C, 0xE0, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x03, 0xE0, 0x7F, 0x01, 0xF0, 0x07, 0xF0, 0x03, 0xC0,
  0x07, 0x80, 0x1E, 0xE0, 0x7B, 0x81, 0xEF, 0x0F, 0x3E, 0x7C, 0x7F, 0xE0,
  0xFF, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x80, 0x7F, 0x01, 0xDE, 0x07, 0xBC, 0x0E, 0x70, 0x38,
  0xE0, 0xF3, 0xC1, 0xC7, 0x87, 0x0F, 0x1E, 0x1E, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x00, 0x0E, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0xFF, 0xE1, 0xE3, 0xC0, 0x07,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0xF0, 0x79, 0xE0, 0xF1, 0xC1, 0xE3,
  0xC7, 0x87, 0xFE, 0x07, 0xF8, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x3F, 0x07,
  0xF0, 0xF8, 0x1E, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x77, 0xC7, 0xFE, 0xFF,
  0xFF, 0x8F, 0xF0, 0xFF, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFE, 0x0F, 0xF0,
  0xFF, 0x1E, 0x7F, 0xC7, 0xF8, 0x1F, 0x00, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF,
  0xF0, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x01, 0xE0,
  0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07,
  0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xE0, 0x1F, 0xE0, 0xFF, 0xC7, 0xCF, 0x1E, 0x3C,
  0x70, 0x73, 0xC1, 0xCF, 0x0F, 0x1C, 0x3C, 0x79, 0xE0, 0xFF, 0x03, 0xF8,
  0x3F, 0xF1, 0xE3, 0xC7, 0x87, 0xBC, 0x1E, 0xF0, 0x7B, 0xC1, 0xEF, 0x0F,
  0x3E, 0x7C, 0x7F, 0xE0, 0xFF, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0xFF, 0x0F,
  0xFC, 0x79, 0xE7, 0x87, 0xBC, 0x3D, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83,
  0xDC, 0x3E, 0xF3, 0xF7, 0xFF, 0x1F, 0xF8, 0x7B, 0xC0, 0x1C, 0x01, 0xE0,
  0x0F, 0x00, 0xF0, 0x3F, 0x07, 0xF0, 0x3F, 0x01, 0xE0, 0x00, 0x1C, 0x78,
  0xF0, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x78,
  0xF1, 0xC0, 0x07, 0x83, 0xC1, 0xE0, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x3C, 0x1C, 0x0E, 0x0F, 0x07,
  0x07, 0x83, 0x80, 0x80, 0x00, 0x08, 0x03, 0x80, 0x7C, 0x0F, 0xE1, 0xFE,
  0x3F, 0xC3, 0xF0, 0x1E, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3C, 0x00, 0xE0, 0x01, 0x00, 0x3F, 0xFC, 0xFF, 0xE3, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x7F, 0xF1, 0xFF, 0xC0, 0x20,
  0x01, 0xC0, 0x0F, 0x80, 0x7F, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x1F,
  0x03, 0xF0, 0x7F, 0x0F, 0xE1, 0xFC, 0x0F, 0x80, 0x70, 0x02, 0x00, 0x00,
  0x0F, 0x81, 0xFE, 0x3F, 0xE7, 0xDF, 0x78, 0xFF, 0x0F, 0x00, 0xF0, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0xC0, 0xF0, 0x0E, 0x01, 0xE0, 0x1C, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x78, 0x07, 0x80, 0x30, 0x00, 0x00,
  0x3F, 0x80, 0x03, 0xFF, 0x80, 0x1F, 0x1F, 0x00, 0xF0, 0x0E, 0x07, 0x00,
  0x18, 0x38, 0x00, 0x61, 0xC0, 0x01, 0xC7, 0x07, 0x83, 0x38, 0x7F, 0x8C,
  0xE3, 0xFE, 0x37, 0x0E, 0x38, 0xDC, 0x70, 0xC3, 0x61, 0xC7, 0x0F, 0x8E,
  0x1C, 0x3E, 0x38, 0x70, 0xF8, 0xE1, 0x87, 0xE3, 0x8E, 0x1B, 0x0C, 0x38,
  0x6C, 0x30, 0xE3, 0xB0, 0xE7, 0x8C, 0xC3, 0xFE, 0x73, 0x0F, 0xDF, 0x8E,
  0x1C, 0x78, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0xDE, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80,
  0x0E, 0xE0, 0x07, 0xB8, 0x01, 0xCF, 0x00, 0xF3, 0xC0, 0x3C, 0xF0, 0x1E,
  0x1C, 0x07, 0x87, 0x03, 0xC1, 0xC0, 0xF0, 0x70, 0x7F, 0xFE, 0x1F, 0xFF,
  0x8F, 0xFF, 0xE3, 0xC0, 0x79, 0xE0, 0x1E, 0x78, 0x07, 0xBE, 0x00, 0xEF,
  0x00, 0x3C, 0x0F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0xC1, 0xE1, 0xF0, 0xF0,
  0x78, 0x70, 0x3C, 0x78, 0x1E, 0x3C, 0x0F, 0x1E, 0x0F, 0x0F, 0x0F, 0x87,
  0xFF, 0x87, 0xFF, 0x03, 0xFF, 0xE1, 0xE0, 0xF0, 0xF0, 0x38, 0x78, 0x1E,
  0x38, 0x0F, 0x3C, 0x0F, 0x1E, 0x07, 0x8F, 0x0F, 0xC7, 0xFF, 0xC3, 0xFF,
  0xC1, 0xFF, 0x80, 0x00, 0xF8, 0x01, 0xFF, 0x03, 0xFF, 0xC1, 0xF1, 0xE1,
  0xE0, 0x78, 0xE0, 0x3C, 0xF0, 0x1E, 0x78, 0x0F, 0x38, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0,
  0x1C, 0x70, 0x1E, 0x3C, 0x0F, 0x1E, 0x0F, 0x0F, 0x8F, 0x83, 0xFF, 0x80,
  0xFF, 0x80, 0x3F, 0x00, 0x0F, 0xF8, 0x07, 0xFF, 0x03, 0xFF, 0xC1, 0xE3,
  0xE0, 0xF0, 0x78, 0x70, 0x3C, 0x78, 0x1E, 0x3C, 0x0F, 0x1E, 0x07, 0x8F,
  0x03, 0xC7, 0x01, 0xE7, 0x80, 0xF3, 0xC0, 0x79, 0xE0, 0x3C, 0xF0, 0x3C,
  0x78, 0x1E, 0x38, 0x0F, 0x3C, 0x0F, 0x1E, 0x0F, 0x8F, 0x1F, 0x87, 0xFF,
  0x83, 0xFF, 0x81, 0xFF, 0x00, 0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE1,
  0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0xFF, 0xC3, 0xFF, 0xC1, 0xFF, 0xE0, 0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF,
  0xC1, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0x81, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0x01, 0xF8, 0x01, 0xFF, 0x03,
  0xFF, 0xC1, 0xF1, 0xE1, 0xE0, 0x79, 0xE0, 0x3C, 0xF0, 0x1E, 0x78, 0x0F,
  0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x0F, 0xE7, 0x87, 0xF3, 0xC3,
  0xF9, 0xC0, 0x3C, 0xE0, 0x1E, 0x70, 0x0F, 0x3C, 0x0F, 0x1E, 0x07, 0x8F,
  0x8F, 0xC3, 0xFF, 0xC0, 0xFF, 0xC0, 0x1F, 0x80, 0x0F, 0x00, 0xF0, 0xF0,
  0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x0E, 0x0F, 0x01, 0xE0, 0xE0, 0x1E, 0x1E,
  0x01, 0xE1, 0xE0, 0x1E, 0x1E, 0x01, 0xE1, 0xE0, 0x3C, 0x1F, 0xFF, 0xC3,
  0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xC0, 0x3C, 0x3C, 0x03, 0x83, 0xC0, 0x78,
  0x38, 0x07, 0x87, 0x80, 0x78, 0x78, 0x07, 0x87, 0x80, 0x78, 0x78, 0x07,
  0x07, 0x80, 0xF0, 0x70, 0x0F, 0x00, 0x0E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7,
  0x1E, 0x3C, 0x78, 0xF1, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xE3, 0xC7, 0x8F,
  0x1E, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0xF0,
  0x78, 0xF0, 0x78, 0xF0, 0xF0, 0x79, 0xF0, 0x7F, 0xE0, 0x3F, 0xC0, 0x1F,
  0x80, 0x0F, 0x01, 0xE0, 0xF0, 0x3E, 0x0F, 0x07, 0xC0, 0xF0, 0xF8, 0x0F,
  0x1F, 0x00, 0xE3, 0xE0, 0x1E, 0x3C, 0x01, 0xE7, 0x80, 0x1E, 0xF8, 0x01,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00,
  0x3E, 0x78, 0x03, 0xC7, 0x80, 0x38, 0x78, 0x07, 0x83, 0xC0, 0x78, 0x3C,
  0x07, 0x83, 0xC0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x70, 0x1F, 0x00, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xFF, 0xBF, 0xFD, 0xFF,
  0xE0, 0x0F, 0x80, 0x1F, 0x07, 0xE0, 0x0F, 0x83, 0xF0, 0x0F, 0xC1, 0xF8,
  0x07, 0xE0, 0xFC, 0x07, 0xF0, 0x7E, 0x03, 0xF8, 0x7F, 0x03, 0xF8, 0x3F,
  0x81, 0xDC, 0x1F, 0xC0, 0xFE, 0x0E, 0xE0, 0xEF, 0x07, 0x78, 0x77, 0x87,
  0x9C, 0x73, 0x83, 0xCE, 0x39, 0xC1, 0xE7, 0x39, 0xE0, 0xF3, 0x9C, 0xF0,
  0x79, 0xDC, 0x78, 0x38, 0xEE, 0x3C, 0x3C, 0x7F, 0x1C, 0x1E, 0x1F, 0x1E,
  0x0F, 0x0F, 0x8F, 0x07, 0x87, 0x87, 0x83, 0xC3, 0xC3, 0xC1, 0xC1, 0xC1,
  0xE0, 0x0F, 0x00, 0xF0, 0xF8, 0x0F, 0x0F, 0x80, 0xF0, 0xF8, 0x0E, 0x0F,
  0xC1, 0xE0, 0xFC, 0x1E, 0x1F, 0xC1, 0xE1, 0xFE, 0x1E, 0x1E, 0xE1, 0xC1,
  0xEE, 0x3C, 0x1C, 0xE3, 0xC3, 0xC7, 0x3C, 0x3C, 0x73, 0xC3, 0xC7, 0x3C,
  0x3C, 0x3B, 0x83, 0xC3, 0xF8, 0x38, 0x3F, 0x87, 0x81, 0xF8, 0x78, 0x1F,
  0x87, 0x81, 0xF8, 0x78, 0x1F, 0x07, 0x80, 0xF0, 0x70, 0x0F, 0x00, 0x00,
  0xF8, 0x01, 0xFF, 0x01, 0xFF, 0xC1, 0xF1, 0xF1, 0xE0, 0x78, 0xF0, 0x3C,
  0xF0, 0x0E, 0x78, 0x07, 0x38, 0x03, 0xBC, 0x03, 0xDE, 0x01, 0xEF, 0x00,
  0xF7, 0x80, 0x7B, 0xC0, 0x3D, 0xC0, 0x1C, 0xE0, 0x1E, 0x70, 0x0F, 0x3C,
  0x0F, 0x1E, 0x07, 0x8F, 0x8F, 0x83, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0x80,
  0x0F, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x3C, 0x3E, 0x0F, 0x03, 0xC3,
  0x80, 0xF1, 0xE0, 0x3C, 0x78, 0x0F, 0x1E, 0x03, 0xC7, 0x81, 0xE1, 0xE1,
  0xF8, 0xFF, 0xFC, 0x3F, 0xFE, 0x0F, 0xFE, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xF8, 0x01, 0xFF, 0x03, 0xFF, 0xC1, 0xF1,
  0xE1, 0xE0, 0x79, 0xE0, 0x3C, 0xF0, 0x1E, 0x78, 0x07, 0x78, 0x07, 0xBC,
  0x03, 0xDE, 0x01, 0xEF, 0x00, 0xF7, 0x80, 0x7B, 0x80, 0x3D, 0xC0, 0x1C,
  0xE0, 0x1E, 0x70, 0x0F, 0x3C, 0x0F, 0x1E, 0x07, 0x8F, 0x8F, 0x83, 0xFF,
  0x80, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0E, 0x00,
  0x02, 0x00, 0x0F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0xC1, 0xE1, 0xF0, 0xF0,
  0x78, 0x70, 0x3C, 0x78, 0x1E, 0x3C, 0x0F, 0x1E, 0x07, 0x8F, 0x07, 0x87,
  0x87, 0xC7, 0xFF, 0xC3, 0xFF, 0xC1, 0xFF, 0xC0, 0xF1, 0xE0, 0x78, 0xF0,
  0x38, 0x3C, 0x3C, 0x1E, 0x1E, 0x0F, 0x0F, 0x07, 0x87, 0x81, 0xE3, 0xC0,
  0xF1, 0xC0, 0x78, 0x01, 0xF0, 0x07, 0xFC, 0x0F, 0xFE, 0x1F, 0x1E, 0x1E,
  0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C, 0xF0,
  0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF8, 0xF8, 0x7F, 0xF8, 0x3F, 0xF0, 0x0F,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E,
  0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x38, 0x70, 0x1E, 0x3C, 0x07, 0x8F, 0x01,
  0xE3, 0xC0, 0x78, 0xF0, 0x1C, 0x3C, 0x0F, 0x0E, 0x03, 0xC7, 0x80, 0xF1,
  0xE0, 0x3C, 0x78, 0x0F, 0x1E, 0x03, 0x87, 0x01, 0xE3, 0xC0, 0x78, 0xF0,
  0x1E, 0x3C, 0x07, 0x87, 0x83, 0xC1, 0xF1, 0xF0, 0x7F, 0xF8, 0x0F, 0xFC,
  0x00, 0xFC, 0x00, 0xF0, 0x0F, 0xF8, 0x07, 0xBC, 0x03, 0xDE, 0x03, 0xCF,
  0x01, 0xE7, 0x81, 0xF1, 0xC0, 0xF0, 0xE0, 0x78, 0x78, 0x78, 0x3C, 0x3C,
  0x1E, 0x3C, 0x0F, 0x1E, 0x07, 0x8E, 0x01, 0xCF, 0x00, 0xE7, 0x00, 0x77,
  0x80, 0x3B, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0xF0, 0x38, 0x1D, 0xE0, 0xF0, 0x7B, 0xC1, 0xE0,
  0xF7, 0x87, 0xC1, 0xCF, 0x0F, 0x87, 0x9E, 0x1F, 0x0F, 0x3C, 0x7E, 0x1C,
  0x78, 0xFC, 0x78, 0xF1, 0xF8, 0xF1, 0xE7, 0x71, 0xC3, 0xCE, 0xE7, 0x87,
  0x9D, 0xCF, 0x0F, 0x73, 0x9C, 0x1E, 0xE3, 0x78, 0x3F, 0xC6, 0xF0, 0x7F,
  0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0xF8, 0x3F, 0x01, 0xF0, 0x7C, 0x03, 0xE0,
  0xF8, 0x07, 0x81, 0xF0, 0x0F, 0x03, 0xC0, 0x1E, 0x07, 0x80, 0x00, 0x0F,
  0x81, 0xF0, 0x78, 0x1E, 0x07, 0x83, 0xE0, 0x78, 0x3C, 0x03, 0xC7, 0x80,
  0x3C, 0xF8, 0x03, 0xCF, 0x00, 0x1D, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC,
  0x00, 0x7B, 0xC0, 0x0F, 0xBC, 0x00, 0xF1, 0xE0, 0x1E, 0x1E, 0x03, 0xE1,
  0xE0, 0x3C, 0x1F, 0x07, 0xC0, 0xF0, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0xF0,
  0x1E, 0xF0, 0x3E, 0x78, 0x3C, 0x78, 0x78, 0x78, 0x78, 0x78, 0xF0, 0x38,
  0xF0, 0x39, 0xE0, 0x3D, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x0F, 0xFF, 0xC7, 0xFF, 0xF1,
  0xFF, 0xF8, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0xC0, 0x01, 0xE0, 0x00, 0xFF, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0xC0, 0x07,
  0xC3, 0xF0, 0xFC, 0x3C, 0x0F, 0x03, 0x80, 0xE0, 0x78, 0x1E, 0x07, 0x81,
  0xE0, 0x78, 0x1C, 0x07, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x80, 0xE0,
  0x78, 0x1E, 0x07, 0x81, 0xE0, 0x70, 0x1C, 0x0F, 0x03, 0xC0, 0xF0, 0x3F,
  0x0F, 0x83, 0xE0, 0xE1, 0xE3, 0xC7, 0x87, 0x0E, 0x1C, 0x38, 0x78, 0xF1,
  0xE1, 0xC3, 0x87, 0x0E, 0x1E, 0x3C, 0x78, 0x70, 0xE1, 0xC3, 0x87, 0x8F,
  0x1E, 0x07, 0xE0, 0xFC, 0x1F, 0x80, 0xE0, 0x1C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x70, 0x0E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x38, 0x07,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0x70, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xC0, 0xF8, 0x3F, 0x07, 0xE0, 0x03, 0x80, 0xF0,
  0x1E, 0x07, 0xC0, 0xF8, 0x3B, 0x87, 0x71, 0xCE, 0x39, 0xCF, 0x39, 0xC3,
  0x78, 0x70, 0x7F, 0xFF, 0xFF, 0xFF, 0xFC, 0x78, 0xF0, 0xF0, 0xE1, 0xC0,
  0x07, 0xC0, 0xFF, 0x8F, 0xFC, 0x78, 0xF7, 0x87, 0x80, 0x3C, 0x01, 0xE1,
  0xFE, 0x3F, 0xF3, 0xF7, 0xBC, 0x3D, 0xE1, 0xEE, 0x0E, 0x78, 0xF3, 0xFF,
  0x8F, 0xFC, 0x3C, 0xE0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0xF0, 0x3F, 0xF0, 0x7F,
  0xF1, 0xF1, 0xE3, 0xC1, 0xE7, 0x83, 0xCF, 0x07, 0x9C, 0x0F, 0x38, 0x1C,
  0xF0, 0x39, 0xE0, 0xF3, 0xC1, 0xE7, 0x83, 0xCF, 0x8F, 0x1F, 0xFE, 0x7B,
  0xF8, 0xF3, 0xC0, 0x07, 0xC0, 0xFF, 0x0F, 0xFC, 0x78, 0xF7, 0x87, 0xB8,
  0x1F, 0xC0, 0xFE, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE1, 0xEF, 0x0F,
  0x78, 0xF1, 0xFF, 0x87, 0xF8, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x0E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x0F,
  0xBC, 0x1F, 0xFC, 0x3F, 0xFC, 0x7C, 0x7C, 0x78, 0x38, 0x70, 0x38, 0xF0,
  0x78, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0x70, 0xF0, 0x70, 0xF0,
  0xF0, 0xF9, 0xF0, 0x7F, 0xF0, 0x7F, 0xF0, 0x3E, 0xE0, 0x07, 0xC0, 0xFF,
  0x8F, 0xFC, 0x78, 0xF7, 0x83, 0xB8, 0x1D, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x01, 0xE0, 0x0F, 0x02, 0x7C, 0x71, 0xFF, 0xC7, 0xFC, 0x1F,
  0x80, 0x01, 0xE0, 0x3E, 0x07, 0xE0, 0xF8, 0x0F, 0x00, 0xE0, 0x1E, 0x01,
  0xE0, 0x7F, 0xC7, 0xF8, 0x7F, 0x81, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x38, 0x03, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x70, 0x07,
  0x00, 0xF0, 0x00, 0x07, 0xCE, 0x0F, 0xEE, 0x1F, 0xFE, 0x3E, 0x3E, 0x3C,
  0x1E, 0x38, 0x1E, 0x78, 0x1C, 0x78, 0x1C, 0x78, 0x3C, 0x78, 0x3C, 0x78,
  0x3C, 0x78, 0x3C, 0x78, 0x38, 0x7C, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x1F,
  0x78, 0x00, 0x70, 0x00, 0x70, 0x40, 0xF0, 0x61, 0xF0, 0xFF, 0xE0, 0x7F,
  0xC0, 0x3F, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0xF0, 0x7F, 0xE1, 0xFF, 0xCF, 0x8F,
  0x3C, 0x3C, 0xF0, 0xF3, 0xC3, 0xCE, 0x0F, 0x38, 0x3D, 0xE0, 0xE7, 0x83,
  0x9E, 0x1E, 0x78, 0x79, 0xC1, 0xE7, 0x07, 0xBC, 0x1C, 0xF0, 0x70, 0x07,
  0x0F, 0x0F, 0x06, 0x00, 0x00, 0x1E, 0x1E, 0x1E, 0x1C, 0x1C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x38, 0x38, 0x78, 0x78, 0x78, 0x70, 0x70, 0xF0, 0x01, 0xC0,
  0x3C, 0x07, 0x80, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x1E, 0x03, 0xC0, 0x70,
  0x0E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x38, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xE0, 0x1C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0xF0, 0x7E,
  0x0F, 0x81, 0xE0, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x1E, 0x1C, 0x3C,
  0x1C, 0x78, 0x3C, 0xF8, 0x3D, 0xF0, 0x3F, 0xE0, 0x3F, 0xC0, 0x3F, 0x80,
  0x3F, 0xC0, 0x7F, 0xC0, 0x7D, 0xC0, 0x79, 0xE0, 0x79, 0xE0, 0x70, 0xF0,
  0x70, 0xF0, 0xF0, 0xF0, 0xF0, 0x78, 0x07, 0x0F, 0x0F, 0x0F, 0x0F, 0x0E,
  0x0E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1C, 0x1C, 0x3C, 0x3C, 0x3C, 0x3C, 0x38,
  0x78, 0x78, 0x78, 0x78, 0x70, 0x70, 0xF0, 0x1E, 0xF0, 0xF0, 0x7F, 0xE7,
  0xE1, 0xFF, 0xFF, 0xC7, 0x8F, 0xCF, 0x3C, 0x3E, 0x1C, 0xF0, 0xF0, 0x73,
  0xC3, 0xC1, 0xCF, 0x0F, 0x0F, 0x38, 0x3C, 0x3D, 0xE0, 0xE0, 0xF7, 0x83,
  0x83, 0xDE, 0x1E, 0x0E, 0x78, 0x78, 0x79, 0xC1, 0xE1, 0xE7, 0x07, 0x87,
  0xBC, 0x1C, 0x1E, 0xF0, 0x70, 0x70, 0x1E, 0xF0, 0x77, 0xE1, 0xFF, 0xCF,
  0x8F, 0x3C, 0x3C, 0xF0, 0xF3, 0xC3, 0xCE, 0x0F, 0x38, 0x3D, 0xE0, 0xE7,
  0x83, 0x9E, 0x1E, 0x78, 0x79, 0xC1, 0xE7, 0x07, 0xBC, 0x1C, 0xF0, 0x70,
  0x07, 0xE0, 0x7F, 0xC3, 0xFF, 0x8F, 0x1E, 0x78, 0x39, 0xE0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xEF, 0x03, 0xBC, 0x1E, 0xF0, 0x73, 0xE3,
  0xC7, 0xFE, 0x0F, 0xF0, 0x1F, 0x00, 0x0E, 0x78, 0x0F, 0xFC, 0x0F, 0xFE,
  0x0F, 0x1E, 0x1E, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x1C, 0x0E,
  0x1C, 0x0E, 0x3C, 0x1E, 0x3C, 0x1E, 0x3C, 0x1E, 0x3E, 0x3C, 0x3F, 0xFC,
  0x7B, 0xF8, 0x79, 0xE0, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x0F, 0x9C, 0x7F, 0x73, 0xFF, 0xDF,
  0x1F, 0x78, 0x3D, 0xC0, 0xEF, 0x03, 0xBC, 0x1E, 0xF0, 0x7B, 0xC1, 0xEF,
  0x07, 0xBC, 0x1C, 0xF0, 0xF3, 0xE7, 0xC7, 0xFF, 0x1F, 0xFC, 0x3E, 0xE0,
  0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70,
  0x1E, 0xE3, 0xFC, 0x7F, 0x8F, 0xE3, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x38,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x1C, 0x07, 0x80, 0xF0, 0x00,
  0x03, 0xE0, 0x3F, 0xC1, 0xFF, 0x8F, 0x9E, 0x3C, 0x3C, 0xF0, 0x03, 0xE0,
  0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0x3C, 0x1C, 0xF0, 0x71, 0xE3,
  0xC7, 0xFF, 0x0F, 0xF8, 0x0F, 0x80, 0x0E, 0x0F, 0x07, 0x83, 0xC1, 0xE3,
  0xFF, 0xFF, 0xFF, 0x3C, 0x1E, 0x0F, 0x07, 0x03, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x38, 0x1E, 0x0F, 0x87, 0xC1, 0xE0, 0x3C, 0x3C, 0xF0, 0xF3, 0x83,
  0xDE, 0x0F, 0x78, 0x39, 0xE0, 0xE7, 0x87, 0x9C, 0x1E, 0x70, 0x7B, 0xC1,
  0xEF, 0x07, 0x3C, 0x3C, 0xF0, 0xF3, 0xE7, 0xCF, 0xFF, 0x1F, 0xF8, 0x3E,
  0xE0, 0xF0, 0x7F, 0x87, 0xBC, 0x3D, 0xE3, 0xCF, 0x1E, 0x78, 0xE1, 0xCF,
  0x0E, 0x70, 0x73, 0x83, 0xBC, 0x1D, 0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x00,
  0xF0, 0x07, 0x80, 0x38, 0x00, 0xF0, 0xE1, 0xFE, 0x1C, 0x3F, 0xC7, 0x87,
  0x78, 0xF1, 0xEF, 0x3E, 0x39, 0xE7, 0xC7, 0x3D, 0xD9, 0xE7, 0xBB, 0x38,
  0xF7, 0x7F, 0x1F, 0xCF, 0xC1, 0xF9, 0xF8, 0x3E, 0x3F, 0x07, 0xC7, 0xC0,
  0xF0, 0xF8, 0x1E, 0x1E, 0x03, 0x83, 0xC0, 0x70, 0x78, 0x00, 0x1E, 0x1F,
  0x0E, 0x1E, 0x0F, 0x3C, 0x0F, 0x3C, 0x07, 0x78, 0x07, 0xF0, 0x07, 0xF0,
  0x03, 0xE0, 0x03, 0xC0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1E, 0xF0,
  0x3C, 0xF0, 0x3C, 0x70, 0x78, 0x78, 0xF8, 0x78, 0x1E, 0x0F, 0x1E, 0x1E,
  0x1E, 0x1E, 0x1E, 0x3C, 0x1E, 0x3C, 0x1E, 0x38, 0x0E, 0x78, 0x0E, 0x70,
  0x0E, 0xF0, 0x0E, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x1F, 0xFC, 0x7F, 0xF3,
  0xFF, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0xFF, 0x3F, 0xFC,
  0xFF, 0xE0, 0x00, 0xC0, 0x70, 0x3C, 0x1E, 0x07, 0x03, 0xC0, 0xE0, 0x38,
  0x0E, 0x07, 0x81, 0xE0, 0x78, 0x1C, 0x07, 0x03, 0xC3, 0xE0, 0xF0, 0x3C,
  0x07, 0x80, 0xE0, 0x38, 0x0E, 0x07, 0x81, 0xE0, 0x78, 0x1C, 0x07, 0x01,
  0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x20, 0x0C, 0x31, 0xC7, 0x1C, 0x71, 0x86,
  0x38, 0xE3, 0x8E, 0x30, 0xC3, 0x1C, 0x71, 0xC6, 0x18, 0x63, 0x8E, 0x38,
  0xE3, 0x0C, 0x00, 0x04, 0x03, 0x80, 0xF0, 0x1C, 0x07, 0x01, 0xE0, 0x78,
  0x1E, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xE0, 0x3C, 0x07, 0x07,
  0xC3, 0xC0, 0xE0, 0x78, 0x1E, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x0F, 0x03,
  0xC0, 0xE0, 0x78, 0x3C, 0x0E, 0x02, 0x00, 0x1E, 0x07, 0x3F, 0x07, 0x7F,
  0x86, 0x7B, 0xCE, 0x71, 0xFE, 0xE0, 0xFC, 0x00, 0x78,
};

const GFXglyph RobotoCondensed_MediumItalic33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 7, 23, 8, 1, -23 },
  { 22, 8, 8, 10, 3, -25 },
  { 30, 16, 23, 17, 1, -23 },
  { 76, 15, 29, 16, 1, -26 },
  { 131, 15, 23, 20, 3, -23 },
  { 175, 16, 23, 18, 1, -23 },
  { 221, 5, 8, 5, 2, -25 },
  { 226, 10, 33, 10, 2, -26 },
  { 268, 11, 33, 10, -2, -26 },
  { 314, 13, 14, 14, 2, -23 },
  { 337, 14, 18, 16, 1, -20 },
  { 369, 6, 9, 7, -2, -4 },
  { 376, 8, 3, 10, 1, -11 },
  { 379, 4, 4, 9, 1, -4 },
  { 381, 15, 25, 11, -2, -23 },
  { 428, 14, 23, 16, 1, -23 },
  { 469, 9, 23, 16, 4, -23 },
  { 495, 15, 23, 16, 0, -23 },
  { 539, 14, 23, 16, 1, -23 },
  { 580, 15, 23, 16, 0, -23 },
  { 624, 15, 23, 16, 1, -23 },
  { 668, 12, 23, 16, 2, -23 },
  { 703, 15, 23, 16, 2, -23 },
  { 747, 14, 23, 16, 1, -23 },
  { 788, 13, 23, 16, 2, -23 },
  { 826, 7, 18, 8, 1, -18 },
  { 842, 9, 23, 8, -2, -18 },
  { 868, 13, 15, 14, 1, -18 },
  { 893, 14, 10, 16, 1, -16 },
  { 911, 13, 15, 15, 1, -18 },
  { 936, 12, 23, 14, 2, -23 },
  { 971, 22, 30, 25, 1, -23 },
  { 1054, 18, 23, 19, -1, -23 },
  { 1106, 17, 23, 18, 0, -23 },
  { 1155, 17, 23, 18, 1, -23 },
  { 1204, 17, 23, 18, 0, -23 },
  { 1253, 17, 23, 16, 0, -23 },
  { 1302, 17, 23, 15, 0, -23 },
  { 1351, 17, 23, 19, 1, -23 },
  { 1400, 20, 23, 20, 0, -23 },
  { 1458, 7, 23, 8, 1, -23 },
  { 1479, 16, 23, 16, 0, -23 },
  { 1525, 20, 23, 18, 0, -23 },
  { 1583, 13, 23, 15, 0, -23 },
  { 1621, 25, 23, 24, 0, -23 },
  { 1693, 20, 23, 20, 0, -23 },
  { 1751, 17, 23, 19, 1, -23 },
  { 1800, 18, 23, 18, 0, -23 },
  { 1852, 17, 27, 19, 1, -23 },
  { 1910, 17, 23, 17, 0, -23 },
  { 1959, 16, 23, 17, 1, -23 },
  { 2005, 16, 23, 17, 3, -23 },
  { 2051, 18, 23, 18, 1, -23 },
  { 2103, 17, 23, 18, 3, -23 },
  { 2152, 23, 23, 24, 3, -23 },
  { 2219, 20, 23, 18, -1, -23 },
  { 2277, 16, 23, 17, 3, -23 },
  { 2323, 18, 23, 17, 0, -23 },
  { 2375, 10, 32, 8, 0, -27 },
  { 2415, 7, 25, 12, 3, -23 },
  { 2437, 11, 32, 8, -2, -27 },
  { 2481, 11, 12, 12, 1, -23 },
  { 2498, 13, 3, 13, -2, 0 },
  { 2503, 7, 5, 10, 3, -25 },
  { 2508, 13, 17, 15, 1, -17 },
  { 2536, 15, 25, 16, 0, -25 },
  { 2583, 13, 17, 15, 1, -17 },
  { 2611, 16, 25, 16, 1, -25 },
  { 2661, 13, 17, 15, 1, -17 },
  { 2689, 12, 25, 10, 1, -25 },
  { 2727, 16, 24, 16, 0, -17 },
  { 2775, 14, 25, 16, 0, -25 },
  { 2819, 8, 23, 8, 0, -23 },
  { 2842, 11, 30, 8, -3, -23 },
  { 2884, 16, 25, 15, 0, -25 },
  { 2934, 8, 25, 8, 0, -25 },
  { 2959, 22, 17, 24, 0, -17 },
  { 3006, 14, 17, 16, 0, -17 },
  { 3036, 14, 17, 16, 1, -17 },
  { 3066, 16, 24, 16, -1, -17 },
  { 3114, 14, 24, 16, 1, -17 },
  { 3156, 11, 17, 10, 0, -17 },
  { 3180, 14, 17, 15, 0, -17 },
  { 3210, 9, 22, 10, 1, -22 },
  { 3235, 14, 17, 16, 1, -17 },
  { 3265, 13, 17, 14, 2, -17 },
  { 3293, 19, 17, 21, 2, -17 },
  { 3334, 16, 17, 14, -1, -17 },
  { 3368, 16, 24, 14, -1, -17 },
  { 3416, 14, 17, 14, 0, -17 },
  { 3446, 10, 32, 10, 1, -26 },
  { 3486, 6, 27, 8, 1, -23 },
  { 3507, 10, 32, 10, -1, -26 },
  { 3547, 16, 7, 18, 1, -13 },
};

const GFXfont RobotoCondensed_MediumItalic33pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_MediumItalic33pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_MediumItalic33pt7bGlyphs,
  0x20, 0x7E, 39
};

#endif // _ROBOTOCONDENSED_MEDIUMITALIC33PT7B_H_
