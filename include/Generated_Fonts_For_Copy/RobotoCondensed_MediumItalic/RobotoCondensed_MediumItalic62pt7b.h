#ifndef _ROBOTOCONDENSED_MEDIUMITALIC62PT7B_H_
#define _ROBOTOCONDENSED_MEDIUMITALIC62PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-MediumItalic.ttf
// Size: 62pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_MediumItalic62pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x00, 0x7E, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x07, 0xC0,
  0x1F, 0xC0, 0x3F, 0x80, 0xFF, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x3E, 0x1F, 0x3E, 0x1F, 0x3E, 0x1F, 0x3E, 0x1F, 0x3E, 0x3F,
  0x7E, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3C, 0x78, 0x7C,
  0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0x78, 0xF0, 0x78, 0xF0, 0x78, 0x00, 0x00,
  0xF0, 0x7C, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x0F,
  0x07, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0xF0,
  0x7C, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x0F, 0x07,
  0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x7C, 0x3E, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0xF0, 0x7C, 0x00,
  0x03, 0xE0, 0xF8, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x0F, 0x87, 0xC0, 0x00,
  0x3E, 0x0F, 0x80, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x03,
  0xE0, 0xF8, 0x00, 0x07, 0xC1, 0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xE0, 0x07, 0xC1, 0xE0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x3E, 0x0F,
  0x80, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x01, 0xE0, 0xF8,
  0x00, 0x07, 0xC1, 0xE0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x1E, 0x0F, 0x80,
  0x00, 0x7C, 0x1F, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x01, 0xE0, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x07, 0xF8, 0x3F,
  0x80, 0xFE, 0x07, 0xF0, 0x3F, 0x80, 0x7F, 0x07, 0xF0, 0x0F, 0xE0, 0xFE,
  0x01, 0xFC, 0x1F, 0x80, 0x3F, 0x83, 0xF0, 0x07, 0xF0, 0x7E, 0x00, 0xFE,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x1F,
  0xC7, 0xF0, 0x03, 0xF8, 0xFE, 0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xE1, 0xFC,
  0x03, 0xF8, 0x3F, 0x80, 0xFF, 0x07, 0xF8, 0x3F, 0xE0, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x00, 0xFF,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xE3,
  0xE0, 0x00, 0x7C, 0x3E, 0x01, 0x8F, 0x81, 0xE0, 0x3E, 0xF8, 0x1E, 0x03,
  0xEF, 0x81, 0xE0, 0x7C, 0xF8, 0x1E, 0x0F, 0x8F, 0x81, 0xE1, 0xF0, 0xF0,
  0x3E, 0x1F, 0x0F, 0x03, 0xE3, 0xE0, 0xF0, 0x3E, 0x7C, 0x0F, 0x87, 0xE7,
  0xC0, 0xF8, 0x7C, 0xF8, 0x07, 0xFF, 0xDF, 0x00, 0x7F, 0xF9, 0xF0, 0x03,
  0xFF, 0x3E, 0x00, 0x1F, 0xE7, 0xC0, 0x00, 0x20, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE7, 0xF8,
  0x00, 0x7C, 0xFF, 0xC0, 0x0F, 0x9F, 0xFE, 0x00, 0xFB, 0xFF, 0xE0, 0x1F,
  0x3E, 0x1F, 0x03, 0xE7, 0xE1, 0xF0, 0x3E, 0x7C, 0x1F, 0x07, 0xC7, 0xC0,
  0xF0, 0xF8, 0x78, 0x0F, 0x0F, 0x87, 0x81, 0xF1, 0xF0, 0x78, 0x1F, 0x3E,
  0x0F, 0x81, 0xF3, 0xE0, 0xF8, 0x1F, 0x7C, 0x07, 0x81, 0xF7, 0x80, 0x7C,
  0x3E, 0x30, 0x07, 0xC7, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFB, 0xFC,
  0x00, 0x3F, 0x87, 0xF0, 0x01, 0xFC, 0x0F, 0xC0, 0x07, 0xF0, 0x3F, 0x00,
  0x1F, 0x80, 0xFC, 0x00, 0x7E, 0x03, 0xF0, 0x01, 0xF8, 0x1F, 0xC0, 0x07,
  0xE0, 0x7E, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x7F, 0x1F, 0xC0, 0x01, 0xFC,
  0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0xFC, 0x3F, 0xFF, 0x83, 0xF1,
  0xFE, 0xFE, 0x0F, 0xC7, 0xF3, 0xFC, 0x7E, 0x3F, 0xC7, 0xF1, 0xF8, 0xFE,
  0x1F, 0xE7, 0xE7, 0xF0, 0x3F, 0xBF, 0x9F, 0xC0, 0xFF, 0xFC, 0x7F, 0x01,
  0xFF, 0xF1, 0xFC, 0x03, 0xFF, 0x8F, 0xF0, 0x0F, 0xFE, 0x1F, 0xC0, 0x1F,
  0xF0, 0x7F, 0x00, 0x7F, 0xC1, 0xFC, 0x00, 0xFE, 0x07, 0xF8, 0x07, 0xFC,
  0x1F, 0xF0, 0x7F, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xF9, 0xFC, 0x03, 0xFF, 0x87, 0xF8, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x1F, 0x3F, 0x3F, 0x3F, 0x3E, 0x3E, 0x3E, 0x3E,
  0x7E, 0x7C, 0x7C, 0x7C, 0x7C, 0x78, 0xF8, 0x00, 0x00, 0x40, 0x00, 0x38,
  0x00, 0x0F, 0x00, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x07,
  0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x07,
  0x80, 0x00, 0xE0, 0x00, 0x10, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x60, 0x3E, 0x03, 0x3C, 0x1F, 0x0F, 0xBF,
  0xCF, 0x9F, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0xC0, 0x01, 0xFB, 0xF0, 0x01, 0xF8, 0xF8, 0x01, 0xF8, 0x7E,
  0x01, 0xFC, 0x1F, 0x01, 0xFC, 0x0F, 0xC0, 0x3C, 0x03, 0xE0, 0x0C, 0x01,
  0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF8, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xE0, 0xFC, 0x1F, 0x87, 0xF0, 0xFE, 0x1F, 0x83, 0xF0, 0x7E,
  0x1F, 0xC3, 0xF0, 0xFE, 0x1F, 0x87, 0xF1, 0xFC, 0x3F, 0x03, 0xC0, 0x30,
  0x00, 0x7F, 0xFC, 0xFF, 0xF9, 0xFF, 0xF3, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF,
  0x80, 0x1C, 0x1F, 0x9F, 0xCF, 0xFF, 0xFB, 0xFD, 0xFC, 0x7C, 0x08, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xCF, 0xF0, 0x1F,
  0xC0, 0xFE, 0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x07, 0xE1, 0xFC, 0x01, 0xF8,
  0x7F, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0xCF, 0xE0, 0x07, 0xF3, 0xF8, 0x01,
  0xFC, 0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xCF, 0xC0, 0x07, 0xE7, 0xF0,
  0x03, 0xF9, 0xFC, 0x00, 0xFE, 0x7F, 0x00, 0x3F, 0x9F, 0xC0, 0x0F, 0xE7,
  0xF0, 0x03, 0xF9, 0xFC, 0x00, 0xFE, 0xFE, 0x00, 0x3F, 0x3F, 0x80, 0x1F,
  0xCF, 0xE0, 0x07, 0xF3, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0x7F, 0x3F, 0x80,
  0x1F, 0xCF, 0xE0, 0x07, 0xE3, 0xF8, 0x03, 0xF8, 0xFC, 0x00, 0xFE, 0x3F,
  0x00, 0x3F, 0x8F, 0xC0, 0x0F, 0xC3, 0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xFC,
  0x3F, 0x80, 0xFE, 0x07, 0xF0, 0x7F, 0x81, 0xFF, 0x7F, 0xC0, 0x7F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0x80, 0x03, 0xC0, 0x0F,
  0xE0, 0x1F, 0xF0, 0x7F, 0xF8, 0xFF, 0xFD, 0xFF, 0xFC, 0xFF, 0xFE, 0x7F,
  0xFF, 0x3F, 0xBF, 0xBE, 0x1F, 0xDC, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xF0, 0x07, 0xFE, 0xFF, 0xC0, 0x3F, 0xC1, 0xFE, 0x03, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x3F, 0xC1, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF0,
  0x7F, 0x00, 0x3F, 0x83, 0xF8, 0x03, 0xF8, 0x1F, 0x80, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x03, 0xFE, 0x7F,
  0xE0, 0x3F, 0xC1, 0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x0F,
  0xF0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x3F,
  0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF8, 0xFE,
  0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x0F,
  0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xFE, 0x7F, 0xC0, 0x3F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFF,
  0xF8, 0x00, 0x3F, 0x7F, 0x00, 0x0F, 0xCF, 0xE0, 0x01, 0xF9, 0xFC, 0x00,
  0x7E, 0x3F, 0x80, 0x1F, 0x87, 0xE0, 0x03, 0xF1, 0xFC, 0x00, 0xFC, 0x3F,
  0x80, 0x3F, 0x87, 0xF0, 0x0F, 0xE0, 0xFE, 0x01, 0xF8, 0x1F, 0xC0, 0x7F,
  0x03, 0xF0, 0x1F, 0xC0, 0xFE, 0x03, 0xF0, 0x1F, 0xC0, 0xFE, 0x03, 0xF8,
  0x3F, 0x80, 0x7F, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x01,
  0xFE, 0x0F, 0xF0, 0x07, 0xC0, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0x7E, 0x00, 0x7F,
  0x07, 0xF0, 0x0F, 0xF0, 0x7F, 0x00, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x3F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x8F, 0xC0,
  0x3F, 0xBF, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFE, 0x7F, 0xE1, 0xFE, 0x7F, 0x80, 0xFF, 0x7F, 0x80, 0x7F,
  0x7F, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7E, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0x7E, 0x01, 0xFE,
  0x7F, 0x01, 0xFC, 0x7F, 0x03, 0xFC, 0x3F, 0xCF, 0xF8, 0x3F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x00, 0x20, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0x00, 0xFF, 0x9F, 0xF0, 0x1F, 0xE0, 0xFE, 0x07, 0xF8,
  0x1F, 0xC0, 0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x07, 0xF0,
  0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xC3, 0xF8, 0x07, 0xF0, 0x3F, 0x00,
  0xFE, 0x07, 0xE0, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x0F, 0xE1, 0xFC, 0x01,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x03, 0xFC, 0x3F, 0x80, 0xFF,
  0x03, 0xF8, 0x1F, 0xC0, 0x3F, 0x07, 0xF0, 0x07, 0xE0, 0xFE, 0x00, 0xFE,
  0x3F, 0x80, 0x1F, 0xC7, 0xF0, 0x03, 0xF8, 0xFE, 0x00, 0x7F, 0x1F, 0xC0,
  0x0F, 0xE3, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xE1,
  0xFE, 0x03, 0xFC, 0x1F, 0xC0, 0xFF, 0x03, 0xFF, 0x7F, 0xE0, 0x3F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFC, 0x0F, 0xFB, 0xFE, 0x1F, 0xE0, 0xFE, 0x1F, 0xC0, 0x7E, 0x3F, 0x80,
  0x7F, 0x3F, 0x80, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00,
  0x7F, 0x7F, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x7F, 0x00, 0xFF, 0x7F, 0x00,
  0xFE, 0x7F, 0x01, 0xFE, 0x7F, 0x83, 0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFC, 0x1F, 0xFE, 0xFC, 0x0F, 0xFD, 0xFC, 0x03, 0xF1,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xE0,
  0x1F, 0x81, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0x7E, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x7E, 0x07, 0xF0, 0x7F, 0xC3, 0xFE,
  0x1F, 0xF0, 0x7F, 0x01, 0xF0, 0x02, 0x00, 0x00, 0x1C, 0x00, 0x3F, 0x00,
  0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF8, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x01,
  0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7F, 0x00,
  0x1F, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFE, 0x00,
  0x1F, 0xFC, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x7F,
  0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x20, 0x1F, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x00, 0x04, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x1F,
  0xFF, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF,
  0xF0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x9F, 0xE1, 0xFE, 0xFF, 0x03,
  0xFB, 0xF8, 0x0F, 0xEF, 0xE0, 0x3F, 0xBF, 0x80, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0x3E, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F,
  0xF0, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF0, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x1F, 0x80, 0x00, 0x00, 0x3C, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0x80, 0xF8,
  0x03, 0xFF, 0x00, 0xF0, 0x1F, 0x00, 0xFF, 0xF8, 0x1E, 0x07, 0xC0, 0x3F,
  0xFF, 0x83, 0xE0, 0xF8, 0x0F, 0xFF, 0xF0, 0x7C, 0x3E, 0x03, 0xF0, 0x7C,
  0x0F, 0x87, 0xC0, 0x7C, 0x0F, 0x81, 0xF1, 0xF0, 0x1F, 0x81, 0xF0, 0x3E,
  0x3E, 0x07, 0xE0, 0x3E, 0x07, 0xC7, 0xC0, 0xF8, 0x0F, 0x80, 0xF9, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x3E, 0x07, 0xE0, 0x3E, 0x03, 0xE7, 0xC0, 0xF8,
  0x07, 0xC0, 0x78, 0xF8, 0x1F, 0x01, 0xF0, 0x0F, 0x3E, 0x07, 0xE0, 0x3E,
  0x01, 0xE7, 0xC0, 0xFC, 0x07, 0xC0, 0x3C, 0xF8, 0x1F, 0x00, 0xF8, 0x0F,
  0x9F, 0x03, 0xE0, 0x3E, 0x01, 0xE3, 0xE0, 0xFC, 0x07, 0xC0, 0x3C, 0x7C,
  0x1F, 0x80, 0xF8, 0x07, 0x8F, 0x03, 0xF0, 0x1F, 0x01, 0xF1, 0xE0, 0x7E,
  0x07, 0xE0, 0x3C, 0x7C, 0x0F, 0xC0, 0xF8, 0x0F, 0x8F, 0x81, 0xF8, 0x3F,
  0x01, 0xE1, 0xF0, 0x3F, 0x07, 0xE0, 0x7C, 0x1E, 0x03, 0xF3, 0xFE, 0x1F,
  0x03, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x78, 0x0F, 0xFE, 0xFF, 0xF8, 0x0F,
  0x80, 0xFF, 0x8F, 0xFE, 0x01, 0xF0, 0x0F, 0xE0, 0xFF, 0x00, 0x3E, 0x00,
  0x70, 0x0F, 0x80, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x01, 0xC0, 0x00, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0x7E, 0x00,
  0x00, 0x3F, 0xBF, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x1F, 0xCF, 0xC0,
  0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x07, 0xF1, 0xFC,
  0x00, 0x07, 0xF0, 0xFE, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x03, 0xF8, 0x3F,
  0x80, 0x01, 0xFC, 0x0F, 0xC0, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0xFE, 0x03,
  0xF0, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x7F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x83, 0xFC,
  0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x07, 0xF0, 0xFE,
  0x00, 0x03, 0xF8, 0xFF, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0x7F, 0x7F,
  0x80, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x07, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0x01, 0xFF, 0x01, 0xFC, 0x00, 0xFF, 0x03,
  0xF8, 0x01, 0xFE, 0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xF8, 0x3F,
  0xC0, 0x07, 0xF0, 0x7F, 0x80, 0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0xC1, 0xFC,
  0x00, 0x7F, 0x03, 0xF8, 0x01, 0xFE, 0x07, 0xF0, 0x03, 0xFC, 0x1F, 0xE0,
  0x1F, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xC0, 0x1F, 0xE0, 0x3F, 0x80, 0x1F, 0xE0, 0x7F, 0x00, 0x1F,
  0xC0, 0xFE, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0xFE,
  0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x07, 0xF0,
  0x7F, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0xFF, 0x07,
  0xF0, 0x03, 0xFE, 0x0F, 0xE0, 0x1F, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFE,
  0x01, 0xFE, 0x07, 0xF8, 0x01, 0xFC, 0x1F, 0xE0, 0x03, 0xF8, 0x3F, 0x80,
  0x03, 0xF8, 0xFF, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x0F, 0xE3, 0xF8, 0x00,
  0x1F, 0xCF, 0xF0, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x7F, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x7F, 0x00, 0x03, 0xF8, 0xFE,
  0x00, 0x07, 0xF1, 0xFC, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x3F, 0x87, 0xF0,
  0x00, 0xFF, 0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0,
  0x1F, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFC, 0x0F, 0xF8, 0x03, 0xF8,
  0x03, 0xFC, 0x03, 0xF8, 0x01, 0xFC, 0x03, 0xF8, 0x01, 0xFE, 0x03, 0xF8,
  0x00, 0xFE, 0x07, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x07, 0xF0,
  0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x07, 0xF0,
  0x00, 0xFE, 0x0F, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0,
  0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0,
  0x01, 0xFE, 0x1F, 0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0,
  0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0,
  0x03, 0xF8, 0x3F, 0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x80,
  0x07, 0xF8, 0x3F, 0x80, 0x07, 0xF0, 0x3F, 0x80, 0x0F, 0xF0, 0x7F, 0x80,
  0x1F, 0xE0, 0x7F, 0x00, 0x3F, 0xE0, 0x7F, 0x00, 0x7F, 0xC0, 0x7F, 0x01,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0x80, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x01,
  0xFE, 0x01, 0xFE, 0x07, 0xF8, 0x01, 0xFC, 0x1F, 0xE0, 0x03, 0xFC, 0x3F,
  0x80, 0x03, 0xF8, 0xFF, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x0F, 0xE3, 0xF8,
  0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x3F,
  0xFF, 0x3F, 0x80, 0xFF, 0xFE, 0x7F, 0x01, 0xFF, 0xF9, 0xFE, 0x03, 0xFF,
  0xF3, 0xFC, 0x07, 0xFF, 0xE7, 0xF0, 0x0F, 0xFF, 0xCF, 0xE0, 0x00, 0x3F,
  0x9F, 0xC0, 0x00, 0xFF, 0x3F, 0x80, 0x01, 0xFC, 0x7F, 0x00, 0x03, 0xF8,
  0xFE, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x3F, 0xC3,
  0xF8, 0x00, 0x7F, 0x87, 0xF0, 0x00, 0xFF, 0x0F, 0xF0, 0x03, 0xFC, 0x0F,
  0xF0, 0x1F, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF0,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x01, 0xFC, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x0F,
  0xF0, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x7F, 0x80, 0x01, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x3F, 0x80, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00,
  0x7F, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x3F,
  0x80, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x1F, 0xE0, 0x00, 0x7F,
  0x80, 0xFE, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x3F, 0x80,
  0x00, 0xFE, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0xFF, 0x00, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00,
  0xFE, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0x07,
  0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x01, 0xFE, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0xFF, 0x01, 0xFC, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x80, 0xFE, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x00, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE,
  0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x3F, 0xC0, 0x1F, 0xE0, 0xFF, 0x00, 0x7F, 0x03, 0xFC, 0x01,
  0xFC, 0x07, 0xF0, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0xC0, 0x7F, 0x01, 0xFE,
  0x01, 0xFE, 0x0F, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xF0,
  0x1F, 0xC0, 0x03, 0xFE, 0x01, 0xFC, 0x00, 0x7F, 0xC0, 0x1F, 0xC0, 0x0F,
  0xF8, 0x01, 0xFC, 0x01, 0xFF, 0x00, 0x1F, 0xC0, 0x1F, 0xF0, 0x03, 0xFC,
  0x03, 0xFE, 0x00, 0x3F, 0x80, 0x7F, 0xC0, 0x03, 0xF8, 0x0F, 0xF8, 0x00,
  0x3F, 0x81, 0xFF, 0x00, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0x7F, 0x83, 0xFE,
  0x00, 0x07, 0xF0, 0x7F, 0xC0, 0x00, 0x7F, 0x0F, 0xF8, 0x00, 0x07, 0xF1,
  0xFF, 0x00, 0x00, 0x7F, 0x1F, 0xE0, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x00,
  0xFF, 0x7F, 0x80, 0x00, 0x0F, 0xEF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xF9, 0xFC, 0x00, 0x01, 0xFF, 0x1F, 0xE0,
  0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0xFF, 0x00, 0x03, 0xF8, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x03,
  0xF8, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x07, 0xF0, 0x03, 0xFC,
  0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x0F,
  0xE0, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x0F, 0xE0, 0x00, 0xFF,
  0x80, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x00, 0xFF,
  0xC0, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x0F,
  0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0x1F, 0xFE, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xF0,
  0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x00,
  0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x1F,
  0xBF, 0x80, 0xFD, 0xF8, 0x00, 0xFD, 0xF8, 0x07, 0xE7, 0xC0, 0x0F, 0xDF,
  0xC0, 0x7F, 0x3F, 0x00, 0x7E, 0xFE, 0x03, 0xF9, 0xF8, 0x07, 0xE7, 0xF0,
  0x1F, 0xCF, 0xC0, 0x3F, 0x3F, 0x80, 0xFE, 0x7E, 0x03, 0xF1, 0xF8, 0x07,
  0xF3, 0xF0, 0x1F, 0x9F, 0xC0, 0x3F, 0x1F, 0x81, 0xFC, 0xFE, 0x03, 0xF8,
  0x7C, 0x0F, 0xC7, 0xF0, 0x1F, 0xC3, 0xE0, 0xFE, 0x3F, 0x80, 0xFE, 0x1F,
  0x07, 0xE1, 0xFC, 0x07, 0xF0, 0xFC, 0x3F, 0x1F, 0xC0, 0x3F, 0x87, 0xE3,
  0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x1F, 0x87, 0xF0, 0x1F, 0xE1, 0xF9, 0xF8,
  0x3F, 0x80, 0xFE, 0x0F, 0xCF, 0xC1, 0xFC, 0x07, 0xF0, 0x3E, 0xFC, 0x1F,
  0xE0, 0x3F, 0x81, 0xF7, 0xE0, 0xFE, 0x01, 0xFC, 0x0F, 0xFE, 0x07, 0xF0,
  0x1F, 0xE0, 0x7F, 0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xFF, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xF8, 0x1F, 0xE0, 0x3F, 0x80, 0xFF, 0x80, 0xFE, 0x01, 0xFC,
  0x07, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0xFF, 0x00,
  0xFE, 0x01, 0xFC, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x3F, 0x80, 0x3F,
  0x00, 0xFF, 0x01, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x07, 0xF0, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x01, 0xFC, 0x03,
  0xFE, 0x00, 0x0F, 0xE0, 0x1F, 0xF0, 0x00, 0x7F, 0x00, 0xFF, 0x80, 0x07,
  0xF8, 0x0F, 0xFC, 0x00, 0x3F, 0x80, 0x7F, 0xF0, 0x01, 0xFC, 0x03, 0xFF,
  0x80, 0x0F, 0xE0, 0x1F, 0xFC, 0x00, 0x7F, 0x00, 0xFF, 0xF0, 0x03, 0xF8,
  0x0F, 0xFF, 0x80, 0x3F, 0xC0, 0x7F, 0xFC, 0x01, 0xFC, 0x03, 0xFB, 0xF0,
  0x0F, 0xE0, 0x1F, 0xDF, 0x80, 0x7F, 0x00, 0xFE, 0xFC, 0x03, 0xF8, 0x07,
  0xF3, 0xE0, 0x1F, 0xC0, 0x7F, 0x9F, 0x81, 0xFC, 0x03, 0xF8, 0xFC, 0x0F,
  0xE0, 0x1F, 0xC3, 0xE0, 0x7F, 0x00, 0xFE, 0x1F, 0x83, 0xF8, 0x07, 0xF0,
  0xFC, 0x1F, 0xC0, 0x3F, 0x87, 0xE1, 0xFE, 0x03, 0xFC, 0x1F, 0x0F, 0xE0,
  0x1F, 0xC0, 0xFC, 0x7F, 0x00, 0xFE, 0x07, 0xE3, 0xF8, 0x07, 0xF0, 0x1F,
  0x1F, 0xC0, 0x3F, 0x80, 0xFC, 0xFE, 0x01, 0xFC, 0x07, 0xEF, 0xF0, 0x1F,
  0xE0, 0x1F, 0x7F, 0x00, 0xFE, 0x00, 0xFF, 0xF8, 0x07, 0xF0, 0x07, 0xFF,
  0xC0, 0x3F, 0x80, 0x3F, 0xFE, 0x01, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xE0,
  0x07, 0xFF, 0x80, 0xFF, 0x00, 0x3F, 0xF8, 0x07, 0xF0, 0x00, 0xFF, 0xC0,
  0x3F, 0x80, 0x07, 0xFE, 0x01, 0xFC, 0x00, 0x3F, 0xF0, 0x0F, 0xE0, 0x00,
  0xFF, 0x80, 0xFF, 0x00, 0x07, 0xF8, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x3F,
  0x80, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFC, 0x03, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x01, 0xFC, 0x07, 0xF0, 0x01,
  0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x00,
  0xFE, 0x1F, 0xC0, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0xFE, 0x3F, 0x80, 0x00,
  0xFE, 0x3F, 0x80, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0xFE, 0x3F, 0x80, 0x00,
  0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00,
  0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x01, 0xFE, 0x7F, 0x00, 0x01,
  0xFC, 0xFF, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x01,
  0xFC, 0xFE, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x03,
  0xF8, 0xFE, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x07,
  0xF0, 0xFE, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x1F,
  0xE0, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xC0, 0x7F, 0xC0, 0x3F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x07, 0xF0, 0x01, 0xFE, 0x03, 0xF8,
  0x00, 0x7F, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x1F, 0xC0, 0xFF,
  0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x07, 0xF8, 0x3F, 0x80, 0x03, 0xFC, 0x1F,
  0xC0, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x7F, 0x07,
  0xF8, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x3F, 0xC0,
  0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0x00, 0x7F, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFE, 0x07, 0xFC, 0x07,
  0xF8, 0x01, 0xFC, 0x0F, 0xF0, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x1F,
  0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0xFE, 0x3F,
  0x80, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0xFE, 0x3F,
  0x80, 0x00, 0xFE, 0x7F, 0x80, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x7F,
  0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x7F,
  0x00, 0x01, 0xFC, 0xFF, 0x00, 0x01, 0xFC, 0xFF, 0x00, 0x01, 0xFC, 0xFE,
  0x00, 0x01, 0xFC, 0xFE, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x01, 0xFC, 0xFE,
  0x00, 0x03, 0xF8, 0xFE, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x03, 0xF8, 0xFE,
  0x00, 0x07, 0xF8, 0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x07, 0xF0, 0xFF,
  0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x3F, 0xC0, 0x7F,
  0xC0, 0x7F, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x0D, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x04, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x03,
  0xFC, 0x07, 0xFE, 0x03, 0xF8, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x03,
  0xF8, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0xFE, 0x07,
  0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x07,
  0xF0, 0x00, 0xFE, 0x07, 0xF0, 0x01, 0xFE, 0x0F, 0xF0, 0x01, 0xFC, 0x0F,
  0xE0, 0x03, 0xFC, 0x0F, 0xE0, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xF8, 0x0F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x1F,
  0xC0, 0xFE, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x3F,
  0x80, 0x7F, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x3F,
  0x80, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0x80, 0x7F, 0x80, 0x3F, 0x80, 0x7F,
  0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x1F, 0xC0, 0x7F,
  0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x1F, 0xE0, 0xFE,
  0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xFF,
  0x01, 0xFE, 0x03, 0xFC, 0x01, 0xFC, 0x07, 0xF0, 0x03, 0xFC, 0x1F, 0xE0,
  0x03, 0xF8, 0x3F, 0x80, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xE0, 0xFE, 0x00,
  0x1F, 0xC1, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0xFF,
  0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x3F, 0x83, 0xF8,
  0x00, 0x7F, 0x07, 0xF0, 0x01, 0xFE, 0x0F, 0xF0, 0x07, 0xF8, 0x0F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x1F, 0xC1,
  0xFE, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x07, 0xF8,
  0x3F, 0x80, 0x03, 0xF8, 0x1F, 0xC0, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0xFE,
  0x0F, 0xF0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x3F,
  0x81, 0xFC, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x07,
  0xF0, 0x7F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xFC, 0x1F, 0xC0, 0x01,
  0xFC, 0x0F, 0xE0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x7F, 0x03, 0xF8, 0x00,
  0x3F, 0x83, 0xFC, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x1F, 0xE0, 0xFE, 0x00,
  0x0F, 0xE0, 0x7F, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x03, 0xF8, 0x1F, 0xC0,
  0x01, 0xFC, 0x1F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFF, 0x07, 0xF0,
  0x00, 0x7F, 0x03, 0xF8, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x1F, 0xC0, 0xFE,
  0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x07, 0xF0, 0x1F,
  0xC0, 0x03, 0xF8, 0x0F, 0xE0, 0x03, 0xFC, 0x07, 0xF8, 0x03, 0xFC, 0x03,
  0xFE, 0x03, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x7F, 0x80, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x7F, 0x8F, 0xE0, 0x00,
  0x3F, 0xC7, 0xF0, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x1F, 0xE1, 0xFC, 0x00,
  0x0F, 0xF0, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x07, 0xF8, 0x3F, 0xC0,
  0x03, 0xF8, 0x1F, 0xE0, 0x03, 0xFC, 0x07, 0xF0, 0x01, 0xFC, 0x03, 0xF8,
  0x01, 0xFE, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x3F, 0xC0, 0x07,
  0xE0, 0x1F, 0xC0, 0x03, 0xF8, 0x0F, 0xE0, 0x01, 0xFC, 0x0F, 0xE0, 0x00,
  0xFE, 0x07, 0xF0, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x3F, 0x83, 0xF8, 0x00,
  0x1F, 0xC3, 0xFC, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x03, 0xF0, 0xFE, 0x00,
  0x01, 0xF8, 0xFE, 0x00, 0x00, 0xFC, 0x7F, 0x00, 0x00, 0x7E, 0x7F, 0x00,
  0x00, 0x3F, 0xBF, 0x80, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x3F, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xC0, 0x0F, 0xFF, 0xE0, 0x07,
  0xF0, 0x03, 0xFB, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0xBF, 0x80, 0x3F, 0xC0, 0x1F, 0xCF, 0xE0, 0x0F, 0xF0, 0x07, 0xF3,
  0xF8, 0x07, 0xFC, 0x01, 0xFC, 0xFE, 0x01, 0xFF, 0x00, 0xFE, 0x3F, 0x80,
  0x7F, 0xC0, 0x3F, 0x8F, 0xE0, 0x3F, 0xF0, 0x0F, 0xE3, 0xF8, 0x0F, 0xFC,
  0x07, 0xF0, 0xFE, 0x07, 0xFF, 0x01, 0xFC, 0x3F, 0x81, 0xFF, 0xC0, 0x7F,
  0x0F, 0xE0, 0x7F, 0xF0, 0x3F, 0x83, 0xF8, 0x3F, 0x7C, 0x0F, 0xE0, 0xFE,
  0x0F, 0xDF, 0x83, 0xF8, 0x3F, 0x83, 0xF7, 0xE1, 0xFC, 0x0F, 0xE1, 0xF9,
  0xF8, 0x7F, 0x03, 0xF8, 0x7E, 0x7E, 0x1F, 0xC0, 0xFE, 0x1F, 0x1F, 0x8F,
  0xE0, 0x3F, 0x8F, 0xC7, 0xE3, 0xF8, 0x0F, 0xE3, 0xF1, 0xF8, 0xFE, 0x03,
  0xF8, 0xF8, 0x7E, 0x3F, 0x00, 0xFE, 0x7E, 0x1F, 0x9F, 0xC0, 0x3F, 0x9F,
  0x87, 0xE7, 0xF0, 0x0F, 0xEF, 0xC1, 0xF9, 0xF8, 0x01, 0xFB, 0xF0, 0x3E,
  0xFE, 0x00, 0x7E, 0xFC, 0x0F, 0xBF, 0x00, 0x1F, 0xFE, 0x03, 0xEF, 0xC0,
  0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x7F,
  0xF0, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0x80,
  0x1F, 0xE0, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x00, 0x7F, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x7F, 0x80, 0x00,
  0x0F, 0xE3, 0xFC, 0x00, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x00, 0x7F, 0x7F,
  0x80, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xDF, 0xC0, 0x00, 0x00, 0xFF, 0x7F, 0x00,
  0x00, 0x07, 0xF9, 0xFE, 0x00, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x00, 0xFF,
  0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0xFF, 0x00,
  0x00, 0xFF, 0x01, 0xFC, 0x00, 0x07, 0xFC, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x07, 0xFC, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x07, 0xFC, 0x00,
  0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x01, 0xFE, 0xFE,
  0x00, 0x07, 0xF9, 0xFC, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x3F, 0xC7, 0xF8,
  0x00, 0xFF, 0x07, 0xF0, 0x01, 0xFE, 0x0F, 0xE0, 0x07, 0xF8, 0x1F, 0xC0,
  0x0F, 0xF0, 0x3F, 0x80, 0x3F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0x7F, 0x01,
  0xFE, 0x00, 0xFE, 0x03, 0xF8, 0x01, 0xFC, 0x0F, 0xF0, 0x01, 0xF8, 0x1F,
  0xC0, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xE3, 0xF8,
  0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0,
  0x07, 0xFF, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00,
  0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0x7F, 0xF0, 0x07,
  0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F,
  0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0x7C, 0x03, 0xF7, 0xC0, 0x3E, 0x7C, 0x07,
  0xE7, 0xC0, 0x7C, 0x7C, 0x0F, 0xC7, 0xE0, 0xF8, 0x3E, 0x1F, 0x83, 0xE1,
  0xF0, 0x3E, 0x3F, 0x03, 0xE3, 0xE0, 0x3E, 0x7E, 0x03, 0xF7, 0xC0, 0x3F,
  0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x7F, 0x07, 0xF8, 0x3F, 0x81, 0xFC,
  0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x00, 0x01, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF8, 0x3F, 0xE3, 0xFC, 0x1F, 0xE0, 0xFF, 0x0F, 0xE0, 0x3F,
  0x8F, 0xE0, 0x1F, 0xC7, 0xF0, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC7, 0xFC, 0x1F, 0xC7, 0xF8,
  0x0F, 0xE3, 0xF8, 0x07, 0xF1, 0xFC, 0x03, 0xF9, 0xFC, 0x01, 0xFC, 0xFE,
  0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x3F, 0x80, 0x7F, 0x1F, 0xE0, 0x7F, 0x8F,
  0xF9, 0xFF, 0xC3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8,
  0x1F, 0xFD, 0xFC, 0x07, 0xF8, 0xFE, 0x00, 0x20, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF9, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x07, 0xF8, 0x1F, 0xE0,
  0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0x7E, 0x0F, 0xE0,
  0x07, 0xE0, 0xFE, 0x00, 0x7E, 0x0F, 0xE0, 0x07, 0xE0, 0xFE, 0x00, 0xFE,
  0x1F, 0xC0, 0x0F, 0xE1, 0xFC, 0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xE1, 0xFC,
  0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xE1, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x0F,
  0xC3, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x1F, 0xC3, 0xF8, 0x01, 0xFC, 0x3F,
  0x80, 0x3F, 0x83, 0xFC, 0x03, 0xF8, 0x7F, 0xC0, 0x7F, 0x87, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x7E, 0x7F, 0xFC, 0x07,
  0xE3, 0xFF, 0x80, 0xFE, 0x1F, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x7F,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x7F, 0xE7, 0xF8, 0x3F, 0x80, 0xFE, 0x3F,
  0x80, 0x7F, 0x1F, 0xC0, 0x1F, 0x8F, 0xC0, 0x0F, 0xCF, 0xE0, 0x07, 0xE7,
  0xF0, 0x03, 0xF3, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x01,
  0xF8, 0xFE, 0x00, 0xFC, 0x7F, 0x00, 0xFE, 0x3F, 0x80, 0x7F, 0x1F, 0xE0,
  0x7F, 0x07, 0xFC, 0xFF, 0x83, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x04, 0x07, 0xF0, 0x03, 0xFC, 0x3F, 0x80, 0x7F, 0xF9, 0xFC, 0x07, 0xFF,
  0xDF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xF7, 0xFF,
  0x81, 0xFE, 0x07, 0xFC, 0x1F, 0xE0, 0x1F, 0xE0, 0xFE, 0x00, 0xFE, 0x0F,
  0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x83, 0xF8, 0x01, 0xFC, 0x1F, 0xC0,
  0x0F, 0xE1, 0xFC, 0x00, 0x7E, 0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x3F,
  0x83, 0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0xFE, 0x00, 0x7F, 0x07,
  0xF0, 0x03, 0xF0, 0x3F, 0x80, 0x3F, 0x81, 0xFC, 0x01, 0xFC, 0x0F, 0xE0,
  0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0x03, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x3F,
  0x80, 0xFF, 0x03, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFE, 0xFC, 0x00, 0x3F,
  0xE7, 0xE0, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF0, 0x3F, 0xE7, 0xFC, 0x3F, 0xC0, 0xFE, 0x1F, 0xC0, 0x7F, 0x1F, 0xC0,
  0x1F, 0x8F, 0xE0, 0x0F, 0xCF, 0xE0, 0x07, 0xF7, 0xF0, 0x03, 0xFB, 0xF8,
  0x01, 0xFD, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x0C, 0x0F, 0xE0, 0x1E, 0x07, 0xFE, 0x7F,
  0x81, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x03, 0xFF,
  0xE0, 0x0F, 0xF8, 0x80, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x07, 0xFF, 0xFC,
  0x1F, 0xFF, 0xE0, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x01, 0xFF, 0x0F, 0xC0, 0x3F, 0xFC, 0xFE, 0x03, 0xFF, 0xF7, 0xF0, 0x3F,
  0xFF, 0xBF, 0x81, 0xFF, 0xFF, 0xF8, 0x1F, 0xFD, 0xFF, 0xC0, 0xFF, 0x03,
  0xFE, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F, 0x00, 0x7F, 0x87, 0xF8, 0x01, 0xFC,
  0x3F, 0x80, 0x1F, 0xC1, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0x7E,
  0x00, 0x3F, 0x87, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xE1, 0xFC, 0x00,
  0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x83, 0xF8, 0x01, 0xFC,
  0x1F, 0xC0, 0x0F, 0xE0, 0xFE, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0x3F,
  0x80, 0x3F, 0x81, 0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x1F, 0xE0, 0x7F, 0x81,
  0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0x7F, 0x00, 0x1F, 0xF3, 0xF8, 0x00,
  0x08, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x06, 0x00, 0x7F, 0x80, 0x7C, 0x07, 0xFC,
  0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x40, 0x00, 0xFE,
  0x7F, 0x80, 0x1F, 0xBF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0x3F, 0xE0, 0x7F, 0x81, 0xFC, 0x0F, 0xE0,
  0x3F, 0x83, 0xF8, 0x03, 0xF0, 0x7F, 0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xC1,
  0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x07, 0xE0, 0x0F, 0xE1, 0xFC, 0x01,
  0xFC, 0x3F, 0x80, 0x3F, 0x87, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0xFC, 0x1F,
  0xC0, 0x3F, 0x87, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x1F,
  0xC3, 0xF8, 0x03, 0xF8, 0x7F, 0x00, 0x7E, 0x0F, 0xE0, 0x1F, 0xC3, 0xF8,
  0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xE1, 0xFC, 0x01, 0xFC,
  0x3F, 0x80, 0x3F, 0x07, 0xE0, 0x0F, 0xE1, 0xFC, 0x01, 0xFC, 0x3F, 0x80,
  0x3F, 0x80, 0x00, 0x70, 0x07, 0xE0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0x80, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80,
  0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x1F,
  0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0xFF, 0x80, 0xFE, 0x03, 0xFC, 0x03, 0xF0,
  0x1F, 0xE0, 0x1F, 0xC0, 0xFF, 0x00, 0x7F, 0x07, 0xFC, 0x01, 0xFC, 0x3F,
  0xE0, 0x07, 0xF0, 0xFF, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0xFE, 0x3F, 0xC0,
  0x03, 0xF9, 0xFE, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFE, 0x7F, 0x00, 0x0F, 0xF1, 0xFC,
  0x00, 0x3F, 0x87, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0x80,
  0x0F, 0xC0, 0xFF, 0x00, 0x7F, 0x01, 0xFC, 0x01, 0xFC, 0x07, 0xF0, 0x07,
  0xF0, 0x1F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFF, 0x01, 0xF8,
  0x03, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0xFE, 0x01, 0xFC, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE,
  0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x20, 0x00, 0xFC, 0x7F, 0x80, 0xFF, 0x00, 0x3F,
  0x7F, 0xF0, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x7F, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xE7, 0xFF, 0xEF,
  0xFC, 0x1F, 0xE0, 0x7F, 0xE0, 0xFF, 0x07, 0xF0, 0x1F, 0xF0, 0x1F, 0xC1,
  0xF8, 0x07, 0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x3F, 0x80,
  0x7F, 0x00, 0x7F, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC3, 0xF8, 0x07, 0xF0,
  0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x7F, 0x00, 0x7F, 0x00, 0xFE,
  0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0x87, 0xF0, 0x07, 0xE0, 0x0F, 0xE1, 0xFC,
  0x03, 0xF8, 0x03, 0xF8, 0x7F, 0x00, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x3F,
  0x80, 0x3F, 0x8F, 0xE0, 0x0F, 0xE0, 0x1F, 0xC3, 0xF8, 0x03, 0xF8, 0x07,
  0xF0, 0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x00, 0x7F, 0x0F,
  0xE0, 0x1F, 0xC0, 0x1F, 0xC3, 0xF0, 0x07, 0xF0, 0x07, 0xF1, 0xFC, 0x01,
  0xFC, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xC0,
  0x3F, 0x87, 0xF0, 0x0F, 0xE0, 0x0F, 0xE1, 0xFC, 0x03, 0xF8, 0x03, 0xF8,
  0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x7E, 0x3F, 0xC0, 0x0F, 0xDF, 0xFC, 0x03, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x3F,
  0xC0, 0xFE, 0x07, 0xF0, 0x1F, 0xC1, 0xFC, 0x01, 0xF8, 0x3F, 0x80, 0x3F,
  0x07, 0xF0, 0x07, 0xE0, 0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x83, 0xF0,
  0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xC3, 0xF8, 0x03, 0xF8,
  0x7F, 0x00, 0x7E, 0x0F, 0xE0, 0x1F, 0xC3, 0xF8, 0x03, 0xF8, 0x7F, 0x00,
  0x7F, 0x0F, 0xE0, 0x0F, 0xE1, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x07,
  0xF0, 0x0F, 0xE1, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x87, 0xF0, 0x07,
  0xF0, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0x83, 0xF8, 0x07, 0xF0, 0xFE,
  0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xC0, 0xFF, 0x9F, 0xF0, 0x7F, 0x81, 0xFE, 0x1F, 0xC0, 0x3F, 0x8F,
  0xE0, 0x0F, 0xE3, 0xF8, 0x03, 0xF9, 0xFC, 0x00, 0x7E, 0x7F, 0x00, 0x1F,
  0xDF, 0xC0, 0x07, 0xF7, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00,
  0x1F, 0xBF, 0x80, 0x0F, 0xEF, 0xE0, 0x03, 0xFB, 0xF8, 0x00, 0xFE, 0xFE,
  0x00, 0x3F, 0xBF, 0x80, 0x0F, 0xEF, 0xE0, 0x03, 0xF3, 0xF8, 0x01, 0xFC,
  0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x3F, 0x8F, 0xF0, 0x0F, 0xE1, 0xFC, 0x07,
  0xF0, 0x7F, 0xCF, 0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xE3, 0xFC, 0x00, 0x3F, 0x7F, 0xF0, 0x01,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0x7F, 0xE0, 0x3F, 0xC0, 0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x1F, 0xC0, 0x1F,
  0xC0, 0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x03, 0xF0, 0x3F, 0x80, 0x1F, 0x81,
  0xFC, 0x00, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0x7F, 0x07, 0xF0,
  0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xC1, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x07,
  0xF0, 0x7F, 0x00, 0x3F, 0x87, 0xF0, 0x01, 0xF8, 0x3F, 0x80, 0x1F, 0xC1,
  0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x03, 0xF8,
  0x03, 0xF8, 0x3F, 0xE0, 0x3F, 0xC1, 0xFF, 0xCF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFE, 0x03, 0xFB, 0xFF, 0xE0, 0x1F, 0x8F, 0xFE, 0x01,
  0xFC, 0x3F, 0xC0, 0x0F, 0xE0, 0x30, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x1F, 0xF1, 0xFC, 0x0F, 0xFF,
  0x3F, 0x83, 0xFF, 0xF7, 0xE0, 0xFF, 0xFE, 0xFC, 0x1F, 0xFF, 0xFF, 0x87,
  0xFE, 0x7F, 0xF1, 0xFF, 0x03, 0xFE, 0x3F, 0xC0, 0x3F, 0xC7, 0xF0, 0x07,
  0xF1, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0xC7, 0xF0, 0x03, 0xF8, 0xFE,
  0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xE7, 0xF0, 0x03, 0xF8, 0xFE, 0x00, 0x7F,
  0x1F, 0xC0, 0x0F, 0xE3, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x8F, 0xE0,
  0x07, 0xF1, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x87, 0xF0, 0x07, 0xF0,
  0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xC3, 0xF8, 0x07, 0xF0, 0x7F, 0x81,
  0xFE, 0x0F, 0xFC, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0x7F, 0x00, 0x02, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x3F, 0x03,
  0xF7, 0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0,
  0x7F, 0xFF, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF8, 0x3F, 0xC3, 0xFC, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0x3F, 0x0F,
  0xE0, 0x1F, 0xC7, 0xF0, 0x0F, 0xE3, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0xFC, 0x00,
  0xFC, 0x7F, 0x00, 0xFE, 0x3F, 0x80, 0x7F, 0x1F, 0xC0, 0x7F, 0x87, 0xF0,
  0x7F, 0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x08, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xE0, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xCF, 0xFF, 0xEF, 0xFF,
  0xF0, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF0,
  0x00, 0xC0, 0x00, 0x0F, 0xE0, 0x0F, 0xC1, 0xF8, 0x03, 0xF8, 0x7F, 0x00,
  0x7F, 0x0F, 0xE0, 0x0F, 0xE1, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x87,
  0xF0, 0x0F, 0xE0, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x87, 0xF0, 0x07,
  0xF0, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xC3, 0xF8, 0x07, 0xF0, 0x7E,
  0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xC3, 0xF8, 0x03, 0xF8, 0x7F, 0x00, 0x7F,
  0x0F, 0xE0, 0x0F, 0xE1, 0xFC, 0x03, 0xF8, 0x3F, 0x00, 0x7F, 0x0F, 0xE0,
  0x0F, 0xE1, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x87, 0xF0, 0x07, 0xF0,
  0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x83, 0xFC, 0x0F, 0xF0, 0x3F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00,
  0xFF, 0xEF, 0xC0, 0x0F, 0xF3, 0xF8, 0x00, 0x30, 0x00, 0x00, 0xFE, 0x00,
  0x7F, 0x3F, 0x00, 0x3F, 0x9F, 0xC0, 0x3F, 0xCF, 0xE0, 0x1F, 0xC7, 0xF0,
  0x0F, 0xE3, 0xF8, 0x0F, 0xE1, 0xFC, 0x07, 0xF0, 0xFE, 0x03, 0xF0, 0x7F,
  0x03, 0xF8, 0x1F, 0x81, 0xFC, 0x0F, 0xC1, 0xFC, 0x07, 0xE0, 0xFE, 0x03,
  0xF0, 0x7E, 0x01, 0xF8, 0x7F, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x1F, 0x80,
  0x3F, 0x1F, 0xC0, 0x0F, 0xCF, 0xC0, 0x07, 0xEF, 0xE0, 0x03, 0xF7, 0xE0,
  0x01, 0xFB, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xFF, 0xC0,
  0x3F, 0x00, 0x7E, 0xFC, 0x03, 0xF0, 0x0F, 0xEF, 0xC0, 0x3F, 0x00, 0xFE,
  0xFC, 0x07, 0xF8, 0x1F, 0xCF, 0xC0, 0x7F, 0x81, 0xFC, 0xFC, 0x0F, 0xF8,
  0x1F, 0x8F, 0xC0, 0xFF, 0x83, 0xF8, 0xFC, 0x0F, 0xF8, 0x3F, 0x8F, 0xC1,
  0xFF, 0x83, 0xF0, 0xFC, 0x1F, 0xF8, 0x7F, 0x0F, 0xC3, 0xFF, 0x87, 0xE0,
  0xFE, 0x3F, 0xF8, 0x7E, 0x0F, 0xE7, 0xEF, 0x8F, 0xE0, 0xFE, 0x7E, 0xF8,
  0xFC, 0x07, 0xE7, 0xCF, 0x8F, 0xC0, 0x7E, 0xFC, 0xF9, 0xFC, 0x07, 0xEF,
  0x8F, 0x9F, 0x80, 0x7F, 0xF8, 0xFD, 0xF8, 0x07, 0xFF, 0x8F, 0xFF, 0x00,
  0x7F, 0xF0, 0xFF, 0xF0, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x7F,
  0xE0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x07, 0xFC,
  0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x07, 0xF8, 0x07, 0xF8, 0x00,
  0x7F, 0x80, 0x7F, 0x80, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF8, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0x7F,
  0x03, 0xFC, 0x01, 0xFC, 0x1F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xE3,
  0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x7E, 0x7F, 0x00, 0x01, 0xFD, 0xFC,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xDF,
  0x80, 0x00, 0xFF, 0x7F, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x1F, 0xC3, 0xF0,
  0x00, 0xFF, 0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xE0, 0xFE, 0x00,
  0xFF, 0x01, 0xFC, 0x03, 0xFC, 0x07, 0xF0, 0x1F, 0xE0, 0x1F, 0xC0, 0x7F,
  0x00, 0x7F, 0x80, 0x07, 0xF8, 0x03, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0x3F,
  0x80, 0x7F, 0x80, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x0F, 0xE0,
  0x3F, 0x80, 0x3F, 0x80, 0xFE, 0x00, 0xFE, 0x07, 0xF8, 0x03, 0xF8, 0x1F,
  0xC0, 0x0F, 0xE0, 0xFF, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x7E, 0x0F, 0xE0,
  0x01, 0xF8, 0x7F, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x1F, 0x8F, 0xE0, 0x00,
  0x7E, 0x3F, 0x80, 0x01, 0xF8, 0xFC, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x1F,
  0xDF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x40, 0x00, 0x78, 0x00, 0x1F, 0x00,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF0,
  0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x00, 0x00, 0x20, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x7F,
  0x80, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7C, 0x00,
  0x07, 0x80, 0x00, 0x60, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x07, 0xC7, 0xFF, 0x00, 0x7E, 0x7F, 0xFC, 0x03, 0xE3, 0xFF, 0xF0, 0x1F,
  0x3F, 0xFF, 0xC1, 0xF9, 0xF8, 0xFF, 0x1F, 0xCF, 0x83, 0xFF, 0xFC, 0xFC,
  0x0F, 0xFF, 0xE7, 0xC0, 0x3F, 0xFE, 0x3E, 0x00, 0xFF, 0xE1, 0xF0, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0xC0, 0x00,
};

const GFXglyph RobotoCondensed_MediumItalic62pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 15, 45, 15, 1, -44 },
  { 86, 16, 16, 19, 5, -47 },
  { 118, 31, 44, 32, 2, -44 },
  { 289, 27, 58, 30, 2, -51 },
  { 485, 28, 46, 38, 6, -45 },
  { 646, 30, 46, 34, 1, -45 },
  { 819, 8, 16, 10, 4, -47 },
  { 835, 19, 63, 19, 3, -49 },
  { 985, 19, 63, 19, -3, -49 },
  { 1135, 25, 26, 27, 3, -44 },
  { 1217, 26, 32, 29, 2, -37 },
  { 1321, 11, 17, 13, -3, -7 },
  { 1345, 15, 6, 19, 2, -22 },
  { 1357, 9, 9, 17, 1, -8 },
  { 1368, 28, 48, 21, -4, -44 },
  { 1536, 26, 46, 30, 3, -45 },
  { 1686, 17, 44, 30, 7, -44 },
  { 1780, 29, 45, 30, 0, -45 },
  { 1944, 28, 46, 30, 1, -45 },
  { 2105, 27, 44, 30, 1, -44 },
  { 2254, 28, 45, 30, 2, -44 },
  { 2412, 24, 45, 30, 3, -44 },
  { 2547, 29, 44, 30, 3, -44 },
  { 2707, 27, 46, 30, 2, -45 },
  { 2863, 24, 45, 30, 4, -45 },
  { 2998, 13, 35, 16, 1, -34 },
  { 3055, 17, 44, 14, -3, -34 },
  { 3149, 24, 29, 27, 2, -34 },
  { 3236, 25, 19, 30, 3, -30 },
  { 3296, 25, 28, 27, 1, -33 },
  { 3384, 22, 46, 26, 5, -45 },
  { 3511, 43, 57, 46, 1, -43 },
  { 3818, 33, 44, 35, -2, -44 },
  { 4000, 31, 44, 33, 1, -44 },
  { 4171, 31, 46, 34, 3, -45 },
  { 4350, 32, 44, 34, 1, -44 },
  { 4526, 31, 44, 30, 1, -44 },
  { 4697, 31, 44, 29, 1, -44 },
  { 4868, 31, 46, 35, 3, -45 },
  { 5047, 37, 44, 37, 1, -44 },
  { 5251, 15, 44, 16, 1, -44 },
  { 5334, 30, 45, 29, 0, -44 },
  { 5503, 36, 44, 33, 1, -44 },
  { 5701, 24, 44, 29, 1, -44 },
  { 5833, 45, 44, 46, 1, -44 },
  { 6081, 37, 44, 37, 1, -44 },
  { 6285, 32, 46, 36, 3, -45 },
  { 6469, 33, 44, 34, 1, -44 },
  { 6651, 32, 53, 36, 3, -45 },
  { 6863, 32, 44, 33, 1, -44 },
  { 7039, 31, 46, 32, 1, -45 },
  { 7218, 30, 44, 32, 5, -44 },
  { 7383, 33, 45, 34, 2, -44 },
  { 7569, 33, 44, 34, 5, -44 },
  { 7751, 42, 44, 45, 6, -44 },
  { 7982, 38, 44, 33, -2, -44 },
  { 8191, 31, 44, 32, 5, -44 },
  { 8362, 35, 44, 32, -1, -44 },
  { 8555, 20, 61, 16, -1, -51 },
  { 8708, 14, 48, 23, 5, -44 },
  { 8792, 20, 61, 16, -3, -51 },
  { 8945, 20, 22, 23, 2, -44 },
  { 9000, 24, 6, 24, -4, 0 },
  { 9018, 12, 9, 19, 6, -46 },
  { 9032, 25, 35, 29, 1, -34 },
  { 9142, 28, 48, 30, 0, -47 },
  { 9310, 25, 35, 28, 2, -34 },
  { 9420, 29, 48, 30, 2, -47 },
  { 9594, 25, 35, 29, 2, -34 },
  { 9704, 22, 48, 19, 2, -48 },
  { 9836, 29, 47, 30, 0, -34 },
  { 10007, 27, 47, 29, 0, -47 },
  { 10166, 14, 46, 15, 1, -46 },
  { 10247, 21, 59, 14, -6, -46 },
  { 10402, 30, 47, 28, 0, -47 },
  { 10579, 15, 47, 15, 1, -47 },
  { 10668, 42, 34, 45, 0, -34 },
  { 10847, 27, 34, 29, 0, -34 },
  { 10962, 26, 35, 30, 2, -34 },
  { 11076, 29, 47, 30, -2, -34 },
  { 11247, 27, 47, 30, 2, -34 },
  { 11406, 20, 34, 19, 0, -34 },
  { 11491, 25, 35, 27, 1, -34 },
  { 11601, 17, 42, 18, 2, -41 },
  { 11691, 27, 34, 29, 2, -33 },
  { 11806, 25, 33, 26, 3, -33 },
  { 11910, 36, 33, 39, 4, -33 },
  { 12059, 30, 33, 27, -2, -33 },
  { 12183, 30, 46, 26, -2, -33 },
  { 12356, 28, 33, 27, -1, -33 },
  { 12472, 19, 59, 18, 2, -48 },
  { 12613, 13, 52, 15, 1, -44 },
  { 12698, 20, 59, 18, -3, -48 },
  { 12846, 29, 13, 34, 3, -25 },
};

const GFXfont RobotoCondensed_MediumItalic62pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_MediumItalic62pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_MediumItalic62pt7bGlyphs,
  0x20, 0x7E, 73
};

#endif // _ROBOTOCONDENSED_MEDIUMITALIC62PT7B_H_
