#ifndef _ROBOTOCONDENSED_MEDIUMITALIC50PT7B_H_
#define _ROBOTOCONDENSED_MEDIUMITALIC50PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-MediumItalic.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_MediumItalic50pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7C, 0x07, 0xC0, 0x7C, 0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x1F, 0x81, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x03,
  0xE0, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x7C, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0x7C, 0x03, 0x80, 0x3C, 0x79, 0xE3, 0xDF, 0x1E,
  0xF9, 0xF7, 0x8F, 0x3C, 0x79, 0xE3, 0xCF, 0x1E, 0x70, 0xE7, 0x87, 0x3C,
  0x79, 0xE3, 0xCE, 0x1C, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x1E, 0x00,
  0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x1C, 0x3C, 0x00,
  0x3C, 0x3C, 0x00, 0x3C, 0x38, 0x00, 0x38, 0x78, 0x00, 0x78, 0x78, 0x0F,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x00,
  0xE1, 0xE0, 0x01, 0xE1, 0xE0, 0x01, 0xE1, 0xE0, 0x01, 0xE3, 0xC0, 0x03,
  0xC3, 0xC0, 0x03, 0xC3, 0xC0, 0x03, 0xC7, 0x80, 0x07, 0x87, 0x80, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0x0F,
  0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x1C,
  0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x38, 0x00, 0x38, 0x78, 0x00, 0x78,
  0x78, 0x00, 0x78, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0x00,
  0x3F, 0xFC, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x83, 0xF8, 0x7E, 0x1F, 0x83,
  0xF0, 0xF8, 0x0F, 0x8F, 0xC0, 0x7C, 0x7E, 0x03, 0xE3, 0xF0, 0x1F, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF3,
  0xE0, 0x0F, 0x9F, 0x00, 0xFC, 0xF8, 0x07, 0xE7, 0xE0, 0x3F, 0x3F, 0x03,
  0xF1, 0xFC, 0x3F, 0x87, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFC, 0x03,
  0xFF, 0x80, 0x07, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x7C, 0x78, 0x08, 0x78, 0x78, 0x1C,
  0x78, 0x38, 0x3C, 0x78, 0x38, 0x7C, 0x78, 0x78, 0x78, 0x70, 0x78, 0xF0,
  0x70, 0x79, 0xE0, 0x70, 0x79, 0xE0, 0x78, 0xF3, 0xC0, 0x7F, 0xF7, 0x80,
  0x3F, 0xE7, 0x80, 0x3F, 0xCF, 0x00, 0x0F, 0x9E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x79, 0xF0, 0x00, 0xF3, 0xFC, 0x00, 0xF7, 0xFE,
  0x01, 0xEF, 0xFE, 0x03, 0xCF, 0x1E, 0x03, 0xDE, 0x0F, 0x07, 0x9E, 0x0F,
  0x0F, 0x1E, 0x0F, 0x0F, 0x1E, 0x0F, 0x1E, 0x1E, 0x0E, 0x3C, 0x1E, 0x1E,
  0x78, 0x1E, 0x1E, 0x38, 0x1E, 0x1E, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x03, 0xF1, 0xF8,
  0x03, 0xE0, 0xF8, 0x03, 0xE0, 0xF8, 0x07, 0xC0, 0xF8, 0x07, 0xC0, 0xF8,
  0x07, 0xC1, 0xF0, 0x07, 0xE3, 0xF0, 0x03, 0xE7, 0xE0, 0x03, 0xEF, 0xC0,
  0x03, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xFE, 0x1F, 0x1F, 0xFE, 0x1F, 0x3F, 0x3F, 0x1F,
  0x3F, 0x3F, 0x3E, 0x7E, 0x1F, 0xBE, 0x7E, 0x1F, 0xBE, 0xFC, 0x0F, 0xFC,
  0xFC, 0x0F, 0xFC, 0xFC, 0x07, 0xFC, 0xFC, 0x07, 0xF8, 0xFC, 0x03, 0xF0,
  0x7E, 0x07, 0xF0, 0x7F, 0x0F, 0xF8, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC,
  0x1F, 0xFE, 0xFC, 0x07, 0xF8, 0x7E, 0x00, 0xC0, 0x00, 0x7D, 0xF7, 0xDE,
  0x79, 0xE7, 0xBE, 0xF3, 0xCF, 0x3C, 0xE0, 0x00, 0x02, 0x00, 0x0E, 0x00,
  0x1E, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3E,
  0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x03, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xF8, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xC0, 0x02, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x00, 0x70, 0x70, 0x6F, 0xCF, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xC0, 0x3F, 0xC0, 0x03, 0xF0, 0x00, 0x7F, 0x80,
  0x0F, 0xF8, 0x01, 0xF3, 0xC0, 0x3E, 0x3E, 0x07, 0xC1, 0xE0, 0x78, 0x1F,
  0x03, 0x80, 0xE0, 0x10, 0x08, 0x00, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x3F, 0xFF, 0xFD, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xC0, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xC3, 0xF0, 0xF8, 0x3E, 0x0F, 0x83, 0xE1, 0xF8,
  0x7C, 0x3F, 0x0F, 0x87, 0xE1, 0xF0, 0x78, 0x0C, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x10, 0xFB, 0xFF, 0xFF, 0xEF, 0x8E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xF8,
  0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0xE0, 0xF8, 0x3E, 0x07, 0xE3, 0xF0,
  0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x07, 0xCF, 0xC0, 0x3E, 0x7E, 0x01, 0xF3,
  0xE0, 0x0F, 0x9F, 0x00, 0xFC, 0xF8, 0x07, 0xEF, 0xC0, 0x3F, 0x7E, 0x01,
  0xFB, 0xF0, 0x0F, 0x9F, 0x80, 0x7C, 0xF8, 0x03, 0xE7, 0xC0, 0x3F, 0x7E,
  0x01, 0xFB, 0xF0, 0x0F, 0xDF, 0x80, 0x7C, 0xFC, 0x03, 0xE7, 0xE0, 0x1F,
  0x3F, 0x01, 0xF9, 0xF8, 0x0F, 0x87, 0xC0, 0x7C, 0x3E, 0x07, 0xE1, 0xF8,
  0x7E, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x0C, 0x01, 0xE0, 0x1F, 0x83, 0xFE, 0x3F, 0xFB,
  0xFF, 0xEF, 0xFF, 0xBF, 0xFC, 0xF1, 0xF3, 0x07, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xE0,
  0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFE, 0x1F, 0xC1,
  0xF8, 0x1F, 0x87, 0xE0, 0x3F, 0x0F, 0xC0, 0x7E, 0x1F, 0x00, 0xFC, 0x3E,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF,
  0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0x87, 0xE0, 0xFC, 0x0F, 0xC3, 0xE0, 0x3F,
  0x1F, 0x80, 0xFC, 0x7E, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xCF, 0xC0, 0x3F, 0x3F, 0x00, 0xF8, 0xFC, 0x07, 0xE3, 0xF0, 0x1F,
  0x87, 0xE0, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xFC, 0x00,
  0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFB,
  0xE0, 0x03, 0xEF, 0xC0, 0x07, 0xDF, 0x80, 0x1F, 0x3F, 0x00, 0x7C, 0x7E,
  0x00, 0xF8, 0xF8, 0x03, 0xE1, 0xF0, 0x0F, 0xC7, 0xE0, 0x1F, 0x0F, 0xC0,
  0x7C, 0x1F, 0x81, 0xF8, 0x3E, 0x03, 0xE0, 0x7C, 0x0F, 0x80, 0xF8, 0x3F,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xE0, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x07, 0xFF, 0xFC, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x3E,
  0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0,
  0xFC, 0x1F, 0x80, 0x20, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0x8F, 0x80, 0x3E, 0x3E, 0x01, 0xF8, 0xFC, 0x07, 0xE3, 0xF0, 0x3F, 0x07,
  0xE1, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xC0, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xE0,
  0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x3E,
  0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xFF, 0xE7, 0xF8,
  0x7E, 0x7F, 0x03, 0xF7, 0xE0, 0x3F, 0x7C, 0x03, 0xF7, 0xC0, 0x3F, 0x7C,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0x7C, 0x03, 0xE7,
  0xC0, 0x7E, 0x7C, 0x07, 0xE7, 0xE0, 0xFC, 0x7E, 0x1F, 0xC3, 0xFF, 0xF8,
  0x3F, 0xFF, 0x01, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x3F, 0x00, 0x3F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x7F, 0xFF, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x7F, 0xFE,
  0x03, 0xFF, 0xF8, 0x1F, 0xC3, 0xF0, 0x7E, 0x0F, 0xC1, 0xF0, 0x3F, 0x0F,
  0xC0, 0x7C, 0x3F, 0x01, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0xC0,
  0xFC, 0x1F, 0x07, 0xE0, 0x7E, 0x1F, 0x80, 0xFF, 0xFC, 0x03, 0xFF, 0xE0,
  0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xF0, 0x1F, 0x87, 0xE0, 0xFC,
  0x0F, 0x83, 0xE0, 0x3F, 0x1F, 0x80, 0xFC, 0x7E, 0x03, 0xF1, 0xF0, 0x0F,
  0xC7, 0xC0, 0x3F, 0x1F, 0x00, 0xFC, 0x7C, 0x03, 0xE1, 0xF8, 0x1F, 0x87,
  0xE0, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0xFF,
  0xE0, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xC0, 0x3F, 0xFC, 0x0F,
  0xFF, 0xC3, 0xFF, 0xF8, 0x7E, 0x1F, 0x9F, 0x81, 0xF3, 0xE0, 0x3E, 0xFC,
  0x07, 0xDF, 0x80, 0xFF, 0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0,
  0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3E, 0xF8, 0x0F, 0xDF, 0x81, 0xFB, 0xF0,
  0x7F, 0x7F, 0xFF, 0xE7, 0xFF, 0xF8, 0x7F, 0xFF, 0x0F, 0xFB, 0xE0, 0x7C,
  0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF8, 0x01, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xF8,
  0x01, 0xFC, 0x00, 0x7C, 0x00, 0x00, 0x03, 0x03, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x07, 0xC3, 0xF8,
  0xFE, 0x3F, 0x87, 0xC0, 0xE0, 0x00, 0x40, 0x0F, 0x80, 0xFE, 0x07, 0xF0,
  0x3F, 0x80, 0xF8, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xC0,
  0x3C, 0x00, 0x40, 0x00, 0x00, 0x00, 0x10, 0x00, 0x06, 0x00, 0x01, 0xE0,
  0x00, 0xFE, 0x00, 0x3F, 0xE0, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xF0,
  0x3F, 0xF8, 0x07, 0xFE, 0x00, 0x7F, 0x80, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x3F,
  0xF8, 0x00, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x70, 0x00,
  0x01, 0x00, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF,
  0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xFF,
  0xFC, 0xFF, 0xFF, 0xC0, 0x08, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0xFC, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x1F,
  0xE0, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFF,
  0x00, 0x7F, 0x80, 0x07, 0xE0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x03, 0xF8, 0x07, 0xFE, 0x07, 0xFF, 0x87, 0xFF, 0xE7, 0xFF,
  0xFB, 0xF0, 0xFF, 0xF0, 0x7F, 0xF8, 0x1F, 0xF8, 0x0F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0xF8,
  0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x07, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x3F, 0x80, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x0F, 0x80, 0x00,
  0xF0, 0x07, 0xC0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x00, 0xE0, 0x7C, 0x00, 0x00, 0x3C, 0x1E, 0x01, 0xF8, 0x0F, 0x0F, 0x00,
  0xFF, 0x81, 0xC3, 0xC0, 0xFF, 0xF0, 0x71, 0xE0, 0x7F, 0xFC, 0x1C, 0x78,
  0x1F, 0x0F, 0x07, 0x1E, 0x0F, 0x83, 0xC1, 0xCF, 0x03, 0xC1, 0xE0, 0x73,
  0xC1, 0xF0, 0x78, 0x1C, 0xF0, 0x78, 0x1E, 0x07, 0x78, 0x3E, 0x07, 0x83,
  0xDE, 0x0F, 0x03, 0xC0, 0xF7, 0x83, 0xC0, 0xF0, 0x3D, 0xE1, 0xF0, 0x3C,
  0x0F, 0x78, 0x7C, 0x0F, 0x03, 0xBC, 0x1F, 0x07, 0x80, 0xEF, 0x07, 0x81,
  0xE0, 0x7B, 0xC1, 0xE0, 0x78, 0x1C, 0xF0, 0x78, 0x3E, 0x07, 0x3C, 0x1E,
  0x0F, 0x83, 0xCF, 0x07, 0xC7, 0xE1, 0xE3, 0xC1, 0xFB, 0xF8, 0xF0, 0xF0,
  0x3F, 0xFF, 0xFC, 0x3C, 0x0F, 0xF3, 0xFE, 0x07, 0x01, 0xF8, 0x7E, 0x01,
  0xE0, 0x10, 0x04, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x0C, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x3F, 0x7C,
  0x00, 0x07, 0xCF, 0x80, 0x01, 0xF9, 0xF0, 0x00, 0x3E, 0x3E, 0x00, 0x0F,
  0xC7, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0x83, 0xF0,
  0x03, 0xF0, 0x3E, 0x00, 0x7E, 0x07, 0xC0, 0x1F, 0x80, 0xF8, 0x03, 0xF0,
  0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0xFC, 0x00,
  0x7C, 0x3F, 0x00, 0x0F, 0x87, 0xE0, 0x01, 0xF1, 0xF8, 0x00, 0x3F, 0x3F,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03,
  0xF0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x3F, 0x03, 0xF8, 0x1F, 0x80, 0xFE, 0x0F,
  0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xE1,
  0xF8, 0x03, 0xF0, 0xF8, 0x03, 0xF0, 0x7C, 0x03, 0xF8, 0x7E, 0x03, 0xF8,
  0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0x03, 0xF0, 0x1F, 0xC1, 0xF8, 0x07, 0xE0, 0xFC, 0x01,
  0xF0, 0x7E, 0x00, 0xFC, 0x3E, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x1F, 0x80,
  0x1F, 0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0xC3, 0xF0, 0x0F, 0xE1, 0xF0,
  0x0F, 0xE1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x01, 0xFC,
  0x0F, 0xC0, 0xFE, 0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x87,
  0xE0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0xFC, 0x00, 0x3E, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x87, 0xC0, 0x07, 0xC1, 0xF0, 0x03,
  0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x3F, 0x80, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x3F, 0x07, 0xF8, 0x1F, 0x80,
  0xFC, 0x0F, 0x80, 0x3E, 0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0xC3, 0xF0,
  0x07, 0xE1, 0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x7C, 0x00, 0xFC, 0x7E,
  0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0x0F, 0xC7,
  0xC0, 0x07, 0xC7, 0xE0, 0x03, 0xE3, 0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xF8,
  0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x3E, 0x00, 0x7E, 0x3F, 0x00, 0x3F,
  0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0x1F, 0x87, 0xE0, 0x1F, 0xC3, 0xF0, 0x1F,
  0xC1, 0xF0, 0x3F, 0xC1, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xE0, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x07,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x01, 0xFC, 0x0F, 0xE0, 0xFE, 0x01, 0xF8,
  0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0x87, 0xE0, 0x03, 0xF1, 0xF0, 0x00,
  0xFC, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x81, 0xFF, 0xC7,
  0xE0, 0x7F, 0xF1, 0xF8, 0x1F, 0xFC, 0x7E, 0x07, 0xFF, 0x1F, 0x03, 0xFF,
  0xCF, 0xC0, 0x03, 0xF3, 0xF0, 0x00, 0xF8, 0xFC, 0x00, 0x7E, 0x3F, 0x00,
  0x1F, 0x87, 0xC0, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x1F,
  0xC0, 0x3F, 0x83, 0xF8, 0x3F, 0xC0, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF0,
  0x01, 0xF8, 0x1F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x03,
  0xF0, 0x7E, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xF8, 0x1F, 0x80, 0x0F, 0xC0,
  0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0xFC, 0x1F, 0x80, 0x07, 0xC0, 0xFC, 0x00, 0x7E, 0x07, 0xC0, 0x03,
  0xF0, 0x7E, 0x00, 0x1F, 0x83, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x83, 0xF0,
  0x00, 0xFC, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x3E, 0x07, 0xE0, 0x03,
  0xF0, 0x3E, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xE0,
  0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF0, 0x3F, 0x00, 0x1F, 0x81, 0xF0,
  0x00, 0xFC, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x01,
  0xF8, 0x3F, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x3F,
  0x03, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0xFC,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0x81, 0xF8, 0x1F, 0x81, 0xF8,
  0x1F, 0x81, 0xF8, 0x1F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xE0,
  0x3E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF0,
  0xFC, 0x07, 0xE0, 0x7C, 0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0x7F, 0x1F, 0xC0,
  0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x07, 0xF8, 0x1F, 0x00, 0x7F, 0x81, 0xF8,
  0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x80, 0x7E, 0x03, 0xF8, 0x03, 0xF0, 0x3F,
  0x80, 0x1F, 0x81, 0xFC, 0x00, 0xF8, 0x1F, 0xC0, 0x0F, 0xC1, 0xFC, 0x00,
  0x7E, 0x1F, 0xC0, 0x03, 0xF1, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0xFC,
  0xFE, 0x00, 0x07, 0xCF, 0xE0, 0x00, 0x7E, 0xFE, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF,
  0x3F, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x3F,
  0x00, 0x1F, 0x81, 0xF8, 0x00, 0xFC, 0x07, 0xE0, 0x07, 0xE0, 0x3F, 0x00,
  0x3F, 0x01, 0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0xFC,
  0x01, 0xFC, 0x07, 0xE0, 0x07, 0xE0, 0x3F, 0x00, 0x3F, 0x01, 0xF8, 0x01,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x00,
  0xFF, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x01, 0xFF, 0x07, 0xFC,
  0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x3F, 0xE0,
  0x7F, 0xC0, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x0F,
  0xFE, 0x0F, 0xBC, 0x00, 0xFF, 0xC0, 0xFB, 0xC0, 0x1F, 0x7C, 0x0F, 0xBE,
  0x01, 0xF7, 0xC0, 0xFB, 0xE0, 0x3F, 0xFC, 0x1F, 0xBE, 0x03, 0xEF, 0xC1,
  0xFB, 0xE0, 0x3E, 0xF8, 0x1F, 0xBE, 0x07, 0xCF, 0x81, 0xF3, 0xE0, 0x7C,
  0xF8, 0x1F, 0x1E, 0x0F, 0x9F, 0x83, 0xF1, 0xE0, 0xF9, 0xF8, 0x3F, 0x1E,
  0x1F, 0x1F, 0x83, 0xF1, 0xF1, 0xF1, 0xF0, 0x3F, 0x1F, 0x3E, 0x1F, 0x03,
  0xF1, 0xF3, 0xE3, 0xF0, 0x3E, 0x1F, 0x3C, 0x3F, 0x07, 0xE0, 0xF7, 0xC3,
  0xF0, 0x7E, 0x0F, 0x78, 0x3F, 0x07, 0xE0, 0xFF, 0x83, 0xE0, 0x7E, 0x0F,
  0xF0, 0x7E, 0x07, 0xE0, 0xFF, 0x07, 0xE0, 0x7C, 0x0F, 0xF0, 0x7E, 0x0F,
  0xC0, 0xFE, 0x07, 0xE0, 0xFC, 0x0F, 0xE0, 0x7E, 0x0F, 0xC0, 0x7C, 0x07,
  0xC0, 0xFC, 0x07, 0xC0, 0xFC, 0x0F, 0xC0, 0x78, 0x0F, 0xC0, 0x03, 0xF0,
  0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xC1, 0xFC, 0x00, 0x7E, 0x0F, 0xF0, 0x03,
  0xF0, 0x7F, 0x80, 0x1F, 0x83, 0xFC, 0x00, 0xF8, 0x1F, 0xE0, 0x0F, 0xC0,
  0xFF, 0x80, 0x7E, 0x0F, 0xFC, 0x03, 0xF0, 0x7F, 0xE0, 0x1F, 0x83, 0xFF,
  0x80, 0xF8, 0x1F, 0xFC, 0x07, 0xC0, 0xFD, 0xE0, 0x7E, 0x07, 0xCF, 0x03,
  0xF0, 0x7E, 0x7C, 0x1F, 0x83, 0xF3, 0xE0, 0xFC, 0x1F, 0x8F, 0x07, 0xC0,
  0xFC, 0x7C, 0x7E, 0x07, 0xC3, 0xE3, 0xF0, 0x7E, 0x0F, 0x1F, 0x83, 0xF0,
  0x78, 0xFC, 0x1F, 0x83, 0xE7, 0xE0, 0xFC, 0x1F, 0x3E, 0x07, 0xE0, 0x7B,
  0xF0, 0x3E, 0x03, 0xFF, 0x83, 0xF0, 0x1F, 0xFC, 0x1F, 0x80, 0x7F, 0xE0,
  0xFC, 0x03, 0xFF, 0x07, 0xE0, 0x1F, 0xF0, 0x3F, 0x00, 0x7F, 0x81, 0xF0,
  0x03, 0xFC, 0x1F, 0x80, 0x1F, 0xE0, 0xFC, 0x00, 0xFF, 0x07, 0xE0, 0x03,
  0xF8, 0x3F, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0x01, 0xFE, 0x1F, 0xE0, 0xFE, 0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x1F,
  0x80, 0x0F, 0x87, 0xE0, 0x03, 0xF1, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x3F,
  0x3F, 0x00, 0x0F, 0xCF, 0xC0, 0x03, 0xF3, 0xE0, 0x00, 0xFD, 0xF8, 0x00,
  0x3F, 0x7E, 0x00, 0x0F, 0x9F, 0x80, 0x07, 0xE7, 0xE0, 0x01, 0xF9, 0xF8,
  0x00, 0x7E, 0x7E, 0x00, 0x1F, 0x9F, 0x00, 0x07, 0xEF, 0xC0, 0x01, 0xF3,
  0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xC7, 0xC0, 0x07,
  0xE1, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x1F, 0xC0, 0x7F, 0x03, 0xF8,
  0x3F, 0x80, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00,
  0x7F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x81, 0xF8,
  0x0F, 0xE0, 0x7E, 0x01, 0xFC, 0x1F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC3,
  0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0x80, 0x0F,
  0xC3, 0xE0, 0x03, 0xF1, 0xF8, 0x01, 0xFC, 0x7E, 0x00, 0x7E, 0x1F, 0x80,
  0x3F, 0x87, 0xE0, 0x1F, 0xC1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x00, 0xFC, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF,
  0xC0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x01, 0xFE, 0x1F, 0xC0, 0xFE,
  0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0x87, 0xE0, 0x03, 0xF1,
  0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xCF, 0x80, 0x03,
  0xF3, 0xE0, 0x00, 0xFD, 0xF8, 0x00, 0x3E, 0x7E, 0x00, 0x0F, 0x9F, 0x80,
  0x07, 0xE7, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0x7E, 0x7C, 0x00, 0x1F, 0xBF,
  0x00, 0x07, 0xEF, 0xC0, 0x01, 0xF3, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x3F,
  0x3F, 0x00, 0x0F, 0x87, 0xC0, 0x07, 0xE1, 0xF0, 0x01, 0xF8, 0x7E, 0x00,
  0xFC, 0x1F, 0x80, 0x7F, 0x03, 0xF8, 0x3F, 0x80, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x10, 0x00, 0x03, 0xFF, 0xE0, 0x01,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0,
  0x3F, 0x01, 0xF8, 0x1F, 0x80, 0x7E, 0x0F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F,
  0x87, 0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0xFC, 0x01,
  0xF8, 0x7C, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x3F, 0x00, 0xFE, 0x1F, 0x80,
  0xFE, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x03, 0xFF,
  0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x3E,
  0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0x7E, 0x07,
  0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x81, 0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xF0,
  0xFC, 0x01, 0xF8, 0x7E, 0x00, 0xFE, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x1F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x3F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x3F, 0x83, 0xF8, 0x1F, 0x80, 0xFC, 0x1F,
  0x80, 0x3E, 0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0xC3, 0xE0, 0x07, 0xE1,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x3F, 0x00,
  0x3F, 0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0x1F, 0x83, 0xF0, 0x0F, 0xC1, 0xFC,
  0x1F, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x01,
  0xFF, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x07, 0xC3, 0xF0, 0x03,
  0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0x80, 0x0F, 0xC7, 0xE0,
  0x03, 0xF1, 0xF8, 0x00, 0xF8, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x87,
  0xE0, 0x07, 0xE1, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x1F,
  0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x3E, 0x00,
  0x3F, 0x1F, 0x80, 0x0F, 0x87, 0xE0, 0x03, 0xE1, 0xF8, 0x01, 0xF8, 0x7E,
  0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x87, 0xC0, 0x07, 0xE3, 0xF0, 0x01, 0xF0,
  0xFC, 0x00, 0x7C, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03,
  0xF0, 0xFC, 0x01, 0xF8, 0x3F, 0x80, 0xFE, 0x07, 0xF0, 0x7F, 0x01, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x01,
  0xF9, 0xF8, 0x00, 0xFE, 0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xC7, 0xE0,
  0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0xFE, 0x1F, 0x80, 0x3F, 0x07,
  0xE0, 0x0F, 0xC0, 0xF8, 0x07, 0xE0, 0x3E, 0x01, 0xF8, 0x0F, 0xC0, 0xFC,
  0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x0F, 0x80, 0x3F, 0x07, 0xE0, 0x0F, 0xC1,
  0xF8, 0x01, 0xF0, 0xFC, 0x00, 0x7C, 0x3F, 0x00, 0x1F, 0x0F, 0x80, 0x07,
  0xC7, 0xE0, 0x01, 0xF1, 0xF0, 0x00, 0x7C, 0xFC, 0x00, 0x1F, 0xBF, 0x00,
  0x07, 0xEF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0xFE, 0x00, 0xF8, 0x03, 0xEF, 0x80, 0x7E, 0x01,
  0xFB, 0xE0, 0x1F, 0x80, 0x7E, 0xF8, 0x07, 0xE0, 0x1F, 0x3E, 0x03, 0xF8,
  0x0F, 0xCF, 0x80, 0xFE, 0x03, 0xF3, 0xE0, 0x3F, 0x80, 0xF8, 0xF8, 0x1F,
  0xE0, 0x7E, 0x3E, 0x07, 0xF8, 0x1F, 0x8F, 0x81, 0xFF, 0x07, 0xC3, 0xE0,
  0xFF, 0xC3, 0xF0, 0xF8, 0x3F, 0xF0, 0xFC, 0x3E, 0x0F, 0x7C, 0x3E, 0x0F,
  0x87, 0xDF, 0x0F, 0x83, 0xE1, 0xF7, 0xC7, 0xE0, 0xF8, 0xF9, 0xF1, 0xF0,
  0x3E, 0x3E, 0x7C, 0x7C, 0x0F, 0x8F, 0x1F, 0x3F, 0x03, 0xE7, 0xC7, 0xCF,
  0x80, 0xF9, 0xF1, 0xF3, 0xE0, 0x3E, 0x78, 0x3D, 0xF8, 0x0F, 0xBE, 0x0F,
  0x7C, 0x03, 0xEF, 0x83, 0xDF, 0x00, 0xFB, 0xC0, 0xFF, 0xC0, 0x3F, 0xF0,
  0x3F, 0xE0, 0x0F, 0xFC, 0x0F, 0xF8, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0xFF, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x0F, 0xF0, 0x0F, 0xF0, 0x03,
  0xFC, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x3F, 0x80,
  0x07, 0xE0, 0x0F, 0xC0, 0x01, 0xF0, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x01,
  0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x01, 0xFC,
  0x01, 0xF8, 0x07, 0xE0, 0x03, 0xF0, 0x3F, 0x80, 0x0F, 0xC1, 0xFC, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0x7C, 0x3F, 0x80, 0x01, 0xF8, 0xFC, 0x00, 0x07,
  0xE7, 0xE0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x3F, 0x7C, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x3F,
  0x1F, 0x80, 0x01, 0xFC, 0x3F, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x3F, 0x83,
  0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x80, 0x7E,
  0x01, 0xFC, 0x01, 0xFC, 0x07, 0xF0, 0x03, 0xF0, 0x3F, 0x80, 0x0F, 0xC0,
  0xFE, 0x00, 0x3F, 0xBF, 0x00, 0x1F, 0x9F, 0x80, 0x1F, 0xCF, 0xC0, 0x0F,
  0xC7, 0xE0, 0x0F, 0xE1, 0xF0, 0x07, 0xE0, 0xFC, 0x07, 0xE0, 0x7E, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x0F, 0x83, 0xF8, 0x07, 0xC1, 0xF8, 0x03, 0xF1,
  0xF8, 0x01, 0xF8, 0xFC, 0x00, 0x7C, 0xFC, 0x00, 0x3E, 0x7E, 0x00, 0x1F,
  0x7E, 0x00, 0x0F, 0xBE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xFC, 0x03, 0xFE,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0xFC, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x83, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7E, 0x0F, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF8, 0x3F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xE0, 0xFC,
  0x1F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x83, 0xF0, 0x7E, 0x07,
  0xC0, 0xF8, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x07,
  0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x78, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xFC, 0x03,
  0xFC, 0x07, 0xBC, 0x07, 0xBC, 0x0F, 0xBC, 0x0F, 0x3C, 0x1F, 0x3E, 0x1E,
  0x1E, 0x3E, 0x1E, 0x3C, 0x1E, 0x7C, 0x1E, 0x78, 0x1E, 0xF8, 0x1F, 0x7F,
  0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFC,
  0x1F, 0x83, 0xE0, 0x7C, 0x1F, 0x03, 0xE0, 0x78, 0x00, 0x7E, 0x00, 0x1F,
  0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE1, 0xF8, 0x3F, 0x1F,
  0x83, 0xF1, 0xF0, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x01, 0xFF, 0xE0,
  0x7F, 0xFE, 0x1F, 0xFF, 0xE3, 0xFF, 0xFE, 0x7F, 0x07, 0xE7, 0xE0, 0x7E,
  0xFC, 0x07, 0xCF, 0xC0, 0x7C, 0xFC, 0x0F, 0xCF, 0xC0, 0xFC, 0xFC, 0x1F,
  0xCF, 0xFF, 0xFC, 0x7F, 0xFF, 0x87, 0xFF, 0xF8, 0x3F, 0xEF, 0xC0, 0xF8,
  0xFC, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xCF,
  0xC0, 0x3F, 0x7F, 0xC0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC,
  0x3F, 0x87, 0xF0, 0xFC, 0x0F, 0xC7, 0xE0, 0x1F, 0x1F, 0x80, 0x7C, 0x7E,
  0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x3F, 0x1F, 0x00, 0xFC, 0xFC, 0x03,
  0xF3, 0xF0, 0x0F, 0xCF, 0xC0, 0x3E, 0x3E, 0x00, 0xF8, 0xF8, 0x07, 0xE7,
  0xE0, 0x1F, 0x9F, 0xC0, 0xFC, 0x7F, 0x87, 0xF1, 0xFF, 0xFF, 0x87, 0xFF,
  0xFE, 0x1F, 0x7F, 0xF0, 0xFC, 0xFF, 0x83, 0xF1, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x1F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xF8,
  0x3F, 0x3F, 0x01, 0xF3, 0xF0, 0x1F, 0x3E, 0x01, 0xF7, 0xE0, 0x1F, 0x7E,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x7E, 0x7C, 0x07, 0xC7, 0xC0, 0x7C,
  0x7E, 0x0F, 0xC7, 0xFF, 0xF8, 0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x0F, 0xFC,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0xF8, 0xFC, 0x03, 0xFE, 0xFC, 0x07, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0x83, 0xF8, 0x3F, 0x01, 0xF8,
  0x3F, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x7E, 0x01, 0xF0, 0x7E, 0x01, 0xF0,
  0x7C, 0x01, 0xF0, 0x7C, 0x03, 0xF0, 0x7C, 0x03, 0xF0, 0xFC, 0x03, 0xF0,
  0xFC, 0x03, 0xE0, 0xFC, 0x03, 0xE0, 0xFC, 0x03, 0xE0, 0xFC, 0x07, 0xE0,
  0x7C, 0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0,
  0x3F, 0xFF, 0xC0, 0x1F, 0xF7, 0xC0, 0x0F, 0xC7, 0xC0, 0x00, 0x7F, 0x00,
  0x0F, 0xFC, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x0F, 0xC1,
  0xF8, 0x7C, 0x07, 0xC7, 0xE0, 0x3E, 0x3E, 0x01, 0xF3, 0xF0, 0x0F, 0x9F,
  0x80, 0x7C, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF,
  0xCF, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC,
  0x03, 0x07, 0xF0, 0x78, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xF0,
  0x0F, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x3F,
  0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x1F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x03, 0xFF, 0xE1,
  0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0xFC, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x3E, 0x03, 0xFE, 0x7C, 0x0F,
  0xFE, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE1, 0xF8, 0x3F, 0xC7, 0xE0,
  0x3F, 0x0F, 0xC0, 0x3E, 0x1F, 0x00, 0xFC, 0x7E, 0x01, 0xF8, 0xFC, 0x03,
  0xF1, 0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x7E,
  0x3F, 0x00, 0xFC, 0x7E, 0x01, 0xF8, 0xFC, 0x03, 0xE0, 0xF8, 0x07, 0xC1,
  0xF0, 0x1F, 0x83, 0xF0, 0x7F, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF0, 0x0F, 0xFB, 0xE0, 0x07, 0xCF, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7C, 0x04, 0x01, 0xF8, 0x1C, 0x07, 0xF0, 0x3F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0xFC, 0x07,
  0xEF, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0x0F,
  0xC7, 0xF0, 0x3E, 0x3F, 0x01, 0xF1, 0xF8, 0x0F, 0x8F, 0xC0, 0x7C, 0x7C,
  0x03, 0xE3, 0xE0, 0x3F, 0x3F, 0x01, 0xF9, 0xF8, 0x0F, 0xCF, 0xC0, 0x7C,
  0x7E, 0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x01, 0xF9, 0xF8, 0x0F, 0xCF, 0xC0,
  0x7E, 0x7E, 0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x01, 0xF8, 0xF8, 0x0F, 0xCF,
  0xC0, 0x7E, 0x7E, 0x03, 0xF0, 0x03, 0xC0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x07, 0xC0, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xE0, 0x7C, 0x1F, 0x83, 0xF0, 0x7E, 0x0F,
  0x81, 0xF0, 0x3E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xC0, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xE0, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x7F, 0xE0,
  0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0xFE,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC1, 0xFC, 0x0F, 0xC3, 0xF8, 0x0F, 0x87, 0xF0,
  0x0F, 0x8F, 0xE0, 0x0F, 0x9F, 0xC0, 0x1F, 0x9F, 0x80, 0x1F, 0xBF, 0x00,
  0x1F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xBF, 0x00, 0x3F, 0x3F, 0x00,
  0x3E, 0x1F, 0x00, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x0F, 0xC0,
  0x7E, 0x0F, 0xC0, 0x7C, 0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0xFC, 0x07, 0xE0,
  0xFC, 0x07, 0xF0, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7C, 0x07, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0xF8,
  0x0F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x01, 0xF0, 0x1F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7C, 0x07, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xF8, 0x0F, 0x80,
  0x07, 0xCF, 0xC0, 0x7C, 0x01, 0xF7, 0xFC, 0x7F, 0xC0, 0xFF, 0xFF, 0x3F,
  0xF8, 0x3F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xC3, 0xF8, 0x7F,
  0x87, 0xF0, 0xFC, 0x1F, 0xC0, 0xFC, 0x7E, 0x03, 0xF0, 0x3F, 0x1F, 0x80,
  0xF8, 0x0F, 0xC7, 0xE0, 0x3E, 0x03, 0xF1, 0xF8, 0x1F, 0x80, 0xFC, 0x7C,
  0x07, 0xE0, 0x3E, 0x1F, 0x01, 0xF8, 0x0F, 0x8F, 0xC0, 0x7C, 0x07, 0xE3,
  0xF0, 0x1F, 0x01, 0xF8, 0xFC, 0x07, 0xC0, 0x7E, 0x3E, 0x03, 0xF0, 0x1F,
  0x8F, 0x80, 0xFC, 0x07, 0xC3, 0xE0, 0x3F, 0x01, 0xF1, 0xF8, 0x0F, 0x80,
  0xFC, 0x7E, 0x03, 0xE0, 0x3F, 0x1F, 0x80, 0xF8, 0x0F, 0xC7, 0xC0, 0x7E,
  0x03, 0xF1, 0xF0, 0x1F, 0x80, 0xF8, 0x7C, 0x07, 0xE0, 0x3E, 0x3F, 0x01,
  0xF0, 0x1F, 0x80, 0x07, 0xC7, 0xC0, 0x7E, 0xFF, 0x83, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0xF0, 0xFC, 0x3F, 0x03, 0xE3, 0xF0, 0x1F,
  0x1F, 0x80, 0xF8, 0xFC, 0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x03, 0xF1, 0xF0,
  0x1F, 0x9F, 0x80, 0xFC, 0xFC, 0x07, 0xC7, 0xE0, 0x3E, 0x3E, 0x01, 0xF1,
  0xF0, 0x1F, 0x9F, 0x80, 0xFC, 0xFC, 0x07, 0xE7, 0xE0, 0x3E, 0x3F, 0x01,
  0xF1, 0xF0, 0x1F, 0x8F, 0x80, 0xFC, 0xFC, 0x07, 0xE7, 0xE0, 0x3F, 0x00,
  0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x0F, 0xE1, 0xFC, 0xFE, 0x07, 0xE7, 0xE0, 0x3F, 0x3E, 0x00, 0xFB,
  0xF0, 0x07, 0xDF, 0x80, 0x3E, 0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0xBE, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xF3, 0xE0, 0x1F, 0x9F,
  0x00, 0xFC, 0xFC, 0x0F, 0xC7, 0xE0, 0xFE, 0x1F, 0xFF, 0xE0, 0xFF, 0xFE,
  0x03, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF3, 0xF0,
  0x01, 0xF7, 0xFC, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0x03, 0xF8, 0x7F, 0x03, 0xE0, 0x3F, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x1F,
  0x07, 0xE0, 0x1F, 0x07, 0xE0, 0x1F, 0x07, 0xC0, 0x3F, 0x07, 0xC0, 0x3F,
  0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3E, 0x0F, 0x80, 0x3E,
  0x0F, 0x80, 0x7E, 0x0F, 0x80, 0x7E, 0x1F, 0x80, 0xFC, 0x1F, 0xC1, 0xFC,
  0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0x7F, 0xF0, 0x3F, 0x3F, 0xE0,
  0x3F, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x7C,
  0x0F, 0xF9, 0xF0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0x7E,
  0x0F, 0xE3, 0xF0, 0x1F, 0x8F, 0xC0, 0x7E, 0x7E, 0x01, 0xF9, 0xF8, 0x07,
  0xE7, 0xE0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x03, 0xF1, 0xF0, 0x0F, 0xCF,
  0xC0, 0x3F, 0x3F, 0x00, 0xFC, 0xFC, 0x03, 0xE3, 0xF0, 0x0F, 0x8F, 0xC0,
  0x7E, 0x1F, 0x01, 0xF8, 0x7E, 0x0F, 0xE1, 0xFF, 0xFF, 0x07, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x1F, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0,
  0x07, 0xCF, 0x07, 0xDF, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF,
  0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00,
  0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0,
  0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xF8, 0x3E, 0x3F, 0x03, 0xF3, 0xF0, 0x3F,
  0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xCF, 0x80,
  0xFC, 0xF8, 0x0F, 0xCF, 0x80, 0xFC, 0xFC, 0x1F, 0x8F, 0xF7, 0xF8, 0x7F,
  0xFF, 0x03, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x3F, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xFC, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x07,
  0xF0, 0x1F, 0x80, 0x1F, 0x01, 0xF9, 0xF8, 0x0F, 0xCF, 0xC0, 0x7E, 0x7E,
  0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x01, 0xF8, 0xF8, 0x0F, 0xCF, 0xC0, 0x7E,
  0x7E, 0x03, 0xE3, 0xF0, 0x1F, 0x1F, 0x01, 0xF8, 0xF8, 0x0F, 0xC7, 0xC0,
  0x7E, 0x7E, 0x03, 0xF3, 0xF0, 0x1F, 0x1F, 0x80, 0xF8, 0xF8, 0x0F, 0xC7,
  0xC0, 0x7E, 0x3E, 0x03, 0xF1, 0xF8, 0x3F, 0x0F, 0xC3, 0xF8, 0x7F, 0xFF,
  0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFC, 0x00, 0x00,
  0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x3F, 0x7E, 0x07, 0xEF, 0xC0, 0xF9,
  0xF8, 0x3F, 0x1F, 0x07, 0xC3, 0xE0, 0xF8, 0x7C, 0x3F, 0x0F, 0x87, 0xC1,
  0xF1, 0xF8, 0x3E, 0x3E, 0x07, 0xC7, 0xC0, 0xF9, 0xF0, 0x0F, 0x3E, 0x01,
  0xEF, 0xC0, 0x3D, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x0F, 0x81, 0xFF, 0xC0, 0x7C, 0x0F, 0xFE, 0x07, 0xE0,
  0x7D, 0xF0, 0x3F, 0x07, 0xEF, 0x83, 0xF8, 0x3E, 0x7C, 0x1F, 0xC1, 0xF3,
  0xE0, 0xFE, 0x1F, 0x9F, 0x0F, 0xF0, 0xF8, 0xF8, 0x7F, 0x87, 0xC3, 0xC7,
  0xFC, 0x7C, 0x1E, 0x3D, 0xE3, 0xE0, 0xF1, 0xEF, 0x1F, 0x07, 0xDF, 0x79,
  0xF0, 0x3E, 0xF3, 0xEF, 0x81, 0xFF, 0x9F, 0xF8, 0x0F, 0xF8, 0xFF, 0xC0,
  0x7F, 0xC3, 0xFE, 0x03, 0xFC, 0x1F, 0xE0, 0x1F, 0xE0, 0xFF, 0x00, 0xFF,
  0x07, 0xF0, 0x07, 0xF0, 0x3F, 0x80, 0x3F, 0x81, 0xFC, 0x01, 0xF8, 0x0F,
  0xC0, 0x0F, 0xC0, 0x7E, 0x00, 0x7C, 0x03, 0xE0, 0x03, 0xE0, 0x1F, 0x00,
  0x00, 0x0F, 0xC0, 0x7E, 0x0F, 0x81, 0xFC, 0x1F, 0x83, 0xF0, 0x3F, 0x0F,
  0xC0, 0x3E, 0x3F, 0x80, 0x7C, 0x7E, 0x00, 0xFD, 0xF8, 0x00, 0xFB, 0xF0,
  0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0x7E, 0x00, 0x7E, 0x7C, 0x01, 0xF8,
  0xF8, 0x07, 0xF1, 0xF8, 0x0F, 0xC1, 0xF0, 0x3F, 0x03, 0xE0, 0x7E, 0x07,
  0xE1, 0xF8, 0x0F, 0xC0, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x3F, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFC, 0x07, 0xE0, 0xFC, 0x07, 0xE0,
  0xF8, 0x03, 0xE1, 0xF8, 0x03, 0xE1, 0xF8, 0x03, 0xE3, 0xF0, 0x03, 0xE3,
  0xF0, 0x03, 0xE7, 0xE0, 0x03, 0xE7, 0xE0, 0x03, 0xE7, 0xC0, 0x03, 0xEF,
  0xC0, 0x03, 0xEF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xC1, 0xFF, 0xFF, 0x00, 0x00, 0x02, 0x00, 0x0E, 0x00, 0x3F, 0x00, 0x7F,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x7F, 0x80,
  0x7F, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80,
  0x03, 0x80, 0x01, 0x00, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xE0,
  0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xE0, 0x78, 0x1E, 0x07, 0x81,
  0xE0, 0x78, 0x1E, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x00, 0x01, 0x80,
  0x03, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x3C, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x7E, 0x01, 0xFC, 0x07,
  0xE0, 0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x00,
  0x3C, 0x00, 0x20, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xE0, 0x1F, 0x1F, 0xF0,
  0x1E, 0x3F, 0xF8, 0x1E, 0x7F, 0xFC, 0x3E, 0x7C, 0x7E, 0x3E, 0x78, 0x3F,
  0xFC, 0xF8, 0x1F, 0xFC, 0xF8, 0x1F, 0xF8, 0xF0, 0x0F, 0xF0, 0x00, 0x03,
  0xE0,
};

const GFXglyph RobotoCondensed_MediumItalic50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 12, 36, 12, 1, -36 },
  { 55, 13, 13, 16, 4, -38 },
  { 77, 24, 36, 26, 2, -36 },
  { 185, 21, 46, 24, 2, -41 },
  { 306, 24, 36, 31, 4, -36 },
  { 414, 24, 37, 27, 1, -36 },
  { 525, 6, 13, 8, 4, -38 },
  { 535, 16, 51, 15, 2, -40 },
  { 637, 15, 51, 16, -2, -40 },
  { 733, 20, 21, 21, 3, -36 },
  { 786, 21, 26, 24, 2, -29 },
  { 855, 10, 14, 11, -3, -6 },
  { 873, 11, 5, 15, 2, -18 },
  { 880, 7, 7, 14, 1, -7 },
  { 887, 23, 39, 17, -3, -36 },
  { 1000, 21, 36, 24, 2, -36 },
  { 1095, 14, 36, 24, 6, -36 },
  { 1158, 23, 36, 24, 0, -36 },
  { 1262, 22, 36, 24, 1, -36 },
  { 1361, 23, 36, 24, 0, -36 },
  { 1465, 22, 36, 24, 2, -36 },
  { 1564, 20, 36, 24, 2, -36 },
  { 1654, 22, 36, 24, 3, -36 },
  { 1753, 22, 36, 24, 1, -36 },
  { 1852, 19, 36, 24, 4, -36 },
  { 1938, 10, 28, 13, 1, -28 },
  { 1973, 13, 36, 11, -2, -28 },
  { 2032, 20, 23, 22, 1, -27 },
  { 2090, 20, 15, 24, 2, -24 },
  { 2128, 20, 23, 22, 1, -27 },
  { 2186, 17, 36, 21, 4, -36 },
  { 2263, 34, 46, 37, 1, -35 },
  { 2459, 27, 36, 28, -2, -36 },
  { 2581, 25, 36, 27, 1, -36 },
  { 2694, 26, 36, 28, 2, -36 },
  { 2811, 25, 36, 28, 1, -36 },
  { 2924, 25, 36, 24, 1, -36 },
  { 3037, 24, 36, 23, 1, -36 },
  { 3145, 26, 36, 29, 2, -36 },
  { 3262, 29, 36, 30, 1, -36 },
  { 3393, 12, 36, 13, 1, -36 },
  { 3447, 24, 36, 24, 0, -36 },
  { 3555, 29, 36, 27, 1, -36 },
  { 3686, 19, 36, 23, 1, -36 },
  { 3772, 36, 36, 37, 1, -36 },
  { 3934, 29, 36, 30, 1, -36 },
  { 4065, 26, 36, 29, 2, -36 },
  { 4182, 26, 36, 27, 1, -36 },
  { 4299, 26, 42, 29, 2, -36 },
  { 4436, 25, 36, 26, 1, -36 },
  { 4549, 25, 36, 26, 1, -36 },
  { 4662, 24, 36, 26, 4, -36 },
  { 4770, 26, 36, 27, 2, -36 },
  { 4887, 26, 36, 28, 4, -36 },
  { 5004, 34, 36, 37, 5, -36 },
  { 5157, 30, 36, 27, -1, -36 },
  { 5292, 25, 36, 26, 4, -36 },
  { 5405, 28, 36, 26, -1, -36 },
  { 5531, 17, 49, 13, -1, -41 },
  { 5636, 11, 39, 18, 4, -36 },
  { 5690, 17, 49, 13, -3, -41 },
  { 5795, 16, 18, 19, 2, -36 },
  { 5831, 19, 5, 19, -3, 0 },
  { 5843, 10, 7, 16, 5, -37 },
  { 5852, 20, 26, 23, 1, -26 },
  { 5917, 22, 38, 24, 0, -38 },
  { 6022, 20, 26, 22, 1, -26 },
  { 6087, 24, 38, 24, 1, -38 },
  { 6201, 21, 26, 23, 1, -26 },
  { 6270, 17, 39, 16, 2, -39 },
  { 6353, 23, 36, 24, 0, -26 },
  { 6457, 21, 38, 24, 0, -38 },
  { 6557, 11, 36, 12, 1, -36 },
  { 6607, 17, 46, 11, -5, -36 },
  { 6705, 24, 38, 23, 0, -38 },
  { 6819, 12, 38, 12, 1, -38 },
  { 6876, 34, 26, 36, 0, -26 },
  { 6987, 21, 26, 24, 0, -26 },
  { 7056, 21, 26, 24, 1, -26 },
  { 7125, 24, 36, 24, -2, -26 },
  { 7233, 22, 36, 24, 1, -26 },
  { 7332, 16, 26, 15, 0, -26 },
  { 7384, 20, 26, 22, 1, -26 },
  { 7449, 13, 33, 15, 2, -33 },
  { 7503, 21, 26, 24, 2, -26 },
  { 7572, 19, 26, 21, 3, -26 },
  { 7634, 29, 26, 31, 3, -26 },
  { 7729, 23, 26, 22, -1, -26 },
  { 7804, 24, 36, 21, -2, -26 },
  { 7912, 22, 26, 22, -1, -26 },
  { 7984, 16, 48, 15, 1, -39 },
  { 8080, 10, 43, 12, 1, -36 },
  { 8134, 15, 48, 15, -2, -39 },
  { 8224, 24, 11, 28, 2, -20 },
};

const GFXfont RobotoCondensed_MediumItalic50pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_MediumItalic50pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_MediumItalic50pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _ROBOTOCONDENSED_MEDIUMITALIC50PT7B_H_
