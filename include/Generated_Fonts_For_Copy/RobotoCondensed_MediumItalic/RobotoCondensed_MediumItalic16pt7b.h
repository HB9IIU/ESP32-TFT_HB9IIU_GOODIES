#ifndef _ROBOTOCONDENSED_MEDIUMITALIC16PT7B_H_
#define _ROBOTOCONDENSED_MEDIUMITALIC16PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-MediumItalic.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_MediumItalic16pt7bBitmaps[] PROGMEM = {
  0x00, 0x33, 0x33, 0x26, 0x66, 0x60, 0x4C, 0x55, 0xD9, 0x0D, 0x09, 0x0A,
  0x0A, 0x3F, 0x16, 0x14, 0x7E, 0x2C, 0x28, 0x68, 0x58, 0x08, 0x10, 0xE3,
  0xE6, 0x48, 0x98, 0x38, 0x38, 0x1A, 0x34, 0x6F, 0x8E, 0x18, 0x00, 0x70,
  0x50, 0xDA, 0x54, 0x74, 0x08, 0x10, 0x16, 0x29, 0x49, 0x4B, 0x0E, 0x1C,
  0x3E, 0x36, 0x36, 0x3C, 0x18, 0x3B, 0x6F, 0xCE, 0xC6, 0x7E, 0x3B, 0x5E,
  0x08, 0x8C, 0xC6, 0x23, 0x18, 0xC4, 0x21, 0x08, 0x43, 0x08, 0x40, 0x10,
  0x86, 0x10, 0x84, 0x21, 0x18, 0xC6, 0x23, 0x19, 0x88, 0x80, 0x10, 0x4D,
  0x5F, 0x71, 0x60, 0x80, 0x10, 0xC3, 0x3F, 0xFC, 0x82, 0x18, 0x6D, 0x60,
  0xFC, 0xC8, 0x02, 0x0C, 0x10, 0x60, 0x83, 0x04, 0x08, 0x30, 0x41, 0x82,
  0x0C, 0x00, 0x39, 0xF4, 0x71, 0xC7, 0x3C, 0xF3, 0x8E, 0x2F, 0x9C, 0x1F,
  0xF3, 0x32, 0x26, 0x66, 0x64, 0x1C, 0x7D, 0x8B, 0x10, 0x60, 0xC3, 0x0C,
  0x30, 0xC3, 0xFF, 0xF0, 0x1C, 0x7D, 0x98, 0x10, 0x61, 0x87, 0x03, 0x07,
  0x8D, 0xF3, 0xC0, 0x06, 0x1C, 0x38, 0xF3, 0x64, 0x99, 0x7F, 0xFE, 0x18,
  0x30, 0x40, 0x3E, 0xFD, 0x82, 0x07, 0x9F, 0x83, 0x06, 0x0D, 0x1B, 0xE3,
  0x80, 0x1C, 0xF6, 0x10, 0xFB, 0xFC, 0xF3, 0xCF, 0x3F, 0x9C, 0x7F, 0xFC,
  0x10, 0x60, 0x83, 0x04, 0x18, 0x20, 0xC1, 0x06, 0x00, 0x1C, 0x7C, 0xC9,
  0x12, 0x67, 0xCF, 0x32, 0x46, 0x8D, 0xF1, 0xC0, 0x39, 0xF4, 0xF1, 0xCF,
  0x3F, 0xDF, 0x08, 0x67, 0x38, 0x32, 0x00, 0x00, 0x0C, 0xC0, 0x31, 0x80,
  0x00, 0x00, 0x04, 0x63, 0x30, 0x02, 0x18, 0xF3, 0x8E, 0x0F, 0x07, 0x04,
  0x7F, 0xF0, 0x00, 0xFB, 0xE0, 0x20, 0xE0, 0xF0, 0x70, 0xCF, 0x18, 0x40,
  0x39, 0xFC, 0xC3, 0x1C, 0x63, 0x18, 0x60, 0x04, 0x10, 0x07, 0x81, 0x88,
  0x40, 0x93, 0x92, 0xDA, 0x92, 0x52, 0x4A, 0xC9, 0xDB, 0x3B, 0x6B, 0x36,
  0x20, 0x04, 0x00, 0xC4, 0x0F, 0x80, 0x03, 0x03, 0x81, 0xC1, 0xE0, 0xF0,
  0xC8, 0x64, 0x7E, 0x3F, 0x90, 0xD8, 0x6C, 0x30, 0x3E, 0x3F, 0x33, 0x23,
  0x63, 0x66, 0x7E, 0x62, 0x63, 0x46, 0xFE, 0xFC, 0x1C, 0x7E, 0x63, 0xC3,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC6, 0xC6, 0xFC, 0x78, 0x3E, 0x3F, 0x33, 0x21,
  0x61, 0x63, 0x63, 0x63, 0x63, 0x46, 0xFE, 0xF8, 0x3F, 0x3F, 0x30, 0x20,
  0x60, 0x7E, 0x7E, 0x60, 0x60, 0x40, 0xFE, 0xFC, 0x3F, 0x3F, 0x30, 0x20,
  0x60, 0x7E, 0x7E, 0x60, 0x60, 0x40, 0xC0, 0xC0, 0x1C, 0x7E, 0x63, 0xC3,
  0xC0, 0xCE, 0xCE, 0xC6, 0xC6, 0xC6, 0xFE, 0x78, 0x30, 0xCC, 0x23, 0x18,
  0x86, 0x61, 0x9F, 0xE7, 0xF9, 0x84, 0x63, 0x10, 0xCC, 0x33, 0x0C, 0x33,
  0x33, 0x26, 0x66, 0x66, 0x4C, 0x03, 0x03, 0x06, 0x06, 0x06, 0x06, 0x06,
  0x06, 0x04, 0xCC, 0xFC, 0x78, 0x31, 0x8C, 0xC3, 0x70, 0x98, 0x6C, 0x1E,
  0x07, 0xC1, 0xB0, 0x6C, 0x11, 0x8C, 0x63, 0x1C, 0x30, 0xC3, 0x08, 0x61,
  0x86, 0x18, 0x61, 0x0F, 0xFF, 0x38, 0x73, 0x87, 0x38, 0xE3, 0x8E, 0x68,
  0xE6, 0x9E, 0x69, 0x66, 0xB6, 0x6A, 0x44, 0xEC, 0xCC, 0xCC, 0xCC, 0x30,
  0xCC, 0x23, 0x98, 0xA6, 0x69, 0x9B, 0x66, 0xD9, 0x94, 0x67, 0x11, 0xCC,
  0x73, 0x0C, 0x1C, 0x3E, 0x63, 0xC3, 0xC3, 0xC3, 0xC3, 0xC2, 0xC6, 0xC6,
  0xFC, 0x78, 0x3E, 0x1F, 0x8C, 0x64, 0x36, 0x1B, 0x19, 0xFC, 0xFC, 0x60,
  0x20, 0x30, 0x18, 0x00, 0x1C, 0x7E, 0x63, 0xC3, 0xC3, 0xC3, 0xC3, 0xC2,
  0xC6, 0xC6, 0xFC, 0x78, 0x0C, 0x04, 0x3E, 0x3F, 0x33, 0x23, 0x63, 0x7F,
  0x7C, 0x6C, 0x66, 0x46, 0xC6, 0xC6, 0x1E, 0x3F, 0x33, 0x20, 0x30, 0x3C,
  0x0E, 0x06, 0xC2, 0x46, 0x7E, 0x3C, 0xFF, 0xFF, 0x18, 0x18, 0x10, 0x30,
  0x30, 0x30, 0x30, 0x30, 0x20, 0x60, 0x63, 0x63, 0x43, 0xC3, 0xC2, 0xC6,
  0xC6, 0xC6, 0xC6, 0xC4, 0xFC, 0x78, 0xC3, 0x21, 0x98, 0xCC, 0xC6, 0x63,
  0x61, 0xB0, 0xD8, 0x78, 0x1C, 0x0C, 0x06, 0x00, 0x46, 0x68, 0xCD, 0x39,
  0xA7, 0x24, 0xEC, 0xB5, 0x94, 0xA2, 0x9C, 0x73, 0x8C, 0x61, 0x8C, 0x31,
  0x80, 0x31, 0x99, 0x8C, 0xC2, 0xC1, 0xE0, 0xE0, 0x70, 0x78, 0x34, 0x33,
  0x19, 0x98, 0xC0, 0xC3, 0x66, 0x66, 0x6C, 0x6C, 0x38, 0x38, 0x30, 0x30,
  0x30, 0x30, 0x60, 0x3F, 0x9F, 0x80, 0xC0, 0xC0, 0xC0, 0x60, 0x60, 0x60,
  0x30, 0x30, 0x3F, 0x9F, 0xC0, 0x39, 0xCC, 0x42, 0x31, 0x8C, 0x63, 0x11,
  0x8C, 0x63, 0x1C, 0xC4, 0x46, 0x66, 0x66, 0x22, 0x33, 0x30, 0x39, 0xC6,
  0x31, 0x88, 0x46, 0x31, 0x8C, 0x62, 0x31, 0x9C, 0x31, 0x9C, 0xAD, 0x4C,
  0xFF, 0xF0, 0xC8, 0x3C, 0xFD, 0x98, 0x33, 0xCD, 0xB3, 0x7E, 0x7C, 0x30,
  0x60, 0xC1, 0xE7, 0xEC, 0xD9, 0xB3, 0x46, 0x8F, 0xF6, 0xC0, 0x3C, 0xFD,
  0x9A, 0x04, 0x18, 0x11, 0x3E, 0x38, 0x03, 0x03, 0x03, 0x3A, 0x7E, 0x66,
  0x46, 0x46, 0xC6, 0xC4, 0x7C, 0x7C, 0x1C, 0x7D, 0x9A, 0x37, 0xF8, 0x10,
  0x3E, 0x38, 0x39, 0xD9, 0xE6, 0x31, 0x18, 0xC6, 0x31, 0x00, 0x3A, 0x7E,
  0x66, 0x46, 0x46, 0xC6, 0xC4, 0x7C, 0x7C, 0x0C, 0xD8, 0x70, 0x30, 0x60,
  0x81, 0xE7, 0xEC, 0xD9, 0xB3, 0x45, 0x8B, 0x36, 0x60, 0x33, 0x02, 0x66,
  0x66, 0x64, 0xCC, 0x0C, 0x30, 0x02, 0x18, 0x61, 0x86, 0x10, 0x43, 0x0C,
  0x31, 0xCE, 0x00, 0x30, 0x30, 0x30, 0x26, 0x6C, 0x7C, 0x78, 0x78, 0x78,
  0x48, 0xCC, 0xCC, 0x33, 0x32, 0x66, 0x66, 0x64, 0xCC, 0x7D, 0xCF, 0xFD,
  0x99, 0xB3, 0x36, 0x66, 0x88, 0xB3, 0x16, 0x66, 0xCC, 0xC0, 0x7C, 0xFD,
  0x9B, 0x36, 0x68, 0xB1, 0x66, 0xCC, 0x1C, 0x7D, 0x9A, 0x34, 0x78, 0xD1,
  0xBE, 0x38, 0x3E, 0x3F, 0x33, 0x33, 0x33, 0x23, 0x63, 0x7E, 0x6C, 0x60,
  0x60, 0x40, 0x3A, 0xFD, 0x9A, 0x34, 0x78, 0xF1, 0x3E, 0x7C, 0x18, 0x30,
  0x40, 0x7B, 0xD8, 0xC6, 0x23, 0x18, 0xC0, 0x3C, 0xF9, 0x9B, 0x03, 0x81,
  0xB3, 0x7E, 0x78, 0x66, 0xF4, 0x4C, 0xCC, 0xCE, 0xE0, 0xCF, 0x3C, 0xF3,
  0xCE, 0x28, 0xBE, 0xF8, 0xCF, 0x3D, 0xB6, 0xD1, 0xC7, 0x18, 0x60, 0xC9,
  0xEC, 0xF6, 0x5B, 0x6F, 0xF7, 0x73, 0xB9, 0x9C, 0xCC, 0x00, 0x66, 0xD8,
  0xB1, 0xC3, 0x07, 0x1E, 0x64, 0xCC, 0x33, 0x33, 0x36, 0x36, 0x3C, 0x3C,
  0x18, 0x18, 0x10, 0x30, 0x60, 0x60, 0x7E, 0xF8, 0x30, 0xC3, 0x06, 0x18,
  0x7E, 0xFC, 0x08, 0xC4, 0x63, 0x18, 0xCC, 0xC3, 0x18, 0xC6, 0x31, 0x84,
  0x32, 0x22, 0x22, 0x64, 0x44, 0x44, 0xCC, 0x10, 0x86, 0x31, 0x88, 0x63,
  0x31, 0x8C, 0x42, 0x33, 0x00, 0x63, 0xFE, 0x70,
};

const GFXglyph RobotoCondensed_MediumItalic16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 4, 12, 4, 0, -12 },
  { 7, 4, 4, 5, 1, -12 },
  { 9, 8, 12, 8, 0, -12 },
  { 21, 7, 15, 8, 1, -14 },
  { 35, 8, 12, 10, 1, -12 },
  { 47, 8, 12, 9, 0, -12 },
  { 59, 2, 4, 3, 1, -12 },
  { 60, 5, 17, 5, 1, -13 },
  { 71, 5, 17, 5, -1, -13 },
  { 82, 6, 7, 7, 1, -12 },
  { 88, 6, 8, 8, 1, -10 },
  { 94, 3, 4, 3, -1, -2 },
  { 96, 3, 2, 5, 1, -6 },
  { 97, 3, 2, 4, 0, -2 },
  { 98, 7, 13, 5, -1, -12 },
  { 110, 6, 12, 8, 1, -12 },
  { 119, 4, 12, 8, 2, -12 },
  { 125, 7, 12, 8, 0, -12 },
  { 136, 7, 12, 8, 0, -12 },
  { 147, 7, 12, 8, 0, -12 },
  { 158, 7, 12, 8, 1, -12 },
  { 169, 6, 12, 8, 1, -12 },
  { 178, 7, 12, 8, 1, -12 },
  { 189, 7, 12, 8, 0, -12 },
  { 200, 6, 12, 8, 1, -12 },
  { 209, 4, 9, 4, 0, -9 },
  { 214, 5, 11, 4, -1, -9 },
  { 221, 7, 8, 7, 0, -9 },
  { 228, 6, 6, 8, 1, -8 },
  { 233, 7, 8, 7, 0, -9 },
  { 240, 6, 12, 7, 1, -12 },
  { 249, 11, 15, 12, 0, -11 },
  { 270, 9, 12, 9, -1, -12 },
  { 284, 8, 12, 9, 0, -12 },
  { 296, 8, 12, 9, 1, -12 },
  { 308, 8, 12, 9, 0, -12 },
  { 320, 8, 12, 8, 0, -12 },
  { 332, 8, 12, 7, 0, -12 },
  { 344, 8, 12, 9, 1, -12 },
  { 356, 10, 12, 10, 0, -12 },
  { 371, 4, 12, 4, 0, -12 },
  { 377, 8, 12, 8, 0, -12 },
  { 389, 10, 12, 9, 0, -12 },
  { 404, 6, 12, 7, 0, -12 },
  { 413, 12, 12, 12, 0, -12 },
  { 431, 10, 12, 10, 0, -12 },
  { 446, 8, 12, 9, 1, -12 },
  { 458, 9, 12, 9, 0, -12 },
  { 472, 8, 14, 9, 1, -12 },
  { 486, 8, 12, 8, 0, -12 },
  { 498, 8, 12, 8, 0, -12 },
  { 510, 8, 12, 8, 1, -12 },
  { 522, 8, 12, 9, 1, -12 },
  { 534, 9, 12, 9, 1, -12 },
  { 548, 11, 12, 12, 1, -12 },
  { 565, 9, 12, 9, 0, -12 },
  { 579, 8, 12, 8, 1, -12 },
  { 591, 9, 12, 8, 0, -12 },
  { 605, 5, 16, 4, 0, -13 },
  { 615, 4, 13, 6, 1, -12 },
  { 622, 5, 16, 4, -1, -13 },
  { 632, 5, 6, 6, 1, -12 },
  { 636, 6, 2, 6, -1, 0 },
  { 638, 3, 2, 5, 2, -12 },
  { 639, 7, 9, 7, 0, -9 },
  { 647, 7, 12, 8, 0, -12 },
  { 658, 7, 9, 7, 0, -9 },
  { 666, 8, 12, 8, 0, -12 },
  { 678, 7, 9, 7, 0, -9 },
  { 686, 5, 12, 5, 1, -12 },
  { 694, 8, 12, 8, 0, -9 },
  { 706, 7, 12, 8, 0, -12 },
  { 717, 4, 12, 4, 0, -12 },
  { 723, 6, 15, 4, -2, -12 },
  { 735, 8, 12, 7, 0, -12 },
  { 747, 4, 12, 4, 0, -12 },
  { 753, 11, 9, 12, 0, -9 },
  { 766, 7, 9, 8, 0, -9 },
  { 774, 7, 9, 8, 0, -9 },
  { 782, 8, 12, 8, -1, -9 },
  { 794, 7, 12, 8, 0, -9 },
  { 805, 5, 9, 5, 0, -9 },
  { 811, 7, 9, 7, 0, -9 },
  { 819, 4, 11, 5, 1, -11 },
  { 825, 6, 9, 8, 1, -9 },
  { 832, 6, 9, 7, 1, -9 },
  { 839, 9, 9, 10, 1, -9 },
  { 850, 7, 9, 7, 0, -9 },
  { 858, 8, 12, 7, -1, -9 },
  { 870, 7, 9, 7, 0, -9 },
  { 878, 5, 16, 5, 0, -13 },
  { 888, 4, 14, 4, 0, -12 },
  { 895, 5, 15, 5, -1, -12 },
  { 905, 7, 3, 9, 1, -6 },
};

const GFXfont RobotoCondensed_MediumItalic16pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_MediumItalic16pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_MediumItalic16pt7bGlyphs,
  0x20, 0x7E, 19
};

#endif // _ROBOTOCONDENSED_MEDIUMITALIC16PT7B_H_
