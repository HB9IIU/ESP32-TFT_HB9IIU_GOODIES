#ifndef _ROBOTOCONDENSED_MEDIUMITALIC14PT7B_H_
#define _ROBOTOCONDENSED_MEDIUMITALIC14PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-MediumItalic.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_MediumItalic14pt7bBitmaps[] PROGMEM = {
  0x00, 0x22, 0x26, 0x66, 0x40, 0xCC, 0x5F, 0xAA, 0x0A, 0x14, 0x51, 0xF1,
  0x45, 0x1F, 0x14, 0x50, 0xA0, 0x08, 0x38, 0xD1, 0x32, 0x06, 0x06, 0x06,
  0xCC, 0xD9, 0xE1, 0x00, 0x61, 0xAA, 0x54, 0xC7, 0x03, 0x8C, 0xA9, 0xD6,
  0x18, 0x1C, 0x68, 0x91, 0x63, 0x0E, 0x57, 0xE6, 0x4C, 0xEC, 0xFA, 0x12,
  0x64, 0xCC, 0x88, 0x88, 0x88, 0xC4, 0x20, 0x84, 0x31, 0x8C, 0x62, 0x10,
  0x8C, 0x44, 0x40, 0x31, 0x3E, 0xC5, 0x48, 0x18, 0x61, 0x1F, 0x7C, 0xC3,
  0x0C, 0x6D, 0x60, 0x70, 0x70, 0x04, 0x10, 0x82, 0x10, 0x43, 0x08, 0x61,
  0x0C, 0x00, 0x3B, 0x73, 0x98, 0xC6, 0x73, 0x97, 0x00, 0x2E, 0x26, 0x66,
  0x44, 0x4C, 0x3C, 0x49, 0x90, 0x20, 0xC3, 0x0C, 0x30, 0x41, 0xF8, 0x3C,
  0xB6, 0x41, 0x0C, 0xE0, 0xF3, 0x49, 0xE0, 0x0C, 0x31, 0xC7, 0x2D, 0xA4,
  0xBF, 0x18, 0x60, 0x7D, 0x04, 0x3C, 0xD8, 0x20, 0xA6, 0xD1, 0xC0, 0x1B,
  0x91, 0xED, 0xC6, 0x33, 0xD3, 0x80, 0xFC, 0x30, 0x86, 0x10, 0xC2, 0x18,
  0x43, 0x00, 0x1C, 0x69, 0x91, 0x63, 0x8D, 0x93, 0x66, 0x48, 0xF0, 0x32,
  0xF3, 0x9C, 0xED, 0xE2, 0x76, 0x00, 0x2C, 0x00, 0x16, 0x33, 0x00, 0x00,
  0x66, 0x4C, 0x04, 0x77, 0x10, 0x70, 0xE0, 0x80, 0xF8, 0x3E, 0x41, 0xC1,
  0x83, 0x39, 0x88, 0x00, 0x76, 0xF6, 0x33, 0x31, 0x00, 0x46, 0x00, 0x0F,
  0x04, 0x22, 0x04, 0x99, 0x4A, 0x54, 0x95, 0x26, 0x4A, 0x96, 0xA6, 0xC4,
  0x01, 0x00, 0x3C, 0x00, 0x06, 0x06, 0x0E, 0x0A, 0x1A, 0x12, 0x33, 0x3F,
  0x63, 0x43, 0x3C, 0x4D, 0x8B, 0x37, 0xCC, 0x91, 0xA2, 0xCD, 0xF0, 0x3C,
  0xDB, 0x1E, 0x0C, 0x10, 0x20, 0x46, 0xD8, 0xE0, 0x3C, 0x4D, 0x8B, 0x16,
  0x2C, 0xD1, 0xA3, 0xCD, 0xF0, 0x3E, 0x41, 0x83, 0x06, 0x0F, 0x90, 0x20,
  0xC1, 0xF8, 0x3E, 0x41, 0x83, 0x06, 0x0F, 0x90, 0x20, 0xC1, 0x80, 0x3C,
  0xDB, 0x1E, 0x0C, 0x13, 0xA3, 0x46, 0xDC, 0xF0, 0x21, 0x21, 0x63, 0x63,
  0x63, 0x7F, 0x42, 0x42, 0xC6, 0xC6, 0x32, 0x26, 0x66, 0x44, 0x4C, 0x06,
  0x0C, 0x10, 0x20, 0xC1, 0x83, 0x64, 0xD8, 0xE0, 0x23, 0x26, 0x6C, 0x68,
  0x78, 0x78, 0x68, 0x4C, 0xCC, 0xC6, 0x20, 0x86, 0x18, 0x61, 0x84, 0x10,
  0xC3, 0xE0, 0x30, 0xCC, 0x37, 0x1D, 0xC7, 0x73, 0xDE, 0xA5, 0xE9, 0x36,
  0xCD, 0xB2, 0x60, 0x31, 0x31, 0x73, 0x7B, 0x6B, 0x6B, 0x4A, 0x4E, 0xC6,
  0xC6, 0x3C, 0xDB, 0x1E, 0x3C, 0x70, 0xE1, 0x46, 0xD8, 0xE0, 0x3E, 0x26,
  0x63, 0x63, 0x66, 0x7C, 0x40, 0x40, 0xC0, 0xC0, 0x3C, 0xDB, 0x1E, 0x3C,
  0x70, 0xA1, 0x46, 0xD8, 0xF0, 0x60, 0x40, 0x3C, 0x4D, 0x8B, 0x16, 0x6F,
  0x93, 0x26, 0xCD, 0x88, 0x1C, 0x6D, 0x8B, 0x03, 0x83, 0x81, 0x62, 0x6C,
  0xF0, 0xFE, 0x20, 0xC1, 0x83, 0x04, 0x08, 0x10, 0x60, 0xC0, 0x46, 0x8F,
  0x1E, 0x2C, 0x51, 0xA3, 0x46, 0xD8, 0xE0, 0xC7, 0x8F, 0x12, 0x64, 0x8B,
  0x16, 0x38, 0x70, 0xC0, 0xCC, 0xF3, 0x2C, 0xDB, 0x56, 0xD5, 0x3D, 0x4E,
  0x71, 0x98, 0x66, 0x11, 0x80, 0x63, 0x36, 0x36, 0x3C, 0x18, 0x18, 0x38,
  0x6C, 0x4C, 0xC4, 0xC6, 0x99, 0x33, 0xC7, 0x06, 0x08, 0x10, 0x60, 0xC0,
  0x7E, 0x06, 0x04, 0x0C, 0x18, 0x30, 0x30, 0x60, 0xC0, 0xFC, 0x32, 0x26,
  0x66, 0x44, 0x4C, 0xCC, 0xC0, 0xD9, 0x24, 0x9B, 0x64, 0x80, 0x38, 0xC4,
  0x23, 0x18, 0xC6, 0x21, 0x18, 0xCE, 0x00, 0x26, 0x7D, 0x90, 0xFC, 0x44,
  0x39, 0xB0, 0xCF, 0x4F, 0x2D, 0x9A, 0x20, 0x86, 0x1F, 0x6D, 0x94, 0x51,
  0xCF, 0x3F, 0x80, 0x39, 0xB4, 0xD0, 0xC3, 0x25, 0x9C, 0x06, 0x0C, 0x19,
  0xA6, 0xC8, 0x93, 0x66, 0xCC, 0xB1, 0xE0, 0x39, 0xB4, 0x53, 0xFF, 0x04,
  0x9E, 0x36, 0x6E, 0x4C, 0xCC, 0xC8, 0x80, 0x3C, 0xD9, 0x12, 0x6C, 0xD9,
  0x93, 0x3C, 0x09, 0x33, 0xC0, 0x20, 0x86, 0x1E, 0x6D, 0xB4, 0xD3, 0xCF,
  0x2C, 0x80, 0x24, 0x36, 0xD2, 0x5B, 0x00, 0x11, 0x03, 0x33, 0x22, 0x26,
  0x66, 0x4C, 0x20, 0x41, 0x83, 0x66, 0x8F, 0x1C, 0x38, 0xD9, 0xB3, 0x20,
  0x22, 0x26, 0x66, 0x44, 0x4C, 0xC0, 0x7B, 0x9B, 0xA6, 0xC9, 0x32, 0x4C,
  0xB3, 0x6C, 0x9B, 0x26, 0x7D, 0xB4, 0xD3, 0x4F, 0x3C, 0xB2, 0x39, 0xB4,
  0x51, 0xC7, 0x34, 0x9E, 0x7D, 0xB4, 0x51, 0x47, 0x3C, 0xBE, 0xC2, 0x08,
  0x00, 0x34, 0xD9, 0x12, 0x6C, 0xD9, 0x92, 0x3C, 0x08, 0x30, 0x60, 0x7B,
  0x90, 0x84, 0x63, 0x18, 0x39, 0xB4, 0x1C, 0x38, 0x2D, 0x9C, 0x27, 0x26,
  0x66, 0x44, 0x60, 0x65, 0x94, 0xD3, 0x4F, 0x35, 0x9E, 0x9C, 0xF5, 0xEE,
  0x71, 0x88, 0x9B, 0x9A, 0xBA, 0xAE, 0xAC, 0xCC, 0xCC, 0xC8, 0x6D, 0xA3,
  0x8C, 0x31, 0xCD, 0xB6, 0x4D, 0x36, 0x9E, 0x71, 0xC7, 0x08, 0x63, 0x0C,
  0x00, 0x7C, 0x31, 0x8C, 0x21, 0x8C, 0x3E, 0x19, 0x8C, 0x42, 0x33, 0x08,
  0x62, 0x10, 0x82, 0x00, 0x24, 0x94, 0x92, 0x4B, 0x40, 0x20, 0x84, 0x21,
  0x08, 0x43, 0x31, 0x08, 0x46, 0x20, 0x66, 0xF9, 0x80,
};

const GFXglyph RobotoCondensed_MediumItalic14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 4, 10, 3, 0, -10 },
  { 6, 4, 4, 4, 1, -11 },
  { 8, 7, 10, 7, 0, -10 },
  { 17, 7, 12, 7, 0, -11 },
  { 28, 7, 10, 9, 1, -10 },
  { 37, 7, 10, 8, 0, -10 },
  { 46, 2, 4, 2, 1, -11 },
  { 47, 4, 14, 4, 1, -11 },
  { 54, 5, 14, 4, -1, -11 },
  { 63, 5, 6, 6, 1, -10 },
  { 67, 6, 8, 7, 0, -9 },
  { 73, 3, 4, 3, -1, -2 },
  { 75, 4, 1, 4, 0, -5 },
  { 76, 2, 2, 4, 0, -2 },
  { 77, 6, 11, 5, -1, -10 },
  { 86, 5, 10, 7, 1, -10 },
  { 93, 4, 10, 7, 2, -10 },
  { 98, 7, 10, 7, 0, -10 },
  { 107, 6, 10, 7, 0, -10 },
  { 115, 6, 10, 7, 0, -10 },
  { 123, 6, 10, 7, 1, -10 },
  { 131, 5, 10, 7, 1, -10 },
  { 138, 6, 10, 7, 1, -10 },
  { 146, 7, 10, 7, 0, -10 },
  { 155, 5, 10, 7, 1, -10 },
  { 162, 3, 8, 4, 0, -8 },
  { 165, 4, 10, 3, -1, -8 },
  { 170, 6, 7, 6, 0, -8 },
  { 176, 5, 3, 7, 1, -6 },
  { 178, 6, 7, 6, 0, -8 },
  { 184, 5, 10, 6, 1, -10 },
  { 191, 10, 13, 10, 0, -10 },
  { 208, 8, 10, 8, -1, -10 },
  { 218, 7, 10, 8, 0, -10 },
  { 227, 7, 10, 8, 1, -10 },
  { 236, 7, 10, 8, 0, -10 },
  { 245, 7, 10, 7, 0, -10 },
  { 254, 7, 10, 7, 0, -10 },
  { 263, 7, 10, 8, 1, -10 },
  { 272, 8, 10, 8, 0, -10 },
  { 282, 4, 10, 4, 0, -10 },
  { 287, 7, 10, 7, 0, -10 },
  { 296, 8, 10, 7, 0, -10 },
  { 306, 6, 10, 6, 0, -10 },
  { 314, 10, 10, 10, 0, -10 },
  { 327, 8, 10, 8, 0, -10 },
  { 337, 7, 10, 8, 1, -10 },
  { 346, 8, 10, 8, 0, -10 },
  { 356, 7, 12, 8, 1, -10 },
  { 367, 7, 10, 7, 0, -10 },
  { 376, 7, 10, 7, 0, -10 },
  { 385, 7, 10, 7, 1, -10 },
  { 394, 7, 10, 8, 1, -10 },
  { 403, 7, 10, 8, 1, -10 },
  { 412, 10, 10, 10, 1, -10 },
  { 425, 8, 10, 8, 0, -10 },
  { 435, 7, 10, 7, 1, -10 },
  { 444, 8, 10, 7, 0, -10 },
  { 454, 4, 13, 4, 0, -11 },
  { 461, 3, 11, 5, 1, -10 },
  { 466, 5, 13, 4, -1, -11 },
  { 475, 4, 5, 5, 1, -10 },
  { 478, 6, 1, 5, -1, 0 },
  { 479, 3, 2, 4, 1, -10 },
  { 480, 6, 8, 6, 0, -8 },
  { 486, 6, 11, 7, 0, -11 },
  { 495, 6, 8, 6, 0, -8 },
  { 501, 7, 11, 7, 0, -11 },
  { 511, 6, 8, 6, 0, -8 },
  { 517, 4, 11, 4, 1, -11 },
  { 523, 7, 11, 7, 0, -8 },
  { 533, 6, 11, 7, 0, -11 },
  { 542, 3, 11, 3, 0, -11 },
  { 547, 4, 14, 3, -1, -11 },
  { 554, 7, 11, 6, 0, -11 },
  { 564, 4, 11, 3, 0, -11 },
  { 570, 10, 8, 10, 0, -8 },
  { 580, 6, 8, 7, 0, -8 },
  { 586, 6, 8, 7, 0, -8 },
  { 592, 6, 11, 7, 0, -8 },
  { 601, 7, 11, 7, 0, -8 },
  { 611, 5, 8, 4, 0, -8 },
  { 616, 6, 8, 6, 0, -8 },
  { 622, 4, 9, 4, 0, -9 },
  { 627, 6, 8, 7, 0, -8 },
  { 633, 5, 8, 6, 1, -8 },
  { 638, 8, 8, 9, 1, -8 },
  { 646, 6, 8, 6, 0, -8 },
  { 652, 6, 11, 6, 0, -8 },
  { 661, 6, 8, 6, 0, -8 },
  { 667, 5, 13, 4, 0, -11 },
  { 676, 3, 12, 3, 0, -10 },
  { 681, 5, 14, 4, -1, -11 },
  { 690, 6, 3, 8, 1, -6 },
};

const GFXfont RobotoCondensed_MediumItalic14pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_MediumItalic14pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_MediumItalic14pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _ROBOTOCONDENSED_MEDIUMITALIC14PT7B_H_
