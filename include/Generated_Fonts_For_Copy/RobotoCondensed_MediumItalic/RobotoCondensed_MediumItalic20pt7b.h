#ifndef _ROBOTOCONDENSED_MEDIUMITALIC20PT7B_H_
#define _ROBOTOCONDENSED_MEDIUMITALIC20PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-MediumItalic.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_MediumItalic20pt7bBitmaps[] PROGMEM = {
  0x00, 0x18, 0xCE, 0x63, 0x18, 0xC6, 0x60, 0x00, 0xCE, 0x30, 0xDE, 0xF5,
  0x2B, 0x00, 0x04, 0x83, 0x60, 0x90, 0x24, 0x7F, 0xDF, 0xE1, 0x20, 0xD8,
  0x26, 0x3F, 0xCF, 0xF1, 0x30, 0x48, 0x36, 0x00, 0x04, 0x04, 0x1E, 0x3F,
  0x73, 0x63, 0x63, 0x70, 0x38, 0x1E, 0x06, 0xC6, 0xC6, 0xC6, 0xFE, 0x78,
  0x30, 0x20, 0x70, 0x6C, 0x36, 0x73, 0x69, 0xE6, 0xA1, 0xF0, 0x3E, 0x1D,
  0x96, 0x5B, 0x79, 0x30, 0xD8, 0x38, 0x0F, 0x07, 0xC1, 0x98, 0x66, 0x1B,
  0x07, 0x81, 0xC0, 0xF3, 0x7E, 0xD9, 0xEE, 0x79, 0x8C, 0x7F, 0x8F, 0x60,
  0x6D, 0x2C, 0x04, 0x31, 0x8C, 0x31, 0x86, 0x18, 0x63, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC1, 0x06, 0x18, 0x20, 0x10, 0x60, 0x83, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x61, 0x86, 0x30, 0xC6, 0x30, 0x80, 0x0C, 0x08,
  0x49, 0xFF, 0x18, 0x3C, 0x6C, 0x44, 0x0C, 0x1C, 0x18, 0x18, 0xFF, 0xFF,
  0x38, 0x30, 0x30, 0x30, 0x36, 0x66, 0xCC, 0xFF, 0x7D, 0x80, 0x01, 0x81,
  0x80, 0xC0, 0xC0, 0x60, 0x60, 0x30, 0x30, 0x18, 0x18, 0x0C, 0x04, 0x06,
  0x02, 0x03, 0x00, 0x1E, 0x3F, 0x73, 0x63, 0x63, 0xE3, 0xE3, 0xC3, 0xC7,
  0xC6, 0xC6, 0xC6, 0xFC, 0x78, 0x0C, 0xF7, 0xB6, 0x18, 0x61, 0x8E, 0x30,
  0xC3, 0x0C, 0x31, 0xC0, 0x0F, 0x0F, 0xCE, 0x66, 0x33, 0x18, 0x1C, 0x0C,
  0x0C, 0x0C, 0x0E, 0x0E, 0x0E, 0x0F, 0xF7, 0xF8, 0x0F, 0x0F, 0xCC, 0x66,
  0x30, 0x18, 0x1C, 0x3C, 0x3C, 0x03, 0x01, 0xB8, 0xCC, 0xE7, 0xE1, 0xE0,
  0x01, 0x81, 0xC1, 0xE1, 0xF0, 0xF0, 0xD8, 0xCC, 0x66, 0x67, 0x7F, 0xFF,
  0xE0, 0xC0, 0x60, 0x30, 0x3F, 0x9F, 0xCC, 0x06, 0x06, 0x03, 0xE1, 0xF8,
  0x4E, 0x07, 0x03, 0xB1, 0x98, 0xCF, 0xC3, 0xC0, 0x06, 0x1E, 0x38, 0x70,
  0x60, 0x7E, 0xFE, 0xE7, 0xC3, 0xC7, 0xC7, 0xC6, 0x7C, 0x38, 0x7F, 0xBF,
  0xC0, 0xC0, 0x60, 0x60, 0x30, 0x30, 0x18, 0x18, 0x1C, 0x0C, 0x0E, 0x06,
  0x07, 0x00, 0x1E, 0x3F, 0x73, 0x63, 0x63, 0x67, 0x3E, 0x7C, 0xE6, 0xC6,
  0xC6, 0xC6, 0xFC, 0x78, 0x1E, 0x3E, 0x63, 0x63, 0xE3, 0xE3, 0x67, 0x7F,
  0x3E, 0x06, 0x0E, 0x1C, 0x78, 0x70, 0x11, 0xCC, 0x00, 0x00, 0x00, 0x47,
  0x18, 0x18, 0xC6, 0x00, 0x00, 0x00, 0x01, 0x8C, 0xC6, 0x71, 0x00, 0x02,
  0x1C, 0xFF, 0x8C, 0x1E, 0x1E, 0x0E, 0x04, 0x7F, 0x7F, 0x00, 0x00, 0x00,
  0xFE, 0xFE, 0x20, 0x38, 0x3C, 0x0F, 0x03, 0x1F, 0x7C, 0x70, 0x40, 0x3C,
  0x7E, 0x66, 0x67, 0x06, 0x0E, 0x1C, 0x18, 0x30, 0x30, 0x00, 0x20, 0x60,
  0x60, 0x03, 0xE0, 0x1C, 0xE0, 0xC0, 0x86, 0x03, 0x31, 0xC4, 0x8D, 0x96,
  0x66, 0x59, 0x11, 0x4C, 0xC5, 0x33, 0x34, 0xCC, 0xB3, 0x22, 0x4F, 0xD9,
  0x19, 0xC6, 0x00, 0x18, 0x00, 0x3B, 0x80, 0x7C, 0x00, 0x01, 0x80, 0x70,
  0x0E, 0x03, 0x60, 0x6C, 0x1D, 0x83, 0x30, 0xE6, 0x18, 0xC7, 0xF8, 0xFF,
  0xB8, 0x76, 0x07, 0xC0, 0xC0, 0x1F, 0x8F, 0xF3, 0x8C, 0xC3, 0x30, 0xCC,
  0x73, 0xF9, 0xFE, 0x71, 0x98, 0x66, 0x19, 0x8E, 0x7F, 0x3F, 0x80, 0x0F,
  0x0F, 0xE3, 0x1D, 0x83, 0x60, 0xF8, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x6C,
  0x3B, 0x8C, 0x7F, 0x0F, 0x00, 0x1F, 0x07, 0xF0, 0xE7, 0x18, 0x63, 0x0C,
  0x61, 0x8C, 0x33, 0x86, 0x70, 0xCC, 0x39, 0x86, 0x31, 0xC7, 0xF1, 0xF8,
  0x00, 0x1F, 0xCF, 0xF3, 0x80, 0xC0, 0x30, 0x0C, 0x03, 0xF9, 0xFC, 0x70,
  0x18, 0x06, 0x01, 0x80, 0x7F, 0x3F, 0xC0, 0x1F, 0xCF, 0xF3, 0x80, 0xC0,
  0x30, 0x0C, 0x03, 0xF1, 0xFC, 0x70, 0x18, 0x06, 0x01, 0x80, 0x60, 0x38,
  0x00, 0x0F, 0x0F, 0xE3, 0x1D, 0x83, 0x60, 0xF8, 0x0E, 0x03, 0x1F, 0xC7,
  0xB0, 0x6C, 0x1B, 0x8E, 0x7F, 0x0F, 0x80, 0x18, 0x33, 0x83, 0x38, 0x73,
  0x07, 0x30, 0x63, 0x06, 0x3F, 0xE7, 0xFE, 0x70, 0xE6, 0x0C, 0x60, 0xC6,
  0x0C, 0x60, 0xCE, 0x1C, 0x18, 0xCE, 0x73, 0x18, 0xC6, 0x73, 0x18, 0xC6,
  0x70, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0xE0, 0x38, 0x0C, 0x03,
  0x00, 0xCC, 0x73, 0x98, 0x7E, 0x0F, 0x00, 0x18, 0x73, 0x8E, 0x39, 0xC3,
  0x38, 0x37, 0x03, 0x60, 0x3E, 0x07, 0xE0, 0x7E, 0x07, 0x70, 0x63, 0x06,
  0x38, 0x63, 0x8E, 0x18, 0x18, 0x38, 0x38, 0x30, 0x30, 0x30, 0x30, 0x70,
  0x70, 0x60, 0x60, 0x60, 0x7F, 0xFF, 0x1C, 0x0E, 0x78, 0x3C, 0xF0, 0x71,
  0xE1, 0xE3, 0xC3, 0xC7, 0x8D, 0x8D, 0x1B, 0x3B, 0x6E, 0x76, 0xD8, 0xCF,
  0x31, 0x9E, 0x63, 0x38, 0xC6, 0x73, 0x9C, 0xC6, 0x00, 0x18, 0x33, 0x83,
  0x3C, 0x73, 0xC6, 0x34, 0x63, 0x66, 0x36, 0x67, 0x6E, 0x73, 0xE6, 0x3C,
  0x63, 0xC6, 0x1C, 0x61, 0xCE, 0x1C, 0x0F, 0x0F, 0xE3, 0x1D, 0x83, 0x60,
  0xF8, 0x3E, 0x0F, 0x07, 0xC1, 0xF0, 0x6C, 0x1B, 0x8E, 0x7F, 0x0F, 0x00,
  0x1F, 0x87, 0xF8, 0xE3, 0x98, 0x33, 0x0E, 0x61, 0xCC, 0x33, 0xFE, 0x7F,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0xC0, 0x00, 0x0F, 0x0F, 0xE3, 0x1D,
  0x83, 0x60, 0xF8, 0x3E, 0x0F, 0x07, 0xC1, 0xF0, 0x6C, 0x1B, 0x8C, 0x7F,
  0x0F, 0x80, 0x70, 0x0C, 0x1F, 0x87, 0xF8, 0xE3, 0x18, 0x63, 0x0C, 0x61,
  0x8C, 0x73, 0xFC, 0x7F, 0x0C, 0x61, 0x8C, 0x31, 0xC6, 0x39, 0xC3, 0x00,
  0x0F, 0x87, 0xF3, 0x8C, 0xC3, 0x30, 0x0E, 0x01, 0xE0, 0x3C, 0x03, 0xB8,
  0x66, 0x19, 0x8E, 0x7F, 0x07, 0x80, 0xFF, 0xFF, 0xC6, 0x03, 0x01, 0x81,
  0xC0, 0xE0, 0x60, 0x30, 0x18, 0x0C, 0x0E, 0x07, 0x03, 0x00, 0x70, 0xDC,
  0x36, 0x0D, 0x87, 0x61, 0xD8, 0x6E, 0x1B, 0x86, 0xC1, 0xB0, 0xEC, 0x3B,
  0x9C, 0xFE, 0x0F, 0x00, 0xC1, 0xF0, 0x6C, 0x3B, 0x0E, 0xE3, 0x39, 0xC6,
  0x61, 0xB8, 0x6C, 0x1B, 0x07, 0x81, 0xE0, 0x70, 0x1C, 0x00, 0xC3, 0x1B,
  0x1C, 0x6C, 0x73, 0xB3, 0xCC, 0xCF, 0x33, 0x3D, 0xCD, 0xB6, 0x36, 0xD8,
  0xDB, 0xE3, 0xCF, 0x0F, 0x3C, 0x38, 0xF0, 0xE3, 0x83, 0x8E, 0x00, 0x1C,
  0x30, 0xE3, 0x83, 0x38, 0x19, 0x80, 0xFC, 0x03, 0xC0, 0x1C, 0x00, 0xE0,
  0x0F, 0x80, 0xEC, 0x06, 0x60, 0x73, 0x87, 0x1C, 0x38, 0x60, 0xC1, 0xB0,
  0xEE, 0x31, 0x9C, 0x66, 0x1B, 0x07, 0xC0, 0xE0, 0x38, 0x0C, 0x03, 0x01,
  0xC0, 0x70, 0x18, 0x00, 0x3F, 0xE7, 0xFC, 0x07, 0x00, 0xC0, 0x30, 0x0E,
  0x03, 0x80, 0x60, 0x18, 0x07, 0x01, 0xC0, 0x30, 0x0F, 0xF9, 0xFF, 0x00,
  0x1C, 0x73, 0x8C, 0x30, 0xC3, 0x0C, 0x71, 0xC6, 0x18, 0x61, 0x8E, 0x38,
  0xC3, 0x8E, 0x00, 0xCC, 0xCC, 0xE6, 0x66, 0x66, 0x67, 0x33, 0x30, 0x1C,
  0x70, 0xC3, 0x1C, 0x71, 0x86, 0x18, 0x63, 0x8E, 0x30, 0xC3, 0x0C, 0x33,
  0xCE, 0x00, 0x18, 0x63, 0x8A, 0x6D, 0x3C, 0xC0, 0xFE, 0xFE, 0xE6, 0x30,
  0x1E, 0x3F, 0x33, 0x03, 0x1F, 0x7B, 0x63, 0xE7, 0xE6, 0x7E, 0x7E, 0x18,
  0x1C, 0x0C, 0x06, 0x03, 0xF1, 0xF8, 0xCE, 0xE3, 0x61, 0xB0, 0xD8, 0xEC,
  0x66, 0x37, 0xFB, 0x78, 0x3C, 0x7E, 0xE6, 0xC7, 0xC0, 0xC0, 0xC0, 0xC6,
  0xCE, 0xFC, 0x78, 0x01, 0x80, 0xC0, 0xE0, 0x63, 0xB3, 0xFB, 0x9D, 0x86,
  0xC7, 0x63, 0x31, 0x98, 0xCC, 0xE7, 0xF1, 0xF8, 0x3C, 0x7E, 0x66, 0xC7,
  0xFF, 0xFE, 0xC0, 0xC0, 0xC4, 0xFE, 0x78, 0x1E, 0x78, 0xC1, 0x8F, 0x9F,
  0x18, 0x30, 0x60, 0xC1, 0x87, 0x0C, 0x18, 0x30, 0x00, 0x1D, 0x9F, 0xDC,
  0xEC, 0x36, 0x3B, 0x19, 0x8C, 0xC6, 0x63, 0x3F, 0x8F, 0xC0, 0xC0, 0x67,
  0xF1, 0xE0, 0x18, 0x1C, 0x0C, 0x06, 0x03, 0xF1, 0xF8, 0xCE, 0xE7, 0x63,
  0x31, 0x98, 0xCC, 0x6E, 0x37, 0x3B, 0x18, 0x11, 0xC6, 0x00, 0x18, 0xC6,
  0x73, 0x98, 0xC6, 0x33, 0x9C, 0x04, 0x1C, 0x18, 0x00, 0x01, 0x83, 0x06,
  0x1C, 0x30, 0x60, 0xC1, 0x83, 0x0E, 0x18, 0x30, 0x63, 0xC7, 0x00, 0x18,
  0x0E, 0x03, 0x00, 0xC0, 0x33, 0x8C, 0xC3, 0x61, 0xF8, 0x7C, 0x1F, 0x07,
  0xC1, 0xB8, 0x66, 0x39, 0x8C, 0x70, 0x18, 0xCE, 0x63, 0x18, 0xC6, 0x73,
  0x18, 0xC6, 0x73, 0x80, 0x3F, 0x78, 0xFF, 0xE3, 0x39, 0xDC, 0xE7, 0x63,
  0x19, 0x8C, 0x66, 0x31, 0x98, 0xC6, 0x63, 0x1B, 0x9C, 0xEC, 0x63, 0x00,
  0x3F, 0x1F, 0x9C, 0xEE, 0x76, 0x33, 0x19, 0x8C, 0xC6, 0xE3, 0x73, 0xB1,
  0x80, 0x3C, 0x7E, 0x67, 0xC3, 0xC3, 0xC3, 0xC7, 0xC6, 0xC6, 0xFC, 0x78,
  0x1F, 0x87, 0xE3, 0x9C, 0xE3, 0x30, 0xCC, 0x33, 0x1C, 0xC6, 0x71, 0x9F,
  0xE6, 0xF1, 0x80, 0x60, 0x18, 0x0E, 0x00, 0x3B, 0x7F, 0xE7, 0xC7, 0xC7,
  0xC6, 0xC6, 0xC6, 0xCE, 0xFE, 0x7E, 0x0C, 0x0C, 0x0C, 0x0C, 0x3E, 0x78,
  0xE3, 0x86, 0x0C, 0x18, 0x30, 0x61, 0xC3, 0x00, 0x1E, 0x3F, 0x73, 0x60,
  0x38, 0x3C, 0x0E, 0x07, 0xE6, 0x7E, 0x3C, 0x31, 0xBF, 0xF6, 0x31, 0x8C,
  0xE6, 0x31, 0xC6, 0x00, 0x63, 0x63, 0xE3, 0xE7, 0xC6, 0xC6, 0xC6, 0xC6,
  0xCE, 0xFE, 0x7C, 0xC7, 0xC6, 0xE6, 0x6C, 0x6C, 0x6C, 0x78, 0x78, 0x70,
  0x70, 0x70, 0xC6, 0x3C, 0x66, 0xCE, 0x6C, 0xEE, 0xDE, 0xCD, 0xAC, 0x53,
  0x87, 0x38, 0x73, 0x86, 0x30, 0x63, 0x00, 0x39, 0xC6, 0x61, 0xB0, 0x6C,
  0x0E, 0x03, 0x81, 0xE0, 0x78, 0x37, 0x1C, 0xC6, 0x30, 0x31, 0xCE, 0x63,
  0x98, 0xEC, 0x1B, 0x07, 0xC1, 0xE0, 0x78, 0x1C, 0x07, 0x01, 0x80, 0x60,
  0x30, 0x3C, 0x0E, 0x00, 0x3F, 0xBF, 0x81, 0xC1, 0xC0, 0xC0, 0xC0, 0xE0,
  0xE0, 0x60, 0x7F, 0x3F, 0x80, 0x0C, 0x61, 0x8C, 0x30, 0xC3, 0x1C, 0x63,
  0x8C, 0x30, 0x61, 0x8C, 0x30, 0xC3, 0x06, 0x08, 0x10, 0x84, 0x63, 0x18,
  0xC4, 0x23, 0x18, 0xC6, 0x21, 0x08, 0xC0, 0x10, 0x60, 0x83, 0x0C, 0x61,
  0x86, 0x18, 0x30, 0xC6, 0x38, 0xC3, 0x0C, 0x31, 0x8E, 0x30, 0x70, 0xBC,
  0xF3, 0xF8, 0xE0,
};

const GFXglyph RobotoCondensed_MediumItalic20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 5, 14, 5, 0, -14 },
  { 10, 5, 5, 6, 2, -15 },
  { 14, 10, 14, 10, 1, -14 },
  { 32, 8, 18, 10, 1, -16 },
  { 50, 9, 14, 12, 2, -14 },
  { 66, 10, 14, 11, 0, -14 },
  { 84, 3, 5, 3, 1, -15 },
  { 86, 6, 21, 6, 1, -16 },
  { 102, 6, 21, 6, -1, -16 },
  { 118, 8, 8, 9, 1, -14 },
  { 126, 8, 10, 9, 1, -12 },
  { 136, 4, 6, 4, -1, -2 },
  { 139, 4, 2, 6, 1, -7 },
  { 140, 3, 3, 5, 0, -3 },
  { 142, 9, 15, 7, -1, -14 },
  { 159, 8, 14, 10, 1, -14 },
  { 173, 6, 14, 10, 2, -14 },
  { 184, 9, 14, 10, 0, -14 },
  { 200, 9, 14, 10, 0, -14 },
  { 216, 9, 14, 10, 0, -14 },
  { 232, 9, 14, 10, 1, -14 },
  { 248, 8, 14, 10, 1, -14 },
  { 262, 9, 14, 10, 1, -14 },
  { 278, 8, 14, 10, 1, -14 },
  { 292, 8, 14, 10, 1, -14 },
  { 306, 5, 11, 5, 0, -11 },
  { 313, 5, 15, 5, -1, -11 },
  { 323, 7, 9, 9, 1, -11 },
  { 331, 8, 7, 10, 1, -10 },
  { 338, 8, 9, 9, 0, -11 },
  { 347, 8, 14, 8, 1, -14 },
  { 361, 14, 18, 15, 0, -14 },
  { 393, 11, 14, 11, -1, -14 },
  { 413, 10, 14, 11, 0, -14 },
  { 431, 10, 14, 11, 1, -14 },
  { 449, 11, 14, 11, 0, -14 },
  { 469, 10, 14, 10, 0, -14 },
  { 487, 10, 14, 9, 0, -14 },
  { 505, 10, 14, 11, 1, -14 },
  { 523, 12, 14, 12, 0, -14 },
  { 544, 5, 14, 5, 0, -14 },
  { 553, 10, 14, 9, 0, -14 },
  { 571, 12, 14, 11, 0, -14 },
  { 592, 8, 14, 9, 0, -14 },
  { 606, 15, 14, 15, 0, -14 },
  { 633, 12, 14, 12, 0, -14 },
  { 654, 10, 14, 12, 1, -14 },
  { 672, 11, 14, 11, 0, -14 },
  { 692, 10, 16, 12, 1, -14 },
  { 712, 11, 14, 11, 0, -14 },
  { 732, 10, 14, 10, 0, -14 },
  { 750, 9, 14, 10, 2, -14 },
  { 766, 10, 14, 11, 1, -14 },
  { 784, 10, 14, 11, 2, -14 },
  { 802, 14, 14, 15, 2, -14 },
  { 827, 13, 14, 11, -1, -14 },
  { 850, 10, 14, 10, 2, -14 },
  { 868, 11, 14, 10, 0, -14 },
  { 888, 6, 19, 5, 0, -16 },
  { 903, 4, 15, 7, 2, -14 },
  { 911, 6, 19, 5, -1, -16 },
  { 926, 6, 7, 7, 1, -14 },
  { 932, 8, 2, 8, -1, 0 },
  { 934, 4, 3, 6, 2, -15 },
  { 936, 8, 11, 9, 0, -11 },
  { 947, 9, 15, 10, 0, -15 },
  { 964, 8, 11, 9, 1, -11 },
  { 975, 9, 15, 10, 1, -15 },
  { 992, 8, 11, 9, 1, -11 },
  { 1003, 7, 15, 6, 1, -15 },
  { 1017, 9, 15, 10, 0, -11 },
  { 1034, 9, 15, 9, 0, -15 },
  { 1051, 5, 16, 5, 0, -16 },
  { 1061, 7, 20, 5, -2, -16 },
  { 1079, 10, 15, 9, 0, -15 },
  { 1098, 5, 15, 5, 0, -15 },
  { 1108, 14, 11, 15, 0, -11 },
  { 1128, 9, 11, 9, 0, -11 },
  { 1141, 8, 11, 10, 1, -11 },
  { 1152, 10, 15, 10, -1, -11 },
  { 1171, 8, 15, 10, 1, -11 },
  { 1186, 7, 11, 6, 0, -11 },
  { 1196, 8, 11, 9, 0, -11 },
  { 1207, 5, 13, 6, 1, -13 },
  { 1216, 8, 11, 9, 1, -11 },
  { 1227, 8, 11, 9, 1, -11 },
  { 1238, 12, 11, 12, 1, -11 },
  { 1255, 10, 11, 9, -1, -11 },
  { 1269, 10, 15, 8, -1, -11 },
  { 1288, 9, 11, 9, 0, -11 },
  { 1301, 6, 20, 6, 1, -16 },
  { 1316, 5, 17, 5, 0, -14 },
  { 1327, 6, 20, 6, -1, -16 },
  { 1342, 9, 4, 11, 1, -8 },
};

const GFXfont RobotoCondensed_MediumItalic20pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_MediumItalic20pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_MediumItalic20pt7bGlyphs,
  0x20, 0x7E, 23
};

#endif // _ROBOTOCONDENSED_MEDIUMITALIC20PT7B_H_
