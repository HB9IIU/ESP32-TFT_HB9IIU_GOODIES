#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated:Fonts_For_Copy/RobotoCondensed_MediumItalic
// Headers: 67

#include "RobotoCondensed_MediumItalic6pt7b.h"
#include "RobotoCondensed_MediumItalic7pt7b.h"
#include "RobotoCondensed_MediumItalic8pt7b.h"
#include "RobotoCondensed_MediumItalic9pt7b.h"
#include "RobotoCondensed_MediumItalic10pt7b.h"
#include "RobotoCondensed_MediumItalic11pt7b.h"
#include "RobotoCondensed_MediumItalic12pt7b.h"
#include "RobotoCondensed_MediumItalic13pt7b.h"
#include "RobotoCondensed_MediumItalic14pt7b.h"
#include "RobotoCondensed_MediumItalic15pt7b.h"
#include "RobotoCondensed_MediumItalic16pt7b.h"
#include "RobotoCondensed_MediumItalic17pt7b.h"
#include "RobotoCondensed_MediumItalic18pt7b.h"
#include "RobotoCondensed_MediumItalic19pt7b.h"
#include "RobotoCondensed_MediumItalic20pt7b.h"
#include "RobotoCondensed_MediumItalic21pt7b.h"
#include "RobotoCondensed_MediumItalic22pt7b.h"
#include "RobotoCondensed_MediumItalic23pt7b.h"
#include "RobotoCondensed_MediumItalic24pt7b.h"
#include "RobotoCondensed_MediumItalic25pt7b.h"
#include "RobotoCondensed_MediumItalic26pt7b.h"
#include "RobotoCondensed_MediumItalic27pt7b.h"
#include "RobotoCondensed_MediumItalic28pt7b.h"
#include "RobotoCondensed_MediumItalic29pt7b.h"
#include "RobotoCondensed_MediumItalic30pt7b.h"
#include "RobotoCondensed_MediumItalic31pt7b.h"
#include "RobotoCondensed_MediumItalic32pt7b.h"
#include "RobotoCondensed_MediumItalic33pt7b.h"
#include "RobotoCondensed_MediumItalic34pt7b.h"
#include "RobotoCondensed_MediumItalic35pt7b.h"
#include "RobotoCondensed_MediumItalic36pt7b.h"
#include "RobotoCondensed_MediumItalic37pt7b.h"
#include "RobotoCondensed_MediumItalic38pt7b.h"
#include "RobotoCondensed_MediumItalic39pt7b.h"
#include "RobotoCondensed_MediumItalic40pt7b.h"
#include "RobotoCondensed_MediumItalic41pt7b.h"
#include "RobotoCondensed_MediumItalic42pt7b.h"
#include "RobotoCondensed_MediumItalic43pt7b.h"
#include "RobotoCondensed_MediumItalic44pt7b.h"
#include "RobotoCondensed_MediumItalic45pt7b.h"
#include "RobotoCondensed_MediumItalic46pt7b.h"
#include "RobotoCondensed_MediumItalic47pt7b.h"
#include "RobotoCondensed_MediumItalic48pt7b.h"
#include "RobotoCondensed_MediumItalic49pt7b.h"
#include "RobotoCondensed_MediumItalic50pt7b.h"
#include "RobotoCondensed_MediumItalic51pt7b.h"
#include "RobotoCondensed_MediumItalic52pt7b.h"
#include "RobotoCondensed_MediumItalic53pt7b.h"
#include "RobotoCondensed_MediumItalic54pt7b.h"
#include "RobotoCondensed_MediumItalic55pt7b.h"
#include "RobotoCondensed_MediumItalic56pt7b.h"
#include "RobotoCondensed_MediumItalic57pt7b.h"
#include "RobotoCondensed_MediumItalic58pt7b.h"
#include "RobotoCondensed_MediumItalic59pt7b.h"
#include "RobotoCondensed_MediumItalic60pt7b.h"
#include "RobotoCondensed_MediumItalic61pt7b.h"
#include "RobotoCondensed_MediumItalic62pt7b.h"
#include "RobotoCondensed_MediumItalic63pt7b.h"
#include "RobotoCondensed_MediumItalic64pt7b.h"
#include "RobotoCondensed_MediumItalic65pt7b.h"
#include "RobotoCondensed_MediumItalic66pt7b.h"
#include "RobotoCondensed_MediumItalic67pt7b.h"
#include "RobotoCondensed_MediumItalic68pt7b.h"
#include "RobotoCondensed_MediumItalic69pt7b.h"
#include "RobotoCondensed_MediumItalic70pt7b.h"
#include "RobotoCondensed_MediumItalic71pt7b.h"
#include "RobotoCondensed_MediumItalic72pt7b.h"
