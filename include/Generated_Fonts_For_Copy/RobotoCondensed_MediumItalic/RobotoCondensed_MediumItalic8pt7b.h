#ifndef _ROBOTOCONDENSED_MEDIUMITALIC8PT7B_H_
#define _ROBOTOCONDENSED_MEDIUMITALIC8PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-MediumItalic.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_MediumItalic8pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x20, 0xE0, 0x33, 0x76, 0x7A, 0x22, 0x54, 0x2A, 0x64, 0xDE,
  0xBE, 0xC0, 0x25, 0x67, 0xBF, 0xC0, 0x29, 0x49, 0x22, 0x55, 0x58, 0x23,
  0x62, 0x22, 0xE4, 0xC0, 0xC0, 0x80, 0x25, 0x29, 0x00, 0x25, 0x59, 0xA6,
  0x35, 0xA0, 0x65, 0x12, 0x4E, 0x65, 0x62, 0xAE, 0x12, 0x6A, 0xE2, 0x74,
  0x62, 0xA6, 0x24, 0x69, 0xA6, 0x71, 0x22, 0x44, 0x25, 0x56, 0xAE, 0xD6,
  0xE5, 0x00, 0x42, 0x42, 0x80, 0x71, 0x80, 0x70, 0xE0, 0x47, 0x00, 0xF6,
  0x20, 0x19, 0x97, 0x6D, 0xD6, 0xE8, 0x18, 0x22, 0x55, 0xF9, 0x75, 0x5B,
  0x9E, 0x35, 0x48, 0x96, 0x65, 0x59, 0x9E, 0x74, 0x4A, 0x8E, 0x74, 0x46,
  0x88, 0x35, 0x4B, 0x97, 0x4A, 0x55, 0x69, 0x48, 0x55, 0xA0, 0x11, 0x12,
  0xAE, 0x5A, 0x98, 0xCA, 0x48, 0x49, 0x49, 0xC0, 0x45, 0x36, 0xEE, 0xBA,
  0xA0, 0x4A, 0x5D, 0x69, 0x48, 0x35, 0x59, 0x96, 0x75, 0x57, 0x88, 0x35,
  0x59, 0x96, 0x10, 0x65, 0x56, 0xA9, 0x25, 0x42, 0x96, 0xE4, 0x44, 0x88,
  0x4A, 0x95, 0x29, 0x30, 0x9A, 0xAC, 0xCC, 0xAD, 0x7B, 0xEB, 0x50, 0x5A,
  0x98, 0xC6, 0x48, 0x9A, 0xCC, 0x88, 0x71, 0x24, 0x4E, 0x49, 0x29, 0x24,
  0xFC, 0x55, 0x6A, 0x0E, 0x80, 0xE0, 0x80, 0x6E, 0xF0, 0x44, 0x69, 0xAE,
  0x72, 0x70, 0x11, 0x7A, 0xAE, 0x7E, 0x30, 0x69, 0x25, 0x00, 0x7A, 0xAE,
  0x2C, 0x49, 0xDB, 0x40, 0x46, 0xA0, 0x20, 0xA4, 0x94, 0x44, 0x6C, 0xAA,
  0x56, 0xA0, 0x7D, 0x6B, 0x50, 0x76, 0xD0, 0x69, 0xA6, 0x69, 0xAE, 0x88,
  0x7A, 0xAE, 0x22, 0x72, 0x40, 0x68, 0xF0, 0x56, 0xC0, 0x5A, 0xAE, 0xA6,
  0x44, 0xAD, 0x54, 0xA0, 0x64, 0x4A, 0xA6, 0x44, 0x48, 0x69, 0x70, 0x49,
  0x45, 0x20, 0x56, 0xA8, 0x55, 0xA8, 0x70,
};

const GFXglyph RobotoCondensed_MediumItalic8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 6, 2, 0, -6 },
  { 3, 2, 2, 2, 1, -6 },
  { 4, 4, 6, 4, 0, -6 },
  { 7, 4, 8, 4, 0, -7 },
  { 11, 3, 6, 5, 1, -6 },
  { 14, 4, 6, 4, 0, -6 },
  { 17, 1, 2, 1, 1, -6 },
  { 18, 3, 8, 2, 0, -6 },
  { 21, 2, 8, 3, 0, -6 },
  { 23, 4, 4, 3, 0, -6 },
  { 25, 4, 4, 4, 0, -5 },
  { 27, 1, 2, 2, 0, -1 },
  { 28, 2, 1, 2, 0, -3 },
  { 29, 1, 1, 2, 0, -1 },
  { 30, 3, 6, 3, 0, -6 },
  { 33, 4, 6, 4, 0, -6 },
  { 36, 2, 6, 4, 1, -6 },
  { 38, 4, 6, 4, 0, -6 },
  { 41, 4, 6, 4, 0, -6 },
  { 44, 4, 6, 4, 0, -6 },
  { 47, 4, 6, 4, 0, -6 },
  { 50, 4, 6, 4, 0, -6 },
  { 53, 4, 6, 4, 0, -6 },
  { 56, 4, 6, 4, 0, -6 },
  { 59, 3, 6, 4, 1, -6 },
  { 62, 2, 4, 2, 0, -4 },
  { 63, 2, 5, 2, 0, -4 },
  { 65, 3, 3, 3, 0, -4 },
  { 67, 4, 3, 4, 0, -4 },
  { 69, 3, 3, 4, 0, -4 },
  { 71, 2, 6, 3, 1, -6 },
  { 73, 6, 8, 6, 0, -6 },
  { 79, 4, 6, 5, 0, -6 },
  { 82, 4, 6, 4, 0, -6 },
  { 85, 4, 6, 4, 0, -6 },
  { 88, 4, 6, 4, 0, -6 },
  { 91, 4, 6, 4, 0, -6 },
  { 94, 4, 6, 4, 0, -6 },
  { 97, 4, 6, 5, 0, -6 },
  { 100, 5, 6, 5, 0, -6 },
  { 104, 2, 6, 2, 0, -6 },
  { 106, 4, 6, 4, 0, -6 },
  { 109, 5, 6, 4, 0, -6 },
  { 113, 3, 6, 4, 0, -6 },
  { 116, 6, 6, 6, 0, -6 },
  { 121, 5, 6, 5, 0, -6 },
  { 125, 4, 6, 5, 0, -6 },
  { 128, 4, 6, 4, 0, -6 },
  { 131, 4, 7, 5, 0, -6 },
  { 135, 4, 6, 4, 0, -6 },
  { 138, 4, 6, 4, 0, -6 },
  { 141, 4, 6, 4, 1, -6 },
  { 144, 5, 6, 4, 0, -6 },
  { 148, 4, 6, 4, 1, -6 },
  { 151, 5, 6, 6, 1, -6 },
  { 155, 5, 6, 4, 0, -6 },
  { 159, 4, 6, 4, 1, -6 },
  { 162, 4, 6, 4, 0, -6 },
  { 165, 3, 8, 2, 0, -7 },
  { 168, 1, 6, 3, 1, -6 },
  { 169, 2, 8, 2, 0, -7 },
  { 171, 3, 3, 3, 0, -6 },
  { 173, 3, 1, 3, 0, 0 },
  { 174, 1, 1, 3, 1, -6 },
  { 175, 3, 4, 4, 0, -4 },
  { 177, 4, 6, 4, 0, -6 },
  { 180, 3, 4, 4, 0, -4 },
  { 182, 4, 6, 4, 0, -6 },
  { 185, 3, 4, 4, 0, -4 },
  { 187, 3, 6, 3, 0, -6 },
  { 190, 4, 6, 4, 0, -4 },
  { 193, 3, 6, 4, 0, -6 },
  { 196, 2, 6, 2, 0, -6 },
  { 198, 3, 8, 2, -1, -6 },
  { 201, 4, 6, 4, 0, -6 },
  { 204, 2, 6, 2, 0, -6 },
  { 206, 5, 4, 6, 0, -4 },
  { 209, 3, 4, 4, 0, -4 },
  { 211, 4, 4, 4, 0, -4 },
  { 213, 4, 6, 4, 0, -4 },
  { 216, 4, 6, 4, 0, -4 },
  { 219, 3, 4, 2, 0, -4 },
  { 221, 3, 4, 4, 0, -4 },
  { 223, 2, 5, 2, 0, -5 },
  { 225, 4, 4, 4, 0, -4 },
  { 227, 4, 4, 3, 0, -4 },
  { 229, 5, 4, 5, 0, -4 },
  { 232, 4, 4, 3, 0, -4 },
  { 234, 4, 6, 3, 0, -4 },
  { 237, 3, 4, 3, 0, -4 },
  { 239, 3, 7, 2, 0, -6 },
  { 242, 2, 7, 2, 0, -6 },
  { 244, 2, 7, 2, 0, -6 },
  { 246, 4, 1, 4, 0, -3 },
};

const GFXfont RobotoCondensed_MediumItalic8pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_MediumItalic8pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_MediumItalic8pt7bGlyphs,
  0x20, 0x7E, 9
};

#endif // _ROBOTOCONDENSED_MEDIUMITALIC8PT7B_H_
