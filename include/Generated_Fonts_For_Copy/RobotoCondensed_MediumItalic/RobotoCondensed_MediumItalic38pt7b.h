#ifndef _ROBOTOCONDENSED_MEDIUMITALIC38PT7B_H_
#define _ROBOTOCONDENSED_MEDIUMITALIC38PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-MediumItalic.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_MediumItalic38pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x87, 0x83, 0xC1, 0xE0, 0xF0, 0xF8, 0x7C, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC3, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1C, 0x0E, 0x00, 0x00,
  0x00, 0x01, 0xC1, 0xE0, 0xF8, 0x78, 0x1C, 0x00, 0x79, 0xDC, 0x77, 0x3D,
  0xCE, 0x73, 0x9C, 0xEE, 0x3B, 0x8C, 0xE3, 0x39, 0xC0, 0x00, 0x38, 0xC0,
  0x0E, 0x38, 0x01, 0xC7, 0x00, 0x38, 0xC0, 0x0E, 0x38, 0x01, 0xC7, 0x00,
  0x38, 0xE0, 0x0E, 0x38, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0x81,
  0xC7, 0x00, 0x38, 0xE0, 0x0E, 0x38, 0x01, 0xC7, 0x00, 0x38, 0xE0, 0x7F,
  0xFF, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x06, 0x38, 0x01, 0xC7, 0x00, 0x38,
  0xE0, 0x06, 0x38, 0x01, 0xC7, 0x00, 0x38, 0xE0, 0x07, 0x38, 0x01, 0xC7,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x0F,
  0x80, 0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0xFE, 0x0F, 0x0F, 0x0F, 0x87, 0xC7,
  0x83, 0xE3, 0xC0, 0xF1, 0xE0, 0x78, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF3, 0xE0, 0x79, 0xF0, 0x3C, 0xF8, 0x1E, 0x3C, 0x1F, 0x1E, 0x1F, 0x0F,
  0xFF, 0x83, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0x80, 0x00, 0x0F, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x01,
  0xC7, 0x04, 0x71, 0xC3, 0x9C, 0x71, 0xC6, 0x1C, 0x73, 0x87, 0x38, 0xE1,
  0xDC, 0x1C, 0xE7, 0x07, 0xFB, 0x80, 0xFD, 0xC0, 0x1E, 0xF0, 0x00, 0x38,
  0x00, 0x1D, 0xF0, 0x0E, 0xFE, 0x03, 0xFF, 0x81, 0xDC, 0x70, 0xE7, 0x1C,
  0x7B, 0x87, 0x1C, 0xE1, 0xCE, 0x38, 0x77, 0x0E, 0x1D, 0xC3, 0xCE, 0x00,
  0x7F, 0x80, 0x1F, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0xFF, 0x00, 0x7F,
  0xE0, 0x1F, 0xF8, 0x0F, 0x8F, 0x03, 0xC3, 0xC0, 0xF0, 0xF0, 0x3C, 0x78,
  0x0F, 0x1E, 0x03, 0xDF, 0x00, 0xFF, 0x80, 0x1F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xFE, 0x3C, 0xFF, 0x8F, 0x7D, 0xF3, 0xFE, 0x3D, 0xEF, 0x8F,
  0xFB, 0xC1, 0xFE, 0xF0, 0x7F, 0x3C, 0x0F, 0x8F, 0x83, 0xE1, 0xFF, 0xFC,
  0x7F, 0xFF, 0x0F, 0xFB, 0xE0, 0xF8, 0x78, 0x73, 0x9C, 0xEF, 0x7B, 0x9C,
  0xE7, 0x00, 0x00, 0x20, 0x0C, 0x07, 0x80, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0x78, 0x1E, 0x03, 0xC0, 0x70, 0x1E, 0x03, 0xC0, 0x70, 0x1E, 0x03, 0xC0,
  0x78, 0x0E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x70, 0x0E,
  0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x02, 0x00, 0x02, 0x00, 0x30, 0x03,
  0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3C, 0x03,
  0xC0, 0x3C, 0x07, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x06, 0x00, 0x40, 0x00, 0x01, 0xE0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x04, 0x1C, 0x2E, 0x31, 0xFF, 0xFF, 0xBF, 0xFF, 0x0F, 0xF0,
  0x0F, 0x80, 0x3F, 0x00, 0xE7, 0x03, 0xCE, 0x0F, 0x1E, 0x1C, 0x1C, 0x00,
  0x20, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFE, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x1E, 0x3C, 0x78, 0xF3, 0xC7, 0x8F, 0x3C,
  0xF9, 0xE1, 0x80, 0x7F, 0xBF, 0xDF, 0xFF, 0xF0, 0x77, 0xFF, 0xF7, 0x00,
  0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00,
  0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0x80,
  0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70,
  0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xF0, 0x07, 0xFC, 0x0F, 0xFC, 0x1F, 0xFE, 0x1E, 0x1E,
  0x3C, 0x1E, 0x3C, 0x1E, 0x7C, 0x1F, 0x78, 0x1F, 0x78, 0x1E, 0x78, 0x1E,
  0x78, 0x1E, 0xF8, 0x1E, 0xF8, 0x1E, 0xF0, 0x1E, 0xF0, 0x3E, 0xF0, 0x3C,
  0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0xF8,
  0xFF, 0xF0, 0x7F, 0xE0, 0x3F, 0xC0, 0x1F, 0x80, 0x00, 0x60, 0x3C, 0x3F,
  0x9F, 0xE7, 0xFC, 0xFF, 0xB8, 0xF4, 0x1E, 0x07, 0xC0, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x03, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x81,
  0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0xC0, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x7F, 0xC0, 0x7F, 0xF0, 0x1F, 0xFE, 0x0F, 0x87, 0x83, 0xC1, 0xF1,
  0xF0, 0x7C, 0x78, 0x1F, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00,
  0x3C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xFF, 0xFC, 0x7F, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xE0, 0x01,
  0xF8, 0x03, 0xFE, 0x03, 0xFF, 0x83, 0xFF, 0xE1, 0xF0, 0xF1, 0xF0, 0x78,
  0xF0, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x7F,
  0xC0, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x00, 0x07, 0x9E, 0x03, 0xCF, 0x03, 0xE7, 0x81, 0xE3, 0xE1, 0xF0,
  0xFF, 0xF0, 0x7F, 0xF0, 0x1F, 0xF0, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x03, 0xFC, 0x01, 0xFC,
  0x01, 0xFE, 0x01, 0xEF, 0x00, 0xE7, 0x80, 0xF7, 0xC0, 0xF3, 0xC0, 0xF1,
  0xE0, 0x78, 0xF0, 0x78, 0x78, 0x78, 0x3C, 0x3C, 0x3E, 0x3F, 0xFF, 0xDF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0xFF, 0xC1, 0xFF, 0xE0,
  0x7F, 0xF8, 0x1F, 0xFE, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38,
  0x00, 0x1E, 0x00, 0x07, 0xBC, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xFE,
  0x07, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xE1, 0xE0, 0x78, 0x78, 0x1E, 0x1E, 0x0F, 0x87, 0xC7, 0xC1, 0xFF,
  0xF0, 0x3F, 0xF8, 0x07, 0xFC, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x03, 0xF8,
  0x0F, 0xF0, 0x3F, 0xE0, 0xFC, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3C,
  0x00, 0xFB, 0xE1, 0xFF, 0xE3, 0xFF, 0xC7, 0xFF, 0xDF, 0x87, 0xBE, 0x0F,
  0x78, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xF7, 0x81, 0xEF, 0x03, 0xDE,
  0x0F, 0xBE, 0x1E, 0x3F, 0xFC, 0x7F, 0xF0, 0x7F, 0xC0, 0x3E, 0x00, 0x3F,
  0xFF, 0x9F, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0xF8,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03,
  0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00,
  0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x01,
  0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xE0, 0xF0, 0xF0, 0xF8, 0x7C, 0x78, 0x3E,
  0x3C, 0x1F, 0x1E, 0x0F, 0x0F, 0x07, 0x87, 0xC7, 0xC1, 0xFF, 0xC0, 0x7F,
  0xC0, 0x7F, 0x80, 0x7F, 0xE0, 0x7C, 0x78, 0x7C, 0x3C, 0x3C, 0x0F, 0x3E,
  0x07, 0x9F, 0x03, 0xCF, 0x83, 0xE7, 0xC1, 0xE1, 0xE1, 0xF0, 0xFF, 0xF0,
  0x7F, 0xF8, 0x1F, 0xF8, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x3F, 0xC1, 0xFF,
  0x8F, 0xFE, 0x7C, 0x7D, 0xE0, 0xFF, 0x83, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x7F, 0xE1, 0xFF, 0xFF, 0xDF, 0xFE, 0x3F,
  0xF8, 0x79, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x80, 0x7C, 0x1F,
  0xE0, 0x7F, 0x03, 0xF8, 0x0F, 0x00, 0x00, 0x0E, 0x1E, 0x1F, 0x1E, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70,
  0xF8, 0xF8, 0xF8, 0x70, 0x03, 0x81, 0xF0, 0x7C, 0x1F, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x7C, 0x1E,
  0x0F, 0x00, 0x80, 0x00, 0x02, 0x00, 0x18, 0x00, 0xF0, 0x07, 0xE0, 0x3F,
  0xC1, 0xFE, 0x0F, 0xF0, 0x3F, 0x80, 0xFC, 0x01, 0xF0, 0x03, 0xF8, 0x03,
  0xFC, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0xFC, 0x00, 0x78, 0x00, 0x70, 0x00,
  0x20, 0x3F, 0xFE, 0x7F, 0xFD, 0xFF, 0xFB, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFD, 0xFF, 0xF3, 0xFF, 0xE7, 0xFF, 0xC0,
  0x10, 0x00, 0x38, 0x00, 0xF8, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x3F, 0x00, 0x3E, 0x01, 0xF8, 0x1F, 0xF0, 0xFF, 0x87, 0xF8,
  0x1F, 0xC0, 0x3E, 0x00, 0x70, 0x00, 0x80, 0x00, 0x0F, 0xC0, 0xFF, 0x0F,
  0xFC, 0xFF, 0xFF, 0x8F, 0xFC, 0x3F, 0xC1, 0xE0, 0x0F, 0x00, 0xF8, 0x07,
  0x80, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x1E, 0x01,
  0xE0, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x0C, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x0F,
  0xFF, 0xE0, 0x07, 0xC0, 0x7C, 0x03, 0xC0, 0x07, 0x01, 0xE0, 0x00, 0xE0,
  0x70, 0x00, 0x38, 0x38, 0x00, 0x06, 0x1E, 0x07, 0x81, 0xC7, 0x07, 0xF8,
  0x73, 0xC3, 0xFF, 0x1C, 0xE1, 0xE3, 0x87, 0x38, 0x70, 0xE1, 0xDC, 0x3C,
  0x38, 0x77, 0x0E, 0x0E, 0x1D, 0xC7, 0x87, 0x07, 0xE1, 0xE1, 0xC1, 0xB8,
  0x70, 0x70, 0xEE, 0x1C, 0x1C, 0x3B, 0x87, 0x0E, 0x0E, 0xE1, 0xC3, 0x83,
  0x38, 0x71, 0xE1, 0xCE, 0x1C, 0x78, 0xE3, 0x87, 0xFF, 0xF8, 0xE1, 0xF9,
  0xFC, 0x38, 0x3C, 0x3C, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xE0, 0x60, 0x00, 0x7F, 0xF8, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7B,
  0x80, 0x07, 0xBC, 0x00, 0xFB, 0xC0, 0x0F, 0x3C, 0x01, 0xF3, 0xC0, 0x1E,
  0x3C, 0x01, 0xE3, 0xC0, 0x3C, 0x3C, 0x03, 0xC3, 0xC0, 0x78, 0x1E, 0x07,
  0x81, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE1, 0xFF, 0xFE, 0x1F, 0xFF, 0xE3,
  0xE0, 0x1E, 0x3C, 0x01, 0xF7, 0xC0, 0x1F, 0x78, 0x01, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0x7F,
  0xFE, 0x0F, 0x83, 0xE0, 0xF8, 0x1F, 0x0F, 0x01, 0xF0, 0xF0, 0x1F, 0x0F,
  0x01, 0xE0, 0xF0, 0x3E, 0x1F, 0x03, 0xE1, 0xF1, 0xFC, 0x1F, 0xFF, 0x81,
  0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xE0, 0x78, 0x3E, 0x07, 0xC3, 0xE0, 0x3C,
  0x3C, 0x03, 0xC3, 0xC0, 0x7C, 0x3C, 0x07, 0xC7, 0xC0, 0x78, 0x7C, 0x0F,
  0x87, 0xFF, 0xF8, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xE1, 0xF0, 0x7C, 0x7C,
  0x07, 0x8F, 0x80, 0xF9, 0xE0, 0x1F, 0x7C, 0x03, 0xEF, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x1E, 0x78, 0x07, 0xCF, 0x00,
  0xF1, 0xF0, 0x3E, 0x1E, 0x0F, 0xC3, 0xFF, 0xF0, 0x3F, 0xFC, 0x03, 0xFF,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0xC0,
  0x7F, 0xFC, 0x0F, 0x83, 0xE0, 0xF8, 0x1E, 0x0F, 0x01, 0xF0, 0xF0, 0x1F,
  0x0F, 0x00, 0xF0, 0xF0, 0x1F, 0x1F, 0x01, 0xF1, 0xF0, 0x1F, 0x1E, 0x01,
  0xF1, 0xE0, 0x1E, 0x1E, 0x01, 0xE3, 0xE0, 0x1E, 0x3E, 0x01, 0xE3, 0xE0,
  0x3E, 0x3C, 0x03, 0xC3, 0xC0, 0x3C, 0x3C, 0x07, 0xC7, 0xC0, 0xF8, 0x7C,
  0x1F, 0x07, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0x80, 0x7F, 0xE0, 0x00,
  0x07, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F,
  0xFF, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0xF0,
  0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0xFF,
  0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xE1, 0xF0,
  0x7C, 0x7C, 0x07, 0xCF, 0x80, 0xF9, 0xE0, 0x0F, 0x7C, 0x01, 0xEF, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0xFF, 0xBE, 0x1F,
  0xF7, 0x83, 0xFE, 0xF0, 0x7F, 0xDE, 0x00, 0xF3, 0xC0, 0x1E, 0x78, 0x03,
  0xCF, 0x80, 0xF9, 0xF0, 0x1F, 0x1F, 0x07, 0xE3, 0xFF, 0xF8, 0x3F, 0xFF,
  0x03, 0xFF, 0x80, 0x1F, 0xC0, 0x00, 0x07, 0xC0, 0x1E, 0x0F, 0x00, 0x7C,
  0x1E, 0x00, 0xF8, 0x3C, 0x01, 0xE0, 0xF8, 0x03, 0xC1, 0xF0, 0x07, 0x83,
  0xC0, 0x0F, 0x07, 0x80, 0x3E, 0x0F, 0x00, 0x7C, 0x1E, 0x00, 0xF0, 0x7C,
  0x01, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFF,
  0xFE, 0x1F, 0x00, 0x78, 0x3E, 0x00, 0xF0, 0x7C, 0x01, 0xE0, 0xF0, 0x07,
  0xC1, 0xE0, 0x0F, 0x83, 0xC0, 0x1E, 0x0F, 0x80, 0x3C, 0x1F, 0x00, 0x78,
  0x3E, 0x00, 0xF0, 0x78, 0x03, 0xE0, 0xF0, 0x07, 0xC1, 0xE0, 0x0F, 0x00,
  0x0F, 0x87, 0xC3, 0xC1, 0xE0, 0xF0, 0xF8, 0x7C, 0x3C, 0x1E, 0x0F, 0x07,
  0x87, 0xC3, 0xE1, 0xE0, 0xF0, 0x78, 0x3C, 0x3E, 0x1F, 0x0F, 0x07, 0x83,
  0xC3, 0xE1, 0xF0, 0xF8, 0x78, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80,
  0x01, 0xE3, 0xE0, 0x78, 0xF8, 0x3E, 0x3E, 0x0F, 0x07, 0x87, 0xC1, 0xFF,
  0xE0, 0x3F, 0xF8, 0x0F, 0xFC, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x7C, 0x0F,
  0x01, 0xF8, 0x1E, 0x07, 0xE0, 0x3C, 0x1F, 0x80, 0xF8, 0x3E, 0x01, 0xF0,
  0xF8, 0x03, 0xC3, 0xE0, 0x07, 0x8F, 0x80, 0x0F, 0x3F, 0x00, 0x1E, 0x7C,
  0x00, 0x7D, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xBC, 0x00, 0x7E, 0x7C, 0x00,
  0xF8, 0xF8, 0x01, 0xE0, 0xF0, 0x03, 0xC1, 0xF0, 0x0F, 0x83, 0xE0, 0x1F,
  0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x78, 0x0F, 0x80, 0xF0, 0x0F, 0x81, 0xE0,
  0x1F, 0x00, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0xFF, 0x7F,
  0xFE, 0xFF, 0xFD, 0xFF, 0xF8, 0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x3F,
  0x07, 0xE0, 0x07, 0xF0, 0x7E, 0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE,
  0x00, 0xFE, 0x0F, 0xF0, 0x1F, 0xE0, 0xFF, 0x01, 0xFE, 0x0F, 0xF0, 0x1D,
  0xE0, 0xFF, 0x03, 0xFE, 0x1E, 0xF0, 0x3F, 0xC1, 0xE7, 0x07, 0xBC, 0x1E,
  0x70, 0x7B, 0xC1, 0xE7, 0x0F, 0x3C, 0x1E, 0x70, 0xF7, 0xC3, 0xE7, 0x9E,
  0x7C, 0x3E, 0x79, 0xE7, 0x83, 0xE7, 0xBC, 0x78, 0x3C, 0x7B, 0xC7, 0x83,
  0xC3, 0xB8, 0xF8, 0x3C, 0x3F, 0x8F, 0x87, 0xC3, 0xF0, 0xF0, 0x7C, 0x3F,
  0x0F, 0x07, 0xC3, 0xE0, 0xF0, 0x78, 0x3E, 0x0F, 0x07, 0x83, 0xC1, 0xF0,
  0x78, 0x3C, 0x1F, 0x00, 0x07, 0xC0, 0x1E, 0x0F, 0x80, 0x7C, 0x1F, 0x00,
  0xF8, 0x3F, 0x01, 0xE0, 0xFE, 0x03, 0xC1, 0xFC, 0x07, 0x83, 0xF8, 0x1F,
  0x07, 0xF8, 0x3E, 0x0F, 0x70, 0x7C, 0x1E, 0xE0, 0xF0, 0x7D, 0xE1, 0xE0,
  0xFB, 0xC3, 0xC1, 0xE3, 0x8F, 0x83, 0xC7, 0x9F, 0x07, 0x8F, 0x3C, 0x1F,
  0x0E, 0x78, 0x3E, 0x1C, 0xF0, 0x7C, 0x3D, 0xE0, 0xF0, 0x3F, 0xC1, 0xE0,
  0x7F, 0x83, 0xC0, 0xFE, 0x0F, 0x81, 0xFC, 0x1F, 0x01, 0xF8, 0x3E, 0x03,
  0xF0, 0x78, 0x07, 0xE0, 0xF0, 0x07, 0xC1, 0xE0, 0x0F, 0x00, 0x00, 0xFC,
  0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xE1, 0xF0, 0x7C, 0x3C, 0x07,
  0xCF, 0x80, 0x79, 0xE0, 0x0F, 0x7C, 0x01, 0xEF, 0x00, 0x3D, 0xE0, 0x07,
  0xBC, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x1E,
  0xF0, 0x03, 0xDE, 0x00, 0x7B, 0xC0, 0x1F, 0x78, 0x03, 0xCF, 0x00, 0xF9,
  0xF0, 0x1E, 0x1F, 0x07, 0xC3, 0xFF, 0xF0, 0x3F, 0xFC, 0x03, 0xFF, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0x0F,
  0xFF, 0xE0, 0xF8, 0x1F, 0x07, 0xC0, 0x78, 0x3C, 0x03, 0xE1, 0xE0, 0x1F,
  0x0F, 0x00, 0xF8, 0x78, 0x07, 0x87, 0xC0, 0x3C, 0x3E, 0x03, 0xE1, 0xE0,
  0x3E, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xFE, 0x01,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xE1,
  0xF0, 0x7C, 0x7C, 0x07, 0xCF, 0x80, 0xF9, 0xE0, 0x0F, 0x7C, 0x01, 0xEF,
  0x00, 0x3D, 0xE0, 0x07, 0xBC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE,
  0x00, 0xF7, 0x80, 0x1E, 0xF0, 0x03, 0xDE, 0x00, 0xFB, 0xC0, 0x1F, 0x78,
  0x03, 0xCF, 0x00, 0xF9, 0xF0, 0x1E, 0x1F, 0x0F, 0xC3, 0xFF, 0xF0, 0x3F,
  0xFC, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0x80, 0x00, 0x20, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x3F,
  0xFE, 0x07, 0xFF, 0xE1, 0xF0, 0x3C, 0x3E, 0x07, 0xC7, 0xC0, 0xF8, 0xF0,
  0x1F, 0x1E, 0x03, 0xE3, 0xC0, 0x7C, 0xF8, 0x0F, 0x1F, 0x03, 0xE3, 0xC0,
  0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0x8F,
  0x81, 0xE0, 0xF0, 0x3C, 0x1F, 0x07, 0x83, 0xE1, 0xF0, 0x7C, 0x3E, 0x07,
  0x87, 0xC0, 0xF8, 0xF0, 0x1F, 0x1E, 0x03, 0xE3, 0xC0, 0x3C, 0x00, 0x00,
  0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xE1, 0xF8, 0x7C, 0x3E,
  0x07, 0x87, 0x80, 0xF8, 0xF0, 0x1F, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x03,
  0xF8, 0x00, 0x1F, 0x00, 0x01, 0xE3, 0xC0, 0x3C, 0x78, 0x07, 0x8F, 0x00,
  0xF1, 0xF0, 0x3E, 0x1F, 0x0F, 0xC3, 0xFF, 0xF0, 0x3F, 0xFC, 0x03, 0xFF,
  0x00, 0x1F, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0xF8, 0x78, 0x07, 0x87, 0xC0,
  0x3C, 0x3E, 0x01, 0xE1, 0xE0, 0x1F, 0x0F, 0x00, 0xF8, 0x78, 0x07, 0x83,
  0xC0, 0x3C, 0x3E, 0x01, 0xE1, 0xF0, 0x0F, 0x0F, 0x00, 0xF8, 0x78, 0x07,
  0xC3, 0xC0, 0x3C, 0x1E, 0x01, 0xE1, 0xF0, 0x0F, 0x0F, 0x80, 0x78, 0x78,
  0x07, 0xC3, 0xC0, 0x3E, 0x1E, 0x01, 0xE0, 0xF0, 0x0F, 0x07, 0x80, 0xF8,
  0x3C, 0x07, 0xC1, 0xF0, 0x7C, 0x0F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0xFF,
  0xC0, 0x01, 0xF8, 0x00, 0xF8, 0x01, 0xFF, 0x80, 0x3E, 0xF8, 0x03, 0xE7,
  0x80, 0x3E, 0x78, 0x07, 0xC7, 0x80, 0x7C, 0x78, 0x0F, 0x87, 0xC0, 0xF8,
  0x7C, 0x0F, 0x07, 0xC1, 0xF0, 0x3C, 0x1E, 0x03, 0xC3, 0xE0, 0x3C, 0x3C,
  0x03, 0xC3, 0xC0, 0x3C, 0x7C, 0x03, 0xC7, 0x80, 0x3C, 0xF8, 0x03, 0xCF,
  0x00, 0x1E, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x3C, 0x07, 0xBC, 0x0F, 0x01, 0xEF, 0x03, 0xC0, 0xFB, 0xC1, 0xF0,
  0x3C, 0xF0, 0x7C, 0x0F, 0x3C, 0x1F, 0x87, 0xCF, 0x0F, 0xE1, 0xE3, 0xC3,
  0xF8, 0x78, 0xF0, 0xFE, 0x3E, 0x3C, 0x7F, 0x8F, 0x0F, 0x1F, 0xE3, 0xC3,
  0xC7, 0x79, 0xF0, 0xF3, 0xDE, 0x78, 0x3C, 0xE7, 0x9E, 0x0F, 0x78, 0xE7,
  0x83, 0xDE, 0x3B, 0xC0, 0xF7, 0x0E, 0xF0, 0x3F, 0xC3, 0xBC, 0x0F, 0xF0,
  0xFE, 0x03, 0xF8, 0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0x3F, 0x83, 0xF0, 0x0F,
  0xC0, 0xFC, 0x03, 0xF0, 0x3F, 0x00, 0xF8, 0x0F, 0x80, 0x3E, 0x03, 0xE0,
  0x0F, 0x80, 0xF8, 0x00, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0xF8, 0x1F, 0x03,
  0xF0, 0x1E, 0x07, 0xC0, 0x3E, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0x78, 0xF8,
  0x00, 0xFB, 0xE0, 0x01, 0xF7, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0x3C, 0x00, 0x3E,
  0x78, 0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x07, 0xC1, 0xE0, 0x1F, 0x03,
  0xE0, 0x3E, 0x07, 0xC0, 0xF8, 0x0F, 0x83, 0xF0, 0x0F, 0x80, 0xF8, 0x03,
  0xEF, 0x00, 0xF9, 0xE0, 0x1F, 0x3E, 0x07, 0xC7, 0xC0, 0xF0, 0x78, 0x3E,
  0x0F, 0x07, 0x81, 0xE1, 0xF0, 0x3C, 0x3C, 0x03, 0xCF, 0x00, 0x7B, 0xE0,
  0x0F, 0x78, 0x01, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F,
  0xFF, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x3F,
  0xFF, 0xC0, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x07, 0x80, 0xF8, 0x0F,
  0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78,
  0x0F, 0x80, 0xF0, 0x0F, 0xE0, 0xFC, 0x0F, 0xC0, 0xFC, 0x00, 0xF0, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x03, 0xF0, 0x7F, 0x07, 0xF0,
  0x7F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xE0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x7C, 0x07, 0x80,
  0x78, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFE, 0x00, 0x01, 0xC0, 0x3C, 0x03, 0xE0, 0x7E, 0x07, 0xE0, 0xFE,
  0x0E, 0xE1, 0xEE, 0x1C, 0xF3, 0xC7, 0x38, 0x77, 0x87, 0x70, 0x70, 0xFF,
  0xFD, 0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xE0, 0xF8, 0xF1, 0xF1, 0xE1, 0xE3,
  0xC0, 0x03, 0xF0, 0x1F, 0xF0, 0x7F, 0xF1, 0xFF, 0xF3, 0xE3, 0xE7, 0x83,
  0xC0, 0x07, 0x80, 0x1F, 0x07, 0xFC, 0x3F, 0xF9, 0xFF, 0xF3, 0xE1, 0xEF,
  0x83, 0xDE, 0x0F, 0xBC, 0x1E, 0x78, 0x7C, 0xFF, 0xF9, 0xFF, 0xF1, 0xFD,
  0xE1, 0xF3, 0xC0, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0xBE,
  0x07, 0xFF, 0x83, 0xFF, 0xE1, 0xFF, 0xF0, 0xF8, 0x7C, 0x78, 0x1E, 0x7C,
  0x0F, 0x3E, 0x07, 0x9E, 0x03, 0xCF, 0x03, 0xE7, 0x81, 0xF3, 0xC0, 0xF3,
  0xE0, 0x79, 0xF0, 0x3C, 0xF8, 0x3E, 0x7C, 0x1E, 0x3F, 0xFF, 0x1F, 0xFF,
  0x1E, 0x7F, 0x0F, 0x1F, 0x00, 0x03, 0xF0, 0x1F, 0xF0, 0x7F, 0xF1, 0xFF,
  0xE3, 0xC1, 0xEF, 0x83, 0xDE, 0x07, 0xBC, 0x0F, 0xF8, 0x01, 0xF0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x07, 0xBC, 0x0F, 0x7C, 0x3C, 0x7F,
  0xF8, 0xFF, 0xE0, 0xFF, 0x80, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x0F, 0x81, 0xF3, 0xE0, 0xFE, 0xF0, 0x7F, 0xFC, 0x3F, 0xFF,
  0x0F, 0x07, 0xC7, 0xC1, 0xF1, 0xE0, 0x78, 0x78, 0x1E, 0x3E, 0x07, 0x8F,
  0x81, 0xE3, 0xC0, 0x78, 0xF0, 0x3E, 0x3C, 0x0F, 0x0F, 0x03, 0xC3, 0xC0,
  0xF0, 0xF8, 0x7C, 0x1F, 0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0x78,
  0x00, 0x03, 0xF0, 0x1F, 0xF0, 0x7F, 0xF0, 0xFF, 0xF3, 0xE1, 0xEF, 0x83,
  0xDE, 0x07, 0xBC, 0x0F, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x1C, 0x7F, 0xF8, 0xFF, 0xF0, 0xFF,
  0xC0, 0x7E, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0xFE, 0x0F, 0xF0, 0x7C, 0x07,
  0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x03, 0xFF, 0x1F, 0xF8, 0xFF, 0xC1, 0xF0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x00, 0x03, 0xE3, 0xC1, 0xFE, 0xF0, 0xFF, 0xF8, 0x7F, 0xFE,
  0x1F, 0x0F, 0x8F, 0x81, 0xE3, 0xC0, 0xF8, 0xF0, 0x3E, 0x7C, 0x0F, 0x1F,
  0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x3C, 0x78, 0x1F, 0x1E, 0x07, 0xC7, 0xC1,
  0xE1, 0xF0, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x3E, 0xF8,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC1, 0x81, 0xE0, 0x7F, 0xF8, 0x3F,
  0xFC, 0x07, 0xFE, 0x00, 0x7E, 0x00, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x1F, 0x7C, 0x1F, 0xFE, 0x1F, 0xFF, 0x1F, 0xFF, 0x1F, 0x0F, 0x1E, 0x0F,
  0x3E, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x1F, 0x3C, 0x1E,
  0x7C, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x3E, 0xF8, 0x3C,
  0xF8, 0x3C, 0xF0, 0x3C, 0x03, 0x03, 0xC1, 0xE0, 0xF0, 0x70, 0x00, 0x00,
  0x00, 0x0F, 0x07, 0x87, 0xC3, 0xE1, 0xE0, 0xF0, 0x78, 0x3C, 0x3E, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xE1, 0xF0, 0xF0, 0x78, 0x3C, 0x1E, 0x1F, 0x00,
  0x00, 0x30, 0x03, 0xC0, 0x3E, 0x00, 0xF0, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE0,
  0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0x80, 0x3C, 0x03, 0xE0, 0xFF, 0x07, 0xF0, 0x3F, 0x01, 0xF0, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC3, 0xF1, 0xF0, 0xF8,
  0x78, 0x7C, 0x1E, 0x3E, 0x07, 0x9F, 0x01, 0xEF, 0x80, 0xFF, 0xC0, 0x3F,
  0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x1F, 0xBC,
  0x07, 0xCF, 0x81, 0xE1, 0xE0, 0x78, 0x78, 0x1E, 0x1F, 0x07, 0x83, 0xC3,
  0xE0, 0xF0, 0xF0, 0x3E, 0x00, 0x07, 0xC1, 0xE0, 0x78, 0x1E, 0x07, 0x83,
  0xE0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x7C, 0x1E, 0x07, 0x81, 0xE0,
  0x78, 0x1E, 0x0F, 0x83, 0xC0, 0xF0, 0x3C, 0x0F, 0x07, 0xC1, 0xF0, 0x78,
  0x1E, 0x07, 0x81, 0xE0, 0xF8, 0x00, 0x0F, 0x7C, 0x1E, 0x07, 0xBF, 0x9F,
  0xE1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x1F, 0x0F, 0x87, 0xC7, 0x83,
  0xE1, 0xF1, 0xE0, 0xF0, 0x7C, 0xF8, 0x3C, 0x1F, 0x3C, 0x0F, 0x07, 0x8F,
  0x07, 0xC1, 0xE3, 0xC1, 0xF0, 0x78, 0xF0, 0x78, 0x1E, 0x7C, 0x1E, 0x0F,
  0x9F, 0x07, 0x83, 0xE7, 0x81, 0xE0, 0xF1, 0xE0, 0xF8, 0x3C, 0x78, 0x3E,
  0x0F, 0x1E, 0x0F, 0x03, 0xCF, 0x83, 0xC1, 0xF3, 0xC0, 0xF0, 0x7C, 0x1E,
  0x7C, 0x1E, 0xFE, 0x1F, 0xFF, 0x1F, 0xFF, 0x1F, 0x0F, 0x1E, 0x0F, 0x3E,
  0x0F, 0x3E, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x1F, 0x3C, 0x1E, 0x7C,
  0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x3E, 0x78, 0x3C, 0xF8,
  0x3C, 0xF0, 0x3C, 0x03, 0xF0, 0x0F, 0xFC, 0x1F, 0xFE, 0x1F, 0xFE, 0x3E,
  0x1E, 0x7C, 0x1F, 0x78, 0x0F, 0x78, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1E, 0xF0, 0x1E, 0xF8, 0x3E, 0x78, 0x7C, 0x7F,
  0xFC, 0x3F, 0xF8, 0x3F, 0xF0, 0x0F, 0xC0, 0x07, 0x3E, 0x03, 0xDF, 0xC0,
  0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0x87, 0xC3, 0xC1, 0xF0, 0xF0, 0x3C, 0x7C,
  0x0F, 0x1E, 0x03, 0xC7, 0x81, 0xF1, 0xE0, 0x7C, 0x78, 0x1E, 0x3E, 0x07,
  0x8F, 0x81, 0xE3, 0xC0, 0xF8, 0xF8, 0x7C, 0x3F, 0xFF, 0x0F, 0xFF, 0x87,
  0xDF, 0xC1, 0xF3, 0xE0, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC7,
  0x87, 0xF7, 0x87, 0xFF, 0xC7, 0xFF, 0xE3, 0xC1, 0xF3, 0xE0, 0xF9, 0xE0,
  0x7C, 0xF0, 0x3C, 0xF8, 0x1E, 0x7C, 0x0F, 0x3C, 0x07, 0x9E, 0x07, 0xCF,
  0x03, 0xE7, 0x81, 0xE3, 0xC0, 0xF1, 0xF0, 0xF8, 0x7F, 0xFC, 0x3F, 0xFE,
  0x0F, 0xFE, 0x03, 0xEF, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01,
  0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x71,
  0xEF, 0x1F, 0xF1, 0xFF, 0x1F, 0x81, 0xF0, 0x1E, 0x03, 0xE0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x07,
  0x80, 0xF8, 0x0F, 0x00, 0x01, 0xF0, 0x07, 0xFC, 0x0F, 0xFE, 0x1F, 0xBE,
  0x1E, 0x1F, 0x1E, 0x1F, 0x1E, 0x00, 0x1F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0,
  0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7C, 0xF8, 0x3C, 0x78, 0x3C, 0x78, 0x3C,
  0x7E, 0xFC, 0x3F, 0xF8, 0x1F, 0xF0, 0x0F, 0xC0, 0x0F, 0x81, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0xFF, 0x9F, 0xF3, 0xFE, 0x1E, 0x03, 0xC0, 0x78, 0x1F,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x81, 0xE0, 0x3C, 0x07,
  0x80, 0xFE, 0x1F, 0x81, 0xF0, 0x1E, 0x00, 0x3E, 0x0F, 0x1F, 0x07, 0x8F,
  0x03, 0xC7, 0x81, 0xE3, 0xC1, 0xF1, 0xE0, 0xF9, 0xF0, 0x78, 0xF8, 0x3C,
  0x78, 0x1E, 0x3C, 0x0F, 0x1E, 0x0F, 0x8F, 0x07, 0xCF, 0x83, 0xC7, 0xC1,
  0xE3, 0xE0, 0xF1, 0xF0, 0xF8, 0x7F, 0xFC, 0x3F, 0xFC, 0x1F, 0xFE, 0x03,
  0xEF, 0x00, 0xF0, 0x3F, 0xE0, 0x7B, 0xE0, 0xF3, 0xC3, 0xC7, 0x87, 0x8F,
  0x1F, 0x1E, 0x3C, 0x3C, 0x78, 0x79, 0xE0, 0xF3, 0xC1, 0xE7, 0x03, 0xDE,
  0x03, 0xBC, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x00, 0xF0, 0x78, 0x3F, 0xC1, 0xE0, 0xFF, 0x07, 0x87,
  0x9C, 0x3E, 0x1E, 0x70, 0xF8, 0x79, 0xC7, 0xE3, 0xC7, 0x1F, 0x8F, 0x1C,
  0x7E, 0x3C, 0x73, 0xF9, 0xE1, 0xCE, 0xF7, 0x87, 0x7B, 0xDC, 0x1D, 0xCF,
  0xF0, 0x7F, 0x1F, 0xC1, 0xF8, 0x7E, 0x07, 0xE1, 0xF8, 0x1F, 0x87, 0xC0,
  0x7C, 0x1F, 0x01, 0xF0, 0x7C, 0x07, 0x81, 0xE0, 0x1E, 0x07, 0x80, 0x0F,
  0x07, 0xC3, 0xC3, 0xE0, 0xF0, 0xF0, 0x1E, 0x7C, 0x07, 0x9E, 0x01, 0xEF,
  0x80, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xFE, 0x01, 0xF7, 0x80, 0x79, 0xE0, 0x3E,
  0x3C, 0x0F, 0x0F, 0x07, 0xC3, 0xC3, 0xE0, 0xF8, 0x1F, 0x07, 0xC7, 0xC1,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x0F, 0x0F, 0x03, 0xC7, 0xC0, 0xF1, 0xE0,
  0x3C, 0xF8, 0x0F, 0x3C, 0x03, 0xCF, 0x00, 0xF7, 0x80, 0x3D, 0xE0, 0x0F,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0x1F,
  0xFF, 0x1F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFE, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x0F,
  0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF,
  0xF8, 0xFF, 0xF8, 0x00, 0x20, 0x0F, 0x01, 0xF0, 0x3C, 0x03, 0xC0, 0x78,
  0x07, 0x80, 0x78, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x1E, 0x01, 0xE0, 0x7C, 0x0F, 0x80, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0x80,
  0x78, 0x03, 0x80, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x04, 0x00, 0x07,
  0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C,
  0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x70, 0x70, 0x70, 0x70, 0x70,
  0x70, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x02, 0x00, 0x38, 0x07, 0x80,
  0x3C, 0x01, 0xC0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x1C, 0x01, 0xF0, 0x0F, 0x00, 0xF0,
  0x1F, 0x03, 0xC0, 0x78, 0x07, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0xF8, 0x07,
  0x00, 0x40, 0x00, 0x1E, 0x00, 0x0F, 0xE0, 0xE7, 0xFC, 0x3B, 0xFF, 0x1E,
  0xF1, 0xFF, 0xB8, 0x3F, 0xCE, 0x0F, 0xE0, 0x00, 0xF0,
};

const GFXglyph RobotoCondensed_MediumItalic38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 9, 27, 9, 1, -27 },
  { 32, 10, 10, 12, 3, -29 },
  { 45, 19, 27, 20, 1, -27 },
  { 110, 17, 35, 18, 1, -31 },
  { 185, 18, 27, 23, 3, -27 },
  { 246, 18, 27, 21, 1, -27 },
  { 307, 5, 10, 6, 3, -29 },
  { 314, 11, 39, 12, 2, -30 },
  { 368, 12, 39, 12, -2, -30 },
  { 427, 15, 16, 16, 2, -27 },
  { 457, 16, 20, 18, 1, -23 },
  { 497, 7, 11, 8, -2, -4 },
  { 507, 9, 4, 11, 1, -14 },
  { 512, 5, 5, 10, 1, -5 },
  { 516, 17, 29, 13, -2, -27 },
  { 578, 16, 27, 18, 2, -27 },
  { 632, 11, 27, 18, 4, -27 },
  { 670, 18, 27, 18, 0, -27 },
  { 731, 17, 27, 18, 1, -27 },
  { 789, 17, 27, 18, 0, -27 },
  { 847, 18, 27, 18, 1, -27 },
  { 908, 15, 27, 18, 2, -27 },
  { 959, 17, 27, 18, 2, -27 },
  { 1017, 17, 27, 18, 1, -27 },
  { 1075, 14, 27, 18, 3, -27 },
  { 1123, 8, 21, 10, 1, -21 },
  { 1144, 10, 28, 9, -2, -21 },
  { 1179, 15, 18, 16, 1, -21 },
  { 1213, 15, 12, 18, 2, -18 },
  { 1236, 15, 17, 17, 1, -20 },
  { 1268, 13, 27, 16, 3, -27 },
  { 1312, 26, 34, 28, 1, -26 },
  { 1423, 20, 27, 22, -1, -27 },
  { 1491, 20, 27, 20, 0, -27 },
  { 1559, 19, 27, 21, 2, -27 },
  { 1624, 20, 27, 21, 0, -27 },
  { 1692, 20, 27, 18, 0, -27 },
  { 1760, 19, 27, 18, 0, -27 },
  { 1825, 19, 27, 22, 2, -27 },
  { 1890, 23, 27, 23, 0, -27 },
  { 1968, 9, 27, 10, 1, -27 },
  { 1999, 18, 27, 18, 0, -27 },
  { 2060, 23, 27, 20, 0, -27 },
  { 2138, 15, 27, 18, 0, -27 },
  { 2189, 28, 27, 28, 0, -27 },
  { 2284, 23, 27, 23, 0, -27 },
  { 2362, 19, 27, 22, 2, -27 },
  { 2427, 21, 27, 21, 0, -27 },
  { 2498, 19, 32, 22, 2, -27 },
  { 2574, 19, 27, 20, 1, -27 },
  { 2639, 19, 27, 20, 1, -27 },
  { 2704, 18, 27, 20, 3, -27 },
  { 2765, 21, 27, 21, 1, -27 },
  { 2836, 20, 27, 21, 3, -27 },
  { 2904, 26, 27, 28, 4, -27 },
  { 2992, 23, 27, 20, -1, -27 },
  { 3070, 19, 27, 20, 3, -27 },
  { 3135, 21, 27, 19, 0, -27 },
  { 3206, 12, 37, 10, 0, -31 },
  { 3262, 9, 29, 14, 3, -27 },
  { 3295, 12, 37, 10, -2, -31 },
  { 3351, 12, 13, 14, 1, -27 },
  { 3371, 15, 4, 15, -2, 0 },
  { 3379, 7, 6, 12, 4, -29 },
  { 3385, 15, 20, 18, 1, -20 },
  { 3423, 17, 29, 18, 0, -29 },
  { 3485, 15, 20, 17, 1, -20 },
  { 3523, 18, 29, 18, 1, -29 },
  { 3589, 15, 20, 17, 1, -20 },
  { 3627, 13, 29, 12, 1, -29 },
  { 3675, 18, 28, 18, 0, -20 },
  { 3738, 16, 29, 18, 0, -29 },
  { 3796, 9, 28, 9, 0, -28 },
  { 3828, 13, 36, 9, -4, -28 },
  { 3887, 18, 29, 17, 0, -29 },
  { 3953, 10, 29, 9, 0, -29 },
  { 3990, 26, 20, 28, 0, -20 },
  { 4055, 16, 20, 18, 0, -20 },
  { 4095, 16, 20, 18, 1, -20 },
  { 4135, 18, 28, 18, -1, -20 },
  { 4198, 17, 28, 18, 1, -20 },
  { 4258, 12, 20, 12, 0, -20 },
  { 4288, 16, 20, 17, 0, -20 },
  { 4328, 11, 25, 11, 1, -25 },
  { 4363, 17, 20, 18, 1, -20 },
  { 4406, 15, 20, 16, 2, -20 },
  { 4444, 22, 20, 24, 2, -20 },
  { 4499, 18, 20, 16, -1, -20 },
  { 4544, 18, 28, 16, -1, -20 },
  { 4607, 16, 20, 16, 0, -20 },
  { 4647, 12, 37, 11, 1, -30 },
  { 4703, 8, 32, 9, 1, -27 },
  { 4735, 12, 37, 11, -2, -30 },
  { 4791, 18, 8, 21, 2, -15 },
};

const GFXfont RobotoCondensed_MediumItalic38pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_MediumItalic38pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_MediumItalic38pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _ROBOTOCONDENSED_MEDIUMITALIC38PT7B_H_
