#ifndef _ROBOTOCONDENSED_MEDIUMITALIC47PT7B_H_
#define _ROBOTOCONDENSED_MEDIUMITALIC47PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-MediumItalic.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_MediumItalic47pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x7E,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x78, 0x0F, 0x03, 0xE0, 0x7C, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x07, 0xC1, 0xF8, 0x3F, 0x07, 0xC0, 0x78, 0x00, 0x78,
  0xF7, 0x8F, 0x78, 0xF7, 0x8F, 0x79, 0xE7, 0x1E, 0xF1, 0xEF, 0x1E, 0xF1,
  0xCE, 0x1C, 0xE1, 0xCE, 0x3C, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x1E, 0x00,
  0x0E, 0x1C, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x1C, 0x38, 0x00,
  0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x38, 0x70, 0x0F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x00, 0xF1, 0xE0, 0x00,
  0xE1, 0xC0, 0x01, 0xE1, 0xC0, 0x01, 0xE3, 0xC0, 0x01, 0xC3, 0x80, 0x03,
  0xC3, 0x80, 0x03, 0xC7, 0x80, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x0F, 0x0E, 0x00, 0x0F, 0x1E, 0x00, 0x0E,
  0x1E, 0x00, 0x1E, 0x1C, 0x00, 0x1E, 0x3C, 0x00, 0x1C, 0x3C, 0x00, 0x3C,
  0x38, 0x00, 0x3C, 0x78, 0x00, 0x38, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x07, 0xE0, 0x01,
  0xFF, 0x80, 0x3F, 0xFC, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xC3, 0xE1,
  0xF8, 0x3F, 0x1F, 0x01, 0xF1, 0xF0, 0x1F, 0x1F, 0x01, 0xF1, 0xF0, 0x1F,
  0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0xCF, 0x80, 0x7C, 0xF8, 0x07, 0xCF, 0x80, 0xFC, 0xF8,
  0x0F, 0x8F, 0x80, 0xF8, 0xFC, 0x1F, 0x87, 0xFF, 0xF0, 0x7F, 0xFF, 0x03,
  0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0x7E, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0x80, 0x03, 0xFE,
  0x00, 0x1F, 0x3C, 0x00, 0x78, 0xF0, 0x31, 0xC1, 0xC1, 0xE7, 0x07, 0x0F,
  0x3C, 0x1C, 0x3C, 0xF0, 0x71, 0xE3, 0xC3, 0xCF, 0x0F, 0x0F, 0x38, 0x3C,
  0x3D, 0xE0, 0x79, 0xEF, 0x01, 0xFF, 0x78, 0x03, 0xFD, 0xE0, 0x07, 0xCF,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xCF, 0x80, 0x0F, 0x7F, 0x00, 0x7B, 0xFE,
  0x03, 0xDF, 0x78, 0x0E, 0x78, 0xF0, 0x7B, 0xC3, 0xC3, 0xCF, 0x0F, 0x0E,
  0x3C, 0x3C, 0x78, 0xF0, 0xF3, 0xC3, 0xC3, 0xDE, 0x0F, 0x0F, 0x70, 0x3C,
  0x78, 0x40, 0xFB, 0xE0, 0x01, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3F, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x00,
  0x3F, 0xFE, 0x00, 0x7C, 0x3C, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0xF0, 0x07,
  0xC1, 0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x1F, 0x00, 0x3E, 0x7E, 0x00, 0x3F,
  0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xF0, 0x78, 0x7F, 0xF0, 0xF1, 0xFB, 0xF1, 0xE7, 0xE3, 0xE7,
  0xCF, 0x87, 0xEF, 0xBF, 0x07, 0xFE, 0x7E, 0x0F, 0xFC, 0xFC, 0x0F, 0xF1,
  0xF8, 0x1F, 0xE3, 0xF0, 0x1F, 0x87, 0xE0, 0x7F, 0x07, 0xF3, 0xFE, 0x0F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x0F, 0xFE, 0xFC, 0x07, 0xF0, 0xFC, 0x3C,
  0xF3, 0xCF, 0x7D, 0xE7, 0x9E, 0x79, 0xC7, 0x3C, 0x00, 0x04, 0x00, 0x38,
  0x00, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x01, 0xF0, 0x03,
  0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0x80,
  0x01, 0x00, 0x01, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x78, 0x01, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0,
  0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x03, 0xC0, 0x0E, 0x00,
  0x10, 0x00, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x02, 0x07, 0x00, 0x38, 0x70, 0xE7, 0xE7, 0x7E, 0x7F, 0xFF,
  0xE3, 0xFF, 0xFE, 0x07, 0xFF, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x7F,
  0x80, 0x0F, 0x3C, 0x01, 0xF3, 0xC0, 0x3E, 0x1E, 0x03, 0xC1, 0xE0, 0x18,
  0x0E, 0x00, 0x00, 0x80, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01,
  0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0xF8, 0x7C, 0x3E, 0x3E, 0x3E,
  0x1F, 0x0F, 0x03, 0x00, 0xFF, 0xFF, 0xFB, 0xFF, 0x7F, 0xEF, 0xFC, 0x7B,
  0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78,
  0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F,
  0xFC, 0x0F, 0xEF, 0xE0, 0xF8, 0x3E, 0x1F, 0x03, 0xE1, 0xF0, 0x1F, 0x3F,
  0x01, 0xF3, 0xE0, 0x1F, 0x3E, 0x01, 0xF3, 0xE0, 0x3F, 0x7E, 0x03, 0xF7,
  0xE0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E,
  0x7C, 0x07, 0xEF, 0xC0, 0x7C, 0xF8, 0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x07,
  0xCF, 0x80, 0x7C, 0xF8, 0x0F, 0x8F, 0x80, 0xF8, 0xF8, 0x1F, 0x87, 0xC1,
  0xF0, 0x7F, 0x7F, 0x07, 0xFF, 0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0x80, 0x07,
  0xE0, 0x00, 0x00, 0x18, 0x01, 0xE0, 0x3F, 0x83, 0xFE, 0x7F, 0xF9, 0xFF,
  0xE7, 0xFF, 0x1E, 0x7C, 0xE1, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x00, 0x1F, 0x80, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x03,
  0xFB, 0xF8, 0x1F, 0x83, 0xE0, 0x7C, 0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0x80,
  0xFC, 0x3E, 0x03, 0xF1, 0xF8, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0x87, 0xFF,
  0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0x00, 0x0F, 0xFE,
  0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0x7F, 0x07, 0xE0, 0xF8, 0x7E,
  0x07, 0xC3, 0xE0, 0x3F, 0x1F, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x07, 0xFF, 0x00, 0x3F,
  0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0xF8, 0x07,
  0xC7, 0xC0, 0x3E, 0x3F, 0x03, 0xF1, 0xF8, 0x3F, 0x07, 0xFF, 0xF8, 0x3F,
  0xFF, 0x80, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x00,
  0xF7, 0xC0, 0x07, 0xDF, 0x00, 0x3E, 0xFC, 0x00, 0xF3, 0xE0, 0x07, 0xCF,
  0x80, 0x3E, 0x3E, 0x00, 0xF0, 0xF8, 0x07, 0xC7, 0xE0, 0x3E, 0x1F, 0x81,
  0xF0, 0x7C, 0x07, 0xC1, 0xF0, 0x3E, 0x07, 0xC1, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xC0, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC1, 0xFF,
  0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0xF8,
  0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xF7, 0xF8, 0x1E,
  0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x07, 0xC7, 0xC0,
  0x7E, 0x3F, 0x03, 0xE0, 0xF8, 0x3F, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x00,
  0xFF, 0xF8, 0x03, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x07,
  0xF8, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xF0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x3E,
  0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0x1F, 0xFF, 0xE3, 0xFF, 0xFE, 0x7F, 0x0F,
  0xCF, 0xC0, 0xF9, 0xF0, 0x1F, 0x3E, 0x03, 0xEF, 0xC0, 0x7F, 0xF8, 0x0F,
  0xBF, 0x01, 0xF7, 0xC0, 0x3E, 0xFC, 0x07, 0xCF, 0x81, 0xF9, 0xF0, 0x3E,
  0x3E, 0x0F, 0xC7, 0xFF, 0xF0, 0x7F, 0xFC, 0x07, 0xFF, 0x80, 0x7F, 0xC0,
  0x07, 0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x07, 0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x03,
  0xF0, 0xF8, 0x3F, 0x07, 0xE1, 0xF0, 0x3F, 0x0F, 0x81, 0xF8, 0x7C, 0x0F,
  0xC3, 0xE0, 0x7C, 0x1F, 0x03, 0xE0, 0xFC, 0x3F, 0x03, 0xF7, 0xF0, 0x0F,
  0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xC3, 0xF0,
  0x7C, 0x0F, 0x87, 0xE0, 0x7C, 0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x8F, 0x80,
  0xFC, 0x7C, 0x07, 0xC3, 0xE0, 0x3E, 0x1F, 0x03, 0xF0, 0xFC, 0x1F, 0x87,
  0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x7F, 0xF8, 0x01, 0xFF, 0x80, 0x07, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFE, 0x1F, 0xFF,
  0x8F, 0xC3, 0xF3, 0xE0, 0x7D, 0xF8, 0x1F, 0x7C, 0x07, 0xDF, 0x01, 0xF7,
  0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7D, 0xF0,
  0x3F, 0x7C, 0x1F, 0xDF, 0xCF, 0xE7, 0xFF, 0xF8, 0xFF, 0xFE, 0x1F, 0xEF,
  0x83, 0xF7, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x0F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x07, 0xFC, 0x01, 0xFC,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0x83, 0xE1, 0xFC, 0x7F, 0x0F, 0x81, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0x78, 0x00,
  0x01, 0xE0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0xF8, 0x0F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0xF8, 0x0F, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x40, 0x00, 0x70, 0x00, 0x7C, 0x00, 0x7F, 0x00,
  0x7F, 0xC0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0x1F, 0xE0,
  0x07, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x38, 0x00,
  0x02, 0x00, 0x1F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xFF, 0xE3,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xFE, 0x3F, 0xFF, 0xCF, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F,
  0xFF, 0xE0, 0x08, 0x00, 0x01, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xE0, 0x01,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x1F, 0xE0, 0x0F, 0xFC, 0x0F, 0xFE, 0x07,
  0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xC0, 0x0F, 0xE0, 0x01, 0xE0, 0x00, 0x70,
  0x00, 0x08, 0x00, 0x00, 0x03, 0xF8, 0x07, 0xFE, 0x07, 0xFF, 0x87, 0xFF,
  0xE3, 0xFF, 0xFB, 0xF0, 0xFD, 0xF8, 0x3E, 0xF8, 0x1F, 0x7C, 0x0F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0,
  0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x78, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xE7, 0xF8, 0x00, 0x7E, 0x00, 0x78, 0x00,
  0xF8, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x1E, 0x03,
  0xC0, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x0F, 0x07, 0x80, 0xF8, 0x07, 0x0F,
  0x03, 0xFE, 0x07, 0x0E, 0x07, 0xFF, 0x87, 0x1E, 0x0F, 0xFF, 0x07, 0x1E,
  0x0F, 0x0F, 0x07, 0x3C, 0x1E, 0x0F, 0x07, 0x3C, 0x1E, 0x0F, 0x07, 0x38,
  0x3C, 0x0E, 0x07, 0x78, 0x3C, 0x1E, 0x07, 0x78, 0x7C, 0x1E, 0x07, 0x78,
  0x78, 0x1E, 0x0F, 0x70, 0x78, 0x1E, 0x0F, 0xF0, 0x78, 0x3C, 0x0E, 0xF0,
  0xF8, 0x3C, 0x0E, 0xF0, 0xF8, 0x3C, 0x1E, 0xF0, 0xF8, 0x3C, 0x1C, 0xF0,
  0xF0, 0x78, 0x1C, 0xF0, 0xF8, 0x78, 0x3C, 0xF0, 0xF8, 0xF8, 0x78, 0xF0,
  0x7F, 0xFC, 0xF0, 0xF0, 0x7F, 0xBF, 0xF0, 0xF0, 0x3F, 0x1F, 0xC0, 0x70,
  0x1E, 0x0F, 0x80, 0x70, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x60, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xBC,
  0x00, 0x03, 0xEF, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x3E,
  0x3E, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0xC3, 0xE0, 0x01, 0xF0, 0xF8, 0x00,
  0xFC, 0x3E, 0x00, 0x3E, 0x07, 0xC0, 0x1F, 0x81, 0xF0, 0x07, 0xC0, 0x7C,
  0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xE0, 0x07, 0xE1, 0xF8, 0x00, 0xF8, 0x7E,
  0x00, 0x3E, 0x3F, 0x00, 0x0F, 0x8F, 0xC0, 0x03, 0xE7, 0xE0, 0x00, 0xF9,
  0xF8, 0x00, 0x3E, 0xFC, 0x00, 0x0F, 0xC0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE1, 0xF8, 0x0F,
  0xC3, 0xF0, 0x0F, 0x87, 0xE0, 0x1F, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x7C,
  0x3E, 0x01, 0xF8, 0xFC, 0x03, 0xF1, 0xF8, 0x0F, 0xC3, 0xF0, 0x7F, 0x07,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0xFC,
  0x07, 0xC1, 0xF0, 0x0F, 0xC3, 0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x1F, 0x80,
  0x3E, 0x3F, 0x00, 0x7C, 0x7E, 0x01, 0xF8, 0xF8, 0x03, 0xF1, 0xF0, 0x0F,
  0xC3, 0xE0, 0x3F, 0x8F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0,
  0x7F, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x0F, 0xE0, 0x7E,
  0x0F, 0xC0, 0x3E, 0x1F, 0x80, 0x3E, 0x1F, 0x00, 0x3F, 0x3F, 0x00, 0x3F,
  0x3E, 0x00, 0x3F, 0x3E, 0x00, 0x3F, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0xF8, 0xFC, 0x00, 0xF8, 0xFC, 0x01, 0xF8, 0x7C, 0x01, 0xF8,
  0x7C, 0x03, 0xF0, 0x7E, 0x07, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0,
  0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xFC,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x3E, 0x0F, 0x80, 0x3E,
  0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3E,
  0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3E,
  0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3E, 0x00, 0x7E, 0x3E, 0x00, 0x7C,
  0x3E, 0x00, 0x7C, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xF8, 0x7E, 0x01, 0xF8,
  0x7C, 0x01, 0xF8, 0x7C, 0x03, 0xF0, 0x7C, 0x0F, 0xE0, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xE1, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xC0, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xC1, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0,
  0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF,
  0xFE, 0x0F, 0xE0, 0x7E, 0x0F, 0xC0, 0x3E, 0x1F, 0x80, 0x3F, 0x1F, 0x00,
  0x3F, 0x3F, 0x00, 0x1F, 0x3F, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x0F,
  0xFE, 0x7C, 0x0F, 0xFE, 0x7C, 0x0F, 0xFC, 0xFC, 0x0F, 0xFC, 0xFC, 0x00,
  0x7C, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00,
  0xF8, 0x7C, 0x00, 0xF8, 0x7E, 0x01, 0xF8, 0x7F, 0x03, 0xF8, 0x3F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x01, 0xFC,
  0x00, 0x07, 0xE0, 0x03, 0xE0, 0xFC, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x83,
  0xE0, 0x03, 0xF0, 0x7C, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x01,
  0xF0, 0x7E, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x01, 0xF8, 0x3E,
  0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xC1, 0xF8, 0x00, 0xF8, 0x3F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xE0, 0xFC, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x03, 0xF0,
  0x7C, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x01, 0xF0, 0x7E, 0x00,
  0x3E, 0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x01, 0xF8, 0x3E, 0x00, 0x3F, 0x0F,
  0xC0, 0x07, 0xC1, 0xF8, 0x00, 0xF8, 0x3F, 0x00, 0x1F, 0x07, 0xC0, 0x03,
  0xE0, 0xF8, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0xFC, 0x1F, 0x83, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x7E, 0x0F, 0xC1, 0xF0, 0x3E, 0x07, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0xFC, 0x1F, 0x83, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x7E, 0x0F, 0xC1, 0xF0, 0x3E, 0x07, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x7E, 0x03, 0xF0,
  0xFC, 0x07, 0xC1, 0xF8, 0x0F, 0x81, 0xF0, 0x3F, 0x03, 0xF0, 0xFC, 0x07,
  0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xE0, 0x0F, 0xE0, 0xFC, 0x03, 0xF8, 0x1F, 0x00, 0xFE,
  0x03, 0xE0, 0x3F, 0x80, 0x7C, 0x07, 0xE0, 0x1F, 0x81, 0xFC, 0x03, 0xF0,
  0x7F, 0x00, 0x7E, 0x1F, 0xC0, 0x0F, 0x87, 0xF0, 0x01, 0xF0, 0xFC, 0x00,
  0x3E, 0x3F, 0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xFB, 0xF8, 0x00, 0x3E, 0xFE,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xEF, 0x80, 0x03, 0xF9, 0xF8,
  0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x83, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x7E,
  0x0F, 0xC0, 0x0F, 0x80, 0xFC, 0x01, 0xF0, 0x1F, 0x80, 0x3E, 0x01, 0xF0,
  0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0x7E, 0x07, 0xC0,
  0x0F, 0xC0, 0xF8, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0x80, 0x07, 0xF0, 0x00,
  0x1F, 0xC1, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x03, 0xF8, 0x1F, 0xE0,
  0x01, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x3F, 0xE0, 0xFF,
  0x80, 0x0F, 0xF8, 0x3F, 0xE0, 0x07, 0xFE, 0x0F, 0xF8, 0x01, 0xFF, 0x03,
  0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0xF0, 0x7D, 0xF0, 0x1F, 0x7C,
  0x1F, 0x7C, 0x07, 0xDF, 0x07, 0xDF, 0x01, 0xEF, 0xC1, 0xF3, 0xC0, 0xFB,
  0xE0, 0x7C, 0xF0, 0x3C, 0xF8, 0x1F, 0x3C, 0x1F, 0x3E, 0x0F, 0xCF, 0x07,
  0x8F, 0x83, 0xE3, 0xC3, 0xE7, 0xE0, 0xF8, 0xF8, 0xF1, 0xF0, 0x3E, 0x3E,
  0x7C, 0x7C, 0x0F, 0x87, 0x9E, 0x1F, 0x07, 0xE1, 0xEF, 0x87, 0xC1, 0xF8,
  0x7B, 0xC3, 0xF0, 0x7E, 0x1F, 0xF0, 0xFC, 0x1F, 0x07, 0xFC, 0x3E, 0x07,
  0xC1, 0xFE, 0x0F, 0x81, 0xF0, 0x7F, 0x83, 0xE0, 0xFC, 0x1F, 0xC1, 0xF8,
  0x3F, 0x03, 0xF0, 0x7E, 0x0F, 0xC0, 0xF8, 0x1F, 0x83, 0xE0, 0x3E, 0x07,
  0xC0, 0xF8, 0x0F, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x03, 0xE0, 0xFC, 0x00,
  0x7C, 0x1F, 0x80, 0x0F, 0x83, 0xF8, 0x03, 0xF0, 0x7F, 0x00, 0x7E, 0x1F,
  0xE0, 0x0F, 0x83, 0xFE, 0x01, 0xF0, 0x7F, 0xC0, 0x3E, 0x0F, 0xF8, 0x07,
  0xC1, 0xFF, 0x81, 0xF8, 0x3E, 0xF0, 0x3F, 0x0F, 0xDE, 0x07, 0xC1, 0xFB,
  0xE0, 0xF8, 0x3F, 0x7C, 0x1F, 0x07, 0xC7, 0x87, 0xE0, 0xF8, 0xF0, 0xFC,
  0x1F, 0x1F, 0x1F, 0x87, 0xE1, 0xE3, 0xE0, 0xFC, 0x3C, 0x7C, 0x1F, 0x07,
  0xCF, 0x83, 0xE0, 0x7B, 0xF0, 0x7C, 0x0F, 0x7E, 0x1F, 0x81, 0xFF, 0xC3,
  0xF0, 0x3F, 0xF0, 0x7E, 0x03, 0xFE, 0x0F, 0x80, 0x7F, 0xC1, 0xF0, 0x0F,
  0xF8, 0x3E, 0x00, 0xFF, 0x0F, 0xC0, 0x1F, 0xC1, 0xF8, 0x03, 0xF8, 0x3F,
  0x00, 0x3F, 0x07, 0xC0, 0x07, 0xE0, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF,
  0xFE, 0x0F, 0xE0, 0x7E, 0x0F, 0xC0, 0x3E, 0x1F, 0x80, 0x3F, 0x1F, 0x00,
  0x1F, 0x3F, 0x00, 0x1F, 0x3F, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x3E, 0x00,
  0x1F, 0x7E, 0x00, 0x1F, 0x7E, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7C, 0x00,
  0x3F, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0xFC, 0x00, 0x3E, 0xFC, 0x00,
  0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7C, 0xFC, 0x00, 0x7C, 0xFC, 0x00,
  0xFC, 0x7C, 0x00, 0xF8, 0x7E, 0x01, 0xF8, 0x7F, 0x07, 0xF0, 0x3F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x7E, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x1F,
  0x80, 0x3E, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xC3,
  0xF0, 0x03, 0xE1, 0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x7C, 0x01, 0xF8,
  0x3E, 0x01, 0xFC, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFE,
  0x0F, 0xE0, 0x7E, 0x0F, 0xC0, 0x3E, 0x1F, 0x80, 0x3F, 0x1F, 0x00, 0x3F,
  0x3F, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x7E, 0x00, 0x1F,
  0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x3E,
  0x7C, 0x00, 0x3E, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x7E,
  0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7C, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC,
  0x7C, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x7E, 0x07, 0xF0, 0x3F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x80, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xF0,
  0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x0F, 0xC0, 0x7E,
  0x0F, 0xC0, 0x3E, 0x0F, 0xC0, 0x3E, 0x0F, 0x80, 0x3F, 0x0F, 0x80, 0x3F,
  0x0F, 0x80, 0x3E, 0x1F, 0x80, 0x3E, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0xFC,
  0x1F, 0x01, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0xC0,
  0x7E, 0x0F, 0xC0, 0x7E, 0x07, 0xC0, 0x7E, 0x07, 0xE0, 0x7C, 0x07, 0xE0,
  0x7C, 0x07, 0xE0, 0x7C, 0x03, 0xE0, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF0,
  0xFC, 0x03, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF8, 0x00, 0x1F, 0xC0,
  0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC1,
  0xFC, 0x0F, 0xC3, 0xF0, 0x1F, 0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x3F,
  0x00, 0x7C, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3E,
  0x3E, 0x00, 0x7E, 0x7C, 0x00, 0xFC, 0xFC, 0x01, 0xF1, 0xF8, 0x03, 0xE1,
  0xF0, 0x0F, 0xC3, 0xF0, 0x3F, 0x87, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x7F, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xC0, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x1F, 0x87, 0xC0,
  0x0F, 0x83, 0xE0, 0x07, 0xC3, 0xF0, 0x03, 0xE1, 0xF8, 0x03, 0xF0, 0xF8,
  0x01, 0xF8, 0x7C, 0x00, 0xFC, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x1F,
  0x80, 0x1F, 0x0F, 0xC0, 0x1F, 0x87, 0xC0, 0x0F, 0xC3, 0xE0, 0x07, 0xE1,
  0xF0, 0x03, 0xE1, 0xF8, 0x01, 0xF0, 0xFC, 0x00, 0xF8, 0x7E, 0x00, 0xFC,
  0x3E, 0x00, 0x7E, 0x1F, 0x00, 0x3F, 0x0F, 0x80, 0x1F, 0x0F, 0xC0, 0x0F,
  0x87, 0xE0, 0x07, 0xC3, 0xF0, 0x07, 0xE1, 0xF0, 0x03, 0xF0, 0xF8, 0x01,
  0xF0, 0x7E, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0xC0, 0xFC, 0x07, 0xFF,
  0xFE, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xBF, 0x00, 0x1F,
  0x9F, 0x80, 0x0F, 0xCF, 0xC0, 0x0F, 0xC3, 0xE0, 0x07, 0xE1, 0xF0, 0x03,
  0xF0, 0xF8, 0x03, 0xF0, 0x7C, 0x01, 0xF8, 0x3F, 0x01, 0xF8, 0x1F, 0x80,
  0xFC, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x7E, 0x01, 0xF0, 0x3E, 0x00, 0xF8,
  0x3F, 0x00, 0x7C, 0x1F, 0x80, 0x3E, 0x0F, 0x80, 0x1F, 0x0F, 0xC0, 0x0F,
  0x87, 0xC0, 0x07, 0xC7, 0xE0, 0x01, 0xF3, 0xE0, 0x00, 0xFB, 0xF0, 0x00,
  0x7D, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x03, 0xE0, 0x1F, 0xFC, 0x03, 0xE0, 0x1F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC,
  0x07, 0xE0, 0x3E, 0x7C, 0x0F, 0xE0, 0x3E, 0x7C, 0x0F, 0xE0, 0x7E, 0x7C,
  0x0F, 0xE0, 0x7C, 0x7C, 0x1F, 0xE0, 0x7C, 0x7C, 0x1F, 0xE0, 0xFC, 0x7C,
  0x1F, 0xE0, 0xF8, 0x7C, 0x3F, 0xE0, 0xF8, 0x7C, 0x3D, 0xE1, 0xF8, 0x7C,
  0x3D, 0xE1, 0xF0, 0x7C, 0x7D, 0xE1, 0xF0, 0x7C, 0x79, 0xE3, 0xF0, 0x7C,
  0x79, 0xE3, 0xE0, 0x7C, 0xF9, 0xE3, 0xE0, 0x7C, 0xF1, 0xE7, 0xE0, 0x7D,
  0xF1, 0xE7, 0xC0, 0x7D, 0xF1, 0xE7, 0xC0, 0x7D, 0xE1, 0xEF, 0x80, 0x7F,
  0xE1, 0xFF, 0x80, 0x7F, 0xC1, 0xFF, 0x80, 0x7F, 0xC1, 0xFF, 0x00, 0x7F,
  0xC0, 0xFF, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x7F,
  0x80, 0xFE, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x03,
  0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x7E, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0x00,
  0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x1F, 0x81, 0xF8, 0x00, 0xF8, 0x3F, 0x00,
  0x0F, 0xC7, 0xE0, 0x00, 0xFC, 0x7E, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x7C,
  0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x1F, 0xBE, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x3F, 0x3F, 0x00, 0x07,
  0xE1, 0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC1, 0xF8, 0x01, 0xFC, 0x1F,
  0x80, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0x00, 0xFC, 0x07,
  0xE0, 0x07, 0xE0, 0xFE, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x7F, 0xF8, 0x01,
  0xFD, 0xF0, 0x03, 0xF3, 0xE0, 0x0F, 0xC7, 0xE0, 0x1F, 0x8F, 0xC0, 0x7E,
  0x0F, 0x80, 0xF8, 0x1F, 0x03, 0xF0, 0x3E, 0x07, 0xC0, 0x7E, 0x1F, 0x80,
  0x7C, 0x7E, 0x00, 0xF8, 0xF8, 0x01, 0xF3, 0xF0, 0x03, 0xE7, 0xC0, 0x03,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0x01, 0xFE, 0x01, 0xFE,
  0x01, 0xFE, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7F, 0x80, 0x7F, 0x80,
  0x7F, 0x80, 0xFF, 0x80, 0xF8, 0x3E, 0x0F, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x03, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8,
  0x3E, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01,
  0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x80, 0x00,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0xFF, 0x01, 0xFE,
  0x07, 0xFC, 0x0F, 0x78, 0x3E, 0x70, 0x78, 0xF1, 0xF1, 0xE3, 0xC3, 0xCF,
  0x87, 0x9E, 0x0F, 0x7C, 0x1E, 0xF0, 0x3C, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3E, 0x1F, 0x87, 0xC1, 0xF0, 0x78, 0x3E,
  0x00, 0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xE1, 0xFC, 0xFC,
  0x3E, 0x0F, 0x8F, 0xC1, 0xF9, 0xF8, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x07, 0xFF, 0x07, 0xFF, 0xE1, 0xFF, 0xFC, 0x7F, 0xDF, 0x9F, 0x83, 0xE7,
  0xE0, 0x7C, 0xFC, 0x0F, 0x9F, 0x01, 0xF3, 0xE0, 0x7E, 0x7C, 0x0F, 0xCF,
  0xEF, 0xF1, 0xFF, 0xFE, 0x1F, 0xFF, 0xC1, 0xFE, 0xF8, 0x1F, 0x9F, 0x80,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x03, 0xF3, 0xE0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF,
  0xF8, 0x3F, 0xFF, 0xC1, 0xF8, 0x3F, 0x1F, 0x81, 0xF8, 0xFC, 0x07, 0xC7,
  0xC0, 0x3E, 0x3E, 0x01, 0xF1, 0xF0, 0x0F, 0x8F, 0x80, 0xFC, 0xFC, 0x07,
  0xE7, 0xC0, 0x3E, 0x3E, 0x01, 0xF1, 0xF0, 0x0F, 0x8F, 0x80, 0x7C, 0x7C,
  0x07, 0xE7, 0xE0, 0x3E, 0x3F, 0x83, 0xF1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8,
  0x7F, 0xFF, 0x87, 0xCF, 0xF8, 0x3E, 0x1F, 0x00, 0x00, 0xFE, 0x00, 0x7F,
  0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xE1, 0xFC, 0xFC, 0x7E, 0x0F, 0xCF, 0x80,
  0xF9, 0xF0, 0x1F, 0x7E, 0x03, 0xEF, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x07,
  0x9F, 0x81, 0xF1, 0xF0, 0x3E, 0x3E, 0x0F, 0xC7, 0xF7, 0xF0, 0x7F, 0xFC,
  0x0F, 0xFF, 0x80, 0xFF, 0xC0, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x07, 0xE3, 0xE0, 0x3F, 0xEF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFE,
  0x07, 0xFF, 0xFC, 0x1F, 0x83, 0xF8, 0x3E, 0x03, 0xF0, 0xFC, 0x07, 0xE1,
  0xF8, 0x0F, 0x83, 0xE0, 0x1F, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x7C, 0x1F,
  0x01, 0xF8, 0x7E, 0x03, 0xF0, 0xFC, 0x07, 0xC1, 0xF8, 0x0F, 0x83, 0xE0,
  0x1F, 0x07, 0xE0, 0x3E, 0x0F, 0xC0, 0xFC, 0x0F, 0x83, 0xF0, 0x1F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x3F, 0xDF, 0x00, 0x3F, 0x3E,
  0x00, 0x00, 0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xE1, 0xFF,
  0xFC, 0x3E, 0x07, 0xCF, 0xC0, 0xF9, 0xF0, 0x1F, 0x7E, 0x03, 0xEF, 0x80,
  0x7D, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x08, 0x3F, 0x03,
  0x87, 0xFF, 0xF8, 0x7F, 0xFF, 0x07, 0xFF, 0xC0, 0x7F, 0xF0, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0xFF, 0x01, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x07,
  0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x7F, 0xF8, 0x7F,
  0xF8, 0x7F, 0xF8, 0xFF, 0xF8, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x00,
  0xFC, 0x7C, 0x0F, 0xF9, 0xF0, 0x7F, 0xF7, 0xC3, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF8, 0x7E, 0x07, 0xE1, 0xF8, 0x1F, 0x87, 0xC0, 0x3E, 0x3F, 0x01, 0xF8,
  0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x3E, 0x01, 0xF1, 0xF8,
  0x07, 0xC7, 0xE0, 0x3F, 0x1F, 0x80, 0xF8, 0x7E, 0x03, 0xE1, 0xF8, 0x0F,
  0x83, 0xE0, 0x3E, 0x0F, 0xC1, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x01,
  0xFF, 0xFC, 0x03, 0xFD, 0xF0, 0x07, 0xE7, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x81, 0xC0, 0x7E, 0x07, 0xC7, 0xF0,
  0x3F, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x0F, 0xCF, 0x80, 0xFB, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F,
  0xFF, 0xF0, 0xFC, 0x3F, 0x1F, 0x81, 0xF1, 0xF0, 0x1F, 0x1F, 0x01, 0xF1,
  0xF0, 0x1F, 0x1F, 0x01, 0xF3, 0xF0, 0x3F, 0x3F, 0x03, 0xE3, 0xE0, 0x3E,
  0x3E, 0x03, 0xE3, 0xE0, 0x3E, 0x3E, 0x03, 0xE7, 0xE0, 0x7E, 0x7C, 0x07,
  0xC7, 0xC0, 0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0x7C, 0x07, 0xCF, 0xC0,
  0xFC, 0xF8, 0x0F, 0x80, 0x01, 0xC0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x03, 0xE0, 0xFC, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC1,
  0xF8, 0x3F, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0xFC, 0x1F, 0x83, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x3F, 0x00, 0x1F, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01,
  0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F,
  0xC0, 0x7F, 0x80, 0xFF, 0x80, 0xFF, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0xFC, 0x1F, 0xC3, 0xF0, 0x7E, 0x0F, 0x83, 0xF0, 0x3E,
  0x1F, 0x80, 0xF8, 0xFC, 0x03, 0xE7, 0xF0, 0x1F, 0x9F, 0x80, 0x7E, 0xFC,
  0x01, 0xF7, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0xFC, 0xF8, 0x03, 0xE3,
  0xE0, 0x0F, 0x8F, 0xC0, 0x7E, 0x1F, 0x01, 0xF0, 0x7C, 0x07, 0xC1, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0xC0, 0x7C, 0x00,
  0x01, 0xF0, 0x3F, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xE0, 0x7E,
  0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x1F, 0x81, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x3F, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xE0, 0x7E, 0x07, 0xC0,
  0x7C, 0x07, 0xC0, 0x7C, 0x00, 0x0F, 0x8F, 0x81, 0xF8, 0x0F, 0xBF, 0xC7,
  0xFC, 0x0F, 0xFF, 0xEF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFF, 0x0F, 0x83, 0xFC, 0x3F, 0x1F, 0x81, 0xF8, 0x3F, 0x1F, 0x01, 0xF0,
  0x1F, 0x1F, 0x01, 0xF0, 0x1F, 0x1F, 0x01, 0xF0, 0x3F, 0x1F, 0x03, 0xF0,
  0x3F, 0x1F, 0x03, 0xF0, 0x3E, 0x3F, 0x03, 0xE0, 0x3E, 0x3E, 0x03, 0xE0,
  0x3E, 0x3E, 0x03, 0xE0, 0x3E, 0x3E, 0x03, 0xE0, 0x7E, 0x3E, 0x07, 0xE0,
  0x7C, 0x3E, 0x07, 0xE0, 0x7C, 0x7E, 0x07, 0xC0, 0x7C, 0x7C, 0x07, 0xC0,
  0x7C, 0x7C, 0x07, 0xC0, 0x7C, 0x7C, 0x07, 0xC0, 0xFC, 0x7C, 0x0F, 0xC0,
  0xF8, 0xFC, 0x0F, 0xC0, 0xF8, 0xFC, 0x0F, 0x80, 0xF8, 0x0F, 0x8F, 0x80,
  0xFB, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF1, 0xFC, 0x3F,
  0x1F, 0x81, 0xF1, 0xF0, 0x1F, 0x1F, 0x01, 0xF1, 0xF0, 0x1F, 0x1F, 0x01,
  0xF3, 0xF0, 0x3F, 0x3F, 0x03, 0xE3, 0xE0, 0x3E, 0x3E, 0x03, 0xE3, 0xE0,
  0x3E, 0x3E, 0x03, 0xE7, 0xE0, 0x7E, 0x7E, 0x07, 0xC7, 0xC0, 0x7C, 0x7C,
  0x07, 0xC7, 0xC0, 0x7C, 0x7C, 0x07, 0xCF, 0xC0, 0xFC, 0xF8, 0x0F, 0x80,
  0x00, 0xFE, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x1F, 0xEF,
  0xE1, 0xF8, 0x3E, 0x3F, 0x03, 0xF3, 0xE0, 0x1F, 0x7E, 0x01, 0xF7, 0xC0,
  0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x01, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xEF, 0xC0, 0x3E, 0xFC, 0x03, 0xE7, 0xC0, 0x7E, 0x7C, 0x07, 0xC7,
  0xE0, 0xFC, 0x7F, 0xBF, 0x83, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0xFF, 0xC0,
  0x07, 0xF0, 0x00, 0x07, 0xC7, 0xC0, 0x1F, 0x7F, 0xC0, 0x7F, 0xFF, 0x01,
  0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0x83, 0xF0, 0xFC, 0x0F, 0xC3, 0xE0,
  0x3F, 0x0F, 0x80, 0x7C, 0x3E, 0x01, 0xF0, 0xF8, 0x0F, 0xC3, 0xE0, 0x3F,
  0x1F, 0x80, 0xFC, 0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x3E, 0x1F,
  0x00, 0xF8, 0x7C, 0x07, 0xE3, 0xF0, 0x1F, 0x0F, 0xC0, 0xFC, 0x3F, 0xEF,
  0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xBF, 0xE0, 0x7E, 0x3E, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0xF8, 0x3F, 0xE7, 0xC3, 0xFF, 0xFC,
  0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x1F, 0x81, 0xF8, 0xF8, 0x0F, 0xCF, 0xC0,
  0x7E, 0x7E, 0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x07, 0xC7,
  0xC0, 0x7E, 0x7E, 0x03, 0xF3, 0xF0, 0x1F, 0x1F, 0x80, 0xF8, 0xF8, 0x07,
  0xC7, 0xE0, 0x3E, 0x3F, 0x03, 0xF0, 0xF8, 0x1F, 0x87, 0xF7, 0xF8, 0x3F,
  0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0xFD, 0xF0, 0x0F, 0xDF, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x0F, 0x9E, 0x1F, 0x7C, 0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0xE1, 0xFE, 0x47,
  0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0x8F, 0xCF, 0xC1,
  0xF3, 0xE0, 0x7C, 0xF8, 0x1F, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00,
  0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFC, 0x00,
  0x1F, 0xBE, 0x03, 0xEF, 0x81, 0xFB, 0xE0, 0x7C, 0xFC, 0x3F, 0x1F, 0xFF,
  0x83, 0xFF, 0xC0, 0x7F, 0xE0, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0xFC, 0x0F,
  0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F,
  0x01, 0xF0, 0x1F, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E,
  0x07, 0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7F,
  0x87, 0xF8, 0x7F, 0x03, 0xF0, 0x1F, 0x00, 0x3F, 0x03, 0xF3, 0xE0, 0x3E,
  0x3E, 0x03, 0xE3, 0xE0, 0x3E, 0x3E, 0x03, 0xE7, 0xE0, 0x7E, 0x7E, 0x07,
  0xE7, 0xC0, 0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0x7C, 0x07, 0xCF, 0xC0,
  0xFC, 0xFC, 0x0F, 0x8F, 0x80, 0xF8, 0xF8, 0x0F, 0x8F, 0x80, 0xF8, 0xF8,
  0x0F, 0x8F, 0x81, 0xF8, 0xF8, 0x1F, 0x0F, 0x83, 0xF0, 0xFF, 0xFF, 0x0F,
  0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFD, 0xF0, 0x1F, 0x3E, 0x00, 0xF8, 0x0F,
  0xFE, 0x03, 0xEF, 0x81, 0xFB, 0xE0, 0x7C, 0xF8, 0x1F, 0x3E, 0x0F, 0xCF,
  0x83, 0xE3, 0xE0, 0xF8, 0x78, 0x7C, 0x1E, 0x1F, 0x07, 0xC7, 0x81, 0xF3,
  0xE0, 0x7C, 0xF8, 0x1F, 0x7C, 0x07, 0xDF, 0x01, 0xF7, 0x80, 0x3F, 0xE0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x1E, 0x03, 0xFF, 0x03,
  0xC0, 0x7F, 0xE0, 0xFC, 0x1F, 0x7C, 0x1F, 0x83, 0xEF, 0x83, 0xF0, 0xFD,
  0xF0, 0xFE, 0x1F, 0x3E, 0x1F, 0xC3, 0xE7, 0xC7, 0xF8, 0xF8, 0xF8, 0xFF,
  0x1F, 0x1F, 0x1F, 0xE3, 0xE3, 0xE7, 0xBC, 0xF8, 0x7C, 0xF7, 0x9F, 0x0F,
  0xBE, 0xF3, 0xC0, 0xF7, 0x9E, 0xF8, 0x1F, 0xF3, 0xDF, 0x03, 0xFC, 0x3B,
  0xC0, 0x7F, 0x87, 0xF8, 0x0F, 0xE0, 0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x3F,
  0x83, 0xF8, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x01, 0xF8,
  0x03, 0xE0, 0x3E, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0xFC, 0x3F,
  0x07, 0xE0, 0x7C, 0x1F, 0x81, 0xF0, 0xFC, 0x07, 0xE3, 0xE0, 0x0F, 0x9F,
  0x80, 0x3E, 0xFC, 0x00, 0xFB, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x80, 0x07, 0xDE, 0x00, 0x3F, 0x7C, 0x00, 0xF9, 0xF0,
  0x07, 0xE7, 0xC0, 0x3F, 0x0F, 0x80, 0xFC, 0x3E, 0x07, 0xE0, 0xF8, 0x1F,
  0x03, 0xF0, 0xFC, 0x07, 0xC0, 0x07, 0xC0, 0x7E, 0x0F, 0x80, 0xF8, 0x1F,
  0x03, 0xF0, 0x3E, 0x07, 0xE0, 0x7C, 0x0F, 0x80, 0xF8, 0x3F, 0x01, 0xF0,
  0x7C, 0x03, 0xE1, 0xF8, 0x07, 0xC3, 0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x9F,
  0x00, 0x1F, 0x3E, 0x00, 0x3E, 0xFC, 0x00, 0x7D, 0xF0, 0x00, 0xFF, 0xE0,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF1, 0xFF, 0xFF, 0x1F, 0xFF, 0xE0, 0x00,
  0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0x7F, 0xFF, 0x8F, 0xFF, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x00, 0x00, 0x04, 0x00, 0x38, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3E,
  0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x7C, 0x00, 0xFC, 0x00,
  0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x38, 0x00,
  0x30, 0x00, 0x03, 0xC0, 0xE0, 0x38, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1C,
  0x07, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x80, 0xE0, 0x78, 0x1E, 0x07,
  0x81, 0xE0, 0x78, 0x1C, 0x07, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x80,
  0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x70, 0x1C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x00, 0x01, 0x00, 0x03, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F,
  0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0xFE,
  0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x01, 0xF8, 0x03, 0xE0, 0x03,
  0x80, 0x04, 0x00, 0x00, 0x07, 0x80, 0x00, 0x7F, 0x80, 0xF3, 0xFF, 0x03,
  0xCF, 0xFE, 0x0F, 0x7F, 0xF8, 0x79, 0xE1, 0xFF, 0xEF, 0x83, 0xFF, 0x3C,
  0x0F, 0xFC, 0xF0, 0x1F, 0xE0, 0x00, 0x1F, 0x00,
};

const GFXglyph RobotoCondensed_MediumItalic47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 11, 33, 12, 1, -33 },
  { 47, 12, 12, 15, 4, -35 },
  { 65, 24, 33, 24, 1, -33 },
  { 164, 20, 42, 23, 2, -38 },
  { 269, 22, 33, 29, 4, -33 },
  { 360, 23, 33, 26, 1, -33 },
  { 455, 6, 12, 8, 3, -35 },
  { 464, 15, 48, 15, 2, -37 },
  { 554, 14, 48, 15, -2, -37 },
  { 638, 20, 20, 20, 2, -33 },
  { 688, 19, 24, 22, 2, -27 },
  { 745, 9, 13, 10, -3, -5 },
  { 760, 11, 5, 14, 2, -17 },
  { 767, 6, 6, 13, 1, -6 },
  { 772, 21, 36, 16, -3, -33 },
  { 867, 20, 33, 23, 2, -33 },
  { 950, 14, 33, 23, 5, -33 },
  { 1008, 22, 33, 23, 0, -33 },
  { 1099, 21, 33, 23, 1, -33 },
  { 1186, 22, 33, 23, 0, -33 },
  { 1277, 21, 33, 23, 2, -33 },
  { 1364, 19, 33, 23, 2, -33 },
  { 1443, 22, 33, 23, 2, -33 },
  { 1534, 21, 33, 23, 1, -33 },
  { 1621, 18, 33, 23, 3, -33 },
  { 1696, 10, 25, 12, 1, -25 },
  { 1728, 12, 33, 11, -2, -25 },
  { 1778, 18, 21, 20, 1, -25 },
  { 1826, 19, 15, 22, 2, -23 },
  { 1862, 19, 21, 21, 1, -25 },
  { 1912, 17, 33, 20, 3, -33 },
  { 1983, 32, 43, 35, 1, -33 },
  { 2155, 26, 33, 27, -2, -33 },
  { 2263, 23, 33, 25, 1, -33 },
  { 2358, 24, 33, 26, 2, -33 },
  { 2457, 24, 33, 26, 1, -33 },
  { 2556, 23, 33, 23, 1, -33 },
  { 2651, 23, 33, 22, 1, -33 },
  { 2746, 24, 33, 27, 2, -33 },
  { 2845, 27, 33, 28, 1, -33 },
  { 2957, 11, 33, 12, 1, -33 },
  { 3003, 23, 33, 22, 0, -33 },
  { 3098, 27, 33, 25, 1, -33 },
  { 3210, 18, 33, 22, 1, -33 },
  { 3285, 34, 33, 35, 1, -33 },
  { 3426, 27, 33, 28, 1, -33 },
  { 3538, 24, 33, 27, 2, -33 },
  { 3637, 25, 33, 26, 1, -33 },
  { 3741, 24, 39, 27, 2, -33 },
  { 3858, 24, 33, 25, 1, -33 },
  { 3957, 23, 33, 24, 1, -33 },
  { 4052, 23, 33, 24, 4, -33 },
  { 4147, 25, 33, 26, 2, -33 },
  { 4251, 25, 33, 26, 4, -33 },
  { 4355, 32, 33, 34, 4, -33 },
  { 4487, 28, 33, 25, -1, -33 },
  { 4603, 23, 33, 24, 4, -33 },
  { 4698, 26, 33, 24, -1, -33 },
  { 4806, 16, 47, 12, -1, -39 },
  { 4900, 10, 36, 17, 4, -33 },
  { 4945, 16, 47, 12, -3, -39 },
  { 5039, 15, 17, 17, 2, -33 },
  { 5071, 18, 4, 18, -3, 0 },
  { 5080, 9, 7, 15, 5, -35 },
  { 5088, 19, 25, 22, 1, -25 },
  { 5148, 21, 35, 23, 0, -35 },
  { 5240, 19, 25, 21, 1, -25 },
  { 5300, 23, 35, 23, 1, -35 },
  { 5401, 19, 25, 22, 1, -25 },
  { 5461, 16, 35, 15, 2, -35 },
  { 5531, 22, 35, 23, 0, -25 },
  { 5628, 20, 35, 22, 0, -35 },
  { 5716, 11, 35, 11, 0, -35 },
  { 5765, 16, 45, 11, -5, -35 },
  { 5855, 22, 35, 21, 0, -35 },
  { 5952, 12, 35, 11, 0, -35 },
  { 6005, 32, 25, 34, 0, -25 },
  { 6105, 20, 25, 22, 0, -25 },
  { 6168, 20, 25, 23, 1, -25 },
  { 6231, 22, 35, 23, -1, -25 },
  { 6328, 21, 35, 23, 1, -25 },
  { 6420, 15, 25, 15, 0, -25 },
  { 6467, 18, 25, 21, 1, -25 },
  { 6524, 12, 31, 14, 2, -31 },
  { 6571, 20, 25, 22, 2, -25 },
  { 6634, 18, 25, 20, 3, -25 },
  { 6691, 27, 25, 29, 3, -25 },
  { 6776, 22, 25, 20, -1, -25 },
  { 6845, 23, 35, 20, -2, -25 },
  { 6946, 20, 25, 20, 0, -25 },
  { 7009, 15, 45, 14, 1, -37 },
  { 7094, 10, 39, 11, 1, -33 },
  { 7143, 15, 45, 14, -2, -37 },
  { 7228, 22, 10, 26, 2, -19 },
};

const GFXfont RobotoCondensed_MediumItalic47pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_MediumItalic47pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_MediumItalic47pt7bGlyphs,
  0x20, 0x7E, 55
};

#endif // _ROBOTOCONDENSED_MEDIUMITALIC47PT7B_H_
