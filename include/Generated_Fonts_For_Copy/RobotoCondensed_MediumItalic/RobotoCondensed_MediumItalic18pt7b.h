#ifndef _ROBOTOCONDENSED_MEDIUMITALIC18PT7B_H_
#define _ROBOTOCONDENSED_MEDIUMITALIC18PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-MediumItalic.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_MediumItalic18pt7bBitmaps[] PROGMEM = {
  0x00, 0x39, 0x8C, 0x63, 0x18, 0x8C, 0x60, 0x00, 0xC4, 0x00, 0x6A, 0xD6,
  0xAD, 0x00, 0x09, 0x05, 0x86, 0x82, 0x47, 0xF1, 0xB0, 0x90, 0x48, 0xFE,
  0x24, 0x12, 0x1B, 0x0D, 0x00, 0x0C, 0x10, 0x71, 0xF6, 0x6C, 0xD8, 0x38,
  0x38, 0x18, 0x1E, 0x3C, 0xDF, 0x9E, 0x10, 0x20, 0x70, 0xD0, 0x92, 0x96,
  0xBC, 0xE8, 0x18, 0x3E, 0x2B, 0x59, 0xDB, 0x9B, 0x0E, 0x0E, 0x0F, 0x8C,
  0xC6, 0x63, 0x60, 0xE0, 0xE0, 0xFB, 0x6D, 0xF3, 0xB9, 0xCF, 0xE3, 0xF0,
  0x49, 0x6C, 0x08, 0xCC, 0x66, 0x31, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x08,
  0x61, 0x00, 0x10, 0x60, 0x82, 0x0C, 0x30, 0xC3, 0x0C, 0x21, 0x86, 0x18,
  0xC3, 0x18, 0x42, 0x00, 0x18, 0x32, 0x4F, 0xF3, 0x8F, 0x12, 0x24, 0x18,
  0x30, 0x60, 0xCF, 0xFF, 0xCC, 0x18, 0x30, 0x60, 0x2D, 0xAC, 0xFF, 0xEC,
  0x03, 0x02, 0x06, 0x04, 0x0C, 0x08, 0x18, 0x18, 0x10, 0x30, 0x20, 0x60,
  0x40, 0xC0, 0x1C, 0x7D, 0x9B, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8B, 0x37,
  0xE7, 0x80, 0x0B, 0xFF, 0x33, 0x18, 0xC6, 0x31, 0x18, 0xC6, 0x00, 0x1E,
  0x3F, 0x33, 0x63, 0x03, 0x03, 0x06, 0x0C, 0x18, 0x30, 0x70, 0xFE, 0xFE,
  0x1E, 0x3F, 0x33, 0x03, 0x03, 0x1E, 0x1E, 0x06, 0x02, 0xC6, 0x66, 0x7E,
  0x38, 0x03, 0x07, 0x0F, 0x0F, 0x1B, 0x36, 0x36, 0x66, 0xFF, 0xFF, 0x0C,
  0x0C, 0x0C, 0x3F, 0x3F, 0x60, 0x60, 0x7C, 0x7C, 0x06, 0x06, 0x06, 0xC6,
  0xCC, 0xFC, 0x78, 0x0E, 0x78, 0xC3, 0x07, 0xDF, 0xB1, 0xE3, 0xC7, 0x8F,
  0x37, 0xE7, 0x80, 0x7F, 0x7F, 0x06, 0x06, 0x0C, 0x0C, 0x18, 0x18, 0x30,
  0x30, 0x60, 0x60, 0xC0, 0x1C, 0x7D, 0x9B, 0x36, 0x6F, 0x9F, 0x66, 0xC5,
  0x9B, 0x37, 0xE7, 0x80, 0x3C, 0xFD, 0x9B, 0x3C, 0x78, 0xF1, 0xBF, 0x74,
  0x18, 0x63, 0xC6, 0x00, 0x33, 0x00, 0x00, 0x0E, 0x60, 0x18, 0xC0, 0x00,
  0x00, 0x06, 0x23, 0x19, 0x80, 0x02, 0x1C, 0xF3, 0x86, 0x07, 0x07, 0x02,
  0x7E, 0xFC, 0x00, 0x0F, 0xDF, 0x80, 0x20, 0x30, 0x3C, 0x0E, 0x06, 0x1E,
  0x78, 0x60, 0x80, 0x3C, 0xFB, 0x98, 0x30, 0xC3, 0x8E, 0x18, 0x20, 0x00,
  0x03, 0x06, 0x00, 0x03, 0xC0, 0x73, 0x06, 0x04, 0x20, 0x22, 0x39, 0x93,
  0x6D, 0xB2, 0x69, 0x93, 0x48, 0x92, 0x4C, 0xB2, 0x65, 0x9F, 0x44, 0xEC,
  0x20, 0x01, 0x80, 0x06, 0x60, 0x1E, 0x00, 0x03, 0x00, 0xE0, 0x78, 0x1E,
  0x0D, 0x83, 0x61, 0x98, 0x66, 0x3F, 0x8F, 0xF3, 0x0D, 0x83, 0x60, 0xC0,
  0x3F, 0x1F, 0xCC, 0x66, 0x33, 0x19, 0xF9, 0xFC, 0xC6, 0x63, 0x31, 0x98,
  0xDF, 0xEF, 0xC0, 0x1E, 0x1F, 0x98, 0x6C, 0x3E, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x61, 0xB1, 0xCF, 0xC3, 0xC0, 0x3E, 0x1F, 0xCC, 0x66, 0x33, 0x19,
  0x8D, 0x86, 0xC3, 0x61, 0xB1, 0x98, 0xDF, 0xCF, 0xC0, 0x3F, 0x9F, 0xCC,
  0x06, 0x03, 0x01, 0xF9, 0xFC, 0xC0, 0x60, 0x30, 0x18, 0x1F, 0xCF, 0xE0,
  0x3F, 0x9F, 0xCC, 0x06, 0x03, 0x01, 0xF9, 0xF8, 0xC0, 0x60, 0x30, 0x18,
  0x1C, 0x0C, 0x00, 0x1E, 0x1F, 0x98, 0x6C, 0x3E, 0x06, 0x03, 0x3D, 0x9E,
  0xC3, 0x61, 0xB0, 0xCF, 0xE3, 0xC0, 0x30, 0x66, 0x0C, 0xC3, 0x18, 0x63,
  0x0C, 0x7F, 0x9F, 0xF3, 0x06, 0x61, 0x8C, 0x31, 0x86, 0x70, 0xCC, 0x18,
  0x39, 0x8C, 0x63, 0x19, 0xCC, 0x63, 0x18, 0xCC, 0x00, 0x01, 0x81, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x0C, 0x06, 0x63, 0x31, 0x8F, 0x87, 0x80,
  0x30, 0xC6, 0x38, 0xCE, 0x1B, 0x83, 0x60, 0x78, 0x1F, 0x03, 0xF0, 0x66,
  0x0C, 0xC1, 0x9C, 0x71, 0x8C, 0x30, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x18,
  0x30, 0x60, 0xC1, 0x87, 0xFF, 0xE0, 0x38, 0x39, 0xC1, 0xCE, 0x0E, 0x70,
  0xF3, 0xC5, 0x96, 0x79, 0xB3, 0xCD, 0xB6, 0x6D, 0xB3, 0x39, 0x99, 0xDD,
  0xCC, 0xCC, 0x66, 0x00, 0x38, 0x67, 0x0C, 0xE3, 0x1E, 0x63, 0xCC, 0x79,
  0x99, 0x33, 0x36, 0x67, 0x8C, 0x71, 0x8E, 0x71, 0xCC, 0x38, 0x1E, 0x1F,
  0x9C, 0x6C, 0x3E, 0x1E, 0x0F, 0x07, 0x83, 0xC3, 0x61, 0xB1, 0xCF, 0xC3,
  0xC0, 0x3F, 0x0F, 0xE3, 0x1C, 0xC3, 0x30, 0xCC, 0x67, 0xF9, 0xFC, 0x60,
  0x18, 0x06, 0x03, 0x80, 0xC0, 0x00, 0x1E, 0x1F, 0x98, 0x6C, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC3, 0x61, 0xB1, 0xCF, 0xC3, 0xC0, 0x30, 0x08, 0x3F,
  0x1F, 0xCC, 0x66, 0x33, 0x19, 0x8D, 0xFC, 0xFC, 0x66, 0x33, 0x19, 0xCC,
  0x6C, 0x30, 0x0F, 0x0F, 0xCC, 0x66, 0x33, 0x01, 0xC0, 0x78, 0x0E, 0x03,
  0x61, 0x98, 0xCF, 0xC3, 0xC0, 0x7F, 0xBF, 0xC7, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x38, 0x18, 0x0C, 0x06, 0x03, 0x00, 0x61, 0xB0, 0xD8, 0x6C,
  0x36, 0x36, 0x1B, 0x0D, 0x86, 0xC3, 0x61, 0xB1, 0x9F, 0xC7, 0x80, 0x61,
  0xD8, 0x66, 0x19, 0x8C, 0x63, 0x19, 0x86, 0x61, 0x98, 0x2C, 0x0F, 0x03,
  0x80, 0xE0, 0x30, 0x00, 0xC6, 0x3C, 0xE6, 0xCE, 0x6C, 0xE6, 0xDE, 0xCD,
  0xEC, 0xD6, 0xCF, 0x68, 0xF7, 0x8E, 0x78, 0xE3, 0x0E, 0x30, 0xC3, 0x00,
  0x30, 0xCC, 0x71, 0x98, 0x6C, 0x1F, 0x07, 0x80, 0xC0, 0x78, 0x3E, 0x0D,
  0x87, 0x73, 0x8C, 0xC3, 0x00, 0xC3, 0x63, 0xB1, 0x99, 0x86, 0xC3, 0xC1,
  0xE0, 0xE0, 0x70, 0x30, 0x18, 0x0C, 0x06, 0x00, 0x3F, 0xCF, 0xE0, 0x18,
  0x0C, 0x06, 0x03, 0x80, 0xC0, 0x60, 0x30, 0x0C, 0x06, 0x03, 0xFC, 0xFF,
  0x00, 0x3C, 0xE3, 0x0C, 0x30, 0xC3, 0x18, 0x61, 0x86, 0x18, 0x63, 0x0C,
  0x30, 0xE3, 0x80, 0xDB, 0x6D, 0xB3, 0x6D, 0xB6, 0xC0, 0x1C, 0x71, 0x86,
  0x18, 0x61, 0x86, 0x18, 0xC3, 0x0C, 0x30, 0xC3, 0x08, 0xE3, 0x80, 0x11,
  0xCE, 0xFC, 0xE4, 0xFF, 0xFC, 0xCD, 0x80, 0x1E, 0x3E, 0x66, 0x06, 0x3E,
  0x76, 0xE6, 0xC6, 0x7E, 0x76, 0x30, 0x30, 0x30, 0x30, 0x3E, 0x3F, 0x63,
  0x63, 0x63, 0x63, 0x63, 0xE6, 0xFE, 0xDC, 0x1C, 0x3E, 0x63, 0x63, 0x60,
  0x60, 0x40, 0x66, 0x7E, 0x38, 0x01, 0x80, 0xC0, 0x60, 0x61, 0xF1, 0xF9,
  0x8C, 0xC6, 0x63, 0x33, 0x31, 0x8C, 0xC7, 0xE1, 0xF0, 0x1E, 0x3E, 0x63,
  0x63, 0x7F, 0x7F, 0x60, 0x60, 0x7E, 0x3C, 0x1C, 0xF3, 0x18, 0xFB, 0xE6,
  0x18, 0x63, 0x0C, 0x30, 0xC3, 0x00, 0x1D, 0x3F, 0x63, 0x63, 0x63, 0x63,
  0x66, 0x66, 0x7E, 0x3E, 0x06, 0x0C, 0xFC, 0x78, 0x30, 0x30, 0x30, 0x30,
  0x3E, 0x7F, 0x63, 0x63, 0x63, 0x66, 0x66, 0xC6, 0xC6, 0xC6, 0x33, 0x03,
  0x36, 0x66, 0x66, 0x6C, 0xC0, 0x0C, 0x30, 0x03, 0x0C, 0x61, 0x86, 0x18,
  0x61, 0x8C, 0x30, 0xC3, 0x3C, 0xE0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x31,
  0xB1, 0xB0, 0xF8, 0x78, 0x3C, 0x1B, 0x19, 0x8C, 0xE6, 0x30, 0x31, 0x8C,
  0x63, 0x19, 0x8C, 0x63, 0x18, 0xCC, 0x60, 0x3E, 0xE7, 0xFF, 0x63, 0x36,
  0x33, 0x66, 0x36, 0x63, 0x66, 0x34, 0x63, 0xC6, 0x6C, 0x66, 0x3E, 0x7F,
  0x63, 0x63, 0x63, 0x66, 0x66, 0xC6, 0xC6, 0xC6, 0x1E, 0x3E, 0x63, 0x63,
  0x63, 0x63, 0x63, 0x66, 0x7E, 0x3C, 0x1F, 0x1F, 0xCC, 0x66, 0x33, 0x19,
  0x8C, 0xC6, 0x66, 0x7F, 0x37, 0x18, 0x0C, 0x06, 0x03, 0x00, 0x1F, 0x3F,
  0x63, 0x63, 0x63, 0x66, 0xC6, 0x66, 0x7E, 0x3E, 0x06, 0x0C, 0x0C, 0x0C,
  0x3D, 0xF7, 0x18, 0x61, 0x86, 0x30, 0xC3, 0x00, 0x1C, 0x7D, 0x9B, 0x03,
  0x83, 0x81, 0xE3, 0x7C, 0x70, 0x66, 0xFF, 0x66, 0xCC, 0xCC, 0xE6, 0x67,
  0x8F, 0x1E, 0x3C, 0x79, 0xB3, 0x66, 0xFD, 0xD8, 0xC7, 0x9B, 0x36, 0x65,
  0x8B, 0x14, 0x38, 0x70, 0xC0, 0xCC, 0xD9, 0x9B, 0x33, 0x6E, 0xCD, 0x59,
  0xEB, 0x3D, 0xC7, 0x38, 0xE6, 0x08, 0xC0, 0x31, 0x8D, 0x87, 0xC3, 0xC0,
  0xC0, 0xE0, 0x70, 0x6C, 0x76, 0x33, 0x00, 0x31, 0x99, 0x8C, 0xC6, 0x63,
  0x60, 0xB0, 0x70, 0x38, 0x18, 0x0C, 0x06, 0x06, 0x07, 0x07, 0x00, 0x7F,
  0x7E, 0x06, 0x0C, 0x18, 0x30, 0x30, 0x60, 0xFC, 0xFC, 0x04, 0x71, 0x86,
  0x30, 0xC3, 0x18, 0xE1, 0x86, 0x18, 0x61, 0x86, 0x08, 0x20, 0x13, 0x33,
  0x22, 0x26, 0x66, 0x44, 0x44, 0xC0, 0x10, 0x61, 0x86, 0x18, 0x61, 0x87,
  0x1C, 0x63, 0x0C, 0x30, 0xC6, 0x18, 0xC0, 0x71, 0xFB, 0xDF, 0x8E,
};

const GFXglyph RobotoCondensed_MediumItalic18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 5, 13, 4, 0, -13 },
  { 10, 5, 5, 6, 1, -14 },
  { 14, 9, 13, 9, 1, -13 },
  { 29, 7, 17, 9, 1, -15 },
  { 44, 8, 13, 11, 2, -13 },
  { 57, 9, 13, 10, 0, -13 },
  { 72, 3, 5, 3, 1, -14 },
  { 74, 5, 18, 6, 1, -14 },
  { 86, 6, 18, 6, -1, -14 },
  { 100, 7, 8, 8, 1, -13 },
  { 107, 7, 10, 8, 1, -11 },
  { 116, 3, 5, 4, -1, -2 },
  { 118, 4, 2, 5, 1, -7 },
  { 119, 3, 2, 5, 0, -2 },
  { 120, 8, 14, 6, -1, -13 },
  { 134, 7, 13, 9, 1, -13 },
  { 146, 5, 13, 9, 2, -13 },
  { 155, 8, 13, 9, 0, -13 },
  { 168, 8, 13, 9, 0, -13 },
  { 181, 8, 13, 9, 0, -13 },
  { 194, 8, 13, 9, 1, -13 },
  { 207, 7, 13, 9, 1, -13 },
  { 219, 8, 13, 9, 1, -13 },
  { 232, 7, 13, 9, 1, -13 },
  { 244, 7, 13, 9, 1, -13 },
  { 256, 4, 9, 5, 0, -9 },
  { 261, 5, 12, 4, -1, -9 },
  { 269, 7, 8, 8, 0, -10 },
  { 276, 7, 6, 9, 1, -9 },
  { 282, 8, 9, 8, 0, -10 },
  { 291, 7, 13, 8, 1, -13 },
  { 303, 13, 17, 13, 0, -13 },
  { 331, 10, 13, 10, -1, -13 },
  { 348, 9, 13, 10, 0, -13 },
  { 363, 9, 13, 10, 1, -13 },
  { 378, 9, 13, 10, 0, -13 },
  { 393, 9, 13, 9, 0, -13 },
  { 408, 9, 13, 8, 0, -13 },
  { 423, 9, 13, 10, 1, -13 },
  { 438, 11, 13, 11, 0, -13 },
  { 456, 5, 13, 5, 0, -13 },
  { 465, 9, 13, 9, 0, -13 },
  { 480, 11, 13, 10, 0, -13 },
  { 498, 7, 13, 8, 0, -13 },
  { 510, 13, 13, 13, 0, -13 },
  { 532, 11, 13, 11, 0, -13 },
  { 550, 9, 13, 11, 1, -13 },
  { 565, 10, 13, 10, 0, -13 },
  { 582, 9, 15, 11, 1, -13 },
  { 599, 9, 13, 9, 0, -13 },
  { 614, 9, 13, 9, 0, -13 },
  { 629, 9, 13, 9, 1, -13 },
  { 644, 9, 13, 10, 1, -13 },
  { 659, 10, 13, 10, 1, -13 },
  { 676, 12, 13, 13, 2, -13 },
  { 696, 10, 13, 10, 0, -13 },
  { 713, 9, 13, 9, 2, -13 },
  { 728, 10, 13, 9, 0, -13 },
  { 745, 6, 18, 5, 0, -15 },
  { 759, 3, 14, 7, 2, -13 },
  { 765, 6, 18, 5, -1, -15 },
  { 779, 5, 6, 7, 1, -13 },
  { 783, 7, 2, 7, -1, 0 },
  { 785, 3, 3, 6, 2, -14 },
  { 787, 8, 10, 8, 0, -10 },
  { 797, 8, 14, 9, 0, -14 },
  { 811, 8, 10, 8, 0, -10 },
  { 821, 9, 14, 9, 0, -14 },
  { 837, 8, 10, 8, 0, -10 },
  { 847, 6, 14, 6, 1, -14 },
  { 858, 8, 14, 9, 0, -10 },
  { 872, 8, 14, 9, 0, -14 },
  { 886, 4, 13, 4, 0, -13 },
  { 893, 6, 17, 4, -2, -13 },
  { 906, 9, 14, 8, 0, -14 },
  { 922, 5, 14, 4, 0, -14 },
  { 931, 12, 10, 13, 0, -10 },
  { 946, 8, 10, 9, 0, -10 },
  { 956, 8, 10, 9, 0, -10 },
  { 966, 9, 14, 9, -1, -10 },
  { 982, 8, 14, 9, 0, -10 },
  { 996, 6, 10, 6, 0, -10 },
  { 1004, 7, 10, 8, 0, -10 },
  { 1013, 4, 12, 5, 1, -12 },
  { 1019, 7, 10, 9, 1, -10 },
  { 1028, 7, 10, 8, 1, -10 },
  { 1037, 11, 10, 11, 1, -10 },
  { 1051, 9, 10, 8, -1, -10 },
  { 1063, 9, 14, 8, -1, -10 },
  { 1079, 8, 10, 8, 0, -10 },
  { 1089, 6, 17, 5, 0, -14 },
  { 1102, 4, 15, 4, 0, -13 },
  { 1110, 6, 17, 5, -1, -14 },
  { 1123, 8, 4, 10, 1, -7 },
};

const GFXfont RobotoCondensed_MediumItalic18pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_MediumItalic18pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_MediumItalic18pt7bGlyphs,
  0x20, 0x7E, 21
};

#endif // _ROBOTOCONDENSED_MEDIUMITALIC18PT7B_H_
