#ifndef _ROBOTOCONDENSED_MEDIUMITALIC57PT7B_H_
#define _ROBOTOCONDENSED_MEDIUMITALIC57PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-MediumItalic.ttf
// Size: 57pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_MediumItalic57pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xC0, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x7E, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0x80, 0x7C,
  0x00, 0x40, 0x00, 0x1E, 0x1E, 0x3E, 0x1E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E,
  0x3E, 0x3E, 0x3E, 0x3C, 0x3C, 0x3C, 0x3C, 0x7C, 0x7C, 0x7C, 0x7C, 0x78,
  0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0xF0, 0x70, 0x00, 0x03, 0xE1,
  0xE0, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x3C, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x87, 0x80, 0x00, 0xF0,
  0x78, 0x00, 0x0F, 0x0F, 0x80, 0x01, 0xF0, 0xF0, 0x00, 0x1E, 0x0F, 0x00,
  0x01, 0xE1, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x3C, 0x00, 0x07, 0x87, 0xC0,
  0x00, 0xF8, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0, 0xF8, 0x00, 0x1F,
  0x0F, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x1F, 0x00, 0x03, 0xE1, 0xF0,
  0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0x00, 0x78, 0x3C, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0xF8, 0x78,
  0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x00, 0x01,
  0xE0, 0xF0, 0x00, 0x1E, 0x1F, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x3C, 0x1E,
  0x00, 0x03, 0xC3, 0xE0, 0x00, 0x7C, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F,
  0x87, 0xF0, 0x3F, 0x83, 0xF8, 0x1F, 0x80, 0xFC, 0x1F, 0xC0, 0x7E, 0x0F,
  0xE0, 0x3F, 0x87, 0xE0, 0x1F, 0xC3, 0xF0, 0x0F, 0xE1, 0xF8, 0x07, 0xF0,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x1F, 0x80,
  0x1F, 0x8F, 0xC0, 0x0F, 0xC7, 0xE0, 0x07, 0xE3, 0xF0, 0x07, 0xF1, 0xFC,
  0x03, 0xF8, 0xFE, 0x01, 0xF8, 0x3F, 0x01, 0xFC, 0x1F, 0xE3, 0xFC, 0x0F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0xF8, 0x78, 0x04, 0x1F, 0x0F, 0x81, 0xE3, 0xC1, 0xF0,
  0x3C, 0xF8, 0x3E, 0x0F, 0x9F, 0x07, 0xC3, 0xE3, 0xE0, 0xF8, 0x78, 0x7C,
  0x1F, 0x1F, 0x0F, 0x83, 0xC7, 0xC1, 0xF0, 0xF9, 0xF0, 0x1E, 0x1F, 0x3C,
  0x03, 0xFF, 0xCF, 0x80, 0x7F, 0xFB, 0xE0, 0x07, 0xFE, 0x78, 0x00, 0x7F,
  0x1F, 0x00, 0x01, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0xFF, 0x00, 0x1F,
  0x3F, 0xF0, 0x03, 0xCF, 0xFE, 0x00, 0xFB, 0xFF, 0xE0, 0x3E, 0x7C, 0x3C,
  0x07, 0x8F, 0x07, 0x81, 0xF3, 0xE0, 0xF0, 0x7C, 0x7C, 0x1F, 0x0F, 0x0F,
  0x03, 0xC3, 0xE1, 0xE0, 0x78, 0xF8, 0x3C, 0x0F, 0x1E, 0x07, 0x81, 0xE7,
  0xC0, 0xF0, 0x7C, 0x70, 0x1F, 0x0F, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFC, 0x7F,
  0x00, 0x1F, 0x83, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x03, 0xF0, 0x03,
  0xF0, 0x3F, 0x00, 0x3F, 0x03, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x07,
  0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0xBF, 0xC0, 0x01, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x3F,
  0x1F, 0xFF, 0x83, 0xE3, 0xFD, 0xFC, 0x3E, 0x3F, 0x8F, 0xE7, 0xE7, 0xF0,
  0xFE, 0x7E, 0x7F, 0x07, 0xF7, 0xC7, 0xE0, 0x7F, 0xFC, 0xFE, 0x03, 0xFF,
  0xCF, 0xE0, 0x3F, 0xF8, 0xFE, 0x01, 0xFF, 0x8F, 0xE0, 0x1F, 0xF0, 0x7E,
  0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x83, 0xFF, 0x03, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0x9F, 0xC0,
  0x3F, 0xE1, 0xFC, 0x00, 0x60, 0x00, 0x00, 0x3E, 0x7C, 0xF9, 0xF3, 0xEF,
  0x9F, 0x3E, 0x7C, 0xF1, 0xE7, 0xCF, 0x9E, 0x00, 0x00, 0x01, 0x00, 0x01,
  0x80, 0x03, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x01,
  0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00,
  0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x20, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80,
  0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x3C, 0x1E, 0x0F, 0x7E, 0x3C,
  0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xE0, 0x7F, 0xFE,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xDF, 0x00,
  0x1F, 0xBE, 0x00, 0x7E, 0x3E, 0x01, 0xF8, 0x7C, 0x07, 0xE0, 0x7C, 0x07,
  0x80, 0xF8, 0x06, 0x00, 0xE0, 0x04, 0x01, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0xFC, 0x1F, 0x87,
  0xE0, 0xFC, 0x3F, 0x07, 0xE1, 0xF8, 0x1E, 0x01, 0x80, 0x7F, 0xFB, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x7E, 0x7F, 0xFF, 0xFF, 0x7F,
  0x7E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x83, 0xF8, 0x3F, 0x07, 0xE0, 0x7F, 0x1F, 0xC0, 0x7E, 0x3F, 0x00,
  0xFC, 0x7E, 0x01, 0xF9, 0xF8, 0x03, 0xF3, 0xF0, 0x07, 0xE7, 0xE0, 0x0F,
  0xCF, 0xC0, 0x1F, 0xBF, 0x80, 0x3F, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0xFD,
  0xF8, 0x01, 0xFB, 0xF0, 0x07, 0xF7, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xBF,
  0x80, 0x3F, 0x7F, 0x00, 0x7E, 0xFC, 0x00, 0xFD, 0xF8, 0x01, 0xFB, 0xF0,
  0x07, 0xF7, 0xE0, 0x0F, 0xCF, 0xC0, 0x1F, 0x9F, 0x80, 0x3F, 0x3F, 0x00,
  0x7E, 0x7E, 0x01, 0xF8, 0xFC, 0x03, 0xF1, 0xF8, 0x07, 0xE3, 0xF0, 0x1F,
  0x87, 0xE0, 0x7F, 0x0F, 0xE1, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0,
  0x1F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x0F, 0x00, 0x7F, 0x01, 0xFF, 0x0F, 0xFF, 0x3F, 0xFF,
  0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x7C, 0x7E, 0x60, 0xFE, 0x80, 0xFE,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xFC,
  0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF8,
  0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80,
  0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x1F, 0xC0,
  0xFE, 0x07, 0xF0, 0x0F, 0xC0, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x3F, 0x07,
  0xF0, 0x07, 0xE0, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF8, 0x1F, 0xE1, 0xFC, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0x3F,
  0x87, 0xF0, 0x0F, 0xC3, 0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF9, 0xFC, 0x01, 0xFC,
  0xFE, 0x00, 0xFC, 0x7F, 0x00, 0x7E, 0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x7F,
  0x07, 0xF8, 0x7F, 0x81, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0x80, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xEF,
  0xC0, 0x03, 0xF7, 0xE0, 0x03, 0xF3, 0xF0, 0x01, 0xF3, 0xF8, 0x01, 0xF9,
  0xFC, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x3F, 0x00, 0xFC,
  0x1F, 0x80, 0x7E, 0x1F, 0xC0, 0x7E, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x3F,
  0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x3F, 0x81, 0xFC, 0x1F, 0x80, 0xFE, 0x1F,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x3F, 0xFF, 0x80,
  0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0x9F,
  0xF0, 0x1F, 0x81, 0xFC, 0x00, 0x40, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x0F,
  0xC3, 0xF8, 0x03, 0xF0, 0xFE, 0x01, 0xFC, 0x1F, 0x80, 0x7E, 0x07, 0xF0,
  0x3F, 0x81, 0xFE, 0x1F, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x80, 0x1F, 0xFE,
  0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xE0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x03, 0xF1, 0xF8, 0x0F, 0xDF, 0xF0, 0x3F, 0xFF, 0xE1,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x9F, 0xFB, 0xFE, 0x7F, 0x83, 0xFB, 0xFC,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF,
  0xC0, 0x1F, 0xBF, 0x00, 0x7E, 0xFC, 0x03, 0xFB, 0xF8, 0x0F, 0xC7, 0xE0,
  0x7F, 0x1F, 0xC3, 0xF8, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x01, 0xFF, 0xF8,
  0x03, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x01, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0x80,
  0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xE1, 0xFC, 0x0F, 0xE0, 0xFE,
  0x07, 0xE0, 0x3F, 0x07, 0xF0, 0x1F, 0x83, 0xF8, 0x0F, 0xC1, 0xF8, 0x07,
  0xE0, 0xFC, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x3F, 0x01, 0xFC, 0x1F, 0x80,
  0xFE, 0x0F, 0xE0, 0x7E, 0x03, 0xF0, 0x7F, 0x01, 0xFE, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x3F,
  0xFF, 0xE0, 0x3F, 0xC3, 0xF0, 0x1F, 0x80, 0xFC, 0x1F, 0xC0, 0x7E, 0x0F,
  0xC0, 0x3F, 0x8F, 0xE0, 0x0F, 0xC7, 0xF0, 0x07, 0xE3, 0xF0, 0x07, 0xF1,
  0xF8, 0x03, 0xF8, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x3F, 0x80, 0xFE,
  0x1F, 0xC0, 0xFF, 0x07, 0xF0, 0xFF, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xFC, 0x01, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFC, 0x3F, 0x8F, 0xE0, 0x7E,
  0x3F, 0x01, 0xF9, 0xFC, 0x07, 0xE7, 0xE0, 0x0F, 0xDF, 0x80, 0x3F, 0x7E,
  0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x01,
  0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7E, 0xFE, 0x03, 0xF9,
  0xFC, 0x1F, 0xE7, 0xF9, 0xFF, 0x9F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xC0, 0xFF, 0xBF, 0x01, 0xF9, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0x80, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x7E, 0x07, 0xF0, 0xFF, 0x0F, 0xF0, 0x7F, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x07,
  0xE0, 0xFF, 0x0F, 0xF0, 0xFF, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80,
  0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x01, 0xC0, 0x00, 0x3E, 0x00, 0x07, 0xF0,
  0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xFF,
  0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x01, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x7E,
  0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x04, 0x00, 0x1F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFE, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01,
  0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0x00, 0x0F,
  0xFE, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0,
  0x07, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0x81, 0xFF, 0xFE, 0x1F, 0xFF,
  0xF1, 0xFE, 0x1F, 0xCF, 0xE0, 0xFE, 0x7E, 0x03, 0xF7, 0xF0, 0x1F, 0xBF,
  0x80, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x01, 0xF0,
  0x00, 0x00, 0x78, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0x00, 0x01,
  0xE0, 0x3E, 0x00, 0xFC, 0x01, 0xE0, 0x78, 0x07, 0xFE, 0x03, 0xC1, 0xF0,
  0x1F, 0xFE, 0x07, 0x83, 0xC0, 0x7F, 0xFE, 0x0F, 0x0F, 0x81, 0xFC, 0x7C,
  0x1E, 0x1E, 0x03, 0xE0, 0xF8, 0x3C, 0x7C, 0x0F, 0x81, 0xE0, 0x78, 0xF8,
  0x3E, 0x07, 0xC0, 0xF1, 0xE0, 0x7C, 0x0F, 0x81, 0xE7, 0xC0, 0xF0, 0x1F,
  0x03, 0xCF, 0x83, 0xE0, 0x3C, 0x07, 0x9E, 0x07, 0xC0, 0xF8, 0x0F, 0x7C,
  0x1F, 0x81, 0xF0, 0x1E, 0xF8, 0x3E, 0x03, 0xE0, 0x3D, 0xF0, 0x7C, 0x07,
  0x80, 0xF3, 0xC0, 0xF8, 0x0F, 0x01, 0xE7, 0x81, 0xF0, 0x3E, 0x03, 0xCF,
  0x07, 0xE0, 0x7C, 0x07, 0x9E, 0x0F, 0x80, 0xF8, 0x1E, 0x7C, 0x1F, 0x03,
  0xE0, 0x3C, 0xF8, 0x3E, 0x07, 0xC0, 0x79, 0xF0, 0x7C, 0x0F, 0x81, 0xE3,
  0xE0, 0xFC, 0x3F, 0x03, 0xC7, 0xC0, 0xF8, 0xFE, 0x0F, 0x0F, 0x81, 0xFF,
  0xFE, 0x7C, 0x0F, 0x03, 0xFF, 0x7F, 0xF8, 0x1E, 0x03, 0xFC, 0x7F, 0xE0,
  0x3C, 0x03, 0xF0, 0x7F, 0x00, 0x78, 0x01, 0x00, 0x30, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x03, 0x00, 0x00, 0x07, 0xF8, 0x3E, 0x00,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x0F, 0xDF, 0x80, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x7F, 0x7E, 0x00,
  0x00, 0xFC, 0xFC, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x07, 0xE3, 0xF0, 0x00,
  0x1F, 0xC3, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x01,
  0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x1F,
  0x80, 0xFC, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0xFC, 0x03, 0xF0, 0x03, 0xF8,
  0x07, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFC, 0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xF8, 0x7F, 0x00, 0x07,
  0xF1, 0xFC, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x1F,
  0x9F, 0xC0, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0xFE,
  0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xC0,
  0x3F, 0xC0, 0x7E, 0x00, 0xFE, 0x07, 0xF0, 0x03, 0xF0, 0x3F, 0x80, 0x1F,
  0x81, 0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0x7E, 0x00, 0x7F, 0x07,
  0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xC1, 0xFC, 0x01, 0xFC, 0x0F, 0xE0,
  0x1F, 0xE0, 0x7E, 0x03, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x03,
  0xF0, 0x07, 0xF0, 0x1F, 0x80, 0x1F, 0x81, 0xFC, 0x00, 0xFE, 0x0F, 0xE0,
  0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x83, 0xF8, 0x01, 0xFC, 0x1F, 0x80, 0x0F,
  0xE0, 0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x3F, 0x83,
  0xF8, 0x03, 0xFC, 0x1F, 0x80, 0x3F, 0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFC, 0x07, 0xFC, 0x1F, 0xE0, 0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x07,
  0xF0, 0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x3F,
  0x80, 0x03, 0xF3, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x03, 0xF7, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0x8F, 0xC0,
  0x01, 0xF8, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF8, 0xFC, 0x00, 0x3F,
  0x8F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x07, 0xF0, 0x0F, 0xE0, 0x7F,
  0x83, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xC0,
  0x7F, 0x80, 0x7E, 0x00, 0xFE, 0x07, 0xF0, 0x07, 0xF0, 0x3F, 0x80, 0x1F,
  0x81, 0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xF0, 0x7E, 0x00, 0x3F, 0x87,
  0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xE1, 0xFC, 0x00, 0x7F, 0x0F, 0xE0,
  0x03, 0xF8, 0x7E, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0xFC, 0x3F, 0x80, 0x07,
  0xE1, 0xFC, 0x00, 0x3F, 0x0F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xC3,
  0xF0, 0x00, 0xFE, 0x1F, 0x80, 0x07, 0xE1, 0xFC, 0x00, 0x3F, 0x0F, 0xE0,
  0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x0F,
  0xE0, 0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x83,
  0xF8, 0x07, 0xF8, 0x1F, 0x80, 0x7F, 0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xF8, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x07, 0xFC, 0x1F, 0xE0, 0x7F,
  0x00, 0xFF, 0x0F, 0xE0, 0x07, 0xF1, 0xFC, 0x00, 0x3F, 0x1F, 0xC0, 0x03,
  0xF1, 0xF8, 0x00, 0x3F, 0x3F, 0x80, 0x03, 0xF3, 0xF8, 0x00, 0x3F, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x3F, 0xFE, 0xFE, 0x03, 0xFF, 0xEF, 0xE0, 0x3F, 0xFE, 0xFE, 0x03,
  0xFF, 0xEF, 0xE0, 0x7F, 0xFC, 0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xFC,
  0xFC, 0x00, 0x1F, 0xCF, 0xC0, 0x01, 0xFC, 0xFC, 0x00, 0x1F, 0xCF, 0xE0,
  0x01, 0xF8, 0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x3F,
  0x87, 0xF0, 0x07, 0xF8, 0x7F, 0xC3, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x7E, 0x00,
  0x07, 0xE0, 0x3F, 0x80, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0xFE, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x03, 0xF0, 0x0F,
  0xC0, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x7F, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x7E,
  0x03, 0xF8, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x03,
  0xF8, 0x0F, 0xE0, 0x00, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7E, 0x00, 0x07, 0xF0, 0x1F,
  0x80, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0xFE, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0xFC,
  0x03, 0xF0, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x07,
  0xF0, 0x1F, 0xC0, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x7F, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x7E, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x01, 0xF8, 0x0F, 0xE0,
  0x00, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0x80, 0x7E, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x0F,
  0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0xFC,
  0x0F, 0xE0, 0x1F, 0xC0, 0x7E, 0x01, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x7F,
  0x03, 0xF8, 0x07, 0xF8, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0x80, 0xFC, 0x00, 0x7F, 0x80,
  0xFE, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x7F, 0x80,
  0x1F, 0x80, 0x7F, 0xC0, 0x0F, 0xC0, 0x3F, 0xC0, 0x07, 0xE0, 0x3F, 0xC0,
  0x07, 0xF0, 0x3F, 0xC0, 0x03, 0xF8, 0x3F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0,
  0x00, 0xFC, 0x1F, 0xE0, 0x00, 0x7E, 0x1F, 0xE0, 0x00, 0x7F, 0x1F, 0xE0,
  0x00, 0x3F, 0x9F, 0xE0, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x0F, 0xEF, 0xE0,
  0x00, 0x07, 0xEF, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xF7, 0xF0, 0x00, 0x1F, 0xF1,
  0xFC, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x03, 0xF0,
  0x1F, 0xC0, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0xFE,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x1F,
  0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xF8, 0x07,
  0xF0, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x7F, 0x80,
  0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF8, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x00, 0x1F, 0xF8,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x07, 0xFE,
  0x00, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x07,
  0xFF, 0x81, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x7F, 0xFC, 0x00, 0xFB, 0xF0, 0x3F, 0x7E,
  0x00, 0xFD, 0xF8, 0x1F, 0x9F, 0x00, 0x7D, 0xFC, 0x0F, 0xCF, 0x80, 0x7E,
  0xFC, 0x07, 0xE7, 0xC0, 0x3F, 0x7E, 0x03, 0xF3, 0xE0, 0x3F, 0x3F, 0x03,
  0xF9, 0xF0, 0x1F, 0x9F, 0x81, 0xFC, 0xF8, 0x1F, 0x9F, 0xC0, 0xFC, 0x7E,
  0x0F, 0xCF, 0xE0, 0x7E, 0x3F, 0x07, 0xC7, 0xE0, 0x3F, 0x0F, 0x87, 0xE3,
  0xF0, 0x1F, 0x87, 0xC3, 0xE1, 0xF8, 0x1F, 0xC3, 0xE3, 0xF1, 0xFC, 0x0F,
  0xE1, 0xF1, 0xF0, 0xFE, 0x07, 0xF0, 0xF9, 0xF8, 0x7F, 0x03, 0xF0, 0x7C,
  0xF8, 0x3F, 0x01, 0xF8, 0x3E, 0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0x7C, 0x1F,
  0xC0, 0xFE, 0x07, 0xFE, 0x0F, 0xE0, 0x7F, 0x03, 0xFE, 0x07, 0xF0, 0x3F,
  0x81, 0xFF, 0x03, 0xF8, 0x1F, 0x80, 0xFF, 0x81, 0xF8, 0x0F, 0xC0, 0x7F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0xC0, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x03, 0xE0, 0x1F, 0xC0, 0xFC,
  0x01, 0xF0, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0xFE, 0x00,
  0x0F, 0xC0, 0xFF, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x07, 0xF0, 0x3F, 0xE0,
  0x03, 0xF8, 0x1F, 0xF0, 0x01, 0xFC, 0x0F, 0xF8, 0x00, 0xFC, 0x07, 0xFC,
  0x00, 0x7E, 0x07, 0xFF, 0x00, 0x7F, 0x03, 0xFF, 0x80, 0x3F, 0x81, 0xFF,
  0xC0, 0x1F, 0xC0, 0xFF, 0xF0, 0x0F, 0xE0, 0x7E, 0xF8, 0x07, 0xE0, 0x7F,
  0x7C, 0x03, 0xF0, 0x3F, 0xBE, 0x03, 0xF8, 0x1F, 0xCF, 0x81, 0xFC, 0x0F,
  0xE7, 0xC0, 0xFE, 0x07, 0xE3, 0xE0, 0x7F, 0x03, 0xF1, 0xF8, 0x3F, 0x03,
  0xF8, 0x7C, 0x1F, 0x81, 0xFC, 0x3E, 0x1F, 0xC0, 0xFE, 0x1F, 0x8F, 0xE0,
  0x7F, 0x07, 0xC7, 0xF0, 0x3F, 0x03, 0xE3, 0xF0, 0x1F, 0x81, 0xF1, 0xF8,
  0x1F, 0xC0, 0xFC, 0xFC, 0x0F, 0xE0, 0x3E, 0xFE, 0x07, 0xF0, 0x1F, 0x7F,
  0x03, 0xF8, 0x0F, 0xFF, 0x81, 0xF8, 0x03, 0xFF, 0x80, 0xFC, 0x01, 0xFF,
  0xC0, 0xFE, 0x00, 0xFF, 0xE0, 0x7F, 0x00, 0x3F, 0xF0, 0x3F, 0x80, 0x1F,
  0xF8, 0x1F, 0x80, 0x0F, 0xFC, 0x0F, 0xC0, 0x07, 0xFC, 0x07, 0xE0, 0x01,
  0xFE, 0x07, 0xF0, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x7F, 0x81, 0xFC, 0x00,
  0x1F, 0xC0, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xF0, 0xFF, 0x80, 0xFE, 0x01, 0xFC,
  0x0F, 0xE0, 0x07, 0xF0, 0x7E, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0xFC, 0x3F,
  0x00, 0x07, 0xE3, 0xF8, 0x00, 0x3F, 0x9F, 0xC0, 0x01, 0xFC, 0xFC, 0x00,
  0x0F, 0xE7, 0xE0, 0x00, 0x7F, 0x7F, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x1F,
  0xDF, 0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x3F, 0x3F,
  0x00, 0x03, 0xFB, 0xF8, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0xFE, 0xFE, 0x00,
  0x07, 0xF7, 0xF0, 0x00, 0x3F, 0x3F, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x1F,
  0xCF, 0xC0, 0x00, 0xFE, 0x7E, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x3F, 0x1F,
  0x80, 0x03, 0xF8, 0xFE, 0x00, 0x1F, 0x87, 0xF0, 0x01, 0xFC, 0x1F, 0xC0,
  0x1F, 0xC0, 0xFE, 0x01, 0xFE, 0x07, 0xFC, 0x3F, 0xE0, 0x1F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0x00, 0x7F, 0x80, 0xFC, 0x00,
  0xFE, 0x07, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x1F,
  0xC1, 0xF8, 0x00, 0x7F, 0x07, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF0,
  0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7E, 0x0F, 0xE0, 0x03, 0xF8, 0x3F,
  0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xFC, 0x1F, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xE1, 0xFF, 0x00, 0xFE, 0x01, 0xFC, 0x07,
  0xF0, 0x03, 0xF8, 0x1F, 0x80, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0x7E, 0x1F, 0xC0, 0x01, 0xF8, 0x7F, 0x00, 0x07, 0xF1, 0xF8, 0x00,
  0x1F, 0xCF, 0xE0, 0x00, 0x7F, 0x3F, 0x80, 0x01, 0xFC, 0xFE, 0x00, 0x07,
  0xE3, 0xF0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x7E, 0x3F, 0x00, 0x03, 0xF9,
  0xFC, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0xFE, 0x7F,
  0x00, 0x03, 0xF1, 0xF8, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x3F, 0x1F, 0x80,
  0x01, 0xFC, 0x7E, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x1F, 0x87, 0xE0, 0x00,
  0xFE, 0x1F, 0x80, 0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x7F,
  0x03, 0xF0, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xE0, 0x3F, 0xE1, 0xFF, 0x00,
  0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0x9F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x08, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xC0, 0x1F, 0xC0, 0x7E,
  0x00, 0xFE, 0x07, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xC1, 0xFC, 0x00,
  0xFE, 0x0F, 0xC0, 0x07, 0xF0, 0x7E, 0x00, 0x3F, 0x83, 0xF0, 0x01, 0xFC,
  0x3F, 0x80, 0x0F, 0xC1, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0x7E,
  0x00, 0x7F, 0x03, 0xF0, 0x0F, 0xF8, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xF8, 0x01, 0xFC, 0x0F, 0xC0, 0x0F, 0xE0, 0x7F, 0x00, 0x7F,
  0x03, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x03,
  0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x07, 0xF0,
  0x1F, 0xC0, 0x1F, 0xC0, 0xFC, 0x00, 0xFE, 0x07, 0xE0, 0x07, 0xF0, 0x7F,
  0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xF0, 0xFC, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0,
  0x0F, 0xF8, 0x7F, 0x80, 0x7F, 0x01, 0xFE, 0x07, 0xF0, 0x07, 0xF0, 0x3F,
  0x80, 0x3F, 0x81, 0xF8, 0x00, 0xFC, 0x1F, 0xC0, 0x07, 0xE0, 0xFE, 0x00,
  0x3F, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x7E, 0x1F, 0xC0, 0x07, 0xF0, 0xFE, 0x00,
  0x3F, 0x83, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x1F, 0xC0, 0xFE, 0x01, 0xFE,
  0x03, 0xFC, 0x1F, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0xFC, 0x1F, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x7F,
  0x07, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x1F, 0x83,
  0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF8, 0x3F, 0x00, 0x0F, 0xE0, 0xFC,
  0x00, 0x3F, 0x87, 0xF0, 0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xF0, 0x7F, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0x7F, 0x07, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x07,
  0xF0, 0xFE, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x7E, 0x0F, 0xE0, 0x01, 0xF8,
  0x3F, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0xFE, 0x1F,
  0xC0, 0x03, 0xF0, 0x7F, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x3F, 0x07, 0xE0,
  0x01, 0xFC, 0x1F, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00,
  0x7E, 0x0F, 0xE0, 0x01, 0xF8, 0x3F, 0x80, 0x0F, 0xE0, 0xFE, 0x00, 0x3F,
  0x81, 0xFC, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0xFF, 0x80,
  0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0xFE,
  0x00, 0x03, 0xFB, 0xF8, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x7F, 0x3F, 0x80,
  0x01, 0xFC, 0xFE, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x3F, 0x87, 0xE0, 0x01,
  0xFE, 0x1F, 0x80, 0x07, 0xF0, 0x7E, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0xFE,
  0x07, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0xE0, 0x7F, 0x00, 0x7F, 0x01,
  0xFC, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x3F,
  0x01, 0xFC, 0x00, 0xFC, 0x07, 0xF0, 0x03, 0xF0, 0x1F, 0x80, 0x0F, 0xC0,
  0xFE, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x01, 0xF8, 0x7F,
  0x00, 0x07, 0xE1, 0xF8, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x7E, 0x3F, 0x00,
  0x01, 0xF9, 0xFC, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x1F, 0x9F, 0x80, 0x00,
  0x3E, 0xFE, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x7C,
  0x00, 0xFF, 0xFC, 0x01, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xF8, 0x03, 0xF7,
  0xF0, 0x07, 0xF0, 0x07, 0xEF, 0xE0, 0x1F, 0xE0, 0x1F, 0xDF, 0xC0, 0x3F,
  0xC0, 0x3F, 0x3F, 0x80, 0x7F, 0x80, 0x7E, 0x3F, 0x01, 0xFF, 0x01, 0xFC,
  0x7E, 0x03, 0xFE, 0x03, 0xF0, 0xFC, 0x07, 0xFC, 0x07, 0xE1, 0xF8, 0x1F,
  0xF8, 0x1F, 0xC3, 0xF0, 0x3F, 0xF0, 0x3F, 0x07, 0xE0, 0x7F, 0xE0, 0x7E,
  0x0F, 0xC1, 0xFF, 0xC1, 0xFC, 0x1F, 0x83, 0xEF, 0x83, 0xF0, 0x3F, 0x07,
  0xDF, 0x07, 0xE0, 0x7E, 0x1F, 0xBE, 0x1F, 0xC0, 0xFC, 0x3E, 0x7C, 0x3F,
  0x01, 0xF8, 0xFC, 0xF8, 0x7E, 0x03, 0xF1, 0xF1, 0xF0, 0xFC, 0x07, 0xE3,
  0xE3, 0xE3, 0xF0, 0x0F, 0xCF, 0xC7, 0xC7, 0xE0, 0x1F, 0x9F, 0x0F, 0x8F,
  0xC0, 0x3F, 0x3E, 0x1F, 0x3F, 0x00, 0x7E, 0xFC, 0x3E, 0x7E, 0x00, 0xFD,
  0xF0, 0x7C, 0xFC, 0x01, 0xFB, 0xE0, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0xFF,
  0xE0, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0x1F,
  0xFC, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x1F,
  0xF0, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x03,
  0xFE, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x7F, 0x00,
  0x1F, 0xE0, 0x1F, 0xC0, 0x07, 0xF8, 0x03, 0xF8, 0x03, 0xFC, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x07, 0xE0, 0x1F, 0xC0, 0x01,
  0xFC, 0x0F, 0xE0, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x1F, 0xC1, 0xFC, 0x00,
  0x03, 0xF8, 0xFF, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x3F, 0x9F, 0xC0,
  0x00, 0x07, 0xEF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x03, 0xF9, 0xF8, 0x00, 0x01, 0xFE, 0x7F, 0x00, 0x00, 0x7F, 0x1F, 0xC0,
  0x00, 0x3F, 0xC7, 0xF0, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x07, 0xF0, 0x3F,
  0x80, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x7F, 0x80,
  0x7F, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xF8,
  0x00, 0xFE, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x1F, 0xE7, 0xF0,
  0x01, 0xFC, 0x7F, 0x00, 0x3F, 0xC7, 0xF0, 0x03, 0xF8, 0x7F, 0x00, 0x7F,
  0x03, 0xF0, 0x07, 0xF0, 0x3F, 0x00, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x81, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x1F, 0x83, 0xF8, 0x01, 0xF8, 0x3F,
  0x00, 0x1F, 0xC7, 0xF0, 0x00, 0xFC, 0xFE, 0x00, 0x0F, 0xCF, 0xC0, 0x00,
  0xFD, 0xFC, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFC, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xF0, 0x07,
  0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x07, 0xFE, 0x00, 0xFC, 0x0F, 0xC0,
  0xFC, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF8,
  0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0xC0, 0xFC,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF,
  0x00, 0xFF, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x01, 0xFF, 0x00,
  0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x1F,
  0xF0, 0x07, 0xBC, 0x03, 0xEF, 0x01, 0xFB, 0xC0, 0x7C, 0xF8, 0x3F, 0x3E,
  0x0F, 0x8F, 0x87, 0xE3, 0xE1, 0xF0, 0xF8, 0xFC, 0x1E, 0x3E, 0x07, 0xDF,
  0x81, 0xF7, 0xC0, 0x7F, 0xF0, 0x1F, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF8, 0xFE, 0x0F, 0xE0, 0xFC,
  0x1F, 0xC1, 0xF8, 0x1F, 0x81, 0xF0, 0x3F, 0x00, 0x02, 0x00, 0x00, 0xFF,
  0xC0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF,
  0x83, 0xF8, 0x3F, 0x0F, 0xE0, 0x7F, 0x1F, 0xC0, 0xFE, 0x3F, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x0F, 0xFF, 0x80,
  0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x7F, 0xC3, 0xF1, 0xFE,
  0x07, 0xE3, 0xF8, 0x0F, 0xCF, 0xE0, 0x1F, 0x9F, 0xC0, 0x7F, 0x3F, 0x80,
  0xFE, 0x7F, 0x01, 0xF8, 0xFE, 0x07, 0xF1, 0xFC, 0x1F, 0xE3, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x07, 0xFF, 0x7E, 0x03, 0xF8, 0xFC,
  0x00, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x04, 0x00, 0x3F, 0xBF, 0xC0, 0x1F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x83,
  0xFE, 0x1F, 0xE1, 0xFE, 0x07, 0xF0, 0xFE, 0x01, 0xF8, 0x7E, 0x00, 0xFC,
  0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x1F, 0xC0, 0x1F, 0x8F, 0xE0, 0x0F,
  0xC7, 0xE0, 0x07, 0xE3, 0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xF8, 0xFC, 0x01,
  0xFC, 0xFE, 0x00, 0xFE, 0x7F, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x1F, 0x80,
  0x1F, 0x8F, 0xC0, 0x1F, 0xC7, 0xE0, 0x0F, 0xC7, 0xF8, 0x0F, 0xE3, 0xFE,
  0x0F, 0xE1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x7E, 0xFF, 0xF8, 0x3F,
  0x3F, 0xF8, 0x3F, 0x0F, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x02, 0x00,
  0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC1,
  0xFF, 0xFF, 0x83, 0xF8, 0x3F, 0x8F, 0xE0, 0x3F, 0x1F, 0x80, 0x7E, 0x7F,
  0x00, 0xFC, 0xFC, 0x01, 0xF9, 0xF8, 0x03, 0xF7, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x3F,
  0x1F, 0x80, 0x7E, 0x3F, 0x00, 0xFC, 0x7F, 0x03, 0xF8, 0xFE, 0x0F, 0xE0,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x00,
  0xFF, 0x80, 0x00, 0x10, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x0F, 0xF1, 0xF8, 0x03, 0xFF, 0x9F, 0x80, 0x7F, 0xFD,
  0xF8, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x1F, 0xE0, 0xFF, 0x01,
  0xFC, 0x07, 0xF0, 0x3F, 0x80, 0x7F, 0x03, 0xF8, 0x03, 0xF0, 0x3F, 0x00,
  0x7F, 0x03, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x7E, 0x07, 0xF0, 0x07, 0xE0,
  0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0xFE, 0x07, 0xE0,
  0x0F, 0xE0, 0x7E, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0x7E, 0x00, 0xFC,
  0x07, 0xE0, 0x0F, 0xC0, 0x7E, 0x01, 0xFC, 0x07, 0xE0, 0x1F, 0xC0, 0x7F,
  0x03, 0xF8, 0x07, 0xF8, 0x7F, 0x80, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xDF, 0x80, 0x07, 0xF9, 0xF0, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x80,
  0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x07, 0xF0, 0x7F, 0x1F,
  0xC0, 0x7E, 0x3F, 0x00, 0xFC, 0xFE, 0x01, 0xF9, 0xF8, 0x03, 0xF3, 0xF0,
  0x07, 0xE7, 0xE0, 0x0F, 0xDF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x20,
  0xFE, 0x00, 0xC0, 0xFE, 0x07, 0xC1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x83,
  0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xE0,
  0x1F, 0xFE, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x3F, 0xFF,
  0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0xFC, 0x03, 0xFF, 0x9F, 0x81,
  0xFF, 0xF7, 0xE0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x83, 0xFC, 0x1F,
  0xF0, 0x7F, 0x01, 0xFE, 0x0F, 0xC0, 0x1F, 0xC3, 0xF8, 0x03, 0xF0, 0x7E,
  0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xC3, 0xF8, 0x03, 0xF8, 0x7F, 0x00, 0x7F,
  0x0F, 0xC0, 0x0F, 0xE1, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x07, 0xE0,
  0x07, 0xE0, 0xFC, 0x01, 0xFC, 0x1F, 0x80, 0x3F, 0x83, 0xF0, 0x07, 0xE0,
  0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x81, 0xF8, 0x03, 0xF0, 0x3F, 0x80,
  0xFE, 0x07, 0xF8, 0x7F, 0xC0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFD, 0xF8, 0x00, 0xFF, 0x7F, 0x00, 0x02, 0x0F,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x10,
  0x01, 0xFC, 0x03, 0x80, 0x7F, 0x00, 0xFC, 0x3F, 0xE0, 0x3F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF7, 0xF8, 0x07, 0xEF, 0xFC,
  0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xF8, 0x7F,
  0x0F, 0xE0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F,
  0x0F, 0xC0, 0x3F, 0x1F, 0xC0, 0x3F, 0x1F, 0xC0, 0x3F, 0x1F, 0x80, 0x7F,
  0x1F, 0x80, 0x7F, 0x1F, 0x80, 0x7E, 0x3F, 0x80, 0x7E, 0x3F, 0x80, 0x7E,
  0x3F, 0x00, 0x7E, 0x3F, 0x00, 0xFE, 0x3F, 0x00, 0xFE, 0x3F, 0x00, 0xFC,
  0x7F, 0x00, 0xFC, 0x7F, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x01, 0xFC,
  0x7E, 0x01, 0xFC, 0x7E, 0x01, 0xF8, 0xFE, 0x01, 0xF8, 0xFE, 0x01, 0xF8,
  0x01, 0xF0, 0x1F, 0x80, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x7E, 0x07, 0xF0, 0x3F,
  0x81, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x81, 0xFC, 0x0F, 0xE0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x7E,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x07, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00,
  0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x3F, 0xC1, 0xFC, 0x0F, 0xF0, 0x3F,
  0x03, 0xFC, 0x07, 0xE0, 0xFF, 0x00, 0xFC, 0x3F, 0xC0, 0x3F, 0x87, 0xF0,
  0x07, 0xF1, 0xFC, 0x00, 0xFC, 0x7F, 0x80, 0x1F, 0x9F, 0xE0, 0x03, 0xF7,
  0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00,
  0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFE, 0x7E, 0x00, 0x3F, 0x8F, 0xC0, 0x07,
  0xE1, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x83, 0xF8, 0x07, 0xF0, 0x7F,
  0x00, 0xFE, 0x07, 0xE0, 0x1F, 0x80, 0xFE, 0x03, 0xF0, 0x1F, 0xC0, 0x7E,
  0x01, 0xFC, 0x0F, 0xC0, 0x3F, 0x83, 0xF8, 0x07, 0xF0, 0x00, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x81, 0xFC,
  0x0F, 0xE0, 0x7E, 0x03, 0xF0, 0x1F, 0x81, 0xFC, 0x0F, 0xE0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x03,
  0xF8, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x0F, 0xCF, 0xF0, 0x3F, 0xE0, 0x1F, 0xBF, 0xF0, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF3, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0x81, 0xFC, 0x1F, 0xF8, 0x7F, 0x07, 0xF0, 0x3F, 0xE0, 0x7E, 0x0F,
  0xE0, 0x3F, 0x80, 0xFE, 0x1F, 0x80, 0x7F, 0x01, 0xFC, 0x3F, 0x00, 0xFC,
  0x03, 0xF8, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x0F, 0xC3,
  0xF8, 0x07, 0xE0, 0x1F, 0x87, 0xE0, 0x1F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F,
  0x80, 0xFE, 0x1F, 0x80, 0x7E, 0x01, 0xFC, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0xFE, 0x01, 0xF8, 0x07, 0xE1, 0xFC, 0x07, 0xF0, 0x0F, 0xC3, 0xF0, 0x0F,
  0xE0, 0x1F, 0x87, 0xE0, 0x1F, 0xC0, 0x7F, 0x0F, 0xC0, 0x3F, 0x00, 0xFE,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x7F, 0x00, 0xFC, 0x03, 0xF0, 0xFE, 0x03,
  0xF8, 0x07, 0xE1, 0xF8, 0x07, 0xF0, 0x0F, 0xC3, 0xF0, 0x0F, 0xE0, 0x3F,
  0x87, 0xE0, 0x1F, 0x80, 0x7F, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x3F, 0x80,
  0x7E, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE7, 0xF8, 0x07, 0xEF,
  0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xF8,
  0x7F, 0x0F, 0xE0, 0x3F, 0x0F, 0xE0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0,
  0x3F, 0x0F, 0xC0, 0x3F, 0x1F, 0xC0, 0x3F, 0x1F, 0xC0, 0x3F, 0x1F, 0x80,
  0x7F, 0x1F, 0x80, 0x7F, 0x1F, 0x80, 0x7E, 0x3F, 0x80, 0x7E, 0x3F, 0x80,
  0x7E, 0x3F, 0x80, 0x7E, 0x3F, 0x00, 0xFE, 0x3F, 0x00, 0xFE, 0x3F, 0x00,
  0xFC, 0x7F, 0x00, 0xFC, 0x7F, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x01,
  0xFC, 0x7E, 0x01, 0xFC, 0x7E, 0x01, 0xF8, 0xFE, 0x01, 0xF8, 0xFE, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x07, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x1F, 0xE1, 0xFC, 0x3F, 0x80,
  0xFE, 0x3F, 0x80, 0x7E, 0x7F, 0x00, 0x7E, 0x7F, 0x00, 0x7E, 0x7E, 0x00,
  0x7E, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00,
  0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0xFE, 0xFC, 0x00,
  0xFE, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x01, 0xFC, 0xFE, 0x01,
  0xF8, 0xFE, 0x03, 0xF8, 0x7F, 0x07, 0xF0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x3F, 0x3F, 0xC0, 0x07, 0xEF, 0xFE, 0x00,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0x87,
  0xF8, 0x1F, 0xC0, 0x7F, 0x03, 0xF8, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x0F,
  0xC0, 0x1F, 0x81, 0xF8, 0x03, 0xF0, 0x7F, 0x00, 0x7E, 0x0F, 0xE0, 0x0F,
  0xC1, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x0F, 0xE0, 0xFC,
  0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x87, 0xF0, 0x07, 0xE0, 0xFC, 0x00, 0xFC,
  0x1F, 0x80, 0x3F, 0x83, 0xF0, 0x07, 0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0xE0,
  0x3F, 0x83, 0xFE, 0x0F, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x01,
  0xFB, 0xFF, 0xE0, 0x3F, 0x3F, 0xF0, 0x0F, 0xE3, 0xFC, 0x01, 0xFC, 0x0C,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC3, 0xE0, 0x3F, 0xF9,
  0xF8, 0x1F, 0xFF, 0x7E, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE1, 0xFE,
  0x0F, 0xF8, 0x7F, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x0F, 0xE0, 0x0F, 0xC3,
  0xF0, 0x07, 0xF0, 0xFC, 0x01, 0xFC, 0x7F, 0x00, 0x7F, 0x1F, 0xC0, 0x1F,
  0x87, 0xE0, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0xFE, 0x1F, 0x80,
  0x3F, 0x87, 0xE0, 0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x1F,
  0x80, 0x3F, 0x07, 0xE0, 0x1F, 0xC1, 0xF8, 0x07, 0xF0, 0x7F, 0x01, 0xF8,
  0x1F, 0xE1, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xBF, 0x00, 0x02, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x80, 0xFC, 0xFC, 0x1F, 0xBF, 0x83, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F,
  0xFF, 0x81, 0xFF, 0xF0, 0x7F, 0xC0, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x04, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x1F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x87, 0xF0, 0x7F, 0x0F, 0xE0, 0x7E,
  0x1F, 0x80, 0xFE, 0x3F, 0x01, 0xFC, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01,
  0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0xFC, 0x7E, 0x01, 0xF8, 0xFC, 0x03,
  0xF1, 0xFC, 0x0F, 0xE1, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x03, 0xFF, 0xFC,
  0x03, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x20, 0x00, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0x00, 0xFC, 0x01, 0xF8, 0x3F, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x7F, 0xE0, 0xFF,
  0xC0, 0xFF, 0x81, 0xFF, 0x01, 0xFC, 0x00, 0x60, 0x00, 0x1F, 0xC0, 0x3F,
  0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x7F, 0x1F, 0x80, 0x7F, 0x1F, 0x80, 0x7E,
  0x3F, 0x80, 0x7E, 0x3F, 0x80, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0xFE,
  0x3F, 0x00, 0xFE, 0x3F, 0x00, 0xFC, 0x7F, 0x00, 0xFC, 0x7F, 0x00, 0xFC,
  0x7E, 0x00, 0xFC, 0x7E, 0x01, 0xFC, 0x7E, 0x01, 0xFC, 0x7E, 0x01, 0xF8,
  0xFE, 0x01, 0xF8, 0xFE, 0x01, 0xF8, 0xFC, 0x03, 0xF8, 0xFC, 0x03, 0xF8,
  0xFC, 0x03, 0xF8, 0xFC, 0x03, 0xF0, 0xFE, 0x07, 0xF0, 0xFE, 0x0F, 0xF0,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0,
  0x1F, 0xE7, 0xE0, 0x03, 0x00, 0x00, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x1F, 0x9F, 0x80, 0xFE, 0x7E, 0x03, 0xF1, 0xF8, 0x0F, 0xC7, 0xE0,
  0x7F, 0x1F, 0x81, 0xF8, 0x7E, 0x0F, 0xE1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x0F, 0x87, 0xE0, 0x3E, 0x1F, 0x80, 0xF8, 0x7E, 0x03, 0xF3, 0xF0, 0x0F,
  0xCF, 0xC0, 0x3F, 0x7E, 0x00, 0xFD, 0xF8, 0x03, 0xF7, 0xC0, 0x07, 0xFF,
  0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x03, 0xE0, 0x1F, 0x9F, 0x80, 0xF8,
  0x07, 0xE7, 0xE0, 0x3E, 0x03, 0xF9, 0xF8, 0x1F, 0xC0, 0xFC, 0x7E, 0x07,
  0xF0, 0x3F, 0x1F, 0x83, 0xFC, 0x1F, 0xC7, 0xE0, 0xFF, 0x07, 0xE1, 0xF8,
  0x7F, 0xC1, 0xF8, 0x7E, 0x1F, 0xF0, 0xFC, 0x1F, 0x87, 0xFC, 0x3F, 0x07,
  0xE3, 0xFF, 0x0F, 0xC1, 0xF8, 0xFF, 0xC7, 0xE0, 0x7E, 0x7D, 0xF1, 0xF8,
  0x1F, 0x9F, 0x7C, 0x7C, 0x07, 0xEF, 0xCF, 0x3F, 0x01, 0xFB, 0xE3, 0xCF,
  0xC0, 0x7E, 0xF8, 0xF3, 0xE0, 0x1F, 0xFC, 0x3F, 0xF8, 0x07, 0xFF, 0x0F,
  0xFC, 0x01, 0xFF, 0xC3, 0xFF, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x1F, 0xF8,
  0x3F, 0xE0, 0x03, 0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x3F,
  0x80, 0xFF, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x03, 0xF8, 0x0F, 0xE0, 0x00,
  0xFC, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x1F, 0x00,
  0x00, 0x03, 0xF0, 0x0F, 0xE0, 0x3F, 0x81, 0xFE, 0x03, 0xF8, 0x1F, 0xC0,
  0x1F, 0x83, 0xF8, 0x01, 0xF8, 0x3F, 0x80, 0x1F, 0xC7, 0xF0, 0x00, 0xFC,
  0x7E, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0xFD, 0xFC, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x03,
  0xFB, 0xF0, 0x00, 0x3F, 0xBF, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x7E, 0x3F,
  0x80, 0x0F, 0xE1, 0xF8, 0x01, 0xFC, 0x1F, 0x80, 0x1F, 0xC1, 0xFC, 0x03,
  0xF8, 0x0F, 0xC0, 0x7F, 0x00, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xF0,
  0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x01, 0xFC,
  0x03, 0xF0, 0x1F, 0xC0, 0x3F, 0x03, 0xF8, 0x03, 0xF0, 0x3F, 0x80, 0x3F,
  0x03, 0xF0, 0x03, 0xF0, 0x7F, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0xFE,
  0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x1F, 0xC0, 0x01,
  0xF9, 0xF8, 0x00, 0x1F, 0xBF, 0x80, 0x01, 0xFB, 0xF0, 0x00, 0x1F, 0xFF,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x80, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x1F,
  0xE0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0xC0, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xC0, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x07, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x07,
  0x80, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x00, 0x00, 0xC0, 0x00,
  0x70, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x0F, 0xF8, 0x07,
  0xF0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F,
  0x00, 0x02, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x7C, 0x3F,
  0xF0, 0x0F, 0x8F, 0xFF, 0x01, 0xF3, 0xFF, 0xF0, 0x7E, 0x7F, 0xFF, 0x0F,
  0x9F, 0x87, 0xFF, 0xF3, 0xE0, 0x7F, 0xFC, 0x7C, 0x07, 0xFF, 0x8F, 0x80,
  0xFF, 0xE3, 0xE0, 0x07, 0xF8, 0x00, 0x00, 0x7C, 0x00,
};

const GFXglyph RobotoCondensed_MediumItalic57pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 14, 42, 14, 1, -41 },
  { 75, 16, 15, 18, 4, -43 },
  { 105, 28, 41, 30, 2, -41 },
  { 249, 25, 54, 28, 2, -48 },
  { 418, 27, 43, 35, 5, -42 },
  { 564, 28, 43, 31, 1, -42 },
  { 715, 7, 14, 9, 4, -43 },
  { 728, 17, 58, 18, 3, -45 },
  { 852, 18, 58, 18, -3, -45 },
  { 983, 23, 24, 25, 3, -41 },
  { 1052, 24, 29, 27, 2, -33 },
  { 1139, 11, 16, 12, -3, -7 },
  { 1161, 13, 5, 17, 2, -20 },
  { 1170, 8, 8, 15, 1, -7 },
  { 1178, 25, 44, 19, -3, -41 },
  { 1316, 23, 43, 28, 3, -42 },
  { 1440, 16, 41, 28, 6, -41 },
  { 1522, 27, 42, 28, 0, -42 },
  { 1664, 25, 43, 28, 1, -42 },
  { 1799, 25, 41, 28, 1, -41 },
  { 1928, 26, 42, 28, 2, -41 },
  { 2065, 22, 42, 28, 3, -41 },
  { 2181, 26, 41, 28, 3, -41 },
  { 2315, 25, 43, 28, 2, -42 },
  { 2450, 22, 42, 28, 4, -42 },
  { 2566, 12, 32, 14, 1, -31 },
  { 2614, 15, 40, 13, -3, -31 },
  { 2689, 21, 26, 25, 2, -31 },
  { 2758, 22, 19, 27, 3, -28 },
  { 2811, 23, 27, 25, 1, -31 },
  { 2889, 21, 43, 24, 4, -42 },
  { 3002, 39, 53, 42, 1, -40 },
  { 3261, 31, 41, 32, -2, -41 },
  { 3420, 29, 41, 31, 1, -41 },
  { 3569, 28, 43, 31, 3, -42 },
  { 3720, 29, 41, 31, 1, -41 },
  { 3869, 29, 41, 27, 1, -41 },
  { 4018, 28, 41, 26, 1, -41 },
  { 4162, 28, 43, 33, 3, -42 },
  { 4313, 34, 41, 34, 1, -41 },
  { 4488, 14, 41, 14, 1, -41 },
  { 4560, 28, 42, 27, 0, -41 },
  { 4707, 33, 41, 30, 1, -41 },
  { 4877, 22, 41, 26, 1, -41 },
  { 4990, 41, 41, 42, 1, -41 },
  { 5201, 33, 41, 34, 1, -41 },
  { 5371, 29, 43, 33, 3, -42 },
  { 5527, 30, 41, 31, 1, -41 },
  { 5681, 30, 49, 33, 2, -42 },
  { 5865, 29, 41, 30, 1, -41 },
  { 6014, 29, 43, 29, 1, -42 },
  { 6170, 27, 41, 29, 5, -41 },
  { 6309, 30, 42, 31, 2, -41 },
  { 6467, 30, 41, 32, 5, -41 },
  { 6621, 39, 41, 42, 5, -41 },
  { 6821, 34, 41, 31, -1, -41 },
  { 6996, 28, 41, 30, 5, -41 },
  { 7140, 32, 41, 29, -1, -41 },
  { 7304, 19, 56, 14, -1, -47 },
  { 7437, 12, 44, 21, 5, -41 },
  { 7503, 18, 56, 14, -3, -47 },
  { 7629, 18, 20, 21, 2, -41 },
  { 7674, 22, 5, 22, -3, 0 },
  { 7688, 11, 8, 18, 6, -42 },
  { 7699, 23, 32, 26, 1, -31 },
  { 7791, 25, 44, 27, 0, -43 },
  { 7929, 23, 32, 26, 1, -31 },
  { 8021, 28, 44, 27, 1, -43 },
  { 8175, 23, 32, 26, 2, -31 },
  { 8267, 20, 44, 18, 2, -44 },
  { 8377, 27, 43, 28, 0, -31 },
  { 8523, 24, 43, 27, 0, -43 },
  { 8652, 13, 41, 13, 1, -41 },
  { 8719, 20, 53, 13, -6, -41 },
  { 8852, 27, 43, 26, 0, -43 },
  { 8998, 13, 43, 13, 1, -43 },
  { 9068, 39, 31, 41, 0, -31 },
  { 9220, 24, 31, 27, 0, -31 },
  { 9313, 24, 32, 28, 2, -31 },
  { 9409, 27, 43, 27, -2, -31 },
  { 9555, 26, 43, 28, 1, -31 },
  { 9695, 19, 31, 18, 0, -31 },
  { 9769, 23, 32, 25, 1, -31 },
  { 9861, 15, 38, 17, 2, -37 },
  { 9933, 24, 31, 27, 2, -30 },
  { 10026, 22, 30, 24, 3, -30 },
  { 10109, 34, 30, 35, 3, -30 },
  { 10237, 28, 30, 25, -2, -30 },
  { 10342, 28, 42, 24, -2, -30 },
  { 10489, 26, 30, 25, -1, -30 },
  { 10587, 18, 55, 17, 1, -45 },
  { 10711, 12, 49, 14, 1, -41 },
  { 10785, 17, 54, 17, -2, -44 },
  { 10900, 27, 12, 32, 2, -23 },
};

const GFXfont RobotoCondensed_MediumItalic57pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_MediumItalic57pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_MediumItalic57pt7bGlyphs,
  0x20, 0x7E, 67
};

#endif // _ROBOTOCONDENSED_MEDIUMITALIC57PT7B_H_
