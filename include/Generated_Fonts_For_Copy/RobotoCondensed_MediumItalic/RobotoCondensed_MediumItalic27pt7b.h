#ifndef _ROBOTOCONDENSED_MEDIUMITALIC27PT7B_H_
#define _ROBOTOCONDENSED_MEDIUMITALIC27PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-MediumItalic.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_MediumItalic27pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0x73, 0x8E, 0x38, 0xE3, 0x8C, 0x71, 0xC7, 0x1C, 0x60, 0x00,
  0x30, 0xE3, 0x8C, 0x00, 0x66, 0xCD, 0x9B, 0x7E, 0xD9, 0xB3, 0x00, 0x01,
  0x98, 0x19, 0x80, 0xCC, 0x06, 0x60, 0x66, 0x1F, 0xFC, 0xFF, 0xE1, 0x98,
  0x0C, 0xC0, 0x66, 0x06, 0x70, 0x33, 0x0F, 0xFE, 0x7F, 0xF0, 0xCC, 0x06,
  0x60, 0x67, 0x03, 0x30, 0x19, 0x80, 0x01, 0x80, 0x18, 0x01, 0x80, 0x78,
  0x1F, 0xE1, 0xFE, 0x38, 0xE3, 0x87, 0x38, 0x73, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x80, 0x7C, 0x01, 0xC0, 0x1C, 0xE1, 0xCE, 0x1C, 0xE1, 0xC7, 0xF8,
  0x7F, 0x83, 0xE0, 0x18, 0x01, 0x80, 0x18, 0x00, 0x3C, 0x03, 0xF0, 0x19,
  0x84, 0xCC, 0x66, 0x66, 0x73, 0x71, 0x9B, 0x0F, 0xB0, 0x3B, 0x80, 0x18,
  0x01, 0xBC, 0x1B, 0xE1, 0xF9, 0x8D, 0x8C, 0xCC, 0x6E, 0x63, 0x63, 0x30,
  0x0F, 0x80, 0x78, 0x07, 0x80, 0x7E, 0x07, 0xF8, 0x39, 0xC3, 0x8E, 0x1C,
  0x60, 0x67, 0x03, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0xCD, 0xEE, 0x6E, 0x7F,
  0x71, 0xFB, 0x8F, 0x9C, 0x38, 0xFF, 0xE3, 0xFF, 0x0F, 0x9C, 0x6D, 0xFF,
  0xB0, 0x01, 0x01, 0x81, 0xC1, 0xC0, 0xC0, 0xE0, 0x60, 0x70, 0x38, 0x18,
  0x1C, 0x0E, 0x07, 0x03, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x03, 0x01, 0x80, 0xC0, 0x70, 0x18, 0x06, 0x02, 0x00, 0x08, 0x0C, 0x0C,
  0x06, 0x06, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x06, 0x0E, 0x0E, 0x0E, 0x0C, 0x1C, 0x18, 0x38, 0x70, 0xE0, 0xC0, 0x80,
  0x03, 0x00, 0x60, 0x18, 0x33, 0x37, 0xFE, 0x7F, 0x83, 0x80, 0xD8, 0x3B,
  0x0E, 0x30, 0x84, 0x00, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xE1, 0xFF,
  0xFF, 0xFF, 0xFF, 0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x00,
  0x1C, 0x63, 0x8E, 0x31, 0xC6, 0x00, 0xFF, 0xFF, 0xC0, 0x5F, 0xF0, 0x00,
  0x30, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x30,
  0x03, 0x80, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03,
  0x00, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x00, 0x07, 0x83,
  0xF8, 0x7F, 0x9C, 0x73, 0x86, 0xE0, 0xDC, 0x3B, 0x87, 0x70, 0xEE, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC3, 0xB8, 0x77, 0x0E, 0x7F, 0x8F, 0xE0, 0xF8,
  0x00, 0x03, 0x1E, 0x7E, 0xFE, 0xCE, 0x0E, 0x0E, 0x1C, 0x1C, 0x1C, 0x1C,
  0x1C, 0x18, 0x38, 0x38, 0x38, 0x38, 0x38, 0x70, 0x03, 0xC0, 0x7F, 0x87,
  0xFC, 0x38, 0xE3, 0x87, 0x1C, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0x7F, 0xE7,
  0xFF, 0x3F, 0xF8, 0x0F, 0x83, 0xF8, 0xFF, 0x9C, 0x77, 0x0E, 0x01, 0xC0,
  0x38, 0x0F, 0x0F, 0xC1, 0xF0, 0x3E, 0x00, 0xE0, 0x1C, 0x03, 0xB8, 0x77,
  0x1E, 0xFF, 0x8F, 0xE0, 0xF8, 0x00, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x1F,
  0x03, 0xF0, 0x3E, 0x07, 0xE0, 0xEE, 0x1C, 0xE1, 0xCE, 0x38, 0xE7, 0x1C,
  0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x1F,
  0xF1, 0xFF, 0x1F, 0xF1, 0x80, 0x38, 0x03, 0x80, 0x3F, 0x83, 0xFC, 0x7F,
  0xC1, 0x1E, 0x00, 0xE0, 0x0E, 0x00, 0xEE, 0x0E, 0xE1, 0xCE, 0x1C, 0x7F,
  0x87, 0xF8, 0x1E, 0x00, 0x01, 0xC0, 0xF8, 0x3F, 0x0F, 0x03, 0xC0, 0x70,
  0x0D, 0xE3, 0xFE, 0x7F, 0xCE, 0x3D, 0xC3, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x73, 0x8E, 0x7F, 0x87, 0xF0, 0x78, 0x00, 0x3F, 0xFB, 0xFF, 0xDF, 0xFC,
  0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0x80, 0x3C, 0x01,
  0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0x80,
  0x1C, 0x00, 0x07, 0x81, 0xFE, 0x1F, 0xE3, 0x8E, 0x38, 0xF3, 0x8E, 0x38,
  0xE3, 0xFC, 0x1F, 0x83, 0xF8, 0x71, 0xCE, 0x1C, 0xE1, 0xCE, 0x1C, 0xE1,
  0xCE, 0x3C, 0xFF, 0x87, 0xF0, 0x3E, 0x00, 0x0F, 0x0F, 0xE7, 0xFD, 0xC7,
  0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0xFF, 0xFD, 0xFE, 0x3F, 0x80,
  0xE0, 0x70, 0x3C, 0x7E, 0x3F, 0x0F, 0x00, 0x11, 0xCE, 0x70, 0x00, 0x00,
  0x00, 0x00, 0x8E, 0x73, 0x80, 0x00, 0x3C, 0x78, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x87, 0x0C, 0x38, 0x71, 0xC1, 0x00, 0x00, 0x40,
  0x70, 0x7C, 0x7F, 0x7E, 0x3E, 0x0E, 0x03, 0xC0, 0x7C, 0x0F, 0xC0, 0xF0,
  0x0C, 0x01, 0x00, 0x3F, 0xEF, 0xFD, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F,
  0xF7, 0xFE, 0xFF, 0xC0, 0x20, 0x1C, 0x07, 0xC0, 0xFC, 0x0F, 0xC0, 0xF0,
  0x3C, 0x7E, 0x7E, 0x3E, 0x0E, 0x02, 0x00, 0x1E, 0x0F, 0xE7, 0xFB, 0xCE,
  0xE3, 0xC0, 0xE0, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x80, 0xE0, 0x30, 0x00,
  0x00, 0x00, 0x80, 0x70, 0x1C, 0x06, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0x80,
  0x70, 0x70, 0x38, 0x06, 0x1C, 0x01, 0x86, 0x00, 0x33, 0x0F, 0x0C, 0xC7,
  0xF3, 0x63, 0x98, 0xD8, 0xC6, 0x3E, 0x71, 0x8F, 0x18, 0x63, 0xC6, 0x38,
  0xF3, 0x8C, 0x2C, 0xE3, 0x1B, 0x39, 0xC6, 0xCE, 0x73, 0x31, 0xFF, 0x8C,
  0x79, 0xC3, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x04, 0x00, 0xFF,
  0x80, 0x0F, 0x80, 0x00, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x1F, 0x80, 0x37, 0x00, 0xEE, 0x01, 0xDC, 0x07, 0x38, 0x0E, 0x70, 0x38,
  0x60, 0x70, 0xE1, 0xFF, 0xC3, 0xFF, 0x8F, 0xFF, 0x1C, 0x0E, 0x70, 0x1C,
  0xE0, 0x3B, 0xC0, 0x78, 0x0F, 0xF0, 0x7F, 0xE1, 0xFF, 0xC7, 0x07, 0x1C,
  0x1C, 0x70, 0x71, 0xC3, 0x8F, 0x3E, 0x3F, 0xE0, 0xFF, 0xC3, 0x87, 0x0E,
  0x0E, 0x78, 0x39, 0xC0, 0xE7, 0x07, 0x9C, 0x1C, 0x7F, 0xF1, 0xFF, 0x8F,
  0xF8, 0x00, 0x03, 0xE0, 0x3F, 0xC1, 0xFF, 0x8F, 0x0E, 0x38, 0x1D, 0xE0,
  0x77, 0x01, 0xDC, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0,
  0x73, 0x81, 0xCF, 0x07, 0x1C, 0x38, 0x7F, 0xE0, 0xFF, 0x01, 0xF0, 0x00,
  0x0F, 0xE0, 0x7F, 0xC1, 0xFF, 0x87, 0x0F, 0x1C, 0x1C, 0x70, 0x71, 0xC1,
  0xCF, 0x07, 0x38, 0x1C, 0xE0, 0x73, 0x81, 0xCE, 0x0E, 0x78, 0x39, 0xC0,
  0xE7, 0x07, 0x1C, 0x3C, 0x7F, 0xE1, 0xFF, 0x0F, 0xF0, 0x00, 0x0F, 0xFC,
  0x7F, 0xF1, 0xFF, 0xC7, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00,
  0x3F, 0xF0, 0xFF, 0x83, 0xFE, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x7F, 0xE1, 0xFF, 0x8F, 0xFE, 0x00, 0x0F, 0xFC, 0x7F, 0xE1,
  0xFF, 0x87, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3F, 0xE0,
  0xFF, 0x83, 0xFE, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x3F, 0xC1, 0xFF, 0x8F,
  0x0F, 0x38, 0x1D, 0xE0, 0x77, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC7, 0xE7,
  0x1F, 0xBC, 0x7E, 0xE0, 0x3B, 0x81, 0xEF, 0x07, 0x1C, 0x1C, 0x7F, 0xF0,
  0xFF, 0x81, 0xF8, 0x00, 0x0E, 0x07, 0x1E, 0x07, 0x1C, 0x07, 0x1C, 0x07,
  0x1C, 0x0F, 0x1C, 0x0E, 0x1C, 0x0E, 0x3C, 0x0E, 0x3F, 0xFE, 0x3F, 0xFE,
  0x3F, 0xFE, 0x38, 0x1C, 0x78, 0x1C, 0x70, 0x1C, 0x70, 0x1C, 0x70, 0x1C,
  0x70, 0x38, 0x70, 0x38, 0xF0, 0x38, 0x0E, 0x1C, 0x78, 0xE1, 0xC3, 0x87,
  0x1E, 0x38, 0x70, 0xE1, 0xC3, 0x8F, 0x1C, 0x38, 0x70, 0xE1, 0xC0, 0x00,
  0x38, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x70, 0x73, 0x87, 0x1E,
  0x38, 0x7F, 0xC3, 0xFC, 0x07, 0x80, 0x0E, 0x0F, 0x1E, 0x1E, 0x1C, 0x3C,
  0x1C, 0x78, 0x1C, 0x70, 0x1C, 0xF0, 0x1D, 0xE0, 0x3F, 0xC0, 0x3F, 0x80,
  0x3F, 0x80, 0x3F, 0xC0, 0x3D, 0xC0, 0x79, 0xC0, 0x70, 0xE0, 0x70, 0xE0,
  0x70, 0xF0, 0x70, 0x70, 0x70, 0x70, 0xF0, 0x78, 0x0E, 0x03, 0xC0, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x7F, 0xEF, 0xFF, 0xFF, 0x80, 0x0F,
  0x00, 0xF1, 0xF0, 0x1F, 0x1F, 0x01, 0xF1, 0xF0, 0x3E, 0x1F, 0x03, 0xE1,
  0xF0, 0x7E, 0x1B, 0x07, 0xE3, 0xB8, 0xEE, 0x3B, 0x8E, 0xE3, 0xB8, 0xDC,
  0x3B, 0x9D, 0xC3, 0xB9, 0x9C, 0x79, 0xB9, 0xC7, 0x1B, 0x1C, 0x71, 0xF3,
  0xC7, 0x1E, 0x38, 0x71, 0xE3, 0x87, 0x1C, 0x38, 0xF1, 0xC3, 0x80, 0x0E,
  0x07, 0x1E, 0x07, 0x1E, 0x07, 0x1F, 0x07, 0x1F, 0x0F, 0x1F, 0x0E, 0x1F,
  0x8E, 0x3D, 0x8E, 0x39, 0x8E, 0x39, 0xCE, 0x39, 0xDE, 0x38, 0xDC, 0x78,
  0xFC, 0x70, 0xFC, 0x70, 0x7C, 0x70, 0x7C, 0x70, 0x78, 0x70, 0x78, 0xF0,
  0x38, 0x03, 0xE0, 0x3F, 0xC1, 0xFF, 0x8F, 0x0F, 0x38, 0x1C, 0xE0, 0x77,
  0x01, 0xDC, 0x07, 0x70, 0x1D, 0xC0, 0x7F, 0x03, 0xF8, 0x0E, 0xE0, 0x3B,
  0x80, 0xEF, 0x07, 0x1C, 0x3C, 0x7F, 0xE0, 0xFF, 0x01, 0xF8, 0x00, 0x0F,
  0xF0, 0x3F, 0xF0, 0x7F, 0xF0, 0xE0, 0xE1, 0xC1, 0xE3, 0x81, 0xC7, 0x07,
  0x9E, 0x0E, 0x38, 0x3C, 0x7F, 0xF0, 0xFF, 0xC1, 0xFF, 0x07, 0x80, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x00, 0x03,
  0xE0, 0x3F, 0xC1, 0xFF, 0x8F, 0x0F, 0x38, 0x1D, 0xE0, 0x77, 0x01, 0xDC,
  0x07, 0x70, 0x1D, 0xC0, 0x7F, 0x03, 0xB8, 0x0E, 0xE0, 0x3B, 0x80, 0xEF,
  0x07, 0x1C, 0x3C, 0x7F, 0xE0, 0xFF, 0x01, 0xFC, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0x00, 0x0F, 0xE0, 0x7F, 0xE1, 0xFF, 0xC7, 0x07, 0x1C, 0x1C, 0x70,
  0x71, 0xC1, 0xCF, 0x0F, 0x38, 0x38, 0xFF, 0xE3, 0xFF, 0x0F, 0xF0, 0x39,
  0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x3C, 0x70, 0xF1, 0xC1, 0xCF, 0x07, 0x00,
  0x07, 0xC0, 0xFF, 0x07, 0xFC, 0x78, 0xF3, 0x83, 0x9C, 0x1C, 0xE0, 0x07,
  0x80, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xC0, 0x0E, 0x70, 0x73, 0x83,
  0x9C, 0x3C, 0xFF, 0xC3, 0xFE, 0x07, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE,
  0x0E, 0x00, 0x70, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xC0,
  0x0E, 0x00, 0x38, 0x1C, 0xE0, 0x73, 0x81, 0xCE, 0x07, 0x38, 0x3D, 0xE0,
  0xE7, 0x03, 0x9C, 0x0E, 0x70, 0x39, 0xC0, 0xE7, 0x07, 0xBC, 0x1C, 0xE0,
  0x73, 0x81, 0xCE, 0x07, 0x3C, 0x38, 0x7F, 0xE1, 0xFF, 0x01, 0xF0, 0x00,
  0xF0, 0x1F, 0xC0, 0xF7, 0x03, 0x9C, 0x1E, 0x70, 0x71, 0xC1, 0xC7, 0x0E,
  0x1C, 0x38, 0x71, 0xE1, 0xC7, 0x03, 0x9C, 0x0E, 0xE0, 0x3B, 0x80, 0xFC,
  0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0x70, 0x01, 0xC0, 0x00, 0xE1, 0xC1,
  0xF8, 0x70, 0xEE, 0x1C, 0x3B, 0x8F, 0x0E, 0xE3, 0xC7, 0x39, 0xF1, 0xCE,
  0x7C, 0x73, 0x9B, 0x38, 0xEE, 0xCE, 0x3B, 0xB3, 0x8E, 0xCD, 0xC3, 0xF3,
  0x70, 0xF8, 0xFC, 0x3E, 0x3E, 0x0F, 0x8F, 0x83, 0xC3, 0xE0, 0xF0, 0xF0,
  0x3C, 0x3C, 0x0E, 0x0F, 0x00, 0x0E, 0x07, 0x07, 0x07, 0x83, 0xC7, 0x80,
  0xE3, 0x80, 0x73, 0xC0, 0x3D, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x73, 0x80, 0x79,
  0xC0, 0x38, 0xE0, 0x3C, 0x78, 0x3C, 0x1C, 0x1C, 0x0E, 0x00, 0xF0, 0x39,
  0xC1, 0xE7, 0x07, 0x1C, 0x3C, 0x70, 0xE0, 0xE7, 0x03, 0x9C, 0x0E, 0xE0,
  0x3B, 0x80, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x1F, 0xFE, 0x3F, 0xF8,
  0x7F, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xE0, 0x07, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xFF, 0xF1, 0xFF, 0xE3, 0xFF, 0xC0, 0x0F, 0x0F, 0x1F, 0x1C,
  0x1C, 0x1C, 0x1C, 0x1C, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x78, 0x70,
  0x70, 0x70, 0x70, 0x70, 0x70, 0xE0, 0xE0, 0xF8, 0xF8, 0xF0, 0xE1, 0x87,
  0x1C, 0x71, 0xC7, 0x1C, 0x30, 0xE3, 0x8E, 0x38, 0xE3, 0x86, 0x1C, 0x71,
  0xC7, 0x1C, 0x07, 0x87, 0xC3, 0xE0, 0x70, 0x38, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC1, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x0F, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0xF8, 0x78, 0x3C, 0x00, 0x06, 0x07, 0x03, 0x83,
  0xE1, 0xB1, 0xD8, 0xCC, 0xE6, 0x63, 0x71, 0x80, 0x7F, 0xEF, 0xFF, 0xFF,
  0x00, 0xE3, 0x9C, 0x70, 0x07, 0x83, 0xF8, 0xFF, 0x9C, 0x70, 0x0E, 0x01,
  0xC3, 0xF9, 0xFF, 0x78, 0xEE, 0x39, 0xC7, 0x78, 0xE7, 0xFC, 0xFF, 0x8F,
  0x70, 0x0E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1F, 0xC3,
  0xFE, 0x3F, 0xF3, 0x87, 0x38, 0x73, 0x87, 0x38, 0x77, 0x07, 0x70, 0x77,
  0x0E, 0x70, 0xE7, 0x0E, 0x7F, 0xCE, 0xFC, 0xE7, 0x80, 0x0F, 0x07, 0xF9,
  0xFF, 0x38, 0xE7, 0x0F, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x87,
  0x71, 0xCF, 0xF8, 0xFE, 0x0F, 0x80, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x7B, 0xC7, 0xFC, 0x7F, 0xE3, 0x87, 0x38, 0x39,
  0xC1, 0xCE, 0x1E, 0x70, 0xE3, 0x87, 0x1C, 0x38, 0xE1, 0xC7, 0x1E, 0x3F,
  0xF0, 0xFF, 0x03, 0xB8, 0x00, 0x0F, 0x07, 0xF8, 0xFF, 0x38, 0x67, 0x0F,
  0xC1, 0xFF, 0xF7, 0xFE, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x4F, 0xF8, 0xFF,
  0x0F, 0x80, 0x07, 0x87, 0xC7, 0xE3, 0x81, 0xC0, 0xE1, 0xFC, 0xFE, 0x38,
  0x1C, 0x0E, 0x07, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x38, 0x1C,
  0x0E, 0x00, 0x0F, 0x38, 0xFD, 0x8F, 0xFC, 0x70, 0xE7, 0x87, 0x38, 0x39,
  0xC1, 0xCE, 0x1C, 0x70, 0xE3, 0x87, 0x1C, 0x38, 0xE1, 0xC7, 0xFE, 0x1F,
  0xE0, 0x7F, 0x00, 0x38, 0x43, 0xC7, 0xFC, 0x3F, 0xC0, 0x7C, 0x00, 0x1E,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x3F, 0xC3, 0xFE, 0x3F,
  0xE3, 0x8E, 0x38, 0x73, 0x8F, 0x78, 0xE7, 0x0E, 0x70, 0xE7, 0x0E, 0x70,
  0xE7, 0x0E, 0xF1, 0xCE, 0x1C, 0xE1, 0xC0, 0x1C, 0x3C, 0x30, 0x00, 0x03,
  0x8F, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x8E, 0x1C, 0x38, 0x70, 0xE1, 0xC7,
  0x00, 0x03, 0x81, 0xC0, 0x60, 0x00, 0x00, 0x1C, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x07, 0x03, 0x81,
  0xC0, 0xE3, 0xF1, 0xF0, 0xF0, 0x00, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x71, 0xC7, 0x1E, 0x39, 0xE1, 0xDE, 0x0E, 0xE0,
  0x7E, 0x03, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0x70, 0x73, 0x83, 0x9C, 0x1C,
  0x71, 0xC3, 0x8E, 0x1C, 0x00, 0x0E, 0x1C, 0x70, 0xE1, 0xC3, 0x87, 0x0E,
  0x38, 0x70, 0xE1, 0xC3, 0x87, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x8E, 0x00,
  0x1B, 0xC7, 0x8F, 0xFB, 0xF3, 0xFF, 0xFC, 0xE3, 0xC7, 0x38, 0xF1, 0xCE,
  0x38, 0x73, 0x8E, 0x1D, 0xC3, 0x87, 0x70, 0xE1, 0xDC, 0x38, 0x77, 0x0E,
  0x39, 0xC7, 0x0E, 0x71, 0xC3, 0xB8, 0x70, 0xEE, 0x1C, 0x38, 0x3B, 0xC3,
  0xFE, 0x3F, 0xE3, 0x8F, 0x38, 0x73, 0x8E, 0x78, 0xE7, 0x0E, 0x70, 0xE7,
  0x0E, 0x70, 0xE7, 0x0E, 0xF1, 0xCE, 0x1C, 0xE1, 0xC0, 0x0F, 0x87, 0xF8,
  0xFF, 0x38, 0x77, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x87,
  0x70, 0xEF, 0xF8, 0xFE, 0x0F, 0x80, 0x1D, 0xE0, 0xFF, 0x87, 0xFE, 0x38,
  0x71, 0xC3, 0x8E, 0x1C, 0xE0, 0xE7, 0x07, 0x38, 0x39, 0xC3, 0x8E, 0x1C,
  0x70, 0xE7, 0xFE, 0x3B, 0xF1, 0xCF, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x38,
  0x01, 0xC0, 0x00, 0x1E, 0x63, 0xFE, 0x7F, 0xE7, 0x0E, 0xF0, 0xEE, 0x0E,
  0xE1, 0xCE, 0x1C, 0xE1, 0xCE, 0x1C, 0xE1, 0xCE, 0x3C, 0xFF, 0x87, 0xF8,
  0x3B, 0x80, 0x38, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x3B, 0x9F, 0xCF,
  0xE7, 0x83, 0x81, 0xC0, 0xE0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x07,
  0x03, 0x80, 0x0F, 0x83, 0xF8, 0xF7, 0x9C, 0x73, 0x80, 0x70, 0x0F, 0x80,
  0xFC, 0x07, 0xC0, 0x3B, 0x87, 0x70, 0xE7, 0xBC, 0xFF, 0x07, 0x80, 0x1C,
  0x38, 0xE7, 0xFF, 0xE7, 0x0E, 0x1C, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x38,
  0x3C, 0x78, 0x70, 0x70, 0xEE, 0x1D, 0xC3, 0xB8, 0x77, 0x0E, 0xE3, 0xFC,
  0x77, 0x0E, 0xE1, 0xDC, 0x3B, 0x87, 0x71, 0xEF, 0xF8, 0xFF, 0x1E, 0xE0,
  0x70, 0xEE, 0x39, 0xC7, 0x38, 0xE7, 0x38, 0xE7, 0x1C, 0xC3, 0xB8, 0x77,
  0x07, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0x78, 0x0E, 0x00, 0xE3, 0x8F, 0xC7,
  0x1F, 0x9E, 0x37, 0x3C, 0xEE, 0x79, 0xDD, 0xF3, 0x3B, 0x6E, 0x7E, 0xDC,
  0xF9, 0xB1, 0xF3, 0xE3, 0xE7, 0x87, 0x8F, 0x0F, 0x1E, 0x1C, 0x38, 0x38,
  0x70, 0x00, 0x1C, 0x78, 0xE3, 0x83, 0x3C, 0x1D, 0xC0, 0xFC, 0x07, 0xE0,
  0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0x60, 0x7B, 0x83, 0x9C, 0x38,
  0xE1, 0xC3, 0x80, 0x1C, 0x38, 0xE3, 0x87, 0x1C, 0x39, 0xE1, 0xCE, 0x0E,
  0x70, 0x77, 0x03, 0xB8, 0x1F, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x07, 0xC0, 0x3E, 0x01, 0xC0, 0x00,
  0x3F, 0xF3, 0xFE, 0x3F, 0xE0, 0x1C, 0x03, 0xC0, 0x78, 0x07, 0x00, 0xE0,
  0x1E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xFF, 0xCF, 0xFC, 0xFF, 0x80, 0x03,
  0x07, 0x0E, 0x0C, 0x1C, 0x1C, 0x1C, 0x18, 0x18, 0x38, 0x38, 0x70, 0xE0,
  0xE0, 0x70, 0x70, 0x70, 0x70, 0x70, 0x70, 0x60, 0x60, 0x70, 0x70, 0x30,
  0x10, 0x0C, 0x30, 0xC7, 0x18, 0x61, 0x86, 0x18, 0x63, 0x0C, 0x30, 0xC3,
  0x0C, 0x71, 0x86, 0x18, 0x61, 0x86, 0x00, 0x08, 0x1C, 0x0E, 0x0E, 0x06,
  0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0F, 0x07, 0x0F, 0x1E, 0x1C, 0x1C,
  0x18, 0x38, 0x38, 0x38, 0x38, 0x30, 0x70, 0xE0, 0x80, 0x3C, 0x1B, 0xF1,
  0xDF, 0xCD, 0xCF, 0xEE, 0x3E, 0x00, 0xE0,
};

const GFXglyph RobotoCondensed_MediumItalic27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 6, 19, 7, 1, -19 },
  { 16, 7, 7, 8, 2, -20 },
  { 23, 13, 19, 14, 1, -19 },
  { 54, 12, 25, 13, 1, -22 },
  { 92, 13, 19, 17, 2, -19 },
  { 123, 13, 19, 15, 1, -19 },
  { 154, 3, 7, 4, 2, -20 },
  { 157, 9, 28, 8, 1, -22 },
  { 189, 8, 27, 8, -1, -21 },
  { 216, 11, 11, 12, 1, -19 },
  { 232, 11, 14, 13, 1, -16 },
  { 252, 6, 7, 6, -2, -3 },
  { 258, 6, 3, 8, 1, -10 },
  { 261, 3, 4, 7, 1, -4 },
  { 263, 13, 21, 9, -2, -19 },
  { 298, 11, 19, 13, 1, -19 },
  { 325, 8, 19, 13, 3, -19 },
  { 344, 13, 19, 13, 0, -19 },
  { 375, 11, 19, 13, 1, -19 },
  { 402, 12, 19, 13, 0, -19 },
  { 431, 12, 19, 13, 1, -19 },
  { 460, 11, 19, 13, 1, -19 },
  { 487, 13, 19, 13, 1, -19 },
  { 518, 12, 19, 13, 1, -19 },
  { 547, 10, 19, 13, 2, -19 },
  { 571, 5, 15, 7, 1, -15 },
  { 581, 7, 19, 6, -1, -15 },
  { 598, 10, 13, 12, 1, -15 },
  { 615, 11, 9, 13, 1, -13 },
  { 628, 10, 12, 12, 1, -14 },
  { 643, 10, 19, 11, 2, -19 },
  { 667, 18, 25, 20, 1, -19 },
  { 724, 15, 19, 15, -1, -19 },
  { 760, 14, 19, 15, 0, -19 },
  { 794, 14, 19, 15, 1, -19 },
  { 828, 14, 19, 15, 0, -19 },
  { 862, 14, 19, 13, 0, -19 },
  { 896, 14, 19, 13, 0, -19 },
  { 930, 14, 19, 15, 1, -19 },
  { 964, 16, 19, 16, 0, -19 },
  { 1002, 7, 19, 7, 0, -19 },
  { 1019, 13, 19, 13, 0, -19 },
  { 1050, 16, 19, 14, 0, -19 },
  { 1088, 11, 19, 13, 0, -19 },
  { 1115, 20, 19, 20, 0, -19 },
  { 1163, 16, 19, 16, 0, -19 },
  { 1201, 14, 19, 16, 1, -19 },
  { 1235, 15, 19, 15, 0, -19 },
  { 1271, 14, 22, 16, 1, -19 },
  { 1310, 14, 19, 14, 0, -19 },
  { 1344, 13, 19, 14, 1, -19 },
  { 1375, 13, 19, 14, 2, -19 },
  { 1406, 14, 19, 15, 1, -19 },
  { 1440, 14, 19, 15, 2, -19 },
  { 1474, 18, 19, 20, 3, -19 },
  { 1517, 17, 19, 15, -1, -19 },
  { 1558, 14, 19, 14, 2, -19 },
  { 1592, 15, 19, 14, 0, -19 },
  { 1628, 8, 26, 7, 0, -22 },
  { 1654, 6, 21, 10, 2, -19 },
  { 1670, 9, 26, 7, -2, -22 },
  { 1700, 9, 10, 10, 1, -19 },
  { 1712, 11, 3, 11, -2, 0 },
  { 1717, 5, 4, 8, 3, -20 },
  { 1720, 11, 15, 12, 0, -15 },
  { 1741, 12, 21, 13, 0, -21 },
  { 1773, 11, 15, 12, 1, -15 },
  { 1794, 13, 21, 13, 1, -21 },
  { 1829, 11, 15, 12, 1, -15 },
  { 1850, 9, 21, 8, 1, -21 },
  { 1874, 13, 20, 13, 0, -15 },
  { 1907, 12, 21, 13, 0, -21 },
  { 1939, 7, 20, 6, 0, -20 },
  { 1957, 9, 25, 6, -3, -20 },
  { 1986, 13, 21, 12, 0, -21 },
  { 2021, 7, 21, 6, 0, -21 },
  { 2040, 18, 15, 20, 0, -15 },
  { 2074, 12, 15, 13, 0, -15 },
  { 2097, 11, 15, 13, 1, -15 },
  { 2118, 13, 20, 13, -1, -15 },
  { 2151, 12, 20, 13, 1, -15 },
  { 2181, 9, 15, 8, 0, -15 },
  { 2198, 11, 15, 12, 0, -15 },
  { 2219, 7, 18, 8, 1, -18 },
  { 2235, 11, 15, 13, 1, -15 },
  { 2256, 11, 15, 12, 1, -15 },
  { 2277, 15, 15, 17, 2, -15 },
  { 2306, 13, 15, 12, -1, -15 },
  { 2331, 13, 20, 11, -1, -15 },
  { 2364, 12, 15, 12, 0, -15 },
  { 2387, 8, 26, 8, 1, -21 },
  { 2413, 6, 23, 7, 0, -19 },
  { 2431, 8, 26, 8, -1, -21 },
  { 2457, 13, 6, 15, 1, -11 },
};

const GFXfont RobotoCondensed_MediumItalic27pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_MediumItalic27pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_MediumItalic27pt7bGlyphs,
  0x20, 0x7E, 32
};

#endif // _ROBOTOCONDENSED_MEDIUMITALIC27PT7B_H_
