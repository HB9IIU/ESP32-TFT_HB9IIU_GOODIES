#ifndef _ROBOTOCONDENSED_MEDIUMITALIC11PT7B_H_
#define _ROBOTOCONDENSED_MEDIUMITALIC11PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-MediumItalic.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_MediumItalic11pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0x24, 0x86, 0xB7, 0x00, 0x14, 0x67, 0xCA, 0x33, 0xE5, 0x18,
  0x11, 0xDA, 0x96, 0x0B, 0x6A, 0x71, 0x00, 0x65, 0x6D, 0xC3, 0xB6, 0xA3,
  0x31, 0xA7, 0x8C, 0x7B, 0x6D, 0x9E, 0xE0, 0x29, 0x49, 0x24, 0x92, 0x00,
  0x22, 0x11, 0x11, 0x12, 0x22, 0x48, 0x24, 0xFE, 0xA0, 0x31, 0x3E, 0x42,
  0x00, 0x5C, 0xE0, 0xC0, 0x08, 0x44, 0x22, 0x11, 0x08, 0x40, 0x3A, 0x52,
  0x94, 0xAD, 0x4E, 0x3C, 0x96, 0x92, 0x3A, 0x42, 0x33, 0x11, 0x1E, 0x3A,
  0x42, 0x61, 0x0F, 0x4E, 0x18, 0xCE, 0xA5, 0x7C, 0x42, 0x39, 0x10, 0xE1,
  0x87, 0x6E, 0x34, 0x8E, 0xB9, 0xBE, 0xF8, 0x8C, 0x46, 0x23, 0x10, 0x3B,
  0x52, 0x65, 0x6F, 0x4E, 0x69, 0x9B, 0xF2, 0x2C, 0x40, 0x01, 0x80, 0x20,
  0x00, 0xD2, 0x13, 0xB0, 0xC1, 0x00, 0x78, 0x1C, 0x41, 0x86, 0xC8, 0x00,
  0x6B, 0x32, 0x44, 0x08, 0x1E, 0x22, 0x5D, 0x55, 0xA5, 0xA9, 0xAA, 0xB6,
  0x40, 0x78, 0x18, 0x62, 0x8A, 0x49, 0xEC, 0xA2, 0x79, 0xB4, 0xDC, 0x49,
  0x2C, 0xBC, 0x39, 0x94, 0x50, 0x41, 0x24, 0x9C, 0x79, 0xB4, 0xD3, 0x4D,
  0x2D, 0xBC, 0x7D, 0x84, 0x1E, 0x41, 0x0C, 0x3C, 0x7D, 0x84, 0x10, 0x79,
  0x0C, 0x30, 0x39, 0x94, 0x50, 0x5D, 0x34, 0x9E, 0x66, 0xC9, 0x13, 0xE4,
  0x49, 0xB3, 0x64, 0x6D, 0x24, 0xB6, 0x08, 0x42, 0x31, 0x8A, 0x4C, 0x64,
  0xD1, 0x63, 0x87, 0x0A, 0x36, 0x64, 0x66, 0x44, 0x44, 0xCF, 0x63, 0x63,
  0x67, 0x77, 0x5E, 0x5A, 0xDA, 0xD2, 0x66, 0xC9, 0x92, 0xA5, 0x4B, 0xB3,
  0x64, 0x39, 0x94, 0x51, 0x45, 0x34, 0x9C, 0x79, 0x94, 0x53, 0x79, 0x0C,
  0x30, 0x39, 0x94, 0x51, 0x45, 0x34, 0x9C, 0x08, 0x79, 0xB4, 0xD2, 0x79,
  0x4D, 0xB2, 0x39, 0xB4, 0x1C, 0x18, 0x2D, 0x9C, 0xF9, 0x08, 0xC6, 0x21,
  0x08, 0x65, 0x14, 0x53, 0x4B, 0x24, 0x9C, 0x8A, 0x29, 0xB4, 0xF1, 0x86,
  0x10, 0x92, 0x92, 0xB6, 0xB4, 0xB4, 0xCC, 0xC8, 0xC8, 0x64, 0xA3, 0x8C,
  0x31, 0xC5, 0xB2, 0x8E, 0xD4, 0xC6, 0x21, 0x08, 0x7C, 0x21, 0x84, 0x21,
  0x8C, 0x3E, 0x6D, 0x24, 0x96, 0x93, 0x00, 0xAB, 0x55, 0x40, 0x31, 0x32,
  0x22, 0x22, 0x66, 0xC0, 0x22, 0x55, 0xF8, 0xD0, 0x72, 0xDD, 0xA9, 0x38,
  0x62, 0x10, 0xE4, 0xA7, 0x3A, 0xB0, 0x72, 0xF1, 0x8D, 0x38, 0x08, 0x20,
  0x9E, 0x4B, 0x6D, 0xB4, 0x70, 0x32, 0x7F, 0x8C, 0x38, 0x32, 0x66, 0x44,
  0x44, 0x40, 0x7A, 0x73, 0xBD, 0x3A, 0x5C, 0x62, 0x10, 0xE5, 0xAF, 0x52,
  0x90, 0x61, 0x24, 0xB4, 0x30, 0x22, 0x26, 0x64, 0x4C, 0x62, 0x10, 0xB5,
  0x33, 0x9A, 0x90, 0x6D, 0x24, 0x96, 0x80, 0x76, 0xB5, 0x6E, 0x9D, 0x32,
  0x40, 0x72, 0xD7, 0xAD, 0x48, 0x32, 0x73, 0x9D, 0x38, 0x72, 0x53, 0x9D,
  0x5A, 0x10, 0x7A, 0x77, 0xBD, 0x38, 0x42, 0x74, 0x4C, 0xC8, 0x72, 0xD8,
  0x69, 0x38, 0x7D, 0x24, 0x90, 0x4A, 0x57, 0xAD, 0x38, 0xBA, 0xAC, 0xCC,
  0xA6, 0xBE, 0xB6, 0xD2, 0x40, 0x5A, 0x88, 0xC7, 0x48, 0x5A, 0x94, 0xC6,
  0x21, 0x10, 0x78, 0x88, 0xCC, 0x78, 0x12, 0x26, 0x4C, 0x44, 0x44, 0x40,
  0x55, 0x5A, 0x80, 0x49, 0xA4, 0x52, 0x52, 0x00, 0x65, 0x60,
};

const GFXglyph RobotoCondensed_MediumItalic11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 3, 8, 3, 0, -8 },
  { 4, 3, 3, 3, 1, -8 },
  { 6, 6, 8, 6, 0, -8 },
  { 12, 5, 10, 5, 0, -9 },
  { 19, 5, 8, 7, 1, -8 },
  { 24, 6, 8, 6, 0, -8 },
  { 30, 1, 3, 2, 1, -8 },
  { 31, 3, 11, 3, 1, -9 },
  { 36, 4, 12, 3, -1, -9 },
  { 42, 4, 5, 5, 1, -8 },
  { 45, 5, 5, 5, 0, -6 },
  { 49, 2, 3, 2, -1, -1 },
  { 50, 3, 1, 3, 0, -4 },
  { 51, 2, 1, 3, 0, -1 },
  { 52, 5, 9, 4, -1, -8 },
  { 58, 5, 8, 5, 0, -8 },
  { 63, 3, 8, 5, 1, -8 },
  { 66, 5, 8, 5, 0, -8 },
  { 71, 5, 8, 5, 0, -8 },
  { 76, 5, 8, 5, 0, -8 },
  { 81, 5, 8, 5, 0, -8 },
  { 86, 4, 8, 5, 1, -8 },
  { 90, 5, 8, 5, 1, -8 },
  { 95, 5, 8, 5, 0, -8 },
  { 100, 4, 8, 5, 1, -8 },
  { 104, 3, 6, 3, 0, -6 },
  { 107, 3, 8, 3, -1, -6 },
  { 110, 5, 5, 5, 0, -6 },
  { 114, 5, 3, 5, 0, -5 },
  { 116, 5, 5, 5, 0, -6 },
  { 120, 4, 8, 5, 1, -8 },
  { 124, 8, 10, 8, 0, -8 },
  { 134, 6, 8, 6, 0, -8 },
  { 140, 6, 8, 6, 0, -8 },
  { 146, 6, 8, 6, 0, -8 },
  { 152, 6, 8, 6, 0, -8 },
  { 158, 6, 8, 5, 0, -8 },
  { 164, 6, 8, 5, 0, -8 },
  { 170, 6, 8, 6, 0, -8 },
  { 176, 7, 8, 7, 0, -8 },
  { 183, 3, 8, 3, 0, -8 },
  { 186, 5, 8, 5, 0, -8 },
  { 191, 7, 8, 6, 0, -8 },
  { 198, 4, 8, 5, 0, -8 },
  { 202, 8, 8, 8, 0, -8 },
  { 210, 7, 8, 7, 0, -8 },
  { 217, 6, 8, 6, 0, -8 },
  { 223, 6, 8, 6, 0, -8 },
  { 229, 6, 9, 6, 0, -8 },
  { 236, 6, 8, 6, 0, -8 },
  { 242, 6, 8, 6, 0, -8 },
  { 248, 5, 8, 6, 1, -8 },
  { 253, 6, 8, 6, 0, -8 },
  { 259, 6, 8, 6, 1, -8 },
  { 265, 8, 8, 8, 1, -8 },
  { 273, 6, 8, 6, 0, -8 },
  { 279, 5, 8, 6, 1, -8 },
  { 284, 6, 8, 6, 0, -8 },
  { 290, 3, 11, 3, 0, -9 },
  { 295, 2, 9, 4, 1, -8 },
  { 298, 4, 11, 3, -1, -9 },
  { 304, 4, 4, 4, 0, -8 },
  { 306, 5, 1, 4, -1, 0 },
  { 307, 2, 2, 3, 1, -9 },
  { 308, 5, 6, 5, 0, -6 },
  { 312, 5, 9, 5, 0, -9 },
  { 318, 5, 6, 5, 0, -6 },
  { 322, 6, 9, 5, 0, -9 },
  { 329, 5, 6, 5, 0, -6 },
  { 333, 4, 9, 3, 0, -9 },
  { 338, 5, 8, 5, 0, -6 },
  { 343, 5, 9, 5, 0, -9 },
  { 349, 3, 8, 3, 0, -8 },
  { 352, 4, 10, 3, -1, -8 },
  { 357, 5, 9, 5, 0, -9 },
  { 363, 3, 9, 3, 0, -9 },
  { 367, 7, 6, 8, 0, -6 },
  { 373, 5, 6, 5, 0, -6 },
  { 377, 5, 6, 5, 0, -6 },
  { 381, 5, 8, 5, 0, -6 },
  { 386, 5, 8, 5, 0, -6 },
  { 391, 4, 6, 3, 0, -6 },
  { 394, 5, 6, 5, 0, -6 },
  { 398, 3, 7, 3, 0, -7 },
  { 401, 5, 6, 5, 0, -6 },
  { 405, 4, 6, 5, 1, -6 },
  { 408, 6, 6, 7, 1, -6 },
  { 413, 5, 6, 5, 0, -6 },
  { 417, 5, 8, 5, 0, -6 },
  { 422, 5, 6, 5, 0, -6 },
  { 426, 4, 11, 3, 0, -9 },
  { 432, 2, 9, 3, 0, -8 },
  { 435, 3, 11, 3, 0, -9 },
  { 440, 6, 2, 6, 0, -4 },
};

const GFXfont RobotoCondensed_MediumItalic11pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_MediumItalic11pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_MediumItalic11pt7bGlyphs,
  0x20, 0x7E, 13
};

#endif // _ROBOTOCONDENSED_MEDIUMITALIC11PT7B_H_
