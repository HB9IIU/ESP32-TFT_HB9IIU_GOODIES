#ifndef _ROBOTOCONDENSED_MEDIUMITALIC34PT7B_H_
#define _ROBOTOCONDENSED_MEDIUMITALIC34PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-MediumItalic.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_MediumItalic34pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1C, 0x1C, 0x3C, 0x3C, 0x3C,
  0x38, 0x38, 0x38, 0x38, 0x78, 0x78, 0x00, 0x00, 0x00, 0x60, 0xF0, 0xF0,
  0xE0, 0x73, 0xB9, 0x99, 0xDC, 0xEE, 0x77, 0x3B, 0x99, 0x8C, 0xC6, 0x00,
  0x00, 0x63, 0x00, 0x73, 0x80, 0x39, 0xC0, 0x18, 0xC0, 0x1C, 0xE0, 0x0E,
  0x70, 0x7F, 0xFE, 0x3F, 0xFF, 0x1F, 0xFF, 0x81, 0x8C, 0x01, 0xCE, 0x00,
  0xE7, 0x00, 0x63, 0x00, 0x73, 0x80, 0x39, 0xC1, 0xFF, 0xFC, 0xFF, 0xFC,
  0x7F, 0xFE, 0x06, 0x38, 0x07, 0x18, 0x03, 0x9C, 0x01, 0x8E, 0x01, 0xC6,
  0x00, 0xE7, 0x00, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x1F,
  0x00, 0xFF, 0x03, 0xFF, 0x0F, 0x9E, 0x1E, 0x1E, 0x3C, 0x3C, 0x70, 0x78,
  0xE0, 0xF1, 0xE0, 0x03, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x03,
  0xE0, 0x01, 0xE0, 0x03, 0xCF, 0x03, 0x9E, 0x07, 0x3C, 0x1E, 0x78, 0x3C,
  0x7D, 0xF0, 0xFF, 0xE0, 0xFF, 0x80, 0x7C, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x00, 0x1E, 0x00, 0x3F, 0x00, 0x77, 0x00, 0xE3, 0x86, 0xE3, 0x8E,
  0xE3, 0x9C, 0xE3, 0x98, 0xE3, 0x38, 0xF7, 0x70, 0x7E, 0xE0, 0x3C, 0xC0,
  0x01, 0xC0, 0x03, 0x80, 0x03, 0x3C, 0x07, 0x7E, 0x0E, 0xEE, 0x1D, 0xC7,
  0x19, 0xC7, 0x39, 0xC7, 0x71, 0xC7, 0x61, 0xC6, 0x21, 0xEE, 0x00, 0xFC,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0xF8, 0x0F, 0xF8, 0x0F, 0x3C, 0x0E, 0x3C,
  0x1E, 0x3C, 0x1E, 0x3C, 0x1E, 0x78, 0x0E, 0xF0, 0x0F, 0xF0, 0x0F, 0xC0,
  0x0F, 0x80, 0x1F, 0x87, 0x3F, 0xCF, 0x7B, 0xCF, 0xF1, 0xEE, 0xF1, 0xFE,
  0xF0, 0xFC, 0xF0, 0xFC, 0xF0, 0x78, 0xF8, 0xFC, 0x7F, 0xFC, 0x3F, 0xDE,
  0x1F, 0x1E, 0x39, 0xDC, 0xE7, 0x39, 0xCC, 0xE0, 0x00, 0x40, 0x70, 0x3C,
  0x1E, 0x07, 0x03, 0x81, 0xE0, 0x70, 0x3C, 0x0E, 0x03, 0x81, 0xE0, 0x70,
  0x1C, 0x07, 0x03, 0xC0, 0xF0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x18, 0x07, 0x01, 0xC0,
  0x38, 0x06, 0x00, 0x80, 0x02, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x18, 0x03,
  0x80, 0x70, 0x0E, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x80, 0xF0,
  0x1C, 0x07, 0x80, 0xE0, 0x1C, 0x07, 0x80, 0xE0, 0x3C, 0x0F, 0x01, 0xC0,
  0x70, 0x0C, 0x01, 0x00, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x63, 0x1B, 0xEF, 0xEF, 0xFF, 0xC3, 0xF0, 0x0F, 0x00, 0x7E, 0x03, 0x9C,
  0x1C, 0x70, 0x70, 0xE0, 0x82, 0x00, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x1F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC1, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0x1E, 0x38, 0x71, 0xE3, 0xC7, 0x1E, 0x78, 0x60, 0x7F, 0xFF,
  0xFF, 0x0F, 0xFF, 0x70, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0,
  0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x07,
  0x00, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x38,
  0x00, 0x70, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x3F, 0xC1, 0xFF, 0x8F, 0x9E,
  0x3C, 0x39, 0xE0, 0xF7, 0x83, 0xDE, 0x0F, 0x70, 0x3F, 0xC0, 0xFF, 0x03,
  0xBC, 0x1E, 0xF0, 0x7B, 0xC1, 0xEE, 0x07, 0xB8, 0x1E, 0xE0, 0x73, 0x83,
  0xCE, 0x0F, 0x38, 0x38, 0xF3, 0xE3, 0xFF, 0x07, 0xF8, 0x0F, 0xC0, 0x00,
  0x83, 0xC7, 0xFF, 0xFF, 0xFF, 0x3A, 0x1C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xC0, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x70, 0x01, 0xF8, 0x03, 0xFC, 0x07, 0xFE, 0x0F, 0x1E, 0x1E, 0x0F,
  0x1E, 0x0F, 0x1E, 0x0F, 0x1C, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x7C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7F, 0xFC, 0xFF, 0xFC,
  0xFF, 0xFC, 0x03, 0xE0, 0x1F, 0xF0, 0x3F, 0xF0, 0xF9, 0xE3, 0xC1, 0xC7,
  0x83, 0xCF, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x01, 0xF0, 0x1F, 0xC0, 0x3F,
  0x00, 0x7F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x79, 0xE0, 0xF3,
  0xC1, 0xE7, 0x87, 0x8F, 0x9F, 0x0F, 0xFC, 0x0F, 0xF0, 0x0F, 0xC0, 0x00,
  0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x01,
  0xFC, 0x01, 0xDC, 0x03, 0xBC, 0x07, 0xBC, 0x07, 0x3C, 0x0E, 0x3C, 0x1E,
  0x38, 0x1C, 0x78, 0x3C, 0x78, 0x78, 0x78, 0x7F, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFE, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x07,
  0xFF, 0x0F, 0xFE, 0x0F, 0xFE, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1C, 0x00, 0x1D, 0xE0, 0x3F, 0xF0, 0x3F, 0xF8, 0x3C, 0xF8, 0x08,
  0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0xF0, 0x3C, 0xF0,
  0x78, 0x78, 0x78, 0x78, 0xF0, 0x3F, 0xF0, 0x3F, 0xE0, 0x0F, 0x80, 0x00,
  0xF0, 0x1F, 0x81, 0xFC, 0x1F, 0x81, 0xF0, 0x1F, 0x00, 0xF0, 0x0F, 0x00,
  0x7B, 0xC3, 0xFF, 0x3F, 0xFD, 0xF9, 0xEF, 0x07, 0xF8, 0x3F, 0xC1, 0xFC,
  0x0F, 0xE0, 0x7F, 0x03, 0xFC, 0x3D, 0xE1, 0xEF, 0x9E, 0x3F, 0xF0, 0xFF,
  0x03, 0xE0, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xF8, 0x00, 0xE0, 0x03, 0xC0,
  0x07, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1E,
  0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00,
  0x78, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x01,
  0xF0, 0x0F, 0xF0, 0x3F, 0xF0, 0xF9, 0xE1, 0xE1, 0xE3, 0xC3, 0xC7, 0x07,
  0x8E, 0x0F, 0x1E, 0x3C, 0x3C, 0xF8, 0x3F, 0xE0, 0x7F, 0x03, 0xFF, 0x0F,
  0x8E, 0x1E, 0x1E, 0x78, 0x3C, 0xF0, 0x79, 0xE0, 0xF3, 0xC1, 0xE7, 0x87,
  0xC7, 0x9F, 0x0F, 0xFC, 0x0F, 0xF0, 0x0F, 0xC0, 0x07, 0xC0, 0x7F, 0x87,
  0xFC, 0x7C, 0xF3, 0x87, 0xBC, 0x1D, 0xE0, 0xEE, 0x07, 0xF0, 0x3F, 0x81,
  0xFC, 0x1E, 0xF0, 0xF7, 0x8F, 0xBF, 0xFC, 0xFF, 0xC3, 0xDE, 0x00, 0xF0,
  0x07, 0x00, 0x78, 0x07, 0x81, 0xF8, 0x3F, 0x81, 0xF8, 0x0F, 0x00, 0x08,
  0x38, 0xF9, 0xF1, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x78, 0xF1, 0xE1, 0x80, 0x00, 0x03, 0xC1, 0xE0, 0xF0, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x1E, 0x0F,
  0x07, 0x07, 0x83, 0xC3, 0xC1, 0xC0, 0x40, 0x00, 0x08, 0x01, 0xC0, 0x3E,
  0x07, 0xE1, 0xFE, 0x3F, 0xC3, 0xF8, 0x1E, 0x00, 0xF8, 0x03, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3E, 0x00, 0x70, 0x01, 0x00, 0x7F, 0xFB, 0xFF, 0xDF,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0xFF, 0xF7, 0xFF,
  0x80, 0x20, 0x01, 0xC0, 0x0F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x03,
  0xE0, 0x0F, 0x03, 0xF8, 0x7F, 0x8F, 0xE1, 0xFC, 0x0F, 0x80, 0x70, 0x02,
  0x00, 0x00, 0x1F, 0x83, 0xFC, 0x7F, 0xEF, 0x9E, 0xF1, 0xEE, 0x0E, 0x00,
  0xE0, 0x1E, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF8, 0x1F, 0x01, 0xE0, 0x3C,
  0x03, 0x80, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x0F, 0x00, 0xF0,
  0x07, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xC0, 0x07, 0xE7, 0xC0, 0x1E,
  0x01, 0xC0, 0x78, 0x01, 0xC0, 0xE0, 0x01, 0x83, 0x80, 0x03, 0x0E, 0x0F,
  0x87, 0x1C, 0x3F, 0xC6, 0x70, 0xFF, 0x0C, 0xE3, 0x8E, 0x1B, 0x87, 0x1C,
  0x37, 0x1C, 0x38, 0x6E, 0x38, 0x61, 0xD8, 0xE1, 0xC3, 0xF1, 0xC3, 0x87,
  0xE3, 0x87, 0x0D, 0xC7, 0x0E, 0x1B, 0x8E, 0x38, 0x77, 0x1C, 0x70, 0xCC,
  0x39, 0xE3, 0x98, 0x7F, 0xEE, 0x38, 0xFD, 0xF8, 0x70, 0xF1, 0xE0, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0,
  0x0F, 0xF0, 0x03, 0xBC, 0x01, 0xE7, 0x00, 0x71, 0xC0, 0x3C, 0x70, 0x0F,
  0x1C, 0x07, 0x87, 0x81, 0xE1, 0xE0, 0xF0, 0x78, 0x3F, 0xFE, 0x1F, 0xFF,
  0x87, 0xFF, 0xE3, 0xC0, 0x38, 0xF0, 0x0F, 0x7C, 0x03, 0xDE, 0x00, 0xFF,
  0x80, 0x3F, 0xC0, 0x0F, 0x07, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x3C,
  0x3E, 0x0F, 0x07, 0x83, 0xC0, 0xF0, 0xE0, 0x3C, 0x78, 0x1E, 0x1E, 0x07,
  0x87, 0x83, 0xC1, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xFE, 0x0F, 0x07, 0xC3,
  0xC0, 0xF0, 0xF0, 0x3C, 0x3C, 0x0F, 0x0F, 0x03, 0xC7, 0x80, 0xF1, 0xE0,
  0x78, 0x78, 0x7E, 0x1F, 0xFF, 0x07, 0xFF, 0x81, 0xFF, 0x80, 0x01, 0xF8,
  0x03, 0xFE, 0x03, 0xFF, 0x83, 0xE3, 0xE3, 0xE0, 0xF1, 0xE0, 0x39, 0xE0,
  0x1E, 0xF0, 0x0F, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x1E, 0x78, 0x0F,
  0x3C, 0x0F, 0x1E, 0x07, 0x8F, 0xCF, 0x83, 0xFF, 0xC0, 0xFF, 0x80, 0x3F,
  0x80, 0x07, 0xF8, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x3C, 0x7E, 0x0F, 0x07,
  0x83, 0xC0, 0xE0, 0xE0, 0x3C, 0x78, 0x0F, 0x1E, 0x03, 0xC7, 0x80, 0xF1,
  0xE0, 0x3C, 0x78, 0x1E, 0x3C, 0x07, 0x8F, 0x01, 0xE3, 0xC0, 0x78, 0xF0,
  0x1E, 0x3C, 0x0F, 0x0F, 0x03, 0xC7, 0x81, 0xF1, 0xE0, 0xF8, 0x78, 0xFC,
  0x1F, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0xC3, 0xFF, 0xE0,
  0xFF, 0xF8, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xFC,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0xFF, 0x07, 0xFF, 0xC1, 0xFF,
  0xF0, 0x07, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE1, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xE0, 0x00, 0x01, 0xF8, 0x03, 0xFE, 0x03, 0xFF, 0x83, 0xE3,
  0xE3, 0xE0, 0xF1, 0xE0, 0x3D, 0xE0, 0x1E, 0xF0, 0x0F, 0x78, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x0F, 0xF7, 0x87, 0xFB, 0xC3, 0xFD,
  0xE0, 0x3C, 0xF0, 0x1E, 0x78, 0x0F, 0x3C, 0x07, 0x9E, 0x03, 0xC7, 0xCF,
  0xE3, 0xFF, 0xE0, 0xFF, 0xE0, 0x1F, 0x80, 0x07, 0x00, 0x78, 0x78, 0x07,
  0x83, 0xC0, 0x3C, 0x1E, 0x01, 0xE0, 0xF0, 0x0F, 0x07, 0x80, 0x78, 0x38,
  0x03, 0x83, 0xC0, 0x3C, 0x1E, 0x01, 0xE0, 0xF0, 0x0F, 0x07, 0xFF, 0xF8,
  0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x1E, 0x01, 0xE0, 0xF0, 0x0F, 0x07, 0x80,
  0x78, 0x3C, 0x03, 0xC1, 0xE0, 0x1E, 0x1E, 0x01, 0xE0, 0xF0, 0x0F, 0x07,
  0x80, 0x78, 0x3C, 0x03, 0xC1, 0xE0, 0x1E, 0x0E, 0x00, 0xF0, 0x0F, 0x0E,
  0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x78,
  0x78, 0x78, 0x78, 0x78, 0x78, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0xF0, 0x78, 0xF0, 0x78,
  0xF0, 0x78, 0x7D, 0xF0, 0x7F, 0xF0, 0x3F, 0xE0, 0x1F, 0x80, 0x07, 0x01,
  0xF0, 0xF0, 0x3E, 0x0F, 0x07, 0xC0, 0xF0, 0x78, 0x0F, 0x0F, 0x80, 0xF1,
  0xF0, 0x0E, 0x3E, 0x01, 0xE7, 0xC0, 0x1E, 0x78, 0x01, 0xEF, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0x78, 0x03,
  0xE7, 0x80, 0x3C, 0x78, 0x03, 0xC3, 0xC0, 0x78, 0x3C, 0x07, 0x83, 0xE0,
  0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1F, 0x07, 0x00, 0xF0, 0x07, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xFF,
  0xF7, 0xFF, 0x9F, 0xFE, 0x07, 0xC0, 0x0F, 0x87, 0xE0, 0x0F, 0xC3, 0xF0,
  0x07, 0xE1, 0xF8, 0x07, 0xF0, 0xFC, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x3F,
  0x01, 0xFC, 0x3F, 0x80, 0xFE, 0x1F, 0xE0, 0xFF, 0x0F, 0x70, 0x77, 0x87,
  0xB8, 0x7B, 0x83, 0x9C, 0x3B, 0xC3, 0xCE, 0x3D, 0xE1, 0xE7, 0x1C, 0xF0,
  0xF3, 0x9E, 0x78, 0x79, 0xCE, 0x3C, 0x3C, 0xE7, 0x3C, 0x1E, 0x3F, 0x1E,
  0x1E, 0x1F, 0x8F, 0x0F, 0x0F, 0x87, 0x87, 0x87, 0xC3, 0xC3, 0xC3, 0xC1,
  0xC1, 0xE1, 0xE1, 0xE0, 0xE0, 0xE0, 0xF0, 0x07, 0x80, 0x70, 0x7C, 0x07,
  0x83, 0xE0, 0x3C, 0x1F, 0x81, 0xE0, 0xFC, 0x0F, 0x07, 0xE0, 0x78, 0x3F,
  0x03, 0x83, 0xDC, 0x3C, 0x1E, 0xE1, 0xE0, 0xF7, 0x0F, 0x07, 0xBC, 0x78,
  0x3C, 0xE3, 0xC3, 0xC7, 0x3C, 0x1E, 0x3D, 0xE0, 0xF0, 0xEF, 0x07, 0x87,
  0x78, 0x3C, 0x3B, 0xC1, 0xE0, 0xFE, 0x1E, 0x07, 0xE0, 0xF0, 0x3F, 0x07,
  0x81, 0xF8, 0x3C, 0x07, 0xC1, 0xE0, 0x3E, 0x0F, 0x01, 0xE0, 0x01, 0xF8,
  0x03, 0xFE, 0x03, 0xFF, 0x83, 0xF7, 0xE3, 0xE0, 0xF1, 0xE0, 0x3D, 0xE0,
  0x1E, 0xF0, 0x0F, 0x78, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0xF7, 0x80, 0x7B, 0xC0, 0x3D, 0xE0, 0x1E, 0xF0, 0x0F, 0x78, 0x0F,
  0x3C, 0x07, 0x9E, 0x07, 0x87, 0xCF, 0xC3, 0xFF, 0xC0, 0xFF, 0xC0, 0x1F,
  0x80, 0x07, 0xFE, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0x87, 0xE0, 0xF0,
  0x3C, 0x1E, 0x07, 0x83, 0x80, 0xF0, 0xF0, 0x1E, 0x1E, 0x03, 0xC3, 0xC0,
  0x78, 0x78, 0x1F, 0x0F, 0x0F, 0xC3, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFE,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0x7E, 0x1F, 0x07, 0x87, 0x80, 0xF3,
  0xC0, 0x3C, 0xF0, 0x0F, 0x3C, 0x03, 0xDE, 0x00, 0xF7, 0x80, 0x3D, 0xE0,
  0x0E, 0x78, 0x07, 0x9E, 0x01, 0xE7, 0x80, 0x79, 0xE0, 0x1E, 0x70, 0x07,
  0x9E, 0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x78, 0x3E, 0x7E, 0x0F, 0xFF, 0x01,
  0xFF, 0x80, 0x1F, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xC0, 0x00,
  0x20, 0x07, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x3C, 0x3E, 0x0F, 0x07,
  0xC3, 0xC0, 0xF0, 0xE0, 0x3C, 0x78, 0x0F, 0x1E, 0x03, 0xC7, 0x81, 0xE1,
  0xE0, 0xF8, 0x78, 0x7C, 0x3F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0x80, 0xF1,
  0xE0, 0x3C, 0x3C, 0x0F, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF8, 0x78, 0x1E,
  0x1E, 0x07, 0x87, 0x81, 0xE1, 0xE0, 0x7C, 0x01, 0xF8, 0x03, 0xFE, 0x03,
  0xFF, 0x83, 0xF3, 0xE1, 0xE0, 0xF1, 0xF0, 0x78, 0xF0, 0x1E, 0x78, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x07,
  0xE0, 0x01, 0xF0, 0x00, 0x78, 0xF0, 0x1E, 0x78, 0x0F, 0x3C, 0x0F, 0x1E,
  0x07, 0x87, 0xCF, 0xC3, 0xFF, 0xC0, 0xFF, 0xC0, 0x1F, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x03,
  0xC7, 0x80, 0xF1, 0xE0, 0x3C, 0x78, 0x0F, 0x1E, 0x03, 0xCF, 0x01, 0xE3,
  0xC0, 0x78, 0xF0, 0x1E, 0x3C, 0x07, 0x8F, 0x01, 0xE3, 0x80, 0x79, 0xE0,
  0x3C, 0x78, 0x0F, 0x1E, 0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x3C, 0xF0, 0x0E,
  0x3C, 0x07, 0x8F, 0x01, 0xE1, 0xE0, 0xF8, 0x7C, 0x7C, 0x1F, 0xFE, 0x03,
  0xFF, 0x00, 0x3F, 0x00, 0xF0, 0x07, 0xBC, 0x01, 0xEF, 0x00, 0xFB, 0xC0,
  0x3C, 0xF0, 0x1F, 0x1C, 0x07, 0x87, 0x83, 0xE1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x1E, 0x07, 0x87, 0x81, 0xE3, 0xC0, 0x78, 0xF0, 0x0E, 0x3C, 0x03,
  0x9E, 0x00, 0xE7, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0xF0, 0x38,
  0x1F, 0xE0, 0x70, 0x3F, 0xC1, 0xE0, 0x7F, 0x83, 0xE1, 0xEF, 0x0F, 0xC3,
  0xDE, 0x1F, 0x87, 0xBC, 0x3F, 0x1E, 0x78, 0xFE, 0x3C, 0xF1, 0xDC, 0x79,
  0xE3, 0xB9, 0xE3, 0xCF, 0x73, 0xC7, 0x9C, 0xE7, 0x07, 0x39, 0xDE, 0x0E,
  0xE3, 0xBC, 0x1D, 0xC7, 0x70, 0x3B, 0x8E, 0xE0, 0x7E, 0x1F, 0xC0, 0xFC,
  0x3F, 0x01, 0xF8, 0x7E, 0x03, 0xE0, 0xFC, 0x07, 0xC1, 0xF0, 0x0F, 0x83,
  0xE0, 0x1E, 0x07, 0xC0, 0x3C, 0x0F, 0x00, 0x0F, 0x80, 0xF0, 0x3C, 0x0F,
  0x81, 0xE0, 0x78, 0x0F, 0x87, 0xC0, 0x3C, 0x7C, 0x01, 0xE3, 0xC0, 0x0F,
  0x3E, 0x00, 0x3D, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x07, 0xBC, 0x00, 0x7C, 0xF0, 0x03, 0xC7, 0x80, 0x3E, 0x3C, 0x03,
  0xE0, 0xF0, 0x1E, 0x07, 0x81, 0xF0, 0x3C, 0x1F, 0x01, 0xF0, 0xF0, 0x0F,
  0xF8, 0x0F, 0x9E, 0x07, 0x8F, 0x07, 0xC7, 0x83, 0xC3, 0xC3, 0xE0, 0xE1,
  0xE0, 0x71, 0xE0, 0x3C, 0xF0, 0x1E, 0xF0, 0x07, 0x78, 0x03, 0xF8, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x0F, 0xFF, 0xC3, 0xFF, 0xF1, 0xFF, 0xFC, 0x00, 0x1E, 0x00, 0x0F,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00,
  0x3F, 0xFF, 0x8F, 0xFF, 0xE3, 0xFF, 0xF8, 0x07, 0xE0, 0xF8, 0x3F, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x38, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3F, 0x07, 0xE0, 0xF8, 0x00, 0xF1, 0xE3, 0xC7, 0x87, 0x0E, 0x1E, 0x3C,
  0x78, 0xF1, 0xE1, 0xC3, 0x87, 0x8F, 0x1E, 0x3C, 0x78, 0x70, 0xE1, 0xE3,
  0xC7, 0x8F, 0x1E, 0x1C, 0x07, 0xE0, 0xFC, 0x1F, 0x80, 0xF0, 0x1E, 0x03,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x70, 0x0E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x1F, 0x07, 0xE0,
  0xFC, 0x00, 0x03, 0x80, 0x70, 0x1E, 0x03, 0xE0, 0xFC, 0x1F, 0x87, 0x70,
  0xEE, 0x38, 0xC7, 0x1D, 0xC3, 0xF8, 0x70, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE,
  0x78, 0xF0, 0xF0, 0xE0, 0xE0, 0x07, 0xE0, 0x7F, 0x87, 0xFE, 0x78, 0xF3,
  0x87, 0xBC, 0x3C, 0x01, 0xE1, 0xFF, 0x3F, 0xFB, 0xFF, 0xBE, 0x1D, 0xE1,
  0xEF, 0x0F, 0x78, 0x7B, 0xC7, 0xDF, 0xFE, 0x7F, 0xF1, 0xE7, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0xF8, 0x3F, 0xF8, 0x7F, 0xF0, 0xF9, 0xF3, 0xE1, 0xE7,
  0x83, 0xCF, 0x07, 0x9E, 0x0F, 0x3C, 0x1E, 0x70, 0x3D, 0xE0, 0x7B, 0xC0,
  0xE7, 0x83, 0xCF, 0x07, 0x9F, 0x1E, 0x3F, 0xFC, 0xF7, 0xF1, 0xE7, 0xC0,
  0x07, 0xE0, 0x7F, 0xC3, 0xFF, 0x8F, 0x1E, 0x78, 0x39, 0xE0, 0xE7, 0x03,
  0xBC, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x73, 0xC3,
  0xCF, 0x9F, 0x1F, 0xF8, 0x3F, 0xC0, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x0F, 0x9E, 0x1F, 0xDE, 0x3F, 0xFC, 0x3E, 0x7C, 0x78, 0x3C, 0x78, 0x3C,
  0xF0, 0x3C, 0xF0, 0x38, 0xF0, 0x38, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0x78,
  0xF0, 0x78, 0xF0, 0x70, 0xF9, 0xF0, 0x7F, 0xF0, 0x7F, 0xF0, 0x3E, 0xF0,
  0x07, 0xE0, 0x3F, 0xC1, 0xFF, 0x8F, 0x9E, 0x78, 0x39, 0xE0, 0xF7, 0x03,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xEF, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x87, 0xCF, 0x1F, 0xFC, 0x3F, 0xE0, 0x7E, 0x00, 0x01, 0xF0, 0x3F, 0x07,
  0xF0, 0xFD, 0x0F, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x7F, 0xC7, 0xFC, 0x7F,
  0xC1, 0xE0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x38,
  0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x70, 0x0F, 0x00, 0x03,
  0xCF, 0x0F, 0xEF, 0x1F, 0xFF, 0x1F, 0x3E, 0x3C, 0x1E, 0x3C, 0x1E, 0x38,
  0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1C, 0x78, 0x3C, 0x78, 0x3C, 0x78,
  0x3C, 0x78, 0x3C, 0x7C, 0xFC, 0x3F, 0xF8, 0x3F, 0xF8, 0x0F, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x40, 0xF0, 0x71, 0xF0, 0xFF, 0xE0, 0x7F, 0xC0, 0x1F,
  0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0xF0, 0x3F, 0xF8, 0x7F, 0xF0, 0xF9, 0xE3,
  0xC1, 0xE7, 0x83, 0xCF, 0x07, 0x1E, 0x0E, 0x3C, 0x3C, 0x70, 0x79, 0xE0,
  0xF3, 0xC1, 0xE7, 0x83, 0x8F, 0x07, 0x1C, 0x1E, 0x78, 0x3C, 0xF0, 0x79,
  0xE0, 0xF0, 0x07, 0x0F, 0x0F, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x1E, 0x1E,
  0x1E, 0x1C, 0x1C, 0x3C, 0x3C, 0x3C, 0x3C, 0x38, 0x78, 0x78, 0x78, 0x78,
  0x78, 0x70, 0xF0, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x70,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x03, 0xC1, 0xF8, 0x3E, 0x07, 0x80, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x1F, 0x1E, 0x3E, 0x1E, 0x7C, 0x1C, 0x78, 0x3C,
  0xF0, 0x3D, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x7F,
  0xE0, 0x7D, 0xE0, 0x79, 0xE0, 0x78, 0xF0, 0x78, 0xF0, 0x70, 0xF0, 0xF0,
  0x78, 0xF0, 0x78, 0x07, 0x03, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x38, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0E,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x70, 0x78, 0x00, 0x1E, 0xF8, 0xF8,
  0x3F, 0xFB, 0xF8, 0x7F, 0xFF, 0xF8, 0xF9, 0xF9, 0xF3, 0xC1, 0xE1, 0xE7,
  0x83, 0xC3, 0xCF, 0x07, 0x07, 0x9E, 0x1E, 0x0F, 0x3C, 0x3C, 0x1E, 0x70,
  0x78, 0x39, 0xE0, 0xF0, 0xF3, 0xC1, 0xE1, 0xE7, 0x83, 0x83, 0xCF, 0x0F,
  0x07, 0x9E, 0x1E, 0x0F, 0x38, 0x3C, 0x1C, 0xF0, 0x78, 0x79, 0xE0, 0xF0,
  0xF0, 0x1E, 0xF8, 0x3F, 0xF8, 0x7F, 0xF0, 0xF9, 0xE3, 0xE1, 0xE7, 0x83,
  0xCF, 0x07, 0x1E, 0x0E, 0x3C, 0x3C, 0x70, 0x79, 0xE0, 0xF3, 0xC1, 0xE7,
  0x83, 0x8F, 0x07, 0x1E, 0x1E, 0x38, 0x3C, 0xF0, 0x79, 0xE0, 0xF0, 0x07,
  0xE0, 0x3F, 0xC1, 0xFF, 0x8F, 0x9F, 0x78, 0x3D, 0xE0, 0xF7, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x7B, 0xC1, 0xE7,
  0x8F, 0x1F, 0xFC, 0x3F, 0xC0, 0x7E, 0x00, 0x0F, 0x7C, 0x0F, 0xFE, 0x0F,
  0xFE, 0x0F, 0x9F, 0x1E, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x1E,
  0x0F, 0x1C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0E, 0x3C, 0x1E, 0x3C, 0x1E, 0x3E,
  0x3C, 0x3F, 0xFC, 0x7B, 0xF8, 0x79, 0xF0, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x0F, 0x9E, 0x3F,
  0xBC, 0xFF, 0xF1, 0xF3, 0xE7, 0x83, 0xCF, 0x07, 0xBC, 0x0F, 0x78, 0x1E,
  0xF0, 0x39, 0xE0, 0xF3, 0xC1, 0xE7, 0x83, 0xCF, 0x07, 0x9E, 0x0E, 0x3E,
  0x7C, 0x3F, 0xF8, 0x7F, 0xF0, 0x7D, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x1E, 0xE3, 0xFC, 0x7F,
  0x8F, 0xF3, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0xF0, 0x1E, 0x00, 0x03, 0xE0, 0x3F,
  0xE1, 0xFF, 0x87, 0x8F, 0x3C, 0x3C, 0xF0, 0xF3, 0xE0, 0x07, 0xC0, 0x0F,
  0xC0, 0x1F, 0xC0, 0x1F, 0x00, 0x3E, 0xF0, 0x79, 0xC1, 0xE7, 0x8F, 0x1F,
  0xFC, 0x3F, 0xE0, 0x3E, 0x00, 0x0F, 0x07, 0x07, 0x83, 0xC7, 0xFF, 0xFF,
  0xFE, 0x38, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0x81, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0xC7, 0xE1, 0xE0, 0x3C, 0x1E, 0x78, 0x38, 0xF0, 0xF1,
  0xC1, 0xE7, 0x83, 0xCF, 0x07, 0x9E, 0x0F, 0x3C, 0x1C, 0x78, 0x78, 0xE0,
  0xF3, 0xC1, 0xE7, 0x83, 0xCF, 0x07, 0x1E, 0x1E, 0x3E, 0x7C, 0x3F, 0xF8,
  0x7F, 0xF0, 0x7D, 0xE0, 0xF0, 0x7F, 0x83, 0xFC, 0x3D, 0xE1, 0xEF, 0x1E,
  0x38, 0xF1, 0xC7, 0x0E, 0x78, 0x73, 0xC3, 0x9C, 0x1D, 0xE0, 0xEE, 0x07,
  0xF0, 0x3F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x00, 0xF0, 0xE0,
  0xFF, 0x0E, 0x0E, 0xF1, 0xE1, 0xEF, 0x1F, 0x1E, 0xF1, 0xF1, 0xCF, 0x3F,
  0x3C, 0xF3, 0xF3, 0x8F, 0x77, 0x78, 0xF7, 0x77, 0x87, 0x77, 0x70, 0x7E,
  0x7F, 0x07, 0xE7, 0xE0, 0x7C, 0x7E, 0x07, 0xC7, 0xE0, 0x78, 0x7C, 0x07,
  0x83, 0xC0, 0x78, 0x38, 0x07, 0x03, 0x80, 0x1E, 0x0F, 0x0F, 0x1E, 0x0F,
  0x1E, 0x0F, 0x3C, 0x07, 0x78, 0x07, 0xF8, 0x07, 0xF0, 0x03, 0xE0, 0x03,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x1E, 0xF0, 0x3C,
  0x70, 0x3C, 0x78, 0x78, 0x78, 0xF8, 0x78, 0x1E, 0x0F, 0x1E, 0x1F, 0x1E,
  0x1E, 0x1E, 0x1E, 0x1E, 0x3C, 0x1E, 0x3C, 0x0E, 0x78, 0x0E, 0x78, 0x0E,
  0x70, 0x0E, 0xF0, 0x0E, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E,
  0x00, 0x3E, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x1F, 0xFE, 0x3F,
  0xF8, 0xFF, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1E,
  0x00, 0x7F, 0xF8, 0xFF, 0xF1, 0xFF, 0xE0, 0x00, 0x40, 0x70, 0x3C, 0x1E,
  0x07, 0x03, 0xC0, 0xF0, 0x38, 0x0E, 0x03, 0x81, 0xE0, 0x78, 0x1E, 0x07,
  0x03, 0xC3, 0xE0, 0xF0, 0x3C, 0x07, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x81,
  0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x0E, 0x03, 0xC0, 0x70, 0x08,
  0x00, 0x0E, 0x18, 0x30, 0xE1, 0xC3, 0x87, 0x0E, 0x18, 0x70, 0xE1, 0xC3,
  0x87, 0x0C, 0x18, 0x70, 0xE1, 0xC3, 0x86, 0x0C, 0x38, 0x70, 0xE1, 0xC3,
  0x06, 0x00, 0x04, 0x03, 0x80, 0xF0, 0x1C, 0x07, 0x81, 0xE0, 0x78, 0x1E,
  0x07, 0x81, 0xE0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x78, 0x0F, 0x01, 0xC1,
  0xF0, 0xF0, 0x38, 0x1E, 0x07, 0x81, 0xE0, 0x70, 0x1C, 0x07, 0x03, 0xC0,
  0xF0, 0x38, 0x1E, 0x0F, 0x03, 0x80, 0x80, 0x00, 0x1E, 0x00, 0x3F, 0x83,
  0x7F, 0xC7, 0x7B, 0xEF, 0x71, 0xFE, 0xE0, 0xFE, 0x00, 0x78,
};

const GFXglyph RobotoCondensed_MediumItalic34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 8, 24, 8, 1, -24 },
  { 25, 9, 9, 11, 3, -26 },
  { 36, 17, 24, 18, 1, -24 },
  { 87, 15, 31, 17, 1, -28 },
  { 146, 16, 24, 21, 3, -24 },
  { 194, 16, 24, 19, 1, -24 },
  { 242, 5, 9, 6, 2, -26 },
  { 248, 10, 35, 11, 2, -27 },
  { 292, 11, 35, 11, -2, -27 },
  { 341, 14, 14, 15, 2, -24 },
  { 366, 14, 18, 16, 1, -21 },
  { 398, 7, 9, 7, -2, -4 },
  { 406, 8, 3, 10, 1, -12 },
  { 409, 4, 5, 9, 1, -5 },
  { 412, 15, 26, 12, -2, -24 },
  { 461, 14, 24, 17, 2, -24 },
  { 503, 9, 24, 17, 4, -24 },
  { 530, 16, 24, 17, 0, -24 },
  { 578, 15, 24, 17, 1, -24 },
  { 623, 16, 24, 17, 0, -24 },
  { 671, 16, 24, 17, 1, -24 },
  { 719, 13, 24, 17, 2, -24 },
  { 758, 15, 24, 17, 2, -24 },
  { 803, 15, 24, 17, 1, -24 },
  { 848, 13, 24, 17, 2, -24 },
  { 887, 7, 19, 9, 1, -19 },
  { 904, 9, 24, 8, -2, -19 },
  { 931, 13, 15, 15, 1, -18 },
  { 956, 13, 10, 16, 2, -16 },
  { 973, 13, 15, 15, 1, -18 },
  { 998, 12, 24, 14, 3, -24 },
  { 1034, 23, 32, 25, 1, -24 },
  { 1126, 18, 24, 19, -1, -24 },
  { 1180, 18, 24, 18, 0, -24 },
  { 1234, 17, 24, 19, 2, -24 },
  { 1285, 18, 24, 19, 0, -24 },
  { 1339, 18, 24, 16, 0, -24 },
  { 1393, 17, 24, 16, 0, -24 },
  { 1444, 17, 24, 19, 2, -24 },
  { 1495, 21, 24, 20, 0, -24 },
  { 1558, 8, 24, 9, 1, -24 },
  { 1582, 16, 24, 16, 0, -24 },
  { 1630, 20, 24, 18, 0, -24 },
  { 1690, 14, 24, 16, 0, -24 },
  { 1732, 25, 24, 25, 0, -24 },
  { 1807, 21, 24, 20, 0, -24 },
  { 1870, 17, 24, 20, 2, -24 },
  { 1921, 19, 24, 19, 0, -24 },
  { 1978, 18, 28, 20, 1, -24 },
  { 2041, 18, 24, 18, 0, -24 },
  { 2095, 17, 24, 17, 1, -24 },
  { 2146, 16, 24, 18, 3, -24 },
  { 2194, 18, 24, 19, 1, -24 },
  { 2248, 18, 24, 19, 3, -24 },
  { 2302, 23, 24, 25, 3, -24 },
  { 2371, 21, 24, 18, -1, -24 },
  { 2434, 17, 24, 18, 3, -24 },
  { 2485, 18, 24, 17, 0, -24 },
  { 2539, 11, 33, 9, 0, -28 },
  { 2585, 7, 26, 12, 3, -24 },
  { 2608, 11, 33, 9, -2, -28 },
  { 2654, 11, 12, 13, 1, -24 },
  { 2671, 13, 3, 13, -2, 0 },
  { 2676, 7, 5, 11, 3, -25 },
  { 2681, 13, 18, 16, 1, -18 },
  { 2711, 15, 26, 16, 0, -26 },
  { 2760, 14, 18, 15, 1, -18 },
  { 2792, 16, 26, 16, 1, -26 },
  { 2844, 14, 18, 16, 1, -18 },
  { 2876, 12, 26, 11, 1, -26 },
  { 2915, 16, 25, 16, 0, -18 },
  { 2965, 15, 26, 16, 0, -26 },
  { 3014, 8, 25, 8, 0, -25 },
  { 3039, 11, 32, 8, -3, -25 },
  { 3083, 16, 26, 15, 0, -26 },
  { 3135, 9, 26, 8, 0, -26 },
  { 3165, 23, 18, 25, 0, -18 },
  { 3217, 15, 18, 16, 0, -18 },
  { 3251, 14, 18, 16, 1, -18 },
  { 3283, 16, 25, 16, -1, -18 },
  { 3333, 15, 25, 16, 1, -18 },
  { 3380, 11, 18, 11, 0, -18 },
  { 3405, 14, 18, 15, 0, -18 },
  { 3437, 9, 22, 10, 1, -22 },
  { 3462, 15, 18, 16, 1, -18 },
  { 3496, 13, 18, 14, 2, -18 },
  { 3526, 20, 18, 21, 2, -18 },
  { 3571, 16, 18, 15, -1, -18 },
  { 3607, 16, 25, 14, -1, -18 },
  { 3657, 15, 18, 15, 0, -18 },
  { 3691, 10, 33, 10, 1, -27 },
  { 3733, 7, 28, 8, 1, -24 },
  { 3758, 10, 33, 10, -1, -27 },
  { 3800, 16, 7, 19, 1, -13 },
};

const GFXfont RobotoCondensed_MediumItalic34pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_MediumItalic34pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_MediumItalic34pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _ROBOTOCONDENSED_MEDIUMITALIC34PT7B_H_
