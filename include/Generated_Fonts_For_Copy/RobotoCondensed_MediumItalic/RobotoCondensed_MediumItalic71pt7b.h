#ifndef _ROBOTOCONDENSED_MEDIUMITALIC71PT7B_H_
#define _ROBOTOCONDENSED_MEDIUMITALIC71PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-MediumItalic.ttf
// Size: 71pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_MediumItalic71pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x01,
  0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x03,
  0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF8, 0x07,
  0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F,
  0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0x7E, 0x00, 0x38, 0x00, 0x1F, 0x87, 0xE3, 0xF0, 0xFC,
  0x7E, 0x1F, 0x8F, 0xC3, 0xF1, 0xF8, 0x7E, 0x7E, 0x0F, 0x8F, 0xC3, 0xF1,
  0xF8, 0x7E, 0x3F, 0x0F, 0xC7, 0xC1, 0xF0, 0xF8, 0x3E, 0x3F, 0x07, 0xC7,
  0xE1, 0xF8, 0xF8, 0x3E, 0x1F, 0x07, 0xC3, 0xE0, 0xF8, 0x7C, 0x1F, 0x0F,
  0x03, 0xC0, 0x00, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x7C, 0x00,
  0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x00, 0x7C, 0x0F,
  0x80, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x0F,
  0x81, 0xF0, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0x01, 0xF0, 0x3E, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x7E,
  0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0x83, 0xF0,
  0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x7E, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00,
  0x3E, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x7C, 0x0F, 0x80,
  0x00, 0x07, 0xC1, 0xF8, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xFF, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xF0, 0x7E, 0x00,
  0x00, 0x3E, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0x7E, 0x0F,
  0xC0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0x01, 0xF8, 0x3F, 0x00, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x01, 0xF0, 0x3E,
  0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xE1, 0xFF, 0x00, 0xFF, 0x81,
  0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x07, 0xF8, 0x03, 0xFC, 0x0F, 0xF0, 0x07,
  0xF8, 0x1F, 0xE0, 0x0F, 0xF0, 0x3F, 0x80, 0x1F, 0xE0, 0x7F, 0x00, 0x3F,
  0xC0, 0xFE, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC7, 0xF8, 0x00,
  0x7F, 0x8F, 0xF0, 0x00, 0xFF, 0x1F, 0xE0, 0x01, 0xFE, 0x1F, 0xC0, 0x03,
  0xFC, 0x3F, 0xC0, 0x0F, 0xF0, 0x7F, 0x80, 0x1F, 0xE0, 0xFF, 0x00, 0x7F,
  0xC1, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x8F, 0xFE, 0x03, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01,
  0xFC, 0x7E, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x20, 0xFC, 0x0F, 0x80, 0x38,
  0x7E, 0x07, 0xE0, 0x3F, 0x3E, 0x03, 0xF0, 0x3F, 0x1F, 0x01, 0xF8, 0x1F,
  0x8F, 0x80, 0xFC, 0x1F, 0x87, 0xC0, 0x7C, 0x1F, 0x83, 0xE0, 0x3E, 0x0F,
  0x83, 0xF0, 0x1F, 0x0F, 0xC0, 0xF8, 0x0F, 0x8F, 0xC0, 0x7C, 0x0F, 0xC7,
  0xC0, 0x3E, 0x07, 0xC7, 0xE0, 0x1F, 0x87, 0xE7, 0xE0, 0x0F, 0xFF, 0xF3,
  0xE0, 0x03, 0xFF, 0xF3, 0xF0, 0x00, 0xFF, 0xF3, 0xF0, 0x00, 0x3F, 0xF3,
  0xF0, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x7F, 0x80, 0x00, 0x7C, 0x7F, 0xE0, 0x00, 0x7E, 0x7F, 0xF8, 0x00,
  0x7E, 0x7F, 0xFE, 0x00, 0x3E, 0x7F, 0xFF, 0x00, 0x3F, 0x3F, 0x0F, 0xC0,
  0x3F, 0x3F, 0x07, 0xE0, 0x3F, 0x1F, 0x81, 0xF0, 0x1F, 0x8F, 0x80, 0xF8,
  0x1F, 0x8F, 0xC0, 0x7C, 0x1F, 0x87, 0xE0, 0x3E, 0x0F, 0x83, 0xF0, 0x1F,
  0x0F, 0xC1, 0xF8, 0x0F, 0x8F, 0xC0, 0xFC, 0x0F, 0xC7, 0xC0, 0x7E, 0x07,
  0xE7, 0xE0, 0x3F, 0x03, 0xF7, 0xE0, 0x1F, 0x81, 0xF0, 0xE0, 0x07, 0xC1,
  0xF8, 0x30, 0x03, 0xF1, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFE, 0x1F,
  0xE0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x03, 0xFC,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x01,
  0xFC, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x07, 0xF0, 0x3F, 0xC0,
  0x00, 0xFE, 0x07, 0xF8, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x03, 0xFC, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xFC, 0x07, 0xF0, 0x7F, 0xFF, 0x80, 0xFC, 0x1F, 0xFF, 0xF8,
  0x3F, 0x83, 0xFE, 0xFF, 0x87, 0xF0, 0xFF, 0x8F, 0xF0, 0xFE, 0x3F, 0xE1,
  0xFF, 0x1F, 0xC7, 0xF8, 0x1F, 0xE7, 0xF1, 0xFF, 0x03, 0xFE, 0xFE, 0x3F,
  0xC0, 0x3F, 0xFF, 0xC7, 0xF8, 0x07, 0xFF, 0xF0, 0xFF, 0x00, 0x7F, 0xFE,
  0x1F, 0xE0, 0x0F, 0xFF, 0x83, 0xFC, 0x00, 0xFF, 0xF0, 0x7F, 0x80, 0x1F,
  0xFC, 0x0F, 0xF0, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x3F, 0xE0,
  0x0F, 0xFC, 0x03, 0xFE, 0x07, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0x1F, 0xF0, 0x07, 0xFF, 0x81, 0xFE, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0x8F, 0xCF, 0xE7, 0xF3, 0xF1, 0xF8, 0xFC, 0x7E, 0x7E,
  0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xE1, 0xF1, 0xF8, 0xFC, 0x7E, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3F, 0x00, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x60, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x30, 0x07, 0xC0, 0x33, 0xC0, 0xFC,
  0x0F, 0x7F, 0x0F, 0x87, 0xF7, 0xFE, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x00, 0x7F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x7F, 0x3F, 0x00, 0x0F, 0xE3, 0xF0, 0x01, 0xFC,
  0x1F, 0x80, 0x3F, 0x81, 0xF8, 0x07, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xFE,
  0x01, 0xE0, 0x0F, 0x80, 0x0C, 0x00, 0x70, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x80,
  0xFE, 0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFC, 0x07, 0xF0, 0x3F, 0xC0,
  0xFE, 0x03, 0xF8, 0x1F, 0xE0, 0xFF, 0x03, 0xF8, 0x1F, 0xE0, 0xFF, 0x03,
  0xF8, 0x03, 0xC0, 0x02, 0x00, 0x3F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF,
  0xFF, 0xE7, 0xFF, 0xF3, 0xFF, 0xF9, 0xFF, 0xFC, 0x1C, 0x3F, 0xBF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF,
  0x83, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0x0F, 0xE0, 0x7F, 0x80,
  0x3F, 0x83, 0xFC, 0x00, 0xFF, 0x0F, 0xF0, 0x03, 0xFC, 0x3F, 0x80, 0x0F,
  0xF1, 0xFE, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0xFF, 0x1F, 0xE0, 0x03, 0xFC,
  0x7F, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0xFF, 0x3F,
  0xC0, 0x03, 0xF8, 0xFF, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x7F, 0x8F, 0xF0,
  0x01, 0xFE, 0x7F, 0x80, 0x07, 0xF9, 0xFE, 0x00, 0x1F, 0xE7, 0xF8, 0x00,
  0x7F, 0x9F, 0xE0, 0x01, 0xFC, 0x7F, 0x80, 0x0F, 0xF1, 0xFE, 0x00, 0x3F,
  0xC7, 0xF8, 0x00, 0xFF, 0x3F, 0xC0, 0x03, 0xFC, 0xFF, 0x00, 0x0F, 0xF3,
  0xFC, 0x00, 0x3F, 0x8F, 0xF0, 0x00, 0xFE, 0x3F, 0xC0, 0x07, 0xF8, 0xFF,
  0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x7F, 0x8F, 0xF0, 0x01, 0xFC, 0x3F, 0xC0,
  0x0F, 0xF0, 0x7F, 0x00, 0x3F, 0x81, 0xFC, 0x01, 0xFE, 0x07, 0xF8, 0x07,
  0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0xC1, 0xFF, 0x00, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x1F, 0x00, 0x07, 0xF0, 0x03, 0xFE, 0x01, 0xFF, 0xE0,
  0x7F, 0xFE, 0x3F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFC,
  0x7F, 0xFF, 0xCF, 0xE3, 0xFC, 0xF8, 0x3F, 0xCC, 0x03, 0xFC, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00,
  0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xC0,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0x83,
  0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0x80,
  0x3F, 0xE0, 0x7F, 0x80, 0x0F, 0xF0, 0x3F, 0xC0, 0x07, 0xF8, 0x1F, 0xE0,
  0x03, 0xFC, 0x1F, 0xE0, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0x87, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03,
  0xFC, 0x01, 0xFE, 0x03, 0xFC, 0x01, 0xFE, 0x07, 0xF8, 0x01, 0xFF, 0x07,
  0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x07, 0xF8, 0x7F, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xF0, 0x7F,
  0x80, 0x0F, 0xF0, 0x7F, 0x80, 0x0F, 0xF0, 0x7F, 0x80, 0x1F, 0xF0, 0x7F,
  0x80, 0x1F, 0xE0, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0xE0, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x07, 0xF7, 0xF8, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x0F, 0xE7, 0xF8, 0x00,
  0x1F, 0xC7, 0xF8, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x3F, 0x8F, 0xF0, 0x00,
  0x7F, 0x0F, 0xF0, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0xFE, 0x0F, 0xF0, 0x01,
  0xFC, 0x0F, 0xF0, 0x01, 0xFC, 0x1F, 0xE0, 0x03, 0xF8, 0x1F, 0xE0, 0x07,
  0xF8, 0x1F, 0xE0, 0x0F, 0xF0, 0x1F, 0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F,
  0xE0, 0x1F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0xC0, 0x7F,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xF0, 0x3F, 0xE0, 0x07, 0xC0, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0xFE,
  0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x1F, 0xE0, 0xFF,
  0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0xC0, 0x7F,
  0x80, 0xFF, 0x80, 0x7F, 0xE1, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0,
  0x07, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE,
  0x3F, 0x80, 0x1F, 0xEF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x3F,
  0xF8, 0x3F, 0xE7, 0xFE, 0x01, 0xFE, 0x7F, 0xC0, 0x1F, 0xF7, 0xFC, 0x00,
  0xFF, 0x7F, 0x80, 0x0F, 0xF7, 0xF8, 0x00, 0xFF, 0x7F, 0x80, 0x0F, 0xF7,
  0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0x7F, 0x00, 0x0F, 0xE7, 0xF0, 0x01, 0xFE,
  0x7F, 0x00, 0x1F, 0xE7, 0xF8, 0x01, 0xFE, 0x7F, 0x80, 0x3F, 0xC7, 0xF8,
  0x07, 0xFC, 0x3F, 0xC0, 0xFF, 0x83, 0xFE, 0x1F, 0xF8, 0x3F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xC3,
  0xFE, 0x01, 0xFF, 0x03, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x0F, 0xF0, 0x07,
  0xF8, 0x1F, 0xE0, 0x0F, 0xF0, 0x3F, 0xC0, 0x1F, 0xE0, 0xFF, 0x00, 0x3F,
  0xC1, 0xFE, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0xFF, 0x07, 0xF8, 0x03, 0xFC,
  0x0F, 0xF0, 0x07, 0xF8, 0x0F, 0xE0, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x3F, 0xC0, 0x7F, 0x80, 0x3F, 0xC1, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0x0F, 0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x0F, 0xF0, 0x3F, 0xC0,
  0x1F, 0xE0, 0xFF, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x3F, 0x83, 0xFC, 0x00,
  0x7F, 0x87, 0xF0, 0x00, 0xFF, 0x1F, 0xE0, 0x01, 0xFE, 0x3F, 0xC0, 0x03,
  0xF8, 0x7F, 0x80, 0x0F, 0xF0, 0xFF, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x7F,
  0xC1, 0xFE, 0x00, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x07, 0xFE, 0x1F, 0xF8,
  0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0x3F, 0xC7, 0xFC,
  0x03, 0xF8, 0xFF, 0x00, 0x7F, 0x9F, 0xE0, 0x0F, 0xF7, 0xF8, 0x01, 0xFE,
  0xFF, 0x00, 0x3F, 0xDF, 0xE0, 0x07, 0xFB, 0xF8, 0x00, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x80, 0x7F, 0xCF, 0xF0, 0x0F, 0xF9, 0xFF, 0x07, 0xFF, 0x3F,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFC, 0x07, 0xFE, 0x7F, 0x80, 0x3F, 0x8F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x0F,
  0xE0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFE, 0x03,
  0xF8, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x07, 0xF0, 0x3F, 0xC0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0,
  0xFF, 0x01, 0xFC, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x03, 0xF0, 0x00,
  0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0x80, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xE0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00,
  0x3C, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8,
  0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x20, 0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0xC0, 0x04, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0xFF, 0xC7, 0xFE, 0x3F,
  0xE0, 0xFF, 0x9F, 0xF0, 0x1F, 0xE7, 0xF8, 0x07, 0xF9, 0xFE, 0x01, 0xFE,
  0xFF, 0x00, 0x7F, 0xBF, 0xC0, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1E, 0x03, 0xF0,
  0x03, 0xFF, 0x80, 0x1F, 0x03, 0xF0, 0x07, 0xFF, 0xE0, 0x1F, 0x07, 0xE0,
  0x0F, 0xFF, 0xF0, 0x1F, 0x07, 0xE0, 0x1F, 0xFF, 0xF8, 0x1F, 0x0F, 0xC0,
  0x3F, 0xE3, 0xF0, 0x1F, 0x0F, 0xC0, 0x7F, 0x83, 0xF0, 0x1F, 0x1F, 0x80,
  0x7E, 0x03, 0xF0, 0x1F, 0x1F, 0x80, 0xFE, 0x03, 0xF0, 0x1F, 0x1F, 0x00,
  0xFC, 0x03, 0xE0, 0x1F, 0x3F, 0x01, 0xFC, 0x07, 0xE0, 0x1F, 0x3F, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x3E, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0x7E, 0x03,
  0xF0, 0x07, 0xC0, 0x1F, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x7E, 0x07,
  0xF0, 0x0F, 0xC0, 0x3E, 0x7C, 0x07, 0xF0, 0x0F, 0xC0, 0x3E, 0x7C, 0x07,
  0xE0, 0x0F, 0x80, 0x3E, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x3E, 0xFC, 0x0F,
  0xE0, 0x1F, 0x80, 0x3E, 0xFC, 0x0F, 0xE0, 0x1F, 0x80, 0x7C, 0xFC, 0x0F,
  0xE0, 0x1F, 0x00, 0x7C, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0x7C, 0xF8, 0x0F,
  0xC0, 0x3F, 0x00, 0xF8, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0xF8, 0x0F,
  0xC0, 0x7F, 0x00, 0xF8, 0xF8, 0x0F, 0xE0, 0x7F, 0x01, 0xF0, 0xF8, 0x0F,
  0xE0, 0xFF, 0x03, 0xF0, 0xF8, 0x0F, 0xE1, 0xFF, 0x07, 0xE0, 0xF8, 0x07,
  0xFF, 0xFF, 0x8F, 0xC0, 0xF8, 0x07, 0xFF, 0xDF, 0xFF, 0xC0, 0xF8, 0x07,
  0xFF, 0x9F, 0xFF, 0x80, 0xFC, 0x03, 0xFF, 0x0F, 0xFF, 0x00, 0xFC, 0x01,
  0xFE, 0x07, 0xFC, 0x00, 0xFC, 0x00, 0x78, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x10, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x70, 0x00, 0x00, 0x07, 0xFF, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0xFE, 0x00, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0x07, 0xFB, 0xF8,
  0x00, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x00,
  0x7F, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x7F,
  0x00, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x00,
  0x7F, 0x81, 0xFC, 0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x07,
  0xF0, 0x00, 0x07, 0xF8, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x00,
  0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x07, 0xF8,
  0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0xFF, 0x80,
  0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x00, 0x7F,
  0x8F, 0xF8, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x7F, 0xC0,
  0x00, 0x03, 0xFE, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xF0, 0x07, 0xFE, 0x01, 0xFE, 0x00, 0x3F,
  0xE0, 0x1F, 0xE0, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x1F, 0xE0,
  0x01, 0xFF, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x01, 0xFF, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x3F,
  0xE0, 0x3F, 0xC0, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0xC0,
  0x1F, 0xF8, 0x07, 0xF8, 0x0F, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0x00,
  0x3F, 0xE0, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x1F,
  0xF0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0xFF,
  0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x1F, 0xE0, 0x00, 0xFF, 0x03, 0xFE, 0x00,
  0x0F, 0xF0, 0x3F, 0xE0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x3F,
  0xC0, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x03, 0xFE,
  0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x7F, 0x80, 0x1F, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFE, 0x1F, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x3F, 0xE0,
  0x01, 0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x01, 0xFE, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x0F,
  0xF1, 0xFF, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x0F, 0xF1, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0xFF,
  0x00, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x01, 0xFF,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x01, 0xFE, 0x07, 0xF8, 0x00,
  0x3F, 0xE0, 0x3F, 0xC0, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x3F,
  0xF8, 0x3F, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xF0, 0x1F, 0xFC, 0x01,
  0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x1F,
  0xE0, 0x1F, 0xE0, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0xE0,
  0x00, 0xFF, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0xFF, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x0F,
  0xF0, 0x7F, 0xC0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0x80,
  0x00, 0xFF, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x01, 0xFE, 0x0F,
  0xF8, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0xFF, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0xFF, 0x00,
  0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x03, 0xFC, 0x1F,
  0xE0, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x07, 0xFC, 0x1F, 0xE0, 0x00, 0x7F,
  0x83, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0xE0, 0x00, 0xFF, 0x83, 0xFC, 0x00,
  0x0F, 0xF0, 0x3F, 0xC0, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x3F,
  0xC0, 0x07, 0xFE, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0x80, 0x7F, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFE, 0x1F, 0xFE, 0x01, 0xFF, 0x80, 0x3F,
  0xE0, 0x3F, 0xE0, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x7F, 0xC0,
  0x00, 0xFF, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0xFF, 0x0F,
  0xF0, 0x00, 0x0F, 0xF1, 0xFF, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x07, 0xFC, 0x03, 0xFF, 0xFE, 0x7F, 0xC0, 0x3F, 0xFF, 0xC7, 0xF8, 0x03,
  0xFF, 0xFC, 0x7F, 0x80, 0x3F, 0xFF, 0xC7, 0xF8, 0x03, 0xFF, 0xFC, 0x7F,
  0x80, 0x3F, 0xFF, 0xC7, 0xF8, 0x07, 0xFF, 0xFC, 0x7F, 0x80, 0x00, 0x7F,
  0x8F, 0xF8, 0x00, 0x07, 0xF8, 0xFF, 0x80, 0x00, 0x7F, 0x8F, 0xF8, 0x00,
  0x07, 0xF8, 0x7F, 0x80, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0x0F, 0xF8, 0x7F,
  0x80, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0xFF,
  0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x01, 0xFF, 0x03, 0xFF, 0x00,
  0x7F, 0xF0, 0x1F, 0xFC, 0x3F, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x00, 0x0F,
  0xF0, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x00,
  0x3F, 0xE0, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x3F,
  0xE0, 0x00, 0x1F, 0xF0, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x7F,
  0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x3F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x03, 0xFE, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF8, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x0F,
  0xF0, 0x1F, 0xE0, 0x03, 0xFC, 0x07, 0xF8, 0x01, 0xFF, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x7F, 0x80, 0x3F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xFC,
  0x07, 0xFC, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0xFF, 0xC0,
  0x0F, 0xF0, 0x00, 0x7F, 0xF0, 0x03, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFE, 0x00, 0x0F, 0xF0, 0x03,
  0xFF, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0x80, 0x3F, 0xF0, 0x00, 0x1F, 0xE0, 0x1F, 0xF8, 0x00, 0x07,
  0xF8, 0x0F, 0xFC, 0x00, 0x01, 0xFE, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x83,
  0xFF, 0x00, 0x00, 0x3F, 0xC1, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x7F, 0xC0,
  0x00, 0x03, 0xFC, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x1F, 0xF8, 0x00, 0x00,
  0x7F, 0xCF, 0xFC, 0x00, 0x00, 0x1F, 0xF7, 0xFE, 0x00, 0x00, 0x07, 0xF9,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xDF,
  0xE0, 0x00, 0x01, 0xFF, 0xE7, 0xFC, 0x00, 0x00, 0x7F, 0xF1, 0xFF, 0x00,
  0x00, 0x1F, 0xF8, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x01,
  0xFE, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x3F, 0xE0,
  0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x80, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x01,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFC,
  0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x00, 0xFF,
  0xFC, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x01,
  0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x80,
  0x03, 0xFF, 0xF8, 0x03, 0xFB, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xBF,
  0x80, 0x07, 0xF7, 0xF8, 0x07, 0xF9, 0xF8, 0x00, 0xFF, 0x7F, 0x00, 0x7F,
  0x9F, 0x80, 0x0F, 0xE7, 0xF0, 0x07, 0xF9, 0xF8, 0x00, 0xFE, 0xFF, 0x00,
  0x7F, 0x9F, 0xC0, 0x1F, 0xCF, 0xF0, 0x07, 0xF9, 0xFC, 0x01, 0xFC, 0xFF,
  0x00, 0x7F, 0x1F, 0xC0, 0x3F, 0x8F, 0xF0, 0x0F, 0xF1, 0xFC, 0x03, 0xF8,
  0xFE, 0x00, 0xFF, 0x1F, 0xC0, 0x7F, 0x1F, 0xE0, 0x0F, 0xF0, 0xFC, 0x07,
  0xF1, 0xFE, 0x00, 0xFF, 0x0F, 0xC0, 0xFE, 0x1F, 0xE0, 0x0F, 0xF0, 0xFC,
  0x0F, 0xE1, 0xFE, 0x00, 0xFF, 0x0F, 0xC1, 0xFC, 0x3F, 0xE0, 0x1F, 0xE0,
  0xFE, 0x1F, 0xC3, 0xFC, 0x01, 0xFE, 0x0F, 0xE3, 0xF8, 0x3F, 0xC0, 0x1F,
  0xE0, 0xFE, 0x3F, 0x83, 0xFC, 0x01, 0xFE, 0x07, 0xE3, 0xF0, 0x3F, 0xC0,
  0x1F, 0xE0, 0x7E, 0x7F, 0x07, 0xFC, 0x03, 0xFE, 0x07, 0xE7, 0xE0, 0x7F,
  0x80, 0x3F, 0xE0, 0x7E, 0xFE, 0x07, 0xF8, 0x03, 0xFC, 0x07, 0xEF, 0xE0,
  0x7F, 0x80, 0x3F, 0xC0, 0x7F, 0xFC, 0x07, 0xF8, 0x03, 0xFC, 0x07, 0xFF,
  0xC0, 0x7F, 0x80, 0x3F, 0xC0, 0x7F, 0xF8, 0x0F, 0xF8, 0x07, 0xFC, 0x03,
  0xFF, 0x80, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8,
  0x03, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x1F,
  0xE0, 0x0F, 0xF0, 0x01, 0xF8, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x0F, 0xF8, 0x00, 0x07, 0xFC,
  0x03, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x3F,
  0xF0, 0x00, 0x1F, 0xE0, 0x0F, 0xFE, 0x00, 0x07, 0xF8, 0x07, 0xFF, 0x80,
  0x03, 0xFE, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x3F,
  0xC0, 0x1F, 0xFF, 0x00, 0x0F, 0xF0, 0x07, 0xFF, 0xC0, 0x03, 0xFC, 0x01,
  0xFF, 0xF0, 0x00, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xDF,
  0x80, 0x1F, 0xE0, 0x0F, 0xF7, 0xE0, 0x07, 0xF8, 0x03, 0xFD, 0xFC, 0x01,
  0xFE, 0x00, 0xFF, 0x7F, 0x00, 0x7F, 0x80, 0x7F, 0xCF, 0xC0, 0x1F, 0xE0,
  0x1F, 0xF3, 0xF8, 0x0F, 0xF8, 0x07, 0xF8, 0xFE, 0x03, 0xFC, 0x01, 0xFE,
  0x1F, 0x80, 0xFF, 0x00, 0x7F, 0x87, 0xE0, 0x3F, 0xC0, 0x1F, 0xE1, 0xFC,
  0x0F, 0xF0, 0x0F, 0xF8, 0x3F, 0x07, 0xFC, 0x03, 0xFC, 0x0F, 0xC1, 0xFF,
  0x00, 0xFF, 0x03, 0xF8, 0x7F, 0x80, 0x3F, 0xC0, 0xFE, 0x1F, 0xE0, 0x0F,
  0xF0, 0x1F, 0x87, 0xF8, 0x03, 0xFC, 0x07, 0xF1, 0xFE, 0x01, 0xFF, 0x01,
  0xFC, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xCF,
  0xF0, 0x07, 0xF8, 0x03, 0xFB, 0xFC, 0x01, 0xFE, 0x00, 0x7E, 0xFF, 0x00,
  0xFF, 0x80, 0x1F, 0xBF, 0xC0, 0x3F, 0xE0, 0x07, 0xFF, 0xF0, 0x0F, 0xF0,
  0x01, 0xFF, 0xF8, 0x03, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0x00, 0x0F,
  0xFF, 0x80, 0x3F, 0xC0, 0x03, 0xFF, 0xE0, 0x1F, 0xF0, 0x00, 0x7F, 0xF8,
  0x07, 0xFC, 0x00, 0x1F, 0xFE, 0x01, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0x3F, 0xF0, 0x07, 0xF8, 0x00,
  0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFE, 0x7F, 0xF8, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x0F, 0xF8,
  0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x07, 0xF8,
  0x3F, 0xC0, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0xFF, 0x00, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x03, 0xFC, 0x7F,
  0xC0, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0xFF, 0x00, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x01, 0xFE, 0x3F, 0xC0,
  0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x07, 0xFC,
  0xFF, 0x00, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00,
  0x0F, 0xF1, 0xFE, 0x00, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x03, 0xFC, 0xFF,
  0x80, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x01, 0xFE, 0x3F, 0xE0, 0x00, 0x0F,
  0xF1, 0xFF, 0x00, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x07, 0xF8, 0x3F, 0xC0,
  0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x7F, 0x80, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x01, 0xFF, 0xC7, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x01, 0xFE,
  0x00, 0x0F, 0xF8, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x00, 0x7F,
  0x80, 0x7F, 0x80, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x0F, 0xF8,
  0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x01, 0xFE,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x7F, 0xC0,
  0x00, 0xFF, 0x81, 0xFF, 0x00, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0x1F, 0xF0,
  0x1F, 0xE0, 0x00, 0xFF, 0xC0, 0x7F, 0x80, 0x07, 0xFE, 0x01, 0xFE, 0x00,
  0x7F, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFE, 0x7F, 0xF8, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0xF0, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x0F, 0xF8, 0x00,
  0x3F, 0xE0, 0x7F, 0x80, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x3F,
  0xC0, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0xFF, 0x00, 0x00, 0x7F, 0x8F, 0xF8, 0x00, 0x03, 0xFC, 0x7F, 0x80,
  0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x07, 0xF8,
  0xFF, 0x00, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x01, 0xFE, 0x7F, 0xC0, 0x00,
  0x0F, 0xF3, 0xFC, 0x00, 0x00, 0xFF, 0x9F, 0xE0, 0x00, 0x07, 0xF8, 0xFF,
  0x00, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x0F,
  0xF1, 0xFE, 0x00, 0x00, 0x7F, 0x9F, 0xF0, 0x00, 0x07, 0xFC, 0xFF, 0x80,
  0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x0F, 0xF1,
  0xFE, 0x00, 0x00, 0xFF, 0x8F, 0xF0, 0x00, 0x07, 0xF8, 0x7F, 0xC0, 0x00,
  0x3F, 0xC1, 0xFE, 0x00, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x7F,
  0x80, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x0F, 0xF0, 0x01, 0xFF,
  0x80, 0x7F, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0xC7, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x3F,
  0xE0, 0x1F, 0xE0, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x1F, 0xE0,
  0x00, 0xFF, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0xE0, 0x00, 0xFF, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x3F, 0xC0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0xC0,
  0x03, 0xFE, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x07, 0xFC, 0x07,
  0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0x80, 0x3F, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFF, 0xE0, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x1F, 0xE0,
  0x01, 0xFE, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x1F, 0xF0, 0x01, 0xFE, 0x01,
  0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x07, 0xF8,
  0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x07, 0xFC, 0x07, 0xF8, 0x00,
  0x7F, 0xC0, 0x7F, 0x80, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x7F,
  0x80, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x01, 0xFE,
  0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xF0,
  0x03, 0xFE, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0xE0, 0x01, 0xFE, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x1F,
  0xF0, 0x3F, 0xC0, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x7F,
  0x80, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x01, 0xFE,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x01, 0xFE, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0x7F, 0xC0, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x3F,
  0xF8, 0x3F, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x01, 0xFE, 0x0F, 0xF8,
  0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x07, 0xF8,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x7F, 0xC0, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x07, 0xFC, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x3F, 0xC0, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x03, 0xFC, 0x1F, 0xE0,
  0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x3F, 0xC0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x03, 0xFC, 0x1F, 0xF0, 0x00,
  0x3F, 0xE0, 0xFF, 0x00, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x3F,
  0xC0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0xFF, 0x80, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x3F, 0xC0,
  0x00, 0x7F, 0x81, 0xFE, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0xFF, 0x80, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x00,
  0x7F, 0x81, 0xFE, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x7F,
  0x80, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x1F, 0xE0, 0x00, 0x7F,
  0x80, 0xFF, 0x80, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x1F, 0xF0,
  0x07, 0xFE, 0x00, 0xFF, 0xF0, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xBF, 0xE0, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x00, 0x7F, 0xEF, 0xF8,
  0x00, 0x03, 0xFE, 0x3F, 0xC0, 0x00, 0x3F, 0xF1, 0xFE, 0x00, 0x01, 0xFF,
  0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x00, 0xFF, 0x83, 0xFC, 0x00,
  0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x03, 0xFE, 0x07,
  0xFC, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x0F,
  0xF8, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x07, 0xFC, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0,
  0x01, 0xFC, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x7F, 0x80, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00,
  0xFF, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x3F, 0xC1, 0xFF,
  0x00, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x00, 0x3F,
  0x87, 0xF8, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x0F, 0xF3, 0xFC, 0x00,
  0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0x0F, 0xEF,
  0xF0, 0x00, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xE0,
  0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xE0,
  0x01, 0xFE, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0xFF, 0x00, 0x1F, 0xE0,
  0x03, 0xFE, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0xFF, 0x00, 0x3F, 0xE0,
  0x03, 0xFC, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFC, 0xFF, 0x00, 0x7F, 0xF0,
  0x07, 0xF8, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xF8, 0xFF, 0x00, 0x7F, 0xF0,
  0x07, 0xF8, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0xF0,
  0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xF0, 0xFF, 0x01, 0xFF, 0xF0,
  0x1F, 0xE0, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xE0, 0xFF, 0x03, 0xFB, 0xF0,
  0x1F, 0xE0, 0xFF, 0x03, 0xFB, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xF3, 0xF0,
  0x3F, 0xC0, 0xFF, 0x07, 0xF3, 0xF0, 0x3F, 0x80, 0xFF, 0x07, 0xF3, 0xF0,
  0x7F, 0x80, 0xFF, 0x07, 0xE3, 0xF0, 0x7F, 0x80, 0xFF, 0x0F, 0xE3, 0xF0,
  0x7F, 0x00, 0xFF, 0x0F, 0xE3, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xC3, 0xF0,
  0xFF, 0x00, 0xFF, 0x1F, 0xC3, 0xF0, 0xFE, 0x00, 0xFF, 0x1F, 0xC3, 0xF1,
  0xFE, 0x00, 0xFF, 0x1F, 0x83, 0xF1, 0xFE, 0x00, 0xFF, 0x3F, 0x83, 0xF1,
  0xFC, 0x00, 0xFF, 0x3F, 0x03, 0xF3, 0xFC, 0x00, 0xFF, 0x7F, 0x03, 0xF3,
  0xFC, 0x00, 0xFF, 0x7F, 0x03, 0xF3, 0xF8, 0x00, 0xFF, 0x7E, 0x03, 0xFB,
  0xF8, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x03, 0xFF,
  0xF0, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x03, 0xFF,
  0xF0, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x01, 0xFF,
  0xE0, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0xC0, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xE0, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xC0, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x0F, 0xFC, 0x00, 0x01, 0xFE, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00,
  0x00, 0xFF, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0x8F, 0xF0, 0x00, 0x00, 0x1F, 0xF1, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x83, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x7F,
  0x80, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x00, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x07,
  0xFE, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFD, 0xFE, 0x00,
  0x01, 0xFF, 0x3F, 0xC0, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x0F, 0xF8, 0xFF,
  0x80, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x1F, 0xF0,
  0x3F, 0xC0, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x3F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0x3F, 0xC0,
  0x3F, 0xC0, 0x03, 0xFC, 0x0F, 0xF8, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x0F,
  0xF0, 0x7F, 0x80, 0x00, 0xFE, 0x1F, 0xF0, 0x00, 0x1F, 0xC3, 0xFC, 0x00,
  0x03, 0xF8, 0xFF, 0x80, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x07, 0xF7, 0xF8,
  0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x07,
  0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0x80, 0x3F,
  0x80, 0x3F, 0x80, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F,
  0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF8, 0x07,
  0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03,
  0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01,
  0xFC, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8,
  0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x1F, 0xBF, 0x00, 0xFE, 0xFC, 0x03, 0xF3, 0xF0, 0x1F, 0xCF,
  0xC0, 0x7E, 0x1F, 0x03, 0xF8, 0x7C, 0x0F, 0xC1, 0xF8, 0x7F, 0x07, 0xE1,
  0xF8, 0x1F, 0x8F, 0xE0, 0x7E, 0x3F, 0x81, 0xF9, 0xFC, 0x07, 0xE7, 0xF0,
  0x1F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFC, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF0, 0xFF, 0x81, 0xFF, 0x03, 0xFC,
  0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x07,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xC0, 0xFF, 0x83, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0xC0,
  0x3F, 0x83, 0xFC, 0x01, 0xFE, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0x0F, 0xF0, 0xFF, 0xC0, 0x7F,
  0x87, 0xFC, 0x03, 0xFC, 0x7F, 0xC0, 0x1F, 0xE3, 0xFC, 0x01, 0xFE, 0x1F,
  0xE0, 0x0F, 0xF1, 0xFF, 0x00, 0x7F, 0x8F, 0xF0, 0x03, 0xFC, 0x7F, 0x80,
  0x1F, 0xE3, 0xFC, 0x01, 0xFF, 0x1F, 0xF0, 0x1F, 0xF0, 0x7F, 0xC3, 0xFF,
  0x83, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xBF, 0xC0, 0x1F, 0xF0, 0xFF, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE,
  0x1F, 0x00, 0x01, 0xFE, 0x7F, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0x87, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x07, 0xFC,
  0x01, 0xFE, 0x07, 0xF8, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0xFE, 0x07, 0xF8,
  0x00, 0xFE, 0x07, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x0F, 0xF0,
  0x00, 0xFE, 0x0F, 0xF0, 0x01, 0xFE, 0x0F, 0xF0, 0x01, 0xFE, 0x0F, 0xF0,
  0x01, 0xFE, 0x0F, 0xF0, 0x01, 0xFE, 0x0F, 0xE0, 0x01, 0xFE, 0x1F, 0xE0,
  0x01, 0xFE, 0x1F, 0xE0, 0x01, 0xFE, 0x1F, 0xE0, 0x01, 0xFE, 0x1F, 0xE0,
  0x01, 0xFC, 0x1F, 0xE0, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0,
  0x03, 0xFC, 0x3F, 0xC0, 0x07, 0xF8, 0x3F, 0xC0, 0x07, 0xF8, 0x3F, 0xE0,
  0x0F, 0xF8, 0x3F, 0xF0, 0x1F, 0xF0, 0x7F, 0xF8, 0x3F, 0xF0, 0x7F, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xBF, 0xFF, 0xC0, 0x7F, 0x3F,
  0xFF, 0x80, 0x7F, 0x1F, 0xFF, 0x00, 0xFF, 0x0F, 0xFE, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xE0, 0xFF, 0xC1, 0xFE, 0x0F, 0xF0, 0x0F, 0xF1, 0xFE, 0x00,
  0xFF, 0x1F, 0xE0, 0x07, 0xF3, 0xFC, 0x00, 0x7F, 0x3F, 0xC0, 0x07, 0xF3,
  0xF8, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x03, 0xFC, 0xFF, 0x00, 0x3F, 0xCF, 0xF0, 0x03, 0xFC, 0x7F,
  0x00, 0x7F, 0x87, 0xF8, 0x0F, 0xF8, 0x7F, 0xC1, 0xFF, 0x03, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xF8,
  0x1F, 0xE0, 0x01, 0xFF, 0x87, 0xF8, 0x00, 0xFF, 0xF1, 0xFE, 0x00, 0xFF,
  0xFE, 0x7F, 0x80, 0x3F, 0xFF, 0xDF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0x0F, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0xC0,
  0x7F, 0x80, 0x3F, 0xF0, 0x3F, 0xE0, 0x07, 0xF8, 0x0F, 0xF0, 0x01, 0xFE,
  0x03, 0xFC, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x07,
  0xF8, 0x1F, 0xE0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0xFF, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x03, 0xFC, 0x0F, 0xF0,
  0x00, 0xFF, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x1F, 0xE0, 0x3F,
  0xC0, 0x07, 0xF8, 0x0F, 0xF0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0xFF, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x07, 0xF0, 0x0F, 0xF0, 0x03, 0xFC,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F,
  0xF0, 0x07, 0xFE, 0x1F, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFB, 0xF8, 0x00, 0x3F,
  0xFD, 0xFE, 0x00, 0x07, 0xFE, 0x7F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0x81, 0xFF, 0x83, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0x7F,
  0x87, 0xF8, 0x01, 0xFC, 0x7F, 0x80, 0x0F, 0xE3, 0xFC, 0x00, 0x7F, 0x1F,
  0xE0, 0x03, 0xF9, 0xFE, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0xFE, 0x7F, 0x80,
  0x07, 0xF3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x18, 0x0F, 0xF8, 0x03, 0xE0, 0x7F, 0xE0, 0x7F, 0x01,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x1F,
  0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x07, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0xFE, 0x1F, 0xC0, 0x0F, 0xFF, 0x8F, 0xE0, 0x0F, 0xFF, 0xE7, 0xF0,
  0x0F, 0xFF, 0xF7, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC,
  0x07, 0xFE, 0x0F, 0xFE, 0x07, 0xFC, 0x03, 0xFF, 0x03, 0xFC, 0x00, 0xFF,
  0x83, 0xFE, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x1F,
  0xE0, 0x7F, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x07, 0xF8, 0x3F, 0xC0, 0x03,
  0xFC, 0x1F, 0xE0, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0x07, 0xF0, 0x00,
  0xFF, 0x07, 0xF8, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x3F, 0xC1, 0xFE, 0x00,
  0x1F, 0xE0, 0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x07, 0xF8, 0x3F, 0xC0,
  0x07, 0xF8, 0x1F, 0xE0, 0x03, 0xFC, 0x0F, 0xF0, 0x01, 0xFE, 0x07, 0xF8,
  0x00, 0xFF, 0x03, 0xFC, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x3F, 0x80, 0xFF,
  0x80, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF8, 0x7F, 0xF0, 0x0F,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFE, 0x7F, 0x80,
  0x00, 0x7C, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x0F, 0xF0, 0x02, 0x00, 0x0F, 0xF8, 0x03, 0x80, 0x0F, 0xF8,
  0x01, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xE1, 0xF0, 0x00, 0x7F, 0xBF, 0xF0, 0x01, 0xFD,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFC, 0x1F, 0xF0, 0x7F, 0xE0, 0x3F,
  0xC1, 0xFF, 0x00, 0xFF, 0x07, 0xF8, 0x03, 0xFC, 0x1F, 0xE0, 0x0F, 0xF0,
  0x7F, 0x80, 0x3F, 0xC1, 0xFE, 0x00, 0xFF, 0x0F, 0xF0, 0x03, 0xFC, 0x3F,
  0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0xFF, 0x0F, 0xF0,
  0x03, 0xFC, 0x3F, 0x80, 0x1F, 0xE1, 0xFE, 0x00, 0x7F, 0x87, 0xF8, 0x01,
  0xFE, 0x1F, 0xE0, 0x07, 0xF8, 0x7F, 0x80, 0x1F, 0xE1, 0xFE, 0x00, 0x7F,
  0x87, 0xF0, 0x03, 0xFC, 0x3F, 0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x3F, 0xC3,
  0xFC, 0x00, 0xFF, 0x0F, 0xF0, 0x03, 0xFC, 0x3F, 0xC0, 0x0F, 0xF1, 0xFE,
  0x00, 0x3F, 0x87, 0xF8, 0x01, 0xFE, 0x1F, 0xE0, 0x07, 0xF8, 0x7F, 0x80,
  0x1F, 0xE1, 0xFE, 0x00, 0x7F, 0x87, 0xF8, 0x01, 0xFE, 0x3F, 0xC0, 0x07,
  0xF0, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x3C, 0x00, 0x7E, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7E, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x03,
  0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07,
  0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F,
  0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F,
  0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F,
  0x80, 0x7F, 0x80, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0xFC,
  0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07,
  0xF8, 0x07, 0xFE, 0x01, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0xC0,
  0x3F, 0xC0, 0x7F, 0xE0, 0x0F, 0xF0, 0x3F, 0xF0, 0x03, 0xFC, 0x1F, 0xF8,
  0x00, 0xFF, 0x07, 0xFC, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x1F, 0xE1, 0xFF,
  0x00, 0x07, 0xF8, 0xFF, 0xC0, 0x01, 0xFE, 0x7F, 0xE0, 0x00, 0x7F, 0x9F,
  0xF0, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0x9F, 0xE0, 0x00, 0x7F, 0xC7, 0xF8, 0x00, 0x3F, 0xE1, 0xFE,
  0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0xFF, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x0F, 0xF0, 0x1F, 0xE0, 0x07, 0xF8,
  0x07, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF8, 0x07, 0xF8, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0x7F, 0x80,
  0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xFC, 0xFF, 0xE0, 0x3F, 0xF0, 0x01, 0xFD,
  0xFF, 0xF0, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF9, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFB, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF, 0x03, 0xFC,
  0x07, 0xFF, 0x81, 0xFF, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x07, 0xF8,
  0x03, 0xFE, 0x00, 0xFF, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x07, 0xF8,
  0x03, 0xFC, 0x00, 0xFF, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x07, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFE, 0x0F, 0xF0,
  0x03, 0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x1F, 0xE0,
  0x07, 0xF8, 0x01, 0xFE, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x1F, 0xE0,
  0x07, 0xF8, 0x01, 0xFE, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFC, 0x1F, 0xE0,
  0x07, 0xF0, 0x03, 0xFC, 0x1F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xF8, 0x3F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF8, 0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x7F, 0x80,
  0x1F, 0xE0, 0x07, 0xF8, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x7F, 0x80,
  0x1F, 0xE0, 0x07, 0xF8, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x7F, 0x80,
  0x1F, 0xC0, 0x0F, 0xF0, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x07, 0xF1, 0xFF, 0x80,
  0x3F, 0xDF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xC1, 0xFF, 0x07, 0xFE,
  0x03, 0xFC, 0x1F, 0xF0, 0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0xC1, 0xFE, 0x00,
  0xFF, 0x07, 0xF8, 0x03, 0xFC, 0x1F, 0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x3F,
  0xC3, 0xFC, 0x00, 0xFF, 0x0F, 0xF0, 0x03, 0xFC, 0x3F, 0xC0, 0x0F, 0xF0,
  0xFF, 0x00, 0x3F, 0xC7, 0xF8, 0x01, 0xFE, 0x1F, 0xE0, 0x07, 0xF8, 0x7F,
  0x80, 0x1F, 0xE1, 0xFE, 0x00, 0x7F, 0x87, 0xF8, 0x01, 0xFE, 0x1F, 0xE0,
  0x07, 0xF8, 0xFF, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0xFF, 0x0F, 0xF0, 0x03,
  0xFC, 0x3F, 0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0xFF,
  0x1F, 0xE0, 0x03, 0xF8, 0x7F, 0x80, 0x1F, 0xE1, 0xFE, 0x00, 0x7F, 0x87,
  0xF8, 0x01, 0xFE, 0x1F, 0xE0, 0x07, 0xF8, 0x7F, 0x80, 0x1F, 0xE3, 0xFC,
  0x00, 0x7F, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0x07,
  0xFC, 0x0F, 0xF8, 0x0F, 0xF8, 0x7F, 0xC0, 0x1F, 0xE1, 0xFE, 0x00, 0x7F,
  0x8F, 0xF0, 0x01, 0xFE, 0x3F, 0xC0, 0x03, 0xF8, 0xFF, 0x00, 0x0F, 0xF7,
  0xF8, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0xFF, 0x7F, 0x80, 0x03, 0xFD, 0xFE,
  0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x3F, 0xBF, 0xC0, 0x01, 0xFE, 0xFF, 0x00,
  0x07, 0xFB, 0xFC, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x7F, 0xBF, 0xC0, 0x01,
  0xFE, 0xFF, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0xFF,
  0x3F, 0xC0, 0x03, 0xFC, 0xFF, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x7F, 0x87,
  0xF8, 0x03, 0xFE, 0x1F, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0xFF, 0x80, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x9F, 0xFC, 0x00, 0x1F, 0xDF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0xFF,
  0x80, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0xC0, 0x7F, 0x80, 0x1F, 0xE0, 0x3F,
  0xC0, 0x0F, 0xF0, 0x1F, 0xE0, 0x07, 0xF8, 0x0F, 0xF0, 0x01, 0xFC, 0x0F,
  0xF0, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x7F, 0x81,
  0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x0F, 0xF0,
  0x7F, 0x80, 0x07, 0xF8, 0x3F, 0xC0, 0x03, 0xFC, 0x1F, 0xE0, 0x01, 0xFE,
  0x0F, 0xF0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x7F,
  0x83, 0xFC, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x1F,
  0xE0, 0x7F, 0x80, 0x0F, 0xF0, 0x3F, 0xE0, 0x0F, 0xF8, 0x1F, 0xF0, 0x0F,
  0xF8, 0x1F, 0xFE, 0x0F, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFE, 0xFF, 0xFE, 0x01, 0xFE, 0x3F,
  0xFE, 0x00, 0xFF, 0x0F, 0xFC, 0x00, 0x7F, 0x81, 0xF8, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFF, 0xC1, 0xFC,
  0x03, 0xFF, 0xC7, 0xF8, 0x1F, 0xFF, 0xCF, 0xF0, 0x7F, 0xFF, 0xDF, 0xC0,
  0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x07, 0xFE, 0x0F, 0xFE, 0x1F,
  0xF0, 0x0F, 0xFC, 0x3F, 0xC0, 0x0F, 0xF8, 0xFF, 0x80, 0x1F, 0xE1, 0xFE,
  0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0xFF, 0x1F, 0xE0,
  0x01, 0xFE, 0x3F, 0xC0, 0x03, 0xF8, 0x7F, 0x80, 0x0F, 0xF0, 0xFF, 0x00,
  0x1F, 0xE3, 0xFC, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x7F, 0x8F, 0xF0, 0x00,
  0xFF, 0x1F, 0xE0, 0x01, 0xFC, 0x3F, 0xC0, 0x07, 0xF8, 0x7F, 0x80, 0x0F,
  0xF0, 0xFF, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x7F,
  0x87, 0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x1F, 0xE0, 0x07, 0xF8,
  0x3F, 0xE0, 0x0F, 0xF0, 0x7F, 0xC0, 0x3F, 0xE0, 0x7F, 0xC1, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xEF, 0xF0, 0x01, 0xFF, 0x9F, 0xE0, 0x00,
  0xF8, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x03, 0xF9, 0xFC,
  0x07, 0xF7, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFF, 0xC4, 0x0F, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0,
  0x7F, 0xC1, 0xFF, 0x0F, 0xF8, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xF0,
  0x0F, 0xF0, 0xFE, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0xFF, 0x00, 0x3F, 0xCF, 0xF0, 0x03, 0xFC, 0xFF, 0x00, 0x7F, 0x8F,
  0xF0, 0x07, 0xF8, 0x7F, 0x80, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x0F, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF0, 0x3F, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0x01, 0xFF,
  0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x1F,
  0x00, 0x07, 0xF0, 0x01, 0xFE, 0x1F, 0xE0, 0x07, 0xF8, 0x3F, 0xC0, 0x0F,
  0xF0, 0x7F, 0x80, 0x1F, 0xE0, 0xFF, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x7F,
  0x83, 0xFC, 0x00, 0xFF, 0x0F, 0xF0, 0x03, 0xFC, 0x1F, 0xE0, 0x07, 0xF8,
  0x3F, 0xC0, 0x0F, 0xF0, 0x7F, 0x80, 0x1F, 0xE0, 0xFF, 0x00, 0x3F, 0xC1,
  0xFE, 0x00, 0x7F, 0x87, 0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x1F,
  0xE0, 0x07, 0xF8, 0x3F, 0xC0, 0x0F, 0xF0, 0x7F, 0x80, 0x1F, 0xE0, 0xFF,
  0x00, 0x3F, 0xC3, 0xFC, 0x00, 0xFF, 0x07, 0xF8, 0x01, 0xFE, 0x0F, 0xF0,
  0x03, 0xFC, 0x1F, 0xE0, 0x07, 0xF8, 0x3F, 0xC0, 0x0F, 0xF0, 0x7F, 0x80,
  0x1F, 0xE0, 0xFE, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0xFF, 0x07, 0xF8, 0x01,
  0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0xE0, 0x3F,
  0xE0, 0x3F, 0xE1, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xF7, 0xF0,
  0x01, 0xFF, 0xCF, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x1F,
  0xEF, 0xF0, 0x01, 0xFE, 0xFF, 0x00, 0x3F, 0xEF, 0xF0, 0x03, 0xFC, 0xFF,
  0x00, 0x3F, 0xC7, 0xF0, 0x07, 0xF8, 0x7F, 0x00, 0x7F, 0x87, 0xF0, 0x07,
  0xF0, 0x7F, 0x00, 0xFF, 0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0x81, 0xFE, 0x07,
  0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFC, 0x03, 0xF8, 0x3F, 0xC0, 0x3F, 0x83,
  0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x3F, 0x87, 0xF8, 0x03, 0xF8, 0x7F, 0x00,
  0x3F, 0x8F, 0xF0, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF9,
  0xFE, 0x00, 0x1F, 0x9F, 0xC0, 0x01, 0xF9, 0xFC, 0x00, 0x1F, 0xFF, 0x80,
  0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x3F, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xC0, 0x1F, 0xEF, 0xF0, 0x07, 0xF0,
  0x07, 0xF9, 0xFC, 0x03, 0xFC, 0x01, 0xFC, 0x7F, 0x00, 0xFF, 0x00, 0xFF,
  0x1F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC7, 0xF0, 0x1F, 0xF0, 0x0F, 0xE1, 0xFC,
  0x07, 0xFC, 0x07, 0xF8, 0x7F, 0x03, 0xFF, 0x01, 0xFC, 0x1F, 0xC0, 0xFF,
  0xC0, 0x7F, 0x07, 0xF0, 0x3F, 0xF0, 0x3F, 0xC1, 0xFC, 0x1F, 0xFE, 0x0F,
  0xE0, 0x7F, 0x07, 0xFF, 0x87, 0xF8, 0x1F, 0xC3, 0xFF, 0xE1, 0xFE, 0x07,
  0xF0, 0xFD, 0xF8, 0x7F, 0x01, 0xFC, 0x7F, 0x7E, 0x3F, 0xC0, 0x7F, 0x1F,
  0x9F, 0x8F, 0xE0, 0x1F, 0xC7, 0xE7, 0xE3, 0xF8, 0x07, 0xF3, 0xF9, 0xF9,
  0xFE, 0x01, 0xFC, 0xFC, 0x7E, 0x7F, 0x00, 0x7F, 0x7F, 0x1F, 0x9F, 0xC0,
  0x1F, 0xDF, 0x87, 0xEF, 0xE0, 0x07, 0xF7, 0xE1, 0xFB, 0xF8, 0x01, 0xFF,
  0xF8, 0x7E, 0xFE, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x03,
  0xFF, 0xC0, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x3F, 0xF8,
  0x00, 0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x3F, 0xE0,
  0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x00,
  0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x7F,
  0x80, 0x3F, 0xE0, 0x1F, 0xE0, 0x1F, 0xF0, 0x03, 0xFC, 0x07, 0xFC, 0x00,
  0xFF, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x07, 0xF0, 0x7F, 0xC0,
  0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x7F, 0x8F, 0xF8, 0x00, 0x0F, 0xE7, 0xFC,
  0x00, 0x03, 0xF9, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xF7, 0xF0,
  0x00, 0x07, 0xF9, 0xFE, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x01, 0xFF, 0x0F,
  0xE0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x1F, 0xF0,
  0x3F, 0xC0, 0x07, 0xFC, 0x07, 0xF8, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x1F, 0xE0, 0x3F, 0xE0, 0x03, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x0F,
  0xF8, 0x0F, 0xF0, 0x03, 0xFC, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x0F, 0xF0, 0x01, 0xFE,
  0x03, 0xFC, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x07,
  0xF8, 0x3F, 0xE0, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x83, 0xFC, 0x00,
  0x1F, 0xE1, 0xFE, 0x00, 0x03, 0xF8, 0x7F, 0x80, 0x00, 0xFE, 0x3F, 0xC0,
  0x00, 0x3F, 0x8F, 0xF0, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x03, 0xF9, 0xFE,
  0x00, 0x00, 0xFE, 0x7F, 0x80, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0x0F, 0xEF,
  0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x03,
  0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x08, 0x00, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x00,
  0x10, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xC0,
  0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x18, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x07, 0xC1, 0xFF, 0xE0, 0x07, 0xE1, 0xFF, 0xF8, 0x03, 0xF1, 0xFF,
  0xFC, 0x01, 0xF9, 0xFF, 0xFF, 0x01, 0xFC, 0xFF, 0xFF, 0xC0, 0xFC, 0xFF,
  0x1F, 0xF0, 0xFE, 0x7F, 0x07, 0xFF, 0xFF, 0x3F, 0x01, 0xFF, 0xFF, 0x1F,
  0x80, 0x7F, 0xFF, 0x1F, 0xC0, 0x1F, 0xFF, 0x8F, 0xC0, 0x07, 0xFF, 0x87,
  0xE0, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0x00,
};

const GFXglyph RobotoCondensed_MediumItalic71pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 16, 51, 17, 2, -50 },
  { 103, 19, 18, 22, 5, -53 },
  { 146, 36, 50, 37, 2, -50 },
  { 371, 31, 66, 34, 2, -58 },
  { 627, 33, 52, 44, 6, -51 },
  { 842, 35, 52, 39, 1, -51 },
  { 1070, 9, 18, 12, 5, -53 },
  { 1091, 22, 73, 22, 3, -57 },
  { 1292, 22, 72, 22, -3, -56 },
  { 1490, 28, 30, 31, 4, -50 },
  { 1595, 30, 37, 33, 2, -42 },
  { 1734, 14, 20, 15, -4, -8 },
  { 1769, 17, 7, 21, 2, -25 },
  { 1784, 9, 10, 19, 2, -9 },
  { 1796, 32, 54, 24, -4, -50 },
  { 2012, 30, 52, 34, 3, -51 },
  { 2207, 20, 50, 34, 8, -50 },
  { 2332, 33, 51, 34, 0, -51 },
  { 2543, 32, 52, 34, 1, -51 },
  { 2751, 32, 50, 34, 1, -50 },
  { 2951, 32, 51, 34, 3, -50 },
  { 3155, 28, 51, 34, 3, -50 },
  { 3334, 32, 50, 34, 4, -50 },
  { 3534, 31, 52, 34, 2, -51 },
  { 3736, 27, 51, 34, 5, -51 },
  { 3909, 14, 39, 18, 2, -38 },
  { 3978, 19, 50, 16, -3, -38 },
  { 4097, 27, 32, 31, 2, -38 },
  { 4205, 29, 22, 34, 3, -34 },
  { 4285, 28, 33, 31, 2, -38 },
  { 4401, 26, 52, 30, 5, -51 },
  { 4570, 48, 65, 53, 2, -49 },
  { 4960, 39, 50, 40, -3, -50 },
  { 5204, 36, 50, 38, 1, -50 },
  { 5429, 36, 52, 39, 3, -51 },
  { 5663, 36, 50, 39, 1, -50 },
  { 5888, 36, 50, 34, 1, -50 },
  { 6113, 35, 50, 33, 1, -50 },
  { 6332, 36, 52, 41, 3, -51 },
  { 6566, 42, 50, 42, 1, -50 },
  { 6829, 17, 50, 18, 1, -50 },
  { 6936, 34, 51, 34, 0, -50 },
  { 7153, 42, 50, 38, 1, -50 },
  { 7416, 28, 50, 33, 1, -50 },
  { 7591, 52, 50, 52, 1, -50 },
  { 7916, 42, 50, 42, 1, -50 },
  { 8179, 37, 52, 42, 3, -51 },
  { 8420, 38, 50, 39, 1, -50 },
  { 8658, 37, 60, 42, 3, -51 },
  { 8936, 36, 50, 37, 1, -50 },
  { 9161, 36, 52, 37, 1, -51 },
  { 9395, 34, 50, 37, 6, -50 },
  { 9608, 37, 51, 39, 3, -50 },
  { 9844, 37, 50, 39, 6, -50 },
  { 10076, 48, 50, 52, 7, -50 },
  { 10376, 43, 50, 38, -2, -50 },
  { 10645, 35, 50, 37, 6, -50 },
  { 10864, 39, 50, 36, -1, -50 },
  { 11108, 23, 69, 18, -1, -58 },
  { 11307, 16, 54, 26, 6, -50 },
  { 11415, 23, 69, 18, -4, -58 },
  { 11614, 22, 25, 26, 3, -50 },
  { 11683, 27, 7, 28, -4, 0 },
  { 11707, 14, 10, 22, 7, -53 },
  { 11725, 29, 40, 33, 1, -39 },
  { 11870, 32, 54, 34, 0, -53 },
  { 12086, 28, 40, 32, 2, -39 },
  { 12226, 34, 54, 34, 2, -53 },
  { 12456, 29, 40, 33, 2, -39 },
  { 12601, 24, 54, 22, 3, -54 },
  { 12763, 33, 53, 34, 0, -39 },
  { 12982, 30, 53, 34, 0, -53 },
  { 13181, 16, 52, 17, 1, -52 },
  { 13285, 24, 66, 16, -7, -52 },
  { 13483, 34, 53, 32, 0, -53 },
  { 13709, 17, 53, 17, 1, -53 },
  { 13822, 48, 39, 51, 0, -39 },
  { 14056, 30, 39, 34, 0, -39 },
  { 14203, 30, 40, 34, 2, -39 },
  { 14353, 33, 53, 34, -2, -39 },
  { 14572, 31, 53, 34, 2, -39 },
  { 14778, 23, 39, 22, 0, -39 },
  { 14891, 28, 40, 31, 1, -39 },
  { 15031, 19, 48, 21, 3, -47 },
  { 15145, 31, 39, 34, 2, -38 },
  { 15297, 28, 38, 30, 4, -38 },
  { 15430, 42, 38, 44, 4, -38 },
  { 15630, 34, 38, 31, -2, -38 },
  { 15792, 34, 52, 30, -2, -38 },
  { 16013, 32, 38, 31, -1, -38 },
  { 16165, 22, 68, 21, 2, -55 },
  { 16352, 15, 59, 17, 1, -50 },
  { 16463, 22, 68, 21, -3, -55 },
  { 16650, 33, 15, 39, 3, -28 },
};

const GFXfont RobotoCondensed_MediumItalic71pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_MediumItalic71pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_MediumItalic71pt7bGlyphs,
  0x20, 0x7E, 83
};

#endif // _ROBOTOCONDENSED_MEDIUMITALIC71PT7B_H_
