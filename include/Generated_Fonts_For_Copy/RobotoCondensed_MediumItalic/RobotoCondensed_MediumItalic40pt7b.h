#ifndef _ROBOTOCONDENSED_MEDIUMITALIC40PT7B_H_
#define _ROBOTOCONDENSED_MEDIUMITALIC40PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-MediumItalic.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_MediumItalic40pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF0, 0x78, 0x3C, 0x3E, 0x1F, 0x0F,
  0x07, 0x83, 0xC1, 0xE1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0xF8, 0x7C, 0x3E, 0x0E, 0x00, 0x39, 0xEF, 0x39,
  0xE7, 0x38, 0xE7, 0x1C, 0xE7, 0x9C, 0xE7, 0x1C, 0xE3, 0x9C, 0x70, 0x00,
  0x38, 0xE0, 0x03, 0x8E, 0x00, 0x38, 0xE0, 0x07, 0x1C, 0x00, 0x71, 0xC0,
  0x07, 0x1C, 0x00, 0xE3, 0x80, 0x0E, 0x38, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF,
  0x1F, 0xFF, 0xF0, 0x1C, 0x70, 0x03, 0x8F, 0x00, 0x38, 0xE0, 0x03, 0x8E,
  0x00, 0x71, 0xE0, 0x07, 0x1C, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0x8F, 0xFF,
  0xF8, 0x0E, 0x38, 0x01, 0xC7, 0x80, 0x1C, 0x70, 0x01, 0xC7, 0x00, 0x38,
  0xF0, 0x03, 0x8E, 0x00, 0x38, 0xE0, 0x07, 0x1E, 0x00, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0xFC, 0x00, 0xFF, 0x80, 0x7F,
  0xF0, 0x1F, 0xFE, 0x0F, 0x8F, 0x83, 0xC1, 0xE1, 0xF0, 0x7C, 0x7C, 0x1F,
  0x1F, 0x07, 0xC7, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xE0, 0x01,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01,
  0xF3, 0xE0, 0x7C, 0xF8, 0x1F, 0x3E, 0x07, 0xC7, 0x81, 0xE1, 0xF0, 0xF8,
  0x7F, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0x00, 0x3F, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0xE0, 0x07, 0xF8,
  0x03, 0xCF, 0x04, 0xE1, 0xC3, 0xB8, 0x71, 0xEE, 0x1C, 0x73, 0x87, 0x38,
  0xE3, 0xDE, 0x38, 0xE7, 0x0F, 0xFB, 0x81, 0xFD, 0xC0, 0x3E, 0xF0, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x7C, 0x07, 0xBF, 0x81, 0xDF, 0xF0, 0xE7,
  0x1C, 0x7B, 0x87, 0x1C, 0xE1, 0xCE, 0x38, 0x77, 0x0E, 0x1F, 0xC3, 0x87,
  0x60, 0xE3, 0x80, 0x3F, 0xE0, 0x07, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0x3F, 0xC0, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x78, 0xF0, 0x1F, 0x1E, 0x03,
  0xC3, 0xC0, 0x78, 0x78, 0x0F, 0x1F, 0x01, 0xE7, 0xC0, 0x1F, 0xF0, 0x03,
  0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x79, 0xFF, 0x8F, 0x3F,
  0xF1, 0xEF, 0x9F, 0x7B, 0xE1, 0xEF, 0x7C, 0x3F, 0xEF, 0x83, 0xF9, 0xF0,
  0x7F, 0x3E, 0x07, 0xC7, 0xC1, 0xF8, 0x7F, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF,
  0xDF, 0x07, 0xE3, 0xE0, 0x7B, 0xDE, 0xE7, 0x3B, 0xDC, 0xE7, 0x00, 0x00,
  0x10, 0x07, 0x00, 0xF0, 0x1E, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0xF0, 0x0F,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78,
  0x07, 0x80, 0x78, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1C, 0x00, 0xC0, 0x04,
  0x00, 0x01, 0x00, 0x30, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xE0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x07, 0x80,
  0x78, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x0E,
  0x00, 0x40, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01,
  0xC0, 0x71, 0xC7, 0x7D, 0xDF, 0xFF, 0xFF, 0x1F, 0xFE, 0x07, 0xE0, 0x07,
  0xC0, 0x0F, 0xE0, 0x1E, 0xF0, 0x3C, 0x70, 0x78, 0x78, 0x30, 0x70, 0x10,
  0x20, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07,
  0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x1E, 0x3C, 0x78, 0xF3,
  0xE7, 0x8F, 0x3C, 0xF9, 0xE1, 0x80, 0x7F, 0xDF, 0xE7, 0xFB, 0xFE, 0x7F,
  0xFF, 0xF7, 0x00, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C,
  0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E,
  0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00,
  0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xF8, 0x03, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xE1, 0xF1, 0xF1, 0xF0, 0x78,
  0xF0, 0x3C, 0x78, 0x1E, 0x7C, 0x0F, 0x3E, 0x07, 0x9E, 0x03, 0xCF, 0x01,
  0xE7, 0x80, 0xF7, 0xC0, 0x7B, 0xE0, 0x7D, 0xF0, 0x3E, 0xF0, 0x1E, 0x78,
  0x0F, 0x3C, 0x07, 0x9E, 0x07, 0xCF, 0x03, 0xE7, 0x81, 0xE3, 0xC1, 0xF1,
  0xF0, 0xF0, 0x7F, 0xF8, 0x3F, 0xF8, 0x0F, 0xF8, 0x03, 0xF0, 0x00, 0x00,
  0x60, 0x7C, 0x3F, 0x3F, 0xEF, 0xFD, 0xFF, 0xB9, 0xF4, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x07, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x03, 0xE0,
  0x7C, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0x80, 0xF0,
  0x1E, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xE0, 0x0F, 0xFE, 0x03, 0xFF, 0xE0,
  0xF8, 0x7C, 0x1E, 0x07, 0x87, 0xC0, 0xF8, 0xF8, 0x1E, 0x1E, 0x03, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7F,
  0xFF, 0x8F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0x80, 0x00, 0xF8, 0x00,
  0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xFE, 0x1F, 0x0F, 0x87, 0xC1, 0xE1, 0xE0,
  0x78, 0xF8, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C,
  0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0xF0, 0x1F, 0x3C, 0x07, 0x8F, 0x83,
  0xE3, 0xE1, 0xF8, 0x7F, 0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xDE, 0x00, 0xFF, 0x80, 0x7B, 0xE0, 0x3E,
  0xF8, 0x0F, 0x3C, 0x07, 0x8F, 0x03, 0xE3, 0xC0, 0xF1, 0xF0, 0x78, 0x7C,
  0x3E, 0x1E, 0x0F, 0x07, 0x87, 0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x07, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE,
  0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F,
  0x80, 0x03, 0xDF, 0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xFF, 0x87, 0xC3,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0xF0, 0x1E, 0x3C, 0x0F, 0x8F, 0x03, 0xC3, 0xE1, 0xF0, 0x7F, 0xF8, 0x1F,
  0xFE, 0x03, 0xFE, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0xFE, 0x01, 0xFE,
  0x07, 0xFC, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00,
  0x3D, 0xF0, 0x7F, 0xF8, 0x7F, 0xFC, 0x7F, 0xFE, 0x7C, 0x3E, 0xF8, 0x1E,
  0xF8, 0x1E, 0xF8, 0x1E, 0xF8, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E,
  0xF0, 0x3E, 0xF8, 0x3C, 0x78, 0x7C, 0x7F, 0xF8, 0x3F, 0xF0, 0x3F, 0xE0,
  0x0F, 0xC0, 0x3F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xFD, 0xFF, 0xFF, 0x00,
  0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F,
  0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00,
  0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F,
  0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xF0,
  0x3F, 0xFE, 0x0F, 0x8F, 0x83, 0xC1, 0xE1, 0xF0, 0x7C, 0x7C, 0x1E, 0x1F,
  0x07, 0x87, 0xC3, 0xE0, 0xF0, 0xF0, 0x3F, 0xFC, 0x07, 0xFE, 0x03, 0xFE,
  0x01, 0xFF, 0xC0, 0xF8, 0xF8, 0x7C, 0x1E, 0x1E, 0x07, 0xC7, 0x81, 0xF3,
  0xE0, 0x7C, 0xF8, 0x1F, 0x3E, 0x07, 0x8F, 0x83, 0xE1, 0xF1, 0xF8, 0x7F,
  0xFC, 0x0F, 0xFE, 0x01, 0xFF, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x1F, 0xF0,
  0x7F, 0xF1, 0xFF, 0xE3, 0xE3, 0xCF, 0x87, 0xDE, 0x07, 0xFC, 0x0F, 0xF8,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x81, 0xFF, 0x03, 0xFF, 0x07, 0xFE, 0x1F,
  0x3F, 0xFE, 0x7F, 0xFC, 0x7F, 0xF8, 0x7D, 0xE0, 0x03, 0xC0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x07, 0xF0, 0x7F, 0xC0, 0xFF, 0x01, 0xF8, 0x03, 0xC0,
  0x00, 0x1E, 0x1F, 0x1F, 0x1F, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0xF8, 0xF8, 0xF8, 0x70, 0x03,
  0xC0, 0xFC, 0x1F, 0x81, 0xE0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x7C, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x81, 0xE0, 0x7C, 0x0F, 0x03, 0xC0,
  0x10, 0x00, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x78, 0x03, 0xF0, 0x1F, 0xE0,
  0xFF, 0x87, 0xFC, 0x3F, 0xE0, 0x7E, 0x01, 0xF0, 0x03, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x70,
  0x00, 0x40, 0x3F, 0xFF, 0x3F, 0xFF, 0x7F, 0xFE, 0x7F, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC,
  0xFF, 0xFC, 0x10, 0x00, 0x1C, 0x00, 0x1F, 0x00, 0x3F, 0x80, 0x1F, 0xE0,
  0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x1E, 0x00, 0x7E, 0x01, 0xFE,
  0x07, 0xFC, 0x3F, 0xF0, 0x7F, 0x80, 0x7E, 0x00, 0xF8, 0x00, 0xE0, 0x00,
  0x80, 0x00, 0x07, 0xE0, 0x7F, 0xC3, 0xFF, 0x9F, 0xFF, 0x7C, 0x7F, 0xE1,
  0xFF, 0x87, 0xFE, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x0E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF,
  0xFC, 0x00, 0x7C, 0x07, 0xC0, 0x1E, 0x00, 0x38, 0x07, 0x80, 0x03, 0x81,
  0xE0, 0x00, 0x70, 0x38, 0x00, 0x07, 0x0F, 0x07, 0xC0, 0xE1, 0xC1, 0xFE,
  0x1C, 0x70, 0x7F, 0xE3, 0x8E, 0x1E, 0x3C, 0x73, 0x87, 0x87, 0x0E, 0x70,
  0xF0, 0xE1, 0xDE, 0x1C, 0x1C, 0x3B, 0x87, 0x87, 0x87, 0x70, 0xE0, 0xE0,
  0xEE, 0x1C, 0x1C, 0x1F, 0xC7, 0x83, 0x83, 0xF0, 0xF0, 0xF0, 0x6E, 0x1E,
  0x1C, 0x1D, 0xC3, 0xC3, 0x83, 0xB8, 0x70, 0xF0, 0x67, 0x0F, 0x1E, 0x1C,
  0xE1, 0xE7, 0xC7, 0x1C, 0x3F, 0xFF, 0xE3, 0x83, 0xF3, 0xF8, 0x70, 0x3C,
  0x3C, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x60, 0x00, 0x7F, 0xFC,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3D, 0xE0, 0x00, 0xF3, 0xC0,
  0x07, 0x8F, 0x00, 0x1E, 0x3C, 0x00, 0xF8, 0xF0, 0x03, 0xC3, 0xC0, 0x1F,
  0x0F, 0x00, 0x78, 0x3C, 0x03, 0xE0, 0xF8, 0x0F, 0x03, 0xE0, 0x7F, 0xFF,
  0x81, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xF0, 0x07, 0x87,
  0xC0, 0x1F, 0x3E, 0x00, 0x7C, 0xF8, 0x01, 0xF7, 0xC0, 0x07, 0xDF, 0x00,
  0x1F, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F,
  0x03, 0xE1, 0xF0, 0x1F, 0x1F, 0x01, 0xF1, 0xF0, 0x1F, 0x1F, 0x01, 0xE1,
  0xE0, 0x3E, 0x1E, 0x07, 0xE3, 0xFF, 0xFC, 0x3F, 0xFF, 0x03, 0xFF, 0xF0,
  0x3F, 0xFF, 0x83, 0xC0, 0xF8, 0x3C, 0x07, 0xC7, 0xC0, 0x7C, 0x7C, 0x07,
  0xC7, 0xC0, 0x7C, 0x7C, 0x07, 0xC7, 0x80, 0x7C, 0xF8, 0x0F, 0x8F, 0x81,
  0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0x00,
  0x7E, 0x00, 0x1F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x1F, 0x83, 0xE1,
  0xF0, 0x1E, 0x3E, 0x01, 0xF3, 0xE0, 0x1F, 0x3C, 0x01, 0xF7, 0xC0, 0x1F,
  0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x07, 0xCF, 0x00,
  0x7C, 0xF8, 0x07, 0x8F, 0x80, 0xF8, 0xF8, 0x0F, 0x87, 0xC1, 0xF0, 0x7F,
  0xFE, 0x03, 0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xFC, 0x00,
  0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0xFF, 0xFC, 0x0F, 0x07, 0xE1, 0xF0, 0x3E,
  0x1F, 0x01, 0xE1, 0xF0, 0x1F, 0x1F, 0x01, 0xF1, 0xE0, 0x1F, 0x1E, 0x01,
  0xF3, 0xE0, 0x1F, 0x3E, 0x01, 0xF3, 0xE0, 0x1F, 0x3E, 0x01, 0xE3, 0xC0,
  0x1E, 0x3C, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3C, 0x78,
  0x07, 0xC7, 0x80, 0x78, 0xF8, 0x0F, 0x8F, 0x83, 0xF0, 0xFF, 0xFE, 0x0F,
  0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0xFF, 0xFE,
  0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xFF,
  0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0,
  0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF,
  0x87, 0xFF, 0xF0, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xFF, 0xF0,
  0x7F, 0xFE, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x1F, 0x83,
  0xE1, 0xF0, 0x1F, 0x3E, 0x01, 0xF3, 0xE0, 0x1F, 0x3C, 0x00, 0xF7, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x83, 0xFE, 0xF8,
  0x3F, 0xEF, 0x83, 0xFE, 0xF8, 0x3F, 0xEF, 0x80, 0x3C, 0xF8, 0x03, 0xCF,
  0x80, 0x7C, 0xF8, 0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x07, 0xC7, 0xC1, 0xFC,
  0x7F, 0xFF, 0x83, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x7F, 0x00, 0x0F, 0x80,
  0x1E, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x78, 0x01, 0xF0, 0xF0, 0x03,
  0xC3, 0xE0, 0x07, 0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x7C,
  0x3C, 0x00, 0xF8, 0x78, 0x01, 0xE1, 0xF0, 0x03, 0xC3, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x3C, 0x00, 0xF0, 0xF8,
  0x01, 0xE1, 0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0x87, 0x80, 0x1F, 0x0F, 0x00,
  0x3C, 0x3E, 0x00, 0x78, 0x7C, 0x01, 0xF0, 0xF8, 0x03, 0xE1, 0xF0, 0x07,
  0xC3, 0xC0, 0x0F, 0x87, 0x80, 0x1E, 0x00, 0x07, 0x87, 0xC3, 0xE1, 0xF0,
  0xF8, 0x78, 0x3C, 0x3E, 0x1F, 0x0F, 0x87, 0x83, 0xC3, 0xE1, 0xF0, 0xF8,
  0x7C, 0x3C, 0x1E, 0x1F, 0x0F, 0x87, 0xC3, 0xC1, 0xE0, 0xF0, 0xF8, 0x7C,
  0x3E, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C,
  0x7C, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x3C, 0x1E, 0x0F, 0x83, 0xE3, 0xF0,
  0x7F, 0xFC, 0x07, 0xFF, 0x00, 0x7F, 0xC0, 0x07, 0xE0, 0x00, 0x0F, 0x80,
  0x7E, 0x1F, 0x01, 0xF8, 0x3E, 0x07, 0xE0, 0x78, 0x1F, 0x80, 0xF0, 0x7E,
  0x03, 0xE0, 0xF8, 0x07, 0xC3, 0xE0, 0x0F, 0x8F, 0xC0, 0x1F, 0x3F, 0x00,
  0x3C, 0xFC, 0x00, 0x79, 0xF0, 0x01, 0xF7, 0xC0, 0x03, 0xFF, 0x00, 0x07,
  0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0xFE,
  0xF8, 0x01, 0xF8, 0xF8, 0x03, 0xE1, 0xF0, 0x07, 0x83, 0xE0, 0x0F, 0x03,
  0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x0F, 0x81, 0xF0, 0x1F,
  0x03, 0xC0, 0x3F, 0x07, 0x80, 0x3E, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1E,
  0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xC0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0x83, 0xF8, 0x01, 0xFC, 0x1F,
  0xC0, 0x0F, 0xE0, 0xFE, 0x00, 0x7F, 0x0F, 0xF0, 0x07, 0xF8, 0x7F, 0x80,
  0x3F, 0xC3, 0xFC, 0x03, 0xFC, 0x1E, 0xE0, 0x1F, 0xE0, 0xF7, 0x01, 0xEF,
  0x07, 0xBC, 0x0F, 0x78, 0x7D, 0xE0, 0xF7, 0xC3, 0xEF, 0x07, 0xBC, 0x1F,
  0x78, 0x79, 0xE0, 0xF3, 0xC3, 0xCF, 0x07, 0x9E, 0x3C, 0xF8, 0x3C, 0x71,
  0xE7, 0xC3, 0xE3, 0x8E, 0x3E, 0x1F, 0x1C, 0xF1, 0xE0, 0xF8, 0xF7, 0x0F,
  0x07, 0x87, 0xF8, 0xF8, 0x3C, 0x3F, 0xC7, 0xC3, 0xE1, 0xFC, 0x3E, 0x1F,
  0x0F, 0xE1, 0xF0, 0xF8, 0x3E, 0x0F, 0x07, 0xC1, 0xF0, 0x78, 0x3C, 0x0F,
  0x07, 0xC1, 0xE0, 0x78, 0x3E, 0x00, 0x0F, 0x80, 0x1E, 0x1F, 0x00, 0x7C,
  0x3F, 0x00, 0xF8, 0x7E, 0x01, 0xF0, 0xFC, 0x03, 0xC3, 0xFC, 0x07, 0x87,
  0xF8, 0x1F, 0x0F, 0xF0, 0x3E, 0x1F, 0xF0, 0x7C, 0x3D, 0xE0, 0xF8, 0x7B,
  0xC1, 0xE1, 0xF3, 0x83, 0xC3, 0xE7, 0x8F, 0x87, 0xCF, 0x1F, 0x0F, 0x8E,
  0x3E, 0x1E, 0x1E, 0x78, 0x3C, 0x3C, 0xF0, 0xF8, 0x39, 0xE1, 0xF0, 0x7F,
  0xC3, 0xE0, 0xFF, 0x87, 0xC1, 0xFF, 0x0F, 0x01, 0xFC, 0x3E, 0x03, 0xF8,
  0x7C, 0x07, 0xF0, 0xF8, 0x07, 0xE1, 0xF0, 0x0F, 0xC3, 0xC0, 0x1F, 0x87,
  0x80, 0x1E, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF,
  0xFE, 0x0F, 0x83, 0xE1, 0xF0, 0x1F, 0x3E, 0x01, 0xF3, 0xE0, 0x0F, 0x3C,
  0x00, 0xF7, 0xC0, 0x0F, 0x7C, 0x00, 0xF7, 0x80, 0x1F, 0x78, 0x01, 0xF7,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xEF, 0x80, 0x1E,
  0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xCF, 0x80, 0x7C, 0x78, 0x0F,
  0x87, 0xC1, 0xF8, 0x7F, 0xFF, 0x03, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x7F,
  0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0,
  0xF0, 0x1F, 0x0F, 0x80, 0x78, 0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x00,
  0xF8, 0xF0, 0x07, 0xC7, 0x80, 0x3C, 0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x1F,
  0x03, 0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x3F, 0xFF, 0x03, 0xFF, 0xE0,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF,
  0xFE, 0x1F, 0x83, 0xE1, 0xF0, 0x1F, 0x3E, 0x01, 0xF3, 0xE0, 0x1F, 0x3C,
  0x00, 0xF7, 0xC0, 0x0F, 0x7C, 0x00, 0xF7, 0x80, 0x1F, 0x78, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1E, 0xF8, 0x01, 0xEF, 0x80, 0x3E,
  0xF0, 0x03, 0xEF, 0x00, 0x3C, 0xF8, 0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x0F,
  0x87, 0xC1, 0xF8, 0x7F, 0xFF, 0x03, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x70, 0x00,
  0x04, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE,
  0x0F, 0x03, 0xE0, 0xF0, 0x1F, 0x1F, 0x01, 0xF1, 0xF0, 0x1F, 0x1F, 0x01,
  0xF1, 0xE0, 0x1F, 0x1E, 0x01, 0xE3, 0xE0, 0x3E, 0x3E, 0x0F, 0xC3, 0xFF,
  0xFC, 0x3F, 0xFF, 0x83, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xC3, 0xE0, 0x7C,
  0x3E, 0x07, 0xC3, 0xE0, 0x7C, 0x1F, 0x07, 0x81, 0xF0, 0x78, 0x1F, 0x0F,
  0x81, 0xF0, 0xF8, 0x0F, 0x8F, 0x80, 0xF8, 0xF0, 0x0F, 0x8F, 0x00, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xC3,
  0xE1, 0xF0, 0x3E, 0x1F, 0x01, 0xE1, 0xE0, 0x1F, 0x1E, 0x01, 0xF1, 0xF0,
  0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x01,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0x8F,
  0x80, 0x78, 0xF8, 0x07, 0x8F, 0x80, 0xF8, 0xF8, 0x0F, 0x87, 0xC1, 0xF0,
  0x7F, 0xFF, 0x03, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x7F, 0x00, 0x7F, 0xFF,
  0xE7, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x7C, 0x3C,
  0x01, 0xE0, 0xF0, 0x07, 0x83, 0xC0, 0x1E, 0x1F, 0x00, 0xF8, 0x7C, 0x03,
  0xE1, 0xF0, 0x0F, 0x87, 0x80, 0x3C, 0x1E, 0x00, 0xF0, 0xF8, 0x07, 0xC3,
  0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x3E, 0x01, 0xF0, 0xF0, 0x07, 0x83, 0xC0,
  0x1E, 0x1F, 0x00, 0xF8, 0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x3E,
  0x1E, 0x00, 0xF0, 0x78, 0x07, 0xC1, 0xE0, 0x1F, 0x07, 0xC0, 0xF8, 0x1F,
  0x87, 0xE0, 0x3F, 0xFF, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x01, 0xFC,
  0x00, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xDE, 0x00, 0x7C, 0xF8, 0x03, 0xE7,
  0xC0, 0x3E, 0x3E, 0x01, 0xF1, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0x7C, 0x0F,
  0x81, 0xE0, 0x7C, 0x0F, 0x03, 0xE0, 0x78, 0x3E, 0x03, 0xC1, 0xF0, 0x1E,
  0x1F, 0x00, 0xF8, 0xF8, 0x07, 0xC7, 0x80, 0x3E, 0x7C, 0x00, 0xF3, 0xC0,
  0x07, 0xBE, 0x00, 0x3D, 0xE0, 0x01, 0xEF, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF0, 0x1E, 0x03, 0xFE, 0x03, 0xC0, 0x7F, 0xC0, 0x78,
  0x0F, 0x78, 0x1F, 0x03, 0xEF, 0x03, 0xE0, 0x7D, 0xE0, 0xFC, 0x0F, 0x3C,
  0x1F, 0xC3, 0xE7, 0x83, 0xF8, 0x7C, 0xF0, 0xFF, 0x0F, 0x1E, 0x1F, 0xE3,
  0xE3, 0xC3, 0xBC, 0x78, 0x78, 0xF7, 0x8F, 0x0F, 0x1E, 0xF3, 0xE1, 0xE3,
  0x9E, 0x78, 0x3C, 0xF3, 0xCF, 0x07, 0x9E, 0x7B, 0xE0, 0xF7, 0x8F, 0x78,
  0x1E, 0xF1, 0xEF, 0x03, 0xDC, 0x1F, 0xE0, 0x7F, 0x83, 0xF8, 0x0F, 0xF0,
  0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x81, 0xF8, 0x07, 0xF0, 0x3F, 0x00,
  0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xF8, 0x03, 0xF0, 0x1F, 0x00, 0x7C, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x3F, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x7E, 0x03,
  0xE0, 0x7C, 0x03, 0xE0, 0xF8, 0x01, 0xE1, 0xF8, 0x01, 0xF1, 0xF0, 0x01,
  0xF3, 0xE0, 0x00, 0xF3, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xEF, 0x80, 0x03,
  0xEF, 0x80, 0x07, 0xCF, 0x80, 0x0F, 0x87, 0xC0, 0x0F, 0x87, 0xC0, 0x1F,
  0x07, 0xC0, 0x3F, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7C, 0x03, 0xE0, 0xFC,
  0x03, 0xF0, 0x78, 0x01, 0xF7, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x7C,
  0x3C, 0x07, 0xC3, 0xC0, 0xF8, 0x3E, 0x1F, 0x03, 0xE1, 0xF0, 0x1E, 0x3E,
  0x01, 0xE3, 0xE0, 0x1E, 0x7C, 0x01, 0xF7, 0x80, 0x0F, 0xF8, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x03, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x78, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC0,
  0x3E, 0x01, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF0, 0x00, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF8, 0xF8, 0x78, 0x78, 0x78, 0x78, 0x78, 0x7C, 0x7C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3E, 0x3E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1F,
  0x1F, 0x0F, 0x0F, 0x03, 0xF8, 0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0x0F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x81,
  0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0xF8,
  0x07, 0xC0, 0x7F, 0x03, 0xB8, 0x3D, 0xC1, 0xCE, 0x1E, 0x70, 0xE3, 0x8F,
  0x1E, 0x70, 0xF7, 0x87, 0xBC, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xF8, 0x7C, 0x3C, 0x3E, 0x1E, 0x0F, 0x01, 0xF0, 0x07, 0xFC,
  0x0F, 0xFE, 0x1F, 0xFE, 0x3E, 0x1F, 0x3C, 0x1F, 0x3C, 0x1F, 0x00, 0x1E,
  0x07, 0xFE, 0x1F, 0xFE, 0x3F, 0xFE, 0x7E, 0x3E, 0xF8, 0x3E, 0xF8, 0x3C,
  0xF0, 0x3C, 0xF0, 0x3C, 0xF8, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0x7F, 0xFC,
  0x1E, 0x7C, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xCF,
  0x80, 0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xE3, 0xE1, 0xE0, 0x7C,
  0x78, 0x1F, 0x1E, 0x07, 0xCF, 0x81, 0xF3, 0xE0, 0x7C, 0xF0, 0x1E, 0x3C,
  0x07, 0x8F, 0x01, 0xE7, 0xC0, 0x79, 0xF0, 0x3E, 0x7C, 0x0F, 0x1F, 0x87,
  0xC7, 0xFF, 0xE1, 0xFF, 0xF8, 0xFB, 0xFC, 0x3C, 0x7C, 0x00, 0x03, 0xF0,
  0x07, 0xFC, 0x1F, 0xFE, 0x1F, 0xFE, 0x3E, 0x1F, 0x3C, 0x0F, 0x7C, 0x0F,
  0x78, 0x0F, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x3E, 0xF8, 0x3C, 0x78, 0x7C, 0x7F, 0xFC, 0x7F, 0xF8,
  0x3F, 0xF0, 0x0F, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x7C, 0xF0, 0x3F, 0xDE, 0x0F, 0xFF, 0xC3, 0xFF, 0xF8, 0x7C,
  0x3F, 0x1F, 0x03, 0xE3, 0xE0, 0x78, 0x78, 0x0F, 0x0F, 0x01, 0xE3, 0xE0,
  0x7C, 0x7C, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x3C, 0x3E, 0x07, 0x87, 0xC0,
  0xF0, 0xF8, 0x3E, 0x1F, 0x0F, 0xC1, 0xFF, 0xF8, 0x3F, 0xFE, 0x03, 0xFF,
  0xC0, 0x3E, 0x78, 0x00, 0x01, 0xF8, 0x07, 0xFC, 0x0F, 0xFE, 0x1F, 0xFE,
  0x3E, 0x1F, 0x3C, 0x0F, 0x7C, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x08,
  0x7C, 0x1C, 0x7F, 0xFC, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xE0, 0x00, 0xF8,
  0x1F, 0xC1, 0xFE, 0x0F, 0xF0, 0xF8, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x1F,
  0x03, 0xFF, 0x3F, 0xF9, 0xFF, 0xCF, 0xFC, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x00, 0x01,
  0xF1, 0xE0, 0xFF, 0x7C, 0x3F, 0xFF, 0x0F, 0xFF, 0xE1, 0xF0, 0xFC, 0x7C,
  0x0F, 0x8F, 0x81, 0xF1, 0xE0, 0x3E, 0x3C, 0x07, 0x8F, 0x80, 0xF1, 0xF0,
  0x1E, 0x3E, 0x07, 0xC7, 0xC0, 0xF8, 0xF8, 0x1E, 0x1F, 0x03, 0xC3, 0xE0,
  0x78, 0x7E, 0x1F, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0xF9,
  0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x60, 0x7C, 0x1F, 0xFF,
  0x83, 0xFF, 0xE0, 0x3F, 0xF8, 0x01, 0xFC, 0x00, 0x07, 0xC0, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x9F, 0x07, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xF8,
  0xF8, 0x7C, 0x78, 0x1E, 0x3C, 0x0F, 0x3E, 0x07, 0x9F, 0x07, 0xCF, 0x83,
  0xE7, 0x81, 0xF3, 0xC0, 0xF1, 0xE0, 0x79, 0xF0, 0x3C, 0xF8, 0x3E, 0x7C,
  0x1F, 0x3C, 0x0F, 0x9E, 0x07, 0x8F, 0x03, 0xCF, 0x81, 0xE7, 0xC1, 0xF0,
  0x03, 0x81, 0xF0, 0x7C, 0x1F, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x03,
  0xC0, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xE0, 0x78, 0x1E, 0x0F, 0x83, 0xE0,
  0xF8, 0x3C, 0x0F, 0x03, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0x81, 0xE0, 0x78,
  0x00, 0x00, 0x38, 0x01, 0xE0, 0x07, 0xC0, 0x1E, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x03, 0xFC,
  0x0F, 0xE0, 0x3F, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0xFC, 0x3C, 0x3F, 0x0F, 0x8F, 0xC1, 0xF1,
  0xF0, 0x3E, 0x7C, 0x07, 0x9F, 0x00, 0xF7, 0xC0, 0x1F, 0xF0, 0x07, 0xFC,
  0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xBE,
  0x03, 0xE3, 0xC0, 0x7C, 0x7C, 0x0F, 0x0F, 0x81, 0xE0, 0xF0, 0x3C, 0x1F,
  0x0F, 0x83, 0xE1, 0xF0, 0x3E, 0x00, 0x03, 0xC1, 0xF0, 0x7C, 0x1E, 0x07,
  0x81, 0xE0, 0x78, 0x3E, 0x0F, 0x83, 0xC0, 0xF0, 0x3C, 0x1F, 0x07, 0xC1,
  0xF0, 0x78, 0x1E, 0x07, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x03, 0xC0, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xE0, 0x78, 0x1E, 0x00, 0x0F, 0x3E, 0x0F, 0x81,
  0xFF, 0xE7, 0xF8, 0x7F, 0xFD, 0xFF, 0x0F, 0xFF, 0xFF, 0xF1, 0xF0, 0xFE,
  0x3E, 0x3C, 0x1F, 0x87, 0xC7, 0x81, 0xE0, 0x78, 0xF0, 0x3C, 0x0F, 0x3E,
  0x0F, 0x83, 0xE7, 0xC1, 0xF0, 0x7C, 0xF0, 0x3C, 0x0F, 0x9E, 0x07, 0x81,
  0xE3, 0xC0, 0xF0, 0x3C, 0x78, 0x1E, 0x07, 0x9F, 0x07, 0xC1, 0xF3, 0xE0,
  0xF8, 0x3E, 0x78, 0x1E, 0x07, 0x8F, 0x03, 0xC0, 0xF1, 0xE0, 0x78, 0x1E,
  0x7C, 0x1F, 0x03, 0xCF, 0x83, 0xE0, 0xF8, 0x0F, 0x3E, 0x0F, 0xFF, 0x87,
  0xFF, 0xC3, 0xFF, 0xF1, 0xF0, 0xF8, 0xF8, 0x3C, 0x78, 0x1E, 0x7C, 0x0F,
  0x3E, 0x0F, 0x9F, 0x07, 0xCF, 0x03, 0xE7, 0x81, 0xE3, 0xC0, 0xF3, 0xE0,
  0x79, 0xF0, 0x7C, 0xF8, 0x3E, 0x78, 0x1F, 0x3C, 0x0F, 0x1E, 0x07, 0x9F,
  0x03, 0xCF, 0x83, 0xE0, 0x01, 0xF8, 0x03, 0xFE, 0x03, 0xFF, 0x83, 0xFF,
  0xE3, 0xE1, 0xF1, 0xE0, 0x7D, 0xF0, 0x3E, 0xF0, 0x1F, 0x78, 0x0F, 0xFC,
  0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xF7, 0xC0, 0x7B, 0xE0, 0x7D,
  0xF0, 0x3C, 0x7C, 0x3E, 0x3F, 0xFE, 0x0F, 0xFE, 0x03, 0xFE, 0x00, 0xFC,
  0x00, 0x07, 0x9F, 0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xF8,
  0x7C, 0x1E, 0x07, 0xC3, 0xC0, 0xF8, 0x78, 0x1F, 0x1F, 0x03, 0xE3, 0xE0,
  0x7C, 0x78, 0x0F, 0x0F, 0x01, 0xE1, 0xE0, 0x3C, 0x7C, 0x0F, 0x8F, 0x81,
  0xF1, 0xF0, 0x3C, 0x3E, 0x0F, 0x87, 0xFF, 0xE0, 0xFF, 0xFC, 0x3E, 0xFF,
  0x07, 0xCF, 0x80, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE7,
  0xC3, 0xFD, 0xE1, 0xFF, 0xF8, 0xFF, 0xFE, 0x3E, 0x1F, 0x9F, 0x03, 0xE7,
  0xC0, 0xF1, 0xE0, 0x3C, 0x78, 0x0F, 0x3E, 0x07, 0xCF, 0x81, 0xF3, 0xE0,
  0x7C, 0xF8, 0x1E, 0x3E, 0x07, 0x8F, 0x81, 0xE3, 0xE0, 0xF8, 0xF8, 0x7E,
  0x1F, 0xFF, 0x87, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0x3C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x0F, 0x78, 0x7F, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF,
  0x8F, 0x80, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xF0,
  0x0F, 0x80, 0x00, 0x01, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0xE1,
  0xF0, 0xF0, 0xF0, 0x78, 0x78, 0x3E, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xF0,
  0x01, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xF3, 0xE0, 0x78, 0xF0,
  0x3C, 0x78, 0x3E, 0x3F, 0xFE, 0x0F, 0xFF, 0x03, 0xFE, 0x00, 0x7E, 0x00,
  0x07, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0xFF, 0xDF, 0xFB, 0xFF, 0xFF,
  0xE3, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0xC1, 0xF8, 0x3F, 0x03, 0xE0,
  0x1E, 0x07, 0x9F, 0x03, 0xCF, 0x83, 0xE7, 0xC1, 0xF3, 0xC0, 0xF9, 0xE0,
  0x78, 0xF0, 0x3C, 0xF8, 0x1E, 0x7C, 0x1F, 0x3E, 0x0F, 0x9E, 0x07, 0xCF,
  0x03, 0xC7, 0x81, 0xE7, 0xC0, 0xF3, 0xE0, 0xF9, 0xF0, 0x7C, 0xF8, 0x7E,
  0x3F, 0xFE, 0x1F, 0xFF, 0x07, 0xF7, 0x81, 0xF3, 0xC0, 0xF8, 0x1F, 0xF8,
  0x1E, 0xF8, 0x3E, 0x78, 0x3C, 0x78, 0x7C, 0x78, 0x78, 0x78, 0x78, 0x78,
  0xF8, 0x78, 0xF0, 0x78, 0xF0, 0x79, 0xE0, 0x39, 0xE0, 0x3F, 0xC0, 0x3F,
  0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0xF8, 0x3C, 0x1F, 0x78, 0x3C, 0x1E, 0x78, 0x7C, 0x3E,
  0x78, 0x7C, 0x3C, 0x78, 0xFC, 0x3C, 0x78, 0xFC, 0x7C, 0x78, 0xFC, 0x78,
  0x79, 0xFC, 0x78, 0x79, 0xDC, 0xF0, 0x7B, 0xDC, 0xF0, 0x7B, 0xDC, 0xF0,
  0x7F, 0x9D, 0xE0, 0x7F, 0x9F, 0xE0, 0x7F, 0x1F, 0xC0, 0x7F, 0x1F, 0xC0,
  0x7E, 0x1F, 0xC0, 0x7E, 0x1F, 0x80, 0x7E, 0x0F, 0x80, 0x7C, 0x0F, 0x00,
  0x7C, 0x0F, 0x00, 0x78, 0x0F, 0x00, 0x0F, 0x03, 0xE1, 0xF0, 0xF8, 0x3E,
  0x3E, 0x03, 0xC7, 0xC0, 0x79, 0xF0, 0x0F, 0xBC, 0x00, 0xFF, 0x80, 0x1F,
  0xE0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0xF9, 0xE0, 0x1F, 0x3C, 0x07, 0xC7,
  0x81, 0xF0, 0xF8, 0x3E, 0x0F, 0x0F, 0x81, 0xE0, 0x1F, 0x03, 0xE3, 0xE0,
  0xF8, 0x7C, 0x1F, 0x07, 0x83, 0xC0, 0xF0, 0xF8, 0x1E, 0x1E, 0x03, 0xC7,
  0xC0, 0x78, 0xF8, 0x0F, 0x1E, 0x01, 0xE7, 0xC0, 0x3C, 0xF0, 0x07, 0xBE,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00,
  0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE3,
  0xFF, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7F, 0xFE, 0x3F, 0xFF, 0x1F, 0xFF, 0x8F,
  0xFF, 0xC0, 0x00, 0x10, 0x07, 0x00, 0xF0, 0x1E, 0x03, 0xC0, 0x3C, 0x07,
  0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F,
  0x01, 0xF0, 0x1E, 0x0F, 0xE0, 0xFC, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x60, 0x07,
  0x07, 0x07, 0x0F, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x1E, 0x1C, 0x1C, 0x1C,
  0x1C, 0x1C, 0x3C, 0x38, 0x38, 0x38, 0x38, 0x38, 0x78, 0x70, 0x70, 0x70,
  0x70, 0x70, 0x70, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0x03, 0x00, 0x1C, 0x00,
  0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x00, 0xF0, 0x07,
  0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE0,
  0x1E, 0x01, 0xF0, 0x0F, 0x01, 0xF0, 0x07, 0x00, 0x20, 0x00, 0x1F, 0x00,
  0x07, 0xF0, 0x39, 0xFF, 0x07, 0x3F, 0xF1, 0xEF, 0x1F, 0xFD, 0xE1, 0xFF,
  0x38, 0x1F, 0xC0, 0x01, 0xF0,
};

const GFXglyph RobotoCondensed_MediumItalic40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 9, 28, 10, 1, -28 },
  { 33, 11, 10, 12, 3, -30 },
  { 47, 20, 28, 21, 1, -28 },
  { 117, 18, 36, 19, 1, -32 },
  { 198, 18, 28, 25, 4, -28 },
  { 261, 19, 28, 22, 1, -28 },
  { 328, 5, 10, 7, 3, -30 },
  { 335, 12, 41, 12, 2, -32 },
  { 397, 12, 41, 12, -2, -32 },
  { 459, 16, 17, 17, 2, -28 },
  { 493, 17, 20, 19, 1, -23 },
  { 536, 7, 11, 9, -2, -5 },
  { 546, 10, 4, 12, 1, -14 },
  { 551, 5, 5, 11, 1, -5 },
  { 555, 18, 30, 14, -2, -28 },
  { 623, 17, 28, 19, 2, -28 },
  { 683, 11, 28, 19, 5, -28 },
  { 722, 19, 28, 19, 0, -28 },
  { 789, 18, 28, 19, 1, -28 },
  { 852, 18, 28, 19, 0, -28 },
  { 915, 18, 28, 19, 2, -28 },
  { 978, 16, 28, 19, 2, -28 },
  { 1034, 18, 28, 19, 2, -28 },
  { 1097, 18, 28, 19, 1, -28 },
  { 1160, 15, 28, 19, 3, -28 },
  { 1213, 8, 22, 10, 1, -22 },
  { 1235, 11, 28, 9, -2, -22 },
  { 1274, 15, 19, 17, 1, -22 },
  { 1310, 16, 12, 19, 2, -19 },
  { 1334, 16, 18, 18, 1, -21 },
  { 1370, 14, 28, 17, 3, -28 },
  { 1419, 27, 37, 30, 1, -28 },
  { 1544, 22, 28, 23, -2, -28 },
  { 1621, 20, 28, 22, 1, -28 },
  { 1691, 20, 28, 22, 2, -28 },
  { 1761, 20, 28, 22, 1, -28 },
  { 1831, 20, 28, 19, 1, -28 },
  { 1901, 19, 28, 19, 1, -28 },
  { 1968, 20, 28, 23, 2, -28 },
  { 2038, 23, 28, 24, 1, -28 },
  { 2119, 9, 28, 10, 1, -28 },
  { 2151, 19, 28, 19, 0, -28 },
  { 2218, 23, 28, 21, 1, -28 },
  { 2299, 15, 28, 19, 1, -28 },
  { 2352, 29, 28, 29, 1, -28 },
  { 2454, 23, 28, 24, 1, -28 },
  { 2535, 20, 28, 23, 2, -28 },
  { 2605, 21, 28, 22, 1, -28 },
  { 2679, 20, 33, 23, 2, -28 },
  { 2762, 20, 28, 21, 1, -28 },
  { 2832, 20, 28, 21, 1, -28 },
  { 2902, 20, 28, 21, 3, -28 },
  { 2972, 22, 28, 22, 1, -28 },
  { 3049, 21, 28, 22, 3, -28 },
  { 3123, 27, 28, 29, 4, -28 },
  { 3218, 24, 28, 22, -1, -28 },
  { 3302, 20, 28, 21, 3, -28 },
  { 3372, 22, 28, 20, 0, -28 },
  { 3449, 13, 39, 10, 0, -33 },
  { 3513, 8, 30, 15, 4, -28 },
  { 3543, 13, 39, 10, -2, -33 },
  { 3607, 13, 14, 15, 1, -28 },
  { 3630, 15, 4, 16, -2, 0 },
  { 3638, 8, 6, 12, 4, -30 },
  { 3644, 16, 21, 18, 1, -21 },
  { 3686, 18, 30, 19, 0, -30 },
  { 3754, 16, 21, 18, 1, -21 },
  { 3796, 19, 30, 19, 1, -30 },
  { 3868, 16, 21, 18, 1, -21 },
  { 3910, 13, 30, 13, 2, -30 },
  { 3959, 19, 29, 19, 0, -21 },
  { 4028, 17, 30, 19, 0, -30 },
  { 4092, 10, 29, 9, 0, -29 },
  { 4129, 14, 37, 9, -4, -29 },
  { 4194, 19, 30, 18, 0, -30 },
  { 4266, 10, 30, 9, 0, -30 },
  { 4304, 27, 21, 29, 0, -21 },
  { 4375, 17, 21, 19, 0, -21 },
  { 4420, 17, 21, 19, 1, -21 },
  { 4465, 19, 29, 19, -1, -21 },
  { 4534, 18, 29, 19, 1, -21 },
  { 4600, 13, 21, 12, 0, -21 },
  { 4635, 17, 21, 18, 0, -21 },
  { 4680, 11, 26, 12, 1, -26 },
  { 4716, 17, 21, 19, 1, -21 },
  { 4761, 16, 21, 17, 2, -21 },
  { 4803, 24, 21, 25, 2, -21 },
  { 4866, 19, 21, 17, -1, -21 },
  { 4916, 19, 29, 17, -1, -21 },
  { 4985, 17, 21, 17, 0, -21 },
  { 5030, 12, 38, 12, 1, -31 },
  { 5087, 8, 33, 10, 1, -28 },
  { 5120, 13, 38, 12, -2, -31 },
  { 5182, 19, 8, 22, 2, -16 },
};

const GFXfont RobotoCondensed_MediumItalic40pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_MediumItalic40pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_MediumItalic40pt7bGlyphs,
  0x20, 0x7E, 47
};

#endif // _ROBOTOCONDENSED_MEDIUMITALIC40PT7B_H_
