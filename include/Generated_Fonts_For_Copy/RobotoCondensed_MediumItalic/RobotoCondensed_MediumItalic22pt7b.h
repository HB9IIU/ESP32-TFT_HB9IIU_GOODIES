#ifndef _ROBOTOCONDENSED_MEDIUMITALIC22PT7B_H_
#define _ROBOTOCONDENSED_MEDIUMITALIC22PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-MediumItalic.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_MediumItalic22pt7bBitmaps[] PROGMEM = {
  0x00, 0x39, 0x8C, 0x67, 0x39, 0x8C, 0x63, 0x38, 0x00, 0x63, 0x18, 0x4B,
  0x2D, 0xB6, 0xDA, 0x40, 0x06, 0xC0, 0x98, 0x33, 0x06, 0x47, 0xFE, 0xFF,
  0x86, 0x40, 0xD8, 0x13, 0x06, 0x43, 0xFE, 0x7F, 0xC6, 0x40, 0xD8, 0x13,
  0x06, 0x40, 0x02, 0x03, 0x03, 0xC7, 0xF3, 0xBB, 0x8D, 0xC6, 0xE0, 0x38,
  0x1E, 0x07, 0x80, 0xE0, 0x36, 0x1B, 0x0D, 0xCE, 0x7E, 0x1E, 0x04, 0x06,
  0x00, 0x78, 0x1E, 0x0C, 0xCF, 0x36, 0xC9, 0x3E, 0xC7, 0x60, 0x10, 0x0C,
  0x06, 0xE1, 0x7C, 0xD3, 0x64, 0xF1, 0x34, 0x7C, 0x0E, 0x07, 0x01, 0xF0,
  0x77, 0x0C, 0xE1, 0x98, 0x37, 0x07, 0xC0, 0xF0, 0x3E, 0x6E, 0xCD, 0x9F,
  0xB1, 0xE6, 0x3C, 0xE7, 0x1F, 0xF1, 0xE6, 0xFF, 0xE0, 0x02, 0x1C, 0x30,
  0xC3, 0x86, 0x0C, 0x30, 0x60, 0xC3, 0x86, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x03, 0x06, 0x06, 0x08, 0x00, 0x10, 0x30, 0x30, 0x60, 0xC0, 0xC1,
  0x83, 0x06, 0x1C, 0x38, 0x60, 0xC1, 0x83, 0x0C, 0x18, 0x70, 0xC3, 0x0C,
  0x10, 0x00, 0x0C, 0x06, 0x03, 0x3F, 0xF3, 0xF0, 0xE0, 0xD0, 0xCC, 0x44,
  0x00, 0x0C, 0x06, 0x03, 0x03, 0x8F, 0xFF, 0xFC, 0x60, 0x30, 0x18, 0x1C,
  0x0E, 0x00, 0x37, 0x76, 0xEC, 0xFF, 0xC0, 0x6D, 0x80, 0x01, 0x80, 0x60,
  0x30, 0x0C, 0x02, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x06, 0x01, 0x80, 0xC0,
  0x30, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x00, 0x0F, 0x1F, 0x8C, 0xEE, 0x36,
  0x1B, 0x0D, 0x87, 0xC7, 0xE3, 0xF1, 0xF0, 0xD8, 0x6C, 0x77, 0x31, 0xF8,
  0x78, 0x06, 0x39, 0xF3, 0x68, 0xC3, 0x87, 0x0C, 0x18, 0x30, 0x61, 0xC3,
  0x86, 0x0C, 0x18, 0x0F, 0x87, 0xF3, 0x9C, 0xC3, 0x30, 0xC0, 0x70, 0x1C,
  0x0E, 0x07, 0x03, 0x80, 0xC0, 0x70, 0x38, 0x1C, 0x0F, 0xFB, 0xFE, 0x0F,
  0x07, 0xE3, 0x9C, 0xC3, 0x00, 0xC0, 0x70, 0x18, 0x3C, 0x0F, 0x00, 0xE0,
  0x18, 0x06, 0xE3, 0x98, 0xE7, 0xF0, 0xF8, 0x01, 0xC0, 0x70, 0x3C, 0x1F,
  0x0F, 0x83, 0x61, 0x98, 0xEE, 0x33, 0x98, 0xEF, 0xFF, 0xFF, 0x03, 0x01,
  0xC0, 0x70, 0x18, 0x1F, 0xCF, 0xF3, 0x00, 0xC0, 0x30, 0x1B, 0x87, 0xF1,
  0x8C, 0x03, 0x80, 0xE0, 0x38, 0x0C, 0xC3, 0x39, 0xC7, 0xE0, 0xF0, 0x07,
  0x07, 0x87, 0x07, 0x07, 0x03, 0x71, 0xFC, 0xE6, 0xE3, 0xF1, 0xF8, 0xFC,
  0x6E, 0x37, 0x39, 0xF8, 0x78, 0x7F, 0xDF, 0xF0, 0x18, 0x06, 0x03, 0x00,
  0xC0, 0x70, 0x18, 0x0E, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x1C, 0x07, 0x03,
  0x80, 0x0F, 0x1F, 0xCE, 0xEE, 0x37, 0x1B, 0x9C, 0xCC, 0x7E, 0x7E, 0x73,
  0xB0, 0xD8, 0x6C, 0x77, 0x3B, 0xF8, 0xF8, 0x3C, 0x7E, 0x67, 0xE7, 0xC3,
  0xC3, 0xC7, 0xC7, 0xC7, 0xFE, 0x76, 0x0E, 0x0C, 0x38, 0xF8, 0xE0, 0x19,
  0xCE, 0x00, 0x00, 0x00, 0x03, 0x38, 0xC0, 0x18, 0x71, 0x80, 0x00, 0x00,
  0x00, 0x00, 0xC3, 0x1C, 0x63, 0x8C, 0x00, 0x01, 0x07, 0x1F, 0x7C, 0xF0,
  0xE0, 0xF8, 0x3E, 0x0E, 0x04, 0x7F, 0xBF, 0xC0, 0x00, 0x0F, 0xF7, 0xF8,
  0x20, 0x1C, 0x0F, 0x81, 0xE0, 0x38, 0x3C, 0x7C, 0xF8, 0x70, 0x20, 0x00,
  0x3C, 0xFF, 0x9E, 0x30, 0x61, 0xC7, 0x1C, 0x30, 0xE1, 0x80, 0x00, 0x08,
  0x38, 0x70, 0x03, 0xE0, 0x1F, 0xF0, 0x70, 0x30, 0xC0, 0x63, 0x00, 0x4C,
  0x78, 0x99, 0xF9, 0xE3, 0x33, 0xCC, 0x45, 0x99, 0x8A, 0x33, 0x14, 0xC6,
  0x69, 0x98, 0x91, 0xFF, 0x23, 0xBC, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x01,
  0xFC, 0x00, 0xF8, 0x00, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0xE0,
  0x6E, 0x06, 0x60, 0xE6, 0x0C, 0x61, 0xC6, 0x1F, 0xE3, 0xFE, 0x30, 0x77,
  0x07, 0x70, 0x7E, 0x07, 0x1F, 0xC3, 0xFC, 0x63, 0x9C, 0x33, 0x86, 0x71,
  0xCC, 0x39, 0xFE, 0x3F, 0x8E, 0x19, 0xC3, 0x38, 0x66, 0x0C, 0xC3, 0x9F,
  0xE7, 0xF8, 0x0F, 0x83, 0xF8, 0xE3, 0x98, 0x77, 0x06, 0xC0, 0x18, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0xEE, 0x1C, 0xC7, 0x1F, 0xC1, 0xF0,
  0x1F, 0x81, 0xFC, 0x18, 0xE3, 0x86, 0x38, 0x63, 0x86, 0x30, 0x63, 0x06,
  0x30, 0x67, 0x0E, 0x70, 0xE7, 0x0C, 0x61, 0xC6, 0x38, 0x7F, 0x0F, 0xE0,
  0x1F, 0xE3, 0xFC, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x01, 0xFC, 0x3F,
  0x8E, 0x01, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x1F, 0xE7, 0xFC, 0x1F, 0xE3,
  0xFC, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x01, 0xFC, 0x3F, 0x8E, 0x01,
  0xC0, 0x38, 0x06, 0x00, 0xC0, 0x18, 0x07, 0x00, 0x0F, 0x83, 0xF8, 0xE3,
  0xB8, 0x77, 0x06, 0xC0, 0x18, 0x07, 0x00, 0xE3, 0xFC, 0xFB, 0x83, 0x70,
  0xEE, 0x1C, 0xE7, 0x9F, 0xE1, 0xF0, 0x18, 0x18, 0xC0, 0xC6, 0x0E, 0x70,
  0x73, 0x83, 0x9C, 0x18, 0xC0, 0xC7, 0xFE, 0x3F, 0xF3, 0x83, 0x9C, 0x1C,
  0xE0, 0xC6, 0x06, 0x30, 0x31, 0x83, 0x9C, 0x1C, 0x1C, 0x61, 0x86, 0x38,
  0xE3, 0x8C, 0x31, 0xC7, 0x1C, 0x71, 0x86, 0x38, 0x00, 0xE0, 0x18, 0x03,
  0x00, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x0E, 0x71,
  0xCE, 0x31, 0xCE, 0x1F, 0x81, 0xE0, 0x18, 0x38, 0xC3, 0x86, 0x38, 0x73,
  0x83, 0xB8, 0x1D, 0xC0, 0xDC, 0x07, 0xC0, 0x3F, 0x03, 0xF8, 0x1C, 0xE0,
  0xE7, 0x06, 0x38, 0x30, 0xE1, 0x87, 0x1C, 0x18, 0x18, 0x0C, 0x06, 0x07,
  0x03, 0x81, 0xC0, 0xC0, 0x60, 0x30, 0x38, 0x1C, 0x0E, 0x06, 0x03, 0x01,
  0xFF, 0xFF, 0x1C, 0x07, 0x1C, 0x0F, 0x1E, 0x0F, 0x3E, 0x1F, 0x3E, 0x1F,
  0x36, 0x1E, 0x36, 0x36, 0x36, 0x36, 0x36, 0x6E, 0x76, 0x6E, 0x76, 0xCE,
  0x72, 0xCC, 0x63, 0xCC, 0x63, 0x9C, 0x63, 0x9C, 0xE3, 0x1C, 0x1C, 0x18,
  0xE0, 0xC7, 0x0E, 0x7C, 0x73, 0xE3, 0x9F, 0x18, 0xD8, 0xC6, 0x66, 0x33,
  0x73, 0x9B, 0x9C, 0x7C, 0xE3, 0xC6, 0x1E, 0x30, 0xF1, 0x83, 0x9C, 0x1C,
  0x0F, 0x83, 0xF8, 0xE3, 0x98, 0x37, 0x06, 0xC0, 0xD8, 0x1F, 0x03, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x6E, 0x1C, 0xE7, 0x1F, 0xC1, 0xF0, 0x1F, 0xC1,
  0xFE, 0x18, 0x73, 0x87, 0x38, 0x73, 0x87, 0x30, 0x73, 0x0E, 0x3F, 0xC7,
  0xF8, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0x0F, 0x83,
  0xF8, 0xE3, 0xB8, 0x77, 0x06, 0xC0, 0xD8, 0x1F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0x70, 0x6E, 0x1C, 0xE7, 0x1F, 0xC1, 0xF8, 0x03, 0x80, 0x30, 0x04,
  0x00, 0x1F, 0xC1, 0xFE, 0x18, 0xE3, 0x86, 0x38, 0x63, 0x86, 0x30, 0xE3,
  0x1E, 0x3F, 0xC7, 0xF0, 0x73, 0x87, 0x38, 0x61, 0x86, 0x1C, 0x61, 0xCE,
  0x1C, 0x07, 0x83, 0xF8, 0x73, 0x9C, 0x33, 0x86, 0x70, 0x07, 0x00, 0xF8,
  0x07, 0x80, 0x78, 0x07, 0x70, 0x66, 0x1C, 0xE7, 0x8F, 0xE0, 0xF0, 0xFF,
  0xFF, 0xF0, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0x80, 0x60, 0x18, 0x0E, 0x03,
  0x80, 0xE0, 0x30, 0x0C, 0x03, 0x01, 0xC0, 0x30, 0x63, 0x06, 0x70, 0x67,
  0x0E, 0x70, 0xE6, 0x0E, 0x60, 0xC6, 0x0C, 0xE0, 0xCE, 0x1C, 0xE1, 0xCC,
  0x1C, 0xE1, 0x8E, 0x38, 0x7F, 0x03, 0xE0, 0xE0, 0xFC, 0x1F, 0x87, 0x70,
  0xEE, 0x18, 0xC7, 0x18, 0xE3, 0x38, 0x67, 0x0C, 0xC1, 0xB8, 0x3E, 0x07,
  0xC0, 0x70, 0x0E, 0x01, 0xC0, 0xE3, 0x8F, 0xC7, 0x1F, 0x8E, 0x37, 0x3C,
  0xEE, 0x79, 0xDC, 0xF3, 0x3B, 0x66, 0x76, 0xDC, 0xED, 0xB1, 0xF3, 0x63,
  0xE7, 0xC7, 0xCF, 0x0F, 0x1E, 0x1E, 0x3C, 0x38, 0x70, 0x70, 0xE0, 0x1C,
  0x38, 0x30, 0xE0, 0xE7, 0x03, 0x9C, 0x06, 0xE0, 0x1B, 0x00, 0x7C, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0xFC, 0x07, 0x70, 0x1C, 0xC0, 0xE3, 0x07,
  0x0E, 0x1C, 0x38, 0xE0, 0xFC, 0x3B, 0x86, 0x31, 0xC6, 0x30, 0xEE, 0x1D,
  0x81, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0x60, 0x0C, 0x03,
  0x80, 0x3F, 0xF3, 0xFF, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x38, 0x03, 0x00,
  0x70, 0x0E, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x70, 0x06, 0x00, 0xFF, 0xCF,
  0xF8, 0x1E, 0x3C, 0x60, 0xC3, 0x87, 0x0E, 0x18, 0x30, 0x61, 0xC3, 0x87,
  0x0C, 0x18, 0x30, 0x61, 0xC3, 0x87, 0x0F, 0x1E, 0x00, 0xC6, 0x39, 0xC6,
  0x31, 0x8C, 0x63, 0x9C, 0x63, 0x18, 0xC6, 0x38, 0x1E, 0x3C, 0x38, 0x60,
  0xC1, 0x83, 0x0E, 0x1C, 0x30, 0x60, 0xC1, 0x87, 0x0E, 0x1C, 0x30, 0x60,
  0xC1, 0x8F, 0x1E, 0x00, 0x0C, 0x38, 0x71, 0xE3, 0xCC, 0x99, 0xE3, 0xFF,
  0xFF, 0x67, 0x30, 0x0F, 0x1F, 0xCC, 0x66, 0x30, 0x18, 0xFD, 0xFE, 0xC7,
  0xE3, 0x73, 0x9F, 0xC7, 0x60, 0x18, 0x06, 0x01, 0x80, 0xE0, 0x38, 0x0D,
  0xC3, 0xF8, 0xE7, 0x31, 0xDC, 0x77, 0x1D, 0x87, 0x61, 0x98, 0x67, 0x3B,
  0xFC, 0xCE, 0x00, 0x1E, 0x7F, 0x63, 0xE3, 0xC0, 0xC0, 0xC0, 0xC0, 0xC7,
  0xC6, 0xFE, 0x78, 0x00, 0xC0, 0x70, 0x1C, 0x06, 0x01, 0x8F, 0x67, 0xD9,
  0x8E, 0xE3, 0xB0, 0xCC, 0x33, 0x0C, 0xC3, 0x31, 0xCE, 0x73, 0xF8, 0x76,
  0x00, 0x1E, 0x7F, 0x63, 0xE3, 0xC3, 0xFF, 0xFF, 0xC0, 0xC0, 0xE6, 0xFE,
  0x3C, 0x0E, 0x3C, 0xE1, 0xC3, 0x1F, 0xBF, 0x38, 0x70, 0xE1, 0x83, 0x06,
  0x1C, 0x38, 0x70, 0xC0, 0x1E, 0xCF, 0xF3, 0x9D, 0xC7, 0x61, 0xD8, 0x66,
  0x19, 0x86, 0x63, 0x9C, 0xE7, 0xF8, 0xFC, 0x03, 0x11, 0xCF, 0xE1, 0xF0,
  0x18, 0x0C, 0x0E, 0x07, 0x03, 0x81, 0xB8, 0xFE, 0x73, 0x71, 0xB8, 0xDC,
  0x6C, 0x36, 0x3B, 0x1F, 0x8F, 0xC6, 0xE3, 0x00, 0x18, 0xC6, 0x00, 0x1C,
  0xC6, 0x33, 0x9C, 0xE6, 0x31, 0x9C, 0xE0, 0x06, 0x0C, 0x18, 0x00, 0x01,
  0xC3, 0x06, 0x0C, 0x38, 0x70, 0xE1, 0x83, 0x06, 0x1C, 0x38, 0x60, 0xC7,
  0x8E, 0x00, 0x18, 0x06, 0x01, 0x80, 0xE0, 0x38, 0x0C, 0x73, 0x38, 0xDC,
  0x36, 0x1F, 0x87, 0xC1, 0xF8, 0x76, 0x19, 0x86, 0x73, 0x8C, 0xE3, 0x80,
  0x18, 0x61, 0x86, 0x38, 0xE3, 0x0C, 0x30, 0xC7, 0x1C, 0x61, 0x86, 0x38,
  0xE0, 0x37, 0x3C, 0x7F, 0xFC, 0xE7, 0x39, 0x8E, 0x77, 0x18, 0xEE, 0x31,
  0xD8, 0x63, 0x31, 0xC6, 0x63, 0x8C, 0xC6, 0x1B, 0x8C, 0x77, 0x18, 0xE0,
  0x37, 0x1F, 0xCE, 0x6E, 0x37, 0x1B, 0x8D, 0x86, 0xC7, 0x63, 0xF1, 0xF8,
  0xDC, 0x60, 0x1E, 0x1F, 0x9C, 0xDC, 0x7C, 0x3E, 0x1F, 0x0F, 0x86, 0xC3,
  0x73, 0xBF, 0x8F, 0x80, 0x1B, 0x83, 0xF8, 0x73, 0x8C, 0x73, 0x8E, 0x71,
  0xCC, 0x39, 0x86, 0x30, 0xCF, 0x39, 0xFE, 0x3B, 0x86, 0x00, 0xC0, 0x18,
  0x07, 0x00, 0x3D, 0xBF, 0xD8, 0xFC, 0x7C, 0x36, 0x1B, 0x0D, 0x8E, 0xC7,
  0x63, 0xBF, 0x8E, 0xC0, 0x60, 0x70, 0x38, 0x1C, 0x36, 0x7C, 0xF9, 0x87,
  0x0E, 0x18, 0x30, 0x60, 0xC3, 0x87, 0x00, 0x1F, 0x1F, 0xCC, 0xEE, 0x33,
  0x01, 0xE0, 0x7C, 0x0E, 0xE3, 0x73, 0x9F, 0xC7, 0x80, 0x30, 0xCF, 0xFE,
  0x71, 0xC6, 0x18, 0x63, 0x8E, 0x38, 0xF1, 0xC0, 0x61, 0xB1, 0xD8, 0xFC,
  0x7E, 0x37, 0x1B, 0x0D, 0x8E, 0xC7, 0x63, 0xBF, 0x8E, 0xC0, 0xE3, 0xF1,
  0xB9, 0xCC, 0xC6, 0x63, 0x71, 0xB0, 0xD8, 0x78, 0x3C, 0x1C, 0x06, 0x00,
  0xE3, 0x1F, 0x39, 0xF9, 0xCC, 0xDE, 0x66, 0xF6, 0x37, 0xB1, 0xED, 0x8F,
  0x78, 0x73, 0xC3, 0x9E, 0x1C, 0xE0, 0xC3, 0x00, 0x18, 0xE3, 0x38, 0x76,
  0x07, 0xC0, 0xF0, 0x1C, 0x03, 0x80, 0xF8, 0x1B, 0x07, 0x61, 0xCE, 0x31,
  0xC0, 0x38, 0xE7, 0x18, 0xE7, 0x0C, 0xC1, 0xB8, 0x36, 0x07, 0xC0, 0xF0,
  0x1E, 0x03, 0xC0, 0x70, 0x0E, 0x01, 0x80, 0x70, 0x3C, 0x07, 0x00, 0x3F,
  0x9F, 0xC0, 0xE0, 0xE0, 0xE0, 0x60, 0x70, 0x70, 0x70, 0x30, 0x3F, 0xDF,
  0xE0, 0x04, 0x31, 0x8E, 0x30, 0xC3, 0x0C, 0x73, 0x8C, 0x18, 0x61, 0x86,
  0x38, 0xE3, 0x86, 0x1C, 0x20, 0x18, 0xC6, 0x21, 0x18, 0xC6, 0x31, 0x88,
  0x46, 0x31, 0x8C, 0x42, 0x30, 0x10, 0x30, 0x30, 0x60, 0xC1, 0x83, 0x0E,
  0x0C, 0x1C, 0x38, 0xC1, 0x87, 0x0E, 0x18, 0x30, 0x61, 0xC7, 0x0C, 0x00,
  0x38, 0xDF, 0x3E, 0xCF, 0x1E, 0xC3, 0x00,
};

const GFXglyph RobotoCondensed_MediumItalic22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 5, 16, 5, 1, -16 },
  { 11, 6, 6, 7, 2, -17 },
  { 16, 11, 16, 11, 1, -16 },
  { 38, 9, 20, 11, 1, -18 },
  { 61, 10, 16, 14, 2, -16 },
  { 81, 11, 16, 12, 0, -16 },
  { 103, 2, 6, 4, 2, -17 },
  { 105, 7, 23, 7, 1, -18 },
  { 126, 7, 22, 7, -1, -17 },
  { 146, 9, 9, 9, 1, -16 },
  { 157, 9, 11, 10, 1, -12 },
  { 170, 4, 6, 5, -1, -3 },
  { 173, 5, 2, 7, 1, -8 },
  { 175, 3, 3, 6, 0, -3 },
  { 177, 10, 17, 7, -1, -16 },
  { 199, 9, 16, 11, 1, -16 },
  { 217, 7, 16, 11, 2, -16 },
  { 231, 10, 16, 11, 0, -16 },
  { 251, 10, 16, 11, 0, -16 },
  { 271, 10, 16, 11, 0, -16 },
  { 291, 10, 16, 11, 1, -16 },
  { 311, 9, 16, 11, 1, -16 },
  { 329, 10, 16, 11, 1, -16 },
  { 349, 9, 16, 11, 1, -16 },
  { 367, 8, 16, 11, 2, -16 },
  { 383, 5, 12, 6, 0, -12 },
  { 391, 6, 15, 5, -1, -12 },
  { 403, 8, 10, 10, 1, -12 },
  { 413, 9, 6, 11, 1, -10 },
  { 420, 9, 10, 10, 0, -12 },
  { 432, 7, 16, 9, 2, -16 },
  { 446, 15, 20, 16, 1, -15 },
  { 484, 12, 16, 13, -1, -16 },
  { 508, 11, 16, 12, 0, -16 },
  { 530, 11, 16, 12, 1, -16 },
  { 552, 12, 16, 12, 0, -16 },
  { 576, 11, 16, 11, 0, -16 },
  { 598, 11, 16, 10, 0, -16 },
  { 620, 11, 16, 13, 1, -16 },
  { 642, 13, 16, 13, 0, -16 },
  { 668, 6, 16, 6, 0, -16 },
  { 680, 11, 16, 10, 0, -16 },
  { 702, 13, 16, 12, 0, -16 },
  { 728, 9, 16, 10, 0, -16 },
  { 746, 16, 16, 16, 0, -16 },
  { 778, 13, 16, 13, 0, -16 },
  { 804, 11, 16, 13, 1, -16 },
  { 826, 12, 16, 12, 0, -16 },
  { 850, 11, 19, 13, 1, -16 },
  { 877, 12, 16, 12, 0, -16 },
  { 901, 11, 16, 11, 0, -16 },
  { 923, 10, 16, 11, 2, -16 },
  { 943, 12, 16, 12, 1, -16 },
  { 967, 11, 16, 12, 2, -16 },
  { 989, 15, 16, 16, 2, -16 },
  { 1019, 14, 16, 12, -1, -16 },
  { 1047, 11, 16, 11, 2, -16 },
  { 1069, 12, 16, 11, 0, -16 },
  { 1093, 7, 22, 6, 0, -18 },
  { 1113, 5, 17, 8, 2, -16 },
  { 1124, 7, 22, 6, -1, -18 },
  { 1144, 7, 8, 8, 1, -16 },
  { 1151, 8, 2, 9, -1, 0 },
  { 1153, 4, 3, 7, 2, -16 },
  { 1155, 9, 12, 10, 0, -12 },
  { 1169, 10, 17, 11, 0, -17 },
  { 1191, 8, 12, 10, 1, -12 },
  { 1203, 10, 17, 11, 1, -17 },
  { 1225, 8, 12, 10, 1, -12 },
  { 1237, 7, 17, 7, 1, -17 },
  { 1252, 10, 16, 11, 0, -12 },
  { 1272, 9, 17, 10, 0, -17 },
  { 1292, 5, 17, 5, 0, -17 },
  { 1303, 7, 21, 5, -2, -17 },
  { 1322, 10, 17, 10, 0, -17 },
  { 1344, 6, 17, 5, 0, -17 },
  { 1357, 15, 12, 16, 0, -12 },
  { 1380, 9, 12, 10, 0, -12 },
  { 1394, 9, 12, 11, 1, -12 },
  { 1408, 11, 16, 11, -1, -12 },
  { 1430, 9, 16, 11, 1, -12 },
  { 1448, 7, 12, 7, 0, -12 },
  { 1459, 9, 12, 10, 0, -12 },
  { 1473, 6, 14, 6, 1, -14 },
  { 1484, 9, 12, 10, 1, -12 },
  { 1498, 9, 12, 9, 1, -12 },
  { 1512, 13, 12, 14, 1, -12 },
  { 1532, 11, 12, 10, -1, -12 },
  { 1549, 11, 16, 9, -1, -12 },
  { 1571, 9, 12, 10, 0, -12 },
  { 1585, 6, 21, 6, 1, -17 },
  { 1601, 5, 19, 5, 0, -16 },
  { 1613, 7, 21, 6, -1, -17 },
  { 1632, 10, 5, 12, 1, -9 },
};

const GFXfont RobotoCondensed_MediumItalic22pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_MediumItalic22pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_MediumItalic22pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _ROBOTOCONDENSED_MEDIUMITALIC22PT7B_H_
