#ifndef _ROBOTOCONDENSED_MEDIUMITALIC35PT7B_H_
#define _ROBOTOCONDENSED_MEDIUMITALIC35PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-MediumItalic.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_MediumItalic35pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x0F, 0x1F, 0x1E, 0x1E, 0x1E, 0x1E, 0x1C, 0x1C, 0x3C, 0x3C,
  0x3C, 0x38, 0x38, 0x38, 0x78, 0x78, 0x00, 0x00, 0x00, 0x60, 0xF0, 0xF0,
  0xF0, 0x60, 0x73, 0xB9, 0xDC, 0xEC, 0x6E, 0x77, 0x3B, 0x9D, 0x8C, 0xC6,
  0x00, 0x00, 0x73, 0x80, 0x38, 0xE0, 0x0E, 0x30, 0x03, 0x9C, 0x00, 0xC7,
  0x00, 0x71, 0x80, 0x1C, 0xE0, 0x7F, 0xFF, 0x1F, 0xFF, 0x87, 0xFF, 0xE0,
  0x31, 0xC0, 0x1C, 0x60, 0x07, 0x38, 0x01, 0x8E, 0x00, 0xE3, 0x03, 0xFF,
  0xF8, 0xFF, 0xFE, 0x3F, 0xFF, 0x81, 0xCE, 0x00, 0x63, 0x80, 0x38, 0xC0,
  0x0E, 0x70, 0x03, 0x1C, 0x01, 0xC6, 0x00, 0x73, 0x80, 0x00, 0x00, 0x30,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x1F, 0x00, 0xFF, 0x83, 0xFF, 0x07,
  0xDF, 0x1E, 0x1E, 0x3C, 0x3C, 0x78, 0x78, 0xF0, 0xF1, 0xE0, 0x03, 0xC0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xC0,
  0x03, 0xDE, 0x07, 0xBC, 0x0F, 0x78, 0x3C, 0x78, 0x78, 0xFB, 0xF1, 0xFF,
  0xC1, 0xFF, 0x00, 0xF8, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00,
  0x3F, 0x00, 0x7F, 0x80, 0x73, 0x86, 0xE3, 0x86, 0xE3, 0x8E, 0xE3, 0x9C,
  0xE3, 0xB8, 0xE3, 0xB8, 0x77, 0x70, 0x7F, 0xE0, 0x3C, 0xC0, 0x01, 0xC0,
  0x03, 0xBC, 0x07, 0x7E, 0x07, 0xFF, 0x0E, 0xE3, 0x1C, 0xC3, 0x1C, 0xC3,
  0x39, 0xC3, 0x71, 0xC7, 0x60, 0xC7, 0x20, 0xEE, 0x00, 0xFE, 0x00, 0x78,
  0x01, 0xF0, 0x01, 0xFC, 0x01, 0xFF, 0x01, 0xF7, 0x80, 0xF1, 0xC0, 0xF0,
  0xE0, 0x78, 0x70, 0x3C, 0x78, 0x0E, 0x78, 0x07, 0xF8, 0x03, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x01, 0xFE, 0x39, 0xFF, 0x1C, 0xF3, 0xCE, 0xF1, 0xEF,
  0x78, 0x7F, 0x3C, 0x3F, 0x9E, 0x0F, 0x8F, 0x07, 0xC7, 0xC7, 0xE1, 0xFF,
  0xF8, 0x7F, 0xFC, 0x1F, 0x9F, 0x00, 0x39, 0xDE, 0xE7, 0x39, 0xCC, 0x60,
  0x00, 0x40, 0x30, 0x1C, 0x0E, 0x07, 0x03, 0xC0, 0xE0, 0x78, 0x1C, 0x0F,
  0x03, 0x80, 0xE0, 0x78, 0x1C, 0x07, 0x03, 0xC0, 0xF0, 0x3C, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x07, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0x80, 0x20, 0x02, 0x00, 0x60,
  0x1E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x70, 0x0F, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1C, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0x80,
  0xF0, 0x1C, 0x07, 0x81, 0xE0, 0x78, 0x0E, 0x01, 0x80, 0x20, 0x00, 0x01,
  0xC0, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x43, 0x8F, 0xEC, 0xFF, 0xFF, 0xCF,
  0xFE, 0x0F, 0x80, 0x7E, 0x01, 0xDC, 0x0E, 0x70, 0x70, 0xE1, 0xC3, 0x82,
  0x08, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x3F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xF0, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x1E, 0x3C, 0x70, 0xE3, 0xC7, 0x9E, 0x38, 0xF0, 0xC0, 0x7F, 0xFF, 0xFF,
  0x67, 0xBD, 0xE7, 0x00, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C,
  0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0,
  0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00,
  0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x03, 0xE0,
  0x3F, 0xC1, 0xFF, 0x87, 0x9F, 0x3C, 0x3C, 0xE0, 0xF7, 0x83, 0xDE, 0x0F,
  0x78, 0x3D, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xEF, 0x07,
  0xBC, 0x1E, 0xE0, 0x7B, 0x81, 0xEE, 0x07, 0x38, 0x3C, 0xF0, 0xF3, 0xE7,
  0x87, 0xFC, 0x1F, 0xE0, 0x1F, 0x00, 0x00, 0xC1, 0xF1, 0xF9, 0xFE, 0xFF,
  0xBD, 0xEC, 0x78, 0x1E, 0x07, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC1,
  0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x00, 0x00, 0xF8, 0x03, 0xFC, 0x07, 0xFE, 0x0F, 0x9F, 0x1F, 0x0F,
  0x1E, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7F, 0xFC,
  0xFF, 0xFC, 0xFF, 0xFC, 0x03, 0xF0, 0x0F, 0xF0, 0x3F, 0xF0, 0xF9, 0xF3,
  0xE1, 0xE7, 0x83, 0xCF, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x01,
  0xF0, 0x3F, 0xC0, 0x7E, 0x00, 0xFE, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x7B, 0xC0, 0xE7, 0x83, 0xCF, 0x07, 0x9F, 0x3E, 0x1F, 0xFC, 0x1F,
  0xF0, 0x1F, 0x80, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00,
  0x7E, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xDE, 0x03, 0xDE, 0x07, 0x9C, 0x07,
  0x3C, 0x0F, 0x3C, 0x1E, 0x3C, 0x1C, 0x3C, 0x3C, 0x3C, 0x78, 0x38, 0x7F,
  0xFF, 0x7F, 0xFE, 0xFF, 0xFE, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x07, 0xFF, 0x07, 0xFF, 0x0F, 0xFF, 0x0F,
  0xFF, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1D, 0xE0, 0x3F,
  0xF8, 0x3F, 0xF8, 0x3E, 0x7C, 0x08, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3C, 0xF0, 0x3C, 0xF0, 0x7C, 0x78, 0x78, 0x7C,
  0xF8, 0x3F, 0xF0, 0x3F, 0xE0, 0x0F, 0x80, 0x00, 0x78, 0x0F, 0xC1, 0xFC,
  0x1F, 0xC1, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x7B, 0xC3, 0xFF, 0x9F,
  0xFD, 0xF9, 0xFF, 0x87, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83,
  0xFC, 0x1F, 0xE0, 0xFF, 0x0F, 0x3C, 0xF9, 0xFF, 0x87, 0xF8, 0x1F, 0x00,
  0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFE, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0,
  0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00,
  0xF0, 0x00, 0x01, 0xF0, 0x0F, 0xF8, 0x3F, 0xF0, 0x79, 0xF1, 0xE1, 0xE3,
  0xC3, 0xC7, 0x87, 0x8E, 0x0F, 0x1E, 0x1E, 0x3C, 0x78, 0x79, 0xF0, 0x7F,
  0xC0, 0xFE, 0x07, 0xFE, 0x0F, 0x1E, 0x3C, 0x1C, 0xF0, 0x3D, 0xE0, 0x7B,
  0xC0, 0xF7, 0x83, 0xCF, 0x07, 0x8F, 0x3F, 0x1F, 0xFC, 0x1F, 0xF0, 0x1F,
  0x80, 0x03, 0xE0, 0x3F, 0xC1, 0xFF, 0x8F, 0x9E, 0x3C, 0x39, 0xE0, 0xF7,
  0x83, 0xDE, 0x0F, 0x70, 0x3D, 0xC0, 0xF7, 0x03, 0xDE, 0x0F, 0x78, 0x79,
  0xF3, 0xE7, 0xFF, 0x8F, 0xFE, 0x1F, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0xFF, 0x07, 0xF8, 0x1F, 0x80, 0x78, 0x00, 0x0C, 0x3C, 0xF9,
  0xF1, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0xF1,
  0xE3, 0xC3, 0x80, 0x01, 0x01, 0xE0, 0x7C, 0x1F, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E,
  0x07, 0x81, 0xE0, 0x70, 0x1C, 0x0F, 0x03, 0x81, 0xE0, 0xF0, 0x08, 0x00,
  0x00, 0x08, 0x01, 0xC0, 0x3E, 0x07, 0xF0, 0xFF, 0x1F, 0xE1, 0xFC, 0x1F,
  0x80, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7E, 0x01, 0xF0, 0x03,
  0x80, 0x04, 0x7F, 0xF9, 0xFF, 0xE7, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFC, 0xFF, 0xF3, 0xFF, 0xC0, 0x20, 0x00, 0xE0, 0x03,
  0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1E, 0x00, 0xF8,
  0x0F, 0xE1, 0xFE, 0x1F, 0xE0, 0xFE, 0x03, 0xE0, 0x0E, 0x00, 0x20, 0x00,
  0x0F, 0x83, 0xFC, 0x7F, 0xE7, 0xDF, 0xF0, 0xFF, 0x0F, 0xF0, 0xF0, 0x0F,
  0x01, 0xE0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x01, 0xE0, 0x3C, 0x03, 0xC0,
  0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x07, 0x00, 0xF8, 0x07, 0x80,
  0x70, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF8, 0x03,
  0xE0, 0x3C, 0x07, 0x80, 0x0C, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x06, 0x1C,
  0x0F, 0x06, 0x1C, 0x3F, 0xC6, 0x38, 0x7F, 0xC7, 0x38, 0xF1, 0xC7, 0x70,
  0xE1, 0x87, 0x71, 0xC3, 0x87, 0x71, 0xC3, 0x87, 0x61, 0xC3, 0x86, 0xE3,
  0xC3, 0x86, 0xE3, 0x87, 0x06, 0xE3, 0x87, 0x0E, 0xE3, 0x87, 0x0C, 0xE3,
  0x8F, 0x0C, 0xE3, 0x8F, 0x1C, 0xE3, 0xFF, 0x38, 0xE1, 0xF7, 0xF0, 0xE1,
  0xE3, 0xE0, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x3C, 0x04, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1D, 0xC0, 0x07, 0xB8, 0x00, 0xE7, 0x00,
  0x3C, 0xF0, 0x07, 0x1E, 0x01, 0xE3, 0xC0, 0x3C, 0x78, 0x0F, 0x0F, 0x01,
  0xE1, 0xE0, 0x78, 0x1C, 0x0F, 0xFF, 0x83, 0xFF, 0xF8, 0x7F, 0xFF, 0x1E,
  0x01, 0xE3, 0xC0, 0x3C, 0xF8, 0x07, 0x9E, 0x00, 0xF7, 0xC0, 0x1E, 0xF0,
  0x03, 0xE0, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x3F, 0xFF, 0x0F,
  0x03, 0xC3, 0xC0, 0xF0, 0xF0, 0x3C, 0x7C, 0x0F, 0x1E, 0x07, 0xC7, 0x81,
  0xE1, 0xE0, 0xF8, 0x7F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFF, 0x83, 0xC0, 0xF0,
  0xF0, 0x3C, 0x3C, 0x07, 0x0F, 0x01, 0xE3, 0xC0, 0xF1, 0xE0, 0x3C, 0x78,
  0x1F, 0x1E, 0x1F, 0x87, 0xFF, 0xE1, 0xFF, 0xF0, 0x7F, 0xF0, 0x00, 0x01,
  0xF8, 0x03, 0xFF, 0x03, 0xFF, 0xC3, 0xF7, 0xE3, 0xE0, 0xF9, 0xE0, 0x3D,
  0xF0, 0x1E, 0xF0, 0x0F, 0x78, 0x07, 0xBC, 0x00, 0x3E, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x0F, 0x3C, 0x07, 0x9E, 0x03, 0xCF, 0x03, 0xC3, 0xE7, 0xE1, 0xFF, 0xE0,
  0x7F, 0xE0, 0x0F, 0xC0, 0x00, 0x07, 0xF8, 0x01, 0xFF, 0x80, 0xFF, 0xF0,
  0x3F, 0xFE, 0x0F, 0x07, 0xC3, 0xC0, 0xF0, 0xF0, 0x3C, 0x7C, 0x0F, 0x1E,
  0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x3C, 0x78, 0x0F, 0x1E, 0x03, 0xCF, 0x80,
  0xF3, 0xC0, 0x3C, 0xF0, 0x1E, 0x3C, 0x07, 0x8F, 0x01, 0xE3, 0xC0, 0xF1,
  0xE0, 0x3C, 0x78, 0x1E, 0x1E, 0x3F, 0x87, 0xFF, 0xC1, 0xFF, 0xC0, 0x7F,
  0xC0, 0x00, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0xFF, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x7F, 0xF8, 0x1F, 0xFE, 0x0F, 0xFF, 0x83, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x00, 0x07,
  0xFF, 0xC1, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x7F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFF, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF8, 0x03, 0xFF,
  0x03, 0xFF, 0xC3, 0xF7, 0xE3, 0xE0, 0x79, 0xE0, 0x3D, 0xF0, 0x1E, 0xF0,
  0x0F, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x0F, 0xF7,
  0x87, 0xFB, 0xC3, 0xFD, 0xE0, 0x1E, 0xF0, 0x0F, 0x78, 0x0F, 0xBC, 0x07,
  0x9E, 0x03, 0xCF, 0x81, 0xE3, 0xFF, 0xF1, 0xFF, 0xF0, 0x7F, 0xF0, 0x0F,
  0xC0, 0x00, 0x07, 0x80, 0x78, 0x3C, 0x03, 0xC3, 0xC0, 0x1E, 0x1E, 0x00,
  0xF0, 0xF0, 0x0F, 0x07, 0x80, 0x78, 0x3C, 0x03, 0xC3, 0xE0, 0x1E, 0x1E,
  0x00, 0xF0, 0xF0, 0x07, 0x87, 0x80, 0x78, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE,
  0x1F, 0xFF, 0xF0, 0xF0, 0x07, 0x87, 0x80, 0x7C, 0x3C, 0x03, 0xC1, 0xE0,
  0x1E, 0x0F, 0x00, 0xF0, 0xF0, 0x07, 0x87, 0x80, 0x3C, 0x3C, 0x03, 0xE1,
  0xE0, 0x1E, 0x0F, 0x00, 0xF0, 0x78, 0x07, 0x80, 0x0F, 0x0F, 0x0F, 0x1E,
  0x1E, 0x1E, 0x1E, 0x1E, 0x3E, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x78, 0x78,
  0x78, 0x78, 0x78, 0x78, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x78, 0x1E, 0x3C,
  0x0F, 0x1E, 0x0F, 0x07, 0x87, 0x83, 0xEF, 0xC1, 0xFF, 0xC0, 0x7F, 0xC0,
  0x0F, 0x80, 0x00, 0x07, 0x81, 0xF8, 0x3C, 0x0F, 0x83, 0xC0, 0xF8, 0x1E,
  0x0F, 0x80, 0xF0, 0xF8, 0x07, 0x8F, 0x80, 0x3C, 0x7C, 0x03, 0xE7, 0xC0,
  0x1E, 0x7C, 0x00, 0xF7, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xEF, 0x00, 0x3E, 0x7C, 0x01,
  0xE1, 0xE0, 0x0F, 0x0F, 0x00, 0xF0, 0x7C, 0x07, 0x81, 0xE0, 0x3C, 0x0F,
  0x01, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x80, 0x07, 0x80, 0x1E,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0xFF, 0xDF, 0xFF, 0x7F, 0xFC, 0x07, 0xC0, 0x0F, 0xC1, 0xF0, 0x03, 0xF0,
  0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0x83, 0xF8, 0x0F,
  0xE0, 0xFE, 0x03, 0xF8, 0x7F, 0x81, 0xFE, 0x1E, 0xE0, 0x77, 0x87, 0xB8,
  0x3D, 0xC1, 0xEE, 0x0E, 0xF0, 0x7B, 0x87, 0xBC, 0x1E, 0xE1, 0xEF, 0x0F,
  0x38, 0x73, 0xC3, 0xCF, 0x3C, 0xE0, 0xF3, 0xCE, 0x78, 0x3C, 0x77, 0x9E,
  0x0F, 0x1D, 0xC7, 0x83, 0xC7, 0xF1, 0xE1, 0xE1, 0xF8, 0x78, 0x78, 0x7E,
  0x3C, 0x1E, 0x1F, 0x0F, 0x07, 0x87, 0xC3, 0xC1, 0xE1, 0xE0, 0xF0, 0x78,
  0x38, 0x3C, 0x00, 0x07, 0x80, 0x78, 0x3C, 0x03, 0xC3, 0xE0, 0x1E, 0x1F,
  0x80, 0xF0, 0xFC, 0x0F, 0x07, 0xE0, 0x78, 0x3F, 0x83, 0xC3, 0xFC, 0x1E,
  0x1E, 0xE0, 0xF0, 0xF7, 0x8F, 0x87, 0x9C, 0x78, 0x3C, 0xE3, 0xC1, 0xE7,
  0x1E, 0x1F, 0x1C, 0xF0, 0xF0, 0xE7, 0x87, 0x87, 0x7C, 0x3C, 0x3F, 0xC1,
  0xE0, 0xFE, 0x0F, 0x07, 0xF0, 0xF8, 0x3F, 0x87, 0x80, 0xFC, 0x3C, 0x07,
  0xC1, 0xE0, 0x3E, 0x0F, 0x01, 0xF0, 0x78, 0x07, 0x80, 0x01, 0xF8, 0x01,
  0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xFC, 0x1E, 0x07, 0x8F, 0x01, 0xE3, 0xC0,
  0x79, 0xE0, 0x1E, 0x78, 0x07, 0x9E, 0x01, 0xEF, 0x80, 0x7B, 0xC0, 0x1E,
  0xF0, 0x07, 0xBC, 0x01, 0xEF, 0x00, 0x7B, 0xC0, 0x1E, 0xF0, 0x0F, 0x3C,
  0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x78, 0xF8, 0x3E, 0x1F, 0xBF, 0x07, 0xFF,
  0x80, 0xFF, 0xC0, 0x0F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xF0, 0x3F,
  0xFF, 0x07, 0xFF, 0xE0, 0xF0, 0x3E, 0x1E, 0x03, 0xC3, 0xC0, 0x78, 0xF8,
  0x0F, 0x1E, 0x01, 0xE3, 0xC0, 0x3C, 0x78, 0x0F, 0x0F, 0x03, 0xE1, 0xE1,
  0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xC1, 0xFF, 0xE0, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF8, 0x01, 0xFF, 0x80, 0xFF,
  0xF0, 0x7F, 0xFC, 0x3E, 0x0F, 0x8F, 0x01, 0xE7, 0xC0, 0x79, 0xE0, 0x1E,
  0x78, 0x07, 0x9E, 0x01, 0xEF, 0x00, 0x7B, 0xC0, 0x1E, 0xF0, 0x07, 0xBC,
  0x01, 0xEF, 0x00, 0x7B, 0xC0, 0x3C, 0xF0, 0x0F, 0x3C, 0x03, 0xCF, 0x01,
  0xF3, 0xC0, 0x78, 0xF8, 0x3E, 0x1F, 0xBF, 0x07, 0xFF, 0x80, 0xFF, 0xC0,
  0x0F, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x10, 0x00,
  0x07, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x3F, 0xFF, 0x0F, 0x03, 0xC3,
  0xC0, 0xF0, 0xF0, 0x3C, 0x7C, 0x0F, 0x1E, 0x03, 0xC7, 0x81, 0xF1, 0xE0,
  0x78, 0x78, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0x03, 0xFF, 0x80, 0xF0, 0xF0,
  0x3C, 0x3C, 0x0F, 0x0F, 0x03, 0xC3, 0xE1, 0xE0, 0x78, 0x78, 0x1E, 0x1E,
  0x07, 0x87, 0x81, 0xF1, 0xE0, 0x7C, 0x78, 0x0F, 0x00, 0x01, 0xF8, 0x03,
  0xFF, 0x03, 0xFF, 0xC3, 0xF7, 0xE1, 0xF0, 0xF8, 0xF0, 0x3C, 0xF0, 0x1E,
  0x78, 0x0F, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x78, 0x0F, 0x3C,
  0x07, 0x9E, 0x03, 0xCF, 0x83, 0xC3, 0xF7, 0xE1, 0xFF, 0xE0, 0x7F, 0xE0,
  0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xE0,
  0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x01, 0xE3,
  0xC0, 0x3C, 0x78, 0x0F, 0x8F, 0x01, 0xE1, 0xE0, 0x3C, 0x3C, 0x07, 0x8F,
  0x00, 0xF1, 0xE0, 0x1E, 0x3C, 0x07, 0x87, 0x80, 0xF0, 0xF0, 0x1E, 0x3E,
  0x03, 0xC7, 0x80, 0x78, 0xF0, 0x0F, 0x1E, 0x03, 0xC3, 0xC0, 0x78, 0x78,
  0x0F, 0x1F, 0x01, 0xE3, 0xE0, 0x3C, 0x3C, 0x0F, 0x07, 0x83, 0xE0, 0xFD,
  0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0xF0, 0x07, 0xFC,
  0x01, 0xFF, 0x00, 0x7B, 0xE0, 0x3E, 0xF8, 0x0F, 0x1E, 0x07, 0xC7, 0x81,
  0xE1, 0xE0, 0x78, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x87, 0xC1, 0xE1, 0xE0,
  0x38, 0x78, 0x0E, 0x3C, 0x03, 0xCF, 0x00, 0xF7, 0x80, 0x3D, 0xE0, 0x0F,
  0x70, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F,
  0xF0, 0x3C, 0x1E, 0xF0, 0x7C, 0x1E, 0xF0, 0x7C, 0x1E, 0xF0, 0x7C, 0x3C,
  0xF0, 0xFC, 0x3C, 0xF0, 0xFC, 0x3C, 0xF1, 0xFC, 0x78, 0x71, 0xDC, 0x78,
  0x71, 0xDC, 0x78, 0x73, 0xDC, 0x70, 0x73, 0x9C, 0xF0, 0x73, 0x9C, 0xF0,
  0x77, 0x9C, 0xE0, 0x77, 0x1D, 0xE0, 0x77, 0x1F, 0xE0, 0x7F, 0x0F, 0xC0,
  0x7E, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x7C, 0x0F, 0x80, 0x7C, 0x0F, 0x80,
  0x7C, 0x0F, 0x80, 0x78, 0x0F, 0x00, 0x78, 0x0F, 0x00, 0x0F, 0x80, 0xF8,
  0x3C, 0x07, 0x81, 0xE0, 0x7C, 0x0F, 0x87, 0xC0, 0x3C, 0x3E, 0x01, 0xE3,
  0xE0, 0x0F, 0x9E, 0x00, 0x3D, 0xF0, 0x01, 0xEF, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xDE, 0x00, 0x3C, 0xF0, 0x03, 0xE7, 0x80, 0x1E,
  0x3E, 0x01, 0xF0, 0xF0, 0x1F, 0x07, 0x80, 0xF0, 0x3E, 0x0F, 0x81, 0xF0,
  0xF8, 0x07, 0x80, 0xF0, 0x0F, 0xFC, 0x07, 0xDE, 0x07, 0xCF, 0x03, 0xC7,
  0x83, 0xE3, 0xC1, 0xE0, 0xE1, 0xF0, 0x78, 0xF0, 0x3C, 0xF0, 0x1E, 0x78,
  0x07, 0x78, 0x03, 0xBC, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0xFF, 0xE1,
  0xFF, 0xFC, 0x7F, 0xFF, 0x0F, 0xFF, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0,
  0x00, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xFE, 0x00, 0x07, 0xE0, 0xFC,
  0x1F, 0x87, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xFC, 0x1F, 0x83, 0xF0, 0x00, 0xF0, 0xF0,
  0xF0, 0x70, 0x70, 0x78, 0x78, 0x78, 0x78, 0x78, 0x38, 0x38, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x1C, 0x1C, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x0E, 0x0E,
  0x0F, 0x07, 0xE0, 0xFC, 0x1F, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0xFC, 0x1F, 0x83,
  0xF0, 0x00, 0x03, 0x80, 0x78, 0x1F, 0x03, 0xE0, 0xFC, 0x1F, 0x87, 0x30,
  0xE7, 0x38, 0xE7, 0x1D, 0xC3, 0xB8, 0x70, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF,
  0x80, 0xF1, 0xE7, 0x8F, 0x1C, 0x07, 0xE0, 0x3F, 0xC1, 0xFF, 0x8F, 0x9E,
  0x3C, 0x3D, 0xE0, 0xF0, 0x07, 0x83, 0xFE, 0x3F, 0xF9, 0xFF, 0xEF, 0x87,
  0xBC, 0x1E, 0xF0, 0xF3, 0xC3, 0xCF, 0xBF, 0x3F, 0xFC, 0x7F, 0xF0, 0xF3,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0xF8, 0x1F, 0xFC, 0x1F, 0xFE, 0x1F,
  0x3E, 0x1E, 0x1E, 0x3C, 0x0E, 0x3C, 0x0F, 0x3C, 0x0E, 0x3C, 0x1E, 0x3C,
  0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x3C, 0x7E, 0x7C, 0x7F,
  0xF8, 0xF7, 0xF0, 0xF3, 0xE0, 0x07, 0xE0, 0x3F, 0xC1, 0xFF, 0x8F, 0x9E,
  0x78, 0x3D, 0xE0, 0xF7, 0x83, 0xFC, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x1E, 0xF0, 0x7B, 0xC3, 0xCF, 0x9F, 0x1F, 0xF8, 0x3F, 0xC0, 0x7E,
  0x00, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x07, 0x9E, 0x0F, 0xEF, 0x0F, 0xFF,
  0x87, 0xCF, 0xC7, 0x83, 0xC3, 0xC1, 0xE1, 0xC0, 0xF1, 0xE0, 0x78, 0xF0,
  0x3C, 0x78, 0x1E, 0x3C, 0x1E, 0x1E, 0x0F, 0x0F, 0x07, 0x87, 0x83, 0xC3,
  0xF7, 0xE0, 0xFF, 0xF0, 0x7F, 0xF0, 0x0F, 0x38, 0x00, 0x07, 0xE0, 0x3F,
  0xC1, 0xFF, 0x8F, 0x9F, 0x7C, 0x3D, 0xE0, 0xF7, 0x83, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x87, 0xCF, 0x1F,
  0xFC, 0x3F, 0xE0, 0x7E, 0x00, 0x00, 0xF0, 0x3F, 0x07, 0xF0, 0x7D, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x7F, 0xC7, 0xFC, 0x7F, 0xC1, 0xE0, 0x1E,
  0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78,
  0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x00, 0x03, 0xE7, 0x0F, 0xFF,
  0x1F, 0xFF, 0x1F, 0x3F, 0x3E, 0x1F, 0x3C, 0x0E, 0x3C, 0x1E, 0x78, 0x1E,
  0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1C, 0x78, 0x3C, 0x78, 0x3C,
  0x7E, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x0F, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x40, 0xF8, 0x71, 0xF0, 0xFF, 0xE0, 0x7F, 0xC0, 0x1F, 0x80, 0x07, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x0F,
  0x00, 0x1E, 0xF8, 0x3F, 0xF8, 0x7F, 0xF8, 0xF9, 0xF3, 0xE1, 0xE7, 0x83,
  0xCF, 0x07, 0x9E, 0x0F, 0x3C, 0x1E, 0x70, 0x39, 0xE0, 0xF3, 0xC1, 0xE7,
  0x83, 0xCF, 0x07, 0x9E, 0x0F, 0x38, 0x3C, 0xF0, 0x79, 0xE0, 0xF0, 0x07,
  0x07, 0xC3, 0xC0, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xE1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0xF0, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x07, 0x80,
  0x78, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x3E, 0x07,
  0xE0, 0x7C, 0x0F, 0x80, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x1F, 0x0F,
  0x0F, 0x07, 0x8F, 0x03, 0xCF, 0x81, 0xCF, 0x81, 0xEF, 0x80, 0xFF, 0x80,
  0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF8, 0x0F, 0xBC, 0x07, 0x8F,
  0x03, 0xC7, 0x81, 0xE3, 0xC0, 0xE0, 0xF0, 0xF0, 0x78, 0x78, 0x3E, 0x00,
  0x07, 0x83, 0xC3, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x78, 0x00, 0x1E, 0xF8, 0x7C, 0x1F, 0xFC, 0xFE,
  0x1F, 0xFF, 0xFE, 0x1F, 0x3F, 0x9F, 0x1E, 0x1F, 0x1F, 0x3C, 0x1E, 0x0F,
  0x3C, 0x1E, 0x0F, 0x3C, 0x1E, 0x0E, 0x3C, 0x1E, 0x1E, 0x3C, 0x3C, 0x1E,
  0x38, 0x3C, 0x1E, 0x78, 0x3C, 0x1E, 0x78, 0x3C, 0x1E, 0x78, 0x3C, 0x1C,
  0x78, 0x38, 0x3C, 0x78, 0x78, 0x3C, 0xF0, 0x78, 0x3C, 0xF0, 0x78, 0x3C,
  0x1E, 0xF8, 0x3F, 0xF8, 0x7F, 0xF8, 0xF9, 0xF3, 0xE1, 0xE7, 0x83, 0xCF,
  0x07, 0x9E, 0x0F, 0x3C, 0x1E, 0x78, 0x79, 0xE0, 0xF3, 0xC1, 0xE7, 0x83,
  0xCF, 0x07, 0x9E, 0x0F, 0x38, 0x3C, 0xF0, 0x79, 0xE0, 0xF0, 0x03, 0xE0,
  0x1F, 0xF0, 0x7F, 0xE1, 0xF3, 0xE7, 0xC3, 0xCF, 0x03, 0x9E, 0x07, 0xF8,
  0x0F, 0xF0, 0x1D, 0xE0, 0x7B, 0xC0, 0xF7, 0x81, 0xEF, 0x03, 0xDE, 0x0F,
  0x1E, 0x3E, 0x3F, 0xF8, 0x3F, 0xE0, 0x3F, 0x00, 0x0F, 0x7C, 0x07, 0xFF,
  0x03, 0xFF, 0xC1, 0xF3, 0xE0, 0xF0, 0xF0, 0xF0, 0x38, 0x78, 0x1C, 0x3C,
  0x0E, 0x1E, 0x0F, 0x0F, 0x07, 0x8F, 0x03, 0xC7, 0x81, 0xE3, 0xC0, 0xF1,
  0xE0, 0xF0, 0xF8, 0xF8, 0x7F, 0xF8, 0x7B, 0xF8, 0x3C, 0xF8, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x8E, 0x3F, 0xFC, 0xFF, 0xF9, 0xF3, 0xF7, 0x83, 0xCF,
  0x07, 0x9E, 0x0F, 0x78, 0x1E, 0xF0, 0x3D, 0xE0, 0x7B, 0xC1, 0xE7, 0x83,
  0xCF, 0x07, 0x9E, 0x0F, 0x3E, 0x7E, 0x3F, 0xFC, 0x7F, 0xF0, 0x3D, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x1E, 0xE1, 0xFE, 0x1F, 0xE1, 0xFE, 0x1F, 0x03, 0xE0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07,
  0x00, 0xF0, 0x0F, 0x00, 0x03, 0xE0, 0x1F, 0xF0, 0x7F, 0xF0, 0xF1, 0xE3,
  0xC3, 0xC7, 0x83, 0x8F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07,
  0xE0, 0x03, 0xCF, 0x07, 0x8E, 0x0F, 0x1E, 0x3E, 0x3F, 0xF8, 0x3F, 0xE0,
  0x1F, 0x00, 0x0F, 0x03, 0xC0, 0xE0, 0x78, 0x1E, 0x1F, 0xF7, 0xFB, 0xFE,
  0x1C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x81, 0xE0, 0x78, 0x1E,
  0x07, 0x81, 0xF8, 0x7E, 0x0F, 0x83, 0xE0, 0x3C, 0x1E, 0x78, 0x3C, 0xF0,
  0x79, 0xE0, 0xE7, 0x83, 0xCF, 0x07, 0x9E, 0x0F, 0x3C, 0x1E, 0x78, 0x3C,
  0xF0, 0x73, 0xC1, 0xE7, 0x83, 0xCF, 0x07, 0x9E, 0x1F, 0x3E, 0x7E, 0x3F,
  0xF8, 0x7F, 0xF0, 0x7D, 0xE0, 0xF0, 0x7B, 0xC1, 0xEF, 0x07, 0xBC, 0x3C,
  0xF0, 0xF1, 0xC7, 0x87, 0x1E, 0x1C, 0x70, 0x73, 0xC1, 0xEE, 0x07, 0xF8,
  0x1F, 0xE0, 0x7F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0,
  0x00, 0xF0, 0x70, 0xF7, 0x87, 0x87, 0xBC, 0x3C, 0x3D, 0xE3, 0xE3, 0xCF,
  0x1F, 0x1E, 0x79, 0xF8, 0xE3, 0xCF, 0xCF, 0x0E, 0x7E, 0x78, 0x77, 0x73,
  0x83, 0xBB, 0xBC, 0x1F, 0x9D, 0xC0, 0xFC, 0x7E, 0x07, 0xE3, 0xF0, 0x3E,
  0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0x07, 0x80, 0x78, 0x3C, 0x03, 0x81, 0xE0,
  0x00, 0x1E, 0x0F, 0x07, 0x8F, 0x83, 0xC7, 0x81, 0xE7, 0x80, 0x73, 0xC0,
  0x3F, 0xC0, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0xF3, 0x80, 0xF9, 0xE0, 0x78, 0xF0, 0x78,
  0x78, 0x7C, 0x1E, 0x00, 0x1E, 0x0F, 0x0F, 0x07, 0x87, 0x87, 0xC3, 0xC3,
  0xC1, 0xE1, 0xE0, 0x71, 0xE0, 0x38, 0xF0, 0x1C, 0xF0, 0x0E, 0x78, 0x07,
  0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0,
  0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0xFE,
  0x3F, 0xFC, 0x7F, 0xF8, 0x03, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x1E, 0x00, 0x7F, 0xF8, 0xFF, 0xF1, 0xFF, 0xE0, 0x00, 0x40, 0x3C, 0x0F,
  0x83, 0xC0, 0x78, 0x0E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x38, 0x0F,
  0x01, 0xE0, 0x3C, 0x0F, 0x07, 0xC0, 0xF0, 0x1E, 0x01, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0x70, 0x0F, 0x00, 0xE0, 0x0C, 0x00, 0x0E, 0x1C, 0x38, 0x61, 0xC3, 0x87,
  0x0E, 0x1C, 0x30, 0x61, 0xC3, 0x87, 0x0E, 0x1C, 0x30, 0xE1, 0xC3, 0x87,
  0x0E, 0x18, 0x30, 0xE1, 0xC3, 0x87, 0x0E, 0x18, 0x00, 0x04, 0x03, 0x80,
  0xF0, 0x1E, 0x07, 0x80, 0xE0, 0x38, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E,
  0x07, 0x01, 0xE0, 0x78, 0x0F, 0x01, 0xC1, 0xF0, 0xF0, 0x3C, 0x1E, 0x07,
  0x81, 0xE0, 0x78, 0x1C, 0x07, 0x03, 0xC0, 0xF0, 0x38, 0x1E, 0x0F, 0x03,
  0x80, 0x80, 0x00, 0x0F, 0x00, 0x1F, 0xC1, 0xCF, 0xF1, 0xEF, 0xFF, 0xE7,
  0x1F, 0xF3, 0x87, 0xF0, 0x00, 0xF0,
};

const GFXglyph RobotoCondensed_MediumItalic35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 8, 25, 9, 1, -25 },
  { 26, 9, 9, 11, 3, -26 },
  { 37, 18, 25, 18, 1, -25 },
  { 94, 15, 32, 17, 1, -29 },
  { 154, 16, 25, 22, 3, -25 },
  { 204, 17, 25, 19, 1, -25 },
  { 258, 5, 9, 6, 2, -26 },
  { 264, 10, 36, 11, 2, -28 },
  { 309, 11, 36, 11, -2, -28 },
  { 359, 14, 15, 15, 2, -25 },
  { 386, 15, 18, 16, 1, -21 },
  { 420, 7, 10, 8, -2, -4 },
  { 429, 8, 3, 11, 1, -12 },
  { 432, 5, 5, 9, 1, -5 },
  { 436, 16, 27, 12, -2, -25 },
  { 490, 14, 25, 17, 2, -25 },
  { 534, 10, 25, 17, 4, -25 },
  { 566, 16, 25, 17, 0, -25 },
  { 616, 15, 25, 17, 1, -25 },
  { 663, 16, 25, 17, 0, -25 },
  { 713, 16, 25, 17, 1, -25 },
  { 763, 13, 25, 17, 2, -25 },
  { 804, 16, 25, 17, 2, -25 },
  { 854, 15, 25, 17, 1, -25 },
  { 901, 14, 25, 17, 2, -25 },
  { 945, 7, 20, 9, 1, -20 },
  { 963, 10, 26, 8, -2, -20 },
  { 996, 13, 16, 15, 1, -19 },
  { 1022, 14, 10, 17, 2, -16 },
  { 1040, 14, 16, 16, 1, -19 },
  { 1068, 12, 25, 15, 3, -25 },
  { 1106, 24, 32, 26, 1, -24 },
  { 1202, 19, 25, 20, -1, -25 },
  { 1262, 18, 25, 19, 0, -25 },
  { 1319, 17, 25, 19, 2, -25 },
  { 1373, 18, 25, 19, 0, -25 },
  { 1430, 18, 25, 17, 0, -25 },
  { 1487, 18, 25, 16, 0, -25 },
  { 1544, 17, 25, 20, 2, -25 },
  { 1598, 21, 25, 21, 0, -25 },
  { 1664, 8, 25, 9, 1, -25 },
  { 1689, 17, 25, 17, 0, -25 },
  { 1743, 21, 25, 19, 0, -25 },
  { 1809, 14, 25, 16, 0, -25 },
  { 1853, 26, 25, 26, 0, -25 },
  { 1935, 21, 25, 21, 0, -25 },
  { 2001, 18, 25, 20, 2, -25 },
  { 2058, 19, 25, 19, 0, -25 },
  { 2118, 18, 29, 20, 2, -25 },
  { 2184, 18, 25, 18, 0, -25 },
  { 2241, 17, 25, 18, 1, -25 },
  { 2295, 17, 25, 18, 3, -25 },
  { 2349, 19, 25, 19, 1, -25 },
  { 2409, 18, 25, 19, 3, -25 },
  { 2466, 24, 25, 26, 3, -25 },
  { 2541, 21, 25, 19, -1, -25 },
  { 2607, 17, 25, 18, 3, -25 },
  { 2661, 19, 25, 18, 0, -25 },
  { 2721, 11, 35, 9, 0, -29 },
  { 2770, 8, 27, 13, 3, -25 },
  { 2797, 11, 35, 9, -2, -29 },
  { 2846, 11, 12, 13, 1, -25 },
  { 2863, 14, 3, 14, -2, 0 },
  { 2869, 6, 5, 11, 4, -26 },
  { 2873, 14, 18, 16, 1, -18 },
  { 2905, 16, 26, 17, 0, -26 },
  { 2957, 14, 18, 16, 1, -18 },
  { 2989, 17, 26, 17, 1, -26 },
  { 3045, 14, 18, 16, 1, -18 },
  { 3077, 12, 26, 11, 1, -26 },
  { 3116, 16, 25, 17, 0, -18 },
  { 3166, 15, 26, 17, 0, -26 },
  { 3215, 9, 25, 8, 0, -25 },
  { 3244, 12, 32, 8, -4, -25 },
  { 3292, 17, 26, 16, 0, -26 },
  { 3348, 9, 26, 8, 0, -26 },
  { 3378, 24, 18, 25, 0, -18 },
  { 3432, 15, 18, 17, 0, -18 },
  { 3466, 15, 18, 17, 1, -18 },
  { 3500, 17, 25, 17, -1, -18 },
  { 3554, 15, 25, 17, 1, -18 },
  { 3601, 12, 18, 11, 0, -18 },
  { 3628, 15, 18, 15, 0, -18 },
  { 3662, 10, 23, 10, 1, -23 },
  { 3691, 15, 18, 17, 1, -18 },
  { 3725, 14, 18, 15, 2, -18 },
  { 3757, 21, 18, 22, 2, -18 },
  { 3805, 17, 18, 15, -1, -18 },
  { 3844, 17, 25, 15, -1, -18 },
  { 3898, 15, 18, 15, 0, -18 },
  { 3932, 11, 33, 10, 1, -27 },
  { 3978, 7, 30, 8, 1, -25 },
  { 4005, 10, 33, 10, -1, -27 },
  { 4047, 17, 7, 19, 1, -14 },
};

const GFXfont RobotoCondensed_MediumItalic35pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_MediumItalic35pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_MediumItalic35pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _ROBOTOCONDENSED_MEDIUMITALIC35PT7B_H_
