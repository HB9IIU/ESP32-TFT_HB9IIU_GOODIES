#ifndef _ROBOTOCONDENSED_MEDIUMITALIC51PT7B_H_
#define _ROBOTOCONDENSED_MEDIUMITALIC51PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-MediumItalic.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_MediumItalic51pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xC0, 0x7C, 0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x1F, 0x81, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x3E, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x7C, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0x7C, 0x03, 0x80, 0x3C, 0x79, 0xE3, 0xCF, 0x1E,
  0xF8, 0xF7, 0x87, 0xBC, 0x79, 0xE3, 0xCF, 0x1E, 0x70, 0xF7, 0x87, 0x3C,
  0x39, 0xE3, 0xCF, 0x1E, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x87, 0x80,
  0x03, 0xC3, 0xC0, 0x03, 0xC3, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xF0, 0xF0,
  0x00, 0xF0, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C,
  0x03, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF8, 0x03, 0xC3, 0xC0, 0x03, 0xC3, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xF0,
  0xF0, 0x00, 0x70, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x1C,
  0x3C, 0x03, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFC, 0x03, 0xC3, 0xC0, 0x01, 0xE3, 0xC0, 0x01, 0xE1, 0xE0, 0x00,
  0xF0, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x3C, 0x3C, 0x00,
  0x1E, 0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xF0, 0x1F,
  0xFF, 0xE0, 0x7E, 0x1F, 0x83, 0xF0, 0x3E, 0x0F, 0xC0, 0xFC, 0x3E, 0x03,
  0xF1, 0xF8, 0x0F, 0xC7, 0xE0, 0x3F, 0x1F, 0x80, 0xFC, 0x3E, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x3E, 0x3E,
  0x00, 0xF8, 0xFC, 0x03, 0xE3, 0xF0, 0x1F, 0x8F, 0xC0, 0xFE, 0x1F, 0x87,
  0xF0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0x80,
  0x07, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0x07, 0x8F, 0x01, 0x1E, 0x0F, 0x07, 0xBC, 0x1E,
  0x0F, 0x78, 0x3C, 0x3C, 0xF0, 0x78, 0xF1, 0xE0, 0xF3, 0xE3, 0xC3, 0xC7,
  0x87, 0x87, 0x9E, 0x0F, 0x1F, 0x78, 0x1F, 0xFC, 0xF0, 0x1F, 0xFB, 0xC0,
  0x1F, 0xEF, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x8F, 0x80, 0x0F, 0x7F, 0x80, 0x3D, 0xFF, 0x80, 0xF3, 0xFF, 0x83,
  0xEF, 0x0F, 0x07, 0x9E, 0x1E, 0x1E, 0x78, 0x3C, 0x78, 0xF0, 0x78, 0xF1,
  0xE0, 0xF3, 0xC3, 0xC1, 0xEF, 0x07, 0x83, 0xFE, 0x0F, 0x07, 0xB8, 0x1F,
  0x1E, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0x87, 0xC0, 0x0F, 0x83, 0xE0, 0x07,
  0xC1, 0xF0, 0x03, 0xE0, 0xF8, 0x03, 0xF0, 0x7C, 0x01, 0xF8, 0x7E, 0x00,
  0x7C, 0x3E, 0x00, 0x3E, 0x7F, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0xC1, 0xE1, 0xFF, 0xE1, 0xF1, 0xFD, 0xF8, 0xF8, 0xFC, 0xFC,
  0x7C, 0xFC, 0x3F, 0x3E, 0x7E, 0x1F, 0xFE, 0x7E, 0x07, 0xFF, 0x3F, 0x03,
  0xFF, 0x1F, 0x80, 0xFF, 0x8F, 0xC0, 0x3F, 0x87, 0xE0, 0x1F, 0xC1, 0xF8,
  0x0F, 0xE0, 0xFF, 0x3F, 0xF0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x07,
  0xFF, 0xDF, 0x80, 0xFF, 0x8F, 0xC0, 0x0C, 0x00, 0x00, 0x3D, 0xF7, 0xDF,
  0x79, 0xE7, 0xBE, 0xF3, 0xCF, 0x3C, 0xF0, 0x00, 0x02, 0x00, 0x06, 0x00,
  0x0F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07,
  0x80, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x01, 0x80, 0x07, 0x80, 0x0F,
  0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0,
  0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0x08, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x60, 0x78, 0x37, 0x87, 0x0F, 0xFF, 0x77, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xF0, 0x7F, 0xF0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0xFB,
  0xC0, 0x1F, 0x3C, 0x03, 0xE1, 0xE0, 0x7C, 0x1F, 0x07, 0x81, 0xF0, 0x38,
  0x0E, 0x00, 0x00, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0x01, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xC3, 0xF0, 0xF8, 0x3E, 0x0F, 0x83, 0xE1, 0xF8,
  0x7C, 0x3F, 0x0F, 0x87, 0xE1, 0xF0, 0x78, 0x0C, 0x00, 0x7F, 0xFF, 0xFE,
  0xFF, 0xEF, 0xFE, 0xFF, 0xE0, 0x38, 0xFB, 0xFF, 0xFF, 0xEF, 0x8E, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0x87, 0xE0, 0xFC, 0x0F,
  0x87, 0xE0, 0x3E, 0x1F, 0x80, 0xF8, 0x7C, 0x03, 0xE3, 0xF0, 0x0F, 0xCF,
  0xC0, 0x3F, 0x3F, 0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0x9F, 0x80,
  0x7E, 0x7E, 0x01, 0xF9, 0xF8, 0x07, 0xE7, 0xE0, 0x1F, 0x9F, 0x80, 0x7E,
  0x7C, 0x01, 0xF1, 0xF0, 0x07, 0xCF, 0xC0, 0x3F, 0x3F, 0x00, 0xFC, 0xFC,
  0x03, 0xF3, 0xF0, 0x0F, 0x8F, 0xC0, 0x3E, 0x3F, 0x01, 0xF8, 0x7C, 0x07,
  0xC1, 0xF0, 0x3F, 0x07, 0xE1, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x00, 0x0C, 0x01, 0xF0,
  0x1F, 0xC3, 0xFF, 0x3F, 0xF9, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0xF1, 0xFB,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x03,
  0xFF, 0xFE, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x3F, 0x0F,
  0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3E, 0x0F, 0x80, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0x80, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x81, 0xFC, 0x3F, 0x83, 0xF0, 0x3F, 0x07, 0xE0, 0x3E, 0x1F, 0x80,
  0x7C, 0x3F, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0,
  0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE3, 0xF0, 0x0F, 0xC7, 0xE0, 0x1F, 0x8F, 0xC0, 0x3F, 0x1F, 0x80,
  0xFC, 0x1F, 0x83, 0xF8, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x3F, 0xFE,
  0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0x80, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF8,
  0x00, 0xFB, 0xF0, 0x01, 0xF7, 0xC0, 0x07, 0xCF, 0x80, 0x1F, 0x3F, 0x00,
  0x3E, 0x7E, 0x00, 0xF8, 0xFC, 0x03, 0xE1, 0xF8, 0x0F, 0xC3, 0xE0, 0x1F,
  0x07, 0xC0, 0x7C, 0x1F, 0x81, 0xF8, 0x3F, 0x03, 0xE0, 0x7E, 0x0F, 0x80,
  0xFC, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xFB, 0xE0, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xE0, 0x7E, 0x0F, 0xE0, 0x18, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE3, 0xF0, 0x0F, 0xC7, 0xE0, 0x1F, 0x0F,
  0xC0, 0x7E, 0x1F, 0x81, 0xFC, 0x1F, 0x87, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F,
  0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x01, 0xFF, 0xE0,
  0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x3F, 0x03, 0xFF, 0xF8, 0x3F, 0xFF,
  0xC3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE7, 0xF8, 0x7F, 0x7F, 0x03, 0xF7, 0xE0,
  0x3F, 0x7E, 0x03, 0xF7, 0xC0, 0x1F, 0x7C, 0x01, 0xFF, 0xC0, 0x1F, 0xFC,
  0x03, 0xF7, 0xC0, 0x3F, 0x7C, 0x03, 0xF7, 0xC0, 0x3E, 0x7C, 0x07, 0xE7,
  0xE0, 0x7E, 0x7F, 0x1F, 0xC3, 0xFF, 0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xF0,
  0x0F, 0xFC, 0x00, 0x3F, 0x00, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xC0, 0xFE, 0x1F, 0x81, 0xF8, 0x3F, 0x03, 0xF0, 0x3F,
  0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF0, 0x7E, 0x07, 0xE0,
  0xFC, 0x0F, 0xC0, 0xF8, 0x1F, 0x81, 0xF8, 0x7E, 0x01, 0xFF, 0xF8, 0x03,
  0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x7F, 0xFE, 0x01, 0xF8,
  0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0x80, 0xFC, 0x3F, 0x00, 0xF8, 0x7E, 0x01,
  0xF0, 0xF8, 0x03, 0xE1, 0xF0, 0x0F, 0xC3, 0xE0, 0x1F, 0x87, 0xE0, 0x3F,
  0x0F, 0xC0, 0xFC, 0x1F, 0xC3, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0,
  0x3F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x7F, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xFC, 0x7E, 0x1F, 0x9F,
  0x81, 0xFB, 0xF0, 0x3F, 0x7C, 0x07, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xFC,
  0x07, 0xFF, 0x81, 0xFF, 0xF8, 0x7F, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0x7F,
  0xFF, 0x87, 0xFB, 0xE0, 0x7E, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFE, 0x03, 0xFF,
  0x80, 0x7F, 0xE0, 0x0F, 0xF8, 0x01, 0xFC, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0x80, 0xF8, 0x3F, 0x07, 0xF0, 0xFC, 0x1F, 0x81, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x1F, 0x07, 0xF0, 0xFE, 0x1F, 0xC1, 0xF0,
  0x1C, 0x00, 0x00, 0xE0, 0x0F, 0x80, 0xFE, 0x07, 0xF0, 0x3F, 0x80, 0xFC,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x3E, 0x01,
  0xF0, 0x1F, 0x80, 0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0x3C, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x07, 0x00, 0x01, 0xF0, 0x00, 0x7E, 0x00,
  0x1F, 0xE0, 0x07, 0xFE, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xFE, 0x07,
  0xFF, 0x00, 0x7F, 0xC0, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00,
  0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0x80, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00,
  0x10, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0xFF, 0xE3,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F,
  0xFF, 0xE3, 0xFF, 0xFF, 0x00, 0x08, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0xFC, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F,
  0xFC, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00,
  0x1F, 0xF0, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x07,
  0xFF, 0x00, 0x7F, 0xC0, 0x07, 0xF0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x03, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xFF, 0xFE,
  0x3F, 0xFF, 0x9F, 0xC7, 0xE7, 0xE0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF,
  0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x03, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xF8, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x1E, 0x00, 0x3F, 0x00, 0x01, 0xE0, 0x07, 0xC0, 0x00, 0x1C, 0x01,
  0xF0, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x07,
  0x03, 0xC0, 0x1F, 0x00, 0xF0, 0xF8, 0x0F, 0xF8, 0x1E, 0x1E, 0x03, 0xFF,
  0x83, 0xC7, 0xC0, 0xFF, 0xF8, 0x78, 0xF0, 0x3E, 0x1E, 0x0F, 0x1E, 0x0F,
  0x83, 0xC1, 0xE7, 0x81, 0xE0, 0x78, 0x3C, 0xF0, 0x7C, 0x1F, 0x07, 0x9E,
  0x0F, 0x03, 0xC0, 0xF7, 0x81, 0xE0, 0x78, 0x1E, 0xF0, 0x7C, 0x0F, 0x03,
  0xDE, 0x0F, 0x81, 0xE0, 0x73, 0xC1, 0xE0, 0x78, 0x0E, 0x78, 0x7C, 0x0F,
  0x03, 0xDE, 0x0F, 0x81, 0xE0, 0x7B, 0xC1, 0xF0, 0x7C, 0x0E, 0x78, 0x3E,
  0x0F, 0x03, 0xCF, 0x07, 0xC1, 0xE0, 0x79, 0xE0, 0xF8, 0x7C, 0x0E, 0x3C,
  0x1F, 0x1F, 0x83, 0xC7, 0x83, 0xFF, 0xF8, 0xF0, 0xF0, 0x3F, 0xEF, 0xFC,
  0x1E, 0x07, 0xF9, 0xFF, 0x01, 0xE0, 0x7E, 0x1F, 0xC0, 0x3C, 0x00, 0x00,
  0xC0, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x08, 0x00, 0x03,
  0xF8, 0x07, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x0F, 0xDF,
  0x00, 0x00, 0xF9, 0xF0, 0x00, 0x1F, 0x9F, 0x00, 0x01, 0xF9, 0xF8, 0x00,
  0x3F, 0x0F, 0x80, 0x03, 0xF0, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xE0,
  0xF8, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0xC0, 0xF8, 0x00, 0xF8, 0x0F, 0xC0,
  0x1F, 0x80, 0xFC, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE,
  0x0F, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x07, 0xE3, 0xF0,
  0x00, 0x7E, 0x3F, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x03,
  0xEF, 0xE0, 0x00, 0x3F, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0x01, 0xFC, 0x1F,
  0x80, 0x7E, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0xC3,
  0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0xFC, 0x03, 0xF8, 0x7E, 0x01, 0xF8,
  0x7E, 0x01, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x83, 0xF0, 0x0F, 0xC1, 0xF8, 0x03,
  0xF0, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x3F, 0x00,
  0x3F, 0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0x0F, 0xC7, 0xE0, 0x0F, 0xC3, 0xF0,
  0x0F, 0xE1, 0xF8, 0x0F, 0xF1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0x01, 0xFE, 0x0F, 0xE0, 0x7E, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x1F,
  0xC0, 0x0F, 0xC7, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0xFC, 0xFC, 0x00, 0x3F,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x3E, 0x3F, 0x00, 0x1F, 0x87, 0xC0, 0x07,
  0xE1, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x7F, 0x03, 0xF8,
  0x3F, 0x80, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00,
  0x7F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xF8,
  0x3F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x1F, 0x83,
  0xF0, 0x03, 0xE0, 0xFC, 0x00, 0xF8, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F,
  0xC3, 0xF0, 0x03, 0xF1, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x3E, 0x1F, 0x80,
  0x1F, 0x87, 0xE0, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x7C, 0x00, 0x7E, 0x3F,
  0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xFC,
  0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x1F, 0x87, 0xE0, 0x07, 0xE1, 0xF8, 0x03,
  0xF8, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0xFE, 0x07, 0xE0, 0xFF, 0x83, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x03,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x07,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x81, 0xFE, 0x0F, 0xE0, 0xFE, 0x01, 0xF8,
  0x3F, 0x00, 0x3F, 0x1F, 0xC0, 0x0F, 0xC7, 0xE0, 0x03, 0xF1, 0xF8, 0x00,
  0xFC, 0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x81, 0xFF, 0xE7,
  0xE0, 0x7F, 0xF9, 0xF8, 0x1F, 0xFE, 0x7E, 0x07, 0xFF, 0x1F, 0x81, 0xFF,
  0xC7, 0xC0, 0x03, 0xF3, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x3F, 0x1F, 0x00,
  0x0F, 0xC7, 0xE0, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x1F,
  0xC0, 0x3F, 0x83, 0xF8, 0x3F, 0xE0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x3E, 0x00, 0x0F, 0x81, 0xF8, 0x00,
  0x7E, 0x07, 0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x07, 0xE0, 0x7E, 0x00, 0x1F,
  0x81, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xF0, 0x3F, 0x00, 0x0F, 0xC0,
  0xFC, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x3F,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xF8, 0x3F, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0xFC,
  0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3E, 0x07,
  0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x07, 0xE0, 0x7E, 0x00, 0x1F, 0x81, 0xF8,
  0x00, 0x7E, 0x07, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xC0, 0xFC, 0x00,
  0x3F, 0x03, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7C, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC1,
  0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7C, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF0, 0x7E, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x07, 0xE0,
  0x7E, 0x03, 0xF0, 0x3F, 0x01, 0xFC, 0x7F, 0x00, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF0, 0x03, 0xF8, 0x0F, 0xC0, 0x1F, 0xC0, 0x3E, 0x00, 0xFF, 0x01,
  0xF8, 0x07, 0xF8, 0x07, 0xE0, 0x3F, 0xC0, 0x1F, 0x80, 0xFE, 0x00, 0x7E,
  0x07, 0xF0, 0x01, 0xF8, 0x3F, 0x80, 0x0F, 0xC1, 0xFC, 0x00, 0x3F, 0x0F,
  0xF0, 0x00, 0xFC, 0x3F, 0x80, 0x03, 0xF1, 0xFC, 0x00, 0x0F, 0xCF, 0xE0,
  0x00, 0x3F, 0x7F, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xBF, 0x00, 0x03, 0xFC,
  0xFC, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF8, 0x1F,
  0x80, 0x07, 0xE0, 0x7F, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x7E, 0x03, 0xF8,
  0x01, 0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7F, 0x00,
  0xFC, 0x00, 0xFC, 0x03, 0xF0, 0x03, 0xF8, 0x0F, 0xC0, 0x0F, 0xE0, 0x3F,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xFF, 0xFE, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x03, 0xFC, 0x0F,
  0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x0F,
  0xF8, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x07, 0xFE, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0x7F, 0xF0, 0x03, 0xFF, 0x03, 0xFF, 0x80, 0x3F, 0xF8,
  0x1F, 0x7C, 0x01, 0xFF, 0xC0, 0xFB, 0xE0, 0x1F, 0xFE, 0x07, 0xDF, 0x00,
  0xFB, 0xF0, 0x7E, 0xF8, 0x0F, 0xDF, 0x03, 0xF7, 0xC0, 0x7C, 0xF8, 0x1F,
  0x9E, 0x03, 0xEF, 0xC0, 0xFC, 0xF0, 0x3E, 0x7E, 0x07, 0xC7, 0xC1, 0xF3,
  0xF0, 0x3E, 0x3E, 0x1F, 0x1F, 0x03, 0xF1, 0xF0, 0xF8, 0xF8, 0x1F, 0x8F,
  0x8F, 0x8F, 0xC0, 0xFC, 0x7C, 0x7C, 0x7E, 0x07, 0xE3, 0xE7, 0xC3, 0xF0,
  0x3F, 0x0F, 0x3E, 0x1F, 0x83, 0xF0, 0x7B, 0xE0, 0xF8, 0x1F, 0x83, 0xDF,
  0x0F, 0xC0, 0xFC, 0x1F, 0xF0, 0x7E, 0x07, 0xE0, 0xFF, 0x83, 0xF0, 0x3F,
  0x07, 0xF8, 0x1F, 0x81, 0xF8, 0x3F, 0xC0, 0xFC, 0x1F, 0x80, 0xFC, 0x0F,
  0xC0, 0xFC, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x3F, 0x01,
  0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0x80, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0xFC,
  0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0x81, 0xFE, 0x00, 0x7E, 0x07,
  0xF8, 0x01, 0xF8, 0x1F, 0xE0, 0x07, 0xE0, 0x7F, 0xC0, 0x1F, 0x81, 0xFF,
  0x00, 0x7E, 0x0F, 0xFC, 0x03, 0xF0, 0x3F, 0xF8, 0x0F, 0xC0, 0xFF, 0xE0,
  0x3F, 0x03, 0xFF, 0x80, 0xFC, 0x0F, 0xDE, 0x03, 0xF0, 0x3F, 0x7C, 0x0F,
  0xC1, 0xF9, 0xF0, 0x7E, 0x07, 0xE3, 0xC1, 0xF8, 0x1F, 0x8F, 0x87, 0xE0,
  0x7E, 0x3E, 0x1F, 0x81, 0xF8, 0x78, 0x7E, 0x07, 0xE1, 0xF1, 0xF0, 0x3F,
  0x07, 0xCF, 0xC0, 0xFC, 0x1F, 0x3F, 0x03, 0xF0, 0x3C, 0xFC, 0x0F, 0xC0,
  0xFB, 0xF0, 0x3F, 0x03, 0xEF, 0xC1, 0xF8, 0x07, 0xBE, 0x07, 0xE0, 0x1F,
  0xF8, 0x1F, 0x80, 0x7F, 0xE0, 0x7E, 0x00, 0xFF, 0x81, 0xF8, 0x03, 0xFE,
  0x07, 0xE0, 0x0F, 0xF8, 0x3F, 0x00, 0x3F, 0xC0, 0xFC, 0x00, 0x7F, 0x03,
  0xF0, 0x01, 0xFC, 0x0F, 0xC0, 0x07, 0xF0, 0x3F, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xF8, 0x0F, 0xF0, 0x7F, 0x01, 0xF8, 0x07, 0xE0, 0x7E,
  0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x1F,
  0x1F, 0x80, 0x03, 0xE3, 0xF0, 0x00, 0x7C, 0x7E, 0x00, 0x1F, 0x8F, 0xC0,
  0x03, 0xF1, 0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xF9,
  0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x07, 0xE7, 0xE0, 0x01, 0xF8, 0xFC, 0x00,
  0x3F, 0x1F, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0x0F,
  0x80, 0x07, 0xE1, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x07,
  0xE0, 0xFE, 0x01, 0xF8, 0x0F, 0xE0, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xC0, 0x3F, 0x81, 0xF8, 0x03,
  0xF0, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x3F,
  0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x1F,
  0x87, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0xFE, 0x1F, 0x80, 0x3F, 0x83, 0xF0,
  0x0F, 0xF0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF,
  0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x01, 0xFE, 0x0F, 0xE0, 0x7E,
  0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x1F, 0xC0, 0x0F, 0xC7, 0xE0, 0x03, 0xF1,
  0xF8, 0x00, 0xFC, 0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xCF, 0xC0, 0x03,
  0xF3, 0xE0, 0x00, 0xFD, 0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xDF, 0x80,
  0x03, 0xF7, 0xE0, 0x00, 0xFD, 0xF8, 0x00, 0x3E, 0x7E, 0x00, 0x1F, 0xBF,
  0x00, 0x07, 0xEF, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x3F,
  0x3F, 0x00, 0x0F, 0xC7, 0xC0, 0x03, 0xF1, 0xF8, 0x01, 0xF8, 0x7E, 0x00,
  0xFE, 0x1F, 0xC0, 0x7F, 0x03, 0xF8, 0x3F, 0x80, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x08, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x81, 0xF8, 0x0F, 0xE0, 0x7E, 0x01, 0xF8, 0x1F, 0x80, 0x7E, 0x07, 0xC0,
  0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x3E, 0x0F,
  0xC0, 0x1F, 0x83, 0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xF8, 0x7E, 0x01, 0xFC,
  0x1F, 0x80, 0xFF, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0xFC,
  0x1F, 0x80, 0x3F, 0x07, 0xF0, 0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF8, 0x1F, 0x80, 0x7E, 0x07, 0xE0, 0x1F,
  0x83, 0xF0, 0x07, 0xE0, 0xFC, 0x01, 0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0xC0,
  0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x3F, 0xC3, 0xF8,
  0x1F, 0x80, 0xFE, 0x1F, 0xC0, 0x3F, 0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x0F,
  0xC3, 0xF0, 0x07, 0xE1, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x7E,
  0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x1F, 0x87, 0xE0, 0x0F, 0xC3,
  0xF0, 0x0F, 0xE1, 0xFE, 0x1F, 0xE0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0,
  0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xF0, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x3F, 0x00,
  0x1F, 0x87, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x1F, 0x00, 0x1F, 0x87,
  0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x03,
  0xF0, 0x7E, 0x00, 0x7E, 0x0F, 0x80, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x7E,
  0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x3F,
  0x0F, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x87, 0xE0,
  0x03, 0xE0, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x87, 0xE0, 0x03, 0xF0,
  0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0x7E, 0x00,
  0x7E, 0x0F, 0xC0, 0x1F, 0xC0, 0xFC, 0x03, 0xF0, 0x1F, 0xC1, 0xFE, 0x03,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFB,
  0xF8, 0x00, 0x7F, 0x3F, 0x00, 0x0F, 0xC7, 0xE0, 0x03, 0xF8, 0xFC, 0x00,
  0x7E, 0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x03, 0xF8, 0x7E, 0x00, 0x7E, 0x0F,
  0xC0, 0x1F, 0xC0, 0xF8, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x3F,
  0x07, 0xF0, 0x03, 0xE0, 0xFC, 0x00, 0x7C, 0x1F, 0x80, 0x0F, 0x87, 0xE0,
  0x01, 0xF0, 0xFC, 0x00, 0x3E, 0x3F, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0xFC,
  0xF8, 0x00, 0x1F, 0xBF, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3F, 0xF8, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xDF,
  0x80, 0x7E, 0x01, 0xFB, 0xF0, 0x0F, 0xC0, 0x3F, 0x7E, 0x03, 0xF8, 0x07,
  0xCF, 0xC0, 0x7F, 0x01, 0xF9, 0xF8, 0x0F, 0xE0, 0x3F, 0x3F, 0x03, 0xFC,
  0x07, 0xC7, 0xE0, 0x7F, 0x81, 0xF8, 0xFC, 0x0F, 0xF0, 0x3F, 0x1F, 0x83,
  0xFE, 0x07, 0xC3, 0xF0, 0x7F, 0xC1, 0xF8, 0x7E, 0x0F, 0xF8, 0x3F, 0x0F,
  0xC3, 0xEF, 0x07, 0xC1, 0xF8, 0x7D, 0xE1, 0xF8, 0x3F, 0x1F, 0x3C, 0x3F,
  0x07, 0xE3, 0xE7, 0x87, 0xC0, 0xFC, 0x7C, 0xF1, 0xF8, 0x1F, 0x9F, 0x1E,
  0x3F, 0x03, 0xF3, 0xE3, 0xC7, 0xC0, 0x7E, 0x78, 0x79, 0xF8, 0x0F, 0xDF,
  0x0F, 0x3F, 0x01, 0xFB, 0xE1, 0xE7, 0xC0, 0x3F, 0x78, 0x3C, 0xF8, 0x07,
  0xFF, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0xFF, 0xC0, 0x1F, 0xF8, 0x1F, 0xF8,
  0x03, 0xFF, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x07, 0xF8, 0x0F,
  0xF8, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0x03, 0xF8,
  0x07, 0xF8, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x01,
  0xF8, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x01,
  0xFC, 0x07, 0xF0, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x1F, 0xC0, 0x7F, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0xFC, 0x7F, 0x00,
  0x01, 0xF9, 0xFC, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x03, 0xF3,
  0xF0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x7E, 0x0F,
  0xC0, 0x01, 0xFC, 0x0F, 0xC0, 0x07, 0xF0, 0x1F, 0x80, 0x0F, 0xE0, 0x3F,
  0x00, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0xFC,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x1F, 0x9F, 0x80, 0x0F, 0xE7,
  0xE0, 0x03, 0xF1, 0xF8, 0x01, 0xFC, 0x3E, 0x00, 0x7E, 0x0F, 0xC0, 0x3F,
  0x03, 0xF0, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x1F, 0x03, 0xF8, 0x07, 0xC0,
  0xFC, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0x8F, 0xC0, 0x03,
  0xE3, 0xF0, 0x00, 0xF9, 0xF8, 0x00, 0x3F, 0x7C, 0x00, 0x07, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x7F, 0xC0, 0x00,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xE0, 0xFC, 0x1F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x83, 0xF0, 0x7E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7E, 0x0F, 0xC1, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF8,
  0x3F, 0x07, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xE0, 0xFC, 0x1F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F,
  0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x01,
  0xFC, 0x01, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xFC, 0x07, 0xBC, 0x0F,
  0xBE, 0x0F, 0x1E, 0x1F, 0x1E, 0x1E, 0x1E, 0x3E, 0x1E, 0x3C, 0x1E, 0x7C,
  0x1F, 0x7C, 0x1F, 0xF8, 0x1F, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0xFE, 0x1F, 0x83, 0xF0, 0xFC, 0x1F,
  0x03, 0xE0, 0xF8, 0x1F, 0x00, 0x7F, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0xE0,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF1, 0xFC, 0x3F, 0x1F, 0x83, 0xF1, 0xF0, 0x1F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x1F, 0xFF, 0x07, 0xFF,
  0xE1, 0xFF, 0xFE, 0x3F, 0xFF, 0xE7, 0xF8, 0x7E, 0x7E, 0x07, 0xEF, 0xC0,
  0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0x7C, 0xFC, 0x0F, 0xCF, 0xC1, 0xFC, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0xFF, 0xC3, 0xFE, 0xFC, 0x0F, 0x8F, 0xC0,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x3E, 0x00, 0x7D,
  0xFF, 0x00, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xE0,
  0xFC, 0x1F, 0x81, 0xF8, 0x3E, 0x01, 0xF8, 0xFC, 0x03, 0xF1, 0xF8, 0x07,
  0xE3, 0xF0, 0x0F, 0xC7, 0xE0, 0x1F, 0x8F, 0x80, 0x3E, 0x1F, 0x00, 0x7C,
  0x7E, 0x00, 0xF8, 0xFC, 0x03, 0xF1, 0xF8, 0x07, 0xE3, 0xF0, 0x0F, 0xC7,
  0xC0, 0x1F, 0x0F, 0x80, 0x7E, 0x3F, 0x80, 0xFC, 0x7F, 0x87, 0xF0, 0xFF,
  0xFF, 0xE1, 0xF7, 0xFF, 0x83, 0xEF, 0xFE, 0x0F, 0xCF, 0xF8, 0x1F, 0x87,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x0F, 0xE1, 0xF8, 0x7C, 0x07, 0xC7, 0xE0, 0x3F, 0x3E,
  0x01, 0xFB, 0xF0, 0x0F, 0xDF, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0xF8, 0xF8, 0x0F, 0xC7, 0xC0, 0x7E, 0x3F, 0x07, 0xE1,
  0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x1F, 0x8F, 0xC0, 0x3F, 0xE7, 0xC0, 0x3F, 0xFB, 0xE0, 0x3F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF8, 0x1F, 0xC3, 0xFC, 0x1F, 0xC0, 0xFE, 0x0F, 0xC0, 0x3E,
  0x07, 0xC0, 0x1F, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0xC1, 0xF8, 0x07,
  0xE0, 0xF8, 0x03, 0xF0, 0x7C, 0x01, 0xF0, 0x3E, 0x00, 0xF8, 0x3F, 0x00,
  0xFC, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x83, 0xF0,
  0x0F, 0x80, 0xFC, 0x0F, 0xC0, 0x7E, 0x0F, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0x7C, 0x00, 0x3E, 0x3E, 0x00,
  0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x0F, 0xE1, 0xF8, 0x7E, 0x07, 0xE7, 0xE0, 0x3F, 0x3F, 0x01, 0xF9,
  0xF0, 0x0F, 0xDF, 0x80, 0x7E, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xCF, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x18, 0x3F, 0x83, 0xE0, 0xFF, 0xFF,
  0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x1F, 0xFC,
  0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8,
  0x07, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xF0, 0xFF, 0xF8, 0x0F, 0xC0, 0x07,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0,
  0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x1F, 0x01, 0xFF, 0x3F, 0x03, 0xFF, 0xBF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFE, 0x0F, 0xE1, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0x80, 0x7E, 0x1F, 0x80,
  0x7C, 0x3F, 0x00, 0x7C, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00,
  0xFC, 0x3E, 0x00, 0xFC, 0x3E, 0x00, 0xF8, 0x7E, 0x00, 0xF8, 0x7E, 0x01,
  0xF8, 0x7E, 0x01, 0xF8, 0x3E, 0x01, 0xF8, 0x3E, 0x01, 0xF8, 0x3F, 0x03,
  0xF0, 0x3F, 0x87, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF0, 0x0F, 0xFB, 0xF0, 0x03, 0xF3, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x20, 0x0F, 0xC0, 0x78, 0x1F, 0xC0, 0x7F, 0xFF,
  0x80, 0xFF, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF1, 0xF0, 0x07, 0xDF,
  0xF0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xE1, 0xFC,
  0x3F, 0x03, 0xF0, 0xF8, 0x0F, 0xC7, 0xE0, 0x3F, 0x1F, 0x80, 0xFC, 0x7E,
  0x03, 0xF1, 0xF8, 0x0F, 0x87, 0xC0, 0x3E, 0x3F, 0x01, 0xF8, 0xFC, 0x07,
  0xE3, 0xF0, 0x1F, 0x8F, 0xC0, 0x7E, 0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC7,
  0xE0, 0x3F, 0x1F, 0x80, 0xFC, 0x7E, 0x03, 0xF1, 0xF8, 0x0F, 0xC7, 0xC0,
  0x3E, 0x1F, 0x00, 0xF8, 0xFC, 0x07, 0xE3, 0xF0, 0x1F, 0x80, 0x00, 0x80,
  0x7C, 0x1F, 0x83, 0xF0, 0x7E, 0x07, 0xC0, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0xFC, 0x1F, 0x03, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0x81, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xC0, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F,
  0x81, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x1F, 0xF8,
  0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x7F, 0x07, 0xC0, 0xFE,
  0x07, 0xC1, 0xFC, 0x0F, 0xC3, 0xF8, 0x0F, 0xC7, 0xF0, 0x0F, 0xC7, 0xE0,
  0x0F, 0x8F, 0xE0, 0x0F, 0x9F, 0xC0, 0x1F, 0xBF, 0x80, 0x1F, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xBF, 0x00, 0x3F, 0x1F, 0x80,
  0x3E, 0x1F, 0x80, 0x3E, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0,
  0x7E, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x7C, 0x07, 0xE0, 0xFC, 0x07, 0xF0,
  0xFC, 0x03, 0xF0, 0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x3E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xC0, 0x7C, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xF8,
  0x0F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF0, 0x1F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x3E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xC0, 0x7C, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xF8, 0x0F, 0x80,
  0x07, 0xC7, 0xC0, 0x7E, 0x00, 0xFB, 0xFE, 0x3F, 0xF0, 0x3F, 0xFF, 0xEF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xC3,
  0xFE, 0x1F, 0x83, 0xF0, 0x3F, 0x81, 0xF0, 0x7C, 0x07, 0xE0, 0x3F, 0x1F,
  0x80, 0xFC, 0x07, 0xE3, 0xF0, 0x1F, 0x80, 0xF8, 0x7E, 0x03, 0xF0, 0x1F,
  0x0F, 0xC0, 0x7C, 0x07, 0xE1, 0xF0, 0x0F, 0x80, 0xFC, 0x3E, 0x03, 0xF0,
  0x1F, 0x8F, 0xC0, 0x7E, 0x03, 0xF1, 0xF8, 0x0F, 0xC0, 0x7C, 0x3F, 0x01,
  0xF0, 0x0F, 0x87, 0xE0, 0x3E, 0x03, 0xF0, 0xF8, 0x0F, 0xC0, 0x7E, 0x1F,
  0x01, 0xF8, 0x0F, 0xC7, 0xE0, 0x3F, 0x01, 0xF8, 0xFC, 0x07, 0xE0, 0x3E,
  0x1F, 0x80, 0xF8, 0x07, 0xC3, 0xF0, 0x1F, 0x01, 0xF8, 0x7C, 0x07, 0xE0,
  0x3F, 0x0F, 0x80, 0xFC, 0x07, 0xE3, 0xF0, 0x1F, 0x80, 0xFC, 0x00, 0x07,
  0xC7, 0xC0, 0x1F, 0x7F, 0xC0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF8, 0x3F, 0x87, 0xF0, 0xFC, 0x0F, 0xC3, 0xE0, 0x3F, 0x1F, 0x80, 0xFC,
  0x7E, 0x03, 0xF1, 0xF8, 0x0F, 0xC7, 0xE0, 0x3E, 0x1F, 0x00, 0xF8, 0xFC,
  0x07, 0xE3, 0xF0, 0x1F, 0x8F, 0xC0, 0x7E, 0x3F, 0x01, 0xF8, 0xF8, 0x07,
  0xC3, 0xE0, 0x1F, 0x1F, 0x80, 0xFC, 0x7E, 0x03, 0xF1, 0xF8, 0x0F, 0xC7,
  0xE0, 0x3F, 0x1F, 0x00, 0xF8, 0x7C, 0x03, 0xE3, 0xF0, 0x1F, 0x8F, 0xC0,
  0x7E, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0x0F, 0xE1, 0xF8, 0x1F, 0x8F, 0xC0, 0x3E,
  0x3F, 0x00, 0xFD, 0xF8, 0x03, 0xF7, 0xE0, 0x0F, 0xDF, 0x80, 0x3F, 0x7E,
  0x00, 0xFD, 0xF0, 0x03, 0xE7, 0xC0, 0x0F, 0x9F, 0x00, 0x3E, 0xFC, 0x01,
  0xF9, 0xF0, 0x07, 0xE7, 0xC0, 0x1F, 0x1F, 0x00, 0xFC, 0x7E, 0x07, 0xF1,
  0xFC, 0x3F, 0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0xFB, 0xFE, 0x00,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xC3, 0xF8,
  0x0F, 0xC0, 0xFC, 0x07, 0xC0, 0x3E, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x0F,
  0xC1, 0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xE0, 0x7C, 0x01, 0xF0, 0x3E, 0x00,
  0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x3F, 0x07, 0xE0,
  0x1F, 0x83, 0xE0, 0x0F, 0x83, 0xF0, 0x0F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFF,
  0x0F, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0x7F, 0xF0, 0x1F,
  0x9F, 0xF0, 0x0F, 0xC3, 0xE0, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0xFC, 0x7E, 0x07, 0xFC, 0xF8, 0x1F, 0xFD, 0xF0, 0x7F, 0xFF,
  0xE1, 0xFF, 0xFF, 0xC3, 0xF8, 0x7F, 0x8F, 0xE0, 0x7F, 0x1F, 0x80, 0x7C,
  0x3E, 0x00, 0xF8, 0xFC, 0x03, 0xF1, 0xF8, 0x07, 0xE3, 0xF0, 0x0F, 0xC7,
  0xC0, 0x1F, 0x8F, 0x80, 0x3E, 0x1F, 0x00, 0xFC, 0x7E, 0x01, 0xF8, 0xFC,
  0x03, 0xF1, 0xF8, 0x07, 0xE3, 0xF0, 0x0F, 0x87, 0xE0, 0x1F, 0x07, 0xE0,
  0x7E, 0x0F, 0xC1, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xC0, 0x3F, 0xEF, 0x80, 0x1F, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xCF, 0x83, 0xEF, 0xC3, 0xFF, 0xE1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F,
  0xF8, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xF8,
  0x3F, 0x1F, 0x03, 0xF3, 0xF0, 0x3F, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F,
  0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80,
  0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0xF8, 0x07, 0xCF, 0x80, 0x7C,
  0xF8, 0x0F, 0xCF, 0xC1, 0xFC, 0x7F, 0xFF, 0x87, 0xFF, 0xF8, 0x3F, 0xFF,
  0x01, 0xFF, 0xC0, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x00, 0xF8, 0x07, 0xE0, 0x3F, 0xE1, 0xFE, 0x07, 0xF0, 0x3F, 0x80,
  0x7C, 0x00, 0x1F, 0x00, 0xF8, 0xF8, 0x07, 0xCF, 0xC0, 0x7E, 0x7E, 0x03,
  0xF3, 0xF0, 0x1F, 0x9F, 0x80, 0xFC, 0xF8, 0x07, 0xC7, 0xC0, 0x7E, 0x7E,
  0x03, 0xF3, 0xF0, 0x1F, 0x9F, 0x80, 0xFC, 0xFC, 0x07, 0xC7, 0xC0, 0x3E,
  0x7E, 0x03, 0xF3, 0xF0, 0x1F, 0x9F, 0x80, 0xFC, 0xFC, 0x07, 0xE7, 0xE0,
  0x3E, 0x3E, 0x03, 0xF1, 0xF0, 0x1F, 0x8F, 0xC0, 0xFC, 0x7E, 0x1F, 0xE3,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x81, 0xFF, 0x7C, 0x07, 0xE0,
  0x00, 0xFC, 0x03, 0xFF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0xFC, 0xFC,
  0x0F, 0xCF, 0xC0, 0xF8, 0x7C, 0x1F, 0x87, 0xC1, 0xF8, 0x7C, 0x1F, 0x07,
  0xC3, 0xF0, 0x7C, 0x3E, 0x07, 0xC7, 0xE0, 0x7C, 0x7C, 0x07, 0xC7, 0xC0,
  0x3E, 0xFC, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xF0,
  0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x0F, 0x80,
  0xFF, 0xF0, 0x3E, 0x03, 0xEF, 0xC0, 0xF8, 0x1F, 0xBF, 0x07, 0xE0, 0x7C,
  0xFC, 0x1F, 0x81, 0xF3, 0xF0, 0xFE, 0x0F, 0xCF, 0xC3, 0xF8, 0x3E, 0x3F,
  0x0F, 0xE0, 0xF8, 0x7C, 0x7F, 0xC7, 0xE1, 0xF1, 0xFF, 0x1F, 0x07, 0xCF,
  0xFC, 0xFC, 0x1F, 0x3F, 0xF3, 0xE0, 0x7C, 0xF3, 0xCF, 0x81, 0xF7, 0xCF,
  0x7E, 0x07, 0xDE, 0x3D, 0xF0, 0x1F, 0xF8, 0xF7, 0xC0, 0x7F, 0xC3, 0xFE,
  0x01, 0xFF, 0x0F, 0xF8, 0x07, 0xFC, 0x3F, 0xE0, 0x1F, 0xE0, 0xFF, 0x00,
  0x7F, 0x83, 0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0x80, 0x1F,
  0xC0, 0xFE, 0x00, 0x7E, 0x03, 0xF0, 0x01, 0xF8, 0x07, 0xC0, 0x07, 0xC0,
  0x1E, 0x00, 0x00, 0x0F, 0xC0, 0x7F, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFC,
  0x07, 0xE1, 0xFC, 0x03, 0xE1, 0xF8, 0x03, 0xF3, 0xF0, 0x03, 0xF3, 0xF0,
  0x01, 0xF7, 0xE0, 0x01, 0xF7, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xEF, 0x80,
  0x0F, 0xCF, 0x80, 0x0F, 0xCF, 0xC0, 0x1F, 0x8F, 0xC0, 0x3F, 0x87, 0xC0,
  0x3F, 0x07, 0xC0, 0x7E, 0x07, 0xE0, 0xFE, 0x07, 0xE0, 0xFC, 0x03, 0xE0,
  0x07, 0xE0, 0x3F, 0x83, 0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0x7E, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x0F, 0x83, 0xF0, 0x07, 0xC1,
  0xF0, 0x03, 0xE1, 0xF8, 0x01, 0xF0, 0xFC, 0x00, 0xF8, 0xFC, 0x00, 0x7C,
  0x7E, 0x00, 0x3E, 0x7E, 0x00, 0x1F, 0x3F, 0x00, 0x0F, 0xDF, 0x00, 0x03,
  0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0x80, 0x00, 0x02, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0,
  0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x7F, 0x80,
  0x7F, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x07, 0x80,
  0x03, 0x80, 0x01, 0x80, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x00, 0x00, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x7F, 0x00, 0xFE, 0x01, 0xF8,
  0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80,
  0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x00,
  0xF8, 0x00, 0xF0, 0x00, 0x40, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xF0, 0x0F,
  0x1F, 0xF8, 0x0F, 0x3F, 0xFC, 0x1F, 0x3F, 0xFC, 0x1E, 0x7C, 0x7E, 0x3E,
  0x7C, 0x3F, 0xFE, 0x78, 0x1F, 0xFC, 0xF8, 0x0F, 0xF8, 0xF8, 0x07, 0xF8,
  0x00, 0x03, 0xE0,
};

const GFXglyph RobotoCondensed_MediumItalic51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 12, 36, 13, 1, -36 },
  { 55, 13, 13, 16, 4, -38 },
  { 77, 25, 36, 27, 2, -36 },
  { 190, 22, 46, 25, 2, -41 },
  { 317, 23, 36, 31, 5, -36 },
  { 421, 25, 37, 28, 1, -36 },
  { 537, 6, 13, 8, 4, -38 },
  { 547, 16, 53, 16, 2, -41 },
  { 653, 15, 53, 16, -2, -41 },
  { 753, 20, 22, 22, 3, -36 },
  { 808, 21, 27, 24, 2, -30 },
  { 879, 10, 14, 11, -3, -6 },
  { 897, 12, 5, 15, 2, -18 },
  { 905, 7, 7, 14, 1, -7 },
  { 912, 23, 39, 17, -3, -36 },
  { 1025, 22, 36, 25, 2, -36 },
  { 1124, 14, 36, 25, 6, -36 },
  { 1187, 24, 36, 25, 0, -36 },
  { 1295, 23, 36, 25, 1, -36 },
  { 1399, 23, 36, 25, 0, -36 },
  { 1503, 23, 36, 25, 2, -36 },
  { 1607, 20, 36, 25, 2, -36 },
  { 1697, 23, 36, 25, 3, -36 },
  { 1801, 23, 36, 25, 1, -36 },
  { 1905, 19, 36, 25, 4, -36 },
  { 1991, 11, 28, 13, 1, -28 },
  { 2030, 13, 36, 12, -2, -28 },
  { 2089, 20, 24, 22, 1, -28 },
  { 2149, 21, 15, 24, 2, -24 },
  { 2189, 20, 23, 23, 1, -27 },
  { 2247, 18, 36, 22, 4, -36 },
  { 2328, 35, 46, 38, 1, -35 },
  { 2530, 28, 36, 29, -2, -36 },
  { 2656, 25, 36, 27, 1, -36 },
  { 2769, 26, 36, 28, 2, -36 },
  { 2886, 26, 36, 28, 1, -36 },
  { 3003, 25, 36, 24, 1, -36 },
  { 3116, 25, 36, 24, 1, -36 },
  { 3229, 26, 36, 29, 2, -36 },
  { 3346, 30, 36, 31, 1, -36 },
  { 3481, 12, 36, 13, 1, -36 },
  { 3535, 25, 36, 24, 0, -36 },
  { 3648, 30, 36, 27, 1, -36 },
  { 3783, 20, 36, 24, 1, -36 },
  { 3873, 37, 36, 37, 1, -36 },
  { 4040, 30, 36, 30, 1, -36 },
  { 4175, 27, 36, 30, 2, -36 },
  { 4297, 27, 36, 28, 1, -36 },
  { 4419, 26, 42, 30, 2, -36 },
  { 4556, 26, 36, 27, 1, -36 },
  { 4673, 25, 36, 26, 1, -36 },
  { 4786, 25, 36, 26, 4, -36 },
  { 4899, 27, 36, 28, 2, -36 },
  { 5021, 27, 36, 28, 4, -36 },
  { 5143, 35, 36, 37, 5, -36 },
  { 5301, 31, 36, 28, -1, -36 },
  { 5441, 26, 36, 26, 4, -36 },
  { 5558, 29, 36, 26, -1, -36 },
  { 5689, 17, 50, 13, -1, -42 },
  { 5796, 11, 39, 19, 4, -36 },
  { 5850, 17, 50, 13, -3, -42 },
  { 5957, 16, 18, 19, 2, -36 },
  { 5993, 20, 5, 20, -3, 0 },
  { 6006, 10, 8, 16, 5, -39 },
  { 6016, 20, 27, 24, 1, -27 },
  { 6084, 23, 38, 24, 0, -38 },
  { 6194, 21, 27, 23, 1, -27 },
  { 6265, 25, 38, 25, 1, -38 },
  { 6384, 21, 27, 23, 1, -27 },
  { 6455, 17, 39, 16, 2, -39 },
  { 6538, 24, 37, 25, 0, -27 },
  { 6649, 22, 38, 24, 0, -38 },
  { 6754, 11, 38, 12, 1, -38 },
  { 6807, 17, 48, 12, -5, -38 },
  { 6909, 24, 38, 23, 0, -38 },
  { 7023, 12, 38, 12, 1, -38 },
  { 7080, 35, 27, 37, 0, -27 },
  { 7199, 22, 27, 24, 0, -27 },
  { 7274, 22, 27, 25, 1, -27 },
  { 7349, 25, 37, 24, -2, -27 },
  { 7465, 23, 37, 25, 1, -27 },
  { 7572, 17, 27, 16, 0, -27 },
  { 7630, 20, 27, 23, 1, -27 },
  { 7698, 13, 34, 15, 2, -34 },
  { 7754, 21, 27, 24, 2, -27 },
  { 7825, 20, 27, 22, 3, -27 },
  { 7893, 30, 27, 32, 3, -27 },
  { 7995, 24, 27, 22, -1, -27 },
  { 8076, 25, 37, 21, -2, -27 },
  { 8192, 23, 27, 22, -1, -27 },
  { 8270, 16, 49, 15, 1, -40 },
  { 8368, 11, 43, 12, 1, -36 },
  { 8428, 16, 49, 15, -2, -40 },
  { 8526, 24, 11, 28, 2, -21 },
};

const GFXfont RobotoCondensed_MediumItalic51pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_MediumItalic51pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_MediumItalic51pt7bGlyphs,
  0x20, 0x7E, 60
};

#endif // _ROBOTOCONDENSED_MEDIUMITALIC51PT7B_H_
