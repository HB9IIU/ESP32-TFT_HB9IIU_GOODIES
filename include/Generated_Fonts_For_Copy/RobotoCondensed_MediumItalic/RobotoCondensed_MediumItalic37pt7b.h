#ifndef _ROBOTOCONDENSED_MEDIUMITALIC37PT7B_H_
#define _ROBOTOCONDENSED_MEDIUMITALIC37PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-MediumItalic.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_MediumItalic37pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x07, 0x83, 0xC1, 0xE1, 0xF0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x70, 0x38, 0x3C, 0x00, 0x00, 0x00,
  0x03, 0x83, 0xC1, 0xE0, 0xF0, 0x38, 0x00, 0x71, 0xDC, 0xE7, 0x39, 0xCE,
  0x73, 0xB8, 0xEE, 0x33, 0x9C, 0xC7, 0x00, 0x00, 0x71, 0xC0, 0x0E, 0x38,
  0x01, 0xCE, 0x00, 0x71, 0xC0, 0x0E, 0x38, 0x01, 0xCE, 0x00, 0x71, 0xC0,
  0xFF, 0xFF, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x0E, 0x38, 0x01, 0xCE, 0x00,
  0x71, 0xC0, 0x0E, 0x38, 0x01, 0xCE, 0x00, 0x71, 0xC0, 0x7F, 0xFF, 0x1F,
  0xFF, 0xE3, 0xFF, 0xFC, 0x0E, 0x38, 0x01, 0xC6, 0x00, 0x71, 0xC0, 0x0E,
  0x38, 0x01, 0xC6, 0x00, 0x31, 0xC0, 0x0E, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x30, 0x00, 0x30, 0x01, 0xF8, 0x03, 0xFC, 0x07, 0xFE, 0x0F,
  0xFF, 0x0F, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x1E, 0x00, 0x1E,
  0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00,
  0x7C, 0x00, 0x3C, 0x00, 0x3E, 0xF0, 0x1E, 0xF0, 0x3C, 0xF8, 0x3C, 0x78,
  0x7C, 0x7F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF0, 0x0F, 0xC0, 0x07, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x1F, 0x00, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xC7, 0x0C,
  0x71, 0xC3, 0xB8, 0x71, 0xCE, 0x1C, 0xE3, 0x87, 0x70, 0x73, 0x9C, 0x1F,
  0xEE, 0x07, 0xF7, 0x00, 0xF9, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x39,
  0xE0, 0x0E, 0xFC, 0x07, 0x7F, 0x83, 0x9C, 0xE1, 0xCE, 0x18, 0x73, 0x86,
  0x38, 0xE3, 0x9C, 0x38, 0xE7, 0x0E, 0x38, 0x03, 0xFC, 0x00, 0x7F, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x0F,
  0x1E, 0x03, 0xC3, 0x80, 0xE1, 0xE0, 0x38, 0x78, 0x0F, 0x3C, 0x03, 0xDE,
  0x00, 0xFF, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0xE3, 0xFE, 0x39,
  0xF7, 0x9E, 0x79, 0xF7, 0xBE, 0x3D, 0xEF, 0x07, 0xF3, 0xC1, 0xFC, 0xF0,
  0x3E, 0x3E, 0x0F, 0x8F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xEF, 0x03, 0xE3,
  0xE0, 0x77, 0x7F, 0xEE, 0xEE, 0xE0, 0x00, 0x20, 0x1C, 0x07, 0x81, 0xE0,
  0x78, 0x0E, 0x03, 0xC0, 0x70, 0x1E, 0x03, 0x80, 0xF0, 0x1C, 0x03, 0x80,
  0xF0, 0x1E, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x07, 0x00, 0xF0, 0x0E, 0x00, 0x80, 0x02, 0x00, 0x30,
  0x03, 0x80, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E,
  0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x06, 0x00, 0x40, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x04, 0x18, 0x2E, 0x33, 0xFF, 0xFF, 0xBF, 0xFF, 0x0F, 0xF0, 0x1F, 0x00,
  0x7F, 0x00, 0xEE, 0x03, 0x8E, 0x0F, 0x1C, 0x1C, 0x18, 0x00, 0x20, 0x00,
  0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03,
  0xC0, 0x7F, 0xFF, 0x7F, 0xFE, 0x7F, 0xFE, 0xFF, 0xFE, 0x03, 0xC0, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x3C, 0x78, 0xE3, 0xC7, 0x9E, 0x3C, 0xF0, 0xC0, 0x7F, 0xBF,
  0xDF, 0xFF, 0xE0, 0x77, 0xFF, 0xF7, 0x00, 0x00, 0x07, 0x00, 0x0F, 0x00,
  0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03,
  0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E,
  0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70,
  0x00, 0xE0, 0x00, 0x03, 0xF0, 0x0F, 0xF0, 0x3F, 0xF0, 0xFF, 0xE3, 0xE1,
  0xE7, 0x83, 0xCF, 0x07, 0xBC, 0x0F, 0x78, 0x1E, 0xF0, 0x3D, 0xE0, 0x7F,
  0xC0, 0xFF, 0x03, 0xFE, 0x07, 0xBC, 0x0F, 0x78, 0x1E, 0xF0, 0x3D, 0xE0,
  0x7B, 0xC1, 0xE7, 0x83, 0xCF, 0x07, 0x9E, 0x1E, 0x3F, 0xFC, 0x3F, 0xF0,
  0x3F, 0xC0, 0x3E, 0x00, 0x00, 0x40, 0x78, 0x3F, 0x3F, 0xE7, 0xFD, 0xF7,
  0xB9, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x03, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x81,
  0xF0, 0x3C, 0x07, 0x80, 0x00, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0xC1, 0xFF,
  0xF0, 0xF0, 0xF8, 0xF8, 0x3C, 0x78, 0x1E, 0x3C, 0x0F, 0x00, 0x07, 0x80,
  0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0,
  0x01, 0xF0, 0x01, 0xFF, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0x7F, 0xFF, 0x00,
  0x01, 0xF0, 0x07, 0xFC, 0x0F, 0xFE, 0x1F, 0xFE, 0x1E, 0x1F, 0x3E, 0x0F,
  0x3C, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x07, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF8, 0x78, 0xFF, 0xF8, 0x7F, 0xF0,
  0x3F, 0xE0, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x07,
  0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x03, 0xFC, 0x03, 0xDE, 0x01, 0xDF, 0x01,
  0xEF, 0x01, 0xE7, 0x80, 0xE3, 0xC0, 0xF1, 0xE0, 0xF0, 0xF0, 0x70, 0xF0,
  0x78, 0x78, 0x7F, 0xFF, 0xBF, 0xFF, 0x9F, 0xFF, 0xDF, 0xFF, 0xE0, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00,
  0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE1, 0xFF, 0xF0, 0xF0, 0x00, 0x78,
  0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0xF8, 0x07, 0xFE, 0x07,
  0xFF, 0x83, 0xFF, 0xE0, 0xE1, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x3C, 0x07, 0x8F, 0x07, 0xC7, 0x83, 0xC3, 0xC3, 0xE1, 0xFF,
  0xE0, 0x7F, 0xF0, 0x1F, 0xF0, 0x07, 0xE0, 0x00, 0x00, 0x78, 0x07, 0xE0,
  0x3F, 0x81, 0xFE, 0x0F, 0x80, 0x7C, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x01,
  0xEF, 0x87, 0xFF, 0x1F, 0xFE, 0xFF, 0xFF, 0xE1, 0xFF, 0x83, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x7B, 0xE3, 0xE7, 0xFF,
  0x1F, 0xFC, 0x3F, 0xE0, 0x7E, 0x00, 0x3F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF,
  0xCF, 0xFF, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0,
  0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF8, 0x03, 0xFC, 0x07, 0xFE, 0x0F, 0xFF, 0x1F, 0x0F,
  0x1E, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x1E, 0x1E, 0x0F, 0xFE,
  0x0F, 0xFC, 0x0F, 0xF0, 0x1F, 0xF8, 0x3C, 0x7C, 0x78, 0x3C, 0x78, 0x3C,
  0xF8, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF8, 0x3C, 0xF8, 0x7C, 0x7F, 0xF8,
  0x7F, 0xF0, 0x3F, 0xE0, 0x0F, 0xC0, 0x07, 0xC0, 0x7F, 0xC3, 0xFF, 0x0F,
  0xFE, 0x78, 0x79, 0xE1, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x1F, 0xF0, 0xFB, 0xF7, 0xE7, 0xFF, 0x9F, 0xFE, 0x1E, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x78, 0x03, 0xE0, 0x1F, 0x07, 0xF8, 0x3F, 0xC0,
  0xFE, 0x03, 0xC0, 0x00, 0x0C, 0x3C, 0xF8, 0xF1, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0xF9, 0xF3, 0xE3, 0x80, 0x03, 0x81,
  0xF0, 0x7C, 0x1F, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1C,
  0x0F, 0x03, 0xC1, 0xE0, 0xF0, 0x08, 0x00, 0x00, 0x04, 0x00, 0x70, 0x07,
  0xC0, 0x7F, 0x07, 0xF8, 0x7F, 0x87, 0xF8, 0x3F, 0x80, 0xF8, 0x03, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0x00, 0x1C, 0x00,
  0x20, 0x3F, 0xFE, 0xFF, 0xF9, 0xFF, 0xF3, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xF9, 0xFF, 0xF3, 0xFF, 0xE7, 0xFF, 0xC0,
  0x10, 0x00, 0x60, 0x03, 0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x1F, 0x00, 0x3C, 0x07, 0xF0, 0x7F, 0x87, 0xF8, 0x7F, 0x83, 0xF8,
  0x0F, 0x80, 0x38, 0x00, 0x80, 0x00, 0x0F, 0xC1, 0xFF, 0x1F, 0xFC, 0xFF,
  0xEF, 0x8F, 0xF8, 0x3F, 0xC3, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x18, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x3E,
  0x03, 0xC0, 0x3C, 0x00, 0xE0, 0x3C, 0x00, 0x38, 0x1C, 0x00, 0x0C, 0x1C,
  0x00, 0x07, 0x1C, 0x0F, 0x83, 0x8E, 0x0F, 0xF1, 0xCE, 0x0F, 0xF8, 0x67,
  0x0F, 0x1C, 0x33, 0x8F, 0x0E, 0x1B, 0x87, 0x0E, 0x1D, 0xC3, 0x87, 0x0E,
  0xE3, 0x83, 0x87, 0xE1, 0xC1, 0xC3, 0xF0, 0xE1, 0xC1, 0xB8, 0xF0, 0xE0,
  0xDC, 0x78, 0x70, 0xEE, 0x3C, 0x78, 0x77, 0x1E, 0x3C, 0x33, 0x8F, 0x3E,
  0x39, 0xC3, 0xFF, 0xF8, 0xE1, 0xFB, 0xF8, 0x70, 0x78, 0xF8, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0,
  0x18, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0xF3, 0x80, 0x0F,
  0x38, 0x01, 0xE3, 0xC0, 0x1E, 0x3C, 0x03, 0xC3, 0xC0, 0x3C, 0x3C, 0x07,
  0x83, 0xC0, 0x78, 0x3C, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x1F, 0xFF, 0xE1,
  0xFF, 0xFE, 0x3E, 0x01, 0xE3, 0xC0, 0x1E, 0x7C, 0x01, 0xE7, 0x80, 0x1E,
  0xF8, 0x01, 0xEF, 0x00, 0x1F, 0x07, 0xFE, 0x00, 0xFF, 0xF0, 0x1F, 0xFF,
  0x07, 0xFF, 0xF0, 0xF8, 0x3E, 0x1E, 0x03, 0xC3, 0xC0, 0x78, 0x78, 0x0F,
  0x0F, 0x03, 0xE3, 0xE0, 0xF8, 0x7C, 0x7F, 0x0F, 0xFF, 0x81, 0xFF, 0xE0,
  0x3F, 0xFE, 0x0F, 0x83, 0xE1, 0xF0, 0x3C, 0x3C, 0x07, 0x87, 0x80, 0xF0,
  0xF0, 0x1E, 0x1E, 0x03, 0xC7, 0xC0, 0xF8, 0xF8, 0x3F, 0x1F, 0xFF, 0xC3,
  0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xC0,
  0xFF, 0xF8, 0x3F, 0xFE, 0x1F, 0x07, 0xCF, 0x80, 0xF3, 0xC0, 0x3D, 0xF0,
  0x0F, 0x78, 0x03, 0xDE, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x03, 0xCF,
  0x00, 0xF3, 0xC0, 0x3C, 0xF0, 0x1F, 0x3E, 0x0F, 0x87, 0xFF, 0xC1, 0xFF,
  0xF0, 0x3F, 0xF0, 0x03, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0xE0, 0x1F,
  0xFE, 0x07, 0xFF, 0xE0, 0xF8, 0x3C, 0x1E, 0x07, 0xC3, 0xC0, 0x78, 0x78,
  0x0F, 0x0F, 0x01, 0xE3, 0xE0, 0x3C, 0x7C, 0x07, 0x8F, 0x00, 0xF1, 0xE0,
  0x1E, 0x3C, 0x03, 0xCF, 0x80, 0xF9, 0xF0, 0x1E, 0x3C, 0x03, 0xC7, 0x80,
  0x78, 0xF0, 0x1F, 0x1E, 0x03, 0xC7, 0xC0, 0xF8, 0xF8, 0x3E, 0x1F, 0xFF,
  0x83, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0xFF,
  0xFC, 0x1F, 0xFF, 0x87, 0xFF, 0xF0, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0xFC, 0x0F, 0xFF,
  0x81, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC0, 0x07, 0xFF,
  0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xE0, 0xF8, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xFF, 0x81, 0xF0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0xF8, 0x7F, 0xFF, 0x1F, 0x07, 0xCF,
  0x80, 0xF3, 0xC0, 0x3D, 0xF0, 0x0F, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x1F, 0xEF, 0x07, 0xFB, 0xC1, 0xFE,
  0xF0, 0x07, 0xBC, 0x03, 0xEF, 0x00, 0xFB, 0xC0, 0x3C, 0xF8, 0x0F, 0x1E,
  0x07, 0xC7, 0xFF, 0xF0, 0xFF, 0xF8, 0x1F, 0xFC, 0x03, 0xF8, 0x00, 0x07,
  0x80, 0x3C, 0x1E, 0x00, 0xF0, 0x78, 0x03, 0xC3, 0xE0, 0x0F, 0x0F, 0x80,
  0x7C, 0x3C, 0x01, 0xE0, 0xF0, 0x07, 0x83, 0xC0, 0x1E, 0x0F, 0x00, 0x78,
  0x7C, 0x03, 0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xC3, 0xE0, 0x0F, 0x0F, 0x80, 0x7C, 0x3C, 0x01, 0xF0, 0xF0, 0x07,
  0x83, 0xC0, 0x1E, 0x0F, 0x00, 0x78, 0x7C, 0x01, 0xE1, 0xF0, 0x0F, 0x87,
  0x80, 0x3C, 0x1E, 0x00, 0xF0, 0x78, 0x03, 0xC1, 0xE0, 0x0F, 0x00, 0x0F,
  0x07, 0x83, 0xC1, 0xE1, 0xF0, 0xF8, 0x78, 0x3C, 0x1E, 0x0F, 0x0F, 0x87,
  0xC3, 0xC1, 0xE0, 0xF0, 0x78, 0x7C, 0x3C, 0x1E, 0x0F, 0x07, 0x87, 0xC3,
  0xE1, 0xE0, 0xF0, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x8F, 0x83, 0xE3,
  0xE0, 0xF0, 0xF8, 0x3C, 0x1E, 0x1F, 0x07, 0xFF, 0x81, 0xFF, 0xC0, 0x3F,
  0xE0, 0x03, 0xF0, 0x00, 0x07, 0x80, 0xFC, 0x1E, 0x03, 0xE0, 0x78, 0x1F,
  0x03, 0xE0, 0xF8, 0x0F, 0x87, 0xC0, 0x3C, 0x3F, 0x00, 0xF0, 0xF8, 0x03,
  0xC7, 0xC0, 0x0F, 0x3E, 0x00, 0x7D, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x3F, 0x3C, 0x00, 0xF8, 0xF8, 0x03, 0xC3, 0xE0, 0x0F, 0x07, 0x80, 0x7C,
  0x1F, 0x01, 0xF0, 0x7C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xE0, 0x78, 0x0F,
  0x81, 0xE0, 0x1F, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0xFF, 0xBF,
  0xFF, 0x7F, 0xFE, 0xFF, 0xF8, 0x07, 0xE0, 0x03, 0xE0, 0xFC, 0x00, 0xFC,
  0x1F, 0x80, 0x1F, 0x87, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x1F, 0xC0,
  0x3F, 0xC3, 0xF8, 0x07, 0xF0, 0x7F, 0x01, 0xFE, 0x0F, 0xE0, 0x3F, 0xC3,
  0xDE, 0x0F, 0x78, 0x7B, 0xC1, 0xEF, 0x0F, 0x78, 0x3B, 0xC1, 0xEF, 0x0F,
  0x78, 0x3C, 0xE1, 0xCF, 0x0F, 0x9C, 0x79, 0xE1, 0xF3, 0x8E, 0x3C, 0x3C,
  0x73, 0xCF, 0x87, 0x8E, 0x71, 0xE0, 0xF1, 0xFE, 0x3C, 0x1E, 0x3F, 0x87,
  0x87, 0xC3, 0xF0, 0xF0, 0xF8, 0x7C, 0x3E, 0x1E, 0x0F, 0x87, 0xC3, 0xC1,
  0xF0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC0, 0x07, 0x80, 0x3C,
  0x1F, 0x00, 0xF0, 0x7C, 0x03, 0xC3, 0xF0, 0x0F, 0x0F, 0xE0, 0x7C, 0x3F,
  0x81, 0xE0, 0xFE, 0x07, 0x83, 0xF8, 0x1E, 0x0F, 0xF0, 0x78, 0x7D, 0xC3,
  0xE1, 0xF7, 0x0F, 0x87, 0x9E, 0x3C, 0x1E, 0x38, 0xF0, 0x78, 0xE3, 0xC3,
  0xE3, 0xCF, 0x0F, 0x8F, 0x7C, 0x3C, 0x1D, 0xF0, 0xF0, 0x7F, 0x83, 0xC1,
  0xFE, 0x0F, 0x03, 0xF8, 0x7C, 0x0F, 0xE1, 0xF0, 0x3F, 0x87, 0x80, 0x7C,
  0x1E, 0x01, 0xF0, 0x78, 0x07, 0xC1, 0xE0, 0x1F, 0x00, 0x00, 0xFC, 0x00,
  0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xC1, 0xF0, 0x7C, 0x7C, 0x07, 0x8F,
  0x00, 0xF3, 0xE0, 0x1F, 0x78, 0x03, 0xEF, 0x00, 0x7D, 0xE0, 0x0F, 0x3C,
  0x01, 0xEF, 0x80, 0x3D, 0xE0, 0x07, 0xBC, 0x00, 0xF7, 0x80, 0x3E, 0xF0,
  0x07, 0xDE, 0x00, 0xF3, 0xC0, 0x1E, 0x78, 0x07, 0xCF, 0x80, 0xF0, 0xF0,
  0x7E, 0x1F, 0xFF, 0x81, 0xFF, 0xE0, 0x1F, 0xF8, 0x01, 0xFC, 0x00, 0x07,
  0xFF, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0x81, 0xF0,
  0xF0, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0xF1, 0xF0, 0x1F,
  0x1F, 0x01, 0xE1, 0xE0, 0x3E, 0x1F, 0xFF, 0xC1, 0xFF, 0xFC, 0x3F, 0xFF,
  0x03, 0xFF, 0xC0, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x3F, 0xFE, 0x07,
  0xFF, 0xC1, 0xF0, 0x7C, 0x7C, 0x07, 0x8F, 0x00, 0xF3, 0xE0, 0x1E, 0x78,
  0x03, 0xCF, 0x00, 0x79, 0xE0, 0x0F, 0x7C, 0x01, 0xEF, 0x80, 0x3D, 0xE0,
  0x07, 0xBC, 0x00, 0xF7, 0x80, 0x3E, 0xF0, 0x07, 0x9E, 0x00, 0xF3, 0xC0,
  0x1E, 0x78, 0x07, 0x8F, 0x01, 0xF1, 0xF0, 0x7C, 0x1F, 0xFF, 0x81, 0xFF,
  0xE0, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xE0, 0x00, 0x38, 0x00, 0x02, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xF0, 0x1F,
  0xFF, 0x07, 0xFF, 0xF0, 0xF8, 0x3E, 0x1E, 0x03, 0xC3, 0xC0, 0x78, 0x78,
  0x0F, 0x0F, 0x01, 0xE3, 0xE0, 0x3C, 0x7C, 0x0F, 0x8F, 0x03, 0xE1, 0xFF,
  0xF8, 0x3F, 0xFE, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x3C, 0x3E, 0x07, 0x87,
  0xC0, 0xF0, 0x78, 0x1E, 0x0F, 0x07, 0xC1, 0xF0, 0xF8, 0x3E, 0x1E, 0x03,
  0xC3, 0xC0, 0x78, 0x78, 0x0F, 0x8F, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0xFF,
  0xC0, 0x7F, 0xF8, 0x3F, 0xFE, 0x1F, 0x07, 0xC7, 0x80, 0xF1, 0xE0, 0x3C,
  0x78, 0x0F, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xCF, 0x00, 0xF3, 0xC0, 0x3C, 0xF0, 0x1F, 0x3E, 0x0F, 0x87, 0xFF, 0xE0,
  0xFF, 0xF0, 0x1F, 0xF8, 0x01, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFE, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0xF1, 0xF0, 0x1F, 0x1F,
  0x01, 0xF1, 0xE0, 0x1E, 0x1E, 0x01, 0xE1, 0xE0, 0x1E, 0x1E, 0x01, 0xE3,
  0xE0, 0x3E, 0x3E, 0x03, 0xE3, 0xC0, 0x3C, 0x3C, 0x03, 0xC3, 0xC0, 0x3C,
  0x3C, 0x03, 0xC7, 0xC0, 0x7C, 0x78, 0x07, 0xC7, 0x80, 0x78, 0x78, 0x07,
  0x87, 0x80, 0x78, 0x78, 0x07, 0x87, 0x80, 0xF8, 0x78, 0x0F, 0x07, 0xC1,
  0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x7E, 0x00, 0xF8,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0x7C, 0x03, 0xE7, 0x80, 0x78, 0xF0,
  0x1F, 0x1E, 0x03, 0xE3, 0xC0, 0xF8, 0x78, 0x1F, 0x0F, 0x03, 0xC1, 0xF0,
  0xF8, 0x1E, 0x1E, 0x03, 0xC7, 0xC0, 0x78, 0xF0, 0x0F, 0x1E, 0x01, 0xE7,
  0x80, 0x3C, 0xF0, 0x07, 0xBE, 0x00, 0x77, 0x80, 0x0E, 0xF0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0xF8, 0x1E, 0x07, 0xFE, 0x07, 0x81, 0xE7, 0x83, 0xE0, 0x79, 0xE0,
  0xF8, 0x3E, 0x78, 0x3E, 0x0F, 0x1E, 0x1F, 0x83, 0xC7, 0x87, 0xE1, 0xF1,
  0xE1, 0xF8, 0x78, 0x78, 0xFE, 0x1E, 0x1E, 0x3B, 0x8F, 0x07, 0x9E, 0xE3,
  0xC1, 0xE7, 0xB8, 0xF0, 0x79, 0xCE, 0x78, 0x1E, 0xF3, 0x9E, 0x07, 0xBC,
  0xE7, 0x81, 0xEE, 0x3B, 0xC0, 0x7F, 0x8E, 0xF0, 0x1F, 0xC3, 0xFC, 0x07,
  0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x7E, 0x0F, 0xE0, 0x1F, 0x83, 0xF0,
  0x07, 0xE0, 0x7C, 0x01, 0xF0, 0x1F, 0x00, 0x7C, 0x07, 0x80, 0x1E, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x7C, 0x0F, 0x80, 0xF8, 0x1F, 0x03, 0xE0, 0x1E,
  0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x7C, 0x00, 0x78, 0xF0, 0x00, 0xF3,
  0xE0, 0x01, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xBE, 0x00, 0x1F, 0x7C, 0x00, 0x7C, 0x78, 0x00,
  0xF8, 0xF8, 0x03, 0xE1, 0xF0, 0x0F, 0x81, 0xE0, 0x1F, 0x03, 0xE0, 0x7C,
  0x07, 0xC1, 0xF8, 0x0F, 0x80, 0xF8, 0x07, 0xCF, 0x00, 0xF9, 0xE0, 0x3E,
  0x3C, 0x07, 0x87, 0xC1, 0xF0, 0x78, 0x3C, 0x0F, 0x0F, 0x81, 0xE1, 0xE0,
  0x3C, 0x78, 0x03, 0xCF, 0x00, 0x7B, 0xC0, 0x0F, 0xF8, 0x01, 0xFE, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF0, 0xFF, 0xFE, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07,
  0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x78, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x00,
  0xF0, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xF0, 0xF0, 0x78, 0x78, 0x78, 0x78,
  0x78, 0x78, 0x78, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x1E, 0x1E,
  0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x03, 0xF0,
  0x7F, 0x07, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x3E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0x80,
  0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x0F,
  0xE0, 0xFE, 0x0F, 0xC0, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x7E, 0x07, 0xE0,
  0xEE, 0x0E, 0xE1, 0xEE, 0x1C, 0xE3, 0xCE, 0x38, 0xF7, 0x87, 0x70, 0x70,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0xF0, 0xF1, 0xE1, 0xE0, 0x03,
  0xE0, 0x1F, 0xF0, 0x7F, 0xF1, 0xFB, 0xE3, 0xC3, 0xC7, 0x87, 0x80, 0x0F,
  0x00, 0x1E, 0x07, 0xFC, 0x7F, 0xF9, 0xFF, 0xF3, 0xE3, 0xEF, 0x87, 0x9E,
  0x0F, 0x3C, 0x1E, 0x78, 0x7C, 0xFF, 0xF9, 0xFF, 0xF1, 0xFD, 0xE1, 0xF3,
  0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x7C, 0x1F, 0xFE, 0x1F, 0xFF, 0x1F,
  0xFF, 0x1F, 0x0F, 0x1E, 0x0F, 0x3E, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C,
  0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x7C, 0x0F, 0x78, 0x1F, 0x78, 0x1E, 0x7C,
  0x3E, 0x7F, 0xFC, 0x7F, 0xFC, 0xF7, 0xF8, 0xF1, 0xF0, 0x03, 0xF0, 0x1F,
  0xF0, 0x7F, 0xF1, 0xFF, 0xE3, 0xC3, 0xEF, 0x03, 0xDE, 0x07, 0xBC, 0x00,
  0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x07, 0xBC,
  0x1E, 0x7C, 0x3C, 0x7F, 0xF0, 0xFF, 0xE0, 0xFF, 0x80, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x07, 0xCF, 0x03, 0xFB, 0xC1, 0xFF, 0xF0,
  0xFF, 0xFC, 0x3C, 0x3E, 0x1E, 0x07, 0x87, 0x81, 0xE1, 0xE0, 0x78, 0xF8,
  0x1E, 0x3C, 0x0F, 0x8F, 0x03, 0xC3, 0xC0, 0xF0, 0xF0, 0x3C, 0x3C, 0x0F,
  0x0F, 0x03, 0xC3, 0xE1, 0xF0, 0x7F, 0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0x80,
  0x7D, 0xE0, 0x03, 0xF0, 0x1F, 0xF0, 0x7F, 0xF1, 0xFF, 0xE3, 0xC1, 0xEF,
  0x83, 0xDE, 0x07, 0xBC, 0x0F, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x18, 0x7F, 0xF8, 0xFF, 0xF0,
  0xFF, 0xC0, 0x7E, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0xFE, 0x0F, 0xF0, 0x78,
  0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x01,
  0xF0, 0x00, 0x03, 0xE3, 0x83, 0xFB, 0xC3, 0xFF, 0xE3, 0xFF, 0xF1, 0xE0,
  0xF9, 0xF0, 0x78, 0xF0, 0x3C, 0x78, 0x1E, 0x7C, 0x0F, 0x3C, 0x07, 0x9E,
  0x03, 0xCF, 0x03, 0xC7, 0x81, 0xE3, 0xC0, 0xF1, 0xE0, 0x78, 0xF8, 0x7C,
  0x3F, 0xFE, 0x1F, 0xFE, 0x07, 0xFF, 0x01, 0xF7, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x01, 0xF0, 0xC1, 0xF0, 0x7B, 0xF8, 0x7F, 0xF8, 0x1F, 0xF8, 0x03,
  0xF0, 0x00, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x7C, 0x1F, 0xFE, 0x1F, 0xFE,
  0x1F, 0xFF, 0x1E, 0x1F, 0x1E, 0x0F, 0x3E, 0x0F, 0x3C, 0x0F, 0x3C, 0x1F,
  0x3C, 0x1E, 0x3C, 0x1E, 0x3C, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x3E,
  0x78, 0x3C, 0x78, 0x3C, 0x78, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0x03, 0x03,
  0xC3, 0xE0, 0xF0, 0x70, 0x00, 0x00, 0x00, 0x0F, 0x07, 0x87, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x7C, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC3, 0xE1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x1F, 0x00, 0x00, 0x30, 0x03, 0xC0, 0x3E, 0x01,
  0xF0, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x7E, 0x07,
  0xF0, 0x3F, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x0F, 0x87, 0x87, 0xC1, 0xE3, 0xE0, 0x78, 0xF8, 0x1E, 0x7C, 0x07, 0xBE,
  0x03, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xF8, 0x03, 0xFE, 0x00,
  0xFF, 0x80, 0x7C, 0xF0, 0x1E, 0x3C, 0x07, 0x8F, 0x81, 0xE1, 0xE0, 0x78,
  0x78, 0x1E, 0x1F, 0x0F, 0x83, 0xC3, 0xC0, 0xF0, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0xF8, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x87, 0xC3, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x1F, 0x00, 0x1E, 0x7C, 0x3E, 0x0F, 0xFF, 0x3F, 0x87, 0xFF,
  0xBF, 0xC3, 0xFF, 0xFF, 0xF1, 0xE1, 0xF8, 0xF8, 0xF0, 0x78, 0x3C, 0xF8,
  0x3C, 0x1E, 0x78, 0x1E, 0x0F, 0x3C, 0x1E, 0x07, 0x9E, 0x0F, 0x07, 0xCF,
  0x07, 0x83, 0xC7, 0x83, 0xC1, 0xE7, 0xC1, 0xE0, 0xF3, 0xC0, 0xF0, 0x79,
  0xE0, 0xF0, 0x3C, 0xF0, 0x78, 0x3E, 0x78, 0x3C, 0x1E, 0x3C, 0x1E, 0x0F,
  0x3E, 0x0F, 0x07, 0x9E, 0x07, 0x83, 0xC0, 0x1E, 0x7C, 0x1E, 0xFE, 0x1F,
  0xFE, 0x1F, 0xFF, 0x1E, 0x1F, 0x1E, 0x0F, 0x3E, 0x0F, 0x3C, 0x0F, 0x3C,
  0x1F, 0x3C, 0x1E, 0x3C, 0x1E, 0x3C, 0x1E, 0x7C, 0x1E, 0x78, 0x1E, 0x78,
  0x3E, 0x78, 0x3C, 0x78, 0x3C, 0xF8, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0x03,
  0xF0, 0x0F, 0xF8, 0x1F, 0xFC, 0x3F, 0xFE, 0x3C, 0x1E, 0x7C, 0x1E, 0x78,
  0x1E, 0x78, 0x1E, 0xF8, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0,
  0x1E, 0xF0, 0x3E, 0xF0, 0x3C, 0x78, 0x7C, 0x7F, 0xF8, 0x7F, 0xF0, 0x3F,
  0xE0, 0x0F, 0x80, 0x0F, 0x3E, 0x07, 0xFF, 0x83, 0xFF, 0xE1, 0xFF, 0xF0,
  0xF0, 0x78, 0x78, 0x3C, 0x7C, 0x1E, 0x3C, 0x0F, 0x1E, 0x07, 0x8F, 0x03,
  0xC7, 0x81, 0xE3, 0xC0, 0xF3, 0xE0, 0x79, 0xE0, 0x7C, 0xF0, 0x3C, 0x7C,
  0x3E, 0x3F, 0xFE, 0x1F, 0xFF, 0x1F, 0xFF, 0x0F, 0x1E, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0xCF, 0x0F, 0xEF, 0x1F, 0xFF, 0x3F, 0xFF, 0x7C,
  0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0xF8, 0x1E, 0xF0, 0x3E, 0xF0,
  0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF8, 0x7C, 0xFF,
  0xF8, 0x7F, 0xF8, 0x3F, 0xF8, 0x1F, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x1E,
  0x71, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0x81, 0xE0, 0x3E, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78,
  0x07, 0x80, 0xF8, 0x0F, 0x00, 0x01, 0xF0, 0x0F, 0xF8, 0x3F, 0xF0, 0xF9,
  0xF1, 0xE1, 0xE7, 0x83, 0xCF, 0x80, 0x0F, 0x00, 0x1F, 0x80, 0x1F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xBC, 0x0F, 0x3C, 0x3E, 0x7C,
  0xF8, 0x7F, 0xF0, 0xFF, 0xC0, 0x7E, 0x00, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x7F, 0xDF, 0xFF, 0xFC, 0x78, 0x1E, 0x07, 0x83, 0xE0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x7E, 0x1F, 0x83, 0xE0,
  0x78, 0x3E, 0x0F, 0x3C, 0x0F, 0x3C, 0x1F, 0x3C, 0x1E, 0x3C, 0x1E, 0x3C,
  0x1E, 0x7C, 0x1E, 0x78, 0x1E, 0x78, 0x3E, 0x78, 0x3C, 0x78, 0x3C, 0x78,
  0x3C, 0xF8, 0x3C, 0xF0, 0x3C, 0xF0, 0x7C, 0xF8, 0x78, 0x7F, 0xF8, 0x7F,
  0xF8, 0x7F, 0xF8, 0x1E, 0x78, 0xF0, 0x3D, 0xE0, 0x7B, 0xC1, 0xE7, 0x83,
  0xC7, 0x0F, 0x8F, 0x1E, 0x1E, 0x3C, 0x3C, 0xF0, 0x79, 0xE0, 0xF3, 0xC1,
  0xEF, 0x03, 0xDE, 0x03, 0xB8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x00, 0xF0, 0x78, 0x3F, 0xC1, 0xE1,
  0xEF, 0x0F, 0x87, 0xBC, 0x3E, 0x1C, 0xF0, 0xF8, 0xF1, 0xC7, 0xE3, 0xC7,
  0x1F, 0x9E, 0x1C, 0xFE, 0x78, 0x73, 0xB9, 0xE1, 0xCE, 0xEF, 0x07, 0x73,
  0xBC, 0x1D, 0xCE, 0xE0, 0x7F, 0x3F, 0x81, 0xF8, 0xFE, 0x07, 0xE3, 0xF0,
  0x1F, 0x0F, 0xC0, 0x7C, 0x1F, 0x01, 0xF0, 0x78, 0x07, 0x81, 0xE0, 0x1E,
  0x07, 0x00, 0x0F, 0x07, 0x83, 0xC3, 0xE0, 0xF0, 0xF0, 0x3E, 0x78, 0x07,
  0xBE, 0x01, 0xEF, 0x00, 0x7F, 0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3E, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xDC, 0x01, 0xF7, 0x80,
  0x79, 0xE0, 0x3E, 0x78, 0x1F, 0x0F, 0x07, 0x83, 0xC3, 0xE0, 0xF0, 0x1E,
  0x07, 0x87, 0x81, 0xE1, 0xE0, 0xF8, 0x7C, 0x3C, 0x0F, 0x1F, 0x03, 0xC7,
  0x80, 0xF1, 0xE0, 0x3C, 0xF0, 0x0F, 0x3C, 0x03, 0xDE, 0x00, 0xF7, 0x80,
  0x3D, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03,
  0xC0, 0x00, 0x1F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFE, 0x1F, 0xFE, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0xC0,
  0x0F, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFF, 0xF8,
  0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0x00, 0x20, 0x1C, 0x07, 0x81, 0xE0,
  0x38, 0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1C, 0x07, 0x80, 0xF0, 0x7C, 0x1F, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x70, 0x02, 0x00, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0xC7, 0x0E, 0x1C, 0x38, 0x70, 0xE3, 0x87, 0x0E, 0x1C, 0x38, 0x70,
  0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x71, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x00,
  0x02, 0x00, 0x30, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x1C, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x3F, 0x07, 0xC0, 0x78, 0x07, 0x80, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0x70, 0x04, 0x00, 0x1E, 0x00, 0x1F, 0x81, 0xDF, 0xE0,
  0xFF, 0xF8, 0xEF, 0x1F, 0xF7, 0x0F, 0xFB, 0x83, 0xF8, 0x00, 0xF8,
};

const GFXglyph RobotoCondensed_MediumItalic37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 9, 26, 9, 1, -26 },
  { 31, 10, 9, 11, 3, -28 },
  { 43, 19, 26, 19, 1, -26 },
  { 105, 16, 33, 18, 1, -30 },
  { 171, 18, 26, 23, 3, -26 },
  { 230, 18, 26, 20, 1, -26 },
  { 289, 4, 9, 6, 3, -28 },
  { 294, 11, 37, 11, 2, -29 },
  { 345, 12, 37, 12, -2, -29 },
  { 401, 15, 16, 16, 2, -26 },
  { 431, 16, 19, 17, 1, -21 },
  { 469, 7, 10, 8, -2, -4 },
  { 478, 9, 4, 11, 1, -13 },
  { 483, 5, 5, 10, 1, -5 },
  { 487, 16, 28, 13, -2, -26 },
  { 543, 15, 26, 18, 2, -26 },
  { 592, 11, 26, 18, 4, -26 },
  { 628, 17, 26, 18, 0, -26 },
  { 684, 16, 26, 18, 1, -26 },
  { 736, 17, 26, 18, 0, -26 },
  { 792, 17, 26, 18, 1, -26 },
  { 848, 14, 26, 18, 2, -26 },
  { 894, 17, 26, 18, 2, -26 },
  { 950, 16, 26, 18, 1, -26 },
  { 1002, 14, 26, 18, 3, -26 },
  { 1048, 7, 20, 9, 1, -20 },
  { 1066, 10, 26, 8, -2, -20 },
  { 1099, 14, 17, 16, 1, -20 },
  { 1129, 15, 12, 18, 2, -18 },
  { 1152, 14, 17, 16, 1, -20 },
  { 1182, 13, 26, 16, 3, -26 },
  { 1225, 25, 34, 28, 1, -26 },
  { 1332, 20, 26, 21, -1, -26 },
  { 1397, 19, 26, 20, 0, -26 },
  { 1459, 18, 26, 20, 2, -26 },
  { 1518, 19, 26, 20, 0, -26 },
  { 1580, 19, 26, 18, 0, -26 },
  { 1642, 19, 26, 17, 0, -26 },
  { 1704, 18, 26, 21, 2, -26 },
  { 1763, 22, 26, 22, 0, -26 },
  { 1835, 9, 26, 9, 1, -26 },
  { 1865, 18, 26, 17, 0, -26 },
  { 1924, 22, 26, 20, 0, -26 },
  { 1996, 15, 26, 17, 0, -26 },
  { 2045, 27, 26, 27, 0, -26 },
  { 2133, 22, 26, 22, 0, -26 },
  { 2205, 19, 26, 22, 2, -26 },
  { 2267, 20, 26, 20, 0, -26 },
  { 2332, 19, 31, 22, 2, -26 },
  { 2406, 19, 26, 19, 0, -26 },
  { 2468, 18, 26, 19, 1, -26 },
  { 2527, 18, 26, 19, 3, -26 },
  { 2586, 20, 26, 20, 1, -26 },
  { 2651, 19, 26, 20, 3, -26 },
  { 2713, 26, 26, 27, 3, -26 },
  { 2798, 23, 26, 20, -1, -26 },
  { 2873, 19, 26, 19, 3, -26 },
  { 2935, 20, 26, 19, 0, -26 },
  { 3000, 12, 36, 9, 0, -30 },
  { 3054, 8, 28, 14, 3, -26 },
  { 3082, 12, 36, 9, -2, -30 },
  { 3136, 12, 13, 14, 1, -26 },
  { 3156, 14, 3, 14, -2, 0 },
  { 3162, 7, 5, 12, 4, -27 },
  { 3167, 15, 20, 17, 1, -20 },
  { 3205, 16, 28, 18, 0, -28 },
  { 3261, 15, 20, 17, 1, -20 },
  { 3299, 18, 28, 18, 1, -28 },
  { 3362, 15, 20, 17, 1, -20 },
  { 3400, 13, 28, 12, 1, -28 },
  { 3446, 17, 28, 18, 0, -20 },
  { 3506, 16, 28, 18, 0, -28 },
  { 3562, 9, 28, 9, 0, -28 },
  { 3594, 13, 36, 8, -4, -28 },
  { 3653, 18, 28, 17, 0, -28 },
  { 3716, 9, 28, 9, 0, -28 },
  { 3748, 25, 20, 27, 0, -20 },
  { 3811, 16, 20, 18, 0, -20 },
  { 3851, 16, 20, 18, 1, -20 },
  { 3891, 17, 28, 18, -1, -20 },
  { 3951, 16, 28, 18, 1, -20 },
  { 4007, 12, 20, 11, 0, -20 },
  { 4037, 15, 20, 16, 0, -20 },
  { 4075, 10, 24, 11, 1, -24 },
  { 4105, 16, 20, 18, 1, -20 },
  { 4145, 15, 20, 16, 2, -20 },
  { 4183, 22, 20, 23, 2, -20 },
  { 4238, 18, 20, 16, -1, -20 },
  { 4283, 18, 28, 16, -1, -20 },
  { 4346, 16, 20, 16, 0, -20 },
  { 4386, 11, 36, 11, 1, -29 },
  { 4436, 7, 31, 9, 1, -26 },
  { 4464, 12, 36, 11, -2, -29 },
  { 4518, 17, 8, 21, 2, -15 },
};

const GFXfont RobotoCondensed_MediumItalic37pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_MediumItalic37pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_MediumItalic37pt7bGlyphs,
  0x20, 0x7E, 43
};

#endif // _ROBOTOCONDENSED_MEDIUMITALIC37PT7B_H_
