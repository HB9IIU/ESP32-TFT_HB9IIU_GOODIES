#ifndef _ROBOTOCONDENSED_MEDIUMITALIC12PT7B_H_
#define _ROBOTOCONDENSED_MEDIUMITALIC12PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-MediumItalic.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_MediumItalic12pt7bBitmaps[] PROGMEM = {
  0x00, 0x2D, 0xA4, 0x86, 0xC0, 0xB6, 0x80, 0x14, 0x51, 0x9F, 0x2B, 0xE5,
  0x14, 0x50, 0x10, 0xE2, 0x9B, 0x60, 0xC1, 0xB2, 0x59, 0xC2, 0x00, 0x62,
  0xAA, 0xBC, 0x20, 0xE5, 0x65, 0x18, 0x38, 0xA2, 0x8E, 0x31, 0x5D, 0xF2,
  0x7C, 0xE0, 0x2D, 0x69, 0x24, 0x92, 0x44, 0x21, 0x11, 0x11, 0x11, 0x32,
  0x24, 0x80, 0x2A, 0xF6, 0xA0, 0x10, 0xBE, 0x42, 0x10, 0x6B, 0x00, 0x60,
  0x70, 0x08, 0x20, 0x84, 0x10, 0x82, 0x10, 0x41, 0x00, 0x76, 0xA7, 0x39,
  0x4A, 0x56, 0xE0, 0x36, 0xA2, 0x22, 0x66, 0x40, 0x39, 0xA4, 0xC2, 0x18,
  0xC6, 0x10, 0xF8, 0x39, 0xA0, 0x82, 0x30, 0x20, 0xB6, 0x70, 0x08, 0x61,
  0x8A, 0x59, 0x6F, 0x84, 0x10, 0x3C, 0x86, 0x1E, 0x08, 0x20, 0x96, 0x70,
  0x36, 0xCF, 0x99, 0x9B, 0xE0, 0xF8, 0xC4, 0x62, 0x31, 0x18, 0x80, 0x39,
  0xA6, 0xDA, 0x31, 0x2C, 0xB6, 0x70, 0x7D, 0x99, 0x9F, 0x32, 0xC0, 0x0C,
  0x00, 0xB0, 0x23, 0x00, 0x00, 0x64, 0x40, 0x09, 0xB0, 0xE1, 0x00, 0xF0,
  0x0F, 0x41, 0x86, 0xE8, 0x00, 0x79, 0x13, 0x64, 0x00, 0xC0, 0x1E, 0x31,
  0x21, 0x4D, 0x55, 0x95, 0xA5, 0x9E, 0x80, 0x40, 0x38, 0x18, 0x61, 0x8A,
  0x29, 0xB7, 0xF3, 0x84, 0x3D, 0x96, 0x53, 0x79, 0x34, 0xF2, 0xF8, 0x39,
  0x2C, 0xE0, 0x82, 0x08, 0xA6, 0xF0, 0x39, 0xB6, 0x51, 0x45, 0x14, 0xF2,
  0xF0, 0x3D, 0x86, 0x10, 0x79, 0x04, 0x30, 0xF8, 0x3D, 0x86, 0x10, 0x79,
  0x04, 0x30, 0xC0, 0x79, 0x2C, 0xE0, 0x82, 0x68, 0xA6, 0x70, 0x22, 0xC5,
  0x9A, 0x37, 0xE8, 0x91, 0x62, 0xCC, 0x2D, 0xB4, 0x96, 0xC0, 0x0C, 0x30,
  0x82, 0x08, 0x29, 0xB4, 0x70, 0x26, 0xD9, 0xA2, 0x87, 0x0F, 0x16, 0x64,
  0xCC, 0x23, 0x18, 0x84, 0x21, 0x18, 0xF8, 0x21, 0xB9, 0xD4, 0xCA, 0x65,
  0x52, 0xA9, 0x6D, 0xB6, 0xDB, 0x00, 0x22, 0xC5, 0xDA, 0xB5, 0x6B, 0x93,
  0x66, 0xCC, 0x39, 0x2C, 0xE3, 0x8E, 0x28, 0xA6, 0x70, 0x3C, 0xC9, 0x9A,
  0x24, 0xCF, 0x10, 0x60, 0xC0, 0x39, 0x2C, 0xE3, 0x8A, 0x28, 0xA6, 0x70,
  0x40, 0x39, 0x96, 0x51, 0x4D, 0xE5, 0xB2, 0xC8, 0x39, 0xB6, 0x58, 0x38,
  0x2C, 0x92, 0x70, 0xFC, 0x82, 0x08, 0x21, 0x86, 0x10, 0x40, 0x66, 0xCD,
  0x92, 0x24, 0x48, 0x93, 0x24, 0x78, 0xC7, 0x3C, 0xB6, 0x51, 0x47, 0x18,
  0x60, 0x99, 0x9B, 0x9B, 0xBA, 0xAA, 0xAE, 0xEC, 0xCC, 0xCC, 0x66, 0x58,
  0xA1, 0xC3, 0x07, 0x1E, 0x24, 0xC8, 0xCF, 0x25, 0x94, 0x61, 0x86, 0x10,
  0x40, 0x7C, 0x10, 0x86, 0x30, 0x86, 0x30, 0xF8, 0x36, 0x64, 0x44, 0x44,
  0xCC, 0x8C, 0x9B, 0x24, 0x92, 0x4C, 0x31, 0x13, 0x32, 0x22, 0x26, 0x6C,
  0x33, 0x55, 0xF8, 0x48, 0x32, 0x42, 0xFD, 0xE9, 0xC0, 0x23, 0x1E, 0x94,
  0xA7, 0x3B, 0xB0, 0x3A, 0x51, 0x8C, 0x6D, 0xC0, 0x04, 0x33, 0xD2, 0x4B,
  0x2C, 0xB6, 0x78, 0x3A, 0x53, 0xFC, 0x21, 0xC0, 0x31, 0x1C, 0xC6, 0x21,
  0x08, 0x40, 0x3D, 0x24, 0xB2, 0xCB, 0x67, 0xA4, 0xF0, 0x23, 0x1E, 0x94,
  0xA7, 0x7B, 0x90, 0x0C, 0x24, 0x92, 0xD8, 0x03, 0x02, 0x22, 0x26, 0x64,
  0x4C, 0x21, 0x86, 0x96, 0x71, 0xCD, 0x34, 0x98, 0x2D, 0xA4, 0x96, 0xC0,
  0x7F, 0x49, 0x49, 0x49, 0xDB, 0xDB, 0x92, 0x7A, 0x52, 0x9D, 0xEE, 0x40,
  0x3A, 0x53, 0x9C, 0xAD, 0xC0, 0x7A, 0x52, 0x9C, 0xEE, 0xD0, 0x80, 0x79,
  0x24, 0xB2, 0xDB, 0x67, 0x04, 0x10, 0x76, 0x44, 0xCC, 0x80, 0x32, 0x50,
  0xE1, 0x69, 0xC0, 0x27, 0x64, 0x44, 0x46, 0x49, 0x24, 0x92, 0xDB, 0x67,
  0x80, 0x9B, 0xAA, 0xEC, 0xC0, 0x97, 0x6A, 0xD6, 0xCD, 0x9B, 0x24, 0x00,
  0x4A, 0xCC, 0x47, 0x2A, 0x40, 0x4A, 0xD4, 0xA6, 0x31, 0x08, 0x80, 0x78,
  0xCC, 0x46, 0x63, 0xC0, 0x12, 0x22, 0x6C, 0x44, 0x44, 0x40, 0x25, 0x24,
  0x92, 0x52, 0x00, 0x44, 0xB6, 0x52, 0x5A, 0x00, 0x65, 0x55, 0x80,
};

const GFXglyph RobotoCondensed_MediumItalic12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 3, 9, 3, 0, -9 },
  { 5, 3, 3, 4, 1, -9 },
  { 7, 6, 9, 6, 0, -9 },
  { 14, 6, 11, 6, 0, -10 },
  { 23, 6, 9, 7, 1, -9 },
  { 30, 6, 9, 7, 0, -9 },
  { 37, 1, 3, 2, 1, -9 },
  { 38, 3, 13, 4, 1, -10 },
  { 43, 4, 13, 4, -1, -10 },
  { 50, 4, 5, 5, 1, -9 },
  { 53, 5, 6, 6, 0, -6 },
  { 57, 3, 3, 3, -1, -1 },
  { 59, 3, 1, 4, 0, -4 },
  { 60, 2, 2, 3, 0, -2 },
  { 61, 6, 10, 4, -1, -9 },
  { 69, 5, 9, 6, 1, -9 },
  { 75, 4, 9, 6, 1, -9 },
  { 80, 6, 9, 6, 0, -9 },
  { 87, 6, 9, 6, 0, -9 },
  { 94, 6, 9, 6, 0, -9 },
  { 101, 6, 9, 6, 0, -9 },
  { 108, 4, 9, 6, 1, -9 },
  { 113, 5, 9, 6, 1, -9 },
  { 119, 6, 9, 6, 0, -9 },
  { 126, 4, 9, 6, 1, -9 },
  { 131, 3, 7, 3, 0, -7 },
  { 134, 4, 9, 3, -1, -7 },
  { 139, 5, 5, 5, 0, -6 },
  { 143, 4, 4, 6, 1, -6 },
  { 145, 5, 5, 5, 0, -6 },
  { 149, 4, 9, 5, 1, -9 },
  { 154, 8, 11, 9, 0, -8 },
  { 165, 6, 9, 7, 0, -9 },
  { 172, 6, 9, 6, 0, -9 },
  { 179, 6, 9, 7, 1, -9 },
  { 186, 6, 9, 7, 0, -9 },
  { 193, 6, 9, 6, 0, -9 },
  { 200, 6, 9, 6, 0, -9 },
  { 207, 6, 9, 7, 1, -9 },
  { 214, 7, 9, 7, 0, -9 },
  { 222, 3, 9, 3, 0, -9 },
  { 226, 6, 9, 6, 0, -9 },
  { 233, 7, 9, 6, 0, -9 },
  { 241, 5, 9, 6, 0, -9 },
  { 247, 9, 9, 9, 0, -9 },
  { 258, 7, 9, 7, 0, -9 },
  { 266, 6, 9, 7, 1, -9 },
  { 273, 7, 9, 7, 0, -9 },
  { 281, 6, 10, 7, 1, -9 },
  { 289, 6, 9, 6, 0, -9 },
  { 296, 6, 9, 6, 0, -9 },
  { 303, 6, 9, 6, 1, -9 },
  { 310, 7, 9, 7, 0, -9 },
  { 318, 6, 9, 7, 1, -9 },
  { 325, 8, 9, 9, 1, -9 },
  { 334, 7, 9, 6, 0, -9 },
  { 342, 6, 9, 6, 1, -9 },
  { 349, 6, 9, 6, 0, -9 },
  { 356, 4, 12, 3, 0, -10 },
  { 362, 3, 10, 4, 1, -9 },
  { 366, 4, 12, 3, -1, -10 },
  { 372, 4, 4, 4, 0, -9 },
  { 374, 5, 1, 5, -1, 0 },
  { 375, 3, 2, 4, 1, -9 },
  { 376, 5, 7, 6, 0, -7 },
  { 381, 5, 9, 6, 0, -9 },
  { 387, 5, 7, 5, 0, -7 },
  { 392, 6, 9, 6, 0, -9 },
  { 399, 5, 7, 6, 0, -7 },
  { 404, 5, 9, 4, 0, -9 },
  { 410, 6, 9, 6, 0, -7 },
  { 417, 5, 9, 6, 0, -9 },
  { 423, 3, 10, 3, 0, -10 },
  { 427, 4, 12, 3, -1, -10 },
  { 433, 6, 9, 5, 0, -9 },
  { 440, 3, 9, 3, 0, -9 },
  { 444, 8, 7, 9, 0, -7 },
  { 451, 5, 7, 6, 0, -7 },
  { 456, 5, 7, 6, 0, -7 },
  { 461, 5, 9, 6, 0, -7 },
  { 467, 6, 9, 6, 0, -7 },
  { 474, 4, 7, 4, 0, -7 },
  { 478, 5, 7, 5, 0, -7 },
  { 483, 4, 8, 4, 0, -8 },
  { 487, 6, 7, 6, 0, -7 },
  { 493, 4, 7, 5, 1, -7 },
  { 497, 7, 7, 7, 1, -7 },
  { 504, 5, 7, 5, 0, -7 },
  { 509, 5, 9, 5, 0, -7 },
  { 515, 5, 7, 5, 0, -7 },
  { 520, 4, 11, 4, 0, -9 },
  { 526, 3, 11, 3, 0, -9 },
  { 531, 3, 11, 4, 0, -9 },
  { 536, 6, 3, 7, 0, -5 },
};

const GFXfont RobotoCondensed_MediumItalic12pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_MediumItalic12pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_MediumItalic12pt7bGlyphs,
  0x20, 0x7E, 14
};

#endif // _ROBOTOCONDENSED_MEDIUMITALIC12PT7B_H_
