#ifndef _ROBOTOCONDENSED_MEDIUMITALIC7PT7B_H_
#define _ROBOTOCONDENSED_MEDIUMITALIC7PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-MediumItalic.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_MediumItalic7pt7bBitmaps[] PROGMEM = {
  0x00, 0x5A, 0x80, 0x80, 0x07, 0x6E, 0xC0, 0x2D, 0xAB, 0xD0, 0x99, 0x76,
  0x66, 0x4A, 0xE0, 0x80, 0x16, 0xA8, 0x15, 0x58, 0x0E, 0x80, 0x5D, 0x20,
  0xC0, 0x00, 0x80, 0x29, 0x48, 0x76, 0xDE, 0xDA, 0x80, 0x64, 0xAE, 0x65,
  0x1E, 0x2D, 0xF2, 0x68, 0x9E, 0x6A, 0xD6, 0x62, 0x24, 0x40, 0x6D, 0x5E,
  0x76, 0xB4, 0x42, 0x02, 0x80, 0x39, 0x00, 0x7C, 0x0F, 0x00, 0xDA, 0x80,
  0x32, 0x6F, 0xBF, 0xC1, 0x80, 0x26, 0x6E, 0x90, 0x65, 0x6A, 0xE0, 0x75,
  0x88, 0x60, 0x65, 0x9A, 0xE0, 0x74, 0x68, 0xE0, 0x64, 0x68, 0x80, 0x75,
  0xB9, 0x60, 0x55, 0x79, 0x90, 0x5A, 0x80, 0x24, 0x9C, 0x56, 0x4A, 0xA0,
  0x4A, 0x4E, 0x4A, 0xF7, 0x5A, 0x80, 0x55, 0xBB, 0xA0, 0x75, 0x99, 0x60,
  0x75, 0x68, 0x80, 0x75, 0x99, 0x62, 0x65, 0x6A, 0xA0, 0x64, 0x6A, 0xE0,
  0xEA, 0x48, 0x55, 0x9A, 0xE0, 0x37, 0x68, 0x1D, 0xBA, 0xA0, 0x56, 0x46,
  0xA0, 0xBB, 0x48, 0x72, 0x44, 0xE0, 0x56, 0xA8, 0x78, 0x56, 0xA8, 0x58,
  0xC0, 0x80, 0x67, 0xF0, 0x4E, 0xDE, 0x76, 0x60, 0x26, 0xAA, 0xE0, 0x77,
  0x70, 0x59, 0x48, 0x56, 0xFE, 0x4E, 0xDA, 0x4A, 0x80, 0x21, 0x24, 0x80,
  0x4F, 0x6A, 0x5A, 0x80, 0x7D, 0x6B, 0x50, 0x76, 0xD0, 0x76, 0xF0, 0x76,
  0xF8, 0x76, 0xF2, 0x6A, 0x71, 0xE0, 0x76, 0xC0, 0x36, 0xF0, 0xB5, 0x20,
  0xA5, 0x9D, 0x40, 0x29, 0x50, 0xB5, 0x28, 0x00, 0x69, 0x60, 0x5A, 0xA0,
  0x5A, 0xA0, 0x56, 0xA0, 0x5A,
};

const GFXglyph RobotoCondensed_MediumItalic7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 5, 2, 0, -5 },
  { 3, 1, 2, 2, 1, -5 },
  { 4, 4, 5, 4, 0, -5 },
  { 7, 3, 7, 3, 0, -6 },
  { 10, 3, 5, 4, 1, -5 },
  { 12, 4, 5, 4, 0, -5 },
  { 15, 1, 2, 1, 0, -5 },
  { 16, 2, 8, 2, 0, -6 },
  { 18, 2, 8, 2, 0, -6 },
  { 20, 3, 3, 3, 0, -5 },
  { 22, 3, 4, 3, 0, -4 },
  { 24, 1, 2, 2, 0, -1 },
  { 25, 2, 1, 2, 0, -3 },
  { 26, 1, 1, 2, 0, -1 },
  { 27, 3, 5, 2, 0, -5 },
  { 29, 3, 5, 3, 0, -5 },
  { 31, 2, 5, 3, 1, -5 },
  { 33, 3, 5, 3, 0, -5 },
  { 35, 3, 5, 3, 0, -5 },
  { 37, 3, 5, 3, 0, -5 },
  { 39, 3, 5, 3, 0, -5 },
  { 41, 3, 5, 3, 0, -5 },
  { 43, 4, 5, 3, 0, -5 },
  { 46, 3, 5, 3, 0, -5 },
  { 48, 3, 5, 3, 0, -5 },
  { 50, 2, 4, 2, 0, -4 },
  { 51, 2, 5, 2, 0, -4 },
  { 53, 3, 3, 3, 0, -4 },
  { 55, 3, 2, 3, 0, -3 },
  { 56, 3, 3, 3, 0, -4 },
  { 58, 2, 5, 3, 1, -5 },
  { 60, 5, 7, 5, 0, -5 },
  { 65, 4, 5, 4, 0, -5 },
  { 68, 4, 5, 4, 0, -5 },
  { 71, 4, 5, 4, 0, -5 },
  { 74, 4, 5, 4, 0, -5 },
  { 77, 4, 5, 3, 0, -5 },
  { 80, 4, 5, 3, 0, -5 },
  { 83, 4, 5, 4, 0, -5 },
  { 86, 4, 5, 4, 0, -5 },
  { 89, 2, 5, 2, 0, -5 },
  { 91, 3, 5, 3, 0, -5 },
  { 93, 4, 5, 4, 0, -5 },
  { 96, 3, 5, 3, 0, -5 },
  { 98, 5, 5, 5, 0, -5 },
  { 102, 4, 5, 4, 0, -5 },
  { 105, 4, 5, 4, 0, -5 },
  { 108, 4, 5, 4, 0, -5 },
  { 111, 4, 6, 4, 0, -5 },
  { 114, 4, 5, 4, 0, -5 },
  { 117, 4, 5, 4, 0, -5 },
  { 120, 3, 5, 4, 1, -5 },
  { 122, 4, 5, 4, 0, -5 },
  { 125, 3, 5, 4, 1, -5 },
  { 127, 4, 5, 5, 1, -5 },
  { 130, 4, 5, 4, 0, -5 },
  { 133, 3, 5, 4, 1, -5 },
  { 135, 4, 5, 4, 0, -5 },
  { 138, 2, 7, 2, 0, -6 },
  { 140, 1, 5, 3, 1, -5 },
  { 141, 2, 7, 2, 0, -6 },
  { 143, 2, 3, 3, 0, -5 },
  { 144, 2, 1, 3, 0, 0 },
  { 145, 1, 1, 2, 1, -5 },
  { 146, 3, 4, 3, 0, -4 },
  { 148, 3, 5, 3, 0, -5 },
  { 150, 3, 4, 3, 0, -4 },
  { 152, 4, 5, 3, 0, -5 },
  { 155, 3, 4, 3, 0, -4 },
  { 157, 3, 5, 2, 0, -5 },
  { 159, 3, 5, 3, 0, -4 },
  { 161, 3, 5, 3, 0, -5 },
  { 163, 2, 5, 2, 0, -5 },
  { 165, 3, 7, 2, -1, -5 },
  { 168, 3, 5, 3, 0, -5 },
  { 170, 2, 5, 2, 0, -5 },
  { 172, 5, 4, 5, 0, -4 },
  { 175, 3, 4, 3, 0, -4 },
  { 177, 3, 4, 3, 0, -4 },
  { 179, 3, 5, 3, 0, -4 },
  { 181, 3, 5, 3, 0, -4 },
  { 183, 2, 4, 2, 0, -4 },
  { 184, 3, 4, 3, 0, -4 },
  { 186, 2, 5, 2, 0, -5 },
  { 188, 3, 4, 3, 0, -4 },
  { 190, 3, 4, 3, 0, -4 },
  { 192, 5, 4, 4, 0, -4 },
  { 195, 3, 4, 3, 0, -4 },
  { 197, 3, 6, 3, 0, -4 },
  { 200, 3, 4, 3, 0, -4 },
  { 202, 2, 6, 2, 0, -5 },
  { 204, 2, 6, 2, 0, -5 },
  { 206, 2, 6, 2, 0, -5 },
  { 208, 4, 2, 4, 0, -3 },
};

const GFXfont RobotoCondensed_MediumItalic7pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_MediumItalic7pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_MediumItalic7pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _ROBOTOCONDENSED_MEDIUMITALIC7PT7B_H_
