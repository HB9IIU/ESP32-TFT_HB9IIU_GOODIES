#ifndef _ROBOTOCONDENSED_MEDIUMITALIC54PT7B_H_
#define _ROBOTOCONDENSED_MEDIUMITALIC54PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-MediumItalic.ttf
// Size: 54pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_MediumItalic54pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF8, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x1F,
  0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x03, 0xF0, 0x3F, 0x81, 0xFC, 0x07,
  0xE0, 0x3E, 0x00, 0x40, 0x00, 0x3E, 0x3C, 0x7C, 0x78, 0xF0, 0xF1, 0xE3,
  0xE3, 0xC7, 0xCF, 0x8F, 0x9F, 0x1E, 0x3C, 0x3C, 0x78, 0x78, 0xF0, 0xF1,
  0xE3, 0xC3, 0x87, 0x8F, 0x0F, 0x1E, 0x1E, 0x00, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0xF0, 0xF0, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF0,
  0xF0, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF0, 0xF0, 0x00,
  0x1E, 0x1E, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF0, 0xF0, 0x07, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x07,
  0xC3, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0xC3, 0xC0,
  0x00, 0xF0, 0xF0, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0xF0,
  0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xF0, 0x07, 0xC3, 0xC0, 0x00, 0xF0, 0xF8, 0x00, 0x1E, 0x1E,
  0x00, 0x07, 0xC3, 0xC0, 0x00, 0xF0, 0xF8, 0x00, 0x1E, 0x1E, 0x00, 0x07,
  0xC3, 0xC0, 0x00, 0xF0, 0xF8, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0xC3, 0xC0,
  0x00, 0xF0, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xE0, 0x7F, 0x0F, 0xE0, 0xFC, 0x0F, 0xC3, 0xF0, 0x1F,
  0x87, 0xE0, 0x3F, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF8,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xF9, 0xF8, 0x03, 0xF3, 0xF0, 0x07, 0xE7, 0xE0, 0x0F,
  0xCF, 0xC0, 0x3F, 0x1F, 0x80, 0x7E, 0x3F, 0x81, 0xFC, 0x3F, 0x07, 0xF0,
  0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00,
  0x7F, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xEF, 0x80, 0x03,
  0xC3, 0xC0, 0x63, 0xE0, 0xF0, 0x39, 0xE0, 0x78, 0x3C, 0xF0, 0x3C, 0x3E,
  0x78, 0x3E, 0x1E, 0x3C, 0x1F, 0x1E, 0x1E, 0x0F, 0x1F, 0x0F, 0x07, 0x9F,
  0x07, 0x87, 0xCF, 0x03, 0xE7, 0xCF, 0x00, 0xFF, 0xEF, 0x80, 0x3F, 0xE7,
  0x80, 0x0F, 0xE7, 0x80, 0x01, 0x87, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE7, 0xF0, 0x01, 0xE7, 0xFC, 0x01,
  0xE7, 0xFF, 0x01, 0xF7, 0xE7, 0x80, 0xF3, 0xC3, 0xE0, 0xF1, 0xE0, 0xF0,
  0xF9, 0xF0, 0x78, 0x78, 0xF0, 0x3C, 0x78, 0x78, 0x1E, 0x7C, 0x3C, 0x0F,
  0x3C, 0x1E, 0x0F, 0xBC, 0x0F, 0x07, 0x9E, 0x07, 0xC7, 0xC2, 0x01, 0xF7,
  0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0x87, 0xC0,
  0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0xF8, 0x1F, 0x80, 0x3E, 0x07,
  0xC0, 0x0F, 0x83, 0xF0, 0x03, 0xE0, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x3F,
  0x7F, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0xC1,
  0xF1, 0xFF, 0xF0, 0x7C, 0xFE, 0xFE, 0x3F, 0x3F, 0x1F, 0x8F, 0x9F, 0xC3,
  0xF3, 0xE7, 0xE0, 0xFD, 0xF9, 0xF8, 0x1F, 0xFC, 0xFE, 0x07, 0xFF, 0x3F,
  0x00, 0xFF, 0xCF, 0xE0, 0x3F, 0xE3, 0xF8, 0x07, 0xF0, 0x7E, 0x01, 0xFC,
  0x1F, 0xC0, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0x03, 0xFF, 0xCF, 0xC0, 0x7F, 0xC3, 0xF8, 0x01, 0x00, 0x00, 0x3E,
  0x78, 0xF3, 0xE7, 0xCF, 0x9F, 0x3C, 0x79, 0xF3, 0xE7, 0x8F, 0x1E, 0x00,
  0x00, 0x02, 0x00, 0x06, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0,
  0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00,
  0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0,
  0x03, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF0, 0x00,
  0xE0, 0x00, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x02, 0x03, 0xC0, 0x9E,
  0x1E, 0x0E, 0x7E, 0x79, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF,
  0xF8, 0x01, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00,
  0x0F, 0x9E, 0x00, 0x7C, 0x7C, 0x03, 0xE1, 0xF0, 0x1F, 0x83, 0xE0, 0x7C,
  0x0F, 0x80, 0x60, 0x1C, 0x00, 0x00, 0x40, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x1F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x07, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xE0, 0xF8, 0x7E, 0x1F,
  0x0F, 0xC3, 0xE1, 0xF8, 0xFC, 0x1E, 0x03, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x18, 0x7E, 0x7E, 0xFE, 0xFE, 0x7E, 0x7C, 0x10,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x81, 0xF8, 0x3F, 0x07,
  0xE0, 0x3E, 0x0F, 0xC0, 0x7E, 0x3F, 0x00, 0xFC, 0x7E, 0x01, 0xF8, 0xFC,
  0x03, 0xF1, 0xF0, 0x07, 0xE7, 0xE0, 0x0F, 0xCF, 0xC0, 0x1F, 0x9F, 0x80,
  0x3F, 0x3F, 0x00, 0x7E, 0x7E, 0x01, 0xF9, 0xF8, 0x03, 0xF3, 0xF0, 0x07,
  0xE7, 0xE0, 0x0F, 0xCF, 0xC0, 0x1F, 0x9F, 0x80, 0x3F, 0x3F, 0x00, 0x7E,
  0x7E, 0x01, 0xF8, 0xF8, 0x03, 0xF3, 0xF0, 0x07, 0xE7, 0xE0, 0x0F, 0xCF,
  0xC0, 0x1F, 0x0F, 0x80, 0x7E, 0x1F, 0x00, 0xFC, 0x3E, 0x01, 0xF0, 0x7E,
  0x07, 0xE0, 0xFC, 0x1F, 0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x01, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x3C, 0x03, 0xF8, 0x1F, 0xF1, 0xFF, 0xEF, 0xFF, 0x9F, 0xFF, 0x3F,
  0xFE, 0xFC, 0xFD, 0xE1, 0xFA, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0x7F, 0x07,
  0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0xC3, 0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xF0,
  0xFC, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFC,
  0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xF0, 0x7E, 0x0F, 0xE0, 0x7F,
  0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x03, 0xF8,
  0xFE, 0x03, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F,
  0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xDF, 0x80, 0x07,
  0xEF, 0xC0, 0x03, 0xE7, 0xE0, 0x03, 0xE7, 0xE0, 0x03, 0xF3, 0xF0, 0x01,
  0xF1, 0xF8, 0x01, 0xF0, 0xFC, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x3F, 0x00,
  0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0x7C, 0x07, 0xE0,
  0x7E, 0x03, 0xF0, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x01,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x9F, 0x00, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xC7, 0xF8, 0x0F, 0x03, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0xFC,
  0x01, 0xF8, 0xFC, 0x03, 0xF8, 0xFC, 0x03, 0xF0, 0x7E, 0x07, 0xF0, 0x7F,
  0x0F, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x7E, 0x01, 0xF7,
  0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE3, 0xFC, 0x3F,
  0x9F, 0xE0, 0x7E, 0x7F, 0x01, 0xF9, 0xF8, 0x07, 0xE7, 0xE0, 0x0F, 0xDF,
  0x80, 0x3F, 0x7E, 0x00, 0xFD, 0xF8, 0x03, 0xF7, 0xE0, 0x1F, 0x9F, 0x80,
  0x7E, 0x7E, 0x01, 0xF9, 0xF8, 0x07, 0xE7, 0xE0, 0x3F, 0x1F, 0x81, 0xFC,
  0x3F, 0x0F, 0xE0, 0xFF, 0xFF, 0x81, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x06, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xFC, 0x3F, 0x87, 0xF0,
  0x3F, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF8, 0x7E, 0x03,
  0xF0, 0xF8, 0x07, 0xE1, 0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0x07, 0xE0, 0xFE,
  0x07, 0xE3, 0xF8, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x1F, 0xFE, 0x00,
  0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x0F, 0xE1, 0xF8, 0x3F, 0x81, 0xF8, 0x7E,
  0x03, 0xF0, 0xFC, 0x03, 0xE3, 0xF0, 0x07, 0xC7, 0xE0, 0x0F, 0x8F, 0xC0,
  0x3F, 0x1F, 0x80, 0x7E, 0x3F, 0x00, 0xFC, 0x7E, 0x01, 0xF8, 0xFC, 0x07,
  0xF1, 0xFC, 0x1F, 0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x03, 0xFF, 0xF8,
  0x03, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF0, 0xFE, 0x1F, 0xC7, 0xE0, 0x7E, 0x7E, 0x03, 0xF3, 0xF0, 0x1F, 0x9F,
  0x80, 0x7D, 0xF8, 0x03, 0xEF, 0xC0, 0x1F, 0x7E, 0x00, 0xFB, 0xF0, 0x0F,
  0xDF, 0x80, 0x7E, 0xFC, 0x03, 0xF7, 0xE0, 0x1F, 0xBF, 0x01, 0xFD, 0xFC,
  0x1F, 0xE7, 0xF1, 0xFF, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x87, 0xFF, 0xFC,
  0x1F, 0xF7, 0xE0, 0x3E, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xFE, 0x00,
  0x7F, 0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x3F, 0xC0,
  0x01, 0xF0, 0x00, 0x00, 0x01, 0x80, 0xF8, 0x3F, 0x87, 0xF0, 0xFE, 0x1F,
  0xC1, 0xF0, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x03,
  0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x07, 0xC0, 0x20, 0x00, 0x00, 0x30,
  0x01, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00,
  0x7E, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0x80, 0x02, 0x00, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x01, 0xC0, 0x00, 0x3E, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00,
  0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0,
  0x1F, 0xFC, 0x00, 0xFF, 0x80, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFF,
  0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0,
  0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x1E, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x80, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8,
  0x08, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x7F,
  0xFC, 0x07, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x7F, 0x80, 0x01, 0xF8, 0x00,
  0x07, 0x80, 0x00, 0x38, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x3F, 0xFC, 0x0F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xFF, 0x9F,
  0xC3, 0xFB, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0x80, 0x00, 0x40, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x03, 0xE0,
  0x01, 0xF8, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0xF8, 0x00,
  0x00, 0xF0, 0x0F, 0x80, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x00, 0x3C, 0x07,
  0x80, 0x3F, 0x00, 0xE0, 0x7C, 0x07, 0xFE, 0x07, 0x83, 0xC0, 0x7F, 0xF8,
  0x3C, 0x3E, 0x07, 0xFF, 0xC1, 0xE1, 0xE0, 0x7E, 0x1E, 0x0F, 0x1F, 0x03,
  0xE1, 0xF0, 0x78, 0xF0, 0x3E, 0x0F, 0x83, 0xC7, 0x81, 0xE0, 0x78, 0x1E,
  0x7C, 0x1F, 0x03, 0xC0, 0xF3, 0xC0, 0xF0, 0x1E, 0x07, 0x9E, 0x0F, 0x81,
  0xF0, 0x3D, 0xF0, 0x7C, 0x0F, 0x81, 0xEF, 0x83, 0xC0, 0x78, 0x0F, 0x78,
  0x3E, 0x03, 0xC0, 0x73, 0xC1, 0xF0, 0x3E, 0x07, 0x9E, 0x0F, 0x81, 0xF0,
  0x3C, 0xF0, 0x7C, 0x0F, 0x01, 0xEF, 0x83, 0xE0, 0x78, 0x0F, 0x7C, 0x1F,
  0x07, 0xC0, 0xF3, 0xE0, 0xF0, 0x3E, 0x07, 0x9F, 0x07, 0xC1, 0xF0, 0x38,
  0xF0, 0x3E, 0x1F, 0x83, 0xC7, 0x81, 0xF1, 0xFC, 0x3C, 0x3E, 0x0F, 0xFF,
  0xE3, 0xE1, 0xF0, 0x7F, 0xEF, 0xFE, 0x07, 0x81, 0xFE, 0x3F, 0xE0, 0x3C,
  0x07, 0xE1, 0xFE, 0x01, 0xE0, 0x08, 0x01, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x40, 0x00,
  0x07, 0xF0, 0x1E, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0x7C,
  0x00, 0x01, 0xFB, 0xE0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0xFC, 0xFC, 0x00,
  0x07, 0xE7, 0xE0, 0x00, 0x7E, 0x3F, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x3F,
  0x07, 0xC0, 0x01, 0xF8, 0x3E, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0xFC, 0x0F,
  0xC0, 0x0F, 0xE0, 0x7E, 0x00, 0x7E, 0x03, 0xF0, 0x07, 0xF0, 0x1F, 0x80,
  0x3F, 0x00, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x07, 0xF0, 0x01,
  0xF8, 0x3F, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x03, 0xF1,
  0xFC, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x7E, 0xFE, 0x00, 0x03, 0xF7, 0xE0,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFC, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x0F,
  0xE0, 0x7F, 0x81, 0xFC, 0x03, 0xF8, 0x3F, 0x00, 0x7F, 0x07, 0xE0, 0x07,
  0xE0, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x87, 0xF0, 0x07, 0xF0, 0xFC,
  0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x83, 0xF0, 0x07, 0xF0, 0x7E, 0x03, 0xFC,
  0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xC1,
  0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x00,
  0xFC, 0x1F, 0x80, 0x1F, 0x87, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xFE, 0x1F,
  0x80, 0x1F, 0xC3, 0xF0, 0x07, 0xF0, 0x7E, 0x03, 0xFE, 0x1F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC,
  0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xE0, 0xFC,
  0x00, 0x7E, 0x1F, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0x7F, 0x1F, 0x80, 0x07,
  0xF3, 0xF8, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x1F, 0x87, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x87, 0xE0, 0x03, 0xF0,
  0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0xFE, 0x03, 0xF8,
  0x1F, 0xE0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xF8, 0x0F, 0xE1, 0xFF, 0x01, 0xF8, 0x07, 0xF0, 0x3F,
  0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xE0, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x1F,
  0x87, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC3, 0xF0,
  0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x1F, 0xC0, 0x07, 0xE3, 0xF8, 0x00, 0xFC,
  0x7E, 0x00, 0x3F, 0x8F, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x3F, 0x00,
  0x1F, 0x8F, 0xE0, 0x03, 0xF1, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0xC7,
  0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0xC7, 0xF0, 0x03,
  0xF0, 0xFC, 0x00, 0xFE, 0x1F, 0x80, 0x3F, 0x83, 0xF0, 0x0F, 0xE0, 0x7E,
  0x0F, 0xFC, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFC, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC1, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFE, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x00,
  0x7E, 0x0F, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x03, 0xF1,
  0xF8, 0x00, 0x3F, 0x1F, 0x80, 0x03, 0xF3, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xF0, 0x3F, 0xFC, 0x7F, 0x03, 0xFF, 0xC7, 0xE0,
  0x3F, 0xFC, 0x7E, 0x03, 0xFF, 0xC7, 0xE0, 0x3F, 0xFC, 0x7E, 0x00, 0x1F,
  0xC7, 0xE0, 0x01, 0xFC, 0x7E, 0x00, 0x1F, 0x87, 0xE0, 0x01, 0xF8, 0x7E,
  0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF8, 0x7E, 0x00, 0x3F, 0x87, 0xF0, 0x03,
  0xF8, 0x3F, 0x00, 0x7F, 0x03, 0xFC, 0x1F, 0xF0, 0x1F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0x03, 0xF0, 0x00,
  0x7E, 0x03, 0xF0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x7E, 0x03, 0xF0, 0x00,
  0x7E, 0x07, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0xFE, 0x07, 0xE0, 0x00,
  0xFC, 0x07, 0xE0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0xFC, 0x07, 0xE0, 0x00,
  0xFC, 0x0F, 0xE0, 0x01, 0xFC, 0x0F, 0xC0, 0x01, 0xFC, 0x0F, 0xC0, 0x01,
  0xF8, 0x0F, 0xC0, 0x01, 0xF8, 0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0x80, 0x03, 0xF0, 0x3F, 0x80, 0x03,
  0xF0, 0x3F, 0x80, 0x07, 0xF0, 0x3F, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x07,
  0xE0, 0x3F, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x0F,
  0xE0, 0x7E, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x0F,
  0xC0, 0x7E, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x1F,
  0xC0, 0xFC, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0xFE, 0x07, 0xF0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x3F, 0x81, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x3F, 0x81, 0xFC, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x81, 0xFC, 0x0F,
  0xC0, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC3, 0xF8, 0x07, 0xE0, 0xFE, 0x01,
  0xF8, 0x3F, 0x80, 0x7E, 0x07, 0xE0, 0x3F, 0x81, 0xF8, 0x1F, 0xC0, 0x7F,
  0x0F, 0xF0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00,
  0x0F, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x04, 0x00, 0x00, 0x03, 0xF8,
  0x01, 0xFE, 0x07, 0xE0, 0x07, 0xF8, 0x0F, 0xC0, 0x1F, 0xE0, 0x1F, 0x80,
  0x3F, 0x80, 0x3F, 0x00, 0xFF, 0x00, 0xFE, 0x03, 0xFC, 0x01, 0xF8, 0x0F,
  0xF0, 0x03, 0xF0, 0x3F, 0xC0, 0x07, 0xE0, 0x7F, 0x00, 0x0F, 0xC1, 0xFC,
  0x00, 0x1F, 0x87, 0xF0, 0x00, 0x7F, 0x1F, 0xE0, 0x00, 0xFC, 0x7F, 0x80,
  0x01, 0xF8, 0xFE, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x07, 0xEF, 0xE0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x1F, 0xF3, 0xF0, 0x00, 0x3F, 0xC7, 0xF0, 0x00, 0x7F,
  0x0F, 0xE0, 0x00, 0xFC, 0x0F, 0xE0, 0x01, 0xF8, 0x1F, 0xC0, 0x07, 0xF0,
  0x1F, 0x80, 0x0F, 0xC0, 0x3F, 0x80, 0x1F, 0x80, 0x7F, 0x00, 0x3F, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x01,
  0xFC, 0x07, 0xE0, 0x03, 0xF8, 0x0F, 0xC0, 0x07, 0xF0, 0x1F, 0x80, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xF8, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x07,
  0xFC, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00,
  0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x01, 0xFF, 0x81,
  0xFF, 0x80, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x07, 0xFE, 0x00,
  0x1F, 0xFC, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x1F, 0xFC, 0x00, 0xFF, 0xE0,
  0x7E, 0xF8, 0x01, 0xFF, 0xC0, 0xFD, 0xF0, 0x07, 0xFF, 0x81, 0xFB, 0xE0,
  0x0F, 0xBF, 0x03, 0xF7, 0xC0, 0x3F, 0x7E, 0x07, 0xEF, 0x80, 0x7D, 0xF8,
  0x1F, 0x9F, 0x01, 0xFB, 0xF0, 0x3F, 0x3E, 0x03, 0xE7, 0xE0, 0x7E, 0x7C,
  0x0F, 0xCF, 0xC0, 0xFC, 0x7C, 0x1F, 0x1F, 0x81, 0xF8, 0xF8, 0x7E, 0x7E,
  0x03, 0xF1, 0xF0, 0xF8, 0xFC, 0x0F, 0xE3, 0xE1, 0xF1, 0xF8, 0x1F, 0x87,
  0xC7, 0xC3, 0xF0, 0x3F, 0x0F, 0x8F, 0x87, 0xE0, 0x7E, 0x1F, 0x3E, 0x1F,
  0xC0, 0xFC, 0x3E, 0x7C, 0x3F, 0x01, 0xF8, 0x3D, 0xF0, 0x7E, 0x07, 0xF0,
  0x7F, 0xE0, 0xFC, 0x0F, 0xC0, 0xFF, 0x81, 0xF8, 0x1F, 0x81, 0xFF, 0x07,
  0xF0, 0x3F, 0x03, 0xFE, 0x0F, 0xE0, 0x7E, 0x07, 0xF8, 0x1F, 0x81, 0xFC,
  0x0F, 0xF0, 0x3F, 0x03, 0xF8, 0x1F, 0xC0, 0x7E, 0x07, 0xE0, 0x1F, 0x80,
  0xFC, 0x0F, 0xC0, 0x3E, 0x03, 0xF8, 0x1F, 0x80, 0x7C, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x7E,
  0x03, 0xFC, 0x00, 0x7E, 0x03, 0xFC, 0x00, 0x7E, 0x07, 0xFC, 0x00, 0xFE,
  0x07, 0xFC, 0x00, 0xFE, 0x07, 0xFE, 0x00, 0xFC, 0x07, 0xFE, 0x00, 0xFC,
  0x07, 0xFE, 0x00, 0xFC, 0x07, 0xFF, 0x00, 0xFC, 0x0F, 0xFF, 0x01, 0xFC,
  0x0F, 0xDF, 0x01, 0xF8, 0x0F, 0xCF, 0x81, 0xF8, 0x0F, 0xCF, 0x81, 0xF8,
  0x0F, 0xCF, 0x81, 0xF8, 0x1F, 0xCF, 0x81, 0xF8, 0x1F, 0xC7, 0xC3, 0xF8,
  0x1F, 0x87, 0xC3, 0xF0, 0x1F, 0x87, 0xC3, 0xF0, 0x1F, 0x83, 0xE3, 0xF0,
  0x1F, 0x83, 0xE3, 0xF0, 0x3F, 0x83, 0xE3, 0xF0, 0x3F, 0x81, 0xF7, 0xF0,
  0x3F, 0x01, 0xF7, 0xE0, 0x3F, 0x01, 0xF7, 0xE0, 0x3F, 0x01, 0xF7, 0xE0,
  0x3F, 0x00, 0xFF, 0xE0, 0x7F, 0x00, 0xFF, 0xE0, 0x7E, 0x00, 0xFF, 0xE0,
  0x7E, 0x00, 0x7F, 0xC0, 0x7E, 0x00, 0x7F, 0xC0, 0x7E, 0x00, 0x7F, 0xC0,
  0xFE, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x3F, 0xC0, 0xFC, 0x00, 0x3F, 0x80,
  0xFC, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x40, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x00, 0xFE,
  0x0F, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0x7F, 0x0F, 0xC0, 0x03, 0xF1, 0xF8,
  0x00, 0x3F, 0x1F, 0x80, 0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x3F, 0x80, 0x03,
  0xF3, 0xF0, 0x00, 0x3F, 0x3F, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x3F, 0x3F,
  0x00, 0x07, 0xF7, 0xF0, 0x00, 0x7E, 0x7F, 0x00, 0x07, 0xE7, 0xE0, 0x00,
  0x7E, 0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x0F, 0xE7,
  0xE0, 0x00, 0xFC, 0x7E, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0xFC, 0x7E, 0x00,
  0x1F, 0xC7, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x87, 0xF0, 0x03, 0xF0,
  0x3F, 0x00, 0x7F, 0x03, 0xFC, 0x1F, 0xE0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x03, 0xF8,
  0x1F, 0xF0, 0x1F, 0xC0, 0x1F, 0xC0, 0xFC, 0x00, 0xFE, 0x07, 0xE0, 0x03,
  0xF0, 0x3F, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0xFC, 0x1F, 0xC0, 0x07, 0xE0,
  0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0xC1, 0xF8,
  0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xE0, 0xFE, 0x00, 0xFF, 0x07, 0xE0, 0x1F,
  0xF0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x03, 0xFC, 0x1F, 0xE0, 0x7F,
  0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x03,
  0xF1, 0xF8, 0x00, 0x3F, 0x1F, 0x80, 0x03, 0xF3, 0xF8, 0x00, 0x3F, 0x3F,
  0x00, 0x03, 0xF3, 0xF0, 0x00, 0x3F, 0x3F, 0x00, 0x03, 0xF3, 0xF0, 0x00,
  0x7F, 0x7F, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xE7,
  0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0xFE, 0x7E, 0x00,
  0x0F, 0xC7, 0xE0, 0x00, 0xFC, 0x7E, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0xFC,
  0x7E, 0x00, 0x1F, 0x87, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x87, 0xF0,
  0x03, 0xF0, 0x7F, 0x00, 0x7F, 0x03, 0xF8, 0x1F, 0xE0, 0x3F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x01, 0xBF, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x0F, 0xE0, 0x7F, 0x81,
  0xFC, 0x03, 0xF8, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x00,
  0xFC, 0x1F, 0x80, 0x1F, 0x87, 0xF0, 0x03, 0xF0, 0xFE, 0x00, 0x7E, 0x1F,
  0x80, 0x1F, 0xC3, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0xFE, 0x1F, 0xC0, 0x3F,
  0x83, 0xF8, 0x3F, 0xF0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFC, 0x1F, 0x80,
  0x3F, 0x03, 0xF0, 0x07, 0xE0, 0x7F, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x80,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0xFE, 0x03, 0xF8, 0x1F, 0x80, 0x7F, 0x03,
  0xF0, 0x07, 0xE0, 0x7E, 0x00, 0xFE, 0x0F, 0xC0, 0x1F, 0xC3, 0xF8, 0x03,
  0xF8, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xF1, 0xF8, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0xFE, 0x07, 0xF0,
  0x3F, 0x80, 0x7E, 0x07, 0xE0, 0x0F, 0xE1, 0xFC, 0x01, 0xFC, 0x3F, 0x80,
  0x1F, 0x87, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x1F, 0x8F, 0xC0,
  0x03, 0xF1, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0x83, 0xF0, 0x03, 0xF0,
  0x7F, 0x00, 0xFE, 0x0F, 0xF0, 0x3F, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00,
  0x01, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x03, 0xF8, 0x3F,
  0x00, 0x1F, 0x83, 0xF8, 0x00, 0xFC, 0x1F, 0xC0, 0x07, 0xE0, 0xFC, 0x00,
  0x3F, 0x07, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0xFC,
  0x1F, 0xC0, 0x07, 0xE0, 0xFE, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF8, 0x3F,
  0x00, 0x1F, 0xC1, 0xF8, 0x00, 0xFE, 0x0F, 0xC0, 0x07, 0xE0, 0xFE, 0x00,
  0x3F, 0x07, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0xFE,
  0x0F, 0xC0, 0x07, 0xF0, 0x7E, 0x00, 0x3F, 0x07, 0xF0, 0x01, 0xF8, 0x3F,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xF0, 0x7E, 0x00,
  0x3F, 0x83, 0xF0, 0x01, 0xF8, 0x3F, 0x80, 0x0F, 0xC1, 0xFC, 0x00, 0x7E,
  0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x03, 0xF8, 0x01, 0xF8, 0x0F,
  0xC0, 0x1F, 0xC0, 0x7F, 0x03, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xFB, 0xF0, 0x00, 0x3F,
  0x9F, 0x80, 0x01, 0xFC, 0xFC, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0xFE, 0x3F,
  0x80, 0x0F, 0xE1, 0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF0, 0x3F, 0x00,
  0x3F, 0x81, 0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x1F, 0xC0, 0x7E, 0x00, 0xFE,
  0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x7F, 0x00, 0xFC, 0x03, 0xF0, 0x07,
  0xF0, 0x3F, 0x80, 0x1F, 0x81, 0xF8, 0x00, 0xFC, 0x1F, 0xC0, 0x07, 0xE0,
  0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF8, 0x7F, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x7E, 0x3F, 0x80, 0x01, 0xF1, 0xF8, 0x00, 0x0F, 0x8F, 0xC0, 0x00,
  0x7C, 0xFC, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xC0, 0x1F, 0xBF, 0x00, 0x7E, 0x00,
  0xFD, 0xF8, 0x03, 0xF0, 0x07, 0xEF, 0xC0, 0x3F, 0x80, 0x7E, 0x7E, 0x01,
  0xFC, 0x03, 0xF3, 0xF0, 0x1F, 0xE0, 0x1F, 0x9F, 0x80, 0xFF, 0x01, 0xF8,
  0xFC, 0x07, 0xF8, 0x0F, 0xC7, 0xE0, 0x7F, 0xC0, 0x7E, 0x3F, 0x03, 0xFE,
  0x07, 0xE1, 0xF8, 0x1F, 0xF0, 0x3F, 0x0F, 0xC1, 0xF7, 0xC1, 0xF8, 0x7E,
  0x0F, 0xBE, 0x1F, 0x83, 0xF0, 0x7D, 0xF0, 0xFC, 0x1F, 0x87, 0xCF, 0x87,
  0xE0, 0xFC, 0x3E, 0x7C, 0x7E, 0x03, 0xE1, 0xF3, 0xE3, 0xF0, 0x1F, 0x1F,
  0x1F, 0x1F, 0x80, 0xF8, 0xF8, 0xF9, 0xF8, 0x07, 0xCF, 0xC7, 0xCF, 0xC0,
  0x3E, 0x7C, 0x3E, 0x7E, 0x01, 0xF3, 0xE1, 0xF7, 0xE0, 0x0F, 0xBE, 0x0F,
  0xBF, 0x00, 0x7D, 0xF0, 0x7D, 0xF8, 0x03, 0xEF, 0x83, 0xEF, 0x80, 0x1F,
  0xF8, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x07, 0xFE, 0x07, 0xFE,
  0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x0F, 0xF0,
  0x07, 0xF8, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0x01,
  0xF8, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x00,
  0xFC, 0x03, 0xF8, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x00,
  0x7E, 0x07, 0xF0, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x7F, 0x1F, 0xC0, 0x00,
  0x3F, 0x1F, 0xC0, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x3F, 0xBF, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00,
  0xFE, 0xFC, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x03,
  0xF8, 0x7E, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x0F,
  0xE0, 0x3F, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x3F,
  0x80, 0x3F, 0x80, 0x7F, 0x80, 0x1F, 0x80, 0x7F, 0x00, 0x1F, 0xC0, 0xFE,
  0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x03,
  0xF9, 0xF8, 0x01, 0xFC, 0x7E, 0x00, 0x7F, 0x1F, 0x80, 0x3F, 0x87, 0xE0,
  0x0F, 0xE0, 0xFC, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0xFE, 0x03,
  0xF0, 0x3F, 0x00, 0x7C, 0x1F, 0xC0, 0x1F, 0x87, 0xE0, 0x07, 0xE3, 0xF0,
  0x01, 0xF9, 0xFC, 0x00, 0x3E, 0x7E, 0x00, 0x0F, 0xBF, 0x80, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x0F,
  0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC,
  0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F,
  0xC0, 0xF8, 0x1F, 0x03, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x03, 0xE0,
  0x7C, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x0F, 0x81, 0xF0, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x3E, 0x07, 0xC0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC0, 0xF8, 0x1F, 0x03, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x03, 0xE0, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE,
  0x00, 0xFF, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x07, 0xDE, 0x03, 0xEF,
  0x03, 0xE7, 0xC1, 0xF3, 0xE1, 0xF1, 0xF0, 0xF8, 0x78, 0xF8, 0x3C, 0x7C,
  0x1E, 0x7C, 0x0F, 0xBE, 0x07, 0xFE, 0x03, 0xE0, 0x7F, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x00, 0x7E, 0x0F,
  0xE0, 0xFC, 0x0F, 0xC0, 0xF8, 0x1F, 0x81, 0xF0, 0x1F, 0x00, 0x04, 0x00,
  0x03, 0xFF, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F,
  0xDF, 0xE1, 0xFC, 0x1F, 0x87, 0xE0, 0x7E, 0x1F, 0x81, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0xC3, 0xF1, 0xFC, 0x0F, 0xC7, 0xE0,
  0x3F, 0x3F, 0x80, 0xFC, 0xFC, 0x03, 0xF3, 0xF0, 0x0F, 0xCF, 0xC0, 0x7E,
  0x3F, 0x01, 0xF8, 0xFE, 0x0F, 0xE3, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x1F,
  0xFF, 0xF8, 0x3F, 0xF7, 0xE0, 0x7F, 0x9F, 0x80, 0x10, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE7, 0xF0, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFE, 0x0F, 0xF0, 0x7E, 0x0F, 0xE0, 0x7F, 0x0F, 0xC0, 0x3F, 0x0F,
  0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x1F,
  0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x7E, 0x3F,
  0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3F,
  0x00, 0xFE, 0x3F, 0x00, 0xFC, 0x7F, 0x01, 0xFC, 0x7F, 0x83, 0xF8, 0x7F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0x7D, 0xFF, 0xF0, 0xFC, 0xFF, 0xE0, 0xFC,
  0x7F, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFC, 0x1F,
  0xC7, 0xE0, 0x3F, 0x3F, 0x00, 0xFC, 0xFC, 0x03, 0xF3, 0xF0, 0x0F, 0xDF,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x01, 0xF1, 0xF0, 0x0F, 0xC7, 0xE0, 0x3F, 0x1F, 0x81, 0xF8, 0x7F,
  0x07, 0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x1F, 0xF0, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x01, 0xFE,
  0x3F, 0x00, 0xFF, 0xCF, 0xC0, 0x7F, 0xFB, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFE, 0x07, 0xF0, 0x7F, 0x81, 0xF8, 0x0F, 0xE0, 0xFC, 0x01, 0xF8,
  0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x0F, 0xC1, 0xF8, 0x03,
  0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x0F, 0xC1, 0xF8,
  0x07, 0xE0, 0xFE, 0x01, 0xF8, 0x3F, 0x80, 0x7E, 0x0F, 0xC0, 0x1F, 0x83,
  0xF0, 0x07, 0xE0, 0x7E, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xFC, 0x1F, 0xC0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0x00, 0x7F, 0xEF, 0x80, 0x0F, 0xF3, 0xE0, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07,
  0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFC, 0x1F, 0xC7, 0xE0, 0x3F, 0x1F, 0x80,
  0xFC, 0xFC, 0x03, 0xF3, 0xF0, 0x0F, 0xCF, 0xC0, 0x3F, 0x7F, 0xFF, 0xFD,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFD, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x30, 0x7F, 0x01, 0xE0, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x07, 0xFC, 0x03, 0xFF, 0x01,
  0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x1F, 0xFF, 0x87, 0xFF, 0xE1,
  0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x80, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC7, 0xC0, 0x7F, 0xF7, 0xE0, 0x7F,
  0xFB, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x3F, 0x81, 0xFC, 0x1F,
  0x80, 0xFE, 0x1F, 0xC0, 0x3F, 0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0xC7,
  0xE0, 0x07, 0xE3, 0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xF8,
  0x7E, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x3F,
  0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0xFC, 0x03,
  0xF0, 0x7E, 0x03, 0xF8, 0x3F, 0x83, 0xF8, 0x1F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xDF, 0x80, 0x3F, 0xCF, 0xC0, 0x01,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x10, 0x03, 0xF8, 0x0C,
  0x03, 0xF8, 0x0F, 0x83, 0xFC, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x01,
  0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0xFF, 0x00,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F,
  0xC1, 0xFC, 0x3F, 0x01, 0xF8, 0x7E, 0x03, 0xF0, 0xFC, 0x07, 0xE3, 0xF8,
  0x0F, 0xC7, 0xE0, 0x1F, 0x8F, 0xC0, 0x3F, 0x1F, 0x80, 0x7E, 0x3F, 0x01,
  0xF8, 0x7E, 0x03, 0xF1, 0xF8, 0x07, 0xE3, 0xF0, 0x0F, 0xC7, 0xE0, 0x1F,
  0x8F, 0xC0, 0x3F, 0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF8, 0xFC, 0x03, 0xF1,
  0xF8, 0x07, 0xE3, 0xF0, 0x0F, 0xC7, 0xE0, 0x1F, 0x8F, 0xC0, 0x7F, 0x1F,
  0x80, 0xFC, 0x7E, 0x01, 0xF8, 0xFC, 0x03, 0xF0, 0x01, 0xE0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC1, 0xF8, 0x1F,
  0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFE,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0x80, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x1F, 0xF8, 0x03,
  0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x3F, 0x81, 0xF8, 0x1F, 0xC0, 0x7E, 0x0F, 0xF0, 0x1F,
  0x87, 0xF8, 0x0F, 0xC1, 0xFC, 0x03, 0xF0, 0xFE, 0x00, 0xFC, 0x7F, 0x00,
  0x3F, 0x3F, 0x80, 0x0F, 0xDF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFB, 0xF8,
  0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF,
  0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xF7, 0xE0, 0x03,
  0xF9, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF8,
  0x07, 0xE0, 0x7E, 0x01, 0xF8, 0x1F, 0x80, 0x7E, 0x07, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x03, 0xF8, 0x0F, 0xE0, 0xFC, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x81, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x3F, 0x7F, 0x81, 0xFE, 0x01, 0xFF, 0xFE, 0x3F, 0xF8, 0x0F, 0xFF, 0xFB,
  0xFF, 0xC0, 0x7F, 0xFF, 0xDF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F,
  0x83, 0xFE, 0x0F, 0xC1, 0xF8, 0x0F, 0xE0, 0x7E, 0x0F, 0xC0, 0x7F, 0x03,
  0xF8, 0x7E, 0x03, 0xF0, 0x1F, 0xC3, 0xF0, 0x1F, 0x80, 0xFE, 0x3F, 0x00,
  0xFC, 0x07, 0xE1, 0xF8, 0x07, 0xE0, 0x3F, 0x0F, 0xC0, 0x3F, 0x01, 0xF8,
  0x7E, 0x03, 0xF0, 0x0F, 0xC3, 0xF0, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0xFC,
  0x03, 0xF1, 0xF8, 0x07, 0xE0, 0x3F, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x7E,
  0x01, 0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0xFC, 0x03,
  0xF0, 0xFC, 0x07, 0xE0, 0x1F, 0x8F, 0xC0, 0x3F, 0x01, 0xF8, 0x7E, 0x01,
  0xF8, 0x0F, 0xC3, 0xF0, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x03, 0xF0,
  0xFC, 0x07, 0xE0, 0x1F, 0x8F, 0xE0, 0x3F, 0x00, 0xFC, 0x7E, 0x01, 0xF8,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xCF, 0xE0, 0x1F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC3, 0xFC, 0x3F, 0x87, 0xE0,
  0x3F, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x7F, 0x01, 0xF8, 0xFC, 0x03,
  0xF1, 0xF8, 0x07, 0xE3, 0xF0, 0x0F, 0xC7, 0xE0, 0x3F, 0x0F, 0xC0, 0x7E,
  0x3F, 0x00, 0xFC, 0x7E, 0x01, 0xF8, 0xFC, 0x03, 0xF1, 0xF8, 0x07, 0xE3,
  0xF0, 0x1F, 0x87, 0xE0, 0x3F, 0x1F, 0x80, 0x7E, 0x3F, 0x00, 0xFC, 0x7E,
  0x01, 0xF8, 0xFC, 0x03, 0xF1, 0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0x8F, 0xC0,
  0x3F, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x07,
  0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x83, 0xF0,
  0x3F, 0x0F, 0xC0, 0x7E, 0x3F, 0x80, 0x7E, 0x7E, 0x00, 0xFC, 0xFC, 0x01,
  0xF9, 0xF8, 0x03, 0xF7, 0xE0, 0x07, 0xEF, 0xC0, 0x0F, 0xDF, 0x80, 0x1F,
  0xBF, 0x00, 0x3F, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0xFD, 0xF8, 0x03, 0xF3,
  0xF0, 0x07, 0xE7, 0xE0, 0x0F, 0xCF, 0xC0, 0x3F, 0x9F, 0x80, 0x7E, 0x3F,
  0x01, 0xFC, 0x7F, 0x07, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF,
  0xFE, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xC1, 0xF8, 0x0F, 0xC0,
  0x7F, 0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x1F,
  0x80, 0x3F, 0x07, 0xE0, 0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0xFC,
  0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x07, 0xE0, 0xFC, 0x01,
  0xF8, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x0F, 0xC1, 0xFC,
  0x03, 0xF0, 0x7F, 0x01, 0xFC, 0x1F, 0xE0, 0xFE, 0x07, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0x3F, 0xF0, 0x0F, 0xC7, 0xF8,
  0x03, 0xF0, 0x30, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x1F, 0x03, 0xFF, 0x3F, 0x07, 0xFF,
  0xBF, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x1F, 0xC1, 0xFE, 0x1F, 0x80,
  0xFE, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0xFE, 0x7E, 0x00,
  0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x00,
  0xFC, 0x7E, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0xFE, 0x01, 0xF8, 0xFC, 0x01,
  0xF8, 0xFC, 0x01, 0xF8, 0xFE, 0x01, 0xF8, 0x7E, 0x03, 0xF0, 0x7E, 0x03,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xE0, 0x0F, 0xF7, 0xE0, 0x01, 0x87, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xFB, 0xF0, 0x7F, 0xFC, 0x1F,
  0xFE, 0x07, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xC0, 0x0F, 0xE0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x07, 0xFB, 0xFC, 0x7F, 0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0x01, 0xF8,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x7E, 0x03, 0xF3, 0xF0, 0x1F,
  0x9F, 0x80, 0xFC, 0xFC, 0x0F, 0xE7, 0xF9, 0xFE, 0x1F, 0xFF, 0xF0, 0x7F,
  0xFF, 0x01, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x03, 0x00, 0x00, 0x03, 0xF0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x1F, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xC0, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0x03, 0xFC, 0x07,
  0xF0, 0x02, 0x00, 0x1F, 0x80, 0x7E, 0x3F, 0x00, 0xFC, 0x7E, 0x03, 0xF1,
  0xFC, 0x07, 0xE3, 0xF0, 0x0F, 0xC7, 0xE0, 0x1F, 0x8F, 0xC0, 0x3F, 0x1F,
  0x80, 0x7E, 0x3F, 0x01, 0xF8, 0x7E, 0x03, 0xF1, 0xF8, 0x07, 0xE3, 0xF0,
  0x0F, 0xC7, 0xE0, 0x1F, 0x8F, 0xC0, 0x3F, 0x1F, 0x80, 0xFC, 0x3F, 0x01,
  0xF8, 0xFC, 0x03, 0xF1, 0xF8, 0x07, 0xE3, 0xF0, 0x0F, 0xC7, 0xE0, 0x3F,
  0x8F, 0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x3F, 0x03, 0xF8, 0x7F, 0x0F, 0xF0,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x01,
  0xFE, 0xFC, 0x00, 0x40, 0x00, 0x00, 0xFC, 0x01, 0xFF, 0xE0, 0x1F, 0xBF,
  0x00, 0xFD, 0xF8, 0x0F, 0xEF, 0xC0, 0x7E, 0x3E, 0x03, 0xF1, 0xF0, 0x3F,
  0x0F, 0xC1, 0xF8, 0x7E, 0x0F, 0x83, 0xF0, 0xFC, 0x1F, 0x87, 0xE0, 0xFC,
  0x7E, 0x07, 0xE3, 0xF0, 0x1F, 0x1F, 0x00, 0xF9, 0xF8, 0x07, 0xCF, 0xC0,
  0x3E, 0x7C, 0x01, 0xF7, 0xE0, 0x0F, 0xBE, 0x00, 0x7D, 0xF0, 0x03, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x07, 0xC0, 0x3F, 0xFC, 0x07, 0xC0, 0x7E, 0xFC, 0x07, 0xC0, 0x7E, 0xFC,
  0x0F, 0xC0, 0x7C, 0x7C, 0x0F, 0xC0, 0xFC, 0x7C, 0x1F, 0xC0, 0xFC, 0x7C,
  0x1F, 0xE0, 0xF8, 0x7C, 0x1F, 0xE1, 0xF8, 0x7C, 0x3F, 0xE1, 0xF8, 0x7C,
  0x3F, 0xE3, 0xF0, 0x7C, 0x7F, 0xE3, 0xF0, 0x7C, 0x7F, 0xE3, 0xE0, 0x7C,
  0x7B, 0xE7, 0xE0, 0x7C, 0xFB, 0xE7, 0xE0, 0x7C, 0xF9, 0xE7, 0xC0, 0x7D,
  0xF1, 0xEF, 0xC0, 0x7D, 0xF1, 0xEF, 0x80, 0x7F, 0xE1, 0xEF, 0x80, 0x7F,
  0xE1, 0xFF, 0x80, 0x7F, 0xC1, 0xFF, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x7F,
  0xC1, 0xFE, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x7F,
  0x01, 0xFC, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x3E,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0xFC,
  0x07, 0xE0, 0x3F, 0x03, 0xF8, 0x07, 0xE1, 0xFC, 0x01, 0xF8, 0x7E, 0x00,
  0x7E, 0x3F, 0x80, 0x0F, 0x8F, 0xC0, 0x03, 0xF7, 0xF0, 0x00, 0xFD, 0xF8,
  0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x80,
  0x03, 0xF7, 0xE0, 0x01, 0xFC, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x0F,
  0xC0, 0x1F, 0xC3, 0xF0, 0x07, 0xE0, 0x7E, 0x03, 0xF8, 0x1F, 0x81, 0xFC,
  0x07, 0xE0, 0x7F, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x1F, 0xC1, 0xF8, 0x07,
  0xF0, 0x7E, 0x01, 0xF8, 0x1F, 0x80, 0xFE, 0x07, 0xE0, 0x3F, 0x00, 0xFC,
  0x1F, 0xC0, 0x3F, 0x07, 0xE0, 0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0xFC, 0x00,
  0xFC, 0x3F, 0x00, 0x3F, 0x1F, 0xC0, 0x0F, 0xC7, 0xE0, 0x03, 0xF1, 0xF8,
  0x00, 0xFC, 0xFC, 0x00, 0x1F, 0x3F, 0x00, 0x07, 0xDF, 0x80, 0x01, 0xF7,
  0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x00, 0x01, 0x00, 0x03, 0xC0,
  0x03, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0xFF, 0x00, 0x7F, 0x00,
  0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xE0, 0x00, 0x10, 0x00, 0x01, 0xE0,
  0x3C, 0x07, 0x81, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0xF8,
  0x1F, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x81, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x07, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x03, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x3E, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x1F, 0x03, 0xE0, 0x78, 0x0F, 0x00,
  0x00, 0x80, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0,
  0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00,
  0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3C, 0x00,
  0x08, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xFE, 0x01, 0xF1, 0xFF, 0xC0,
  0x78, 0xFF, 0xF8, 0x1E, 0x3F, 0xFE, 0x0F, 0x9F, 0x9F, 0xE7, 0xE7, 0xC1,
  0xFF, 0xF1, 0xF0, 0x7F, 0xFC, 0xF8, 0x0F, 0xFE, 0x3E, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0x00,
};

const GFXglyph RobotoCondensed_MediumItalic54pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 13, 39, 13, 1, -38 },
  { 65, 15, 14, 17, 4, -41 },
  { 92, 27, 38, 28, 2, -38 },
  { 221, 23, 51, 26, 2, -45 },
  { 368, 25, 40, 33, 5, -39 },
  { 493, 26, 40, 29, 1, -39 },
  { 623, 7, 14, 9, 4, -41 },
  { 636, 16, 55, 17, 3, -43 },
  { 746, 16, 55, 17, -2, -43 },
  { 856, 22, 23, 23, 3, -38 },
  { 920, 22, 28, 25, 2, -32 },
  { 997, 10, 15, 12, -3, -6 },
  { 1016, 12, 5, 16, 2, -19 },
  { 1024, 8, 8, 15, 1, -7 },
  { 1032, 24, 41, 18, -3, -38 },
  { 1155, 23, 40, 26, 2, -39 },
  { 1270, 15, 38, 26, 6, -38 },
  { 1342, 25, 39, 26, 0, -39 },
  { 1464, 24, 40, 26, 1, -39 },
  { 1584, 25, 38, 26, 0, -38 },
  { 1703, 24, 39, 26, 2, -38 },
  { 1820, 22, 39, 26, 2, -38 },
  { 1928, 24, 38, 26, 3, -38 },
  { 2042, 23, 40, 26, 2, -39 },
  { 2157, 21, 39, 26, 4, -39 },
  { 2260, 11, 30, 14, 1, -29 },
  { 2302, 15, 38, 12, -3, -29 },
  { 2374, 21, 25, 23, 1, -29 },
  { 2440, 22, 16, 26, 2, -26 },
  { 2484, 22, 25, 24, 1, -29 },
  { 2553, 19, 40, 23, 4, -39 },
  { 2648, 37, 50, 40, 1, -38 },
  { 2880, 29, 38, 31, -2, -38 },
  { 3018, 27, 38, 29, 1, -38 },
  { 3147, 28, 40, 30, 2, -39 },
  { 3287, 27, 38, 30, 1, -38 },
  { 3416, 27, 38, 26, 1, -38 },
  { 3545, 26, 38, 25, 1, -38 },
  { 3669, 28, 40, 31, 2, -39 },
  { 3809, 32, 38, 32, 1, -38 },
  { 3961, 13, 38, 14, 1, -38 },
  { 4023, 26, 39, 26, 0, -38 },
  { 4150, 31, 38, 29, 1, -38 },
  { 4298, 21, 38, 25, 1, -38 },
  { 4398, 39, 38, 40, 1, -38 },
  { 4584, 32, 38, 32, 1, -38 },
  { 4736, 28, 40, 32, 2, -39 },
  { 4876, 29, 38, 29, 1, -38 },
  { 5014, 28, 46, 32, 2, -39 },
  { 5175, 27, 38, 28, 1, -38 },
  { 5304, 27, 40, 28, 1, -39 },
  { 5439, 26, 38, 28, 4, -38 },
  { 5563, 29, 39, 30, 2, -38 },
  { 5705, 29, 38, 30, 4, -38 },
  { 5843, 37, 38, 40, 5, -38 },
  { 6019, 32, 38, 29, -1, -38 },
  { 6171, 26, 38, 28, 5, -38 },
  { 6295, 30, 38, 28, -1, -38 },
  { 6438, 18, 53, 14, -1, -44 },
  { 6558, 11, 41, 20, 5, -38 },
  { 6615, 18, 53, 14, -3, -44 },
  { 6735, 17, 19, 20, 2, -38 },
  { 6776, 21, 5, 21, -3, 0 },
  { 6790, 11, 8, 17, 5, -41 },
  { 6801, 22, 31, 25, 1, -30 },
  { 6887, 24, 42, 26, 0, -41 },
  { 7013, 22, 31, 24, 1, -30 },
  { 7099, 26, 42, 26, 1, -41 },
  { 7236, 22, 31, 25, 1, -30 },
  { 7322, 18, 42, 17, 2, -42 },
  { 7417, 25, 41, 26, 0, -30 },
  { 7546, 23, 41, 26, 0, -41 },
  { 7664, 12, 40, 13, 1, -40 },
  { 7724, 19, 51, 12, -6, -40 },
  { 7846, 26, 41, 24, 0, -41 },
  { 7980, 13, 41, 13, 1, -41 },
  { 8047, 37, 30, 39, 0, -30 },
  { 8186, 23, 30, 26, 0, -30 },
  { 8273, 23, 31, 26, 1, -30 },
  { 8363, 26, 41, 26, -2, -30 },
  { 8497, 24, 41, 26, 1, -30 },
  { 8620, 18, 30, 17, 0, -30 },
  { 8688, 21, 31, 24, 1, -30 },
  { 8770, 14, 37, 16, 2, -36 },
  { 8835, 23, 30, 26, 2, -29 },
  { 8922, 21, 29, 23, 3, -29 },
  { 8999, 32, 29, 34, 3, -29 },
  { 9115, 26, 29, 23, -2, -29 },
  { 9210, 26, 40, 23, -2, -29 },
  { 9340, 24, 29, 23, -1, -29 },
  { 9427, 17, 52, 16, 1, -42 },
  { 9538, 11, 45, 13, 1, -38 },
  { 9600, 17, 52, 16, -2, -42 },
  { 9711, 26, 11, 30, 2, -21 },
};

const GFXfont RobotoCondensed_MediumItalic54pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_MediumItalic54pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_MediumItalic54pt7bGlyphs,
  0x20, 0x7E, 63
};

#endif // _ROBOTOCONDENSED_MEDIUMITALIC54PT7B_H_
