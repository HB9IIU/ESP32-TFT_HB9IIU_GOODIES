#ifndef _ROBOTOCONDENSED_MEDIUMITALIC23PT7B_H_
#define _ROBOTOCONDENSED_MEDIUMITALIC23PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-MediumItalic.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_MediumItalic23pt7bBitmaps[] PROGMEM = {
  0x00, 0x39, 0xCC, 0x63, 0x39, 0xCE, 0x63, 0x18, 0xC0, 0x03, 0x18, 0xC0,
  0x6F, 0x3C, 0xB6, 0xDA, 0x60, 0x06, 0x60, 0xC8, 0x1B, 0x06, 0x60, 0xC8,
  0x7F, 0xDF, 0xF8, 0xCC, 0x1B, 0x02, 0x63, 0xFE, 0x7F, 0xC2, 0x60, 0xCC,
  0x19, 0x02, 0x60, 0xCC, 0x00, 0x03, 0x00, 0x80, 0xF0, 0x7E, 0x39, 0x8C,
  0x77, 0x1D, 0xC0, 0x30, 0x0F, 0x01, 0xE0, 0x3C, 0x03, 0x00, 0xEC, 0x3B,
  0x0C, 0xE7, 0x1F, 0x83, 0xC0, 0x40, 0x10, 0x00, 0x38, 0x0F, 0x83, 0x31,
  0x66, 0x6C, 0xD9, 0x9A, 0x3E, 0xC3, 0xB0, 0x0C, 0x01, 0xF8, 0x6F, 0x1B,
  0x33, 0x66, 0xCC, 0xF1, 0x90, 0x3E, 0x03, 0x80, 0x07, 0x80, 0xFC, 0x1D,
  0xC1, 0x8C, 0x18, 0xC1, 0x98, 0x1F, 0x80, 0xF0, 0x1E, 0x03, 0xE6, 0x77,
  0x66, 0x36, 0x63, 0xE6, 0x1C, 0x73, 0xC7, 0xFC, 0x1E, 0xE0, 0xDB, 0x6D,
  0x00, 0x02, 0x0C, 0x30, 0xC1, 0x86, 0x0C, 0x38, 0x60, 0xC1, 0x87, 0x0E,
  0x18, 0x30, 0x60, 0xC1, 0x81, 0x03, 0x06, 0x06, 0x04, 0x00, 0x10, 0x30,
  0x30, 0x60, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x70, 0xE1, 0x83, 0x06,
  0x18, 0x30, 0xE1, 0x86, 0x18, 0x20, 0x00, 0x06, 0x01, 0x00, 0xC1, 0xB6,
  0xFF, 0x87, 0x83, 0xC0, 0xD8, 0x66, 0x00, 0x80, 0x0E, 0x07, 0x03, 0x01,
  0x80, 0xC7, 0xFF, 0xFE, 0x38, 0x18, 0x0C, 0x06, 0x07, 0x00, 0x37, 0x76,
  0xEC, 0xFF, 0xC0, 0xDF, 0x00, 0x00, 0xC0, 0x60, 0x18, 0x0C, 0x03, 0x01,
  0x80, 0x60, 0x38, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x06, 0x01,
  0x80, 0xC0, 0x30, 0x00, 0x0F, 0x07, 0xE3, 0x98, 0xC7, 0x71, 0xD8, 0x76,
  0x1D, 0x86, 0xE1, 0xB8, 0x6E, 0x3B, 0x8E, 0xE3, 0x38, 0xCE, 0x71, 0xF8,
  0x3C, 0x00, 0x0C, 0xFF, 0xFE, 0x18, 0x63, 0x8E, 0x38, 0xE3, 0x0C, 0x71,
  0xC7, 0x1C, 0x60, 0x07, 0x83, 0xF8, 0xE7, 0x1C, 0x73, 0x0E, 0x01, 0x80,
  0x70, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0F, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0xFC, 0xFF, 0x80, 0x0F, 0x83, 0xF8, 0xE7, 0x1C, 0x70, 0x0E, 0x01, 0x80,
  0x70, 0x7C, 0x0F, 0x00, 0x30, 0x06, 0x00, 0xEE, 0x18, 0xC3, 0x1C, 0xE3,
  0xF8, 0x1E, 0x00, 0x00, 0xC0, 0x38, 0x0F, 0x01, 0xE0, 0x7C, 0x1B, 0x83,
  0x60, 0xCC, 0x39, 0x86, 0x71, 0x8E, 0x7F, 0xEF, 0xFC, 0x06, 0x00, 0xC0,
  0x38, 0x07, 0x00, 0x1F, 0xC7, 0xF3, 0x80, 0xC0, 0x30, 0x0C, 0x07, 0xE1,
  0xFC, 0x73, 0x80, 0xE0, 0x38, 0x0E, 0xC3, 0xB8, 0xEE, 0x71, 0xF8, 0x3C,
  0x00, 0x03, 0x87, 0xC7, 0x87, 0x03, 0x03, 0x81, 0xB8, 0xFE, 0xF3, 0xF1,
  0xF8, 0xFC, 0x7E, 0x3F, 0x1D, 0x9C, 0xFC, 0x3C, 0x00, 0x7F, 0xEF, 0xF8,
  0x07, 0x00, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x70,
  0x0E, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x80, 0xE0, 0x00, 0x0F, 0x07, 0xE3,
  0x98, 0xC7, 0x71, 0xDC, 0x63, 0x38, 0xFC, 0x3E, 0x18, 0xCE, 0x33, 0x0E,
  0xC3, 0xB0, 0xCE, 0x71, 0xF8, 0x3C, 0x00, 0x1E, 0x7F, 0x77, 0xE3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xE7, 0xFF, 0x7F, 0x06, 0x0E, 0x0C, 0x3C, 0xF8, 0xE0,
  0x37, 0x30, 0x00, 0x00, 0x00, 0xCE, 0xC0, 0x1C, 0x71, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x0C, 0x71, 0x8E, 0x30, 0x01, 0x07, 0x1F, 0x7C, 0xF0,
  0xE0, 0xF8, 0x3E, 0x0E, 0x02, 0x7F, 0xBF, 0xC0, 0x00, 0x00, 0x07, 0xFB,
  0xFC, 0x40, 0x38, 0x1F, 0x03, 0xE0, 0x78, 0x78, 0xF9, 0xF0, 0xE0, 0x40,
  0x00, 0x3C, 0x7E, 0xE7, 0xC7, 0x07, 0x07, 0x0E, 0x1C, 0x38, 0x30, 0x70,
  0x70, 0x00, 0x00, 0x60, 0xE0, 0x60, 0x01, 0xF0, 0x0F, 0xF0, 0x30, 0x30,
  0xC0, 0x33, 0x00, 0x64, 0x3C, 0x58, 0xFC, 0xB3, 0x31, 0xC6, 0x63, 0x98,
  0xCF, 0x31, 0x1C, 0x66, 0x38, 0xCC, 0x51, 0x99, 0xA3, 0xFE, 0x47, 0x38,
  0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0xFC, 0x01, 0xF0, 0x00, 0x00, 0xC0,
  0x0F, 0x00, 0x78, 0x07, 0xC0, 0x36, 0x03, 0xB0, 0x19, 0x80, 0xCC, 0x0E,
  0x60, 0x63, 0x87, 0x1C, 0x3F, 0xE3, 0xFF, 0x18, 0x19, 0xC0, 0xCE, 0x06,
  0xE0, 0x38, 0x1F, 0xC1, 0xFE, 0x18, 0xF1, 0x87, 0x38, 0x73, 0x87, 0x38,
  0xE3, 0xFC, 0x3F, 0xC3, 0x0E, 0x70, 0xE7, 0x0E, 0x70, 0xE7, 0x0E, 0x61,
  0xC7, 0xF8, 0xFF, 0x00, 0x07, 0x81, 0xFC, 0x3C, 0xE3, 0x06, 0x70, 0x77,
  0x07, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x0C, 0xE0, 0xCE,
  0x1C, 0x73, 0x87, 0xF8, 0x3E, 0x00, 0x1F, 0x81, 0xFE, 0x18, 0xE1, 0x87,
  0x38, 0x73, 0x87, 0x38, 0x73, 0x87, 0x30, 0x73, 0x07, 0x70, 0x67, 0x06,
  0x70, 0xE7, 0x1C, 0x63, 0xC7, 0xF8, 0xFE, 0x00, 0x1F, 0xF1, 0xFF, 0x18,
  0x01, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0xFC, 0x3F, 0xC3, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x07, 0xF8, 0xFF, 0x80, 0x1F, 0xF1,
  0xFE, 0x18, 0x01, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x3F, 0xC3,
  0xF8, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x00,
  0x07, 0xC1, 0xFE, 0x3C, 0xE3, 0x07, 0x70, 0x77, 0x00, 0x60, 0x06, 0x00,
  0xE3, 0xEE, 0x3E, 0xE0, 0xEE, 0x0E, 0xE0, 0xCE, 0x0C, 0x73, 0xC7, 0xF8,
  0x1F, 0x00, 0x1C, 0x1C, 0x70, 0x71, 0x81, 0xC6, 0x06, 0x38, 0x18, 0xE0,
  0xE3, 0x83, 0x8F, 0xFE, 0x3F, 0xF8, 0xC0, 0xC7, 0x03, 0x1C, 0x1C, 0x70,
  0x71, 0xC1, 0xC6, 0x07, 0x18, 0x18, 0xE0, 0x60, 0x1C, 0x71, 0xC6, 0x18,
  0xE3, 0x8E, 0x30, 0xC3, 0x1C, 0x71, 0xC6, 0x18, 0x60, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x06,
  0x00, 0xCE, 0x39, 0xC7, 0x3D, 0xC3, 0xF8, 0x3C, 0x00, 0x1C, 0x38, 0x71,
  0xE1, 0x87, 0x06, 0x38, 0x39, 0xC0, 0xEE, 0x03, 0xF8, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x07, 0xB8, 0x1C, 0xE0, 0x71, 0x81, 0xC7, 0x06, 0x1C, 0x18,
  0x38, 0xE0, 0xE0, 0x1C, 0x0E, 0x06, 0x03, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x30, 0x18, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0x80, 0xFF, 0xFF, 0x80, 0x1E,
  0x07, 0x8F, 0x03, 0xC7, 0x83, 0xE3, 0xC1, 0xE3, 0xE0, 0xF1, 0xF0, 0xF8,
  0xF8, 0x6C, 0x6C, 0x7E, 0x36, 0x37, 0x1B, 0xBB, 0x1C, 0xD9, 0x8E, 0x6D,
  0xC7, 0x3C, 0xE3, 0x9E, 0x71, 0x8E, 0x38, 0xC7, 0x18, 0xE3, 0x0C, 0x00,
  0x1C, 0x1C, 0x70, 0x71, 0xC1, 0xC7, 0x86, 0x3E, 0x18, 0xF8, 0xE3, 0xF3,
  0x8E, 0xCE, 0x33, 0x38, 0xCC, 0xC7, 0x1B, 0x1C, 0x7C, 0x71, 0xF1, 0xC7,
  0xC6, 0x0E, 0x18, 0x38, 0xE0, 0xE0, 0x07, 0x81, 0xFE, 0x3C, 0xE3, 0x87,
  0x70, 0x77, 0x07, 0x60, 0x76, 0x07, 0xE0, 0x6E, 0x06, 0xE0, 0x6E, 0x0E,
  0xE0, 0xEE, 0x1C, 0x73, 0xC7, 0xF8, 0x1E, 0x00, 0x1F, 0xC0, 0xFF, 0x06,
  0x1C, 0x30, 0x63, 0x83, 0x1C, 0x18, 0xE0, 0xC7, 0x0E, 0x30, 0xF1, 0xFF,
  0x1F, 0xE0, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x00,
  0x07, 0x81, 0xFE, 0x3C, 0xE3, 0x06, 0x70, 0x77, 0x07, 0x60, 0x76, 0x07,
  0xE0, 0x6E, 0x06, 0xE0, 0x6E, 0x0E, 0xE0, 0xEE, 0x1C, 0x73, 0xC7, 0xF8,
  0x1F, 0x00, 0x38, 0x01, 0xC0, 0x08, 0x1F, 0xC1, 0xFE, 0x18, 0x71, 0x87,
  0x38, 0x73, 0x87, 0x38, 0x73, 0x8E, 0x3F, 0xC3, 0xF8, 0x73, 0x87, 0x18,
  0x71, 0xC7, 0x1C, 0x61, 0xC6, 0x1C, 0xE0, 0xE0, 0x07, 0xC0, 0xFE, 0x1C,
  0xE3, 0x87, 0x38, 0x73, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x01,
  0xC0, 0x0E, 0x60, 0xE6, 0x0C, 0x71, 0xC3, 0xF8, 0x1F, 0x00, 0xFF, 0xFF,
  0xFC, 0x38, 0x06, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x00,
  0x60, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x00, 0x38, 0x73,
  0x07, 0x30, 0x77, 0x06, 0x70, 0x67, 0x06, 0x70, 0xE6, 0x0E, 0x60, 0xEE,
  0x0E, 0xE0, 0xCE, 0x0C, 0xE1, 0xCE, 0x1C, 0xF3, 0x87, 0xF0, 0x3E, 0x00,
  0xE0, 0x7E, 0x0E, 0xE0, 0xEE, 0x0C, 0xE1, 0xC6, 0x1C, 0x63, 0x86, 0x38,
  0x63, 0x07, 0x70, 0x76, 0x07, 0xE0, 0x7E, 0x03, 0xC0, 0x3C, 0x03, 0x80,
  0x38, 0x00, 0xE1, 0x87, 0xE3, 0x86, 0xE3, 0x8E, 0xE3, 0x8E, 0xE7, 0x8C,
  0xE7, 0x8C, 0xE7, 0x9C, 0xED, 0x98, 0xED, 0x98, 0xED, 0xB8, 0xF9, 0xB0,
  0xF8, 0xF0, 0xF8, 0xF0, 0xF0, 0xE0, 0x70, 0xE0, 0x70, 0xE0, 0x60, 0xC0,
  0x1C, 0x1C, 0x38, 0xE0, 0xE3, 0x83, 0x9C, 0x06, 0x70, 0x1F, 0x80, 0x7C,
  0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0xFC, 0x03, 0xF0, 0x1C, 0xC0, 0x73,
  0x83, 0x8E, 0x1C, 0x38, 0x70, 0x70, 0xE0, 0xFC, 0x1D, 0x87, 0x30, 0xC7,
  0x38, 0xE6, 0x0D, 0xC1, 0xF0, 0x3E, 0x07, 0x80, 0x60, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0x80, 0x30, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x70, 0x0E,
  0x01, 0xC0, 0x1C, 0x03, 0x80, 0x70, 0x07, 0x00, 0xE0, 0x1C, 0x01, 0x80,
  0x38, 0x07, 0x00, 0xE0, 0x0F, 0xFC, 0xFF, 0xC0, 0x1E, 0x3C, 0x60, 0xC1,
  0x87, 0x0E, 0x1C, 0x30, 0x60, 0xC3, 0x87, 0x0E, 0x1C, 0x30, 0x60, 0xC3,
  0x87, 0x0E, 0x1E, 0x3C, 0x00, 0xE7, 0x38, 0xC6, 0x31, 0x8E, 0x73, 0x9C,
  0x63, 0x18, 0xC7, 0x39, 0xC0, 0x1E, 0x3C, 0x38, 0x70, 0xE1, 0x83, 0x06,
  0x1C, 0x38, 0x70, 0xC1, 0x83, 0x0E, 0x1C, 0x38, 0x70, 0xC1, 0x83, 0x1E,
  0x3C, 0x00, 0x0C, 0x38, 0x71, 0xA3, 0x6C, 0xD9, 0xE3, 0xFF, 0x7F, 0x80,
  0x61, 0x8C, 0x0F, 0x07, 0xE3, 0x9C, 0xC7, 0x01, 0x87, 0xE7, 0xF9, 0xCE,
  0xE3, 0xB9, 0xE7, 0xF0, 0xEE, 0x1C, 0x06, 0x01, 0x80, 0x60, 0x38, 0x0E,
  0x03, 0xF8, 0xFF, 0x39, 0xCC, 0x37, 0x0D, 0xC3, 0x71, 0xD8, 0x76, 0x1D,
  0xCE, 0xFF, 0xBB, 0xC0, 0x1E, 0x1F, 0x9C, 0xDC, 0x7E, 0x3E, 0x03, 0x01,
  0x80, 0xC3, 0x73, 0xBF, 0x8F, 0x80, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xE0,
  0x1C, 0x03, 0x8F, 0x63, 0xFC, 0x73, 0x9C, 0x73, 0x8E, 0x61, 0xCC, 0x31,
  0x86, 0x30, 0xC7, 0x38, 0xFF, 0x0F, 0xE0, 0x1E, 0x1F, 0x9C, 0xFC, 0x7E,
  0x3F, 0xFF, 0xFF, 0x80, 0xC0, 0x71, 0x1F, 0xC7, 0x80, 0x0F, 0x1F, 0x1C,
  0x38, 0x38, 0x38, 0xFC, 0xFC, 0x70, 0x70, 0x70, 0x70, 0x60, 0x60, 0xE0,
  0xE0, 0xE0, 0xE0, 0x1E, 0xE7, 0xFC, 0xE7, 0x38, 0x67, 0x1C, 0xC3, 0x98,
  0x73, 0x0E, 0x61, 0x8E, 0x71, 0xFE, 0x1F, 0xC0, 0x38, 0x06, 0x11, 0xC7,
  0xF0, 0x7C, 0x00, 0x1C, 0x06, 0x01, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0xF8,
  0xFE, 0x39, 0xDC, 0x77, 0x1D, 0xC7, 0x71, 0x98, 0x66, 0x1B, 0x8E, 0xE3,
  0xB8, 0xE0, 0x18, 0x71, 0x80, 0x00, 0xE3, 0x8C, 0x30, 0xC7, 0x1C, 0x71,
  0x86, 0x18, 0xE0, 0x06, 0x06, 0x06, 0x00, 0x00, 0x0E, 0x0E, 0x0C, 0x0C,
  0x0C, 0x1C, 0x1C, 0x1C, 0x18, 0x18, 0x18, 0x38, 0x38, 0x38, 0x70, 0xF0,
  0xE0, 0x1C, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x80, 0x70, 0x0E, 0x79, 0x9E,
  0x33, 0x86, 0xE1, 0xF8, 0x3F, 0x07, 0xE0, 0xEC, 0x19, 0xC3, 0x38, 0xE3,
  0x1C, 0x70, 0x1C, 0x71, 0x86, 0x38, 0xE3, 0x8E, 0x30, 0xC7, 0x1C, 0x71,
  0xC6, 0x18, 0xE3, 0x80, 0x3F, 0x9C, 0x3F, 0xFE, 0x39, 0xE7, 0x31, 0xC7,
  0x71, 0xC6, 0x71, 0xC6, 0x71, 0x86, 0x61, 0x8E, 0x63, 0x8E, 0x63, 0x8E,
  0xE3, 0x8C, 0xE3, 0x8C, 0x3F, 0x8F, 0xF3, 0x9C, 0xC7, 0x71, 0xDC, 0x77,
  0x19, 0x86, 0x61, 0x98, 0xEE, 0x3B, 0x8E, 0x1E, 0x1F, 0x9C, 0xFC, 0x3E,
  0x1E, 0x0F, 0x07, 0x87, 0xC3, 0xF3, 0x9F, 0x87, 0x80, 0x1F, 0xC3, 0xFC,
  0x73, 0x8C, 0x33, 0x86, 0x70, 0xCE, 0x39, 0x87, 0x30, 0xE7, 0x39, 0xFF,
  0x3B, 0x87, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xE0, 0x00, 0x3D, 0xDF, 0xE7,
  0x3B, 0x86, 0xE3, 0xB0, 0xEC, 0x3B, 0x0C, 0xC3, 0x39, 0xCF, 0xF1, 0xFC,
  0x07, 0x01, 0x80, 0x60, 0x38, 0x0E, 0x00, 0x3F, 0x3E, 0x3E, 0x30, 0x70,
  0x70, 0x70, 0x60, 0x60, 0x60, 0xE0, 0xE0, 0x0F, 0x0F, 0xE3, 0x18, 0xC7,
  0x38, 0x0F, 0x80, 0xF0, 0x0E, 0xE3, 0xB8, 0xC7, 0xF0, 0xF8, 0x38, 0xE3,
  0x3F, 0xFD, 0xC7, 0x1C, 0x61, 0x8E, 0x38, 0xE3, 0xC7, 0x00, 0x71, 0xD8,
  0x66, 0x19, 0x8E, 0xE3, 0xB8, 0xEE, 0x33, 0x0C, 0xC3, 0x39, 0xCF, 0xF1,
  0xFC, 0xE3, 0xF1, 0xD8, 0xCC, 0xE6, 0x63, 0x71, 0xB0, 0xD8, 0x7C, 0x3C,
  0x0E, 0x06, 0x00, 0xE3, 0x1F, 0x9C, 0x66, 0x73, 0x99, 0xCC, 0x6F, 0x31,
  0xBD, 0xC7, 0x96, 0x1E, 0x78, 0x79, 0xC1, 0xC7, 0x07, 0x1C, 0x18, 0x60,
  0x18, 0xE3, 0x98, 0x77, 0x07, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0xF8, 0x1B,
  0x07, 0x71, 0xCE, 0x38, 0xC0, 0x38, 0xE7, 0x1C, 0x63, 0x0C, 0xE1, 0x98,
  0x37, 0x06, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0x78, 0x06, 0x01, 0xC0, 0x30,
  0x0E, 0x07, 0x80, 0xE0, 0x00, 0x3F, 0xCF, 0xF0, 0x38, 0x1C, 0x06, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x18, 0x0F, 0xF3, 0xFC, 0x04, 0x1C, 0x70, 0xC3,
  0x87, 0x0C, 0x18, 0x30, 0xE3, 0x86, 0x06, 0x0C, 0x18, 0x30, 0x61, 0xC1,
  0x83, 0x07, 0x04, 0x00, 0x18, 0xC6, 0x31, 0x88, 0xC6, 0x31, 0x8C, 0x42,
  0x31, 0x8C, 0x63, 0x11, 0x80, 0x18, 0x38, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x38, 0x71, 0xC3, 0x0E, 0x1C, 0x38, 0x60, 0xC3, 0x8E, 0x18,
  0x00, 0x38, 0x6F, 0x8D, 0xBB, 0x63, 0xEC, 0x38,
};

const GFXglyph RobotoCondensed_MediumItalic23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 5, 17, 6, 1, -17 },
  { 12, 6, 6, 7, 2, -17 },
  { 17, 11, 17, 12, 1, -17 },
  { 41, 10, 21, 11, 1, -19 },
  { 68, 11, 17, 14, 2, -17 },
  { 92, 12, 17, 13, 0, -17 },
  { 118, 3, 6, 4, 2, -17 },
  { 121, 7, 23, 7, 1, -18 },
  { 142, 7, 23, 7, -1, -18 },
  { 163, 10, 10, 10, 1, -17 },
  { 176, 9, 12, 11, 1, -14 },
  { 190, 4, 6, 5, -1, -3 },
  { 193, 5, 2, 7, 1, -8 },
  { 195, 3, 3, 6, 1, -3 },
  { 197, 10, 18, 8, -1, -17 },
  { 220, 10, 17, 11, 1, -17 },
  { 242, 6, 17, 11, 3, -17 },
  { 255, 11, 17, 11, 0, -17 },
  { 279, 11, 17, 11, 0, -17 },
  { 303, 11, 17, 11, 0, -17 },
  { 327, 10, 17, 11, 1, -17 },
  { 349, 9, 17, 11, 1, -17 },
  { 369, 11, 17, 11, 1, -17 },
  { 393, 10, 17, 11, 1, -17 },
  { 415, 8, 17, 11, 2, -17 },
  { 432, 4, 13, 6, 1, -13 },
  { 439, 6, 16, 5, -1, -13 },
  { 451, 8, 10, 10, 1, -12 },
  { 461, 9, 7, 11, 1, -11 },
  { 469, 9, 10, 10, 1, -12 },
  { 481, 8, 17, 10, 2, -17 },
  { 498, 15, 21, 17, 1, -16 },
  { 538, 13, 17, 13, -1, -17 },
  { 566, 12, 17, 12, 0, -17 },
  { 592, 12, 17, 13, 1, -17 },
  { 618, 12, 17, 13, 0, -17 },
  { 644, 12, 17, 11, 0, -17 },
  { 670, 12, 17, 11, 0, -17 },
  { 696, 12, 17, 13, 1, -17 },
  { 722, 14, 17, 14, 0, -17 },
  { 752, 6, 17, 6, 0, -17 },
  { 765, 11, 17, 11, 0, -17 },
  { 789, 14, 17, 12, 0, -17 },
  { 819, 9, 17, 11, 0, -17 },
  { 839, 17, 17, 17, 0, -17 },
  { 876, 14, 17, 14, 0, -17 },
  { 906, 12, 17, 13, 1, -17 },
  { 932, 13, 17, 13, 0, -17 },
  { 960, 12, 20, 13, 1, -17 },
  { 990, 12, 17, 12, 0, -17 },
  { 1016, 12, 17, 12, 0, -17 },
  { 1042, 11, 17, 12, 2, -17 },
  { 1066, 12, 17, 13, 1, -17 },
  { 1092, 12, 17, 13, 2, -17 },
  { 1118, 16, 17, 17, 2, -17 },
  { 1152, 14, 17, 12, -1, -17 },
  { 1182, 11, 17, 12, 2, -17 },
  { 1206, 12, 17, 12, 0, -17 },
  { 1232, 7, 23, 6, 0, -19 },
  { 1253, 5, 18, 8, 2, -17 },
  { 1265, 7, 23, 6, -1, -19 },
  { 1286, 7, 8, 9, 1, -17 },
  { 1293, 9, 2, 9, -1, 0 },
  { 1296, 5, 3, 7, 2, -17 },
  { 1298, 10, 12, 11, 0, -12 },
  { 1313, 10, 18, 11, 0, -18 },
  { 1336, 9, 12, 10, 1, -12 },
  { 1350, 11, 18, 11, 1, -18 },
  { 1375, 9, 12, 11, 1, -12 },
  { 1389, 8, 18, 7, 1, -18 },
  { 1407, 11, 17, 11, 0, -12 },
  { 1431, 10, 18, 11, 0, -18 },
  { 1454, 6, 17, 5, 0, -17 },
  { 1467, 8, 22, 5, -2, -17 },
  { 1489, 11, 18, 10, 0, -18 },
  { 1514, 6, 18, 5, 0, -18 },
  { 1528, 16, 12, 17, 0, -12 },
  { 1552, 10, 12, 11, 0, -12 },
  { 1567, 9, 12, 11, 1, -12 },
  { 1581, 11, 17, 11, -1, -12 },
  { 1605, 10, 17, 11, 1, -12 },
  { 1627, 8, 12, 7, 0, -12 },
  { 1639, 10, 12, 10, 0, -12 },
  { 1654, 6, 15, 7, 1, -15 },
  { 1666, 10, 12, 11, 1, -12 },
  { 1681, 9, 12, 10, 1, -12 },
  { 1695, 14, 12, 14, 1, -12 },
  { 1716, 11, 12, 10, -1, -12 },
  { 1733, 11, 17, 10, -1, -12 },
  { 1757, 10, 12, 10, 0, -12 },
  { 1772, 7, 22, 7, 1, -18 },
  { 1792, 5, 20, 6, 0, -17 },
  { 1805, 7, 22, 7, -1, -18 },
  { 1825, 11, 5, 13, 1, -9 },
};

const GFXfont RobotoCondensed_MediumItalic23pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_MediumItalic23pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_MediumItalic23pt7bGlyphs,
  0x20, 0x7E, 27
};

#endif // _ROBOTOCONDENSED_MEDIUMITALIC23PT7B_H_
