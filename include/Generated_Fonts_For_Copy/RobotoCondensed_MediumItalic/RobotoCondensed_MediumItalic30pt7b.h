#ifndef _ROBOTOCONDENSED_MEDIUMITALIC30PT7B_H_
#define _ROBOTOCONDENSED_MEDIUMITALIC30PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-MediumItalic.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_MediumItalic30pt7bBitmaps[] PROGMEM = {
  0x00, 0x1E, 0x38, 0x70, 0xE3, 0xC7, 0x8E, 0x1C, 0x38, 0x70, 0xE3, 0x87,
  0x0E, 0x1C, 0x00, 0x00, 0x03, 0x87, 0x0E, 0x1C, 0x00, 0x73, 0x73, 0x77,
  0x67, 0x66, 0x66, 0x66, 0xC6, 0x01, 0xCC, 0x03, 0x18, 0x06, 0x70, 0x1C,
  0xC0, 0x31, 0x80, 0x67, 0x00, 0xCC, 0x1F, 0xFF, 0x3F, 0xFE, 0x0C, 0xE0,
  0x39, 0x80, 0x63, 0x00, 0xCE, 0x1F, 0xFF, 0x3F, 0xFE, 0x0C, 0xE0, 0x39,
  0x80, 0x63, 0x00, 0xCE, 0x03, 0x98, 0x06, 0x30, 0x0C, 0xE0, 0x00, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x07, 0x80, 0xFF, 0x0F, 0xF8, 0x79, 0xE7, 0x87,
  0x3C, 0x39, 0xC1, 0xCF, 0x00, 0x78, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x00, 0xE0, 0x07, 0xB8, 0x3D, 0xC1, 0xEF, 0x0E, 0x78, 0xF1, 0xFF,
  0x07, 0xF0, 0x1F, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x3C, 0x01, 0xF8,
  0x0E, 0x61, 0x31, 0x86, 0xC6, 0x33, 0x19, 0xCC, 0x66, 0x33, 0xB0, 0xFD,
  0xC1, 0xEE, 0x00, 0x30, 0x01, 0xC0, 0x0E, 0xF0, 0x37, 0xE1, 0xD9, 0x8E,
  0xE7, 0x33, 0x1D, 0x8C, 0x7E, 0x31, 0x90, 0xEE, 0x01, 0xF0, 0x03, 0x80,
  0x03, 0xC0, 0x3F, 0x80, 0xFF, 0x07, 0x9C, 0x1C, 0x70, 0x71, 0xC1, 0xCF,
  0x07, 0x78, 0x1F, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0xC0, 0x7F, 0x9D, 0xCE,
  0x7F, 0x3F, 0xF8, 0x7E, 0xE1, 0xFB, 0x83, 0xCF, 0x0F, 0x3F, 0xFC, 0x7F,
  0xF8, 0x7C, 0xE0, 0x77, 0x76, 0x6E, 0xEE, 0x00, 0x80, 0x60, 0x38, 0x1C,
  0x0E, 0x03, 0x81, 0xC0, 0x70, 0x18, 0x0E, 0x03, 0x80, 0xE0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x0E, 0x03, 0x80, 0xE0, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x1C, 0x07, 0x00, 0xC0, 0x38, 0x06, 0x00, 0x80, 0x08, 0x06,
  0x03, 0x80, 0xC0, 0x70, 0x38, 0x0C, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x0F, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0xE0, 0x70, 0x38,
  0x38, 0x1C, 0x1C, 0x0E, 0x0E, 0x0E, 0x06, 0x02, 0x00, 0x07, 0x00, 0x70,
  0x06, 0x00, 0x60, 0xE6, 0x7F, 0xFF, 0x3F, 0xC1, 0xE0, 0x3F, 0x03, 0xB0,
  0x73, 0x8E, 0x38, 0x01, 0x00, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00,
  0x70, 0x03, 0x83, 0xFF, 0xDF, 0xFE, 0xFF, 0xF0, 0x78, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x78, 0x00, 0x1C, 0x71, 0xCE, 0x39, 0xC7, 0x18,
  0xFF, 0xFF, 0xF8, 0xEF, 0xFE, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x1C,
  0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x38,
  0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x70,
  0x01, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x03,
  0xC0, 0x7F, 0x87, 0xFC, 0x38, 0xE3, 0xC3, 0x9C, 0x1C, 0xE0, 0xEF, 0x07,
  0x78, 0x7B, 0x83, 0xDC, 0x1C, 0xE0, 0xE7, 0x07, 0x78, 0x3B, 0xC1, 0xDE,
  0x1E, 0xF0, 0xE3, 0x87, 0x1C, 0x70, 0xFF, 0x83, 0xF8, 0x0F, 0x80, 0x01,
  0x83, 0xCF, 0xCF, 0xE7, 0xF2, 0x38, 0x3C, 0x1E, 0x0E, 0x07, 0x03, 0x81,
  0xC1, 0xE0, 0xF0, 0x70, 0x38, 0x1C, 0x0E, 0x0F, 0x07, 0x83, 0x81, 0xC0,
  0x03, 0xE0, 0x1F, 0xE0, 0xFF, 0x87, 0x8F, 0x1C, 0x3C, 0xF0, 0xF3, 0xC3,
  0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3F, 0xFC, 0xFF,
  0xF3, 0xFF, 0xC0, 0x07, 0xC0, 0x7F, 0x07, 0xFC, 0x78, 0xF3, 0x87, 0x9C,
  0x3C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x7F, 0x03, 0xF0, 0x1F, 0x80, 0x1E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0xE0, 0xE7, 0x07, 0x3C, 0x79, 0xFF, 0x87,
  0xF8, 0x1F, 0x00, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x01, 0xF8,
  0x07, 0xE0, 0x3F, 0x81, 0xDE, 0x07, 0x70, 0x39, 0xC1, 0xC7, 0x07, 0x3C,
  0x38, 0xF1, 0xE3, 0xC7, 0xFF, 0xBF, 0xFE, 0xFF, 0xF8, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x0F, 0xFC, 0x3F, 0xE1, 0xFF, 0x87,
  0x00, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0xF0, 0x3F, 0xE0, 0xFF, 0x83,
  0x8F, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0xE0, 0xF3,
  0xC3, 0x87, 0x1E, 0x1F, 0xF0, 0x3F, 0x80, 0x7C, 0x00, 0x00, 0xF0, 0x3E,
  0x07, 0xE0, 0xF0, 0x1E, 0x01, 0xC0, 0x3C, 0x03, 0xBC, 0x7F, 0xE7, 0xFE,
  0x78, 0xF7, 0x07, 0x70, 0x77, 0x07, 0xF0, 0x7F, 0x07, 0x70, 0xF7, 0x0E,
  0x71, 0xE7, 0xFC, 0x3F, 0x81, 0xF0, 0x7F, 0xFB, 0xFF, 0xDF, 0xFE, 0x00,
  0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1C, 0x01, 0xE0,
  0x0E, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x1E,
  0x00, 0xE0, 0x0F, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x7F, 0x87, 0xFC, 0x38,
  0xF3, 0xC7, 0x9E, 0x1C, 0xE1, 0xE7, 0x0F, 0x3C, 0x70, 0xFF, 0x07, 0xF0,
  0x7F, 0x87, 0x9E, 0x38, 0x73, 0xC3, 0x9C, 0x1C, 0xE0, 0xE7, 0x07, 0x3C,
  0x78, 0xFF, 0x87, 0xF8, 0x0F, 0x80, 0x0F, 0x81, 0xFC, 0x3F, 0xE7, 0x8E,
  0x70, 0xE7, 0x0F, 0xF0, 0xFF, 0x0F, 0xE0, 0xFF, 0x0E, 0xF0, 0xEF, 0x1E,
  0x7F, 0xE7, 0xFE, 0x3D, 0xC0, 0x1C, 0x03, 0x80, 0x78, 0x0F, 0x07, 0xE0,
  0x7C, 0x07, 0x00, 0x18, 0xF3, 0xCE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xE3, 0xCF, 0x38, 0x0E, 0x0E, 0x0E, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x38, 0x38, 0x38, 0x70, 0x70, 0xE0, 0x40,
  0x00, 0x20, 0x1C, 0x0F, 0x87, 0xF3, 0xF9, 0xFC, 0x3E, 0x07, 0x80, 0xFC,
  0x07, 0xE0, 0x7E, 0x03, 0xC0, 0x38, 0x01, 0x00, 0x3F, 0xF3, 0xFF, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE7, 0xFE, 0xFF, 0xE0, 0x20, 0x03,
  0x80, 0x3C, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xE0, 0x3E, 0x0F, 0xE3,
  0xF8, 0xFE, 0x0F, 0x80, 0xE0, 0x08, 0x00, 0x0F, 0x07, 0xF9, 0xFF, 0x3C,
  0xFF, 0x1F, 0xE3, 0xC0, 0x78, 0x0E, 0x03, 0xC0, 0xF0, 0x3C, 0x07, 0x81,
  0xE0, 0x38, 0x0E, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x3C, 0x07, 0x80,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x03, 0xC3, 0xC0, 0x70, 0x0E,
  0x0E, 0x00, 0x61, 0xC0, 0x07, 0x18, 0x3C, 0x33, 0x8F, 0xE3, 0x31, 0xE6,
  0x37, 0x1C, 0xE3, 0x63, 0x8E, 0x36, 0x38, 0xC3, 0xE3, 0x0C, 0x3E, 0x70,
  0xC3, 0xC7, 0x1C, 0x7C, 0x71, 0xC6, 0xC7, 0x18, 0x6C, 0x73, 0x8C, 0xC7,
  0x79, 0xCC, 0x7F, 0xF8, 0xC3, 0xCF, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06,
  0x00, 0x00, 0x70, 0x00, 0x03, 0xC3, 0x00, 0x1F, 0xF0, 0x00, 0xFC, 0x00,
  0x00, 0x38, 0x00, 0x78, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x01, 0xDC, 0x01, 0xDC, 0x03, 0x9C, 0x03, 0x9C, 0x07, 0x9E, 0x07, 0x0E,
  0x0F, 0x0E, 0x0E, 0x0E, 0x1F, 0xFE, 0x1F, 0xFE, 0x3F, 0xFE, 0x3C, 0x0F,
  0x78, 0x0F, 0x78, 0x0F, 0x70, 0x0F, 0xF0, 0x07, 0x0F, 0xF8, 0x0F, 0xFC,
  0x0F, 0xFE, 0x1E, 0x1E, 0x1E, 0x0E, 0x1E, 0x0E, 0x1C, 0x0E, 0x1C, 0x1E,
  0x1C, 0x1E, 0x3F, 0xFC, 0x3F, 0xF0, 0x3F, 0xF8, 0x38, 0x3C, 0x38, 0x1C,
  0x38, 0x1C, 0x78, 0x1C, 0x78, 0x3C, 0x78, 0x3C, 0x70, 0x78, 0x7F, 0xF8,
  0x7F, 0xF0, 0xFF, 0xC0, 0x01, 0xF0, 0x07, 0xFC, 0x0F, 0xFC, 0x1E, 0x1E,
  0x1C, 0x0E, 0x3C, 0x0E, 0x38, 0x0E, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x3C,
  0x70, 0x3C, 0x70, 0x38, 0x78, 0x78, 0x3F, 0xF0, 0x3F, 0xE0, 0x0F, 0x80,
  0x0F, 0xF0, 0x0F, 0xF8, 0x0F, 0xFC, 0x1E, 0x1E, 0x1E, 0x0E, 0x1E, 0x0E,
  0x1E, 0x0F, 0x1C, 0x0F, 0x1C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0E, 0x3C, 0x0E,
  0x38, 0x0E, 0x38, 0x1E, 0x38, 0x1E, 0x78, 0x1C, 0x78, 0x3C, 0x78, 0x38,
  0x70, 0xF8, 0x7F, 0xF0, 0x7F, 0xE0, 0xFF, 0x80, 0x0F, 0xFE, 0x0F, 0xFE,
  0x0F, 0xFE, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF0, 0x38, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x7F, 0xF0,
  0x7F, 0xF0, 0xFF, 0xF0, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xFF,
  0xE1, 0xFF, 0x83, 0xFF, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0,
  0x07, 0xFC, 0x0F, 0xFE, 0x1E, 0x1E, 0x1C, 0x0E, 0x3C, 0x0E, 0x38, 0x0F,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0xFE, 0x70, 0xFE,
  0xF0, 0xFC, 0xF0, 0x1C, 0xF0, 0x1C, 0x70, 0x3C, 0x70, 0x3C, 0x78, 0x7C,
  0x3F, 0xF8, 0x1F, 0xF0, 0x0F, 0xC0, 0x0F, 0x01, 0xC3, 0x80, 0xF0, 0xE0,
  0x3C, 0x78, 0x0F, 0x1E, 0x03, 0x87, 0x80, 0xE1, 0xE0, 0x38, 0x70, 0x1E,
  0x1C, 0x07, 0x8F, 0xFF, 0xE3, 0xFF, 0xF0, 0xFF, 0xFC, 0x38, 0x07, 0x0E,
  0x03, 0xC3, 0x80, 0xF1, 0xE0, 0x3C, 0x78, 0x0E, 0x1E, 0x03, 0x87, 0x00,
  0xE1, 0xC0, 0x78, 0x70, 0x1E, 0x3C, 0x07, 0x80, 0x1E, 0x38, 0x70, 0xE3,
  0xC7, 0x8F, 0x1C, 0x38, 0x71, 0xE3, 0xC7, 0x8E, 0x1C, 0x38, 0xF1, 0xE3,
  0xC7, 0x0E, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0xF0, 0xF1,
  0xE1, 0xC3, 0xC7, 0x83, 0xFE, 0x07, 0xF8, 0x03, 0xE0, 0x00, 0x0F, 0x07,
  0xC3, 0x83, 0xE0, 0xE0, 0xF0, 0x78, 0x78, 0x1E, 0x3C, 0x07, 0x9F, 0x01,
  0xE7, 0x80, 0x73, 0xC0, 0x1D, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x0F, 0xB8, 0x03, 0xCF, 0x01, 0xE3, 0xC0, 0x78, 0x70,
  0x1E, 0x1E, 0x07, 0x07, 0x81, 0xC0, 0xE0, 0x70, 0x3C, 0x3C, 0x0F, 0x00,
  0x0F, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xC0,
  0x1C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x07, 0x80,
  0x78, 0x07, 0x80, 0x70, 0x07, 0xFF, 0x7F, 0xFF, 0xFF, 0x0F, 0x80, 0x7C,
  0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC7, 0xE0, 0x3F, 0x1F, 0x80, 0xFC, 0x7E,
  0x07, 0xE1, 0xF8, 0x1F, 0x87, 0xE0, 0xEE, 0x1D, 0x83, 0xB8, 0xF7, 0x0F,
  0xE3, 0xDC, 0x77, 0x8F, 0x71, 0xDC, 0x39, 0xCE, 0x70, 0xE7, 0x39, 0xC3,
  0x9D, 0xCF, 0x1E, 0x77, 0x3C, 0x78, 0xF8, 0xF1, 0xE3, 0xE3, 0x87, 0x0F,
  0x0E, 0x1C, 0x3C, 0x78, 0x70, 0xE1, 0xE3, 0xC3, 0x87, 0x80, 0x0F, 0x01,
  0xC3, 0xC0, 0xF0, 0xF0, 0x3C, 0x7E, 0x0F, 0x1F, 0x83, 0x87, 0xE0, 0xE1,
  0xD8, 0x38, 0x77, 0x1E, 0x1D, 0xC7, 0x8F, 0x71, 0xE3, 0xCE, 0x70, 0xF3,
  0x9C, 0x38, 0xE7, 0x0E, 0x1B, 0xC3, 0x87, 0xF1, 0xE1, 0xFC, 0x78, 0x7E,
  0x1E, 0x0F, 0x87, 0x03, 0xE1, 0xC0, 0xF8, 0x70, 0x1E, 0x3C, 0x07, 0x80,
  0x01, 0xF0, 0x07, 0xFC, 0x0F, 0xFC, 0x1E, 0x1E, 0x1C, 0x0E, 0x3C, 0x0F,
  0x38, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x70, 0x0E, 0x70, 0x0E,
  0x70, 0x0E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1C, 0x70, 0x1C, 0x70, 0x3C,
  0x78, 0x78, 0x3F, 0xF0, 0x3F, 0xE0, 0x0F, 0x80, 0x0F, 0xF8, 0x0F, 0xFE,
  0x0F, 0xFE, 0x1E, 0x0F, 0x1E, 0x07, 0x1E, 0x07, 0x1C, 0x07, 0x1C, 0x07,
  0x1C, 0x0F, 0x3C, 0x0F, 0x3C, 0x1E, 0x3F, 0xFE, 0x3F, 0xF8, 0x3F, 0xF0,
  0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x07, 0xFC, 0x0F, 0xFC, 0x1E, 0x1E,
  0x1C, 0x0E, 0x3C, 0x0E, 0x38, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x70, 0x0E,
  0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1C,
  0x70, 0x3C, 0x70, 0x38, 0x78, 0x78, 0x3F, 0xF0, 0x3F, 0xE0, 0x0F, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x20, 0x0F, 0xF8, 0x0F, 0xFC,
  0x0F, 0xFE, 0x1E, 0x1E, 0x1E, 0x0F, 0x1E, 0x0F, 0x1C, 0x0F, 0x1C, 0x0F,
  0x1C, 0x0E, 0x3C, 0x1E, 0x3C, 0x3C, 0x3F, 0xFC, 0x3F, 0xF8, 0x3F, 0xF0,
  0x38, 0xF0, 0x78, 0x70, 0x78, 0x70, 0x78, 0x78, 0x70, 0x78, 0x70, 0x38,
  0x70, 0x38, 0xF0, 0x3C, 0x03, 0xE0, 0x1F, 0xF0, 0x7F, 0xE0, 0xF1, 0xE3,
  0xC1, 0xC7, 0x03, 0x8E, 0x07, 0x1E, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x70, 0x3C, 0xE0, 0x79,
  0xC0, 0xE3, 0xC3, 0xC3, 0xFF, 0x03, 0xFC, 0x03, 0xF0, 0x00, 0x7F, 0xFE,
  0xFF, 0xFD, 0xFF, 0xF0, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x00, 0x1C, 0x0F, 0x1C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0E,
  0x3C, 0x0E, 0x38, 0x0E, 0x38, 0x1E, 0x38, 0x1E, 0x78, 0x1E, 0x78, 0x1C,
  0x78, 0x1C, 0x70, 0x1C, 0x70, 0x1C, 0x70, 0x3C, 0xF0, 0x3C, 0xF0, 0x38,
  0xF0, 0x38, 0xF0, 0x78, 0x78, 0xF0, 0x7F, 0xF0, 0x3F, 0xE0, 0x1F, 0x80,
  0x70, 0x0F, 0x70, 0x0F, 0x70, 0x1E, 0x70, 0x1E, 0x78, 0x3C, 0x78, 0x3C,
  0x78, 0x38, 0x78, 0x78, 0x38, 0x78, 0x38, 0x70, 0x38, 0xF0, 0x38, 0xE0,
  0x39, 0xE0, 0x39, 0xC0, 0x39, 0xC0, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0xE0, 0xE0, 0x7E, 0x0F,
  0x0F, 0xE0, 0xF0, 0xEE, 0x1F, 0x0E, 0xE1, 0xF1, 0xEE, 0x1F, 0x1C, 0xE3,
  0xF1, 0xCE, 0x3F, 0x3C, 0xE3, 0x73, 0xCE, 0x77, 0x38, 0xE7, 0x73, 0x8E,
  0x67, 0x78, 0xEE, 0x77, 0x0E, 0xE7, 0x70, 0xEC, 0x7F, 0x0F, 0xC7, 0xE0,
  0xFC, 0x7E, 0x0F, 0x83, 0xE0, 0xF8, 0x3C, 0x0F, 0x83, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0x80, 0x0F, 0x03, 0xC3, 0xC1, 0xF0, 0x70, 0x78, 0x1E, 0x3C,
  0x07, 0x8F, 0x00, 0xE7, 0x80, 0x39, 0xC0, 0x0F, 0xF0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F,
  0x80, 0x3D, 0xE0, 0x0F, 0x38, 0x07, 0x8F, 0x03, 0xC3, 0xC0, 0xF0, 0x70,
  0x78, 0x1E, 0x1E, 0x07, 0x80, 0xE0, 0x3F, 0xC0, 0xFF, 0x07, 0xBC, 0x1C,
  0x70, 0xF1, 0xC3, 0x87, 0x1E, 0x1E, 0x70, 0x3B, 0xC0, 0xEE, 0x03, 0xF0,
  0x0F, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x1F, 0xFF, 0x1F, 0xFF,
  0x1F, 0xFF, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x70,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x0F, 0x00,
  0x0E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0xFF, 0xF8,
  0xFF, 0xF8, 0xFF, 0xF8, 0x0F, 0x87, 0xC3, 0xE1, 0xC0, 0xE0, 0xF0, 0x78,
  0x38, 0x1C, 0x0E, 0x07, 0x07, 0x83, 0xC1, 0xE0, 0xE0, 0x70, 0x38, 0x1C,
  0x1E, 0x0F, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0xF0, 0x78, 0x3C, 0x1F, 0x0F,
  0x87, 0xC0, 0xE3, 0x8E, 0x38, 0xE3, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x79,
  0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x3C, 0x71, 0xC7, 0x07, 0xC1, 0xF0, 0x7C,
  0x0F, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x07, 0x81, 0xE0, 0x78, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x3C, 0x0F, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x07, 0x81,
  0xE0, 0x78, 0x1C, 0x07, 0x01, 0xC1, 0xF0, 0x7C, 0x3F, 0x00, 0x07, 0x01,
  0xC0, 0xF0, 0x3C, 0x1F, 0x86, 0xE3, 0xB8, 0xE6, 0x71, 0x9C, 0x6E, 0x1C,
  0x7F, 0xF7, 0xFF, 0xFF, 0xE0, 0xF1, 0xE3, 0x87, 0x07, 0xC0, 0x7F, 0x87,
  0xFC, 0x78, 0xE3, 0x87, 0x00, 0x38, 0x3F, 0xC7, 0xFE, 0x3C, 0x73, 0xC7,
  0x9C, 0x3C, 0xE1, 0xC7, 0x1E, 0x3F, 0xF1, 0xFF, 0x83, 0x9C, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0xBC, 0x1F,
  0xF1, 0xFF, 0xCF, 0x1E, 0x70, 0x73, 0x83, 0x9C, 0x1C, 0xE0, 0xEF, 0x07,
  0x78, 0x3B, 0x83, 0xDC, 0x1C, 0xF1, 0xE7, 0xFF, 0x7F, 0xF3, 0x9F, 0x00,
  0x0F, 0x81, 0xFE, 0x3F, 0xE7, 0x8F, 0x70, 0x7F, 0x07, 0xF0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0xEE, 0x1E, 0xF1, 0xC7, 0xFC, 0x7F, 0x83, 0xE0,
  0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x83, 0xDE, 0x3F, 0xF8, 0xFF, 0xE7, 0x8F, 0x1C, 0x1C, 0xF0, 0x73, 0xC3,
  0xCE, 0x0F, 0x38, 0x38, 0xE0, 0xE3, 0x83, 0x8E, 0x0E, 0x3C, 0x78, 0xFF,
  0xE1, 0xFF, 0x03, 0xDC, 0x00, 0x07, 0x81, 0xFE, 0x3F, 0xE7, 0x8F, 0x70,
  0x77, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x0E, 0x00, 0xF0,
  0xC7, 0xFC, 0x7F, 0xC1, 0xF0, 0x03, 0xC1, 0xF0, 0xFC, 0x38, 0x1E, 0x07,
  0x01, 0xC1, 0xFE, 0x7F, 0x1F, 0xC3, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x81,
  0xE0, 0x78, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x3C, 0x0F, 0x00, 0x07, 0x9C,
  0x7F, 0x71, 0xFF, 0xCF, 0x1F, 0x38, 0x39, 0xE0, 0xE7, 0x83, 0x9C, 0x1E,
  0x70, 0x79, 0xC1, 0xC7, 0x07, 0x1C, 0x1C, 0x78, 0xF1, 0xFF, 0xC3, 0xFF,
  0x07, 0xB8, 0x00, 0xE0, 0x03, 0x84, 0x1E, 0x3F, 0xF0, 0xFF, 0x80, 0xFC,
  0x00, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x70,
  0x03, 0xBC, 0x1F, 0xF1, 0xFF, 0xCF, 0x1E, 0x70, 0xF3, 0x87, 0x9C, 0x3D,
  0xE1, 0xEF, 0x0E, 0x78, 0x73, 0x83, 0x9C, 0x3C, 0xE1, 0xEF, 0x0F, 0x78,
  0x73, 0xC3, 0x80, 0x04, 0x1C, 0x38, 0x70, 0x00, 0x07, 0x0E, 0x1C, 0x78,
  0xF1, 0xC3, 0x87, 0x0E, 0x3C, 0x78, 0xE1, 0xC3, 0x87, 0x1E, 0x00, 0x01,
  0x80, 0x70, 0x1C, 0x07, 0x00, 0x00, 0x00, 0x38, 0x0E, 0x03, 0x81, 0xE0,
  0x78, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x3C, 0x0F, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x07, 0x81, 0xE0, 0x70, 0x3C, 0x3F, 0x0F, 0x83, 0xC0, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x0F,
  0x1C, 0x78, 0xF3, 0xC3, 0xDE, 0x0E, 0xF0, 0x3B, 0x80, 0xFE, 0x03, 0xF8,
  0x1F, 0xE0, 0x7F, 0x81, 0xEF, 0x07, 0x1C, 0x1C, 0x78, 0x71, 0xE3, 0xC3,
  0x8F, 0x0F, 0x00, 0x0E, 0x0E, 0x0E, 0x0E, 0x1E, 0x1E, 0x1C, 0x1C, 0x1C,
  0x1C, 0x3C, 0x3C, 0x38, 0x38, 0x38, 0x38, 0x78, 0x78, 0x70, 0x70, 0x70,
  0x70, 0xF0, 0x1D, 0xE3, 0xE1, 0xFF, 0x7F, 0x3F, 0xFF, 0xF3, 0xC7, 0xC7,
  0x38, 0x78, 0x73, 0x87, 0x87, 0x38, 0x78, 0x73, 0x87, 0x07, 0x78, 0x70,
  0xF7, 0x87, 0x0F, 0x70, 0x70, 0xE7, 0x0F, 0x0E, 0x70, 0xF0, 0xE7, 0x0E,
  0x0E, 0xF0, 0xE1, 0xEF, 0x0E, 0x1E, 0x1D, 0xE0, 0xFF, 0x8F, 0xFE, 0x78,
  0xF3, 0x87, 0x9C, 0x3C, 0xE1, 0xE7, 0x0F, 0x78, 0x73, 0xC3, 0x9C, 0x1C,
  0xE1, 0xE7, 0x0F, 0x38, 0x73, 0xC3, 0x9E, 0x1C, 0x07, 0xC1, 0xFE, 0x3F,
  0xF7, 0x8F, 0x70, 0x7F, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0xFE, 0x0E, 0xF1, 0xE7, 0xFC, 0x7F, 0x81, 0xF0, 0x0E, 0xF0, 0x3F, 0xE1,
  0xFF, 0xC7, 0x8F, 0x1C, 0x1C, 0x70, 0x71, 0xC1, 0xC7, 0x07, 0x3C, 0x1C,
  0xF0, 0x73, 0x83, 0xCE, 0x0E, 0x3C, 0x78, 0xFF, 0xC7, 0xFF, 0x1E, 0xF0,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x0F,
  0x39, 0xFF, 0xCF, 0xFE, 0xF1, 0xE7, 0x07, 0x78, 0x3B, 0xC3, 0xDC, 0x1E,
  0xE0, 0xE7, 0x07, 0x38, 0x39, 0xC1, 0xCF, 0x1E, 0x7F, 0xF1, 0xFF, 0x07,
  0xB8, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x1D,
  0xC7, 0xF3, 0xFC, 0xFC, 0x3C, 0x0E, 0x03, 0x80, 0xE0, 0x78, 0x1E, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x0F, 0x03, 0xC0, 0x07, 0xC1, 0xFE, 0x1F, 0xF3,
  0xC7, 0x38, 0x73, 0x80, 0x3E, 0x01, 0xF8, 0x0F, 0xC0, 0x3E, 0x00, 0xEF,
  0x0E, 0x70, 0xE7, 0xFE, 0x3F, 0xC1, 0xF0, 0x1E, 0x1C, 0x1C, 0x1C, 0xFF,
  0xFF, 0xFF, 0x38, 0x38, 0x38, 0x38, 0x78, 0x78, 0x70, 0x70, 0x70, 0x70,
  0x7C, 0x7C, 0x3C, 0x38, 0x79, 0xC3, 0xDE, 0x1C, 0xF0, 0xE7, 0x07, 0x38,
  0x79, 0xC3, 0xCE, 0x1E, 0xF0, 0xE7, 0x87, 0x38, 0x39, 0xC3, 0xCF, 0x1E,
  0x7F, 0xE1, 0xFF, 0x07, 0xB8, 0xE0, 0xFC, 0x3F, 0x87, 0x70, 0xEE, 0x39,
  0xC7, 0x39, 0xE3, 0xB8, 0x77, 0x0F, 0xC1, 0xF8, 0x3E, 0x07, 0xC0, 0xF8,
  0x1E, 0x01, 0xC0, 0xE1, 0xC3, 0xF0, 0xE3, 0xF8, 0xF1, 0xDC, 0x78, 0xEE,
  0x7C, 0xF7, 0x3E, 0x73, 0x9B, 0x39, 0xDD, 0xB8, 0xEC, 0xDC, 0x7E, 0x6E,
  0x3F, 0x3E, 0x1F, 0x1F, 0x0F, 0x8F, 0x07, 0x87, 0x81, 0xC3, 0xC0, 0xE1,
  0xC0, 0x1E, 0x3C, 0x78, 0xF0, 0xE7, 0x83, 0x9C, 0x0F, 0xF0, 0x1F, 0x80,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xF0, 0x3C, 0xE0,
  0xE3, 0x87, 0x8E, 0x3C, 0x3C, 0x1C, 0x1C, 0x70, 0xF1, 0xC3, 0x87, 0x1E,
  0x1C, 0x70, 0x71, 0xC1, 0xCF, 0x07, 0xB8, 0x0F, 0xE0, 0x3F, 0x00, 0xFC,
  0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x78,
  0x01, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0x3F, 0xF9, 0xFF, 0xCF,
  0xFC, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0x70, 0x07, 0x80, 0x7F, 0xF3, 0xFF, 0x9F, 0xF8, 0x01, 0x81,
  0xC1, 0xC1, 0xC0, 0xE0, 0xF0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x07, 0x0F,
  0x87, 0x83, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x1C, 0x0E, 0x01, 0x00, 0x0E, 0x1C, 0x30, 0x60, 0xC1, 0x87,
  0x0E, 0x1C, 0x30, 0x60, 0xC1, 0x87, 0x0E, 0x18, 0x30, 0x60, 0xC3, 0x87,
  0x0E, 0x18, 0x30, 0x60, 0xC0, 0x08, 0x07, 0x03, 0x80, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x07, 0x03, 0x80, 0xE0, 0x78, 0x1C, 0x1E, 0x1C, 0x1E,
  0x0E, 0x07, 0x03, 0x81, 0xC1, 0xE0, 0xE0, 0x70, 0x78, 0x78, 0x38, 0x10,
  0x00, 0x1E, 0x0C, 0xFC, 0x37, 0xF9, 0xDC, 0xFE, 0xE1, 0xF8, 0x03, 0xC0,
};

const GFXglyph RobotoCondensed_MediumItalic30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 7, 22, 7, 1, -22 },
  { 21, 8, 8, 9, 2, -23 },
  { 29, 15, 22, 16, 1, -22 },
  { 71, 13, 28, 15, 1, -25 },
  { 117, 14, 22, 19, 3, -22 },
  { 156, 14, 22, 16, 1, -22 },
  { 195, 4, 8, 5, 2, -23 },
  { 199, 10, 31, 9, 1, -24 },
  { 238, 9, 31, 9, -1, -24 },
  { 273, 12, 13, 13, 2, -22 },
  { 293, 13, 15, 14, 1, -17 },
  { 318, 6, 8, 6, -2, -3 },
  { 324, 7, 3, 9, 1, -11 },
  { 327, 4, 4, 8, 1, -4 },
  { 329, 14, 24, 10, -2, -22 },
  { 371, 13, 22, 15, 1, -22 },
  { 407, 9, 22, 15, 3, -22 },
  { 432, 14, 22, 15, 0, -22 },
  { 471, 13, 22, 15, 1, -22 },
  { 507, 14, 22, 15, 0, -22 },
  { 546, 14, 22, 15, 1, -22 },
  { 585, 12, 22, 15, 1, -22 },
  { 618, 13, 22, 15, 2, -22 },
  { 654, 13, 22, 15, 1, -22 },
  { 690, 12, 22, 15, 2, -22 },
  { 723, 6, 16, 8, 1, -16 },
  { 735, 8, 21, 7, -1, -16 },
  { 756, 11, 14, 13, 1, -16 },
  { 776, 12, 9, 14, 1, -14 },
  { 790, 12, 14, 13, 1, -16 },
  { 811, 11, 22, 13, 2, -22 },
  { 842, 20, 28, 22, 1, -21 },
  { 912, 16, 22, 17, -1, -22 },
  { 956, 16, 22, 16, 0, -22 },
  { 1000, 16, 22, 17, 1, -22 },
  { 1044, 16, 22, 17, 0, -22 },
  { 1088, 16, 22, 14, 0, -22 },
  { 1132, 15, 22, 14, 0, -22 },
  { 1174, 16, 22, 17, 1, -22 },
  { 1218, 18, 22, 18, 0, -22 },
  { 1268, 7, 22, 8, 1, -22 },
  { 1288, 15, 22, 14, 0, -22 },
  { 1330, 18, 22, 16, 0, -22 },
  { 1380, 12, 22, 14, 0, -22 },
  { 1413, 22, 22, 22, 0, -22 },
  { 1474, 18, 22, 18, 0, -22 },
  { 1524, 16, 22, 18, 1, -22 },
  { 1568, 16, 22, 16, 0, -22 },
  { 1612, 16, 26, 18, 1, -22 },
  { 1664, 16, 22, 16, 0, -22 },
  { 1708, 15, 22, 15, 1, -22 },
  { 1750, 15, 22, 16, 2, -22 },
  { 1792, 16, 22, 17, 1, -22 },
  { 1836, 16, 22, 17, 2, -22 },
  { 1880, 20, 22, 22, 3, -22 },
  { 1935, 18, 22, 16, -1, -22 },
  { 1985, 14, 22, 16, 3, -22 },
  { 2024, 16, 22, 15, 0, -22 },
  { 2068, 9, 30, 8, 0, -25 },
  { 2102, 6, 24, 11, 3, -22 },
  { 2120, 10, 30, 8, -2, -25 },
  { 2158, 10, 11, 11, 1, -22 },
  { 2172, 12, 3, 12, -2, 0 },
  { 2177, 6, 4, 9, 3, -22 },
  { 2180, 13, 16, 14, 0, -16 },
  { 2206, 13, 23, 14, 0, -23 },
  { 2244, 12, 16, 13, 1, -16 },
  { 2268, 14, 23, 14, 1, -23 },
  { 2309, 12, 16, 14, 1, -16 },
  { 2333, 10, 23, 9, 1, -23 },
  { 2362, 14, 22, 15, 0, -16 },
  { 2401, 13, 23, 14, 0, -23 },
  { 2439, 7, 22, 7, 0, -22 },
  { 2459, 10, 28, 7, -3, -22 },
  { 2494, 14, 23, 14, 0, -23 },
  { 2535, 8, 23, 7, 0, -23 },
  { 2558, 20, 16, 22, 0, -16 },
  { 2598, 13, 16, 14, 0, -16 },
  { 2624, 12, 16, 15, 1, -16 },
  { 2648, 14, 22, 14, -1, -16 },
  { 2687, 13, 22, 15, 1, -16 },
  { 2723, 10, 16, 9, 0, -16 },
  { 2743, 12, 16, 13, 0, -16 },
  { 2767, 8, 20, 9, 1, -20 },
  { 2787, 13, 16, 14, 1, -16 },
  { 2813, 11, 16, 13, 2, -16 },
  { 2835, 17, 16, 19, 2, -16 },
  { 2869, 14, 16, 13, -1, -16 },
  { 2897, 14, 22, 13, -1, -16 },
  { 2936, 13, 16, 13, 0, -16 },
  { 2962, 9, 28, 9, 1, -23 },
  { 2994, 7, 26, 7, 0, -22 },
  { 3017, 9, 28, 9, -1, -23 },
  { 3049, 14, 6, 17, 1, -12 },
};

const GFXfont RobotoCondensed_MediumItalic30pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_MediumItalic30pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_MediumItalic30pt7bGlyphs,
  0x20, 0x7E, 35
};

#endif // _ROBOTOCONDENSED_MEDIUMITALIC30PT7B_H_
