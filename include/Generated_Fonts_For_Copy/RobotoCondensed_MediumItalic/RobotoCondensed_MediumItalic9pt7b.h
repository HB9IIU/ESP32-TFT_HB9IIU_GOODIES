#ifndef _ROBOTOCONDENSED_MEDIUMITALIC9PT7B_H_
#define _ROBOTOCONDENSED_MEDIUMITALIC9PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-MediumItalic.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_MediumItalic9pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x48, 0xF0, 0x29, 0x9E, 0xAF, 0x32, 0x80, 0x23, 0x54, 0x21,
  0x96, 0x40, 0xCD, 0xE4, 0x7B, 0x30, 0x32, 0x9C, 0xCB, 0x49, 0xC0, 0xC0,
  0x29, 0x29, 0x22, 0x40, 0x55, 0x56, 0x80, 0x27, 0x66, 0x22, 0xF2, 0x40,
  0x50, 0xC0, 0x80, 0x10, 0x84, 0x42, 0x21, 0x08, 0x35, 0x55, 0x99, 0x60,
  0x59, 0x24, 0x90, 0x75, 0x13, 0x24, 0xF0, 0x75, 0x12, 0x19, 0x60, 0x13,
  0x55, 0xF2, 0x20, 0x74, 0x71, 0x19, 0x60, 0x34, 0x75, 0x99, 0x60, 0x78,
  0x84, 0x42, 0x21, 0x00, 0x35, 0x56, 0x99, 0x60, 0xF6, 0xDE, 0xA0, 0x40,
  0x80, 0x40, 0xA0, 0x16, 0xC2, 0x70, 0xF0, 0x43, 0x68, 0xF4, 0xA8, 0x20,
  0x3D, 0x15, 0xEB, 0xB6, 0xF8, 0x1C, 0x11, 0x8C, 0xA7, 0x4A, 0x40, 0x72,
  0x56, 0xE5, 0x4B, 0xC0, 0x32, 0x50, 0x88, 0x29, 0xC0, 0x72, 0x52, 0x95,
  0x4B, 0x80, 0x7A, 0x10, 0xE4, 0x43, 0xC0, 0x72, 0x10, 0xE4, 0x42, 0x00,
  0x32, 0x50, 0xB8, 0xA9, 0xC0, 0x4A, 0x52, 0xF4, 0xC6, 0x40, 0x55, 0x68,
  0x11, 0x11, 0x1A, 0xE0, 0x4A, 0x98, 0xC6, 0x4A, 0x40, 0x44, 0x44, 0x48,
  0xF0, 0x66, 0xC9, 0xB3, 0x67, 0x56, 0xA9, 0x00, 0x4B, 0x5A, 0xD5, 0xCE,
  0x40, 0x32, 0x52, 0x98, 0xA9, 0xC0, 0x72, 0x52, 0xE4, 0x42, 0x00, 0x32,
  0x52, 0x98, 0xA9, 0xC2, 0x72, 0x56, 0xE5, 0x4A, 0x40, 0x32, 0x50, 0x61,
  0x49, 0x80, 0xF4, 0x44, 0x44, 0x80, 0x4A, 0x52, 0x99, 0x49, 0xC0, 0x99,
  0xAA, 0xAC, 0x40, 0xA6, 0x9A, 0xB6, 0xDB, 0x49, 0x00, 0x4A, 0x8C, 0x46,
  0x2A, 0x40, 0x9A, 0xA4, 0x44, 0x80, 0x78, 0x84, 0x44, 0x23, 0xC0, 0x69,
  0x29, 0x26, 0xAA, 0xA5, 0x24, 0x92, 0x92, 0x2D, 0x80, 0x70, 0x90, 0x61,
  0x7A, 0xE0, 0x44, 0x75, 0x99, 0xE0, 0x65, 0x8A, 0x60, 0x10, 0x9D, 0x29,
  0x49, 0x80, 0x75, 0xF8, 0x60, 0x29, 0xA4, 0xA0, 0x7D, 0x99, 0x72, 0xE0,
  0x44, 0x75, 0x99, 0xA0, 0x45, 0x68, 0x20, 0x92, 0x92, 0xC0, 0x44, 0x56,
  0xEA, 0xA0, 0x55, 0x68, 0x7D, 0x59, 0x65, 0xA4, 0x75, 0x99, 0xA0, 0x75,
  0x99, 0x60, 0x75, 0x99, 0xE8, 0x80, 0x7D, 0x99, 0x62, 0x20, 0x6A, 0x48,
  0x64, 0x6A, 0xE0, 0x5D, 0x24, 0x80, 0x55, 0x99, 0x60, 0x56, 0x66, 0x40,
  0xAF, 0xBD, 0x4A, 0x00, 0x56, 0x66, 0xA0, 0x56, 0x66, 0x44, 0x80, 0x72,
  0x44, 0xE0, 0x29, 0x28, 0x92, 0x40, 0x55, 0x6A, 0x55, 0x5A, 0x80, 0x6D,
  0x80,
};

const GFXglyph RobotoCondensed_MediumItalic9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 7, 2, 0, -7 },
  { 3, 2, 2, 3, 1, -7 },
  { 4, 5, 7, 5, 0, -7 },
  { 9, 4, 9, 4, 0, -8 },
  { 14, 4, 7, 6, 1, -7 },
  { 18, 5, 7, 5, 0, -7 },
  { 23, 1, 2, 1, 1, -7 },
  { 24, 3, 9, 3, 0, -7 },
  { 28, 2, 9, 3, 0, -7 },
  { 31, 4, 4, 4, 0, -7 },
  { 33, 4, 5, 4, 0, -6 },
  { 36, 2, 2, 2, -1, -1 },
  { 37, 2, 1, 3, 0, -3 },
  { 38, 1, 1, 2, 0, -1 },
  { 39, 5, 8, 3, -1, -7 },
  { 44, 4, 7, 4, 0, -7 },
  { 48, 3, 7, 4, 1, -7 },
  { 51, 4, 7, 4, 0, -7 },
  { 55, 4, 7, 4, 0, -7 },
  { 59, 4, 7, 4, 0, -7 },
  { 63, 4, 7, 4, 0, -7 },
  { 67, 4, 7, 4, 0, -7 },
  { 71, 5, 7, 4, 0, -7 },
  { 76, 4, 7, 4, 0, -7 },
  { 80, 3, 7, 4, 1, -7 },
  { 83, 2, 5, 2, 0, -5 },
  { 85, 2, 6, 2, 0, -5 },
  { 87, 4, 4, 4, 0, -5 },
  { 89, 4, 3, 4, 0, -4 },
  { 91, 4, 4, 4, 0, -5 },
  { 93, 3, 7, 4, 1, -7 },
  { 96, 6, 8, 7, 0, -6 },
  { 102, 5, 7, 5, 0, -7 },
  { 107, 5, 7, 5, 0, -7 },
  { 112, 5, 7, 5, 0, -7 },
  { 117, 5, 7, 5, 0, -7 },
  { 122, 5, 7, 4, 0, -7 },
  { 127, 5, 7, 4, 0, -7 },
  { 132, 5, 7, 5, 0, -7 },
  { 137, 5, 7, 5, 0, -7 },
  { 142, 2, 7, 2, 0, -7 },
  { 144, 4, 7, 4, 0, -7 },
  { 148, 5, 7, 5, 0, -7 },
  { 153, 4, 7, 4, 0, -7 },
  { 157, 7, 7, 7, 0, -7 },
  { 164, 5, 7, 5, 0, -7 },
  { 169, 5, 7, 5, 0, -7 },
  { 174, 5, 7, 5, 0, -7 },
  { 179, 5, 8, 5, 0, -7 },
  { 184, 5, 7, 5, 0, -7 },
  { 189, 5, 7, 5, 0, -7 },
  { 194, 4, 7, 5, 1, -7 },
  { 198, 5, 7, 5, 0, -7 },
  { 203, 4, 7, 5, 1, -7 },
  { 207, 6, 7, 7, 1, -7 },
  { 213, 5, 7, 5, 0, -7 },
  { 218, 4, 7, 5, 1, -7 },
  { 222, 5, 7, 5, 0, -7 },
  { 227, 3, 8, 2, 0, -7 },
  { 230, 2, 8, 3, 1, -7 },
  { 232, 3, 8, 2, -1, -7 },
  { 235, 3, 3, 3, 0, -7 },
  { 237, 4, 1, 4, -1, 0 },
  { 238, 2, 2, 3, 1, -7 },
  { 239, 4, 5, 4, 0, -5 },
  { 242, 4, 7, 4, 0, -7 },
  { 246, 4, 5, 4, 0, -5 },
  { 249, 5, 7, 4, 0, -7 },
  { 254, 4, 5, 4, 0, -5 },
  { 257, 3, 7, 3, 0, -7 },
  { 260, 4, 7, 4, 0, -5 },
  { 264, 4, 7, 4, 0, -7 },
  { 268, 2, 7, 2, 0, -7 },
  { 270, 3, 9, 2, -1, -7 },
  { 274, 4, 7, 4, 0, -7 },
  { 278, 2, 7, 2, 0, -7 },
  { 280, 6, 5, 7, 0, -5 },
  { 284, 4, 5, 4, 0, -5 },
  { 287, 4, 5, 4, 0, -5 },
  { 290, 4, 7, 4, 0, -5 },
  { 294, 4, 7, 4, 0, -5 },
  { 298, 3, 5, 3, 0, -5 },
  { 300, 4, 5, 4, 0, -5 },
  { 303, 3, 6, 3, 0, -6 },
  { 306, 4, 5, 4, 0, -5 },
  { 309, 4, 5, 4, 0, -5 },
  { 312, 5, 5, 6, 1, -5 },
  { 316, 4, 5, 4, 0, -5 },
  { 319, 4, 7, 4, 0, -5 },
  { 323, 4, 5, 4, 0, -5 },
  { 326, 3, 9, 3, 0, -7 },
  { 330, 2, 8, 2, 0, -7 },
  { 332, 2, 9, 3, 0, -7 },
  { 335, 5, 2, 5, 0, -4 },
};

const GFXfont RobotoCondensed_MediumItalic9pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_MediumItalic9pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_MediumItalic9pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _ROBOTOCONDENSED_MEDIUMITALIC9PT7B_H_
