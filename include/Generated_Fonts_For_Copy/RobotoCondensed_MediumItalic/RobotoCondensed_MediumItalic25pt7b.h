#ifndef _ROBOTOCONDENSED_MEDIUMITALIC25PT7B_H_
#define _ROBOTOCONDENSED_MEDIUMITALIC25PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-MediumItalic.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_MediumItalic25pt7bBitmaps[] PROGMEM = {
  0x00, 0x39, 0xCE, 0x73, 0x98, 0xCE, 0x73, 0x98, 0xC6, 0x00, 0x18, 0xE6,
  0x00, 0x6C, 0xDB, 0xB6, 0x6C, 0xD9, 0x00, 0x03, 0x30, 0x36, 0x06, 0x60,
  0x66, 0x06, 0x43, 0xFF, 0x3F, 0xF0, 0xCC, 0x19, 0x81, 0x98, 0x19, 0x8F,
  0xFC, 0xFF, 0xC3, 0x30, 0x66, 0x06, 0x60, 0x66, 0x04, 0xC0, 0x03, 0x00,
  0x60, 0x0C, 0x07, 0xC1, 0xFC, 0x7B, 0x8E, 0x31, 0x87, 0x30, 0xE7, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0xE7, 0x0E, 0xE1, 0x9C, 0x73, 0xDE,
  0x3F, 0x83, 0xE0, 0x30, 0x06, 0x00, 0x38, 0x07, 0xC0, 0x66, 0x2C, 0x66,
  0xC6, 0xCC, 0xDC, 0x7D, 0x87, 0xB0, 0x06, 0x00, 0x60, 0x0D, 0xE1, 0xBE,
  0x1B, 0x33, 0x23, 0x66, 0x36, 0x27, 0x03, 0xE0, 0x1C, 0x0F, 0x01, 0xF8,
  0x1D, 0xC3, 0x9C, 0x39, 0xC3, 0x98, 0x3B, 0x81, 0xF0, 0x1E, 0x03, 0xE6,
  0x7E, 0x6E, 0x76, 0xE7, 0xEC, 0x3C, 0xE3, 0xCF, 0x7C, 0x7F, 0xC3, 0xCE,
  0x6F, 0x6D, 0x80, 0x01, 0x07, 0x0E, 0x0C, 0x1C, 0x18, 0x38, 0x30, 0x70,
  0x70, 0x60, 0x60, 0x60, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x60,
  0x60, 0x60, 0x30, 0x30, 0x10, 0x08, 0x18, 0x0C, 0x0E, 0x06, 0x06, 0x06,
  0x06, 0x07, 0x07, 0x07, 0x06, 0x06, 0x06, 0x0E, 0x0E, 0x0E, 0x0C, 0x1C,
  0x1C, 0x18, 0x38, 0x70, 0x60, 0xC0, 0x80, 0x06, 0x01, 0x80, 0x61, 0x99,
  0xFF, 0xCF, 0xE1, 0xE0, 0xF8, 0x33, 0x18, 0xC2, 0x20, 0x06, 0x01, 0x80,
  0xE0, 0x38, 0x0E, 0x3F, 0xFF, 0xFF, 0xFF, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x18, 0x00, 0x33, 0x77, 0x6E, 0xC0, 0xFF, 0xE0, 0xFF, 0x00, 0x00, 0xE0,
  0x18, 0x07, 0x00, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x01, 0xC0,
  0x30, 0x0E, 0x01, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x80,
  0x60, 0x00, 0x0F, 0x83, 0xF8, 0xF7, 0x1C, 0x67, 0x0E, 0xE1, 0xDC, 0x33,
  0x86, 0x61, 0xDC, 0x3B, 0x87, 0x70, 0xEE, 0x1D, 0xC3, 0x38, 0xE3, 0xB8,
  0x7F, 0x07, 0x80, 0x06, 0x3F, 0xF7, 0xE9, 0xC3, 0x87, 0x0E, 0x18, 0x30,
  0xE1, 0xC3, 0x87, 0x0C, 0x38, 0x70, 0xE0, 0x07, 0xC0, 0xFE, 0x1C, 0xE3,
  0x87, 0x38, 0x73, 0x86, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x80,
  0xF0, 0x1E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xFF, 0xCF, 0xFC, 0x07, 0x80,
  0xFE, 0x1D, 0xE3, 0x86, 0x38, 0x60, 0x0E, 0x00, 0xE0, 0x3C, 0x0F, 0x80,
  0xF8, 0x01, 0xC0, 0x0C, 0x00, 0xC6, 0x1C, 0x71, 0xC7, 0xBC, 0x3F, 0x81,
  0xE0, 0x00, 0xE0, 0x1C, 0x07, 0x81, 0xF0, 0x3E, 0x0D, 0xC3, 0xB0, 0x6E,
  0x19, 0xC7, 0x38, 0xC7, 0x38, 0xEF, 0xFF, 0xFF, 0xC0, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x1F, 0xE3, 0xFC, 0x7F, 0x9C, 0x03, 0x80, 0x60, 0x0F, 0xC3,
  0xFC, 0x7B, 0x80, 0x38, 0x07, 0x00, 0xE0, 0x1D, 0xC3, 0xB8, 0xE7, 0xBC,
  0x7F, 0x07, 0xC0, 0x03, 0x83, 0xE1, 0xF0, 0x70, 0x38, 0x0C, 0x07, 0xF1,
  0xFE, 0x7B, 0xFC, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x39, 0xDE, 0x7F,
  0x0F, 0x80, 0x7F, 0xF7, 0xFF, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x03,
  0x80, 0x38, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x38,
  0x03, 0x80, 0x70, 0x07, 0x00, 0x0F, 0x83, 0xF8, 0xF7, 0x1C, 0x73, 0x0E,
  0x61, 0x8C, 0x71, 0xDE, 0x1F, 0x87, 0xE1, 0xCE, 0x70, 0xCE, 0x19, 0xC3,
  0x38, 0xE7, 0xBC, 0x7F, 0x07, 0xC0, 0x1E, 0x1F, 0x9E, 0xEC, 0x7E, 0x1F,
  0x0F, 0x87, 0xC7, 0xE3, 0xFB, 0xDF, 0xE7, 0x60, 0x70, 0x38, 0x39, 0xF8,
  0xF8, 0x70, 0x00, 0x3B, 0xCC, 0x00, 0x00, 0x00, 0x00, 0x39, 0xCC, 0x00,
  0x1C, 0x70, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0x8C, 0x31, 0xC6, 0x38,
  0x40, 0x00, 0x81, 0xC3, 0xE7, 0xE7, 0xC7, 0x83, 0x81, 0xF0, 0x3E, 0x0F,
  0x81, 0xC0, 0x40, 0x7F, 0xDF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xEF, 0xF8,
  0x40, 0x38, 0x1F, 0x03, 0xE0, 0x78, 0x1C, 0x3E, 0xFC, 0xF8, 0x70, 0x20,
  0x00, 0x1E, 0x3F, 0x9D, 0xDC, 0x7E, 0x38, 0x18, 0x1C, 0x1E, 0x1E, 0x0E,
  0x0E, 0x06, 0x07, 0x00, 0x00, 0x00, 0xC0, 0xF0, 0x30, 0x00, 0x01, 0xF8,
  0x01, 0xFE, 0x03, 0x81, 0x83, 0x80, 0x61, 0x80, 0x31, 0x87, 0x08, 0xCF,
  0xE6, 0xC6, 0x63, 0x66, 0x31, 0xE3, 0x18, 0xF3, 0x8C, 0x59, 0x8C, 0x6C,
  0xC6, 0x36, 0x63, 0x1B, 0x33, 0x99, 0x9F, 0xF8, 0xC7, 0x38, 0x60, 0x00,
  0x30, 0x00, 0x1C, 0x00, 0x07, 0x04, 0x01, 0xFE, 0x00, 0x7E, 0x00, 0x00,
  0xE0, 0x03, 0x80, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x33, 0x01,
  0xCC, 0x06, 0x30, 0x38, 0xC0, 0xC3, 0x87, 0xFE, 0x1F, 0xF8, 0xFF, 0xE3,
  0x83, 0x9C, 0x0E, 0x70, 0x1B, 0x80, 0x70, 0x1F, 0xE0, 0xFF, 0x87, 0xFE,
  0x38, 0x71, 0xC3, 0x9C, 0x1C, 0xE1, 0xC7, 0x1E, 0x3F, 0xE1, 0xFF, 0x0E,
  0x18, 0xE0, 0xE7, 0x07, 0x38, 0x39, 0xC3, 0x8E, 0x7C, 0x7F, 0xC7, 0xFC,
  0x00, 0x07, 0xC0, 0x7F, 0x07, 0xBC, 0x70, 0x63, 0x03, 0xB8, 0x1D, 0xC0,
  0x0E, 0x00, 0x70, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x06, 0x70, 0x71,
  0x83, 0x8F, 0x78, 0x3F, 0x80, 0xF8, 0x00, 0x1F, 0xC0, 0xFF, 0x07, 0xFC,
  0x38, 0x71, 0xC3, 0x9C, 0x1C, 0xE0, 0xE7, 0x07, 0x38, 0x39, 0xC1, 0xCE,
  0x0E, 0xE0, 0xE7, 0x07, 0x38, 0x39, 0xC3, 0x8E, 0x78, 0x7F, 0x87, 0xF8,
  0x00, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x3F, 0xE1, 0xFE, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x7F, 0xC7, 0xFE, 0x00, 0x1F, 0xF8, 0xFF, 0x87, 0xFC,
  0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x3F, 0xC1, 0xFE, 0x0E,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00,
  0x00, 0x07, 0xC0, 0x7F, 0x07, 0xBC, 0x70, 0x63, 0x83, 0xB8, 0x1D, 0xC0,
  0x0E, 0x00, 0x70, 0x07, 0x1F, 0xB8, 0xFD, 0xC0, 0xEE, 0x07, 0x70, 0x71,
  0xC3, 0x8F, 0xFC, 0x3F, 0xC0, 0xF8, 0x00, 0x1C, 0x0E, 0x38, 0x1C, 0x70,
  0x38, 0xE0, 0x71, 0xC1, 0xC7, 0x03, 0x8E, 0x07, 0x1C, 0x0E, 0x3F, 0xFC,
  0x7F, 0xF8, 0xE0, 0xE3, 0x81, 0xC7, 0x03, 0x8E, 0x07, 0x1C, 0x0E, 0x38,
  0x18, 0x60, 0x71, 0xC0, 0xE0, 0x1C, 0x71, 0xC7, 0x1C, 0x63, 0x8E, 0x38,
  0xE3, 0x8C, 0x71, 0xC7, 0x1C, 0x71, 0x80, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xC0,
  0x1C, 0x01, 0xCE, 0x1C, 0xE3, 0x87, 0xF8, 0x7F, 0x03, 0xE0, 0x1C, 0x1E,
  0x38, 0x78, 0x71, 0xE0, 0xE3, 0x81, 0xCE, 0x07, 0x38, 0x0E, 0xF0, 0x1F,
  0xC0, 0x3F, 0x00, 0x7F, 0x00, 0xFE, 0x03, 0xCE, 0x07, 0x1C, 0x0E, 0x38,
  0x1C, 0x38, 0x38, 0x70, 0x60, 0xE1, 0xC0, 0xE0, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x81, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x7F, 0xFF, 0xF0, 0x1E, 0x01, 0xC3, 0xC0, 0x78,
  0x78, 0x0F, 0x0F, 0x03, 0xE1, 0xF0, 0x7C, 0x7E, 0x1F, 0x8F, 0xC3, 0x61,
  0xD8, 0xEC, 0x3B, 0x1B, 0x87, 0x67, 0x70, 0xCC, 0xEE, 0x39, 0x99, 0xC7,
  0x37, 0x30, 0xE7, 0xCE, 0x1C, 0xF9, 0xC3, 0x8E, 0x38, 0x61, 0xC7, 0x1C,
  0x30, 0xE0, 0x1C, 0x0E, 0x3C, 0x1C, 0x78, 0x38, 0xF0, 0x71, 0xF1, 0xC7,
  0x63, 0x8E, 0xC7, 0x1D, 0x8E, 0x3B, 0x9C, 0x73, 0x38, 0xE6, 0xE3, 0x8F,
  0xC7, 0x0F, 0x8E, 0x1F, 0x1C, 0x3E, 0x38, 0x78, 0x70, 0x71, 0xC0, 0xE0,
  0x07, 0xC0, 0x7F, 0x07, 0xFC, 0x70, 0x73, 0x83, 0xB8, 0x1D, 0xC0, 0xEE,
  0x07, 0x70, 0x3F, 0x01, 0xF8, 0x1D, 0xC0, 0xEE, 0x07, 0x70, 0x39, 0xC3,
  0x8F, 0xF8, 0x3F, 0x80, 0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0xC1, 0xFF, 0x87,
  0x0E, 0x1C, 0x1C, 0xE0, 0x73, 0x83, 0x8E, 0x0E, 0x38, 0xF8, 0xFF, 0xC3,
  0xFC, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x03,
  0x80, 0x00, 0x07, 0xC0, 0x7F, 0x07, 0xFC, 0x70, 0xE3, 0x83, 0xB8, 0x1D,
  0xC0, 0xEE, 0x07, 0x60, 0x3F, 0x01, 0xB8, 0x1D, 0xC0, 0xEE, 0x07, 0x70,
  0x31, 0xC3, 0x8F, 0xF8, 0x3F, 0x80, 0xFC, 0x00, 0x70, 0x01, 0xC0, 0x08,
  0x00, 0x1F, 0xE0, 0xFF, 0x87, 0xFE, 0x38, 0x71, 0xC3, 0x9C, 0x1C, 0xE0,
  0xE7, 0x0E, 0x39, 0xF1, 0xFF, 0x0F, 0xF0, 0xE3, 0x87, 0x1C, 0x38, 0xE1,
  0xC3, 0x8E, 0x1C, 0x70, 0xE7, 0x07, 0x00, 0x07, 0x81, 0xFE, 0x3F, 0xE3,
  0x87, 0x70, 0x77, 0x00, 0x38, 0x03, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xC0,
  0x1C, 0xC0, 0xCE, 0x1C, 0xE1, 0xCF, 0xFC, 0x7F, 0x83, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x1C, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x38, 0x39, 0xC1, 0xCE, 0x0E, 0x70, 0x77, 0x03, 0x38, 0x39, 0xC1,
  0xCE, 0x0E, 0x70, 0x73, 0x03, 0xB8, 0x19, 0xC1, 0xCE, 0x0E, 0x70, 0x73,
  0x87, 0x9F, 0x78, 0x7F, 0x81, 0xF8, 0x00, 0xE0, 0x3F, 0x03, 0xF8, 0x1D,
  0xC1, 0xE7, 0x0E, 0x38, 0x71, 0xC7, 0x0E, 0x38, 0x73, 0x83, 0x9C, 0x1C,
  0xE0, 0x6E, 0x03, 0x70, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xC0,
  0x00, 0xE1, 0xC3, 0xF0, 0xE1, 0xF8, 0x70, 0xFC, 0x78, 0xEE, 0x3C, 0x77,
  0x1E, 0x39, 0x9F, 0x38, 0xCD, 0x9C, 0x66, 0xCE, 0x37, 0x66, 0x1B, 0x37,
  0x0D, 0x9B, 0x87, 0xCF, 0x83, 0xC7, 0xC1, 0xE3, 0xE0, 0xF1, 0xE0, 0x70,
  0x70, 0x38, 0x38, 0x00, 0x0E, 0x0E, 0x0E, 0x1E, 0x0E, 0x1C, 0x0F, 0x38,
  0x07, 0x78, 0x07, 0x70, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0,
  0x07, 0xC0, 0x0F, 0xE0, 0x0E, 0xE0, 0x1C, 0xE0, 0x1C, 0x70, 0x38, 0x70,
  0x78, 0x70, 0x70, 0x78, 0xE0, 0x73, 0x07, 0x9C, 0x38, 0xE3, 0xC7, 0x1C,
  0x19, 0xC0, 0xCE, 0x07, 0xE0, 0x3F, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x1F, 0xF8,
  0x7F, 0xE3, 0xFF, 0x80, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x3C, 0x00, 0xFF, 0xE3, 0xFF, 0x80, 0x1F, 0x1F, 0x1C, 0x1C, 0x1C, 0x18,
  0x18, 0x38, 0x38, 0x38, 0x38, 0x38, 0x30, 0x70, 0x70, 0x70, 0x70, 0x70,
  0x60, 0x60, 0xE0, 0xE0, 0xE0, 0xF0, 0xF0, 0xE3, 0x86, 0x18, 0x61, 0xC7,
  0x1C, 0x71, 0xC3, 0x0C, 0x38, 0xE3, 0x8E, 0x38, 0x61, 0x86, 0x1F, 0x1F,
  0x06, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0C, 0x0C, 0x1C, 0x1C, 0x1C, 0x1C,
  0x1C, 0x18, 0x38, 0x38, 0x38, 0x38, 0x38, 0x30, 0x30, 0xF0, 0xF0, 0x0C,
  0x0E, 0x1E, 0x1E, 0x36, 0x36, 0x66, 0x67, 0xE3, 0xFF, 0xFF, 0xC0, 0xEE,
  0x73, 0x0F, 0x83, 0xF8, 0xF7, 0x1C, 0x60, 0x0C, 0x3F, 0x8F, 0xF3, 0x8E,
  0x61, 0xDC, 0x31, 0xDE, 0x3F, 0xC3, 0xF8, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0x80, 0x70, 0x0E, 0xF1, 0xFE, 0x3D, 0xE7, 0x1C, 0xC3, 0xB8, 0x77,
  0x0E, 0xE1, 0xDC, 0x3B, 0x8E, 0x7B, 0xDF, 0xF3, 0xBC, 0x00, 0x1F, 0x0F,
  0xE7, 0xB9, 0x87, 0xE1, 0xF8, 0x0E, 0x03, 0x80, 0xC3, 0xB8, 0xEF, 0x71,
  0xF8, 0x3C, 0x00, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x1E, 0xC3, 0xEC, 0x7B, 0xCE, 0x1C, 0xE1, 0xCE, 0x1C, 0xE1, 0x8E, 0x38,
  0xC3, 0x8E, 0x38, 0xF7, 0x8F, 0xF8, 0x7B, 0x00, 0x1F, 0x0F, 0xE7, 0xB9,
  0xC7, 0xE1, 0xFF, 0xFF, 0xFB, 0x80, 0xE0, 0x38, 0x4F, 0x71, 0xFC, 0x3E,
  0x00, 0x07, 0x0F, 0x1E, 0x1C, 0x38, 0x38, 0x7E, 0xFE, 0x38, 0x30, 0x70,
  0x70, 0x70, 0x70, 0x70, 0x60, 0xE0, 0xE0, 0xE0, 0x0F, 0x71, 0xFE, 0x3D,
  0xE7, 0x8E, 0x70, 0xE7, 0x0E, 0x70, 0xE7, 0x0C, 0x61, 0xC7, 0x1C, 0x7B,
  0xC7, 0xFC, 0x3D, 0xC0, 0x18, 0x03, 0x8E, 0x78, 0xFF, 0x03, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x70, 0x0E, 0xE1, 0xFE, 0x3D, 0xE7,
  0x1C, 0xC3, 0xB8, 0x77, 0x0C, 0xE3, 0x9C, 0x73, 0x0E, 0xE1, 0xDC, 0x33,
  0x86, 0x00, 0x1C, 0x71, 0xC0, 0x00, 0xE3, 0x8E, 0x38, 0xE3, 0x1C, 0x71,
  0xC7, 0x18, 0x63, 0x80, 0x03, 0x81, 0xC0, 0xE0, 0x00, 0x00, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x18, 0x1C, 0x0E,
  0x07, 0x03, 0x83, 0x83, 0xC3, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x18, 0x03, 0x80, 0x38, 0xE3, 0x9E, 0x3B, 0xC3, 0xF8, 0x37, 0x07, 0xE0,
  0x7E, 0x07, 0xF0, 0x77, 0x06, 0x38, 0x63, 0x8E, 0x38, 0xE1, 0xC0, 0x1C,
  0x71, 0xC7, 0x1C, 0x63, 0x8E, 0x38, 0xE3, 0x8C, 0x71, 0xC7, 0x1C, 0x61,
  0x8E, 0x00, 0x3B, 0x8F, 0x1F, 0xEF, 0x8F, 0x7D, 0xE7, 0x1C, 0x73, 0x0E,
  0x3B, 0x86, 0x1D, 0xC3, 0x0E, 0xE3, 0x86, 0x71, 0xC7, 0x38, 0xE3, 0x98,
  0x71, 0xDC, 0x30, 0xEE, 0x38, 0x70, 0x3B, 0xC7, 0xF8, 0xF7, 0x9C, 0x73,
  0x0E, 0xE1, 0xDC, 0x33, 0x8E, 0x71, 0xCC, 0x3B, 0x87, 0x70, 0xCE, 0x18,
  0x1F, 0x0F, 0xE7, 0xBD, 0xC7, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8,
  0xEF, 0x79, 0xFC, 0x3E, 0x00, 0x1D, 0xE1, 0xFE, 0x1E, 0xF1, 0xC7, 0x18,
  0x73, 0x87, 0x38, 0x73, 0x87, 0x38, 0x73, 0x8E, 0x3D, 0xE7, 0xFC, 0x77,
  0x87, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0x1E, 0xE7, 0xD9, 0xEF,
  0x70, 0xEE, 0x1D, 0xC3, 0xB8, 0x67, 0x1C, 0xC3, 0x9C, 0x73, 0xDE, 0x7F,
  0xC7, 0xB0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x3B, 0x3F, 0x3F,
  0x38, 0x30, 0x70, 0x70, 0x70, 0x70, 0x70, 0x60, 0xE0, 0xE0, 0x0F, 0x07,
  0xF3, 0x9C, 0xC3, 0x38, 0x0F, 0x01, 0xF0, 0x1E, 0x03, 0xB8, 0x67, 0x39,
  0xFC, 0x3E, 0x00, 0x38, 0x70, 0xE7, 0xFF, 0xC6, 0x1C, 0x38, 0x70, 0xE1,
  0x83, 0x0E, 0x1F, 0x1E, 0x38, 0x70, 0xCE, 0x39, 0xC7, 0x38, 0xE6, 0x1D,
  0xC3, 0xB8, 0x67, 0x1C, 0xE3, 0x9C, 0x73, 0xDE, 0x7F, 0x87, 0xB0, 0xE1,
  0xD8, 0x76, 0x39, 0x8E, 0x67, 0x1D, 0xC7, 0x61, 0xF8, 0x7C, 0x0F, 0x03,
  0xC0, 0xE0, 0x38, 0x00, 0xC7, 0x1F, 0x1C, 0x7C, 0x73, 0xB3, 0xCE, 0xCF,
  0x33, 0x7D, 0xCD, 0xB7, 0x36, 0xD8, 0xF3, 0xE3, 0xCF, 0x0F, 0x3C, 0x38,
  0x70, 0xE1, 0x80, 0x1C, 0x71, 0xCE, 0x1C, 0xE0, 0xDC, 0x0F, 0x80, 0xF8,
  0x07, 0x00, 0xF0, 0x1F, 0x81, 0xF8, 0x39, 0x87, 0x1C, 0x71, 0xC0, 0x38,
  0x71, 0x87, 0x18, 0xE1, 0x8E, 0x1D, 0xC1, 0xDC, 0x1F, 0x81, 0xF8, 0x1F,
  0x01, 0xF0, 0x0E, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x1C, 0x0F, 0x80, 0xF0,
  0x0E, 0x00, 0x3F, 0xE7, 0xF8, 0x07, 0x01, 0xC0, 0x70, 0x1E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0xC0, 0x7F, 0xCF, 0xF8, 0x02, 0x1C, 0x30, 0xE1,
  0x83, 0x0E, 0x1C, 0x38, 0x71, 0xC7, 0x0E, 0x0C, 0x1C, 0x38, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x0C, 0x08, 0x0C, 0x61, 0x86, 0x18, 0x61, 0x84, 0x30,
  0xC3, 0x0C, 0x30, 0xC6, 0x18, 0x61, 0x86, 0x18, 0xC0, 0x08, 0x1C, 0x0C,
  0x0E, 0x0E, 0x0E, 0x0E, 0x0C, 0x0C, 0x0E, 0x07, 0x0F, 0x1C, 0x1C, 0x18,
  0x38, 0x38, 0x38, 0x38, 0x30, 0x70, 0xE0, 0xC0, 0x3C, 0x37, 0xE7, 0x7F,
  0xEE, 0x7E, 0xC3, 0xC0,
};

const GFXglyph RobotoCondensed_MediumItalic25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 5, 18, 6, 1, -18 },
  { 13, 7, 6, 8, 2, -19 },
  { 19, 12, 18, 13, 1, -18 },
  { 46, 11, 23, 12, 1, -21 },
  { 78, 12, 18, 15, 2, -18 },
  { 105, 12, 18, 14, 1, -18 },
  { 132, 3, 6, 4, 2, -19 },
  { 135, 8, 26, 8, 1, -20 },
  { 161, 8, 26, 8, -1, -20 },
  { 187, 10, 11, 11, 1, -18 },
  { 201, 10, 13, 12, 1, -15 },
  { 218, 4, 7, 5, -1, -3 },
  { 222, 6, 2, 8, 1, -8 },
  { 224, 3, 3, 7, 1, -3 },
  { 226, 11, 20, 8, -1, -18 },
  { 254, 11, 18, 12, 1, -18 },
  { 279, 7, 18, 12, 3, -18 },
  { 295, 12, 18, 12, 0, -18 },
  { 322, 12, 18, 12, 0, -18 },
  { 349, 11, 18, 12, 0, -18 },
  { 374, 11, 18, 12, 1, -18 },
  { 399, 10, 18, 12, 1, -18 },
  { 422, 12, 18, 12, 1, -18 },
  { 449, 11, 18, 12, 1, -18 },
  { 474, 9, 18, 12, 2, -18 },
  { 495, 5, 13, 6, 1, -13 },
  { 504, 6, 17, 6, -1, -13 },
  { 517, 9, 12, 11, 1, -14 },
  { 531, 10, 7, 12, 1, -12 },
  { 540, 9, 11, 11, 1, -13 },
  { 553, 9, 18, 11, 2, -18 },
  { 574, 17, 23, 19, 1, -17 },
  { 623, 14, 18, 14, -1, -18 },
  { 655, 13, 18, 13, 0, -18 },
  { 685, 13, 18, 14, 1, -18 },
  { 715, 13, 18, 14, 0, -18 },
  { 745, 13, 18, 12, 0, -18 },
  { 775, 13, 18, 12, 0, -18 },
  { 805, 13, 18, 14, 1, -18 },
  { 835, 15, 18, 15, 0, -18 },
  { 869, 6, 18, 6, 0, -18 },
  { 883, 12, 18, 12, 0, -18 },
  { 910, 15, 18, 13, 0, -18 },
  { 944, 10, 18, 12, 0, -18 },
  { 967, 19, 18, 18, 0, -18 },
  { 1010, 15, 18, 15, 0, -18 },
  { 1044, 13, 18, 15, 1, -18 },
  { 1074, 14, 18, 14, 0, -18 },
  { 1106, 13, 21, 15, 1, -18 },
  { 1141, 13, 18, 13, 0, -18 },
  { 1171, 12, 18, 13, 1, -18 },
  { 1198, 12, 18, 13, 2, -18 },
  { 1225, 13, 18, 14, 1, -18 },
  { 1255, 13, 18, 14, 2, -18 },
  { 1285, 17, 18, 18, 2, -18 },
  { 1324, 16, 18, 13, -1, -18 },
  { 1360, 13, 18, 13, 2, -18 },
  { 1390, 14, 18, 13, 0, -18 },
  { 1422, 8, 25, 6, 0, -21 },
  { 1447, 6, 20, 9, 2, -18 },
  { 1462, 8, 25, 6, -1, -21 },
  { 1487, 8, 9, 9, 1, -18 },
  { 1496, 9, 2, 10, -1, 0 },
  { 1499, 4, 4, 8, 3, -19 },
  { 1501, 11, 13, 12, 0, -13 },
  { 1519, 11, 19, 12, 0, -19 },
  { 1546, 10, 13, 11, 1, -13 },
  { 1563, 12, 19, 12, 1, -19 },
  { 1592, 10, 13, 12, 1, -13 },
  { 1609, 8, 19, 8, 1, -19 },
  { 1628, 12, 18, 12, 0, -13 },
  { 1655, 11, 19, 12, 0, -19 },
  { 1682, 6, 18, 6, 0, -18 },
  { 1696, 9, 23, 6, -3, -18 },
  { 1722, 12, 19, 11, 0, -19 },
  { 1751, 6, 19, 6, 0, -19 },
  { 1766, 17, 13, 18, 0, -13 },
  { 1794, 11, 13, 12, 0, -13 },
  { 1812, 10, 13, 12, 1, -13 },
  { 1829, 12, 18, 12, -1, -13 },
  { 1856, 11, 18, 12, 1, -13 },
  { 1881, 8, 13, 8, 0, -13 },
  { 1894, 10, 13, 11, 0, -13 },
  { 1911, 7, 16, 7, 1, -16 },
  { 1925, 11, 13, 12, 1, -13 },
  { 1943, 10, 13, 11, 1, -13 },
  { 1960, 14, 13, 16, 2, -13 },
  { 1983, 12, 13, 11, -1, -13 },
  { 2003, 12, 18, 10, -1, -13 },
  { 2030, 11, 13, 11, 0, -13 },
  { 2048, 7, 24, 7, 1, -20 },
  { 2069, 6, 21, 6, 0, -18 },
  { 2085, 8, 23, 7, -1, -19 },
  { 2108, 12, 5, 14, 1, -10 },
};

const GFXfont RobotoCondensed_MediumItalic25pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_MediumItalic25pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_MediumItalic25pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _ROBOTOCONDENSED_MEDIUMITALIC25PT7B_H_
