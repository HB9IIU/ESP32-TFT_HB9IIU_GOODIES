#ifndef _ROBOTOCONDENSED_SEMIBOLD10PT7B_H_
#define _ROBOTOCONDENSED_SEMIBOLD10PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-SemiBold.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_SemiBold10pt7bBitmaps[] PROGMEM = {
  0x00, 0xFA, 0xB6, 0x80, 0x31, 0x9E, 0xAF, 0xA9, 0x40, 0x23, 0x94, 0x83,
  0x09, 0x6E, 0x20, 0x62, 0xA7, 0x04, 0x2C, 0xD0, 0xC0, 0x71, 0x45, 0x1A,
  0xFB, 0x67, 0x80, 0xE0, 0x6A, 0xAA, 0x90, 0x89, 0x32, 0x5A, 0x50, 0x2F,
  0x65, 0x22, 0xF2, 0x20, 0x58, 0xC0, 0x80, 0x24, 0xA4, 0xA4, 0x72, 0xB7,
  0xBD, 0xA9, 0xC0, 0x75, 0x54, 0x76, 0x84, 0x22, 0x23, 0xE0, 0x76, 0x84,
  0x61, 0x69, 0xC0, 0x31, 0x94, 0xAF, 0x88, 0x40, 0xE8, 0xE2, 0x3A, 0xE0,
  0x68, 0xEB, 0xBA, 0xE0, 0xF8, 0x84, 0x62, 0x11, 0x00, 0x72, 0x94, 0xE5,
  0x29, 0xC0, 0x75, 0xD5, 0x71, 0x60, 0x88, 0x40, 0x58, 0x1E, 0xE1, 0xE3,
  0x80, 0x8D, 0xC0, 0x7D, 0x12, 0x20, 0x60, 0x3C, 0x85, 0x6D, 0x5A, 0xB5,
  0x55, 0xA0, 0x38, 0x30, 0xC3, 0x16, 0x79, 0x2C, 0xC0, 0xE9, 0x9E, 0x99,
  0xF0, 0x7A, 0x71, 0x8C, 0x25, 0xE0, 0xE9, 0x99, 0x99, 0xE0, 0xF8, 0x8E,
  0x88, 0xF0, 0xF8, 0x8E, 0x88, 0x80, 0x7A, 0x51, 0xB4, 0xA5, 0xE0, 0x9C,
  0xE7, 0xF9, 0xCE, 0x60, 0xFE, 0x11, 0x11, 0x1D, 0x70, 0x95, 0x39, 0xCA,
  0x5A, 0x40, 0x88, 0x88, 0x88, 0xF0, 0x8F, 0x3C, 0xF5, 0xB6, 0xDA, 0x40,
  0x9E, 0xF7, 0xFB, 0xDE, 0x60, 0x79, 0x24, 0xF3, 0x4D, 0x27, 0x80, 0xF9,
  0x9F, 0x88, 0x80, 0x79, 0x2C, 0xB3, 0xC9, 0x27, 0x82, 0xE9, 0x9E, 0xAB,
  0x90, 0x72, 0x50, 0x61, 0xE5, 0xC0, 0xF9, 0x08, 0x42, 0x10, 0x80, 0x99,
  0x99, 0x99, 0xE0, 0xC9, 0x24, 0x96, 0x70, 0xC3, 0x00, 0xD2, 0xB5, 0x6A,
  0xF6, 0xCD, 0x99, 0x00, 0x4A, 0xCC, 0x67, 0x2F, 0x20, 0xCA, 0xD4, 0x62,
  0x10, 0x80, 0xF8, 0x84, 0x46, 0x23, 0xE0, 0xFF, 0xC0, 0xC4, 0x44, 0x62,
  0x23, 0xD5, 0x55, 0x70, 0x66, 0x6A, 0xF0, 0x48, 0x75, 0x7D, 0x70, 0x88,
  0x8E, 0xBB, 0xBE, 0x7D, 0xCD, 0x70, 0x11, 0x17, 0xDD, 0xD7, 0x75, 0xFC,
  0x70, 0x69, 0x74, 0x92, 0x7D, 0xDD, 0x71, 0x70, 0x92, 0x7B, 0x6D, 0xBE,
  0x45, 0x55, 0xC0, 0x88, 0x8A, 0xCC, 0xEA, 0xFF, 0xFE, 0x9A, 0x69, 0xA4,
  0xF6, 0xDA, 0x76, 0xF7, 0xB7, 0x00, 0xEB, 0xBB, 0xE8, 0x80, 0x7D, 0xDD,
  0x71, 0x10, 0xEA, 0x80, 0x7D, 0x7D, 0x70, 0x4B, 0xA4, 0x98, 0xB6, 0xDE,
  0xD5, 0x76, 0x60, 0x95, 0xD7, 0x5A, 0x68, 0x56, 0x26, 0xD0, 0xD5, 0x76,
  0x66, 0x40, 0xF3, 0x24, 0xF0, 0x29, 0x28, 0x92, 0x44, 0xFF, 0x89, 0x22,
  0x92, 0x50, 0xDB,
};

const GFXglyph RobotoCondensed_SemiBold10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 7, 3, 1, -7 },
  { 2, 3, 3, 3, 0, -8 },
  { 4, 5, 7, 5, 0, -7 },
  { 9, 5, 9, 5, 0, -8 },
  { 15, 6, 7, 6, 0, -7 },
  { 21, 6, 7, 6, 0, -7 },
  { 27, 1, 3, 2, 0, -8 },
  { 28, 2, 10, 3, 1, -8 },
  { 31, 3, 10, 3, 0, -8 },
  { 35, 4, 4, 4, 0, -7 },
  { 37, 4, 5, 5, 0, -6 },
  { 40, 2, 3, 2, 0, -1 },
  { 41, 2, 1, 3, 1, -4 },
  { 42, 1, 1, 3, 1, -1 },
  { 43, 3, 8, 3, 0, -7 },
  { 46, 5, 7, 5, 0, -7 },
  { 51, 2, 7, 5, 1, -7 },
  { 53, 5, 7, 5, 0, -7 },
  { 58, 5, 7, 5, 0, -7 },
  { 63, 5, 7, 5, 0, -7 },
  { 68, 4, 7, 5, 1, -7 },
  { 72, 4, 7, 5, 1, -7 },
  { 76, 5, 7, 5, 0, -7 },
  { 81, 5, 7, 5, 0, -7 },
  { 86, 4, 7, 5, 0, -7 },
  { 90, 1, 5, 3, 1, -5 },
  { 91, 2, 7, 2, 0, -5 },
  { 93, 4, 4, 4, 0, -5 },
  { 95, 3, 3, 5, 1, -5 },
  { 97, 3, 4, 5, 1, -5 },
  { 99, 4, 7, 4, 0, -7 },
  { 103, 7, 9, 8, 0, -7 },
  { 111, 6, 7, 6, 0, -7 },
  { 117, 4, 7, 6, 1, -7 },
  { 121, 5, 7, 6, 0, -7 },
  { 126, 4, 7, 6, 1, -7 },
  { 130, 4, 7, 5, 1, -7 },
  { 134, 4, 7, 5, 1, -7 },
  { 138, 5, 7, 6, 0, -7 },
  { 143, 5, 7, 6, 1, -7 },
  { 148, 1, 7, 3, 1, -7 },
  { 149, 4, 7, 5, 0, -7 },
  { 153, 5, 7, 6, 1, -7 },
  { 158, 4, 7, 5, 1, -7 },
  { 162, 6, 7, 8, 1, -7 },
  { 168, 5, 7, 6, 1, -7 },
  { 173, 6, 7, 6, 0, -7 },
  { 179, 4, 7, 6, 1, -7 },
  { 183, 6, 8, 6, 0, -7 },
  { 189, 4, 7, 5, 1, -7 },
  { 193, 5, 7, 5, 0, -7 },
  { 198, 5, 7, 5, 0, -7 },
  { 203, 4, 7, 6, 1, -7 },
  { 207, 6, 7, 6, 0, -7 },
  { 213, 7, 7, 8, 0, -7 },
  { 220, 5, 7, 6, 0, -7 },
  { 225, 5, 7, 5, 0, -7 },
  { 230, 5, 7, 5, 0, -7 },
  { 235, 1, 10, 3, 1, -8 },
  { 237, 4, 8, 4, 0, -7 },
  { 241, 2, 10, 3, 0, -8 },
  { 244, 4, 4, 4, 0, -7 },
  { 246, 4, 1, 4, 0, 0 },
  { 247, 3, 2, 3, 0, -8 },
  { 248, 4, 5, 5, 0, -5 },
  { 251, 4, 8, 5, 1, -8 },
  { 255, 4, 5, 5, 0, -5 },
  { 258, 4, 8, 5, 0, -8 },
  { 262, 4, 5, 5, 0, -5 },
  { 265, 3, 8, 3, 0, -8 },
  { 268, 4, 7, 5, 0, -5 },
  { 272, 3, 8, 5, 1, -8 },
  { 275, 1, 7, 2, 1, -7 },
  { 276, 2, 9, 2, 0, -7 },
  { 279, 4, 8, 5, 1, -8 },
  { 283, 1, 8, 2, 1, -8 },
  { 284, 6, 5, 7, 1, -5 },
  { 288, 3, 5, 5, 1, -5 },
  { 290, 5, 5, 5, 0, -5 },
  { 294, 4, 7, 5, 1, -5 },
  { 298, 4, 7, 5, 0, -5 },
  { 302, 2, 5, 3, 1, -5 },
  { 304, 4, 5, 5, 0, -5 },
  { 307, 3, 7, 3, 0, -7 },
  { 310, 3, 5, 5, 1, -5 },
  { 312, 4, 5, 4, 0, -5 },
  { 315, 6, 5, 6, 0, -5 },
  { 319, 4, 5, 5, 0, -5 },
  { 322, 4, 7, 4, 0, -5 },
  { 326, 4, 5, 5, 0, -5 },
  { 329, 3, 10, 3, 0, -8 },
  { 333, 1, 8, 3, 1, -7 },
  { 334, 3, 10, 3, 0, -8 },
  { 338, 4, 2, 6, 1, -4 },
};

const GFXfont RobotoCondensed_SemiBold10pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_SemiBold10pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_SemiBold10pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _ROBOTOCONDENSED_SEMIBOLD10PT7B_H_
