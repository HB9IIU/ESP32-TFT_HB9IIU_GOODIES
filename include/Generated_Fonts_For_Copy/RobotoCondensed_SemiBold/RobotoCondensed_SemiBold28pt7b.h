#ifndef _ROBOTOCONDENSED_SEMIBOLD28PT7B_H_
#define _ROBOTOCONDENSED_SEMIBOLD28PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-SemiBold.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_SemiBold28pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0x00, 0xEF, 0xFE, 0xEF,
  0xDF, 0xBF, 0x7C, 0xF9, 0xF3, 0x80, 0x06, 0x60, 0x33, 0x01, 0x98, 0x1C,
  0xC0, 0xE6, 0x06, 0x71, 0xFF, 0xEF, 0xFF, 0x0C, 0xC0, 0xE6, 0x07, 0x30,
  0x33, 0x8F, 0xFF, 0x7F, 0xF8, 0x66, 0x03, 0x30, 0x39, 0x81, 0xCC, 0x0C,
  0xE0, 0x67, 0x00, 0x06, 0x00, 0x60, 0x06, 0x00, 0xF8, 0x3F, 0xC3, 0xFE,
  0x79, 0xE7, 0x8F, 0x70, 0xF7, 0x80, 0x78, 0x03, 0xE0, 0x1F, 0x80, 0xFC,
  0x03, 0xE0, 0x1E, 0x00, 0xFF, 0x0F, 0xF0, 0xF7, 0x8E, 0x7F, 0xE3, 0xFC,
  0x0F, 0x80, 0x60, 0x06, 0x00, 0x60, 0x3C, 0x00, 0x7E, 0x00, 0x66, 0x10,
  0xE7, 0x38, 0xE7, 0x30, 0xE7, 0x70, 0x66, 0x60, 0x7E, 0xE0, 0x3C, 0xC0,
  0x01, 0x80, 0x01, 0x80, 0x03, 0x3C, 0x03, 0x7E, 0x06, 0xE6, 0x0E, 0xE7,
  0x0C, 0xE7, 0x1C, 0xE7, 0x18, 0xE6, 0x00, 0x7E, 0x00, 0x3C, 0x0F, 0x00,
  0x3F, 0x00, 0xFF, 0x01, 0xCE, 0x07, 0x8E, 0x0F, 0x38, 0x0E, 0x70, 0x1F,
  0xE0, 0x1F, 0x80, 0x3C, 0x00, 0xFC, 0xE3, 0xFD, 0xCF, 0x7B, 0x9E, 0x7F,
  0x3C, 0x7E, 0x78, 0xF8, 0xF0, 0xF0, 0xFF, 0xF0, 0xFF, 0xE0, 0xF9, 0xE0,
  0xFF, 0xFF, 0xB0, 0x04, 0x31, 0xCE, 0x31, 0xC7, 0x18, 0xE3, 0x8E, 0x38,
  0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0x61, 0xC7, 0x0C, 0x38, 0x70, 0xC1,
  0x83, 0x0E, 0x1C, 0x70, 0xE3, 0x87, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7,
  0x1C, 0x71, 0xC7, 0x1C, 0xE3, 0x8C, 0x73, 0x8C, 0x20, 0x07, 0x00, 0x70,
  0x07, 0x04, 0x71, 0x7E, 0xFF, 0xFF, 0x0F, 0x80, 0xF8, 0x1D, 0x83, 0x9C,
  0x38, 0xE1, 0x08, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE1, 0xFF, 0xFF,
  0xFF, 0xFF, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x00, 0x39,
  0xCE, 0x73, 0xB9, 0xCC, 0xFF, 0xFF, 0xF8, 0x6F, 0xFE, 0x03, 0x81, 0xC0,
  0xC0, 0xE0, 0x70, 0x30, 0x38, 0x1C, 0x0E, 0x06, 0x07, 0x03, 0x81, 0x81,
  0xC0, 0xE0, 0x70, 0x30, 0x38, 0x1C, 0x0C, 0x06, 0x07, 0x00, 0x0F, 0x03,
  0xFC, 0x3F, 0xE7, 0x9E, 0x70, 0xE7, 0x0E, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0x70, 0xE7, 0x0E, 0x79, 0xE3,
  0xFC, 0x3F, 0xC0, 0xF0, 0x03, 0x0F, 0x7F, 0xFF, 0xFF, 0x8F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x1F, 0x83, 0xFC, 0x7F, 0xE7, 0x1E, 0xF0, 0xEF, 0x0E, 0x00, 0xE0, 0x0E,
  0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0xE0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0x03, 0xFC, 0x7F, 0xEF, 0x1E,
  0xF0, 0xE0, 0x0E, 0x00, 0xE0, 0x1E, 0x0F, 0xC0, 0xF8, 0x0F, 0xC0, 0x1E,
  0x00, 0xE0, 0x0F, 0xF0, 0xFF, 0x0E, 0xF1, 0xE7, 0xFE, 0x3F, 0xC1, 0xF0,
  0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x7C, 0x0F, 0xC0, 0xFC, 0x1D, 0xC1, 0xDC,
  0x39, 0xC3, 0x9C, 0x79, 0xC7, 0x1C, 0xF1, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x3F, 0xE3, 0xFE, 0x3F, 0xE3, 0x80,
  0x78, 0x07, 0x80, 0x70, 0x07, 0x78, 0x7F, 0xC7, 0xFE, 0x31, 0xE0, 0x0F,
  0x00, 0xF0, 0x0F, 0xF0, 0xF7, 0x0F, 0x79, 0xE7, 0xFE, 0x3F, 0xC0, 0xF8,
  0x03, 0x80, 0xF8, 0x1F, 0x83, 0xE0, 0x38, 0x07, 0x80, 0x70, 0x07, 0x78,
  0x7F, 0xE7, 0xFE, 0xF8, 0xFF, 0x0F, 0xF0, 0xF7, 0x0F, 0x70, 0xF7, 0x0F,
  0x78, 0xE3, 0xFE, 0x1F, 0xC0, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E,
  0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x78,
  0x07, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x03, 0xC0,
  0x0F, 0x03, 0xFC, 0x7F, 0xE7, 0x9E, 0x70, 0xE7, 0x0E, 0x70, 0xE7, 0x9E,
  0x3F, 0xC1, 0xF8, 0x3F, 0xC7, 0x9E, 0x70, 0xEF, 0x0F, 0xF0, 0xFF, 0x0F,
  0x79, 0xE7, 0xFE, 0x3F, 0xC0, 0xF8, 0x0F, 0x03, 0xF8, 0x7F, 0xC7, 0x9E,
  0x70, 0xEF, 0x0E, 0xF0, 0xEF, 0x0F, 0xF0, 0xF7, 0x9F, 0x7F, 0xF3, 0xFE,
  0x1E, 0xE0, 0x0E, 0x01, 0xE0, 0x1C, 0x07, 0xC1, 0xF8, 0x1F, 0x01, 0xC0,
  0xEF, 0xFE, 0x00, 0x00, 0x00, 0x06, 0xFF, 0xE0, 0x73, 0xDE, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x39, 0xCE, 0x73, 0xB8, 0x80, 0x00, 0x40, 0x70,
  0x7C, 0x7F, 0x7F, 0x3F, 0x0E, 0x03, 0xE0, 0x7F, 0x07, 0xF0, 0x7C, 0x07,
  0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0x80, 0x38, 0x0F, 0x83, 0xF8, 0x3F, 0x83, 0xF0, 0x3C, 0x3F, 0x3F, 0xBF,
  0x8F, 0x83, 0x80, 0x80, 0x00, 0x1F, 0x1F, 0xEF, 0xFF, 0xCF, 0xE1, 0xC0,
  0x70, 0x1C, 0x0F, 0x07, 0x83, 0xC0, 0xF0, 0x78, 0x1E, 0x07, 0x00, 0x00,
  0x00, 0x0C, 0x07, 0x81, 0xE0, 0x30, 0x01, 0xF8, 0x00, 0xFF, 0xC0, 0x3C,
  0x3C, 0x0E, 0x01, 0xC3, 0x80, 0x1C, 0x70, 0x01, 0x9C, 0x1E, 0x3B, 0x8F,
  0xE3, 0x61, 0xCC, 0x6C, 0x73, 0x8F, 0x8C, 0x71, 0xF3, 0x8E, 0x3E, 0x71,
  0xC7, 0xCE, 0x38, 0xF9, 0xC7, 0x1F, 0x38, 0xC7, 0xE7, 0xBC, 0xCC, 0x7D,
  0xF1, 0x87, 0x3C, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0xC2,
  0x00, 0x7F, 0xE0, 0x03, 0xF0, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0,
  0x03, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x07, 0x70, 0x0F, 0x70, 0x0E, 0x78,
  0x0E, 0x38, 0x1E, 0x38, 0x1E, 0x3C, 0x1C, 0x3C, 0x3F, 0xFC, 0x3F, 0xFE,
  0x3F, 0xFE, 0x78, 0x1E, 0x78, 0x0E, 0x78, 0x0F, 0x70, 0x0F, 0xFF, 0x8F,
  0xFC, 0xFF, 0xEE, 0x1F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0E, 0xFF, 0xEF,
  0xFC, 0xFF, 0xEE, 0x0F, 0xE0, 0xFE, 0x07, 0xE0, 0xFE, 0x0F, 0xE0, 0xFF,
  0xFE, 0xFF, 0xEF, 0xF8, 0x07, 0xC0, 0x7F, 0xC3, 0xFF, 0x9F, 0x1E, 0x78,
  0x3D, 0xC0, 0xFF, 0x03, 0xFC, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0xF7, 0x03, 0xDE, 0x0F, 0x78, 0x78, 0xFF, 0xE1,
  0xFF, 0x03, 0xF0, 0xFF, 0x0F, 0xFC, 0xFF, 0xEE, 0x1E, 0xE0, 0xFE, 0x0F,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0xFE, 0x0F, 0xE1, 0xEF, 0xFE, 0xFF, 0xCF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xFF, 0xDF, 0xFB, 0xFF,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1F, 0xFB, 0xFF, 0x7F, 0xEE, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x00, 0x0F, 0xC0, 0x7F, 0xC3, 0xFF, 0x9F, 0x1E,
  0x78, 0x3D, 0xC0, 0xFF, 0x03, 0xFC, 0x00, 0xF0, 0x03, 0xC7, 0xFF, 0x1F,
  0xFC, 0x7F, 0xF0, 0x3F, 0xC0, 0xF7, 0x03, 0xDE, 0x0F, 0x7C, 0x3C, 0xFF,
  0xF1, 0xFF, 0x81, 0xF8, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xF8, 0x7F, 0x8F, 0xF3, 0xFF, 0xF9,
  0xFE, 0x0F, 0x80, 0xE0, 0x7B, 0x83, 0xCE, 0x1F, 0x38, 0x78, 0xE3, 0xC3,
  0x8F, 0x0E, 0x78, 0x3B, 0xC0, 0xEF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xE0,
  0xFF, 0x83, 0xCF, 0x0E, 0x3E, 0x38, 0x78, 0xE1, 0xF3, 0x83, 0xCE, 0x0F,
  0xB8, 0x1E, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x07, 0xFC, 0x07, 0xFE, 0x03,
  0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xFC, 0x3F, 0xEE,
  0x3B, 0xF7, 0x1D, 0xFB, 0x8E, 0xFC, 0xEF, 0x7E, 0x77, 0x3F, 0x3B, 0x9F,
  0x8F, 0xCF, 0xC7, 0xC7, 0xE3, 0xE3, 0xF1, 0xF1, 0xF8, 0x70, 0xFC, 0x38,
  0x70, 0xF0, 0x3F, 0x81, 0xFE, 0x0F, 0xF0, 0x7F, 0xC3, 0xFE, 0x1F, 0xF8,
  0xFD, 0xC7, 0xEF, 0x3F, 0x39, 0xF9, 0xEF, 0xC7, 0x7E, 0x3F, 0xF0, 0xFF,
  0x87, 0xFC, 0x1F, 0xE0, 0xFF, 0x03, 0xF8, 0x1F, 0xC0, 0x70, 0x07, 0xC0,
  0x7F, 0xC3, 0xFF, 0x9F, 0x1E, 0x78, 0x3D, 0xC0, 0xFF, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x77, 0x01,
  0xDE, 0x0F, 0x7C, 0x7C, 0xFF, 0xE1, 0xFF, 0x01, 0xF0, 0xFF, 0x87, 0xFF,
  0x3F, 0xFD, 0xC1, 0xEE, 0x07, 0x70, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F,
  0x07, 0xBF, 0xFD, 0xFF, 0xCF, 0xF8, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x07, 0xC0, 0x3F, 0xE0, 0xFF, 0xE3,
  0xE3, 0xC7, 0x83, 0xCE, 0x07, 0xBC, 0x07, 0x78, 0x0E, 0xF0, 0x1D, 0xE0,
  0x3B, 0xC0, 0x77, 0x80, 0xEF, 0x01, 0xDE, 0x03, 0x9C, 0x0F, 0x3C, 0x1E,
  0x7C, 0x78, 0x7F, 0xF0, 0x7F, 0xC0, 0x3F, 0xC0, 0x07, 0xC0, 0x07, 0x80,
  0x07, 0x00, 0x04, 0xFF, 0x87, 0xFF, 0x3F, 0xF9, 0xC1, 0xEE, 0x0F, 0x70,
  0x7B, 0x83, 0xDC, 0x1E, 0xE1, 0xF7, 0xFF, 0x3F, 0xF1, 0xFF, 0x0E, 0x3C,
  0x71, 0xE3, 0x87, 0x9C, 0x3C, 0xE0, 0xE7, 0x07, 0xB8, 0x3D, 0xC0, 0xF0,
  0x0F, 0x81, 0xFF, 0x1F, 0xFC, 0xF1, 0xEF, 0x07, 0xF8, 0x3D, 0xC0, 0x0F,
  0x80, 0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3F, 0xC1,
  0xFE, 0x0F, 0xF8, 0xFB, 0xFF, 0x8F, 0xF8, 0x1F, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xF0, 0xFF, 0xFE, 0x7F, 0xE1, 0xF8,
  0x70, 0x0F, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x38, 0x1C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x1C, 0x3C, 0x1C, 0x38, 0x1E, 0x78, 0x1E, 0x78, 0x0E, 0x70,
  0x0E, 0x70, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x03, 0xC0, 0x03, 0xC0, 0xE0, 0xE0, 0xFE, 0x1C, 0x1F, 0xC3, 0xC7, 0xF8,
  0xF8, 0xF7, 0x1F, 0x1E, 0xE3, 0xE3, 0x9C, 0x7C, 0x73, 0xCF, 0xCE, 0x7B,
  0xBB, 0xCF, 0x77, 0x78, 0xEE, 0xEF, 0x1D, 0xDD, 0xC3, 0xB9, 0xF8, 0x7E,
  0x3F, 0x0F, 0xC7, 0xE0, 0xF8, 0xFC, 0x1F, 0x0F, 0x03, 0xC1, 0xE0, 0x78,
  0x3C, 0x0F, 0x07, 0x80, 0xF0, 0x3F, 0xE1, 0xE7, 0x87, 0x9E, 0x3C, 0x3C,
  0xF0, 0xF3, 0x81, 0xFE, 0x07, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03,
  0xF0, 0x1F, 0xC0, 0x7F, 0x83, 0xDE, 0x0F, 0x3C, 0x78, 0xF1, 0xE1, 0xEF,
  0x07, 0xBC, 0x0F, 0xF0, 0x1E, 0xF0, 0x79, 0xE0, 0xF1, 0xC1, 0xC3, 0xC7,
  0x83, 0x8E, 0x07, 0xBC, 0x0F, 0x78, 0x0E, 0xE0, 0x1F, 0xC0, 0x1F, 0x00,
  0x3E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xE0,
  0x0E, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1C,
  0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C,
  0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0xFF, 0xF0, 0xF0, 0x0E, 0x01, 0xE0,
  0x3C, 0x03, 0x80, 0x78, 0x0F, 0x00, 0xE0, 0x1E, 0x03, 0xC0, 0x38, 0x07,
  0x00, 0xF0, 0x0E, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x70, 0x0F, 0x01, 0xE0,
  0x1C, 0x03, 0xC0, 0xFF, 0xFF, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF,
  0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3F, 0xFF, 0xFF,
  0x1C, 0x0E, 0x0F, 0x87, 0xC3, 0x63, 0xB9, 0xDC, 0xC6, 0xE3, 0xF1, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF1, 0xE3, 0x87, 0x1F, 0x07, 0xF9, 0xFF,
  0x38, 0xFF, 0x1E, 0x03, 0xC7, 0xFB, 0xFF, 0x79, 0xFE, 0x3F, 0xC7, 0xF8,
  0xFF, 0xFE, 0xFF, 0xCF, 0x38, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x3B, 0xC7, 0xFC, 0xFF, 0xDE, 0x3B, 0x87, 0xF0, 0xFE, 0x1F, 0xC3,
  0xF8, 0x7F, 0x0F, 0xE1, 0xFE, 0x3B, 0xFF, 0x7F, 0xCE, 0xF0, 0x1F, 0x07,
  0xF9, 0xFF, 0x38, 0xFF, 0x0F, 0xE1, 0xFC, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC3, 0xB8, 0xF7, 0xFC, 0x7F, 0x87, 0xC0, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC7, 0xBB, 0xFF, 0x7F, 0xFE, 0x3F, 0xC3, 0xF8, 0x7F,
  0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x3D, 0xFF, 0xBF, 0xF1, 0xEE,
  0x1F, 0x07, 0xF9, 0xFF, 0xB8, 0xFF, 0x0F, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x03, 0xC0, 0x3C, 0x27, 0xFE, 0x7F, 0xC3, 0xE0, 0x0F, 0x1F, 0x3F,
  0x38, 0x78, 0x78, 0xFE, 0xFE, 0xFE, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78,
  0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x1E, 0xF3, 0xFF, 0x7F, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0x7F, 0xF3, 0xFF, 0x1E, 0xF0, 0x0F, 0x00, 0xE2, 0x1E, 0x7F, 0xE7, 0xFC,
  0x1F, 0x00, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3D, 0xE7,
  0xFE, 0xFF, 0xFF, 0x3F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87,
  0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0E, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x18, 0xF3, 0xC7, 0x00, 0x01, 0xC7, 0x1C, 0x71, 0xC7,
  0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xCF, 0xFF, 0xEF, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0xF7, 0x1E, 0xE7,
  0x9D, 0xE3, 0xBC, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0xC7, 0xF8, 0xE7, 0x9C,
  0xF3, 0x8F, 0x71, 0xEE, 0x1E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xEF, 0x1E, 0x7F, 0xDF, 0xBF, 0xFF, 0xFE, 0x7C, 0xFE, 0x1C, 0x3F,
  0x0E, 0x1F, 0x87, 0x0F, 0xC3, 0x87, 0xE1, 0xC3, 0xF0, 0xE1, 0xF8, 0x70,
  0xFC, 0x38, 0x7E, 0x1C, 0x3F, 0x0E, 0x1F, 0x87, 0x0E, 0xF7, 0x9F, 0xFB,
  0xFF, 0xFC, 0xFF, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3,
  0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x38, 0x1F, 0x83, 0xFC, 0x7F, 0xE7, 0x9E,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xF7, 0x9E,
  0x7F, 0xE3, 0xFC, 0x1F, 0x80, 0xEF, 0x1F, 0xF3, 0xFF, 0x79, 0xEE, 0x1F,
  0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF1, 0xEF, 0xFD, 0xFF,
  0x3B, 0xC7, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x00, 0x1E, 0xEF,
  0xFD, 0xFF, 0xF8, 0xFF, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F,
  0xC3, 0xF8, 0xF7, 0xFE, 0xFF, 0xC7, 0xB8, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0xEF, 0xFF, 0xFF, 0xFE, 0x1C, 0x38, 0x70, 0xE1, 0xC3,
  0x87, 0x0E, 0x1C, 0x38, 0x00, 0x1F, 0x0F, 0xF1, 0xFF, 0x78, 0xEF, 0x1E,
  0xF0, 0x1F, 0x81, 0xFC, 0x0F, 0xC0, 0x7B, 0x87, 0xF8, 0xF7, 0xFC, 0xFF,
  0x87, 0xC0, 0x3C, 0x3C, 0x3C, 0xFF, 0xFF, 0xFF, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3F, 0x1F, 0x0F, 0xF0, 0xFE, 0x1F, 0xC3,
  0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xB8,
  0xF7, 0xFE, 0xFF, 0xC7, 0xB8, 0x70, 0xF7, 0x0F, 0x78, 0xE7, 0x8E, 0x39,
  0xE3, 0x9C, 0x39, 0xC3, 0xDC, 0x1D, 0xC1, 0xF8, 0x1F, 0x80, 0xF8, 0x0F,
  0x80, 0xF0, 0x0F, 0x00, 0xE3, 0x87, 0xE3, 0xC7, 0xE3, 0xCF, 0xF3, 0xCF,
  0xF3, 0xCE, 0x77, 0xEE, 0x77, 0xEE, 0x77, 0xEE, 0x76, 0x7C, 0x3E, 0x7C,
  0x3E, 0x7C, 0x3E, 0x7C, 0x3C, 0x3C, 0x3C, 0x38, 0x1C, 0x38, 0x78, 0xF7,
  0x8E, 0x3D, 0xE3, 0xDC, 0x1F, 0xC1, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x81,
  0xF8, 0x1F, 0xC3, 0xDC, 0x39, 0xE7, 0x8E, 0x78, 0xF0, 0xF0, 0xF7, 0x0F,
  0x78, 0xE7, 0x9E, 0x39, 0xE3, 0x9C, 0x3D, 0xC3, 0xDC, 0x1F, 0xC1, 0xF8,
  0x1F, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0,
  0x3E, 0x03, 0xC0, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0x07, 0x81,
  0xC0, 0xF0, 0x78, 0x1C, 0x0F, 0x03, 0x81, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC,
  0x04, 0x1C, 0x71, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE3, 0xCF, 0x1C,
  0x3C, 0x3C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x1C, 0x3C, 0x10,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xC3, 0xC3,
  0x87, 0x0F, 0x1E, 0x3C, 0x78, 0xF1, 0xE1, 0xC3, 0xE3, 0xC7, 0x9C, 0x38,
  0xF1, 0xE3, 0xC7, 0x8F, 0x1C, 0x38, 0xF1, 0xC3, 0x00, 0x1C, 0x1B, 0xF0,
  0xDF, 0xCE, 0xE7, 0xFE, 0x1F, 0x00, 0x70,
};

const GFXglyph RobotoCondensed_SemiBold28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 4, 20, 7, 2, -20 },
  { 11, 7, 7, 9, 1, -21 },
  { 18, 13, 20, 15, 1, -20 },
  { 51, 12, 26, 14, 1, -23 },
  { 90, 16, 20, 18, 1, -20 },
  { 130, 15, 20, 16, 1, -20 },
  { 168, 3, 7, 5, 1, -21 },
  { 171, 6, 28, 9, 2, -22 },
  { 192, 6, 28, 9, 1, -22 },
  { 213, 12, 12, 13, 0, -20 },
  { 231, 11, 14, 13, 1, -16 },
  { 251, 5, 8, 7, 0, -3 },
  { 256, 7, 3, 9, 1, -10 },
  { 259, 4, 4, 8, 2, -4 },
  { 261, 9, 22, 10, 0, -20 },
  { 286, 12, 20, 14, 1, -20 },
  { 316, 8, 20, 14, 2, -20 },
  { 336, 12, 20, 14, 1, -20 },
  { 366, 12, 20, 14, 1, -20 },
  { 396, 12, 20, 14, 1, -20 },
  { 426, 12, 20, 14, 1, -20 },
  { 456, 12, 20, 14, 1, -20 },
  { 486, 12, 20, 14, 1, -20 },
  { 516, 12, 20, 14, 1, -20 },
  { 546, 12, 20, 14, 1, -20 },
  { 576, 4, 15, 7, 2, -15 },
  { 584, 5, 20, 7, 1, -15 },
  { 597, 10, 13, 13, 1, -15 },
  { 614, 10, 8, 14, 2, -13 },
  { 624, 10, 13, 13, 2, -15 },
  { 641, 10, 20, 12, 1, -20 },
  { 666, 19, 25, 21, 1, -19 },
  { 726, 16, 20, 17, 0, -20 },
  { 766, 12, 20, 16, 2, -20 },
  { 796, 14, 20, 16, 1, -20 },
  { 831, 12, 20, 16, 2, -20 },
  { 861, 11, 20, 14, 2, -20 },
  { 889, 11, 20, 13, 2, -20 },
  { 917, 14, 20, 16, 1, -20 },
  { 952, 13, 20, 17, 2, -20 },
  { 985, 4, 20, 7, 2, -20 },
  { 995, 11, 20, 14, 1, -20 },
  { 1023, 14, 20, 15, 2, -20 },
  { 1058, 11, 20, 13, 2, -20 },
  { 1086, 17, 20, 21, 2, -20 },
  { 1129, 13, 20, 17, 2, -20 },
  { 1162, 14, 20, 17, 1, -20 },
  { 1197, 13, 20, 16, 2, -20 },
  { 1230, 15, 24, 17, 1, -20 },
  { 1275, 13, 20, 15, 2, -20 },
  { 1308, 13, 20, 15, 1, -20 },
  { 1341, 13, 20, 15, 1, -20 },
  { 1374, 12, 20, 16, 2, -20 },
  { 1404, 16, 20, 16, 0, -20 },
  { 1444, 19, 20, 21, 1, -20 },
  { 1492, 14, 20, 16, 1, -20 },
  { 1527, 15, 20, 15, 0, -20 },
  { 1565, 13, 20, 15, 1, -20 },
  { 1598, 5, 28, 7, 2, -23 },
  { 1616, 11, 22, 11, 0, -20 },
  { 1647, 6, 28, 7, 0, -23 },
  { 1668, 9, 10, 11, 1, -20 },
  { 1680, 11, 3, 11, 0, 0 },
  { 1685, 6, 4, 9, 1, -21 },
  { 1688, 11, 15, 13, 1, -15 },
  { 1709, 11, 21, 14, 2, -21 },
  { 1738, 11, 15, 13, 1, -15 },
  { 1759, 11, 21, 14, 1, -21 },
  { 1788, 11, 15, 13, 1, -15 },
  { 1809, 8, 21, 9, 1, -21 },
  { 1830, 12, 21, 14, 1, -15 },
  { 1862, 11, 21, 14, 1, -21 },
  { 1891, 3, 21, 7, 2, -21 },
  { 1899, 6, 27, 7, -1, -21 },
  { 1920, 11, 21, 13, 2, -21 },
  { 1949, 3, 21, 7, 2, -21 },
  { 1957, 17, 15, 21, 2, -15 },
  { 1989, 11, 15, 14, 1, -15 },
  { 2010, 12, 15, 14, 1, -15 },
  { 2033, 11, 21, 14, 2, -15 },
  { 2062, 11, 21, 14, 1, -15 },
  { 2091, 7, 15, 9, 2, -15 },
  { 2105, 11, 15, 13, 1, -15 },
  { 2126, 8, 18, 9, 0, -18 },
  { 2144, 11, 15, 14, 1, -15 },
  { 2165, 12, 15, 12, 0, -15 },
  { 2188, 16, 15, 18, 1, -15 },
  { 2218, 12, 15, 13, 0, -15 },
  { 2241, 12, 21, 12, 0, -15 },
  { 2273, 10, 15, 13, 1, -15 },
  { 2292, 7, 27, 8, 1, -22 },
  { 2316, 3, 24, 7, 2, -20 },
  { 2325, 7, 27, 8, 1, -22 },
  { 2349, 13, 6, 16, 1, -11 },
};

const GFXfont RobotoCondensed_SemiBold28pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_SemiBold28pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_SemiBold28pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _ROBOTOCONDENSED_SEMIBOLD28PT7B_H_
