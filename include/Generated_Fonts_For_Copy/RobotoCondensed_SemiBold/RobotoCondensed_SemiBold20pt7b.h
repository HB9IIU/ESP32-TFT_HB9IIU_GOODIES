#ifndef _ROBOTOCONDENSED_SEMIBOLD20PT7B_H_
#define _ROBOTOCONDENSED_SEMIBOLD20PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-SemiBold.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_SemiBold20pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFB, 0x60, 0x3E, 0xC0, 0xDE, 0xF7, 0x29, 0x00, 0x1B,
  0x0D, 0x84, 0xC2, 0x4F, 0xFF, 0xFC, 0xD8, 0x6C, 0xFF, 0x7F, 0x89, 0x0C,
  0x86, 0xC3, 0x60, 0x08, 0x08, 0x3C, 0x7E, 0x67, 0xE7, 0xE3, 0x70, 0x7C,
  0x1E, 0x07, 0xC7, 0xE3, 0xE7, 0x7E, 0x3C, 0x18, 0x18, 0x70, 0x1F, 0x03,
  0x66, 0x64, 0x8D, 0xB1, 0xFC, 0x1D, 0x80, 0x6E, 0x0B, 0xE3, 0x4C, 0x49,
  0x99, 0x30, 0x3E, 0x03, 0x80, 0x3C, 0x1F, 0x86, 0x61, 0x98, 0x66, 0x1F,
  0x03, 0x81, 0xE6, 0xFD, 0xB3, 0xEC, 0x7B, 0x9C, 0xFF, 0x8F, 0x70, 0xFE,
  0x80, 0x08, 0xCC, 0x46, 0x31, 0x98, 0xC6, 0x31, 0x8C, 0x31, 0x8C, 0x21,
  0x86, 0x10, 0x8C, 0xC6, 0x63, 0x33, 0x33, 0x33, 0x33, 0x36, 0x6C, 0xC8,
  0x08, 0x04, 0x02, 0x1F, 0x73, 0xF0, 0xE0, 0xD8, 0xEC, 0x22, 0x00, 0x18,
  0x18, 0x18, 0x18, 0xFF, 0xFF, 0x18, 0x18, 0x18, 0x18, 0x77, 0x76, 0x64,
  0xFF, 0xC0, 0x7D, 0x80, 0x0C, 0x30, 0xC6, 0x18, 0x61, 0x0C, 0x30, 0xC6,
  0x18, 0x61, 0x0C, 0x00, 0x3C, 0x7E, 0xE7, 0xE7, 0xE3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xE3, 0xE7, 0xE7, 0x7E, 0x3C, 0x1B, 0xFF, 0x73, 0x9C, 0xE7, 0x39,
  0xCE, 0x73, 0x9C, 0x3C, 0x7E, 0xE7, 0xC7, 0xC7, 0x07, 0x06, 0x0E, 0x1C,
  0x38, 0x70, 0x60, 0xFF, 0xFF, 0x3C, 0x7E, 0xE7, 0xC7, 0x07, 0x06, 0x3E,
  0x3E, 0x07, 0x07, 0xC7, 0xE7, 0xFE, 0x3C, 0x0E, 0x0E, 0x1E, 0x1E, 0x36,
  0x36, 0x66, 0x66, 0xC6, 0xFF, 0xFF, 0x06, 0x06, 0x06, 0x7F, 0x7F, 0x60,
  0x60, 0x60, 0x7C, 0xFE, 0x67, 0x03, 0x03, 0xE3, 0xE7, 0x7E, 0x3C, 0x0C,
  0x3C, 0x78, 0x60, 0xE0, 0xFE, 0xFF, 0xE7, 0xE3, 0xE3, 0xE3, 0x67, 0x7E,
  0x3C, 0xFF, 0xFF, 0x07, 0x06, 0x06, 0x0E, 0x0C, 0x1C, 0x1C, 0x18, 0x38,
  0x38, 0x30, 0x70, 0x3C, 0x7E, 0xE7, 0xE7, 0xE7, 0x66, 0x7E, 0x7E, 0xE7,
  0xE7, 0xE7, 0xE7, 0x7E, 0x3C, 0x3C, 0x7E, 0xE6, 0xE7, 0xC7, 0xE7, 0xE7,
  0x7F, 0x3F, 0x07, 0x06, 0x0E, 0x3C, 0x30, 0x7D, 0x80, 0x00, 0x7D, 0x80,
  0x7F, 0x80, 0x00, 0x0D, 0xBF, 0xA0, 0x02, 0x1C, 0xFF, 0xCE, 0x1C, 0x3E,
  0x1F, 0x0E, 0x04, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x81, 0xC3, 0xE1,
  0xF0, 0xE1, 0xCF, 0xFC, 0xE1, 0x00, 0x79, 0xFB, 0xBE, 0x30, 0xE1, 0xC7,
  0x1C, 0x30, 0x60, 0x01, 0x83, 0x86, 0x00, 0x07, 0xC0, 0x7F, 0x83, 0x03,
  0x18, 0x06, 0x63, 0x99, 0x1F, 0x2C, 0xCC, 0xB3, 0x32, 0xC8, 0xCB, 0x62,
  0x2D, 0x88, 0xB3, 0x66, 0xCF, 0xF3, 0x3B, 0xC6, 0x00, 0x1C, 0x00, 0x3F,
  0x80, 0x3E, 0x00, 0x06, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x81, 0xB8,
  0x19, 0x83, 0x9C, 0x39, 0xC3, 0xFC, 0x7F, 0xC7, 0x0E, 0x60, 0xEE, 0x06,
  0xFE, 0x7F, 0xB8, 0xFC, 0x7E, 0x3F, 0x1F, 0xFD, 0xFE, 0xE3, 0xF0, 0xF8,
  0x7C, 0x7F, 0xF7, 0xF0, 0x1E, 0x1F, 0xE7, 0x3B, 0x86, 0xE1, 0xF8, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x7E, 0x1D, 0xCE, 0x7F, 0x87, 0x80, 0xFC, 0x7F,
  0xB9, 0xFC, 0x7E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0xFC, 0xFF,
  0xF7, 0xE0, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xFE, 0xFE, 0xE0, 0xE0,
  0xE0, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xFE, 0xFE,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x1E, 0x1F, 0xE7, 0x3B, 0x87, 0xE1,
  0xF8, 0x0E, 0x03, 0x9F, 0xE7, 0xF8, 0x7E, 0x1D, 0xC7, 0x7F, 0xC7, 0xC0,
  0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7F, 0xFF, 0xFF, 0xE1, 0xF8,
  0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xD8,
  0xEE, 0xE7, 0xF1, 0xF0, 0xE3, 0xF8, 0xEE, 0x73, 0x9C, 0xEE, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFE, 0x39, 0xCE, 0x73, 0x8E, 0xE3, 0xB8, 0x70, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF,
  0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xF0, 0xFF, 0x8D, 0xFC, 0x7F, 0xE3, 0xFD,
  0xBF, 0xED, 0xBF, 0x6D, 0xFB, 0xEF, 0xCE, 0x7E, 0x73, 0xF3, 0x9C, 0xE0,
  0xFC, 0x3F, 0x0F, 0xE3, 0xF8, 0xFF, 0x3E, 0xCF, 0xBB, 0xE6, 0xF9, 0xFE,
  0x3F, 0x8F, 0xE1, 0xF8, 0x70, 0x1E, 0x1F, 0xE7, 0x3B, 0x87, 0xE1, 0xF8,
  0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1D, 0xCE, 0x7F, 0x87, 0x80, 0xFE,
  0x3F, 0xEE, 0x3B, 0x86, 0xE1, 0xF8, 0x6E, 0x3B, 0xFE, 0xFE, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x00, 0x1E, 0x1F, 0xE7, 0x3B, 0x87, 0xE1, 0xF8,
  0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1D, 0xCE, 0x7F, 0x87, 0xC0, 0x38,
  0x07, 0x00, 0x80, 0xFE, 0x3F, 0xCE, 0x3B, 0x8E, 0xE1, 0xB8, 0xEE, 0x3B,
  0xFC, 0xFE, 0x39, 0xCE, 0x73, 0x8E, 0xE3, 0xB8, 0x60, 0x3E, 0x3F, 0xB8,
  0xFC, 0x7E, 0x07, 0x81, 0xF0, 0x3E, 0x07, 0xE1, 0xF8, 0xFC, 0x77, 0xF1,
  0xF0, 0xFF, 0xFF, 0xC7, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F,
  0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x77, 0xF1, 0xF0, 0xE0, 0xEC, 0x1D,
  0xC3, 0x38, 0x63, 0x1C, 0x63, 0x8E, 0x61, 0xDC, 0x1B, 0x83, 0x60, 0x7C,
  0x07, 0x80, 0xE0, 0x1C, 0x00, 0x63, 0x8E, 0xC7, 0x19, 0x8E, 0x33, 0x9C,
  0xE7, 0x3D, 0xC6, 0xDB, 0x8D, 0xB6, 0x1B, 0x6C, 0x36, 0xD8, 0x7C, 0xF0,
  0xF1, 0xE0, 0xE3, 0x81, 0xC7, 0x03, 0x8E, 0x00, 0x70, 0xCE, 0x38, 0xE6,
  0x1D, 0xC1, 0xF0, 0x3E, 0x03, 0x80, 0x70, 0x1F, 0x03, 0x60, 0xEE, 0x18,
  0xC7, 0x1C, 0xE1, 0x80, 0xE0, 0xCE, 0x39, 0xC6, 0x19, 0xC3, 0xB8, 0x36,
  0x07, 0xC0, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x00,
  0xFF, 0xFF, 0xC0, 0xC0, 0xE0, 0xE0, 0x60, 0x70, 0x30, 0x38, 0x38, 0x1C,
  0x1C, 0x0F, 0xFF, 0xFC, 0xFF, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE,
  0xEF, 0xF0, 0xE0, 0x60, 0x70, 0x70, 0x30, 0x38, 0x38, 0x18, 0x1C, 0x1C,
  0x0C, 0x0E, 0x0E, 0x06, 0x07, 0xFF, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77,
  0x77, 0x7F, 0xF0, 0x31, 0xC7, 0x9E, 0xDB, 0x3C, 0xC0, 0xFF, 0xFF, 0xE6,
  0x30, 0x3C, 0x7E, 0xE6, 0x06, 0x3E, 0xFE, 0xE6, 0xC6, 0xE6, 0xFE, 0x77,
  0xE0, 0xE0, 0xE0, 0xE0, 0xFE, 0xFE, 0xE7, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3,
  0xE7, 0xFE, 0xDE, 0x3C, 0x7E, 0xE6, 0xC7, 0xC0, 0xC0, 0xC0, 0xC7, 0xE6,
  0x7E, 0x3C, 0x07, 0x07, 0x07, 0x07, 0x7F, 0xFF, 0xE7, 0xC7, 0xC7, 0xC7,
  0xC7, 0xC7, 0xE7, 0xFF, 0x7F, 0x3C, 0x7E, 0xE7, 0xC7, 0xFF, 0xFF, 0xC0,
  0xC0, 0xE2, 0x7F, 0x3C, 0x1C, 0xF3, 0x8C, 0xFF, 0xF3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x00, 0x7B, 0x7F, 0xE7, 0xC7, 0xC7, 0xC7, 0xC7, 0xC7,
  0xE7, 0x7F, 0x3F, 0x07, 0x47, 0x7E, 0x3C, 0xE0, 0xE0, 0xE0, 0xE0, 0xFC,
  0xFE, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0x5F, 0x8F,
  0xFF, 0xFF, 0xFF, 0xF8, 0x27, 0x60, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77,
  0x7E, 0xC0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE7, 0xEE, 0xEC, 0xFC, 0xF8, 0xF8,
  0xFC, 0xEE, 0xEE, 0xE7, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xDE,
  0xF7, 0xFF, 0xB9, 0xCF, 0xCE, 0x7E, 0x73, 0xF3, 0x9F, 0x9C, 0xFC, 0xE7,
  0xE7, 0x3F, 0x39, 0xF9, 0xCE, 0xDE, 0xFE, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7,
  0xE7, 0xE7, 0xE7, 0xE7, 0x3C, 0x7E, 0xE7, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xE7, 0x7E, 0x3C, 0xDE, 0xFE, 0xE7, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE7,
  0xFE, 0xFE, 0xE0, 0xE0, 0xE0, 0xE0, 0x7B, 0xFF, 0xE7, 0xC7, 0xC7, 0xC7,
  0xC7, 0xC7, 0xE7, 0xFF, 0x7F, 0x07, 0x07, 0x07, 0x07, 0xDF, 0xFF, 0xCE,
  0x73, 0x9C, 0xE7, 0x38, 0x7D, 0xFF, 0x9F, 0x0F, 0x0F, 0x87, 0x83, 0xC7,
  0xFD, 0xF0, 0x30, 0xCF, 0xFF, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0F, 0x3C,
  0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xFF, 0x7F, 0xE3,
  0x31, 0x99, 0xCE, 0xE3, 0x61, 0xB0, 0xD8, 0x7C, 0x1C, 0x0E, 0x07, 0x00,
  0xE6, 0x36, 0x73, 0x67, 0x36, 0x77, 0x7F, 0x63, 0xDE, 0x3D, 0xE3, 0xDE,
  0x39, 0xE3, 0x8C, 0x18, 0xC0, 0x63, 0x3B, 0x8D, 0x87, 0xC1, 0xC0, 0xE0,
  0x70, 0x7C, 0x36, 0x3B, 0x98, 0xC0, 0xE3, 0x31, 0x99, 0xCE, 0xE7, 0x61,
  0xB0, 0xF8, 0x78, 0x1C, 0x0E, 0x07, 0x03, 0x01, 0x83, 0xC1, 0xC0, 0xFF,
  0xFC, 0x38, 0xE1, 0x87, 0x0C, 0x38, 0xE1, 0xFF, 0xF8, 0x11, 0x9C, 0xC6,
  0x31, 0x8C, 0x66, 0x30, 0xC6, 0x31, 0x8C, 0x63, 0x8C, 0x20, 0xFF, 0xFF,
  0x80, 0x43, 0x1C, 0x63, 0x18, 0xC6, 0x30, 0xC6, 0x63, 0x18, 0xC6, 0x33,
  0x98, 0x80, 0x71, 0xBE, 0xF3, 0xF8, 0xE0,
};

const GFXglyph RobotoCondensed_SemiBold20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 3, 14, 5, 1, -14 },
  { 7, 5, 5, 6, 1, -15 },
  { 11, 9, 14, 11, 1, -14 },
  { 27, 8, 18, 10, 1, -16 },
  { 45, 11, 14, 13, 1, -14 },
  { 65, 10, 14, 11, 1, -14 },
  { 83, 2, 5, 3, 1, -15 },
  { 85, 5, 20, 6, 1, -16 },
  { 98, 4, 20, 6, 1, -16 },
  { 108, 9, 9, 9, 0, -14 },
  { 119, 8, 10, 10, 1, -12 },
  { 129, 4, 6, 5, 0, -2 },
  { 132, 5, 2, 7, 1, -7 },
  { 134, 3, 3, 6, 1, -3 },
  { 136, 6, 15, 7, 0, -14 },
  { 148, 8, 14, 10, 1, -14 },
  { 162, 5, 14, 10, 2, -14 },
  { 171, 8, 14, 10, 1, -14 },
  { 185, 8, 14, 10, 1, -14 },
  { 199, 8, 14, 10, 1, -14 },
  { 213, 8, 14, 10, 1, -14 },
  { 227, 8, 14, 10, 1, -14 },
  { 241, 8, 14, 10, 1, -14 },
  { 255, 8, 14, 10, 1, -14 },
  { 269, 8, 14, 10, 1, -14 },
  { 283, 3, 11, 5, 1, -11 },
  { 288, 3, 15, 5, 1, -11 },
  { 294, 7, 10, 9, 1, -11 },
  { 303, 8, 6, 10, 1, -9 },
  { 309, 7, 10, 9, 1, -11 },
  { 318, 7, 14, 9, 1, -14 },
  { 331, 14, 18, 15, 1, -14 },
  { 363, 12, 14, 12, 0, -14 },
  { 384, 9, 14, 11, 1, -14 },
  { 400, 10, 14, 11, 1, -14 },
  { 418, 9, 14, 11, 1, -14 },
  { 434, 8, 14, 10, 1, -14 },
  { 448, 8, 14, 10, 1, -14 },
  { 462, 10, 14, 12, 1, -14 },
  { 480, 10, 14, 12, 1, -14 },
  { 498, 3, 14, 5, 1, -14 },
  { 504, 9, 14, 10, 0, -14 },
  { 520, 10, 14, 11, 1, -14 },
  { 538, 8, 14, 10, 1, -14 },
  { 552, 13, 14, 15, 1, -14 },
  { 575, 10, 14, 12, 1, -14 },
  { 593, 10, 14, 12, 1, -14 },
  { 611, 10, 14, 11, 1, -14 },
  { 629, 10, 17, 12, 1, -14 },
  { 651, 10, 14, 11, 1, -14 },
  { 669, 9, 14, 11, 1, -14 },
  { 685, 9, 14, 11, 1, -14 },
  { 701, 9, 14, 11, 1, -14 },
  { 717, 11, 14, 11, 0, -14 },
  { 737, 15, 14, 15, 0, -14 },
  { 764, 11, 14, 11, 0, -14 },
  { 784, 11, 14, 11, 0, -14 },
  { 804, 9, 14, 11, 1, -14 },
  { 820, 4, 19, 5, 1, -16 },
  { 830, 8, 15, 8, 0, -14 },
  { 845, 4, 19, 5, 0, -16 },
  { 855, 6, 7, 8, 1, -14 },
  { 861, 8, 2, 8, 0, 0 },
  { 863, 4, 3, 7, 1, -15 },
  { 865, 8, 11, 9, 1, -11 },
  { 876, 8, 15, 10, 1, -15 },
  { 891, 8, 11, 9, 1, -11 },
  { 902, 8, 15, 10, 1, -15 },
  { 917, 8, 11, 10, 1, -11 },
  { 928, 6, 15, 7, 0, -15 },
  { 940, 8, 15, 10, 1, -11 },
  { 955, 8, 15, 10, 1, -15 },
  { 970, 3, 15, 5, 1, -15 },
  { 976, 4, 19, 5, 0, -15 },
  { 986, 8, 15, 9, 1, -15 },
  { 1001, 3, 15, 5, 1, -15 },
  { 1007, 13, 11, 15, 1, -11 },
  { 1025, 8, 11, 10, 1, -11 },
  { 1036, 8, 11, 10, 1, -11 },
  { 1047, 8, 15, 10, 1, -11 },
  { 1062, 8, 15, 10, 1, -11 },
  { 1077, 5, 11, 7, 1, -11 },
  { 1084, 7, 11, 9, 1, -11 },
  { 1094, 6, 13, 6, 0, -13 },
  { 1104, 8, 11, 10, 1, -11 },
  { 1115, 9, 11, 9, 0, -11 },
  { 1128, 12, 11, 13, 0, -11 },
  { 1145, 9, 11, 9, 0, -11 },
  { 1158, 9, 15, 9, 0, -11 },
  { 1175, 7, 11, 9, 1, -11 },
  { 1185, 5, 20, 6, 1, -16 },
  { 1198, 1, 17, 5, 2, -14 },
  { 1201, 5, 20, 6, 0, -16 },
  { 1214, 9, 4, 11, 1, -8 },
};

const GFXfont RobotoCondensed_SemiBold20pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_SemiBold20pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_SemiBold20pt7bGlyphs,
  0x20, 0x7E, 23
};

#endif // _ROBOTOCONDENSED_SEMIBOLD20PT7B_H_
