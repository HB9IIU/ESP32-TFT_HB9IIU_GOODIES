#ifndef _ROBOTOCONDENSED_SEMIBOLD46PT7B_H_
#define _ROBOTOCONDENSED_SEMIBOLD46PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-SemiBold.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_SemiBold46pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF7, 0xDF, 0x7D, 0xF7, 0x80, 0x00, 0x00, 0x1E, 0xFF, 0xFF,
  0xFF, 0x78, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F,
  0x8F, 0xF1, 0xFC, 0x3B, 0x87, 0x70, 0xE0, 0x00, 0xE1, 0xC0, 0x0F, 0x0E,
  0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80, 0x1E, 0x3C, 0x00, 0xF1, 0xE0, 0x07,
  0x0F, 0x00, 0x38, 0x70, 0x03, 0xC3, 0x83, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x81, 0xC3, 0xC0, 0x0E, 0x1C, 0x00, 0xF1,
  0xE0, 0x07, 0x8F, 0x00, 0x3C, 0x78, 0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x0F,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0x0F, 0x1E,
  0x00, 0x78, 0xF0, 0x03, 0x87, 0x80, 0x1C, 0x38, 0x01, 0xE1, 0xC0, 0x0F,
  0x1E, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80, 0x1E, 0x3C, 0x00, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x03, 0xF0,
  0x01, 0xFF, 0x80, 0x7F, 0xF8, 0x1F, 0xFF, 0x87, 0xFF, 0xF8, 0xFC, 0x3F,
  0x3F, 0x07, 0xE7, 0xE0, 0x7E, 0xFC, 0x0F, 0xDF, 0x81, 0xFB, 0xF0, 0x3F,
  0x3F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xC0,
  0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xF8,
  0x00, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFB,
  0xF0, 0x3F, 0x7F, 0x0F, 0xC7, 0xFF, 0xF8, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0,
  0xFF, 0xE0, 0x03, 0xF0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xFE, 0x00, 0x0F, 0x8F, 0x07, 0x07, 0x87, 0x83, 0xC3, 0xC3, 0xC3, 0xC1,
  0xE1, 0xE1, 0xE0, 0xF0, 0xF1, 0xE0, 0x78, 0x78, 0xE0, 0x3E, 0x3C, 0xF0,
  0x0F, 0xFE, 0x70, 0x07, 0xFE, 0x78, 0x01, 0xFE, 0x38, 0x00, 0x3E, 0x3C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x1F, 0x00, 0x0F, 0x3F, 0xC0, 0x07, 0xBF, 0xF0, 0x07, 0x9F, 0xFC, 0x03,
  0x9F, 0x1E, 0x03, 0xCF, 0x0F, 0x01, 0xC7, 0x87, 0x81, 0xE3, 0xC3, 0xC0,
  0xE1, 0xE1, 0xE0, 0xF0, 0xF0, 0xF0, 0x70, 0x7C, 0x78, 0x18, 0x1F, 0xFC,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF,
  0x00, 0x3F, 0x1F, 0x80, 0x3F, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x0F,
  0x80, 0x3E, 0x0F, 0x80, 0x3F, 0x1F, 0x00, 0x1F, 0x3F, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xF8, 0x7C, 0x3F, 0xF8, 0x7C, 0x7E, 0xFC, 0x7C, 0xFC, 0xFE,
  0xFC, 0xFC, 0x7E, 0xF8, 0xFC, 0x3F, 0xF8, 0xFC, 0x3F, 0xF8, 0xFC, 0x1F,
  0xF8, 0xFC, 0x0F, 0xF0, 0xFC, 0x0F, 0xF0, 0xFE, 0x0F, 0xF0, 0x7F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xFE, 0xFC, 0x07, 0xF0,
  0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x40, 0x38, 0x0F, 0x01,
  0xE0, 0x78, 0x1F, 0x03, 0xC0, 0xF8, 0x1E, 0x07, 0xC0, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x03, 0xC0, 0x7C, 0x0F, 0x81, 0xF0, 0x1E, 0x03, 0xE0, 0x3C, 0x07,
  0xC0, 0x78, 0x0F, 0x80, 0xF0, 0x0F, 0x01, 0xE0, 0x1C, 0x00, 0x80, 0x40,
  0x0C, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0xF8, 0x0F, 0x01,
  0xF0, 0x3E, 0x03, 0xC0, 0x7C, 0x0F, 0x81, 0xF0, 0x3F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC1, 0xF8, 0x3E, 0x07, 0xC0, 0xF8, 0x1E, 0x07,
  0xC0, 0xF8, 0x1E, 0x07, 0xC0, 0xF0, 0x3E, 0x0F, 0x81, 0xE0, 0x78, 0x06,
  0x00, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x81, 0xC0, 0x3C, 0x38, 0x77, 0xF7, 0x3F, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFC, 0x3F, 0xF8, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x0F, 0xF8,
  0x03, 0xEF, 0x80, 0xF8, 0xF0, 0x1E, 0x1F, 0x07, 0xC1, 0xF0, 0x70, 0x38,
  0x00, 0x02, 0x00, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x7C, 0xFB, 0xE7, 0x82, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x10, 0xFB, 0xFF, 0xFF, 0xFF, 0x9E, 0x00, 0x00, 0x3E, 0x00,
  0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x7C,
  0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0,
  0x01, 0xE0, 0x07, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0xFC,
  0x0F, 0xFF, 0xC3, 0xFF, 0xF8, 0x7E, 0x3F, 0x9F, 0x83, 0xF3, 0xF0, 0x3E,
  0x7C, 0x07, 0xDF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F,
  0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF,
  0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFB,
  0xE0, 0x3F, 0x7C, 0x07, 0xCF, 0xC1, 0xF9, 0xF8, 0x3F, 0x1F, 0x8F, 0xE3,
  0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xC0, 0x3F, 0xF0, 0x03, 0xF8, 0x00,
  0x00, 0x30, 0x1F, 0x07, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF,
  0xE3, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC7,
  0xFF, 0xF8, 0xFC, 0x3F, 0xBF, 0x03, 0xF7, 0xE0, 0x7E, 0xFC, 0x07, 0xDF,
  0x80, 0xFB, 0xF0, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F,
  0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xF0, 0x01,
  0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFC, 0x3F, 0xBF,
  0x03, 0xF7, 0xE0, 0x7E, 0xFC, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x01, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xE0, 0x03,
  0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0x80, 0xFF, 0xF0,
  0x3F, 0x7F, 0x0F, 0xE7, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xC0, 0xFF,
  0xF0, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x1F,
  0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0x7E, 0x00, 0xFB, 0xF0, 0x07, 0xDF, 0x80,
  0x7C, 0xFC, 0x03, 0xE7, 0xE0, 0x3E, 0x3F, 0x01, 0xF1, 0xF8, 0x1F, 0x0F,
  0xC0, 0xF8, 0x7E, 0x0F, 0x83, 0xF0, 0x7C, 0x1F, 0x87, 0xE0, 0xFC, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF,
  0xC0, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8,
  0xFF, 0xFF, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x7E, 0x07,
  0xFF, 0xF0, 0xFF, 0xFF, 0x1F, 0xFF, 0xE3, 0xFF, 0xFE, 0x3E, 0x0F, 0xC0,
  0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0xFC, 0x07, 0xEF, 0x80, 0xFD, 0xF8, 0x3F, 0xBF,
  0x87, 0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0x07, 0xFF, 0xC0, 0x7F, 0xF0, 0x03,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0xC0, 0x0F, 0xF8, 0x03, 0xFF, 0x00,
  0xFF, 0xE0, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x3E, 0x07, 0xDF, 0xF0, 0xFF, 0xFF, 0x1F,
  0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0x0F, 0xDF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFE,
  0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x07, 0xDF, 0x00, 0xFB, 0xE0, 0x3F, 0x7E,
  0x07, 0xEF, 0xC0, 0xFD, 0xF8, 0x1F, 0x9F, 0x87, 0xE3, 0xFF, 0xFC, 0x3F,
  0xFF, 0x03, 0xFF, 0xC0, 0x3F, 0xF0, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F,
  0xFF, 0xC3, 0xFF, 0xF8, 0xFE, 0x3F, 0x9F, 0x83, 0xF3, 0xF0, 0x7E, 0x7E,
  0x0F, 0xCF, 0xC1, 0xF9, 0xF8, 0x3F, 0x3F, 0x07, 0xE3, 0xF1, 0xF8, 0x7F,
  0xFF, 0x07, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFF, 0x07, 0xFF, 0xF0, 0xFC,
  0x7F, 0x3F, 0x07, 0xE7, 0xE0, 0x7D, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0,
  0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFD, 0xF8, 0x3F, 0x3F, 0x87, 0xE7, 0xFF,
  0xFC, 0x7F, 0xFF, 0x07, 0xFF, 0xC0, 0x7F, 0xF0, 0x03, 0xF8, 0x00, 0x03,
  0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xF8, 0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0xFE,
  0x3F, 0x1F, 0x83, 0xF3, 0xE0, 0x7E, 0xFC, 0x0F, 0xDF, 0x80, 0xFB, 0xF0,
  0x1F, 0x7E, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFB, 0xF0,
  0x7F, 0x7E, 0x1F, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF,
  0x7C, 0x0F, 0x8F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x80, 0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0xFE,
  0x00, 0x7F, 0x00, 0x0F, 0x80, 0x00, 0x10, 0xFB, 0xFF, 0xFF, 0xFF, 0x9E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x87,
  0xDF, 0xFF, 0xFF, 0xFC, 0xF0, 0x00, 0x3E, 0x3F, 0x3F, 0x3F, 0x3F, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x3E, 0x3E, 0x3E, 0x7C,
  0x7C, 0x78, 0x30, 0x00, 0x00, 0x80, 0x01, 0xC0, 0x03, 0xE0, 0x07, 0xF0,
  0x0F, 0xF8, 0x1F, 0xFC, 0x3F, 0xFC, 0x7F, 0xF8, 0xFF, 0xE0, 0x7F, 0xC0,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F,
  0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xC0, 0x0F, 0xE0, 0x01, 0xF0, 0x00, 0x38,
  0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x80, 0x00,
  0xE0, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xF0,
  0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0x00, 0x3F, 0x00, 0x7F, 0x01, 0xFF,
  0x07, 0xFF, 0x1F, 0xFC, 0x7F, 0xF0, 0xFF, 0xC0, 0xFF, 0x80, 0xFE, 0x00,
  0xF8, 0x00, 0xE0, 0x00, 0x80, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF,
  0xE0, 0xFF, 0xFC, 0x7F, 0xFF, 0x9F, 0x87, 0xE7, 0xE1, 0xFB, 0xF0, 0x3E,
  0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x0F, 0x80, 0x01, 0xC0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3C,
  0x07, 0x80, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x78,
  0xF0, 0x07, 0xC0, 0xF1, 0xE0, 0x3F, 0xE0, 0xE3, 0xC0, 0xFF, 0xE1, 0xEF,
  0x03, 0xFF, 0xC3, 0xDE, 0x0F, 0x87, 0x87, 0xBC, 0x1E, 0x0F, 0x07, 0x70,
  0x7C, 0x3C, 0x0F, 0xE0, 0xF0, 0x78, 0x1F, 0xC1, 0xE0, 0xF0, 0x3F, 0x83,
  0xC1, 0xE0, 0x7F, 0x0F, 0x83, 0xC0, 0xFE, 0x1F, 0x07, 0x81, 0xFC, 0x3E,
  0x0F, 0x07, 0xF8, 0x7C, 0x1E, 0x0F, 0xF0, 0xF8, 0x3C, 0x1F, 0xE1, 0xF0,
  0xF8, 0x3B, 0xC3, 0xE1, 0xF0, 0xF7, 0x83, 0xE7, 0xE1, 0xEF, 0x07, 0xFF,
  0xEF, 0x8F, 0x0F, 0xFB, 0xFE, 0x1E, 0x0F, 0xE7, 0xF8, 0x3C, 0x0F, 0x83,
  0xE0, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x01, 0x80,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7D, 0xF0,
  0x00, 0x1F, 0x7E, 0x00, 0x0F, 0xCF, 0x80, 0x03, 0xE3, 0xE0, 0x00, 0xF8,
  0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x87, 0xC0, 0x07, 0xC1, 0xF8, 0x03,
  0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x03, 0xE0, 0x0F, 0x80, 0xFC,
  0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xF0, 0x03, 0xF1, 0xF8, 0x00, 0xFC, 0x7E,
  0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xEF, 0xE0, 0x01, 0xFB, 0xF0, 0x00, 0x7E,
  0xFC, 0x00, 0x1F, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0xC0, 0xFE, 0xFC, 0x07, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x7E, 0xFC, 0x07,
  0xEF, 0xC3, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFE, 0xFC, 0x07, 0xEF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x80,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x87, 0xF0, 0x7F, 0x0F, 0xC0, 0x3F, 0x3F,
  0x00, 0x7E, 0x7E, 0x00, 0xFC, 0xFC, 0x01, 0xFB, 0xF0, 0x01, 0xFF, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x1F, 0xBF, 0x00, 0x7E,
  0x7E, 0x00, 0xFC, 0xFC, 0x01, 0xF9, 0xFC, 0x03, 0xF1, 0xFC, 0x1F, 0xC1,
  0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x00,
  0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFC, 0x7E, 0x0F, 0xF3, 0xF0, 0x1F, 0x9F, 0x80, 0x7E, 0xFC,
  0x03, 0xF7, 0xE0, 0x1F, 0xBF, 0x00, 0x7D, 0xF8, 0x03, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF,
  0xF0, 0x07, 0xDF, 0x80, 0x7E, 0xFC, 0x03, 0xF7, 0xE0, 0x1F, 0xBF, 0x01,
  0xF9, 0xF8, 0x3F, 0xCF, 0xFF, 0xFC, 0x7F, 0xFF, 0xC3, 0xFF, 0xFC, 0x1F,
  0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0xFF,
  0xCF, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0xFF,
  0xCF, 0xFF, 0xF3, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0x87, 0xF0, 0x7F, 0x1F, 0xC0, 0x7F, 0x3F, 0x00, 0x7E, 0x7E, 0x00,
  0xFC, 0xFC, 0x00, 0xFB, 0xF8, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x07, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x07, 0xFF,
  0x80, 0x0F, 0xFF, 0x80, 0x1F, 0xBF, 0x00, 0x3F, 0x7E, 0x00, 0x7E, 0xFE,
  0x00, 0xFC, 0xFC, 0x01, 0xF9, 0xFE, 0x0F, 0xF1, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0x83, 0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0x80, 0xFC, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x81, 0xFB, 0xF8, 0x3F, 0x3F, 0x8F,
  0xE7, 0xFF, 0xF8, 0x7F, 0xFF, 0x07, 0xFF, 0xC0, 0x7F, 0xF0, 0x03, 0xF8,
  0x00, 0xFC, 0x01, 0xFF, 0xF0, 0x0F, 0xEF, 0xC0, 0x7F, 0xBF, 0x01, 0xFC,
  0xFC, 0x0F, 0xE3, 0xF0, 0x3F, 0x8F, 0xC1, 0xFC, 0x3F, 0x0F, 0xE0, 0xFC,
  0x3F, 0x83, 0xF1, 0xFC, 0x0F, 0xCF, 0xE0, 0x3F, 0x3F, 0x80, 0xFD, 0xFC,
  0x03, 0xF7, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xFC, 0x03,
  0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0x7F, 0x03, 0xF8,
  0xFC, 0x0F, 0xC3, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0xC3, 0xF0, 0x3F,
  0x0F, 0xC0, 0xFE, 0x3F, 0x01, 0xFC, 0xFC, 0x07, 0xF3, 0xF0, 0x0F, 0xEF,
  0xC0, 0x3F, 0xBF, 0x00, 0x7F, 0xFC, 0x01, 0xFC, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFE,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xBE, 0x03, 0xFF, 0xFD, 0xF0,
  0x3E, 0xFF, 0xEF, 0xC1, 0xF7, 0xFF, 0x3E, 0x0F, 0xBF, 0xFD, 0xF0, 0x7D,
  0xFF, 0xEF, 0xC7, 0xCF, 0xFF, 0x3E, 0x3E, 0x7F, 0xF9, 0xF1, 0xF3, 0xFF,
  0xCF, 0xDF, 0x1F, 0xFE, 0x3E, 0xF8, 0xFF, 0xF1, 0xF7, 0xC7, 0xFF, 0x8F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xE1, 0xFF, 0xE1, 0xFF, 0x0F, 0xFF, 0x0F, 0xF8,
  0x7F, 0xF8, 0x7F, 0x83, 0xFF, 0xC1, 0xFC, 0x1F, 0xFE, 0x0F, 0xE0, 0xFF,
  0xF0, 0x7E, 0x07, 0xFF, 0x81, 0xF0, 0x3F, 0xFC, 0x0F, 0x81, 0xF8, 0xFC,
  0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x00,
  0x7F, 0xFC, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x7F, 0xF7,
  0xC1, 0xFF, 0xDF, 0x87, 0xFF, 0x3E, 0x1F, 0xFC, 0xFC, 0x7F, 0xF1, 0xF1,
  0xFF, 0xC7, 0xE7, 0xFF, 0x0F, 0x9F, 0xFC, 0x3F, 0x7F, 0xF0, 0x7D, 0xFF,
  0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0,
  0x7F, 0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F,
  0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0x80,
  0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x87, 0xF8, 0x7F, 0x8F,
  0xC0, 0x7F, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0xFF, 0xF8,
  0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F,
  0xBF, 0x00, 0x3F, 0x7E, 0x00, 0x7E, 0xFC, 0x01, 0xFC, 0xFC, 0x03, 0xF1,
  0xFE, 0x1F, 0xE1, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x01,
  0xFF, 0xE0, 0x00, 0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x7E, 0x03, 0xFB, 0xF0, 0x0F, 0xFF,
  0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03,
  0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0xFE, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x0F, 0xFF, 0xC0,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F,
  0xC3, 0xFC, 0x7F, 0x01, 0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x7E,
  0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC,
  0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC,
  0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC,
  0x00, 0x7E, 0xFC, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E,
  0x00, 0xFC, 0x3F, 0x01, 0xFC, 0x3F, 0xC3, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x10, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x7E, 0x07, 0xFB, 0xF0, 0x1F, 0xDF,
  0x80, 0x7E, 0xFC, 0x03, 0xF7, 0xE0, 0x1F, 0xBF, 0x00, 0xFD, 0xF8, 0x07,
  0xEF, 0xC0, 0x3F, 0x7E, 0x01, 0xFB, 0xF0, 0x1F, 0xDF, 0x81, 0xFC, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF, 0xE1, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0,
  0x7E, 0x1F, 0x83, 0xF0, 0xFE, 0x1F, 0x83, 0xF0, 0xFC, 0x1F, 0xC7, 0xE0,
  0x7E, 0x3F, 0x03, 0xF9, 0xF8, 0x0F, 0xCF, 0xC0, 0x7E, 0x7E, 0x03, 0xFB,
  0xF0, 0x0F, 0xDF, 0x80, 0x7F, 0xFC, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0x7F,
  0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x87, 0xFF, 0xFE, 0x3F, 0x83, 0xF9,
  0xF8, 0x0F, 0xDF, 0xC0, 0x7E, 0xFC, 0x03, 0xF7, 0xE0, 0x0F, 0xFF, 0x80,
  0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFB, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC,
  0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0xFE, 0xFE, 0x0F, 0xE7, 0xFF, 0xFF,
  0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x00, 0xFF, 0xF0, 0x01, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0xFC, 0x01,
  0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE,
  0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F,
  0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80,
  0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x1F, 0xBF, 0x00, 0xFD, 0xFE, 0x0F, 0xE7,
  0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x01, 0xFF, 0xE0, 0x03, 0xFC,
  0x00, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xBF, 0x80, 0x0F, 0xCF, 0xC0,
  0x0F, 0xE7, 0xE0, 0x07, 0xF3, 0xF0, 0x03, 0xF1, 0xFC, 0x01, 0xF8, 0x7E,
  0x01, 0xFC, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x07, 0xE0, 0x3F, 0x03,
  0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0x80, 0x7C, 0x0F, 0xC0, 0x3F, 0x07, 0xE0,
  0x1F, 0x87, 0xE0, 0x0F, 0xC3, 0xF0, 0x03, 0xE1, 0xF8, 0x01, 0xF8, 0xF8,
  0x00, 0xFC, 0xFC, 0x00, 0x3E, 0x7E, 0x00, 0x1F, 0x3F, 0x00, 0x0F, 0xDF,
  0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x03, 0xE0,
  0x1F, 0xFE, 0x01, 0xF0, 0x1F, 0x9F, 0x81, 0xF8, 0x0F, 0xCF, 0xC0, 0xFE,
  0x07, 0xE7, 0xE0, 0x7F, 0x03, 0xF3, 0xF0, 0x3F, 0x81, 0xF9, 0xF8, 0x1F,
  0xC0, 0xF8, 0x7C, 0x1F, 0xE0, 0xFC, 0x3E, 0x0F, 0xF8, 0x7E, 0x1F, 0x87,
  0xFC, 0x3F, 0x0F, 0xC3, 0xFE, 0x1F, 0x87, 0xE1, 0xFF, 0x0F, 0xC3, 0xF1,
  0xF7, 0x87, 0xC0, 0xF8, 0xFB, 0xE3, 0xE0, 0x7C, 0x7D, 0xF3, 0xF0, 0x3F,
  0x3E, 0xF9, 0xF8, 0x1F, 0x9E, 0x7C, 0xFC, 0x0F, 0xDF, 0x1E, 0x7C, 0x03,
  0xEF, 0x8F, 0x3E, 0x01, 0xF7, 0xC7, 0xDF, 0x00, 0xFB, 0xE3, 0xFF, 0x80,
  0x7D, 0xE1, 0xFF, 0xC0, 0x3F, 0xF0, 0x7F, 0xE0, 0x1F, 0xF8, 0x3F, 0xE0,
  0x07, 0xFC, 0x1F, 0xF0, 0x03, 0xFE, 0x0F, 0xF8, 0x01, 0xFE, 0x07, 0xFC,
  0x00, 0xFF, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x1F, 0xC0, 0x7F,
  0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x07, 0xE0, 0x1F, 0xC0, 0x03, 0xF0, 0x07,
  0xE0, 0x00, 0xFE, 0x00, 0x7E, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFC, 0x3F,
  0x81, 0xFC, 0x3F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0xC3, 0xF0, 0x0F,
  0xC3, 0xF0, 0x0F, 0xE7, 0xE0, 0x07, 0xE7, 0xE0, 0x07, 0xFF, 0xC0, 0x03,
  0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x07, 0xEF, 0xE0, 0x07,
  0xE7, 0xE0, 0x0F, 0xC7, 0xF0, 0x0F, 0xC3, 0xF0, 0x1F, 0xC3, 0xF8, 0x1F,
  0x83, 0xF8, 0x3F, 0x81, 0xFC, 0x3F, 0x01, 0xFC, 0x7F, 0x00, 0xFE, 0x7E,
  0x00, 0xFE, 0xFE, 0x00, 0x7E, 0x7E, 0x00, 0x3F, 0x7F, 0x00, 0x7F, 0x7F,
  0x00, 0x7E, 0x3F, 0x00, 0xFE, 0x3F, 0x80, 0xFC, 0x1F, 0x80, 0xFC, 0x1F,
  0x81, 0xFC, 0x0F, 0xC1, 0xF8, 0x0F, 0xC1, 0xF8, 0x0F, 0xC3, 0xF0, 0x07,
  0xE3, 0xF0, 0x07, 0xE3, 0xE0, 0x03, 0xE7, 0xE0, 0x03, 0xF7, 0xE0, 0x01,
  0xF7, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7C, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x80,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0x3F,
  0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F,
  0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F,
  0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x1E, 0xF8, 0x1E, 0x78, 0x3E, 0x78, 0x3E, 0x7C,
  0x3C, 0x3C, 0x7C, 0x3C, 0x7C, 0x3E, 0x78, 0x1E, 0xF8, 0x1E, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7E, 0x07,
  0xE0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0xF8, 0x03, 0xF0, 0x03, 0xFF,
  0x83, 0xFF, 0xF0, 0xFF, 0xFC, 0x7F, 0xFF, 0x9F, 0x87, 0xEF, 0xC1, 0xFB,
  0xF0, 0x7E, 0x00, 0x1F, 0x81, 0xFF, 0xE1, 0xFF, 0xF8, 0xFF, 0xFE, 0x7F,
  0xFF, 0x9F, 0x87, 0xEF, 0xC1, 0xFB, 0xF0, 0x7E, 0xFC, 0x1F, 0xBF, 0x07,
  0xEF, 0xC1, 0xFB, 0xFF, 0xFE, 0x7F, 0xFF, 0x9F, 0xFF, 0xE3, 0xFE, 0xFC,
  0x3E, 0x3F, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x3E, 0x0F, 0xDF, 0xF1, 0xFF, 0xFF, 0x3F,
  0xFF, 0xF7, 0xFF, 0xFE, 0xFE, 0x0F, 0xDF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE,
  0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC,
  0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xFC,
  0x1F, 0xBF, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0x9F, 0xBF, 0xE3, 0xF1,
  0xF0, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0x03, 0xFF, 0xF0, 0xFF, 0xFC, 0x7F,
  0xFF, 0x9F, 0x87, 0xEF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xF7, 0xE1, 0xF9, 0xFF, 0xFE, 0x3F,
  0xFF, 0x0F, 0xFF, 0x80, 0xFF, 0xC0, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x1F, 0x3F, 0x1F,
  0xFF, 0xCF, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0x03,
  0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF,
  0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC,
  0x0F, 0xFF, 0x87, 0xF7, 0xFF, 0xFD, 0xFF, 0xFF, 0x3F, 0xFF, 0xC7, 0xFD,
  0xF0, 0x7C, 0x7C, 0x03, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xFF, 0xFE,
  0x7F, 0xFF, 0x9F, 0x83, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFC, 0x07, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x47, 0xF0, 0x39, 0xFF, 0xFF,
  0x3F, 0xFF, 0xC7, 0xFF, 0xE0, 0xFF, 0xF0, 0x0F, 0xF0, 0x00, 0xF8, 0x1F,
  0xC1, 0xFE, 0x1F, 0xF0, 0xFF, 0x8F, 0xE0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x07, 0xE7, 0xE3, 0xFE, 0xFC, 0xFF,
  0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0xE0,
  0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80,
  0x7F, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80,
  0xFF, 0xF8, 0x3F, 0xBF, 0xFF, 0xF7, 0xFF, 0xFE, 0x7F, 0xFF, 0xC7, 0xFD,
  0xF8, 0x3E, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x40, 0x3F, 0x0C, 0x0F,
  0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0x0F, 0xFF, 0xC0, 0xFF, 0xF0, 0x07, 0xF8,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF1, 0xF0, 0xFD, 0xFF, 0x3F, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F,
  0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF,
  0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0,
  0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFC, 0x7C, 0xFF, 0xFB, 0xF7,
  0xC7, 0x80, 0x00, 0x00, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD,
  0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF,
  0x7E, 0x0F, 0x83, 0xE1, 0xFC, 0x7F, 0x0F, 0x81, 0xC0, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3E, 0x1F, 0xBF,
  0xEF, 0xFB, 0xFC, 0xFE, 0x3F, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0xFE,
  0xFC, 0x1F, 0xCF, 0xC3, 0xF8, 0xFC, 0x3F, 0x0F, 0xC7, 0xF0, 0xFC, 0xFE,
  0x0F, 0xCF, 0xC0, 0xFD, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFF,
  0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0xFE,
  0x7E, 0x0F, 0xC7, 0xE0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF8, 0xFC, 0x1F, 0x8F,
  0xC1, 0xFC, 0xFC, 0x0F, 0xCF, 0xC0, 0xFE, 0xFC, 0x07, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xF8, 0xF8, 0x1F, 0x87, 0xDF, 0xF1, 0xFE, 0x3F, 0xFF, 0xDF, 0xF9,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x7E, 0x1F, 0xE1, 0xFB, 0xE0,
  0x7E, 0x07, 0xFF, 0x03, 0xF0, 0x3F, 0xF8, 0x1F, 0x81, 0xFF, 0xC0, 0xFC,
  0x0F, 0xFE, 0x07, 0xE0, 0x7F, 0xF0, 0x3F, 0x03, 0xFF, 0x81, 0xF8, 0x1F,
  0xFC, 0x0F, 0xC0, 0xFF, 0xE0, 0x7E, 0x07, 0xFF, 0x03, 0xF0, 0x3F, 0xF8,
  0x1F, 0x81, 0xFF, 0xC0, 0xFC, 0x0F, 0xFE, 0x07, 0xE0, 0x7F, 0xF0, 0x3F,
  0x03, 0xFF, 0x81, 0xF8, 0x1F, 0xFC, 0x0F, 0xC0, 0xFF, 0xE0, 0x7E, 0x07,
  0xFF, 0x03, 0xF0, 0x3F, 0xFC, 0x7C, 0x3F, 0x7F, 0xCF, 0xFF, 0xFB, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F,
  0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF,
  0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0,
  0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0x03, 0xF8,
  0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC7, 0xFF, 0xFC, 0xFC, 0x1F,
  0xBF, 0x83, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F,
  0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F,
  0xFC, 0x07, 0xFF, 0x80, 0xFD, 0xF8, 0x3F, 0x3F, 0xFF, 0xE3, 0xFF, 0xF8,
  0x3F, 0xFE, 0x03, 0xFF, 0x80, 0x1F, 0xC0, 0xFC, 0x7C, 0x1F, 0xBF, 0xE3,
  0xFF, 0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFC, 0x1F, 0xBF, 0x03, 0xFF,
  0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF,
  0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF,
  0x80, 0xFF, 0xF8, 0x3F, 0x7F, 0xFF, 0xEF, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F,
  0x7F, 0xC7, 0xE3, 0xE0, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xC7, 0xC7, 0xFD, 0xF3, 0xFF, 0xFD, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFE, 0x03,
  0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF,
  0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0xFD, 0xFF, 0xFF, 0x7F,
  0xFF, 0xCF, 0xFF, 0xF1, 0xFF, 0xFC, 0x1F, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0xFC, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x0F, 0xE0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F,
  0xFF, 0xE7, 0xF7, 0xF7, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFE, 0x00,
  0x3F, 0xC0, 0x1F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xF8, 0x03,
  0xFE, 0x00, 0x7F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFF, 0x07, 0xFF, 0xFF, 0xF7,
  0xFF, 0xF1, 0xFF, 0xF0, 0x7F, 0xF0, 0x0F, 0xE0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x81, 0xFF, 0x1F,
  0xF0, 0xFF, 0x0F, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF,
  0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC,
  0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03,
  0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xF7, 0xE1, 0xFD,
  0xFF, 0xFF, 0x7F, 0xFF, 0xCF, 0xFD, 0xF1, 0xFF, 0x7C, 0x3F, 0x1F, 0xFC,
  0x07, 0xFF, 0x81, 0xFB, 0xF0, 0x3F, 0x3E, 0x07, 0xE7, 0xE0, 0xF8, 0xFC,
  0x3F, 0x0F, 0x87, 0xE1, 0xF0, 0xFC, 0x3F, 0x1F, 0x07, 0xE3, 0xE0, 0x7C,
  0xFC, 0x0F, 0x9F, 0x01, 0xF3, 0xE0, 0x1F, 0x7C, 0x03, 0xEF, 0x80, 0x7F,
  0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0xFC, 0x1F, 0x03, 0xFF,
  0x83, 0xE0, 0x7F, 0xF0, 0x7C, 0x1F, 0xBE, 0x0F, 0xC3, 0xF7, 0xC3, 0xF8,
  0x7C, 0xF8, 0x7F, 0x0F, 0x9F, 0x8F, 0xE1, 0xF1, 0xF1, 0xFE, 0x7E, 0x3E,
  0x7F, 0xCF, 0xC7, 0xCF, 0xF9, 0xF0, 0xF9, 0xEF, 0x3E, 0x1F, 0x3D, 0xF7,
  0xC1, 0xFF, 0xBE, 0xF8, 0x3F, 0xF3, 0xFE, 0x07, 0xFC, 0x7F, 0xC0, 0xFF,
  0x8F, 0xF8, 0x1F, 0xF1, 0xFF, 0x01, 0xFE, 0x1F, 0xE0, 0x3F, 0x83, 0xF8,
  0x07, 0xF0, 0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xC0, 0xFC, 0x01, 0xF0,
  0x1F, 0x00, 0x3E, 0x03, 0xE0, 0xFE, 0x0F, 0xCF, 0xC1, 0xF9, 0xFC, 0x7E,
  0x1F, 0x8F, 0xC3, 0xF1, 0xF0, 0x3F, 0x7E, 0x07, 0xEF, 0x80, 0x7F, 0xF0,
  0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x03, 0xF7, 0xC0,
  0x7E, 0xFC, 0x1F, 0x8F, 0xC3, 0xF1, 0xF8, 0xFC, 0x3F, 0x9F, 0x83, 0xF7,
  0xE0, 0x7F, 0x7E, 0x03, 0xF7, 0xE0, 0x7E, 0x7E, 0x07, 0xE3, 0xE0, 0x7E,
  0x3F, 0x07, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC1, 0xF0, 0xF8, 0x1F, 0x8F,
  0x81, 0xF9, 0xF8, 0x0F, 0x9F, 0x80, 0xF9, 0xF0, 0x0F, 0xDF, 0x00, 0x7F,
  0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x1E, 0x03, 0xE0, 0x7E, 0x07, 0xC0,
  0xFC, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x07, 0xF0, 0xFE, 0x0F,
  0xC0, 0xFC, 0x0F, 0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xE0, 0x06, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x60, 0x0E, 0x03, 0xE0, 0x7E, 0x03,
  0xE0, 0x7C, 0x0F, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xF0, 0x3E, 0x07, 0xE0, 0x7E, 0x07,
  0xC0, 0xF8, 0x3F, 0x0F, 0xC3, 0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x7E, 0x0F, 0x81,
  0xF0, 0xFC, 0x1F, 0x01, 0xC0, 0x20, 0x00, 0x07, 0x80, 0x00, 0x7F, 0x81,
  0xF3, 0xFF, 0x07, 0xCF, 0xFC, 0x1E, 0x7F, 0xF8, 0xF9, 0xF3, 0xFF, 0xE7,
  0x83, 0xFF, 0x3E, 0x0F, 0xFC, 0xF8, 0x1F, 0xE0, 0x00, 0x1E, 0x00,
};

const GFXglyph RobotoCondensed_SemiBold46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 6, 33, 12, 3, -33 },
  { 26, 11, 12, 15, 2, -35 },
  { 43, 21, 33, 24, 2, -33 },
  { 130, 19, 42, 23, 2, -38 },
  { 230, 25, 33, 29, 2, -33 },
  { 334, 24, 33, 26, 2, -33 },
  { 433, 4, 12, 8, 2, -35 },
  { 439, 11, 46, 15, 3, -36 },
  { 503, 11, 46, 15, 1, -36 },
  { 567, 19, 20, 21, 1, -33 },
  { 615, 18, 23, 22, 2, -27 },
  { 667, 7, 13, 11, 1, -5 },
  { 679, 11, 5, 15, 2, -17 },
  { 686, 7, 7, 13, 3, -7 },
  { 693, 15, 36, 16, 0, -33 },
  { 761, 19, 33, 23, 2, -33 },
  { 840, 12, 33, 23, 4, -33 },
  { 890, 19, 33, 23, 2, -33 },
  { 969, 19, 33, 23, 2, -33 },
  { 1048, 21, 33, 23, 1, -33 },
  { 1135, 19, 33, 23, 2, -33 },
  { 1214, 19, 33, 23, 2, -33 },
  { 1293, 19, 33, 23, 2, -33 },
  { 1372, 19, 33, 23, 2, -33 },
  { 1451, 19, 33, 23, 2, -33 },
  { 1530, 7, 26, 12, 3, -26 },
  { 1553, 8, 34, 11, 1, -26 },
  { 1587, 17, 22, 21, 1, -25 },
  { 1634, 17, 15, 23, 3, -22 },
  { 1666, 16, 22, 21, 3, -25 },
  { 1710, 18, 33, 20, 1, -33 },
  { 1785, 31, 42, 35, 2, -32 },
  { 1948, 26, 33, 27, 1, -33 },
  { 2056, 20, 33, 26, 3, -33 },
  { 2139, 23, 33, 26, 2, -33 },
  { 2234, 21, 33, 26, 3, -33 },
  { 2321, 18, 33, 23, 3, -33 },
  { 2396, 18, 33, 22, 3, -33 },
  { 2471, 23, 33, 27, 2, -33 },
  { 2566, 22, 33, 28, 3, -33 },
  { 2657, 6, 33, 12, 3, -33 },
  { 2682, 19, 33, 22, 1, -33 },
  { 2761, 22, 33, 25, 3, -33 },
  { 2852, 18, 33, 22, 3, -33 },
  { 2927, 29, 33, 35, 3, -33 },
  { 3047, 22, 33, 28, 3, -33 },
  { 3138, 23, 33, 28, 2, -33 },
  { 3233, 21, 33, 26, 3, -33 },
  { 3320, 24, 39, 28, 2, -33 },
  { 3437, 21, 33, 25, 3, -33 },
  { 3524, 21, 33, 25, 2, -33 },
  { 3611, 23, 33, 25, 1, -33 },
  { 3706, 21, 33, 26, 3, -33 },
  { 3793, 25, 33, 26, 1, -33 },
  { 3897, 33, 33, 35, 1, -33 },
  { 4034, 24, 33, 26, 1, -33 },
  { 4133, 24, 33, 25, 0, -33 },
  { 4232, 21, 33, 24, 2, -33 },
  { 4319, 8, 45, 12, 3, -38 },
  { 4364, 18, 36, 17, 0, -33 },
  { 4445, 8, 45, 12, 1, -38 },
  { 4490, 16, 16, 18, 1, -33 },
  { 4522, 18, 5, 18, 0, 0 },
  { 4534, 11, 7, 15, 1, -35 },
  { 4544, 18, 24, 22, 2, -24 },
  { 4598, 19, 35, 23, 2, -35 },
  { 4682, 18, 24, 21, 2, -24 },
  { 4736, 18, 35, 23, 2, -35 },
  { 4815, 18, 24, 22, 2, -24 },
  { 4869, 13, 35, 15, 1, -35 },
  { 4926, 19, 33, 23, 2, -24 },
  { 5005, 18, 35, 23, 2, -35 },
  { 5084, 7, 33, 11, 2, -33 },
  { 5113, 10, 42, 11, -1, -33 },
  { 5166, 20, 35, 22, 2, -35 },
  { 5254, 6, 35, 11, 3, -35 },
  { 5281, 29, 24, 34, 3, -24 },
  { 5368, 18, 24, 23, 2, -24 },
  { 5422, 19, 24, 23, 2, -24 },
  { 5479, 19, 33, 23, 2, -24 },
  { 5558, 18, 33, 23, 2, -24 },
  { 5633, 12, 24, 15, 2, -24 },
  { 5669, 17, 24, 21, 2, -24 },
  { 5720, 12, 30, 14, 1, -30 },
  { 5765, 18, 24, 23, 2, -24 },
  { 5819, 19, 24, 20, 1, -24 },
  { 5876, 27, 24, 29, 1, -24 },
  { 5957, 19, 24, 21, 1, -24 },
  { 6014, 20, 33, 20, 0, -24 },
  { 6097, 17, 24, 21, 2, -24 },
  { 6148, 12, 44, 14, 1, -36 },
  { 6214, 4, 39, 12, 4, -33 },
  { 6234, 11, 44, 14, 1, -36 },
  { 6295, 22, 10, 26, 2, -19 },
};

const GFXfont RobotoCondensed_SemiBold46pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_SemiBold46pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_SemiBold46pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _ROBOTOCONDENSED_SEMIBOLD46PT7B_H_
