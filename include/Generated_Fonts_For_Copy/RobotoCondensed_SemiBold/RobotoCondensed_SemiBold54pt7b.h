#ifndef _ROBOTOCONDENSED_SEMIBOLD54PT7B_H_
#define _ROBOTOCONDENSED_SEMIBOLD54PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-SemiBold.ttf
// Size: 54pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_SemiBold54pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x7E, 0xFF, 0xFF,
  0x7F, 0x7E, 0x3E, 0x00, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F,
  0xFC, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0xFF, 0xC7, 0xFC, 0x3F, 0xE1, 0xFF,
  0x0F, 0xF8, 0x78, 0x00, 0x7C, 0x3C, 0x00, 0x3E, 0x1E, 0x00, 0x1E, 0x1F,
  0x00, 0x0F, 0x0F, 0x80, 0x07, 0x87, 0x80, 0x03, 0xC3, 0xC0, 0x03, 0xE1,
  0xE0, 0x01, 0xF0, 0xF0, 0x00, 0xF0, 0xF8, 0x00, 0x78, 0x7C, 0x00, 0x3C,
  0x3E, 0x07, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFE, 0x03, 0xC3, 0xE0, 0x01, 0xE1, 0xF0, 0x00, 0xF0, 0xF0, 0x00,
  0x78, 0x78, 0x00, 0x7C, 0x3C, 0x00, 0x3E, 0x1E, 0x00, 0x1E, 0x1F, 0x00,
  0x0F, 0x0F, 0x81, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0x80, 0xF8, 0x78, 0x00, 0x78, 0x7C, 0x00, 0x3C, 0x3E,
  0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x87, 0x80, 0x07, 0xC3,
  0xC0, 0x03, 0xE3, 0xE0, 0x01, 0xE1, 0xF0, 0x00, 0xF0, 0xF8, 0x00, 0x78,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0xFF, 0xC0,
  0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F,
  0xCF, 0xF1, 0xFC, 0x1F, 0xE7, 0xF0, 0x3F, 0x9F, 0xC0, 0xFE, 0x7F, 0x01,
  0xF9, 0xFC, 0x07, 0xE7, 0xF0, 0x1F, 0x9F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x3F,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFB, 0xF0, 0x0F, 0xEF,
  0xC0, 0x1F, 0xBF, 0x80, 0x7F, 0xFE, 0x01, 0xFB, 0xF8, 0x0F, 0xEF, 0xF0,
  0x3F, 0x9F, 0xE3, 0xFE, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFE,
  0x03, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7C, 0x7C, 0x06, 0x03, 0xC1, 0xF0, 0x7C,
  0x1E, 0x0F, 0x83, 0xC0, 0xF0, 0x7C, 0x3E, 0x07, 0x83, 0xE1, 0xE0, 0x3C,
  0x1F, 0x1F, 0x01, 0xE0, 0xF8, 0xF0, 0x0F, 0x07, 0xCF, 0x80, 0x7C, 0x7C,
  0x78, 0x03, 0xFF, 0xE7, 0xC0, 0x0F, 0xFE, 0x3C, 0x00, 0x3F, 0xF3, 0xC0,
  0x00, 0xFE, 0x1E, 0x00, 0x00, 0x81, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0xFF, 0x00, 0x07,
  0xCF, 0xFC, 0x00, 0x3C, 0xFF, 0xF0, 0x03, 0xE7, 0xFF, 0x80, 0x1E, 0x7C,
  0x3E, 0x01, 0xF3, 0xE1, 0xF0, 0x0F, 0x1E, 0x0F, 0x80, 0xF8, 0xF0, 0x7C,
  0x07, 0x87, 0x83, 0xE0, 0x78, 0x3C, 0x1F, 0x03, 0xC1, 0xE0, 0xF8, 0x3C,
  0x0F, 0x87, 0xC1, 0xE0, 0x7C, 0x3E, 0x02, 0x01, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F,
  0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xE7, 0xF0,
  0x01, 0xFC, 0x3F, 0x00, 0x1F, 0x83, 0xF0, 0x01, 0xF8, 0x1F, 0x00, 0x1F,
  0x83, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0x83, 0xF0, 0x01, 0xFC, 0x7E,
  0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x7F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFE,
  0x0F, 0xC1, 0xFF, 0xE0, 0xFC, 0x3F, 0xFF, 0x0F, 0xC3, 0xFF, 0xF8, 0xFC,
  0x7F, 0x3F, 0xCF, 0xC7, 0xE1, 0xFD, 0xF8, 0xFE, 0x1F, 0xFF, 0x8F, 0xE0,
  0xFF, 0xF8, 0xFE, 0x07, 0xFF, 0x8F, 0xE0, 0x3F, 0xF0, 0xFE, 0x03, 0xFF,
  0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0x01, 0xFE, 0x07, 0xFC, 0x7F, 0xF0, 0x7F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFD,
  0xFE, 0x03, 0xFF, 0x0F, 0xF0, 0x02, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x10, 0x01, 0x80, 0x1C, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0x3E,
  0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x03, 0xE0,
  0x1F, 0x00, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x07,
  0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0x00, 0x18, 0x00, 0x40, 0x20,
  0x03, 0x80, 0x1E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0x80, 0x7E, 0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x81,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x01, 0xF8, 0x0F, 0x80, 0x7C,
  0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x07,
  0x80, 0x38, 0x00, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x18, 0x1E,
  0x02, 0x3C, 0x3C, 0x1E, 0xFF, 0x79, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0x80, 0x07, 0xCF, 0x80, 0x1F, 0x9F, 0x80, 0x7E, 0x1F, 0x80,
  0xF8, 0x1F, 0x01, 0xF0, 0x3E, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x20, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC,
  0x7E, 0x7E, 0x3F, 0x1F, 0x8F, 0x8F, 0xC7, 0xC7, 0xE1, 0xE0, 0x20, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3E, 0x7F, 0x7F, 0xFF,
  0x7F, 0x7F, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03,
  0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x87, 0xF8, 0xFF, 0x1F, 0xC1, 0xFC, 0x7E, 0x03, 0xF3, 0xF8, 0x0F, 0xEF,
  0xE0, 0x3F, 0xBF, 0x80, 0xFE, 0xFE, 0x01, 0xFB, 0xF0, 0x07, 0xEF, 0xC0,
  0x1F, 0xBF, 0x00, 0x7E, 0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xFF, 0xC0, 0x1F,
  0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF,
  0x00, 0x7E, 0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xEF, 0xC0, 0x1F, 0xBF, 0x80,
  0x7E, 0xFE, 0x03, 0xFB, 0xF8, 0x0F, 0xEF, 0xE0, 0x3F, 0x9F, 0x80, 0xFC,
  0x7F, 0x07, 0xF1, 0xFE, 0x3F, 0xC3, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F,
  0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x08, 0x00, 0x00, 0x0C,
  0x00, 0xF0, 0x0F, 0xC1, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xE3, 0xFC, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x10, 0x00, 0x03, 0xFF, 0x00, 0x1F,
  0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x1F, 0xF1,
  0xFE, 0x3F, 0x81, 0xFE, 0x7F, 0x01, 0xFD, 0xFC, 0x03, 0xFB, 0xF8, 0x07,
  0xF7, 0xF0, 0x0F, 0xEF, 0xE0, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xE7, 0xFC, 0x7F, 0x9F, 0xC0, 0xFE, 0x7F, 0x01, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x80,
  0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0x7F, 0xFF, 0x03, 0xFD, 0xFE, 0x1F, 0xE7, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x08, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x0F, 0xBF, 0x80, 0x3F,
  0x7F, 0x00, 0x7C, 0xFE, 0x01, 0xF9, 0xFC, 0x03, 0xF3, 0xF8, 0x0F, 0xC7,
  0xF0, 0x1F, 0x8F, 0xE0, 0x7E, 0x1F, 0xC0, 0xFC, 0x3F, 0x83, 0xF0, 0x7F,
  0x07, 0xE0, 0xFE, 0x1F, 0x81, 0xFC, 0x3F, 0x03, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xF9, 0xF8, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xE1, 0xFF, 0xFF, 0xC7, 0xF9, 0xFF, 0x0F, 0x81, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07,
  0xEF, 0xE0, 0x3F, 0x9F, 0xC0, 0xFE, 0x7F, 0x8F, 0xF0, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x01, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x01, 0xFF, 0x80, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0xFC, 0x0F, 0xEF, 0xFC, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xBF, 0xC1, 0xFE, 0xFF, 0x03, 0xFB,
  0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFD, 0xF8, 0x07,
  0xF7, 0xF0, 0x3F, 0x9F, 0xC0, 0xFE, 0x3F, 0xCF, 0xF8, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x03,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xE0,
  0x3F, 0xFF, 0x83, 0xFF, 0xFE, 0x1F, 0xFF, 0xF9, 0xFE, 0x3F, 0xCF, 0xE0,
  0xFE, 0x7F, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF,
  0xE0, 0x3F, 0xBF, 0x01, 0xF9, 0xFC, 0x1F, 0xCF, 0xE0, 0xFE, 0x3F, 0xFF,
  0xE0, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x01, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF1, 0xFE, 0x3F, 0xCF, 0xE0, 0xFE, 0xFE, 0x03, 0xFF, 0xF0, 0x1F,
  0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8,
  0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0x07, 0xFB, 0xFC, 0x7F, 0x9F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x04,
  0x00, 0x00, 0x10, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xF0,
  0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC3, 0xFC, 0xFF, 0x0F, 0xE0, 0xFE, 0x7F,
  0x03, 0xF9, 0xFC, 0x07, 0xE7, 0xF0, 0x1F, 0xDF, 0x80, 0x7F, 0xFE, 0x01,
  0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xDF, 0x80, 0x7F, 0x7F, 0x01, 0xFD,
  0xFC, 0x07, 0xF7, 0xF0, 0x1F, 0xDF, 0xE0, 0xFF, 0x3F, 0xEF, 0xFC, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x07, 0xFD, 0xFC, 0x07, 0xC7,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xE0, 0x1F, 0xFF, 0x00, 0x7F,
  0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x7F, 0x7F, 0xFF, 0xFF, 0x7F, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x7F, 0x7F, 0xFF, 0x7F, 0x7F, 0x3E, 0x00, 0x0F, 0x07, 0xE3, 0xFC, 0xFF,
  0x3F, 0xCF, 0xF1, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F,
  0x0F, 0xC3, 0xF1, 0xF8, 0x7C, 0x1F, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00,
  0x1C, 0x00, 0x0F, 0x80, 0x07, 0xF0, 0x03, 0xFE, 0x01, 0xFF, 0xC0, 0xFF,
  0xF8, 0x7F, 0xFC, 0x3F, 0xFE, 0x1F, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xC0,
  0x0F, 0xC0, 0x01, 0xFE, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE,
  0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xF0, 0x03, 0xFE, 0x00, 0x1F,
  0xC0, 0x00, 0xF8, 0x00, 0x07, 0x00, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x80, 0x00, 0x0E, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0xFF,
  0x80, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80,
  0x3F, 0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x00, 0x07, 0xF0, 0x01, 0xFF,
  0x00, 0xFF, 0xF0, 0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF8,
  0x0F, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0xF8, 0x00, 0x0E, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0x03,
  0xFF, 0xF8, 0x7F, 0xFF, 0xC7, 0xFF, 0xFE, 0xFF, 0x9F, 0xEF, 0xE0, 0xFE,
  0xFE, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x0F, 0xF8, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x7C, 0x00, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x3E,
  0x00, 0x7E, 0x03, 0xE1, 0xF0, 0x0F, 0xF8, 0x0F, 0x0F, 0x00, 0xFF, 0xF0,
  0x78, 0xF8, 0x0F, 0xFF, 0x83, 0xC7, 0xC0, 0xFE, 0x7C, 0x1F, 0x3C, 0x07,
  0xC3, 0xE0, 0x7B, 0xE0, 0x7C, 0x1F, 0x03, 0xDF, 0x03, 0xE0, 0xF8, 0x1E,
  0xF8, 0x3E, 0x07, 0xC0, 0xF7, 0x81, 0xF0, 0x3E, 0x07, 0xBC, 0x0F, 0x81,
  0xF0, 0x3D, 0xE0, 0xFC, 0x0F, 0x01, 0xFF, 0x07, 0xC0, 0x78, 0x0F, 0xF8,
  0x3E, 0x03, 0xC0, 0x7F, 0xC1, 0xF0, 0x3E, 0x03, 0xFE, 0x0F, 0x81, 0xF0,
  0x1F, 0xF0, 0x7C, 0x0F, 0x81, 0xFF, 0x83, 0xE0, 0x7C, 0x0F, 0x7C, 0x1F,
  0x03, 0xE0, 0x79, 0xE0, 0xFC, 0x1F, 0x03, 0xCF, 0x07, 0xE1, 0xF8, 0x3C,
  0x78, 0x1F, 0x9F, 0xC3, 0xE3, 0xE0, 0xFF, 0xFF, 0xFE, 0x1F, 0x07, 0xFE,
  0xFF, 0xF0, 0xF8, 0x1F, 0xF3, 0xFF, 0x03, 0xE0, 0x7F, 0x0F, 0xE0, 0x1F,
  0x00, 0x40, 0x08, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x01, 0x80, 0x00, 0x3F, 0xF0, 0x7C, 0x00,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x3F, 0x3F, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x07, 0xF3, 0xF0, 0x00,
  0x1F, 0xCF, 0xE0, 0x00, 0x7E, 0x1F, 0x80, 0x01, 0xF8, 0x7E, 0x00, 0x0F,
  0xE1, 0xFC, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xF0,
  0x3F, 0x80, 0x1F, 0xC0, 0xFE, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC3,
  0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xFC, 0x7F, 0x80, 0x07, 0xF9, 0xFC,
  0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x07, 0xF0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE,
  0xFE, 0x01, 0xFE, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFE,
  0xFE, 0x00, 0xFE, 0xFE, 0x03, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0xFE, 0x01, 0xFE,
  0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC3, 0xFF, 0x3F, 0xF1, 0xFE,
  0x01, 0xFE, 0x7F, 0x00, 0x3F, 0x9F, 0xC0, 0x0F, 0xEF, 0xE0, 0x01, 0xFF,
  0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80,
  0x0F, 0xF7, 0xF0, 0x03, 0xF9, 0xFC, 0x00, 0xFE, 0x7F, 0x80, 0x7F, 0x8F,
  0xF8, 0x7F, 0xC3, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x30, 0x00, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xE3, 0xF8, 0x0F, 0xF9, 0xFC, 0x03, 0xFC, 0xFE,
  0x00, 0xFF, 0x7F, 0x00, 0x3F, 0xBF, 0x80, 0x1F, 0xDF, 0xC0, 0x0F, 0xEF,
  0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F,
  0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07,
  0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00,
  0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xDF, 0xC0,
  0x0F, 0xEF, 0xE0, 0x07, 0xF7, 0xF0, 0x07, 0xFB, 0xF8, 0x07, 0xF9, 0xFC,
  0x07, 0xFC, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFB, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0x3F, 0xF1, 0xFE, 0x01, 0xFE,
  0x7F, 0x80, 0x3F, 0x9F, 0xC0, 0x0F, 0xEF, 0xF0, 0x01, 0xFF, 0xF8, 0x00,
  0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xE0,
  0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xF7,
  0xF0, 0x01, 0xFD, 0xFE, 0x00, 0x7F, 0x7F, 0xC0, 0x3F, 0xCF, 0xFE, 0x7F,
  0xF1, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x38, 0x00, 0xFE, 0x00, 0x0F, 0xFF,
  0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE,
  0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80,
  0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF,
  0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0xFF, 0xFC, 0x00, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xFC,
  0x07, 0xF7, 0xF0, 0x3F, 0xDF, 0xE0, 0xFE, 0x7F, 0xCF, 0xF8, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x0F, 0xFC, 0x00,
  0x01, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xDF, 0xC0, 0x0F, 0xFB, 0xF8, 0x03,
  0xFE, 0x7F, 0x00, 0x7F, 0x8F, 0xE0, 0x1F, 0xE1, 0xFC, 0x03, 0xFC, 0x3F,
  0x80, 0xFF, 0x07, 0xF0, 0x3F, 0xC0, 0xFE, 0x07, 0xF8, 0x1F, 0xC1, 0xFE,
  0x03, 0xF8, 0x7F, 0x80, 0x7F, 0x0F, 0xF0, 0x0F, 0xE3, 0xFC, 0x01, 0xFC,
  0x7F, 0x00, 0x3F, 0x9F, 0xE0, 0x07, 0xF7, 0xF8, 0x00, 0xFE, 0xFE, 0x00,
  0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFE, 0xFF, 0x00,
  0xFF, 0x8F, 0xE0, 0x1F, 0xE1, 0xFE, 0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0x03,
  0xFC, 0x0F, 0xE0, 0x3F, 0xC1, 0xFC, 0x07, 0xF8, 0x3F, 0x80, 0x7F, 0x87,
  0xF0, 0x0F, 0xF0, 0xFE, 0x00, 0xFF, 0x1F, 0xC0, 0x1F, 0xE3, 0xF8, 0x01,
  0xFE, 0x7F, 0x00, 0x3F, 0xEF, 0xE0, 0x03, 0xFD, 0xFC, 0x00, 0x7F, 0xC0,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xF0, 0x07, 0xDF, 0xFF, 0xFF, 0x01, 0xFB, 0xFF, 0xF7, 0xE0,
  0x3F, 0x7F, 0xFE, 0xFC, 0x07, 0xEF, 0xFF, 0xDF, 0xC1, 0xF9, 0xFF, 0xF9,
  0xF8, 0x3F, 0x3F, 0xFF, 0x3F, 0x07, 0xE7, 0xFF, 0xE7, 0xE1, 0xF8, 0xFF,
  0xFC, 0x7E, 0x3F, 0x1F, 0xFF, 0x8F, 0xC7, 0xE3, 0xFF, 0xF1, 0xF8, 0xF8,
  0x7F, 0xFE, 0x1F, 0xBF, 0x0F, 0xFF, 0xC3, 0xF7, 0xE1, 0xFF, 0xF8, 0x7E,
  0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xFC,
  0x1F, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xE0, 0x7F,
  0xFE, 0x07, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xE0,
  0x3F, 0xFF, 0x01, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0x80, 0xFF, 0xFC, 0x03,
  0xE0, 0x1F, 0xC0, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xBF, 0x83, 0xFF, 0xF7, 0xF0, 0x7F, 0xFE, 0x7F, 0x0F,
  0xFF, 0xCF, 0xE1, 0xFF, 0xF8, 0xFE, 0x3F, 0xFF, 0x1F, 0xC7, 0xFF, 0xE1,
  0xFC, 0xFF, 0xFC, 0x3F, 0x9F, 0xFF, 0x83, 0xFB, 0xFF, 0xF0, 0x7F, 0x7F,
  0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xC0,
  0x00, 0x04, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFE, 0xFF, 0xC1,
  0xFE, 0x03, 0xFC, 0x7F, 0x80, 0x3F, 0x8F, 0xE0, 0x07, 0xFB, 0xFC, 0x00,
  0x7F, 0x7F, 0x00, 0x0F, 0xEF, 0xE0, 0x01, 0xFD, 0xFC, 0x00, 0x1F, 0xFF,
  0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F,
  0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0,
  0x01, 0xFD, 0xFE, 0x00, 0x3F, 0x9F, 0xC0, 0x07, 0xF3, 0xFC, 0x01, 0xFE,
  0x7F, 0xC0, 0x7F, 0x87, 0xFF, 0x7F, 0xF0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x20, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFB, 0xF8, 0x03,
  0xFD, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80,
  0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8,
  0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xBF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0,
  0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xC3, 0xFE, 0x03, 0xFC, 0x7F, 0x80, 0x3F, 0x8F, 0xE0, 0x07, 0xFB,
  0xFC, 0x00, 0x7F, 0x7F, 0x00, 0x0F, 0xEF, 0xE0, 0x01, 0xFD, 0xFC, 0x00,
  0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF,
  0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE,
  0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x0F,
  0xEF, 0xE0, 0x01, 0xFD, 0xFE, 0x00, 0x3F, 0x9F, 0xC0, 0x0F, 0xF3, 0xFC,
  0x01, 0xFC, 0x7F, 0xC0, 0x7F, 0x87, 0xFF, 0x7F, 0xE0, 0x7F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x67, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x04, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x8F, 0xE0, 0x1F,
  0xE3, 0xF8, 0x03, 0xFC, 0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xCF, 0xE0,
  0x07, 0xF3, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xCF,
  0xE0, 0x07, 0xF3, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0xFF, 0x3F, 0x80, 0x7F,
  0x8F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFE, 0x0F, 0xF0, 0x3F,
  0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x83, 0xF8, 0x0F, 0xE0, 0xFE, 0x03, 0xFC,
  0x3F, 0x80, 0xFF, 0x0F, 0xE0, 0x1F, 0xC3, 0xF8, 0x07, 0xF8, 0xFE, 0x00,
  0xFE, 0x3F, 0x80, 0x3F, 0xCF, 0xE0, 0x07, 0xF3, 0xF8, 0x01, 0xFE, 0xFE,
  0x00, 0x7F, 0xBF, 0x80, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xF0, 0xFF, 0x8F, 0xF8, 0xFF, 0x01, 0xFE, 0x7F, 0x00, 0x7F, 0x3F, 0x80,
  0x3F, 0x9F, 0xC0, 0x1F, 0xCF, 0xE0, 0x0F, 0xF7, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x0F,
  0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80,
  0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03,
  0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0xFE, 0xFE, 0x00, 0xFF, 0x7F, 0x80,
  0x7F, 0x1F, 0xF8, 0xFF, 0x8F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x00, 0x18, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xFF,
  0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF,
  0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F,
  0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03,
  0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00,
  0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0,
  0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE,
  0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF,
  0xE0, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x01, 0xFC, 0xFF, 0x01, 0xFE,
  0x7F, 0xE3, 0xFF, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x20, 0x00, 0xFE, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFE, 0xFE, 0x00, 0x0F,
  0xE7, 0xF0, 0x00, 0x7F, 0x3F, 0xC0, 0x07, 0xF8, 0xFE, 0x00, 0x3F, 0x87,
  0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xE0, 0xFE, 0x00, 0xFF, 0x07, 0xF0,
  0x07, 0xF0, 0x3F, 0x80, 0x3F, 0x81, 0xFC, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x3F, 0x80, 0xFE, 0x01, 0xFC, 0x07, 0xF0, 0x07, 0xE0, 0x3F, 0x00,
  0x3F, 0x83, 0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0xFE, 0x00, 0x3F,
  0x0F, 0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x3F, 0x1F,
  0x80, 0x01, 0xF9, 0xFC, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x3F, 0x7E, 0x00,
  0x01, 0xFB, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xFD, 0xFC, 0x03, 0xF8,
  0x07, 0xF7, 0xF0, 0x0F, 0xE0, 0x1F, 0xDF, 0xC0, 0x3F, 0x80, 0x7F, 0x7F,
  0x00, 0xFE, 0x01, 0xFD, 0xFC, 0x07, 0xF8, 0x07, 0xE3, 0xF0, 0x1F, 0xF0,
  0x3F, 0x8F, 0xE0, 0x7F, 0xC0, 0xFE, 0x3F, 0x81, 0xFF, 0x03, 0xF8, 0xFE,
  0x07, 0xFC, 0x0F, 0xE3, 0xF8, 0x3F, 0xF0, 0x3F, 0x8F, 0xE0, 0xFF, 0xE0,
  0xFC, 0x1F, 0x83, 0xFF, 0x87, 0xF0, 0x7F, 0x0F, 0xFE, 0x1F, 0xC1, 0xFC,
  0x3E, 0xF8, 0x7F, 0x07, 0xF1, 0xFB, 0xE1, 0xFC, 0x1F, 0xC7, 0xEF, 0xC7,
  0xE0, 0x3F, 0x1F, 0xBF, 0x1F, 0x80, 0xFC, 0x7C, 0xFC, 0x7E, 0x03, 0xF1,
  0xF1, 0xF3, 0xF8, 0x0F, 0xEF, 0xC7, 0xCF, 0xE0, 0x3F, 0xBF, 0x1F, 0xBF,
  0x00, 0x7E, 0xFC, 0x7E, 0xFC, 0x01, 0xFB, 0xE1, 0xFB, 0xF0, 0x07, 0xEF,
  0x83, 0xEF, 0xC0, 0x1F, 0xFE, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x3F, 0xFC,
  0x01, 0xFF, 0xE0, 0xFF, 0xE0, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x0F, 0xFC,
  0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0xE0,
  0x03, 0xFE, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x07, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF7, 0xF8, 0x01, 0xFE,
  0x3F, 0xC0, 0x1F, 0xE3, 0xFC, 0x03, 0xFC, 0x1F, 0xC0, 0x3F, 0xC1, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x80, 0xFF, 0x07, 0xF0, 0x07, 0xF0, 0xFF,
  0x00, 0x7F, 0x8F, 0xE0, 0x03, 0xF9, 0xFE, 0x00, 0x3F, 0xDF, 0xC0, 0x01,
  0xFD, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0,
  0x03, 0xF9, 0xFC, 0x00, 0x7F, 0x9F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0xFF,
  0x0F, 0xF0, 0x0F, 0xE0, 0x7F, 0x01, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F,
  0x83, 0xFC, 0x03, 0xFC, 0x3F, 0xC0, 0x3F, 0xC7, 0xF8, 0x01, 0xFE, 0x7F,
  0x80, 0x1F, 0xEF, 0xF0, 0x00, 0xFF, 0x7F, 0x00, 0x07, 0xF3, 0xFC, 0x00,
  0x7F, 0x8F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xC3, 0xFC, 0x01, 0xFE,
  0x0F, 0xE0, 0x0F, 0xE0, 0x7F, 0x80, 0xFF, 0x01, 0xFC, 0x07, 0xF0, 0x0F,
  0xE0, 0x3F, 0x80, 0x3F, 0x83, 0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0,
  0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x07, 0xE3, 0xF0,
  0x00, 0x3F, 0xBF, 0x80, 0x00, 0xFD, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F,
  0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8,
  0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F,
  0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3,
  0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xF1, 0xFC, 0x7F,
  0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7,
  0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC,
  0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F,
  0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1,
  0xFC, 0x7F, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFF, 0x00,
  0x7F, 0xC0, 0x3E, 0xF8, 0x0F, 0xBE, 0x03, 0xEF, 0x81, 0xF1, 0xF0, 0x7C,
  0x7C, 0x1F, 0x1F, 0x0F, 0xC7, 0xE3, 0xE0, 0xF8, 0xF8, 0x3E, 0x7E, 0x0F,
  0xDF, 0x01, 0xF7, 0xC0, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x81, 0xFC, 0x07,
  0xF0, 0x1F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF,
  0xFF, 0xC7, 0xF8, 0x7F, 0x1F, 0xC1, 0xFC, 0x7F, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xE1,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x7F, 0xC3, 0xF9, 0xFC, 0x0F, 0xE7, 0xF0,
  0x3F, 0xBF, 0x80, 0xFE, 0xFE, 0x03, 0xFB, 0xF8, 0x0F, 0xEF, 0xE0, 0x3F,
  0xBF, 0x81, 0xFE, 0xFF, 0x0F, 0xF9, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFE, 0x1F, 0xFB, 0xF8, 0x3F, 0xC7, 0xF0, 0x08, 0x00, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x82, 0x00, 0xFE, 0x7F, 0x83, 0xFB,
  0xFF, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFE, 0x3F,
  0xEF, 0xF0, 0x3F, 0xBF, 0x80, 0xFE, 0xFE, 0x01, 0xFB, 0xF8, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFB, 0xF8, 0x0F, 0xEF, 0xF0, 0x3F, 0xBF,
  0xE3, 0xFE, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xDF, 0xFE, 0x3F, 0x3F,
  0xF0, 0xFC, 0x7F, 0x80, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x1F, 0xF8,
  0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xC3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF9, 0xFE,
  0x1F, 0xEF, 0xE0, 0x7F, 0x7F, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x1F, 0xFF, 0x00, 0xFD, 0xF8, 0x0F, 0xEF, 0xE0, 0x7F, 0x7F, 0x87,
  0xF1, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0xFF, 0xF8, 0x01,
  0xFF, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x10, 0x7F, 0x07, 0xF9, 0xFC, 0x3F, 0xF7, 0xF1, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFD, 0xFF, 0x3F, 0xF7, 0xF0, 0x3F, 0xFF, 0xC0, 0x7F,
  0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE,
  0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01,
  0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFD,
  0xFC, 0x07, 0xF7, 0xF0, 0x3F, 0xDF, 0xF1, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xC3, 0xFF, 0x7F, 0x07, 0xF8, 0xFC, 0x03, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFC, 0x7F, 0x9F, 0xC0, 0xFE, 0x7F,
  0x01, 0xF9, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x02, 0x1F, 0xE0, 0x1C, 0x3F, 0xC1, 0xF8, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x07, 0xFE, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x07,
  0xFF, 0x07, 0xFF, 0x0F, 0xF8, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFE, 0xFF, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF3, 0xF0, 0xFF, 0xEF, 0xC7,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF7, 0xFC, 0x7F, 0xDF, 0xC0,
  0x7F, 0x7F, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F,
  0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE,
  0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01,
  0xFF, 0xF8, 0x07, 0xF7, 0xF0, 0x1F, 0xDF, 0xC0, 0x7F, 0x7F, 0xC7, 0xFC,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x1F,
  0xE7, 0xF0, 0x04, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x20, 0x07,
  0xF1, 0xC0, 0x3F, 0x87, 0xF7, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE7, 0xF8, 0x7F, 0x7F, 0xE3, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xF7, 0xFC, 0xFF, 0xBF, 0x81, 0xFD, 0xFC, 0x0F,
  0xEF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE,
  0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F,
  0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0,
  0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xF8, 0x7D, 0xFF, 0xFF, 0xFF,
  0xEF, 0xCF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xC1, 0xFC, 0x3F, 0x87,
  0xF0, 0xFE, 0x1F, 0xC1, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE,
  0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F,
  0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3,
  0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF1, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFE, 0xFF, 0x9F, 0xE3, 0xF0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x07, 0xFB, 0xF8, 0x1F, 0xEF, 0xE0, 0xFF, 0x3F,
  0x87, 0xF8, 0xFE, 0x1F, 0xC3, 0xF8, 0xFF, 0x0F, 0xE7, 0xF8, 0x3F, 0x9F,
  0xC0, 0xFE, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00,
  0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0xFF,
  0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xF7, 0xF8, 0x3F, 0x8F, 0xE0, 0xFE, 0x3F,
  0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFE, 0x3F, 0x83, 0xF8, 0xFE, 0x0F, 0xF3,
  0xF8, 0x1F, 0xEF, 0xE0, 0x7F, 0xBF, 0x80, 0xFF, 0xFE, 0x03, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x04, 0x00, 0x20, 0x3F, 0x1F, 0xE0, 0xFF, 0x0F, 0xCF, 0xFC, 0x7F, 0xF3,
  0xF7, 0xFF, 0xBF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF,
  0xEF, 0xF9, 0xFF, 0xE7, 0xFF, 0xF8, 0x1F, 0xE0, 0x7F, 0xFE, 0x07, 0xF8,
  0x1F, 0xFF, 0x80, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0x01, 0xFF, 0xF8, 0x0F,
  0xC0, 0x7F, 0xFE, 0x03, 0xF0, 0x1F, 0xFF, 0x80, 0xFC, 0x07, 0xFF, 0xE0,
  0x3F, 0x01, 0xFF, 0xF8, 0x0F, 0xC0, 0x7F, 0xFE, 0x03, 0xF0, 0x1F, 0xFF,
  0x80, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0x01, 0xFF, 0xF8, 0x0F, 0xC0, 0x7F,
  0xFE, 0x03, 0xF0, 0x1F, 0xFF, 0x80, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0x01,
  0xFF, 0xF8, 0x0F, 0xC0, 0x7F, 0xFE, 0x03, 0xF0, 0x1F, 0xFF, 0x80, 0xFC,
  0x07, 0xFF, 0xE0, 0x3F, 0x01, 0xFF, 0xF8, 0x0F, 0xC0, 0x7F, 0xFE, 0x03,
  0xF0, 0x1F, 0xFF, 0x80, 0xFC, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE3, 0xFC,
  0x3F, 0x3F, 0xF1, 0xFB, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFB, 0xFE,
  0x3F, 0xDF, 0xC0, 0xFE, 0xFE, 0x07, 0xF7, 0xF0, 0x1F, 0xFF, 0x80, 0xFF,
  0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0,
  0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF,
  0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03,
  0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF,
  0x01, 0xFC, 0x00, 0x10, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x7F,
  0xFF, 0x01, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xF1, 0xFE, 0x3F, 0xC1,
  0xFE, 0x7F, 0x01, 0xFC, 0xFC, 0x03, 0xFB, 0xF8, 0x03, 0xFF, 0xF0, 0x07,
  0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F,
  0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF,
  0xE0, 0x0F, 0xEF, 0xC0, 0x3F, 0x9F, 0xC0, 0x7F, 0x3F, 0xC1, 0xFE, 0x3F,
  0xC7, 0xF8, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x7F,
  0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x04, 0x00, 0x00, 0x00, 0x08, 0x03, 0xF1,
  0xFE, 0x0F, 0xDF, 0xFC, 0x3F, 0x7F, 0xF8, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xCF, 0xF8, 0xFF, 0xBF, 0x81, 0xFE, 0xFE, 0x03, 0xFB, 0xF8, 0x0F, 0xEF,
  0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xEF, 0xE0, 0x3F, 0xBF,
  0x80, 0xFE, 0xFF, 0x8F, 0xFB, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xF8, 0xFE, 0xFF, 0xC3, 0xF9, 0xFE, 0x0F, 0xE0, 0x80, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x1F, 0xE3, 0xF0, 0xFF, 0xCF, 0xC7, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFC, 0x7F, 0xDF, 0xC0, 0xFF, 0xFF,
  0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01,
  0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8,
  0x07, 0xF7, 0xF0, 0x1F, 0xDF, 0xC0, 0xFF, 0x7F, 0x87, 0xFC, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x0F, 0xFD, 0xFC, 0x1F, 0xE7, 0xF0,
  0x0C, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x17, 0xE3, 0xFF, 0x7F, 0xFB,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0x07, 0xF0, 0x3F, 0x81,
  0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F,
  0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0,
  0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x20, 0x00, 0x7F, 0xE0,
  0x0F, 0xFF, 0x81, 0xFF, 0xFC, 0x3F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0x0F,
  0xF7, 0xE0, 0x7F, 0x7E, 0x07, 0xF7, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x03,
  0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x07, 0xF7, 0xFF, 0xFF,
  0x3F, 0xFF, 0xE3, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0x60,
  0x00, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xC0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFE, 0x03, 0xFF, 0x0F, 0xFC, 0x3F,
  0xF0, 0x7F, 0xC0, 0xFF, 0x00, 0x60, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF,
  0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F,
  0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC,
  0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F,
  0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0,
  0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xE3, 0xFF, 0x7F, 0xFF, 0xFB,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xF7, 0xF0, 0xFF, 0x3F, 0x80, 0x80,
  0x00, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x3F, 0x9F, 0xC0, 0xFE,
  0x7F, 0x03, 0xF9, 0xFC, 0x0F, 0xE3, 0xF0, 0x3F, 0x0F, 0xC1, 0xFC, 0x3F,
  0x87, 0xF0, 0xFE, 0x1F, 0x81, 0xF8, 0x7E, 0x07, 0xE1, 0xF8, 0x1F, 0xCF,
  0xE0, 0x3F, 0x3F, 0x00, 0xFC, 0xFC, 0x03, 0xF3, 0xF0, 0x0F, 0xCF, 0xC0,
  0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFC, 0x00, 0xFE, 0x03, 0xE0,
  0x3F, 0xFE, 0x07, 0xE0, 0x3F, 0x7E, 0x07, 0xE0, 0x7F, 0x7E, 0x07, 0xE0,
  0x7F, 0x7E, 0x07, 0xF0, 0x7E, 0x7F, 0x0F, 0xF0, 0x7E, 0x7F, 0x0F, 0xF0,
  0x7E, 0x3F, 0x0F, 0xF0, 0x7E, 0x3F, 0x0F, 0xF8, 0xFE, 0x3F, 0x1F, 0xF8,
  0xFC, 0x3F, 0x1F, 0xF8, 0xFC, 0x3F, 0x9F, 0xF8, 0xFC, 0x1F, 0x9F, 0xFC,
  0xFC, 0x1F, 0xBF, 0x7D, 0xF8, 0x1F, 0xBE, 0x7D, 0xF8, 0x1F, 0xBE, 0x7D,
  0xF8, 0x0F, 0xBE, 0x7F, 0xF8, 0x0F, 0xFE, 0x3F, 0xF8, 0x0F, 0xFC, 0x3F,
  0xF0, 0x0F, 0xFC, 0x3F, 0xF0, 0x0F, 0xFC, 0x3F, 0xF0, 0x07, 0xFC, 0x1F,
  0xF0, 0x07, 0xF8, 0x1F, 0xF0, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x1F,
  0xE0, 0x07, 0xF8, 0x0F, 0xE0, 0x03, 0xF0, 0x0F, 0xE0, 0x03, 0xF0, 0x0F,
  0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0xFF, 0x01, 0xFD, 0xFC, 0x0F, 0xE7, 0xF8,
  0x3F, 0x8F, 0xE1, 0xFC, 0x3F, 0xC7, 0xF0, 0x7F, 0x3F, 0x80, 0xFE, 0xFE,
  0x03, 0xFB, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x80, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0,
  0x0F, 0xFF, 0xC0, 0x3F, 0xBF, 0x81, 0xFC, 0xFE, 0x07, 0xF3, 0xFC, 0x3F,
  0x87, 0xF0, 0xFE, 0x1F, 0xE7, 0xF0, 0x3F, 0x9F, 0xC0, 0xFF, 0xFF, 0x01,
  0xFC, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x3F, 0x9F, 0xC0, 0xFE,
  0x7F, 0x03, 0xF9, 0xFC, 0x0F, 0xE7, 0xF0, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F,
  0x87, 0xF0, 0xFE, 0x1F, 0x81, 0xF8, 0xFE, 0x07, 0xE3, 0xF8, 0x1F, 0xCF,
  0xE0, 0x7F, 0x3F, 0x00, 0xFC, 0xFC, 0x03, 0xF7, 0xF0, 0x0F, 0xFF, 0x80,
  0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x03, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x30, 0x07, 0x80, 0x7C, 0x07, 0xF0, 0x7F,
  0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x3F, 0x81,
  0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F,
  0x81, 0xF8, 0x0F, 0xC0, 0xFE, 0x0F, 0xE0, 0xFF, 0x07, 0xF0, 0x3F, 0x01,
  0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFE, 0x07,
  0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xFE, 0x03, 0xF8,
  0x0F, 0x80, 0x3C, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x60, 0x01, 0xE0, 0x07, 0xC0, 0x3F, 0x80, 0x7F,
  0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xFC,
  0x07, 0xF0, 0x0F, 0xC0, 0xFF, 0x07, 0xFC, 0x1F, 0xC0, 0xFE, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x03, 0xF0, 0x1F, 0xC0, 0xFE, 0x01, 0xF0, 0x07, 0x80, 0x18, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0xF0, 0x07, 0xCF, 0xFC, 0x03, 0xE7, 0xFF, 0x03, 0xF7,
  0xFF, 0xC1, 0xF3, 0xFF, 0xF1, 0xFB, 0xF1, 0xFF, 0xFD, 0xF8, 0x7F, 0xFC,
  0xF8, 0x1F, 0xFE, 0x7C, 0x07, 0xFE, 0x3E, 0x01, 0xFE, 0x00, 0x00, 0x3E,
  0x00,
};

const GFXglyph RobotoCondensed_SemiBold54pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 8, 39, 14, 3, -38 },
  { 40, 13, 14, 17, 2, -41 },
  { 63, 25, 38, 29, 2, -38 },
  { 182, 22, 51, 27, 3, -45 },
  { 323, 29, 40, 34, 3, -39 },
  { 468, 28, 40, 31, 2, -39 },
  { 608, 5, 14, 9, 2, -41 },
  { 617, 13, 55, 17, 3, -43 },
  { 707, 13, 55, 17, 1, -43 },
  { 797, 23, 23, 24, 1, -38 },
  { 864, 22, 28, 26, 2, -32 },
  { 941, 9, 16, 13, 1, -6 },
  { 959, 12, 6, 18, 3, -20 },
  { 968, 8, 8, 15, 3, -7 },
  { 976, 17, 41, 18, 0, -38 },
  { 1064, 22, 40, 27, 3, -39 },
  { 1174, 14, 38, 27, 4, -38 },
  { 1241, 23, 39, 27, 2, -39 },
  { 1354, 22, 40, 27, 2, -39 },
  { 1464, 23, 38, 27, 2, -38 },
  { 1574, 22, 39, 27, 3, -38 },
  { 1682, 22, 39, 27, 3, -38 },
  { 1790, 23, 38, 27, 2, -38 },
  { 1900, 21, 40, 27, 3, -39 },
  { 2005, 22, 39, 27, 2, -39 },
  { 2113, 8, 30, 14, 3, -29 },
  { 2143, 10, 39, 13, 1, -29 },
  { 2192, 19, 25, 24, 2, -29 },
  { 2252, 19, 17, 27, 4, -26 },
  { 2293, 20, 25, 25, 3, -29 },
  { 2356, 20, 40, 24, 2, -39 },
  { 2456, 37, 49, 41, 2, -37 },
  { 2683, 30, 38, 32, 1, -38 },
  { 2826, 24, 38, 30, 3, -38 },
  { 2940, 26, 40, 31, 3, -39 },
  { 3070, 25, 38, 31, 3, -38 },
  { 3189, 22, 38, 27, 3, -38 },
  { 3294, 21, 38, 26, 3, -38 },
  { 3394, 26, 40, 32, 3, -39 },
  { 3524, 27, 38, 33, 3, -38 },
  { 3653, 7, 38, 14, 4, -38 },
  { 3687, 22, 39, 26, 1, -38 },
  { 3795, 27, 38, 30, 3, -38 },
  { 3924, 21, 38, 26, 3, -38 },
  { 4024, 35, 38, 41, 3, -38 },
  { 4191, 27, 38, 33, 3, -38 },
  { 4320, 27, 40, 33, 3, -39 },
  { 4455, 25, 38, 31, 3, -38 },
  { 4574, 27, 46, 33, 3, -39 },
  { 4730, 26, 38, 30, 3, -38 },
  { 4854, 25, 40, 29, 2, -39 },
  { 4979, 27, 38, 29, 1, -38 },
  { 5108, 25, 39, 31, 3, -38 },
  { 5230, 29, 38, 31, 1, -38 },
  { 5368, 38, 38, 41, 1, -38 },
  { 5549, 28, 38, 30, 1, -38 },
  { 5682, 29, 38, 29, 0, -38 },
  { 5820, 25, 38, 29, 2, -38 },
  { 5939, 10, 54, 14, 3, -45 },
  { 6007, 20, 41, 20, 1, -38 },
  { 6110, 10, 54, 14, 1, -45 },
  { 6178, 18, 19, 21, 1, -38 },
  { 6221, 20, 6, 22, 1, 0 },
  { 6236, 13, 8, 18, 1, -40 },
  { 6249, 22, 31, 26, 2, -30 },
  { 6335, 22, 42, 27, 3, -41 },
  { 6451, 21, 31, 25, 2, -30 },
  { 6533, 22, 42, 27, 2, -41 },
  { 6649, 22, 31, 26, 2, -30 },
  { 6735, 16, 42, 18, 1, -42 },
  { 6819, 22, 41, 27, 2, -30 },
  { 6932, 21, 41, 26, 3, -41 },
  { 7040, 7, 40, 13, 3, -40 },
  { 7075, 11, 51, 13, -1, -40 },
  { 7146, 22, 41, 25, 3, -41 },
  { 7259, 7, 41, 13, 3, -41 },
  { 7295, 34, 30, 40, 3, -30 },
  { 7423, 21, 30, 26, 3, -30 },
  { 7502, 23, 31, 27, 2, -30 },
  { 7592, 22, 41, 27, 3, -30 },
  { 7705, 22, 41, 27, 2, -30 },
  { 7818, 13, 30, 18, 3, -30 },
  { 7867, 20, 31, 25, 2, -30 },
  { 7945, 14, 37, 16, 1, -36 },
  { 8010, 21, 30, 26, 3, -29 },
  { 8089, 22, 29, 24, 1, -29 },
  { 8169, 32, 29, 34, 1, -29 },
  { 8285, 22, 29, 24, 1, -29 },
  { 8365, 22, 40, 24, 1, -29 },
  { 8475, 20, 29, 24, 2, -29 },
  { 8548, 13, 52, 16, 2, -42 },
  { 8633, 4, 45, 14, 5, -38 },
  { 8656, 14, 52, 16, 1, -42 },
  { 8747, 25, 12, 31, 3, -22 },
};

const GFXfont RobotoCondensed_SemiBold54pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_SemiBold54pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_SemiBold54pt7bGlyphs,
  0x20, 0x7E, 63
};

#endif // _ROBOTOCONDENSED_SEMIBOLD54PT7B_H_
