#ifndef _ROBOTOCONDENSED_SEMIBOLD13PT7B_H_
#define _ROBOTOCONDENSED_SEMIBOLD13PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-SemiBold.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_SemiBold13pt7bBitmaps[] PROGMEM = {
  0x00, 0xFE, 0xA3, 0xC0, 0xFF, 0x80, 0x28, 0xA5, 0x3F, 0x53, 0xE5, 0x14,
  0xA0, 0x23, 0xB7, 0xBC, 0x38, 0x73, 0xDB, 0x88, 0xE1, 0x52, 0xA7, 0x81,
  0x05, 0x8C, 0xA9, 0x0C, 0x73, 0x4D, 0x3C, 0x6E, 0xF9, 0xB6, 0xFC, 0xFC,
  0x29, 0x69, 0x24, 0x99, 0x22, 0x89, 0x92, 0x49, 0x25, 0xA8, 0x30, 0x8F,
  0xCC, 0x71, 0x20, 0x30, 0xC3, 0x3F, 0xFC, 0xC3, 0x0C, 0x57, 0xE0, 0xF0,
  0x11, 0x22, 0x26, 0x44, 0xC8, 0x76, 0xE7, 0x39, 0xCE, 0x7B, 0x70, 0x3C,
  0x92, 0x49, 0x20, 0x39, 0xB4, 0xC3, 0x18, 0x43, 0x18, 0x7C, 0x39, 0xB4,
  0xC2, 0x38, 0x3C, 0xDB, 0x38, 0x18, 0x63, 0x8A, 0x69, 0x2F, 0xC2, 0x08,
  0xFE, 0x31, 0xED, 0x8E, 0x7B, 0x70, 0x33, 0x31, 0x6D, 0xCE, 0x7B, 0x70,
  0xFC, 0x30, 0x86, 0x18, 0x43, 0x0C, 0x60, 0x76, 0xE7, 0xA7, 0x4E, 0x7B,
  0x70, 0x76, 0xA7, 0x3D, 0xFC, 0x46, 0x60, 0xF0, 0x3C, 0x4C, 0x00, 0x92,
  0xC0, 0x09, 0xF9, 0xC3, 0x84, 0xF8, 0x3E, 0x8E, 0x33, 0xE8, 0x73, 0xF2,
  0x33, 0x10, 0x04, 0x30, 0x3C, 0x62, 0xC1, 0x9D, 0xB5, 0xA5, 0xA5, 0xAD,
  0xB6, 0x80, 0x40, 0x3C, 0x18, 0x18, 0x38, 0x2C, 0x2C, 0x64, 0x7E, 0x46,
  0xC2, 0xFB, 0x6C, 0xB6, 0xFB, 0x2C, 0xF6, 0xF8, 0x7B, 0x78, 0xE0, 0x82,
  0x08, 0xF3, 0x78, 0xF3, 0x6C, 0xF3, 0xCF, 0x3C, 0xF6, 0xF0, 0xFE, 0x31,
  0x8F, 0x63, 0x18, 0xF8, 0xFE, 0x31, 0x8F, 0x63, 0x18, 0xC0, 0x7B, 0x78,
  0xE0, 0x82, 0x7C, 0xF3, 0x78, 0xCF, 0x3C, 0xF3, 0xFF, 0x3C, 0xF3, 0xCC,
  0xFF, 0xFF, 0xC0, 0x0C, 0x30, 0xC3, 0x0C, 0x3C, 0xDE, 0x78, 0xCF, 0x6F,
  0x3C, 0xF3, 0xCD, 0xB6, 0xCC, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xF8, 0xC3,
  0xC7, 0xE7, 0xA7, 0xA7, 0xBF, 0xBB, 0x9B, 0x9B, 0xC7, 0x1E, 0x69, 0xB6,
  0x59, 0xE3, 0x8C, 0x7B, 0x7C, 0xE3, 0x8E, 0x38, 0xF7, 0x78, 0xFB, 0x7C,
  0xF3, 0xDF, 0xEC, 0x30, 0xC0, 0x7B, 0x78, 0xE3, 0x8E, 0x38, 0xF7, 0x78,
  0x30, 0x40, 0xFB, 0x6C, 0xF3, 0xDB, 0xCD, 0xB6, 0xCC, 0x39, 0xB4, 0x58,
  0x38, 0x34, 0x5B, 0x38, 0xFE, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10,
  0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xF6, 0x78, 0xC6, 0x8D, 0x9B, 0x22, 0xC5,
  0x8E, 0x1C, 0x18, 0xCC, 0x93, 0x24, 0xD9, 0xB6, 0x7F, 0x9D, 0xC3, 0x30,
  0xCC, 0x33, 0x00, 0x46, 0xD8, 0xB1, 0xC1, 0x87, 0x0B, 0x36, 0x46, 0xC6,
  0xD9, 0xB1, 0x43, 0x82, 0x04, 0x08, 0x10, 0xFC, 0x30, 0x86, 0x10, 0xC6,
  0x18, 0x7C, 0xEA, 0xAA, 0xAA, 0xC0, 0xC2, 0x18, 0xC2, 0x18, 0xC2, 0x18,
  0xC0, 0xED, 0xB6, 0xDB, 0x6D, 0xBE, 0x23, 0x94, 0xA5, 0x80, 0xF8, 0x64,
  0xF4, 0x85, 0xE9, 0x4B, 0xE0, 0x84, 0x21, 0x6D, 0xCE, 0x73, 0xDD, 0x80,
  0x39, 0xA4, 0xF0, 0x41, 0xB3, 0x80, 0x0C, 0x30, 0xDF, 0x6D, 0x3C, 0xD3,
  0x6D, 0xF0, 0x76, 0xE7, 0xF8, 0x69, 0xC0, 0x36, 0x6F, 0x66, 0x66, 0x66,
  0x7D, 0xB4, 0xF3, 0x4D, 0xB7, 0xC3, 0x4D, 0xE0, 0x84, 0x21, 0x6D, 0xCE,
  0x73, 0x9C, 0xC0, 0xA2, 0xAA, 0xA0, 0x51, 0x55, 0x55, 0xC0, 0x84, 0x21,
  0x3B, 0x73, 0x9E, 0x94, 0xC0, 0xFF, 0xC0, 0xB6, 0xDB, 0x9B, 0x9B, 0x9B,
  0x9B, 0x9B, 0xB6, 0xE7, 0x39, 0xCE, 0x60, 0x39, 0xB4, 0xF3, 0x4D, 0xB3,
  0x80, 0xF6, 0xE7, 0x39, 0xEE, 0xD0, 0x84, 0x00, 0x7D, 0xB4, 0xF3, 0x4D,
  0xB7, 0xC3, 0x0C, 0x30, 0xBE, 0x49, 0x20, 0x7A, 0x58, 0xF1, 0xA5, 0xE0,
  0x66, 0xF6, 0x66, 0x66, 0x70, 0x9C, 0xE7, 0x39, 0xEF, 0xE0, 0xC9, 0x25,
  0x9E, 0x70, 0xC3, 0x00, 0xDB, 0x5B, 0x5A, 0x5E, 0x76, 0x66, 0x26, 0x49,
  0xE3, 0x0C, 0x31, 0xEC, 0x80, 0xC9, 0x25, 0x9E, 0x70, 0xC3, 0x08, 0x61,
  0x80, 0xF3, 0x26, 0xCC, 0xF0, 0x22, 0x66, 0x66, 0xC6, 0x66, 0x62, 0xFF,
  0xE0, 0xC4, 0x66, 0x66, 0x36, 0x66, 0x4C, 0xEE, 0xA9, 0x80,
};

const GFXglyph RobotoCondensed_SemiBold13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 2, 9, 3, 1, -9 },
  { 4, 3, 3, 4, 1, -10 },
  { 6, 6, 9, 7, 1, -9 },
  { 13, 5, 11, 7, 1, -10 },
  { 20, 7, 9, 8, 1, -9 },
  { 28, 6, 9, 7, 1, -9 },
  { 35, 2, 3, 2, 0, -10 },
  { 36, 3, 13, 4, 1, -10 },
  { 41, 3, 13, 4, 0, -10 },
  { 46, 6, 6, 6, 0, -9 },
  { 51, 6, 8, 6, 0, -9 },
  { 57, 2, 4, 3, 0, -2 },
  { 58, 3, 1, 4, 1, -4 },
  { 59, 2, 2, 4, 1, -2 },
  { 60, 4, 10, 4, 0, -9 },
  { 65, 5, 9, 7, 1, -9 },
  { 71, 3, 9, 7, 1, -9 },
  { 75, 6, 9, 7, 0, -9 },
  { 82, 6, 9, 7, 0, -9 },
  { 89, 6, 9, 7, 0, -9 },
  { 96, 5, 9, 7, 1, -9 },
  { 102, 5, 9, 7, 1, -9 },
  { 108, 6, 9, 7, 0, -9 },
  { 115, 5, 9, 7, 1, -9 },
  { 121, 5, 9, 7, 1, -9 },
  { 127, 2, 7, 3, 1, -7 },
  { 129, 3, 9, 3, 0, -7 },
  { 133, 5, 6, 6, 0, -7 },
  { 137, 5, 3, 6, 1, -6 },
  { 139, 4, 6, 6, 1, -7 },
  { 142, 5, 9, 6, 0, -9 },
  { 148, 8, 12, 10, 1, -9 },
  { 160, 8, 9, 8, 0, -9 },
  { 169, 6, 9, 7, 1, -9 },
  { 176, 6, 9, 7, 1, -9 },
  { 183, 6, 9, 7, 1, -9 },
  { 190, 5, 9, 6, 1, -9 },
  { 196, 5, 9, 6, 1, -9 },
  { 202, 6, 9, 8, 1, -9 },
  { 209, 6, 9, 8, 1, -9 },
  { 216, 2, 9, 3, 1, -9 },
  { 219, 6, 9, 6, 0, -9 },
  { 226, 6, 9, 7, 1, -9 },
  { 233, 5, 9, 6, 1, -9 },
  { 239, 8, 9, 10, 1, -9 },
  { 248, 6, 9, 8, 1, -9 },
  { 255, 6, 9, 8, 1, -9 },
  { 262, 6, 9, 7, 1, -9 },
  { 269, 6, 11, 8, 1, -9 },
  { 278, 6, 9, 7, 1, -9 },
  { 285, 6, 9, 7, 0, -9 },
  { 292, 7, 9, 7, 0, -9 },
  { 300, 6, 9, 7, 1, -9 },
  { 307, 7, 9, 7, 0, -9 },
  { 315, 10, 9, 10, 0, -9 },
  { 327, 7, 9, 7, 0, -9 },
  { 335, 7, 9, 7, 0, -9 },
  { 343, 6, 9, 7, 0, -9 },
  { 350, 2, 13, 3, 1, -11 },
  { 354, 5, 10, 5, 0, -9 },
  { 361, 3, 13, 3, 0, -11 },
  { 366, 5, 5, 5, 0, -9 },
  { 370, 5, 1, 5, 0, 0 },
  { 371, 3, 2, 4, 0, -10 },
  { 372, 5, 7, 6, 1, -7 },
  { 377, 5, 10, 6, 1, -10 },
  { 384, 6, 7, 6, 0, -7 },
  { 390, 6, 10, 6, 0, -10 },
  { 398, 5, 7, 6, 1, -7 },
  { 403, 4, 10, 4, 0, -10 },
  { 408, 6, 10, 7, 0, -7 },
  { 416, 5, 10, 6, 1, -10 },
  { 423, 2, 10, 3, 1, -10 },
  { 426, 2, 13, 3, 0, -10 },
  { 430, 5, 10, 6, 1, -10 },
  { 437, 1, 10, 3, 1, -10 },
  { 439, 8, 7, 10, 1, -7 },
  { 446, 5, 7, 6, 1, -7 },
  { 451, 6, 7, 6, 0, -7 },
  { 457, 5, 10, 6, 1, -7 },
  { 464, 6, 10, 6, 0, -7 },
  { 472, 3, 7, 4, 1, -7 },
  { 475, 5, 7, 6, 0, -7 },
  { 480, 4, 9, 4, 0, -9 },
  { 485, 5, 7, 6, 1, -7 },
  { 490, 6, 7, 6, 0, -7 },
  { 496, 8, 7, 8, 0, -7 },
  { 503, 6, 7, 6, 0, -7 },
  { 509, 6, 10, 6, 0, -7 },
  { 517, 4, 7, 6, 1, -7 },
  { 521, 4, 12, 4, 0, -10 },
  { 527, 1, 11, 3, 1, -9 },
  { 529, 4, 12, 4, 0, -10 },
  { 535, 6, 3, 7, 1, -5 },
};

const GFXfont RobotoCondensed_SemiBold13pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_SemiBold13pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_SemiBold13pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _ROBOTOCONDENSED_SEMIBOLD13PT7B_H_
