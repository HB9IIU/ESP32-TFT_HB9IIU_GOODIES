#ifndef _ROBOTOCONDENSED_SEMIBOLD15PT7B_H_
#define _ROBOTOCONDENSED_SEMIBOLD15PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-SemiBold.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_SemiBold15pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0x3C, 0xB6, 0xD0, 0x2C, 0x50, 0xA7, 0xF2, 0x8D, 0x12,
  0x7E, 0x50, 0xA1, 0x40, 0x30, 0xC7, 0xBF, 0xCF, 0x0E, 0x1E, 0x18, 0x3C,
  0xFF, 0x78, 0x80, 0xE0, 0xB4, 0xB4, 0xB8, 0xE8, 0x10, 0x16, 0x2B, 0x29,
  0x49, 0x06, 0x70, 0xF3, 0x26, 0xC7, 0x0E, 0x3D, 0xEF, 0xDD, 0xF9, 0xD8,
  0xF0, 0x25, 0x2D, 0xB6, 0xDB, 0x24, 0x48, 0x44, 0x62, 0x33, 0x33, 0x33,
  0x32, 0x64, 0x40, 0x10, 0x23, 0xF9, 0x82, 0x89, 0x00, 0x30, 0xC3, 0x3F,
  0xFC, 0xC3, 0x0C, 0x6D, 0x60, 0xFC, 0xF0, 0x18, 0x84, 0x63, 0x10, 0x8C,
  0x42, 0x31, 0x80, 0x73, 0xEC, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0xE7, 0x00,
  0x1F, 0xF3, 0x33, 0x33, 0x33, 0x30, 0x7B, 0xEC, 0xC3, 0x18, 0x63, 0x18,
  0x63, 0xFF, 0xC0, 0x73, 0xEC, 0xC3, 0x38, 0xE0, 0xC3, 0x8F, 0xE7, 0x00,
  0x0C, 0x38, 0x71, 0xE3, 0xC5, 0x9B, 0x3F, 0xFE, 0x18, 0x30, 0x7F, 0xFC,
  0x30, 0xFB, 0xF0, 0xC3, 0xCF, 0xE7, 0x80, 0x39, 0xEC, 0x30, 0xFB, 0xFC,
  0xF3, 0xCF, 0xE7, 0x80, 0xFF, 0xF0, 0x86, 0x18, 0xC3, 0x0C, 0x61, 0x86,
  0x00, 0x7B, 0xEC, 0xF3, 0xF9, 0xEC, 0xF3, 0xCF, 0xE7, 0x80, 0x73, 0xEC,
  0xB3, 0xCF, 0xF7, 0xC2, 0x19, 0xE6, 0x00, 0xF0, 0x0F, 0x6C, 0x00, 0x1B,
  0x78, 0x04, 0x77, 0x30, 0x70, 0x70, 0x40, 0xFF, 0xC0, 0x0F, 0xFC, 0x87,
  0x1E, 0x37, 0xF2, 0x00, 0x39, 0xFC, 0xC3, 0x0C, 0x63, 0x0C, 0x00, 0xC3,
  0x00, 0x1E, 0x08, 0x64, 0x0B, 0x3B, 0x9A, 0x64, 0x9B, 0x26, 0xD9, 0xB6,
  0xA6, 0xEC, 0x01, 0x88, 0x3E, 0x00, 0x18, 0x0E, 0x07, 0x06, 0x83, 0x61,
  0xB0, 0x98, 0xFE, 0x7F, 0x31, 0xB0, 0xE0, 0xF9, 0xFB, 0x36, 0x6C, 0xDF,
  0xB3, 0x63, 0xC7, 0xFB, 0xE0, 0x38, 0xFB, 0x1E, 0x3C, 0x18, 0x30, 0x63,
  0xC7, 0xF9, 0xE0, 0xF9, 0xFB, 0x36, 0x3C, 0x78, 0xF1, 0xE3, 0xCD, 0xFB,
  0xE0, 0xFF, 0xFC, 0x30, 0xFB, 0xEC, 0x30, 0xC3, 0xFF, 0xC0, 0xFF, 0xFC,
  0x30, 0xFB, 0xEC, 0x30, 0xC3, 0x0C, 0x00, 0x7D, 0xFF, 0x1E, 0x0C, 0x1B,
  0xF7, 0xE3, 0xC6, 0xFC, 0xF0, 0xC7, 0x8F, 0x1E, 0x3F, 0xFF, 0xF1, 0xE3,
  0xC7, 0x8F, 0x18, 0xFF, 0xFF, 0xFC, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0xCD, 0xF3, 0x80, 0xC7, 0x9B, 0x76, 0xCF, 0x1E, 0x3E, 0x6C, 0xCD, 0x9F,
  0x18, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0xFF, 0xC0, 0xE1, 0xF0,
  0xF8, 0xFC, 0x7F, 0x2F, 0xB7, 0x5B, 0xB9, 0xDC, 0xEE, 0x73, 0x20, 0xC7,
  0xCF, 0x9F, 0xBF, 0x7B, 0xF7, 0xE7, 0xCF, 0x8F, 0x18, 0x38, 0xFB, 0x1E,
  0x3C, 0x78, 0xF1, 0xE3, 0xC6, 0xFC, 0xE0, 0xF9, 0xFB, 0x1E, 0x3C, 0x7F,
  0xBE, 0x60, 0xC1, 0x83, 0x00, 0x38, 0xFB, 0x1E, 0x3C, 0x78, 0xF1, 0xE3,
  0xC6, 0xF8, 0xF0, 0x30, 0x20, 0xF9, 0xFB, 0x3E, 0x3C, 0xDF, 0xBE, 0x6C,
  0xCD, 0x9B, 0x18, 0x7B, 0xFC, 0xF0, 0xE1, 0xE1, 0xC3, 0xCF, 0xF7, 0x80,
  0xFF, 0xFF, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0xC7,
  0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0xF9, 0xE0, 0xC3, 0x63, 0x63,
  0x66, 0x66, 0x36, 0x36, 0x3C, 0x1C, 0x1C, 0x18, 0xC6, 0x6C, 0xCD, 0xB9,
  0xB7, 0x66, 0xEC, 0xD7, 0x8A, 0xF1, 0xDE, 0x39, 0x87, 0x30, 0xC6, 0x00,
  0x63, 0x66, 0x36, 0x3C, 0x1C, 0x18, 0x3C, 0x3C, 0x36, 0x66, 0x63, 0xC3,
  0x66, 0x66, 0x24, 0x3C, 0x3C, 0x18, 0x18, 0x18, 0x18, 0x18, 0xFF, 0xF0,
  0xC6, 0x18, 0xC6, 0x18, 0xC3, 0xFF, 0xC0, 0xFF, 0x6D, 0xB6, 0xDB, 0x6F,
  0xC0, 0xC1, 0x86, 0x18, 0x20, 0xC3, 0x0C, 0x18, 0x61, 0x83, 0xFD, 0xB6,
  0xDB, 0x6D, 0xBF, 0xC0, 0x31, 0x9C, 0xB4, 0x80, 0xFF, 0xF0, 0x63, 0x73,
  0xE1, 0x9E, 0xDA, 0x6F, 0xBA, 0xC3, 0x0C, 0x30, 0xFB, 0xFC, 0xF3, 0xCF,
  0x3F, 0xFE, 0x77, 0xF3, 0x08, 0x67, 0xEE, 0x0C, 0x30, 0xC3, 0x6F, 0xFC,
  0xE3, 0x8F, 0x3F, 0xDB, 0x73, 0xEC, 0xE3, 0xFF, 0x0F, 0x9E, 0x39, 0xD8,
  0xCF, 0x31, 0x8C, 0x63, 0x18, 0xC0, 0x7F, 0xFC, 0xE3, 0x8F, 0x3F, 0xDF,
  0x0F, 0xE7, 0x80, 0xC3, 0x0C, 0x30, 0xFB, 0xEC, 0xF3, 0xCF, 0x3C, 0xF3,
  0xF3, 0xFF, 0xFC, 0x6C, 0x36, 0xDB, 0x6D, 0xBF, 0x80, 0xC3, 0x0C, 0x30,
  0xDB, 0x6F, 0x3C, 0xF3, 0x6D, 0xB3, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xF3,
  0x79, 0xBC, 0xDE, 0x6F, 0x37, 0x9B, 0xFB, 0xEC, 0xF3, 0xCF, 0x3C, 0xF3,
  0x7B, 0xEC, 0xE3, 0x8F, 0x3F, 0x9E, 0xFB, 0xFC, 0xF3, 0xCF, 0x3F, 0xFE,
  0xC3, 0x0C, 0x00, 0x6F, 0xFC, 0xE3, 0x8F, 0x3F, 0xDB, 0x0C, 0x30, 0xC0,
  0xFF, 0xCC, 0xCC, 0xCC, 0x39, 0xB6, 0x1C, 0x1D, 0x36, 0xCE, 0x66, 0xF6,
  0x66, 0x66, 0x73, 0xCF, 0x3C, 0xF3, 0xCF, 0x3F, 0xDB, 0xCD, 0xB6, 0xDA,
  0x78, 0xE3, 0x8C, 0xCD, 0xA6, 0xDF, 0x6F, 0xB7, 0x73, 0xB8, 0xCC, 0x66,
  0x6C, 0xD8, 0xE1, 0xC3, 0x87, 0x1B, 0x36, 0xCD, 0xB6, 0xDA, 0x78, 0xE3,
  0x8C, 0x31, 0xC6, 0x00, 0xFF, 0xCC, 0x66, 0x63, 0xFF, 0x13, 0x22, 0x26,
  0x6C, 0x62, 0x22, 0x23, 0x10, 0xFF, 0xFF, 0xFF, 0xC0, 0x46, 0x66, 0x66,
  0x33, 0x66, 0x66, 0x66, 0x40, 0x67, 0xFA, 0x70,
};

const GFXglyph RobotoCondensed_SemiBold15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 2, 11, 4, 1, -11 },
  { 4, 3, 4, 5, 1, -11 },
  { 6, 7, 11, 8, 1, -11 },
  { 16, 6, 14, 8, 1, -13 },
  { 27, 8, 11, 10, 1, -11 },
  { 38, 7, 11, 9, 1, -11 },
  { 48, 1, 4, 2, 1, -11 },
  { 49, 3, 15, 5, 1, -12 },
  { 55, 4, 15, 5, 0, -12 },
  { 63, 7, 6, 7, 0, -11 },
  { 69, 6, 8, 7, 1, -9 },
  { 75, 3, 4, 4, 0, -2 },
  { 77, 3, 2, 5, 1, -6 },
  { 78, 2, 2, 4, 1, -2 },
  { 79, 5, 12, 5, 0, -11 },
  { 87, 6, 11, 8, 1, -11 },
  { 96, 4, 11, 8, 1, -11 },
  { 102, 6, 11, 8, 1, -11 },
  { 111, 6, 11, 8, 1, -11 },
  { 120, 7, 11, 8, 0, -11 },
  { 130, 6, 11, 8, 1, -11 },
  { 139, 6, 11, 8, 1, -11 },
  { 148, 6, 11, 8, 1, -11 },
  { 157, 6, 11, 8, 1, -11 },
  { 166, 6, 11, 8, 1, -11 },
  { 175, 2, 8, 4, 1, -8 },
  { 177, 3, 10, 4, 0, -8 },
  { 181, 6, 7, 7, 0, -8 },
  { 187, 5, 6, 7, 1, -8 },
  { 191, 5, 7, 7, 1, -8 },
  { 196, 6, 11, 7, 0, -11 },
  { 205, 10, 13, 12, 1, -10 },
  { 222, 9, 11, 9, 0, -11 },
  { 235, 7, 11, 8, 1, -11 },
  { 245, 7, 11, 9, 1, -11 },
  { 255, 7, 11, 9, 1, -11 },
  { 265, 6, 11, 7, 1, -11 },
  { 274, 6, 11, 7, 1, -11 },
  { 283, 7, 11, 9, 1, -11 },
  { 293, 7, 11, 9, 1, -11 },
  { 303, 2, 11, 4, 1, -11 },
  { 306, 6, 11, 7, 0, -11 },
  { 315, 7, 11, 8, 1, -11 },
  { 325, 6, 11, 7, 1, -11 },
  { 334, 9, 11, 11, 1, -11 },
  { 347, 7, 11, 9, 1, -11 },
  { 357, 7, 11, 9, 1, -11 },
  { 367, 7, 11, 8, 1, -11 },
  { 377, 7, 13, 9, 1, -11 },
  { 389, 7, 11, 8, 1, -11 },
  { 399, 6, 11, 8, 1, -11 },
  { 408, 8, 11, 8, 0, -11 },
  { 419, 7, 11, 9, 1, -11 },
  { 429, 8, 11, 9, 0, -11 },
  { 440, 11, 11, 11, 0, -11 },
  { 456, 8, 11, 8, 0, -11 },
  { 467, 8, 11, 8, 0, -11 },
  { 478, 6, 11, 8, 1, -11 },
  { 487, 3, 14, 4, 1, -12 },
  { 493, 6, 12, 6, 0, -11 },
  { 502, 3, 14, 4, 0, -12 },
  { 508, 5, 5, 6, 0, -11 },
  { 512, 6, 2, 6, 0, 0 },
  { 514, 4, 2, 5, 0, -11 },
  { 515, 6, 8, 7, 1, -8 },
  { 521, 6, 12, 7, 1, -12 },
  { 530, 5, 8, 7, 1, -8 },
  { 535, 6, 12, 7, 1, -12 },
  { 544, 6, 8, 7, 1, -8 },
  { 550, 5, 12, 5, 0, -12 },
  { 558, 6, 11, 8, 1, -8 },
  { 567, 6, 12, 7, 1, -12 },
  { 576, 2, 11, 4, 1, -11 },
  { 579, 3, 14, 4, 0, -11 },
  { 585, 6, 12, 7, 1, -12 },
  { 594, 2, 12, 4, 1, -12 },
  { 597, 9, 8, 11, 1, -8 },
  { 606, 6, 8, 7, 1, -8 },
  { 612, 6, 8, 7, 1, -8 },
  { 618, 6, 11, 7, 1, -8 },
  { 627, 6, 11, 7, 1, -8 },
  { 636, 4, 8, 5, 1, -8 },
  { 640, 6, 8, 7, 0, -8 },
  { 646, 4, 10, 5, 0, -10 },
  { 651, 6, 8, 7, 1, -8 },
  { 657, 6, 8, 7, 0, -8 },
  { 663, 9, 8, 10, 0, -8 },
  { 672, 7, 8, 7, 0, -8 },
  { 679, 6, 11, 7, 0, -8 },
  { 688, 5, 8, 7, 1, -8 },
  { 693, 4, 15, 5, 0, -12 },
  { 701, 2, 13, 4, 1, -11 },
  { 705, 4, 15, 5, 0, -12 },
  { 713, 7, 3, 8, 1, -6 },
};

const GFXfont RobotoCondensed_SemiBold15pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_SemiBold15pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_SemiBold15pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _ROBOTOCONDENSED_SEMIBOLD15PT7B_H_
