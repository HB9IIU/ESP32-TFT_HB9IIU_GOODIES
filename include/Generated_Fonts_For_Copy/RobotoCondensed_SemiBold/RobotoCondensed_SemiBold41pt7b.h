#ifndef _ROBOTOCONDENSED_SEMIBOLD41PT7B_H_
#define _ROBOTOCONDENSED_SEMIBOLD41PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-SemiBold.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_SemiBold41pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x0E, 0xFF, 0xFF, 0xF7, 0x00, 0xE3, 0xF8, 0xFE, 0x3F,
  0x8F, 0xE3, 0xB8, 0xEE, 0x3B, 0x8E, 0xE3, 0xB8, 0xEE, 0x38, 0x01, 0xC7,
  0x00, 0x78, 0xE0, 0x0F, 0x1C, 0x01, 0xC7, 0x80, 0x38, 0xF0, 0x07, 0x1C,
  0x00, 0xE3, 0x80, 0x1C, 0x70, 0x07, 0x8E, 0x0F, 0xFF, 0xFD, 0xFF, 0xFF,
  0xBF, 0xFF, 0xF0, 0x71, 0xC0, 0x0E, 0x38, 0x03, 0xC7, 0x00, 0x78, 0xE0,
  0x0E, 0x3C, 0x01, 0xC7, 0x83, 0xFF, 0xFE, 0x7F, 0xFF, 0xCF, 0xFF, 0xF8,
  0x3C, 0x70, 0x07, 0x8E, 0x00, 0xE3, 0xC0, 0x1C, 0x78, 0x03, 0x8E, 0x00,
  0x71, 0xC0, 0x1E, 0x38, 0x03, 0xC7, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x3F, 0x00, 0x7F, 0xE0, 0x7F, 0xF8, 0x7F, 0xFC,
  0x7F, 0x7F, 0x3F, 0x0F, 0x9F, 0x07, 0xCF, 0x83, 0xF7, 0xC1, 0xFB, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x03, 0xFE, 0x00,
  0x7F, 0xC0, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0xF8, 0x1F,
  0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x83, 0xE7, 0xE7, 0xF3, 0xFF, 0xF8, 0xFF,
  0xF8, 0x3F, 0xF8, 0x07, 0xF0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x1F, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x3C, 0xF0,
  0x20, 0xF1, 0xE1, 0xC3, 0x87, 0x8F, 0x0E, 0x1E, 0x38, 0x38, 0x79, 0xE0,
  0xE1, 0xE7, 0x03, 0xC7, 0xBC, 0x0F, 0x3C, 0xE0, 0x1F, 0xF7, 0x80, 0x3F,
  0x9C, 0x00, 0x7C, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x78, 0x00, 0xF7,
  0xF8, 0x03, 0xBF, 0xE0, 0x1E, 0xF3, 0xC0, 0x73, 0x87, 0x03, 0xCE, 0x1C,
  0x0E, 0x38, 0x70, 0x70, 0xE1, 0xC1, 0xC3, 0x87, 0x0E, 0x0E, 0x1C, 0x18,
  0x3C, 0xF0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x01, 0xE0, 0x03, 0xE0,
  0x00, 0x7F, 0xC0, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xF7, 0xE0, 0x1F,
  0x1F, 0x00, 0xF0, 0x78, 0x07, 0x87, 0xC0, 0x3E, 0x3E, 0x01, 0xF3, 0xE0,
  0x0F, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x07, 0x87, 0xFC, 0x3C, 0x7F, 0xF1, 0xE7, 0xEF, 0xDF, 0x3E, 0x3E, 0xF9,
  0xF1, 0xFF, 0xCF, 0x87, 0xFC, 0x7C, 0x1F, 0xE3, 0xE0, 0xFE, 0x1F, 0x83,
  0xF0, 0xFE, 0x7F, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xF7, 0xE0,
  0x7E, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x80, 0x70,
  0x3C, 0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x78, 0x1E, 0x0F, 0x03, 0xC0, 0xF0,
  0x7C, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E,
  0x0F, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x7C, 0x0F, 0x03, 0xC0,
  0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x07, 0x00,
  0x80, 0x40, 0x18, 0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x78, 0x1F,
  0x03, 0xC0, 0xF0, 0x3E, 0x07, 0x81, 0xE0, 0x78, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x78, 0x1E,
  0x07, 0x83, 0xE0, 0xF0, 0x3C, 0x1F, 0x07, 0x81, 0xE0, 0xF0, 0x7C, 0x1E,
  0x0F, 0x01, 0x80, 0x40, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x07, 0x0E, 0x1B, 0xE7, 0x3D, 0xFF, 0xFF, 0xFF, 0xFF,
  0x87, 0xFC, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0xF3, 0xC0, 0xF8,
  0xF0, 0x78, 0x7C, 0x18, 0x1C, 0x04, 0x04, 0x00, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3C, 0xF3, 0xCF, 0x3C, 0xF7, 0xDF, 0x7B,
  0xEF, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x73, 0xEF, 0xFF, 0xF9, 0xC0,
  0x00, 0x78, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xC0, 0x1E, 0x00, 0x07, 0xE0, 0x07, 0xFC, 0x07, 0xFF, 0x07, 0xFF,
  0xC7, 0xF7, 0xE3, 0xE1, 0xF9, 0xF0, 0x7D, 0xF0, 0x3E, 0xF8, 0x1F, 0x7C,
  0x0F, 0xBE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F,
  0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xEF, 0x81,
  0xF7, 0xC0, 0xF9, 0xF0, 0x7C, 0xF8, 0x7E, 0x7E, 0x7E, 0x1F, 0xFF, 0x07,
  0xFF, 0x01, 0xFF, 0x00, 0x7E, 0x00, 0x00, 0x60, 0x3C, 0x3F, 0x9F, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xE0,
  0x0F, 0xFC, 0x0F, 0xFF, 0x0F, 0xFF, 0xC7, 0xE7, 0xF7, 0xE1, 0xFB, 0xE0,
  0x7D, 0xF0, 0x3E, 0xF8, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0,
  0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x01, 0xF8,
  0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x03, 0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x87, 0xFF, 0xE7, 0xF3, 0xF3, 0xF0,
  0xFD, 0xF0, 0x3E, 0xF8, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0,
  0x07, 0xE0, 0x3F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF8, 0x07, 0xFE, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFF, 0xE0, 0x7D, 0xF0,
  0x3E, 0xF8, 0x3F, 0x7F, 0x3F, 0x9F, 0xFF, 0x8F, 0xFF, 0x81, 0xFF, 0x80,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x03, 0xFF, 0x01, 0xFF,
  0xC0, 0x7B, 0xF0, 0x3E, 0xFC, 0x0F, 0x3F, 0x07, 0xCF, 0xC1, 0xE3, 0xF0,
  0xF8, 0xFC, 0x3C, 0x3F, 0x1F, 0x0F, 0xC7, 0xC3, 0xF3, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x3F, 0xFF, 0x1F, 0xFF,
  0x8F, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xF1, 0xE0, 0x00, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x7C, 0x0F, 0xFF, 0x87, 0xFF, 0xE3,
  0xFF, 0xF9, 0xF0, 0xFC, 0x10, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xFF, 0xC0, 0xFF, 0xF0, 0x7E, 0xF8, 0x3E, 0x7F,
  0x7F, 0x1F, 0xFF, 0x0F, 0xFF, 0x81, 0xFF, 0x00, 0x7F, 0x00, 0x00, 0x78,
  0x01, 0xFC, 0x01, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x3E, 0x1F, 0x7F, 0x8F,
  0xFF, 0xE7, 0xFF, 0xFB, 0xF9, 0xFD, 0xF8, 0x3F, 0xFC, 0x1F, 0xFC, 0x07,
  0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFB, 0xE0, 0x7D, 0xF0, 0x7E, 0xFC,
  0x3E, 0x3F, 0x7F, 0x1F, 0xFF, 0x07, 0xFF, 0x81, 0xFF, 0x00, 0x3F, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x0F, 0xFC, 0x0F, 0xFF,
  0x07, 0xFF, 0xC7, 0xF7, 0xE3, 0xE1, 0xF9, 0xF0, 0x7C, 0xF8, 0x3E, 0x7C,
  0x1F, 0x3E, 0x0F, 0x9F, 0x0F, 0xC7, 0xEF, 0xC3, 0xFF, 0xC0, 0xFF, 0xC0,
  0x7F, 0xF0, 0x7F, 0xFC, 0x7E, 0x3E, 0x3E, 0x0F, 0xBE, 0x07, 0xDF, 0x03,
  0xEF, 0x81, 0xFF, 0xC0, 0xFF, 0xF0, 0x7D, 0xF8, 0x3E, 0x7E, 0x7F, 0x3F,
  0xFF, 0x0F, 0xFF, 0x83, 0xFF, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x0F, 0xF8,
  0x3F, 0xFC, 0x3F, 0xFC, 0x7F, 0x7E, 0x7C, 0x3E, 0xFC, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xFC, 0x1F, 0x7E, 0x7F, 0x7F, 0xFF, 0x3F, 0xFF, 0x1F, 0xFF, 0x0F, 0x9F,
  0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFC, 0x0F, 0xFC, 0x0F, 0xF8,
  0x0F, 0xF0, 0x0F, 0xC0, 0x0F, 0x00, 0x73, 0xEF, 0xFF, 0xF9, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xCF, 0xBF, 0xFF, 0xE7, 0x00,
  0x1C, 0x7D, 0xFB, 0xF3, 0xE7, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3C, 0x79, 0xF3,
  0xCF, 0x04, 0x00, 0x00, 0x02, 0x00, 0x1C, 0x00, 0xF8, 0x07, 0xF0, 0x3F,
  0xE1, 0xFF, 0x8F, 0xFC, 0x7F, 0xE0, 0xFF, 0x01, 0xF0, 0x03, 0xF8, 0x07,
  0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0x00, 0x3E, 0x00,
  0x1C, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x80, 0x03, 0x80, 0x0F, 0x80, 0x3F, 0x80, 0xFF, 0x83, 0xFF,
  0x83, 0xFF, 0x81, 0xFF, 0x01, 0xFC, 0x01, 0xF0, 0x1F, 0xC1, 0xFF, 0x3F,
  0xFB, 0xFF, 0x8F, 0xF8, 0x3F, 0x80, 0xF8, 0x03, 0x80, 0x08, 0x00, 0x00,
  0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFE, 0x7F, 0xFE, 0xFC, 0x3E,
  0xFC, 0x3E, 0xF8, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0x07, 0xE0,
  0x07, 0xC0, 0x0F, 0x00, 0xF0, 0x00, 0x78, 0x1E, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x1C, 0x3C, 0x00, 0x01, 0xC3, 0x80, 0x7C, 0x0E, 0x78, 0x1F, 0xE0,
  0xE7, 0x83, 0xFF, 0x0E, 0x70, 0x7E, 0xF0, 0xEF, 0x07, 0x8F, 0x0F, 0xF0,
  0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0x0F, 0xF0, 0xF0, 0xF0, 0xFE, 0x1E, 0x0F,
  0x0F, 0xE1, 0xE0, 0xF0, 0xFE, 0x1E, 0x0E, 0x0E, 0xE1, 0xE0, 0xE0, 0xEE,
  0x1E, 0x0E, 0x0E, 0xE1, 0xE1, 0xE0, 0xEF, 0x1F, 0x1E, 0x1C, 0xF0, 0xFF,
  0xF3, 0xCF, 0x0F, 0xFF, 0xF8, 0x70, 0x7E, 0x7F, 0x07, 0x03, 0xC3, 0xE0,
  0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFE, 0x1E, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xEF, 0x00, 0x07, 0xDF,
  0x00, 0x1F, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x7C, 0x7C, 0x01, 0xF0, 0xF8,
  0x03, 0xE1, 0xF0, 0x07, 0xC3, 0xE0, 0x1F, 0x83, 0xE0, 0x3E, 0x07, 0xC0,
  0x7C, 0x0F, 0x80, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFE, 0x3F, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x01, 0xFB, 0xF0,
  0x03, 0xF7, 0xE0, 0x03, 0xEF, 0x80, 0x07, 0xE0, 0xFF, 0xF0, 0x3F, 0xFF,
  0x0F, 0xFF, 0xF3, 0xFF, 0xFC, 0xF8, 0xFF, 0xBE, 0x07, 0xEF, 0x80, 0xFB,
  0xE0, 0x3E, 0xF8, 0x0F, 0xBE, 0x03, 0xEF, 0x81, 0xFB, 0xE0, 0x7C, 0xFF,
  0xFF, 0x3F, 0xFF, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0xF8, 0x1F, 0xBE, 0x03,
  0xEF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF,
  0xE0, 0x3E, 0xF8, 0x7F, 0xBF, 0xFF, 0xEF, 0xFF, 0xF3, 0xFF, 0xF8, 0xFF,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC,
  0x3F, 0xDF, 0xE7, 0xE0, 0x7E, 0x7C, 0x03, 0xE7, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0x7C, 0x03, 0xE7,
  0xE0, 0x7E, 0x3F, 0xFF, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0xFF, 0xF0,
  0x01, 0xFC, 0x00, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0xC3, 0xFF, 0xF8,
  0xF9, 0xFF, 0x3E, 0x07, 0xEF, 0x80, 0xFB, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFB, 0xE0, 0x7E, 0xF9, 0xFF, 0x3F,
  0xFF, 0x8F, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xFC, 0xFF,
  0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0xFF, 0xBF, 0xFF, 0x7F,
  0xFE, 0xFF, 0xFD, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC,
  0x3F, 0xDF, 0xE7, 0xE0, 0x7E, 0x7C, 0x03, 0xE7, 0xC0, 0x3F, 0xFC, 0x01,
  0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x3F, 0xFF, 0x83, 0xFF, 0xF8, 0x3F, 0xFF, 0x83, 0xFF, 0xF8,
  0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xF7, 0xC0, 0x1F, 0x7E, 0x01, 0xF7,
  0xE0, 0x3F, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xE0, 0x7F, 0xF8,
  0x01, 0xFE, 0x00, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80,
  0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8,
  0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x3F,
  0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03,
  0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80,
  0x3F, 0xF8, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFB, 0xF0, 0x7D,
  0xF8, 0x7E, 0x7F, 0x7F, 0x3F, 0xFF, 0x0F, 0xFF, 0x03, 0xFF, 0x00, 0x7E,
  0x00, 0xF8, 0x07, 0xEF, 0x80, 0xFC, 0xF8, 0x1F, 0xCF, 0x81, 0xF8, 0xF8,
  0x3F, 0x0F, 0x83, 0xF0, 0xF8, 0x7E, 0x0F, 0x8F, 0xC0, 0xF8, 0xFC, 0x0F,
  0x9F, 0x80, 0xFB, 0xF0, 0x0F, 0xBF, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00,
  0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFC, 0xFC,
  0x0F, 0xC7, 0xE0, 0xF8, 0x7E, 0x0F, 0x83, 0xF0, 0xF8, 0x3F, 0x0F, 0x81,
  0xF8, 0xF8, 0x1F, 0x8F, 0x80, 0xFC, 0xF8, 0x0F, 0xCF, 0x80, 0x7E, 0xF8,
  0x07, 0xE0, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFC, 0x00, 0x1F,
  0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x07,
  0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xC0, 0x7B, 0xFD, 0xE0, 0x3D, 0xFE, 0xF8, 0x3E, 0xFF, 0xFC,
  0x1E, 0x7F, 0xDE, 0x0F, 0x7F, 0xEF, 0x8F, 0xBF, 0xF7, 0xC7, 0xDF, 0xF9,
  0xE3, 0xCF, 0xFC, 0xFB, 0xE7, 0xFE, 0x7D, 0xF3, 0xFF, 0x1E, 0xF1, 0xFF,
  0x8F, 0x78, 0xFF, 0xC7, 0xFC, 0x7F, 0xE3, 0xFC, 0x3F, 0xF0, 0xFE, 0x1F,
  0xF8, 0x7F, 0x0F, 0xFC, 0x3F, 0x87, 0xFE, 0x0F, 0x83, 0xFF, 0x07, 0xC1,
  0xFF, 0x83, 0xE0, 0xF8, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F,
  0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3F, 0xFB, 0xE3,
  0xFF, 0xBF, 0x3F, 0xF9, 0xF3, 0xFF, 0x8F, 0xBF, 0xF8, 0xFB, 0xFF, 0x87,
  0xFF, 0xF8, 0x7F, 0xFF, 0x83, 0xFF, 0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xF8,
  0x1F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xF8, 0x07, 0xFF,
  0x80, 0x3F, 0xF8, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x07, 0xFF,
  0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFE, 0x3F, 0x03, 0xF1, 0xF8, 0x0F, 0xCF,
  0x80, 0x3E, 0xFC, 0x01, 0xF7, 0xE0, 0x0F, 0xBE, 0x00, 0x7F, 0xF0, 0x03,
  0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8,
  0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F,
  0x3E, 0x00, 0xF9, 0xF0, 0x0F, 0xCF, 0xC0, 0xFC, 0x3F, 0xFF, 0xE1, 0xFF,
  0xFE, 0x07, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xF8,
  0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0x87, 0xF9, 0xF0, 0x1F,
  0xBE, 0x01, 0xF7, 0xC0, 0x3E, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F,
  0xFC, 0x03, 0xEF, 0x80, 0x7D, 0xF0, 0x1F, 0xBE, 0x1F, 0xF7, 0xFF, 0xFC,
  0xFF, 0xFF, 0x1F, 0xFF, 0xC3, 0xFF, 0xE0, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xF8,
  0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xFF, 0xFE, 0x3F, 0x03, 0xF1, 0xF0,
  0x0F, 0xDF, 0x80, 0x3E, 0xFC, 0x01, 0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00,
  0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xEF,
  0xC0, 0x1F, 0x3E, 0x00, 0xF9, 0xF0, 0x0F, 0xCF, 0xC0, 0xFC, 0x3F, 0xFF,
  0xE1, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0xE0, 0x00, 0x02,
  0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0xFF, 0x8F, 0x87,
  0xF9, 0xF0, 0x3F, 0x3E, 0x03, 0xF7, 0xC0, 0x7E, 0xF8, 0x0F, 0xDF, 0x01,
  0xFB, 0xE0, 0x3F, 0x7C, 0x07, 0xCF, 0x81, 0xF9, 0xF0, 0xFF, 0x3F, 0xFF,
  0xC7, 0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xE1, 0xF0, 0x7C, 0x3F,
  0x0F, 0x87, 0xE1, 0xF0, 0x7E, 0x3E, 0x0F, 0xC7, 0xC0, 0xF8, 0xF8, 0x1F,
  0x9F, 0x01, 0xF3, 0xE0, 0x3F, 0x7C, 0x07, 0xEF, 0x80, 0x7E, 0x03, 0xF0,
  0x07, 0xFF, 0x03, 0xFF, 0xF1, 0xFF, 0xFC, 0x7F, 0xBF, 0xBF, 0x03, 0xFF,
  0xC0, 0xFF, 0xF0, 0x1F, 0xF8, 0x07, 0xFF, 0x00, 0x07, 0xE0, 0x01, 0xFE,
  0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x7F,
  0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xF0, 0x3F, 0x7F, 0xBF, 0xDF, 0xFF, 0xE3, 0xFF, 0xF0, 0x7F,
  0xF8, 0x03, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F,
  0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F,
  0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F,
  0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F,
  0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x01, 0xFB,
  0xF0, 0x3F, 0x7F, 0xFF, 0xC7, 0xFF, 0xF8, 0x7F, 0xFE, 0x07, 0xFF, 0x80,
  0x3F, 0x80, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0x9F, 0x00,
  0x7E, 0x7C, 0x01, 0xF9, 0xF8, 0x07, 0xC7, 0xE0, 0x1F, 0x0F, 0x80, 0xFC,
  0x3E, 0x03, 0xF0, 0xFC, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC1, 0xF8, 0x1F,
  0x07, 0xC0, 0x3E, 0x1F, 0x00, 0xF8, 0x7C, 0x03, 0xE3, 0xE0, 0x0F, 0x8F,
  0x80, 0x1F, 0x3E, 0x00, 0x7C, 0xF8, 0x01, 0xF7, 0xC0, 0x03, 0xDF, 0x00,
  0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0xF8, 0x0F,
  0x80, 0xFF, 0xE0, 0x7C, 0x0F, 0xFF, 0x03, 0xE0, 0x7E, 0xF8, 0x1F, 0x03,
  0xE7, 0xC1, 0xFC, 0x1F, 0x3E, 0x0F, 0xE0, 0xF9, 0xF0, 0x7F, 0x07, 0xCF,
  0xC3, 0xF8, 0x7E, 0x3E, 0x1F, 0xC3, 0xE1, 0xF1, 0xFF, 0x1F, 0x0F, 0x8F,
  0x78, 0xF8, 0x7C, 0x7B, 0xC7, 0xC3, 0xE3, 0xDE, 0x3E, 0x0F, 0x1E, 0xF3,
  0xE0, 0x7D, 0xF7, 0xDF, 0x03, 0xEF, 0x1E, 0xF8, 0x1F, 0x78, 0xF7, 0xC0,
  0xFB, 0xC7, 0xBE, 0x07, 0xDE, 0x3D, 0xF0, 0x1F, 0xF1, 0xFF, 0x00, 0xFF,
  0x07, 0xF8, 0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0xC1, 0xFE, 0x01, 0xFE, 0x0F,
  0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x01, 0xF8, 0x01, 0xF8, 0x0F, 0xC0,
  0x0F, 0xC0, 0x7E, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0xFC, 0x01, 0xFB, 0xF0,
  0x1F, 0x9F, 0x80, 0xFC, 0x7E, 0x0F, 0xC3, 0xF0, 0x7E, 0x0F, 0xC3, 0xE0,
  0x7E, 0x3F, 0x01, 0xF1, 0xF0, 0x0F, 0xDF, 0x80, 0x3E, 0xF8, 0x01, 0xFF,
  0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xBE,
  0x00, 0xFD, 0xF8, 0x07, 0xC7, 0xC0, 0x7E, 0x3F, 0x03, 0xE1, 0xF8, 0x3F,
  0x07, 0xE1, 0xF0, 0x3F, 0x1F, 0x80, 0xFC, 0xFC, 0x07, 0xEF, 0xC0, 0x1F,
  0x80, 0x7C, 0x00, 0xF9, 0xF8, 0x07, 0xE7, 0xE0, 0x1F, 0x8F, 0xC0, 0x7C,
  0x3F, 0x03, 0xF0, 0x7C, 0x0F, 0x81, 0xF8, 0x7E, 0x03, 0xE1, 0xF0, 0x0F,
  0x87, 0xC0, 0x3F, 0x3F, 0x00, 0x7C, 0xF8, 0x01, 0xF3, 0xE0, 0x03, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01,
  0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0,
  0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03,
  0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x07, 0xE0,
  0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0x7C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0,
  0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9,
  0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xFF, 0xFF, 0xFF, 0xFE,
  0x07, 0x80, 0x1E, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0x81, 0xFE,
  0x07, 0x38, 0x3C, 0xF0, 0xF3, 0xC3, 0xCF, 0x1E, 0x1E, 0x78, 0x79, 0xE1,
  0xEF, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7C,
  0x1F, 0x83, 0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0x07, 0xE0, 0x1F, 0xF8, 0x3F,
  0xFC, 0x7F, 0xFC, 0xFC, 0x7E, 0xF8, 0x3E, 0xF8, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x0F, 0xFE, 0x3F, 0xFE, 0x7F, 0xFE, 0xFE, 0x3E, 0xF8, 0x3E, 0xF8,
  0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xFC, 0x7E, 0xFF, 0xFE, 0x7F, 0xFE, 0x3F,
  0xFF, 0x1F, 0x1F, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0xF8,
  0x3E, 0xFF, 0x1F, 0xFF, 0xCF, 0xFF, 0xF7, 0xFB, 0xFB, 0xF0, 0x7D, 0xF0,
  0x3F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x1F, 0xFE, 0x0F, 0xBF, 0x9F,
  0xDF, 0xFF, 0xEF, 0xFF, 0xE7, 0xDF, 0xE3, 0xE7, 0xC0, 0x07, 0xE0, 0x1F,
  0xF8, 0x3F, 0xFC, 0x7F, 0xFE, 0xFE, 0x7E, 0xF8, 0x3E, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3E, 0xFE, 0x7E, 0x7F, 0xFC, 0x3F,
  0xFC, 0x1F, 0xF8, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x83, 0xE7, 0xC7, 0xFB, 0xE7, 0xFF, 0xF3, 0xFF, 0xFB, 0xF9, 0xFD, 0xF8,
  0x7E, 0xF8, 0x1F, 0x7C, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF,
  0xC0, 0xFF, 0xE0, 0x7D, 0xF0, 0x3E, 0xF8, 0x1F, 0x7C, 0x0F, 0xBF, 0x0F,
  0xDF, 0xCF, 0xE7, 0xFF, 0xF3, 0xFF, 0xF8, 0xFF, 0x7C, 0x1F, 0x3E, 0x07,
  0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFE, 0x7E, 0x7E, 0xFC, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x04, 0x7F, 0x1E, 0x7F,
  0xFF, 0x3F, 0xFE, 0x1F, 0xFC, 0x07, 0xF0, 0x01, 0xF0, 0x7F, 0x0F, 0xF1,
  0xFF, 0x1F, 0xC1, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x0F, 0xFE, 0xFF, 0xEF,
  0xFE, 0xFF, 0xE1, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x00, 0x0F, 0x8F, 0x3F, 0xEF, 0x7F, 0xFF,
  0x7F, 0xFF, 0xFF, 0x7F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xFC, 0x1F, 0xFF, 0x7F, 0x7F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFF,
  0x0F, 0x9F, 0x00, 0x1F, 0x00, 0x1F, 0x20, 0x3F, 0x3C, 0x7F, 0x7F, 0xFE,
  0x7F, 0xFC, 0x3F, 0xF8, 0x0F, 0xE0, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0xF0, 0xFB, 0xFC, 0xFF, 0xFE, 0xFF, 0xFE, 0xFE, 0x7F, 0xFC, 0x3F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x11, 0xEF, 0xFF, 0xFD,
  0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x04, 0x07, 0x87, 0xE3,
  0xF1, 0xF0, 0x78, 0x00, 0x00, 0x00, 0x0F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC,
  0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F,
  0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xCF, 0xDF,
  0xEF, 0xF7, 0xF3, 0xE0, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x1F, 0xBE, 0x0F, 0xDF, 0x0F, 0xCF, 0x8F, 0xC7, 0xC7, 0xC3, 0xE7, 0xE1,
  0xF7, 0xE0, 0xFB, 0xE0, 0x7F, 0xF0, 0x3F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFF,
  0x07, 0xFF, 0x83, 0xFF, 0xE1, 0xF9, 0xF0, 0xF8, 0xFC, 0x7C, 0x3E, 0x3E,
  0x1F, 0x9F, 0x07, 0xCF, 0x83, 0xF7, 0xC0, 0xFB, 0xE0, 0x7E, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0xF8,
  0x3E, 0x3E, 0xFF, 0x3F, 0xCF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFE,
  0x7F, 0xDF, 0xFF, 0x0F, 0xC1, 0xFF, 0x81, 0xF0, 0x7F, 0xE0, 0x7C, 0x1F,
  0xF8, 0x1F, 0x07, 0xFE, 0x07, 0xC1, 0xFF, 0x81, 0xF0, 0x7F, 0xE0, 0x7C,
  0x1F, 0xF8, 0x1F, 0x07, 0xFE, 0x07, 0xC1, 0xFF, 0x81, 0xF0, 0x7F, 0xE0,
  0x7C, 0x1F, 0xF8, 0x1F, 0x07, 0xFE, 0x07, 0xC1, 0xFF, 0x81, 0xF0, 0x7F,
  0xE0, 0x7C, 0x1F, 0xF8, 0x1F, 0x07, 0xFE, 0x07, 0xC1, 0xF0, 0xF8, 0xF8,
  0xFB, 0xFC, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0x7F, 0xFC, 0x3F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x07, 0xE0, 0x0F, 0xFC, 0x0F, 0xFF,
  0x0F, 0xFF, 0xC7, 0xE7, 0xF7, 0xE0, 0xFB, 0xE0, 0x7D, 0xF0, 0x3F, 0xF8,
  0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F,
  0xE0, 0x7F, 0xF0, 0x3E, 0xFC, 0x1F, 0x3F, 0x3F, 0x9F, 0xFF, 0x87, 0xFF,
  0x81, 0xFF, 0x80, 0x3F, 0x00, 0xF9, 0xF0, 0x7D, 0xFE, 0x3F, 0xFF, 0x9F,
  0xFF, 0xEF, 0xE7, 0xF7, 0xE0, 0xFB, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x0F,
  0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0,
  0x7F, 0xF0, 0x3E, 0xFC, 0x1F, 0x7F, 0x3F, 0xBF, 0xFF, 0xDF, 0xFF, 0xCF,
  0xBF, 0xC7, 0xCF, 0x83, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x00, 0x07, 0xCF, 0x8F,
  0xF7, 0xCF, 0xFF, 0xE7, 0xFF, 0xF7, 0xF3, 0xFB, 0xF0, 0x7D, 0xF0, 0x3E,
  0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0,
  0xFB, 0xE0, 0x7D, 0xF0, 0x3E, 0xF8, 0x1F, 0x7E, 0x0F, 0xBF, 0x9F, 0xCF,
  0xFF, 0xE7, 0xFF, 0xF1, 0xFE, 0xF8, 0x3E, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0xF9, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFD, 0xFC, 0x3F, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x00, 0x07, 0xF0, 0x1F, 0xF8,
  0x3F, 0xFE, 0x3F, 0xFE, 0x7E, 0x3F, 0x7C, 0x1F, 0x7C, 0x1F, 0x7E, 0x00,
  0x7F, 0x00, 0x3F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0xF8, 0x1F, 0x7C, 0x1F, 0x7E, 0x3F, 0x7F, 0xFE, 0x3F, 0xFE,
  0x1F, 0xFC, 0x07, 0xF0, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF1, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xF0,
  0x7F, 0x0F, 0xE0, 0xFC, 0x0F, 0x80, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xFC, 0x3F, 0x7E, 0x7F, 0x7F, 0xFF, 0x7F, 0xFF, 0x3F, 0xDF,
  0x0F, 0x9F, 0xF8, 0x1F, 0x7C, 0x0F, 0xBF, 0x07, 0xCF, 0x87, 0xE7, 0xC3,
  0xE3, 0xE1, 0xF1, 0xF0, 0xF8, 0x7C, 0x78, 0x3E, 0x7C, 0x1F, 0x3E, 0x07,
  0x9F, 0x03, 0xCF, 0x01, 0xF7, 0x80, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F,
  0x00, 0xF8, 0x3C, 0x1F, 0xF8, 0x3C, 0x1F, 0xF8, 0x3C, 0x1F, 0x78, 0x7E,
  0x1F, 0x7C, 0x7E, 0x1E, 0x7C, 0x7E, 0x3E, 0x7C, 0x7E, 0x3E, 0x7C, 0xFF,
  0x3E, 0x3C, 0xFF, 0x3E, 0x3C, 0xFF, 0x3C, 0x3E, 0xF7, 0x3C, 0x3F, 0xE7,
  0xFC, 0x3F, 0xE7, 0xFC, 0x1F, 0xE7, 0xF8, 0x1F, 0xE3, 0xF8, 0x1F, 0xC3,
  0xF8, 0x1F, 0xC3, 0xF8, 0x0F, 0xC3, 0xF8, 0x0F, 0xC1, 0xF0, 0x0F, 0x81,
  0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0xFC, 0x1F, 0x3E, 0x1F, 0x9F,
  0x8F, 0x87, 0xC7, 0xC3, 0xF7, 0xC0, 0xFB, 0xE0, 0x7F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x7F,
  0x80, 0x3F, 0xE0, 0x3F, 0xF0, 0x1F, 0x7C, 0x1F, 0x3E, 0x1F, 0x8F, 0x8F,
  0x87, 0xCF, 0xC1, 0xF7, 0xE0, 0xFC, 0x7C, 0x0F, 0x9F, 0x03, 0xE7, 0xE0,
  0xF9, 0xF8, 0x7E, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0x7C, 0xF8,
  0x1F, 0x3E, 0x07, 0xCF, 0x81, 0xF3, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03,
  0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xC0, 0x03, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F,
  0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xC0,
  0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E,
  0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x80, 0xF0, 0x7C,
  0x3E, 0x0F, 0x83, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0x78, 0x3E, 0x3F, 0x8F, 0xC3, 0xE0, 0xFC, 0x0F, 0x81,
  0xE0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x03, 0xC0, 0xF8, 0x1F, 0x07, 0xC0, 0xF0, 0x08, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x40, 0x3C, 0x0F, 0x81, 0xF0, 0x3C, 0x0F, 0x83, 0xE0, 0xF8,
  0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x81, 0xE0, 0x7C, 0x1F, 0x03,
  0xF0, 0x7C, 0x1F, 0x0F, 0xC7, 0xC1, 0xF0, 0x78, 0x1E, 0x0F, 0x83, 0xE0,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xC1, 0xF0, 0xF8,
  0x1C, 0x04, 0x00, 0x0F, 0x00, 0x07, 0xF0, 0x3C, 0xFF, 0x07, 0xBF, 0xF0,
  0xF7, 0xFF, 0xFF, 0xF1, 0xFF, 0xBC, 0x1F, 0xF7, 0x81, 0xFC, 0x00, 0x1E,
  0x00,
};

const GFXglyph RobotoCondensed_SemiBold41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 5, 29, 11, 3, -29 },
  { 20, 10, 11, 13, 2, -31 },
  { 34, 19, 29, 22, 2, -29 },
  { 103, 17, 37, 21, 2, -33 },
  { 182, 22, 29, 26, 2, -29 },
  { 262, 21, 29, 23, 2, -29 },
  { 339, 4, 11, 7, 1, -31 },
  { 345, 10, 41, 13, 2, -32 },
  { 397, 10, 41, 13, 1, -32 },
  { 449, 17, 18, 18, 1, -29 },
  { 488, 17, 21, 20, 1, -24 },
  { 533, 6, 12, 10, 1, -5 },
  { 542, 9, 4, 14, 2, -14 },
  { 547, 6, 6, 12, 3, -6 },
  { 552, 13, 32, 14, 0, -29 },
  { 604, 17, 29, 21, 2, -29 },
  { 666, 11, 29, 21, 3, -29 },
  { 706, 17, 29, 21, 2, -29 },
  { 768, 17, 29, 21, 1, -29 },
  { 830, 18, 29, 21, 1, -29 },
  { 896, 17, 29, 21, 2, -29 },
  { 958, 17, 29, 21, 2, -29 },
  { 1020, 18, 29, 21, 1, -29 },
  { 1086, 17, 29, 21, 2, -29 },
  { 1148, 16, 29, 21, 2, -29 },
  { 1206, 6, 23, 11, 3, -23 },
  { 1224, 7, 30, 10, 1, -23 },
  { 1251, 15, 19, 18, 1, -22 },
  { 1287, 15, 12, 20, 3, -19 },
  { 1310, 14, 19, 19, 3, -22 },
  { 1344, 16, 29, 18, 1, -29 },
  { 1402, 28, 37, 31, 2, -28 },
  { 1532, 23, 29, 24, 1, -29 },
  { 1616, 18, 29, 23, 3, -29 },
  { 1682, 20, 29, 23, 2, -29 },
  { 1755, 18, 29, 23, 3, -29 },
  { 1821, 16, 29, 20, 3, -29 },
  { 1879, 15, 29, 20, 3, -29 },
  { 1934, 20, 29, 24, 2, -29 },
  { 2007, 20, 29, 25, 3, -29 },
  { 2080, 5, 29, 11, 3, -29 },
  { 2099, 17, 29, 20, 1, -29 },
  { 2161, 20, 29, 23, 3, -29 },
  { 2234, 15, 29, 20, 3, -29 },
  { 2289, 25, 29, 31, 3, -29 },
  { 2380, 20, 29, 25, 3, -29 },
  { 2453, 21, 29, 25, 2, -29 },
  { 2530, 19, 29, 23, 3, -29 },
  { 2599, 21, 34, 25, 2, -29 },
  { 2689, 19, 29, 22, 3, -29 },
  { 2758, 18, 29, 22, 2, -29 },
  { 2824, 20, 29, 22, 1, -29 },
  { 2897, 19, 29, 23, 2, -29 },
  { 2966, 22, 29, 24, 1, -29 },
  { 3046, 29, 29, 31, 1, -29 },
  { 3152, 21, 29, 23, 1, -29 },
  { 3229, 22, 29, 22, 0, -29 },
  { 3309, 18, 29, 22, 2, -29 },
  { 3375, 8, 41, 11, 2, -34 },
  { 3416, 16, 32, 16, 0, -29 },
  { 3480, 7, 41, 11, 1, -34 },
  { 3516, 14, 15, 16, 1, -29 },
  { 3543, 16, 4, 16, 0, 0 },
  { 3551, 10, 6, 13, 1, -31 },
  { 3559, 16, 22, 19, 2, -22 },
  { 3603, 17, 31, 20, 2, -31 },
  { 3669, 16, 22, 19, 2, -22 },
  { 3713, 17, 31, 20, 1, -31 },
  { 3779, 16, 22, 20, 2, -22 },
  { 3823, 12, 31, 13, 1, -31 },
  { 3870, 16, 30, 21, 2, -22 },
  { 3930, 16, 31, 20, 2, -31 },
  { 3992, 6, 31, 10, 2, -31 },
  { 4016, 9, 39, 10, -1, -31 },
  { 4060, 17, 31, 19, 2, -31 },
  { 4126, 6, 31, 10, 2, -31 },
  { 4150, 26, 22, 31, 2, -22 },
  { 4222, 16, 22, 20, 2, -22 },
  { 4266, 17, 22, 20, 2, -22 },
  { 4313, 17, 30, 20, 2, -22 },
  { 4377, 17, 30, 20, 1, -22 },
  { 4441, 11, 22, 13, 2, -22 },
  { 4472, 16, 22, 19, 1, -22 },
  { 4516, 11, 27, 12, 0, -27 },
  { 4554, 16, 22, 20, 2, -22 },
  { 4598, 17, 22, 18, 1, -22 },
  { 4645, 24, 22, 26, 1, -22 },
  { 4711, 17, 22, 18, 1, -22 },
  { 4758, 18, 30, 18, 0, -22 },
  { 4826, 15, 22, 18, 2, -22 },
  { 4868, 10, 39, 12, 1, -32 },
  { 4917, 4, 34, 10, 3, -29 },
  { 4934, 10, 39, 12, 1, -32 },
  { 4983, 19, 9, 23, 2, -17 },
};

const GFXfont RobotoCondensed_SemiBold41pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_SemiBold41pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_SemiBold41pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _ROBOTOCONDENSED_SEMIBOLD41PT7B_H_
