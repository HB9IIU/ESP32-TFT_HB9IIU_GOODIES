#ifndef _ROBOTOCONDENSED_SEMIBOLD18PT7B_H_
#define _ROBOTOCONDENSED_SEMIBOLD18PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-SemiBold.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_SemiBold18pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x6D, 0xB6, 0x03, 0x7C, 0xBB, 0xBB, 0xB0, 0x12, 0x16, 0x36,
  0x36, 0xFF, 0x24, 0x24, 0x2C, 0xFE, 0x6C, 0x68, 0x68, 0x48, 0x10, 0x20,
  0xF3, 0xFE, 0x7C, 0xF8, 0x38, 0x3C, 0x1C, 0x1E, 0x3C, 0x7F, 0xCF, 0x08,
  0x10, 0x70, 0x34, 0x09, 0xB2, 0x68, 0xD6, 0x1D, 0x00, 0xC0, 0x2E, 0x16,
  0x8D, 0x32, 0x4C, 0x9A, 0x03, 0x80, 0x38, 0x3E, 0x1B, 0x0D, 0x86, 0xC3,
  0xC1, 0xC1, 0xF6, 0xDF, 0x67, 0xB1, 0x9F, 0xE7, 0xB8, 0xF8, 0x13, 0x26,
  0x6C, 0xCC, 0xCC, 0xCC, 0xC6, 0x62, 0x31, 0x43, 0x18, 0x63, 0x18, 0x63,
  0x18, 0xC6, 0x33, 0x18, 0xCC, 0x62, 0x00, 0x18, 0x18, 0x59, 0xFF, 0x18,
  0x3C, 0x66, 0x24, 0x30, 0x60, 0xC1, 0x8F, 0xFF, 0xCC, 0x18, 0x30, 0x60,
  0x6D, 0xB4, 0xFF, 0x5F, 0x80, 0x0C, 0x21, 0x86, 0x10, 0xC3, 0x0C, 0x21,
  0x86, 0x10, 0xC3, 0x00, 0x38, 0xFB, 0xBE, 0x3C, 0x78, 0xF1, 0xE3, 0xC7,
  0x8F, 0xBB, 0xE3, 0x80, 0x0B, 0xFF, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31,
  0x80, 0x3D, 0xFB, 0x3E, 0x30, 0x61, 0xC3, 0x0C, 0x38, 0xE1, 0x87, 0xFF,
  0xE0, 0x79, 0xFB, 0x38, 0x30, 0xE7, 0x8F, 0x07, 0x07, 0x8F, 0x3F, 0xE7,
  0x80, 0x0C, 0x38, 0x71, 0xE2, 0xCD, 0x9B, 0x66, 0xFF, 0xFC, 0x30, 0x60,
  0xC0, 0x7E, 0xFD, 0x87, 0x0F, 0xDF, 0xC1, 0x83, 0x07, 0x8F, 0x9B, 0xE3,
  0x80, 0x1C, 0x79, 0xC3, 0x0D, 0xDF, 0xF9, 0xE3, 0xC7, 0x8F, 0x9B, 0xF3,
  0xC0, 0xFF, 0xFC, 0x18, 0x70, 0xC1, 0x86, 0x0C, 0x38, 0x60, 0xC3, 0x86,
  0x00, 0x38, 0xFB, 0xBE, 0x3E, 0xEF, 0x9F, 0x77, 0xC7, 0x8F, 0x1B, 0xF3,
  0xC0, 0x38, 0xFB, 0xBE, 0x3C, 0x78, 0xF1, 0xFF, 0x76, 0x1C, 0x33, 0xC7,
  0x00, 0x5F, 0x80, 0x02, 0xFC, 0x27, 0x60, 0x00, 0x00, 0x66, 0x66, 0x40,
  0x04, 0x77, 0xFC, 0xC3, 0xC7, 0xC7, 0x04, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xC0, 0x81, 0xC3, 0xE1, 0xF0, 0xE7, 0xFE, 0x70, 0x80, 0x7B, 0xFC, 0xC3,
  0x0C, 0x73, 0x8C, 0x30, 0x00, 0x0C, 0x30, 0x0F, 0x83, 0x9C, 0x20, 0x66,
  0x02, 0xC7, 0x3C, 0xD9, 0xD9, 0x99, 0x91, 0x99, 0x19, 0x93, 0x9F, 0xAC,
  0xDC, 0xC0, 0x06, 0x00, 0x39, 0x01, 0xF0, 0x0E, 0x03, 0x81, 0xE0, 0x78,
  0x1B, 0x06, 0xC3, 0x30, 0xCE, 0x3F, 0x9F, 0xE6, 0x1D, 0x83, 0xE0, 0xC0,
  0xFC, 0xFE, 0xC7, 0xC3, 0xC7, 0xFE, 0xFE, 0xC7, 0xC3, 0xC3, 0xC7, 0xFF,
  0xFC, 0x3E, 0x3F, 0xB8, 0xD8, 0x7C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x61,
  0xF8, 0xCF, 0xE3, 0xE0, 0xFC, 0xFE, 0xC7, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC7, 0xFE, 0xFC, 0xFF, 0xFF, 0x06, 0x0C, 0x1F, 0xFF, 0xE0,
  0xC1, 0x83, 0x07, 0xFF, 0xE0, 0xFF, 0xFF, 0x06, 0x0C, 0x18, 0x3F, 0xFF,
  0xC1, 0x83, 0x06, 0x0C, 0x00, 0x3E, 0x3F, 0xB8, 0xD8, 0x7C, 0x06, 0x03,
  0x3F, 0x9F, 0xC3, 0xE1, 0xF8, 0xEF, 0xE3, 0xE0, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1F, 0xFF, 0xFF, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x18, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0xE7, 0x66, 0x7E, 0x3C, 0xC3, 0xE3, 0xB3, 0x99, 0xCD, 0xC6, 0xC3,
  0xE1, 0xF8, 0xEE, 0x67, 0x31, 0xD8, 0xEC, 0x38, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x07, 0xFF, 0xE0, 0xE0, 0xFE, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF1, 0xFD, 0x9F, 0xD9, 0xFD, 0xB7, 0xCF, 0x7C, 0xF7, 0xCE,
  0x7C, 0xE7, 0xC6, 0x70, 0xE1, 0xF0, 0xFC, 0x7E, 0x3F, 0x9E, 0xCF, 0x77,
  0x9B, 0xCF, 0xE3, 0xF1, 0xF8, 0x7C, 0x38, 0x3E, 0x3F, 0xB8, 0xD8, 0x7C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE1, 0xF8, 0xCF, 0xE3, 0xE0, 0xFE, 0x7F,
  0xB0, 0xD8, 0x6C, 0x36, 0x1B, 0xFD, 0xFC, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x00, 0x3E, 0x3F, 0xB8, 0xD8, 0x7C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE1,
  0xF8, 0xCF, 0xE3, 0xF0, 0x1C, 0x04, 0xFC, 0x7F, 0x31, 0xD8, 0x6C, 0x36,
  0x3B, 0xF9, 0xF8, 0xCE, 0x63, 0x31, 0xD8, 0xEC, 0x30, 0x3C, 0x7E, 0xE7,
  0xC7, 0xE0, 0x78, 0x3C, 0x0E, 0x07, 0xC3, 0xC7, 0xFE, 0x3C, 0xFF, 0xFF,
  0xC3, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xE3,
  0x7F, 0x3C, 0xE1, 0xD8, 0x76, 0x19, 0xC6, 0x33, 0x8C, 0xE3, 0x30, 0xEC,
  0x1F, 0x07, 0x81, 0xE0, 0x38, 0x0C, 0x00, 0x63, 0x1B, 0x18, 0xD9, 0xCE,
  0xCE, 0x76, 0x7B, 0x3B, 0xD8, 0xD6, 0xC7, 0xB6, 0x3C, 0xB1, 0xE7, 0x0F,
  0x38, 0x31, 0xC1, 0x8E, 0x00, 0x61, 0x9C, 0xE3, 0x30, 0xEC, 0x1E, 0x07,
  0x80, 0xC0, 0x78, 0x1E, 0x0F, 0xC3, 0x31, 0xCE, 0x61, 0x80, 0xE1, 0x98,
  0xE7, 0x30, 0xCC, 0x37, 0x0F, 0x81, 0xE0, 0x70, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x00, 0xFF, 0xFF, 0x06, 0x0E, 0x0C, 0x1C, 0x18, 0x30, 0x70,
  0x60, 0xE0, 0xFF, 0xFF, 0xFF, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xFC, 0xE0,
  0xC1, 0x83, 0x83, 0x06, 0x0E, 0x0C, 0x18, 0x30, 0x30, 0x60, 0xC0, 0xC0,
  0xFF, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0xFF, 0x10, 0x70, 0xA3,
  0x66, 0xC8, 0x80, 0xFF, 0xFC, 0x61, 0x8E, 0x79, 0xFB, 0x30, 0x77, 0xFD,
  0xF3, 0xE7, 0xFE, 0xFC, 0xC1, 0x83, 0x06, 0x0D, 0xDF, 0xF1, 0xE3, 0xC7,
  0x8F, 0x1E, 0x3F, 0xFB, 0x80, 0x79, 0xFB, 0x3E, 0x3C, 0x18, 0x30, 0x63,
  0xFC, 0xF0, 0x06, 0x0C, 0x18, 0x37, 0x7F, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E,
  0x3F, 0xEE, 0xC0, 0x38, 0xFB, 0x1E, 0x3F, 0xFF, 0xF0, 0x60, 0x7E, 0x78,
  0x1C, 0xF3, 0x0C, 0xFB, 0xE3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC0, 0x77,
  0xFF, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xFE, 0xEC, 0x18, 0x3F, 0xCF, 0x00,
  0xC1, 0x83, 0x06, 0x0D, 0xDF, 0xF3, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78,
  0xC0, 0xF3, 0xFF, 0xFF, 0xC0, 0x6C, 0x36, 0xDB, 0x6D, 0xB6, 0xDF, 0xC0,
  0xC1, 0x83, 0x06, 0x0C, 0xF9, 0xB6, 0x7C, 0xF9, 0xF3, 0x76, 0x6C, 0xF8,
  0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0xDD, 0xDF, 0xFF, 0x39, 0xE3, 0x3C, 0x67,
  0x8C, 0xF1, 0x9E, 0x33, 0xC6, 0x78, 0xCC, 0xDD, 0xFF, 0x3E, 0x3C, 0x78,
  0xF1, 0xE3, 0xC7, 0x8C, 0x39, 0xFB, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xFC,
  0x70, 0xDD, 0xFF, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xFF, 0xBB, 0x06, 0x0C,
  0x18, 0x00, 0x77, 0xFF, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xFE, 0xEC, 0x18,
  0x30, 0x60, 0xC0, 0xD7, 0xB9, 0x8C, 0x63, 0x18, 0xC6, 0x00, 0x7B, 0xFC,
  0xF0, 0xF8, 0xF0, 0xF3, 0xFD, 0xE0, 0x73, 0xBF, 0xF7, 0x39, 0xCE, 0x73,
  0x8E, 0x70, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE7, 0xFE, 0xEC, 0xE7,
  0x66, 0x66, 0x66, 0x7C, 0x3C, 0x3C, 0x3C, 0x18, 0x18, 0xE6, 0x6C, 0xCD,
  0xB9, 0xB7, 0x66, 0xFC, 0xD7, 0x8E, 0xF1, 0xCE, 0x39, 0x86, 0x30, 0x66,
  0x76, 0x3C, 0x3C, 0x18, 0x1C, 0x3C, 0x3E, 0x66, 0x67, 0xE7, 0x66, 0x66,
  0x66, 0x7C, 0x3C, 0x3C, 0x3C, 0x18, 0x18, 0x18, 0x38, 0x70, 0x60, 0xFF,
  0xF1, 0xC6, 0x30, 0xC6, 0x38, 0xFF, 0xF0, 0x37, 0x66, 0x66, 0x6C, 0xCE,
  0x66, 0x66, 0x67, 0x30, 0xFF, 0xFE, 0x43, 0x18, 0x63, 0x18, 0xC7, 0x39,
  0x8C, 0x63, 0x19, 0x8C, 0x40, 0x71, 0xFB, 0xDF, 0xCE,
};

const GFXglyph RobotoCondensed_SemiBold18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 3, 13, 5, 1, -13 },
  { 6, 4, 5, 6, 1, -14 },
  { 9, 8, 13, 10, 1, -13 },
  { 22, 7, 17, 9, 1, -15 },
  { 37, 10, 13, 11, 1, -13 },
  { 54, 9, 13, 10, 1, -13 },
  { 69, 1, 5, 3, 1, -14 },
  { 70, 4, 18, 6, 1, -14 },
  { 79, 5, 18, 6, 0, -14 },
  { 91, 8, 8, 8, 0, -13 },
  { 99, 7, 10, 9, 1, -11 },
  { 108, 3, 5, 4, 0, -2 },
  { 110, 4, 2, 6, 1, -7 },
  { 111, 3, 3, 5, 1, -3 },
  { 113, 6, 14, 6, 0, -13 },
  { 124, 7, 13, 9, 1, -13 },
  { 136, 5, 13, 9, 1, -13 },
  { 145, 7, 13, 9, 1, -13 },
  { 157, 7, 13, 9, 1, -13 },
  { 169, 7, 13, 9, 1, -13 },
  { 181, 7, 13, 9, 1, -13 },
  { 193, 7, 13, 9, 1, -13 },
  { 205, 7, 13, 9, 1, -13 },
  { 217, 7, 13, 9, 1, -13 },
  { 229, 7, 13, 9, 1, -13 },
  { 241, 3, 10, 5, 1, -10 },
  { 245, 4, 13, 4, 0, -10 },
  { 252, 6, 9, 8, 1, -10 },
  { 259, 7, 6, 9, 1, -9 },
  { 265, 7, 9, 8, 1, -10 },
  { 273, 6, 13, 8, 1, -13 },
  { 283, 12, 16, 14, 1, -12 },
  { 307, 10, 13, 11, 0, -13 },
  { 324, 8, 13, 10, 1, -13 },
  { 337, 9, 13, 10, 1, -13 },
  { 352, 8, 13, 10, 1, -13 },
  { 365, 7, 13, 9, 1, -13 },
  { 377, 7, 13, 9, 1, -13 },
  { 389, 9, 13, 11, 1, -13 },
  { 404, 9, 13, 11, 1, -13 },
  { 419, 3, 13, 5, 1, -13 },
  { 424, 8, 13, 9, 0, -13 },
  { 437, 9, 13, 10, 1, -13 },
  { 452, 7, 13, 9, 1, -13 },
  { 464, 12, 13, 14, 1, -13 },
  { 484, 9, 13, 11, 1, -13 },
  { 499, 9, 13, 11, 1, -13 },
  { 514, 9, 13, 10, 1, -13 },
  { 529, 9, 15, 11, 1, -13 },
  { 546, 9, 13, 10, 1, -13 },
  { 561, 8, 13, 10, 1, -13 },
  { 574, 9, 13, 10, 0, -13 },
  { 589, 8, 13, 10, 1, -13 },
  { 602, 10, 13, 10, 0, -13 },
  { 619, 13, 13, 14, 0, -13 },
  { 641, 10, 13, 10, 0, -13 },
  { 658, 10, 13, 10, 0, -13 },
  { 675, 8, 13, 10, 1, -13 },
  { 688, 3, 18, 5, 1, -15 },
  { 695, 7, 14, 7, 0, -13 },
  { 708, 4, 18, 5, 0, -15 },
  { 717, 7, 6, 7, 0, -13 },
  { 723, 7, 2, 7, 0, 0 },
  { 725, 5, 3, 6, 0, -14 },
  { 727, 7, 10, 9, 1, -10 },
  { 736, 7, 14, 9, 1, -14 },
  { 749, 7, 10, 8, 1, -10 },
  { 758, 7, 14, 9, 1, -14 },
  { 771, 7, 10, 9, 1, -10 },
  { 780, 6, 14, 6, 0, -14 },
  { 791, 7, 14, 9, 1, -10 },
  { 804, 7, 14, 9, 1, -14 },
  { 817, 2, 13, 4, 1, -13 },
  { 821, 3, 17, 4, 0, -13 },
  { 828, 7, 14, 8, 1, -14 },
  { 841, 2, 14, 4, 1, -14 },
  { 845, 11, 10, 13, 1, -10 },
  { 859, 7, 10, 9, 1, -10 },
  { 868, 7, 10, 9, 1, -10 },
  { 877, 7, 14, 9, 1, -10 },
  { 890, 7, 14, 9, 1, -10 },
  { 903, 5, 10, 6, 1, -10 },
  { 910, 6, 10, 8, 1, -10 },
  { 918, 5, 12, 5, 0, -12 },
  { 926, 7, 10, 9, 1, -10 },
  { 935, 8, 10, 8, 0, -10 },
  { 945, 11, 10, 11, 0, -10 },
  { 959, 8, 10, 8, 0, -10 },
  { 969, 8, 14, 8, 0, -10 },
  { 983, 6, 10, 8, 1, -10 },
  { 991, 4, 17, 5, 1, -14 },
  { 1000, 1, 15, 5, 2, -13 },
  { 1002, 5, 17, 5, 0, -14 },
  { 1013, 8, 4, 10, 1, -7 },
};

const GFXfont RobotoCondensed_SemiBold18pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_SemiBold18pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_SemiBold18pt7bGlyphs,
  0x20, 0x7E, 21
};

#endif // _ROBOTOCONDENSED_SEMIBOLD18PT7B_H_
