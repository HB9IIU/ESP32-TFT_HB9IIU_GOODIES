#ifndef _ROBOTOCONDENSED_SEMIBOLD37PT7B_H_
#define _ROBOTOCONDENSED_SEMIBOLD37PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-SemiBold.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_SemiBold37pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B,
  0xC0, 0x00, 0x3F, 0xFF, 0x7B, 0xC0, 0xF3, 0xFC, 0xFF, 0x3F, 0xCE, 0xF3,
  0xBC, 0xEF, 0x3B, 0x8E, 0xE3, 0xB8, 0xE0, 0x03, 0x9C, 0x01, 0xCE, 0x01,
  0xC7, 0x00, 0xE3, 0x80, 0x71, 0xC0, 0x38, 0xE0, 0x1C, 0x70, 0xFF, 0xFF,
  0x7F, 0xFF, 0xBF, 0xFF, 0xC3, 0x8E, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0x73,
  0x80, 0x39, 0xC0, 0x38, 0xE0, 0xFF, 0xFE, 0x7F, 0xFF, 0x3F, 0xFF, 0x83,
  0x8E, 0x01, 0xCE, 0x00, 0xE7, 0x00, 0xE3, 0x80, 0x71, 0xC0, 0x38, 0xE0,
  0x1C, 0x70, 0x00, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x7C,
  0x03, 0xFE, 0x0F, 0xFE, 0x3F, 0xFE, 0x7C, 0x7C, 0xF0, 0x79, 0xE0, 0xFB,
  0xC1, 0xF7, 0x83, 0xEF, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x1F,
  0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xDE, 0x07, 0xFC, 0x0F, 0xFC, 0x1F,
  0xF8, 0x3E, 0xF8, 0xF9, 0xFF, 0xF1, 0xFF, 0xC1, 0xFF, 0x01, 0xFC, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x3E, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x80,
  0x0E, 0x38, 0x20, 0xE3, 0x87, 0x0E, 0x38, 0x70, 0xE3, 0x8E, 0x0E, 0x39,
  0xC0, 0xE3, 0x9C, 0x0F, 0xFB, 0x80, 0x7F, 0x38, 0x03, 0xE7, 0x00, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x00, 0xE7, 0x80, 0x1C, 0xFE, 0x01, 0xDF, 0xE0,
  0x3B, 0xCF, 0x07, 0x38, 0x70, 0x73, 0x87, 0x0E, 0x38, 0x70, 0xE3, 0x87,
  0x1C, 0x3C, 0xF0, 0x41, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x78, 0x03, 0xE0,
  0x00, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x3E, 0x3C, 0x03, 0xE3,
  0xC0, 0x3E, 0x3C, 0x03, 0xE3, 0xC0, 0x1E, 0x7C, 0x01, 0xFF, 0x80, 0x1F,
  0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFE, 0x3C, 0x3F, 0xE3, 0xC7,
  0xDF, 0x3C, 0x7C, 0xFB, 0xC7, 0x8F, 0xFC, 0xF8, 0x7F, 0x8F, 0x83, 0xF8,
  0x7C, 0x3F, 0x07, 0xC3, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF,
  0xC0, 0x7E, 0x3E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0x01, 0x81, 0xE1,
  0xE0, 0xE0, 0xF0, 0x70, 0x78, 0x3C, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC0, 0xE0, 0x78,
  0x3C, 0x1E, 0x0F, 0x03, 0xC1, 0xE0, 0x70, 0x3C, 0x0E, 0x07, 0x81, 0xE0,
  0x70, 0x10, 0x40, 0x70, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0x70, 0x3C, 0x1E,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x3E, 0x1F, 0x0F, 0x07, 0x83, 0xC1, 0xE1, 0xE0, 0xF0,
  0x70, 0x78, 0x38, 0x3C, 0x3C, 0x1C, 0x04, 0x00, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x41, 0xC0, 0x79, 0xCF, 0x7F, 0xFF, 0x7F, 0xFF,
  0x07, 0xF8, 0x03, 0xE0, 0x07, 0xF0, 0x0F, 0x70, 0x1E, 0x78, 0x1C, 0x3C,
  0x1C, 0x1C, 0x00, 0x10, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x7D, 0xF7, 0xDF, 0x7D, 0xE7, 0x9E, 0xF3, 0xC6,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x7B, 0xFF, 0xDF, 0x78, 0x00, 0xF0, 0x0E,
  0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x38,
  0x07, 0x80, 0x70, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xE0,
  0x1C, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x78, 0x07, 0x00,
  0x70, 0x0F, 0x00, 0x07, 0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0xFF, 0xC7, 0xC7,
  0xDF, 0x0F, 0xBE, 0x0F, 0x7C, 0x1F, 0xF8, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF,
  0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0,
  0x7F, 0xE0, 0xFF, 0xC1, 0xEF, 0x87, 0xCF, 0x8F, 0x9F, 0xFE, 0x1F, 0xFC,
  0x1F, 0xF0, 0x1F, 0x80, 0x00, 0xC1, 0xF1, 0xFD, 0xFF, 0xFF, 0xFF, 0xFE,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0x07, 0xE0, 0x0F, 0xF8, 0x1F, 0xFC, 0x3F, 0xFE, 0x7C, 0x3E, 0x7C,
  0x3E, 0x78, 0x1E, 0xF8, 0x1E, 0xF8, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7F, 0xFF, 0x7F,
  0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F,
  0xFC, 0x7C, 0x3E, 0x7C, 0x3E, 0x78, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x3E, 0x00, 0x3E, 0x07, 0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xFC, 0x00,
  0x3E, 0x00, 0x1E, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x7C, 0x1E, 0x7C,
  0x3E, 0x7F, 0xFE, 0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xE0, 0x00, 0x7C, 0x00,
  0xFC, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x07,
  0xFC, 0x07, 0x7C, 0x0F, 0x7C, 0x0F, 0x7C, 0x1E, 0x7C, 0x1E, 0x7C, 0x3C,
  0x7C, 0x7C, 0x7C, 0x78, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7C, 0x3F, 0xFC, 0x7F, 0xF8, 0xFF, 0xF3, 0xFF, 0xE7, 0xC0, 0x0F, 0x80,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF7, 0xC1, 0xFF, 0xE3, 0xFF, 0xC7,
  0xFF, 0xCF, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7F, 0xE0,
  0xFF, 0xC1, 0xFF, 0x83, 0xEF, 0x8F, 0x9F, 0xFF, 0x1F, 0xFC, 0x1F, 0xF0,
  0x0F, 0x80, 0x00, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0xFF, 0x83, 0xF8, 0x07,
  0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xF3, 0xC3, 0xFF, 0xE7, 0xFF,
  0xEF, 0xFF, 0xDF, 0x8F, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x3F,
  0xE0, 0xFF, 0xC1, 0xF7, 0x83, 0xEF, 0x8F, 0x8F, 0xFF, 0x1F, 0xFC, 0x1F,
  0xF0, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x78, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x3F, 0xE0, 0xFF,
  0xE3, 0xFF, 0xC7, 0xC7, 0xDF, 0x0F, 0xBE, 0x1F, 0x7C, 0x1E, 0xF8, 0x3C,
  0xF0, 0xF9, 0xF1, 0xF1, 0xFF, 0xC1, 0xFF, 0x03, 0xFE, 0x1F, 0xFE, 0x3E,
  0x3E, 0xF8, 0x3D, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x8F,
  0x9F, 0xFF, 0x3F, 0xFC, 0x3F, 0xF0, 0x1F, 0x80, 0x0F, 0xC0, 0x3F, 0xC0,
  0xFF, 0xC3, 0xFF, 0xCF, 0xCF, 0x9F, 0x0F, 0xBE, 0x0F, 0x78, 0x1E, 0xF0,
  0x3D, 0xE0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x87, 0xEF, 0xFF, 0xDF, 0xFF,
  0x1F, 0xFE, 0x0F, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80,
  0x7E, 0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0x80, 0x3C, 0x00, 0x7B, 0xFF, 0xDF,
  0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0xFF, 0xF7, 0xDE,
  0x3C, 0xF9, 0xFB, 0xE3, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x9E, 0x3C, 0x79, 0xE0, 0x80,
  0x00, 0x08, 0x01, 0xC0, 0x3E, 0x07, 0xF0, 0xFF, 0x9F, 0xF3, 0xFE, 0x1F,
  0xC0, 0xF8, 0x07, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFC, 0x03,
  0xE0, 0x07, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x03, 0x80, 0x0F, 0x80, 0x3F, 0x80, 0xFF, 0x80, 0xFF, 0x80,
  0x7F, 0x80, 0x7F, 0x00, 0x7C, 0x07, 0xF0, 0xFF, 0x8F, 0xF8, 0xFF, 0x83,
  0xF8, 0x0F, 0x80, 0x38, 0x00, 0x80, 0x00, 0x0F, 0xC0, 0xFF, 0xC7, 0xFF,
  0x9F, 0xFE, 0xFC, 0xFF, 0xE1, 0xFF, 0x87, 0xC0, 0x1F, 0x00, 0x7C, 0x03,
  0xE0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x1C, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0xFF, 0xFC, 0x00, 0xF8, 0x1F, 0x00, 0xF0, 0x03, 0xC0, 0xF0, 0x00, 0xF0,
  0xF0, 0x00, 0x38, 0x70, 0x00, 0x1E, 0x78, 0x1F, 0x07, 0x38, 0x1F, 0xC3,
  0x9C, 0x1F, 0xF1, 0xDE, 0x1E, 0x38, 0x7E, 0x0E, 0x1C, 0x3F, 0x0F, 0x1E,
  0x1F, 0x87, 0x0F, 0x0F, 0xC3, 0x87, 0x87, 0xE3, 0xC3, 0x83, 0xF1, 0xE1,
  0xC1, 0xF8, 0xF0, 0xE0, 0xFC, 0x78, 0x70, 0xEE, 0x3C, 0x38, 0x77, 0x1E,
  0x3C, 0x3B, 0x87, 0x9E, 0x39, 0xC3, 0xFF, 0xFC, 0xF0, 0xFD, 0xFC, 0x38,
  0x38, 0x78, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7E, 0x06, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F,
  0xE0, 0x03, 0xCF, 0x00, 0x1E, 0x78, 0x01, 0xF3, 0xE0, 0x0F, 0x9F, 0x00,
  0x78, 0x78, 0x07, 0xC3, 0xC0, 0x3E, 0x1F, 0x01, 0xE0, 0xF8, 0x1F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC3, 0xE0, 0x1F, 0x1F,
  0x00, 0xF8, 0xF8, 0x07, 0xCF, 0x80, 0x1F, 0x7C, 0x00, 0xFB, 0xE0, 0x07,
  0xC0, 0xFF, 0xF0, 0x7F, 0xFE, 0x3F, 0xFF, 0x9F, 0xFF, 0xEF, 0x83, 0xF7,
  0xC0, 0xFB, 0xE0, 0x7D, 0xF0, 0x1E, 0xF8, 0x1F, 0x7C, 0x0F, 0xBF, 0xFF,
  0x9F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xF3, 0xE0, 0x7D, 0xF0, 0x3E, 0xF8,
  0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0xFB,
  0xFF, 0xFD, 0xFF, 0xFC, 0xFF, 0xFC, 0x7F, 0xF8, 0x00, 0x03, 0xF0, 0x03,
  0xFF, 0x01, 0xFF, 0xF0, 0xFF, 0xFC, 0x7E, 0x1F, 0x9F, 0x03, 0xEF, 0x80,
  0x7B, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1E, 0x7C, 0x0F, 0x9F, 0x87, 0xE3, 0xFF,
  0xF0, 0xFF, 0xFC, 0x0F, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xE0, 0x7F, 0xFC,
  0x3F, 0xFF, 0x1F, 0xFF, 0xCF, 0x83, 0xF7, 0xC0, 0xFB, 0xE0, 0x3D, 0xF0,
  0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03,
  0xFF, 0x01, 0xEF, 0x81, 0xF7, 0xC1, 0xFB, 0xFF, 0xF9, 0xFF, 0xF8, 0xFF,
  0xF8, 0x7F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0xBF, 0xFF, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0xBF, 0xFF, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x03, 0xF8, 0x03, 0xFF, 0x83, 0xFF,
  0xF0, 0xFF, 0xFC, 0x7E, 0x1F, 0x9F, 0x03, 0xEF, 0x80, 0x7B, 0xE0, 0x1F,
  0xF8, 0x07, 0xFE, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x7F, 0xFE,
  0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0x7C, 0x07, 0xDF, 0x83, 0xF3, 0xFF, 0xFC, 0x7F, 0xFE,
  0x0F, 0xFF, 0x00, 0xFE, 0x00, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFE, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x8F, 0x9F, 0xFF,
  0x1F, 0xFC, 0x1F, 0xF0, 0x1F, 0x80, 0xF8, 0x0F, 0xFE, 0x07, 0xEF, 0x81,
  0xFB, 0xE0, 0xFC, 0xF8, 0x3E, 0x3E, 0x1F, 0x8F, 0x8F, 0xC3, 0xE3, 0xE0,
  0xF9, 0xF0, 0x3E, 0xFC, 0x0F, 0xBE, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x3F,
  0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0xFE, 0xF8, 0x3F, 0x3F, 0x0F, 0x87,
  0xC3, 0xE1, 0xF8, 0xF8, 0x3E, 0x3E, 0x0F, 0xCF, 0x81, 0xFB, 0xE0, 0x7E,
  0xF8, 0x0F, 0xFE, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xC3, 0xDF, 0xFB, 0xC3, 0xDF, 0xFB, 0xC3, 0xDF, 0xFB, 0xC3, 0xDF,
  0xF9, 0xE7, 0x9F, 0xF9, 0xE7, 0x9F, 0xF9, 0xE7, 0x9F, 0xF8, 0xFF, 0x1F,
  0xF8, 0xFF, 0x1F, 0xF8, 0xFF, 0x1F, 0xF8, 0xFE, 0x1F, 0xF8, 0x7E, 0x1F,
  0xF8, 0x7E, 0x1F, 0xF8, 0x7E, 0x1F, 0xF8, 0x3C, 0x1F, 0xF8, 0x3C, 0x1F,
  0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF,
  0xC0, 0xFF, 0xF0, 0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xF0, 0xFF, 0xBC,
  0x3F, 0xEF, 0x8F, 0xF9, 0xE3, 0xFE, 0x7C, 0xFF, 0x8F, 0x3F, 0xE3, 0xEF,
  0xF8, 0x7B, 0xFE, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x1F, 0xFE,
  0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFE, 0x01, 0xF0, 0x03,
  0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xF0, 0xFF, 0xFC, 0x7E, 0x1F, 0x9F, 0x03,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0x7C, 0x0F, 0xDF, 0x87,
  0xE3, 0xFF, 0xF8, 0x7F, 0xFC, 0x0F, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0xF0,
  0x3F, 0xFF, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0xF8, 0x1F, 0xBE, 0x03, 0xEF,
  0x80, 0xFB, 0xE0, 0x1E, 0xF8, 0x07, 0xFE, 0x01, 0xEF, 0x80, 0xFB, 0xE0,
  0x3E, 0xF8, 0x1F, 0xBF, 0xFF, 0xCF, 0xFF, 0xE3, 0xFF, 0xF0, 0xFF, 0xF0,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x01,
  0xFF, 0x80, 0x7F, 0xFC, 0x1F, 0xFF, 0x87, 0xE1, 0xF8, 0xF8, 0x1F, 0x3E,
  0x01, 0xF7, 0xC0, 0x3E, 0xF8, 0x07, 0xDF, 0x00, 0x7B, 0xE0, 0x0F, 0x7C,
  0x01, 0xEF, 0x80, 0x3D, 0xF0, 0x07, 0xBE, 0x00, 0xF7, 0xC0, 0x1E, 0xF8,
  0x03, 0xDF, 0x00, 0xFB, 0xE0, 0x1F, 0x7C, 0x03, 0xE7, 0xC0, 0xFC, 0xFC,
  0x3F, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0x00, 0x00, 0x40, 0xFF,
  0xF0, 0x3F, 0xFF, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0xF8, 0x3F, 0x3E, 0x07,
  0xEF, 0x80, 0xFB, 0xE0, 0x3E, 0xF8, 0x0F, 0xBE, 0x03, 0xEF, 0x81, 0xF3,
  0xE0, 0xFC, 0xFF, 0xFE, 0x3F, 0xFF, 0x8F, 0xFF, 0x83, 0xFF, 0xE0, 0xF8,
  0xFC, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE0, 0xF8, 0xF8, 0x3E, 0x3E, 0x07,
  0xCF, 0x81, 0xF3, 0xE0, 0x7E, 0xF8, 0x0F, 0xBE, 0x03, 0xE0, 0x03, 0xF0,
  0x07, 0xFE, 0x07, 0xFF, 0x87, 0xFF, 0xE7, 0xE1, 0xF3, 0xE0, 0x7D, 0xF0,
  0x3E, 0xF8, 0x1F, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x03, 0xFE, 0x00,
  0xFF, 0xC0, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0x80, 0x07,
  0xFE, 0x03, 0xFF, 0x01, 0xF7, 0xC0, 0xFB, 0xF0, 0xFC, 0xFF, 0xFC, 0x7F,
  0xFE, 0x0F, 0xFE, 0x01, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF,
  0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F,
  0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0,
  0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF,
  0x80, 0xFB, 0xE0, 0xF9, 0xFF, 0xFC, 0x7F, 0xFC, 0x1F, 0xFC, 0x03, 0xF8,
  0x00, 0x7C, 0x01, 0xFB, 0xE0, 0x0F, 0x9F, 0x00, 0x7C, 0x7C, 0x03, 0xE3,
  0xE0, 0x3E, 0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0x83, 0xE0, 0x7C, 0x1F, 0x07,
  0xC0, 0xF8, 0x3E, 0x03, 0xC1, 0xF0, 0x1F, 0x0F, 0x00, 0xF8, 0xF8, 0x07,
  0xC7, 0xC0, 0x1E, 0x3C, 0x00, 0xF9, 0xE0, 0x07, 0xDF, 0x00, 0x1E, 0xF8,
  0x00, 0xF7, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x1E,
  0x07, 0xFE, 0x07, 0x81, 0xFF, 0x83, 0xE0, 0x7D, 0xE0, 0xFC, 0x1E, 0x78,
  0x3F, 0x07, 0x9F, 0x0F, 0xC3, 0xE7, 0xC3, 0xF0, 0xF9, 0xF1, 0xFC, 0x3E,
  0x3C, 0x7F, 0x8F, 0x0F, 0x1F, 0xE3, 0xC3, 0xC7, 0xF8, 0xF0, 0xF9, 0xFE,
  0x7C, 0x3E, 0xF3, 0x9F, 0x0F, 0xBC, 0xF7, 0xC1, 0xEF, 0x3D, 0xE0, 0x7B,
  0xCF, 0x78, 0x1E, 0xF3, 0xDE, 0x07, 0xF8, 0x7F, 0x81, 0xFE, 0x1F, 0xE0,
  0x3F, 0x87, 0xF0, 0x0F, 0xE1, 0xFC, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x0F,
  0xC0, 0x3F, 0x03, 0xF0, 0x0F, 0xC0, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0xFC,
  0x07, 0xEF, 0x80, 0xF9, 0xF8, 0x3F, 0x1F, 0x07, 0xC3, 0xE1, 0xF8, 0x3E,
  0x3E, 0x07, 0xC7, 0xC0, 0x7D, 0xF0, 0x0F, 0xBE, 0x00, 0xFF, 0x80, 0x1F,
  0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F,
  0xE0, 0x07, 0xFC, 0x01, 0xF7, 0xC0, 0x3E, 0xF8, 0x0F, 0x9F, 0x81, 0xF1,
  0xF0, 0x7C, 0x3F, 0x0F, 0x83, 0xE3, 0xE0, 0x7E, 0x7C, 0x07, 0xDF, 0x00,
  0xFC, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x7E, 0x07, 0xC3, 0xE0, 0x7C, 0x3E,
  0x07, 0xC1, 0xF0, 0xF8, 0x1F, 0x0F, 0x80, 0xF0, 0xF0, 0x0F, 0x9F, 0x00,
  0xF9, 0xE0, 0x07, 0xBE, 0x00, 0x7F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9,
  0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xFF, 0xFF, 0xFF, 0xE0, 0x78,
  0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x1E, 0x00,
  0x7C, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x78, 0x01, 0xF0,
  0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x1F,
  0xFF, 0xFF, 0xFF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF,
  0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF,
  0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0x00, 0xF0, 0x0F, 0x81, 0xF8, 0x1F, 0x81,
  0xFC, 0x3D, 0xC3, 0x9C, 0x39, 0xE7, 0x8E, 0x70, 0xEF, 0x0F, 0xF0, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3E, 0x0F, 0x83, 0xC0,
  0xF0, 0x7C, 0x07, 0xE0, 0x3F, 0xF0, 0xFF, 0xE3, 0xFF, 0xE7, 0xC7, 0xCF,
  0x87, 0x80, 0x0F, 0x00, 0x1E, 0x07, 0xFC, 0x3F, 0xF8, 0xFF, 0xF3, 0xE1,
  0xE7, 0x83, 0xCF, 0x07, 0xBE, 0x0F, 0x3E, 0x3E, 0x7F, 0xFE, 0xFF, 0xFC,
  0xFF, 0xF8, 0x79, 0xF0, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFB, 0xE1, 0xFF, 0xF3, 0xFF,
  0xF7, 0xFF, 0xEF, 0xC7, 0xDF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F,
  0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC,
  0x3E, 0xFF, 0xFD, 0xFF, 0xFB, 0xDF, 0xE7, 0x9F, 0x00, 0x07, 0xE0, 0x3F,
  0xE0, 0xFF, 0xE1, 0xFF, 0xE7, 0xC3, 0xCF, 0x07, 0xDE, 0x0F, 0xFC, 0x0F,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x03, 0xDE,
  0x0F, 0xBE, 0x1F, 0x3F, 0xFC, 0x7F, 0xF0, 0x7F, 0xC0, 0x3F, 0x00, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x0F, 0x9E, 0x3F, 0xBC, 0xFF, 0xFB, 0xFF, 0xF7, 0xC3, 0xEF,
  0x83, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0,
  0xFF, 0x81, 0xFF, 0x03, 0xDE, 0x07, 0xBE, 0x1F, 0x7F, 0xFE, 0x7F, 0xFC,
  0x7F, 0x78, 0x7C, 0xF0, 0x07, 0xE0, 0x3F, 0xF0, 0xFF, 0xF1, 0xFF, 0xE7,
  0xC3, 0xEF, 0x83, 0xDE, 0x07, 0xBC, 0x0F, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x3F, 0x06, 0x3F, 0xFE,
  0x7F, 0xFC, 0x3F, 0xF0, 0x3F, 0x80, 0x03, 0xE1, 0xFC, 0x7F, 0x8F, 0xF3,
  0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0xFF, 0xDF, 0xFB, 0xFF, 0x7F, 0xE3, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x00, 0x0F, 0x9F, 0x1F,
  0xFF, 0x3F, 0xFF, 0x7F, 0xFF, 0x7C, 0x3F, 0x7C, 0x1F, 0x78, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x78,
  0x1F, 0x7C, 0x1F, 0x7C, 0x3F, 0x7F, 0xFF, 0x3F, 0xFF, 0x1F, 0xDF, 0x0F,
  0x9F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x18, 0x3E, 0x3F, 0xFE, 0x3F,
  0xFC, 0x1F, 0xF8, 0x07, 0xE0, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF9, 0xE3, 0xFF, 0xEF, 0xFF,
  0xBF, 0xFF, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0,
  0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8,
  0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0x77, 0xFF, 0xF7, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0E, 0x1F, 0x1F, 0x1F, 0x0E, 0x00, 0x00, 0x00, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0xFE, 0xFE, 0xFC, 0xF8,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x7D, 0xF1, 0xFB, 0xE3, 0xE7, 0xCF, 0x8F, 0xBF,
  0x1F, 0x7C, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0x81, 0xFF, 0x83, 0xFF, 0x07,
  0xFF, 0x0F, 0xFE, 0x1F, 0x3E, 0x3E, 0x7C, 0x7C, 0x7C, 0xF8, 0xFD, 0xF0,
  0xFB, 0xE1, 0xFF, 0xC1, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF1,
  0xE0, 0xF8, 0xF7, 0xFB, 0xFC, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xF8,
  0x7E, 0x3E, 0xF8, 0x7C, 0x1E, 0xF8, 0x7C, 0x1E, 0xF8, 0x7C, 0x1F, 0xF8,
  0x7C, 0x1F, 0xF8, 0x7C, 0x1F, 0xF8, 0x7C, 0x1F, 0xF8, 0x7C, 0x1F, 0xF8,
  0x7C, 0x1F, 0xF8, 0x7C, 0x1F, 0xF8, 0x7C, 0x1F, 0xF8, 0x7C, 0x1F, 0xF8,
  0x7C, 0x1F, 0xF8, 0x7C, 0x1F, 0xF8, 0x7C, 0x1F, 0xF8, 0x7C, 0x1F, 0xF1,
  0xE3, 0xDF, 0xEF, 0xFF, 0xBF, 0xFF, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE,
  0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF,
  0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0x07, 0xE0,
  0x1F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFE, 0x7E, 0x3E, 0x7C, 0x1F, 0x78, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0x78, 0x1F, 0x7C, 0x1F, 0x7C, 0x3E, 0x3F, 0xFE, 0x3F, 0xFC, 0x1F, 0xF8,
  0x07, 0xE0, 0xF3, 0xE1, 0xEF, 0xF3, 0xFF, 0xF7, 0xFF, 0xEF, 0x87, 0xDF,
  0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1,
  0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x3E, 0xFF, 0xFD, 0xFF, 0xF3,
  0xFF, 0xE7, 0xDF, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x0F, 0x9E, 0x3F, 0xBC, 0xFF,
  0xFB, 0xFF, 0xF7, 0xC3, 0xEF, 0x83, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F,
  0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xDE, 0x07, 0xBE,
  0x1F, 0x7F, 0xFE, 0x7F, 0xFC, 0x7F, 0x78, 0x7C, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0xF3, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E,
  0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x00, 0x0F,
  0xC0, 0x7F, 0xC3, 0xFF, 0x9F, 0xFF, 0x7C, 0x7D, 0xE0, 0xF7, 0xC0, 0x1F,
  0x80, 0x3F, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x00, 0xFC, 0x01, 0xFF,
  0x83, 0xDE, 0x0F, 0x7F, 0xFC, 0xFF, 0xE1, 0xFF, 0x03, 0xF8, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0xC7, 0xF0, 0xFC, 0x1F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8,
  0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE,
  0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x87, 0xFE, 0x1F, 0xFF, 0xFD, 0xFF, 0xF3,
  0xFB, 0xC7, 0xCF, 0xF8, 0x3F, 0xF0, 0x7B, 0xE1, 0xF3, 0xC3, 0xE7, 0x87,
  0xCF, 0x8F, 0x1F, 0x1E, 0x1E, 0x7C, 0x3C, 0xF0, 0x79, 0xE0, 0xFB, 0xC0,
  0xF7, 0x81, 0xFE, 0x03, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F,
  0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF0, 0x78, 0x7F, 0xC1, 0xE1, 0xFF, 0x8F,
  0x87, 0xBE, 0x3E, 0x1E, 0x78, 0xFC, 0x79, 0xE3, 0xF3, 0xE7, 0x8F, 0xCF,
  0x1E, 0x7F, 0x3C, 0x7D, 0xFC, 0xF0, 0xF7, 0x7B, 0xC3, 0xDD, 0xEF, 0x0F,
  0xF3, 0xF8, 0x3F, 0xCF, 0xE0, 0x7E, 0x3F, 0x81, 0xF8, 0xFE, 0x07, 0xE1,
  0xF8, 0x1F, 0x87, 0xC0, 0x7C, 0x1F, 0x00, 0xF0, 0x7C, 0x03, 0xC0, 0xF0,
  0xF8, 0x3E, 0xF8, 0xF9, 0xF1, 0xF1, 0xF7, 0xC3, 0xEF, 0x83, 0xDE, 0x07,
  0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7F, 0x01, 0xFE,
  0x03, 0xFE, 0x0F, 0xFC, 0x1F, 0x7C, 0x7C, 0xF8, 0xF8, 0xFB, 0xE1, 0xF7,
  0xC1, 0xF0, 0x7C, 0x1F, 0x7C, 0x1E, 0x7C, 0x3E, 0x7C, 0x3E, 0x3C, 0x3E,
  0x3E, 0x3C, 0x3E, 0x7C, 0x1E, 0x7C, 0x1E, 0x78, 0x1E, 0x78, 0x1F, 0x78,
  0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0,
  0x07, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3C, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0xF8, 0x07,
  0xC0, 0x7C, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0x01, 0xC1, 0xE1, 0xE1,
  0xF0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0xF8,
  0x78, 0xFC, 0x7C, 0x3C, 0x1F, 0x83, 0xC1, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3E, 0x0F, 0x07, 0xC1, 0xE0, 0x20,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x40, 0x78, 0x3E, 0x0F, 0x07, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF8, 0x3C, 0x1F, 0x87, 0xC1, 0xE1, 0xF1, 0xE1,
  0xF0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x78, 0x7C, 0x3C, 0x08, 0x00, 0x1E, 0x00, 0x1F, 0x81, 0xDF, 0xE1, 0xEF,
  0xF8, 0xFF, 0x1F, 0xF7, 0x8F, 0xFB, 0x83, 0xF8, 0x00, 0x78,
};

const GFXglyph RobotoCondensed_SemiBold37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 5, 26, 10, 2, -26 },
  { 18, 10, 10, 12, 1, -28 },
  { 31, 17, 26, 20, 2, -26 },
  { 87, 15, 33, 19, 2, -30 },
  { 149, 20, 26, 24, 2, -26 },
  { 214, 20, 26, 21, 1, -26 },
  { 279, 4, 10, 6, 1, -28 },
  { 284, 9, 37, 12, 2, -29 },
  { 326, 9, 37, 12, 1, -29 },
  { 368, 16, 16, 17, 0, -26 },
  { 400, 15, 19, 18, 1, -21 },
  { 436, 6, 11, 9, 1, -4 },
  { 445, 8, 4, 12, 2, -13 },
  { 449, 6, 5, 11, 2, -5 },
  { 453, 12, 28, 13, 0, -26 },
  { 495, 15, 26, 19, 2, -26 },
  { 544, 10, 26, 19, 3, -26 },
  { 577, 16, 26, 19, 1, -26 },
  { 629, 16, 26, 19, 1, -26 },
  { 681, 16, 26, 19, 1, -26 },
  { 733, 15, 26, 19, 2, -26 },
  { 782, 15, 26, 19, 2, -26 },
  { 831, 16, 26, 19, 1, -26 },
  { 883, 15, 26, 19, 2, -26 },
  { 932, 15, 26, 19, 2, -26 },
  { 981, 6, 20, 10, 2, -20 },
  { 996, 7, 27, 9, 1, -20 },
  { 1020, 13, 17, 17, 1, -20 },
  { 1048, 14, 12, 18, 2, -18 },
  { 1069, 14, 17, 17, 2, -20 },
  { 1099, 14, 26, 16, 1, -26 },
  { 1145, 25, 34, 28, 2, -26 },
  { 1252, 21, 26, 22, 0, -26 },
  { 1321, 17, 26, 21, 2, -26 },
  { 1377, 18, 26, 21, 2, -26 },
  { 1436, 17, 26, 21, 2, -26 },
  { 1492, 15, 26, 18, 2, -26 },
  { 1541, 15, 26, 18, 2, -26 },
  { 1590, 18, 26, 22, 2, -26 },
  { 1649, 18, 26, 23, 2, -26 },
  { 1708, 4, 26, 10, 3, -26 },
  { 1721, 15, 26, 18, 1, -26 },
  { 1770, 18, 26, 20, 2, -26 },
  { 1829, 15, 26, 18, 2, -26 },
  { 1878, 24, 26, 28, 2, -26 },
  { 1956, 18, 26, 23, 2, -26 },
  { 2015, 18, 26, 22, 2, -26 },
  { 2074, 18, 26, 21, 2, -26 },
  { 2133, 19, 31, 22, 2, -26 },
  { 2207, 18, 26, 20, 2, -26 },
  { 2266, 17, 26, 20, 1, -26 },
  { 2322, 18, 26, 20, 1, -26 },
  { 2381, 17, 26, 21, 2, -26 },
  { 2437, 21, 26, 21, 0, -26 },
  { 2506, 26, 26, 28, 1, -26 },
  { 2591, 19, 26, 21, 1, -26 },
  { 2653, 20, 26, 20, 0, -26 },
  { 2718, 17, 26, 20, 1, -26 },
  { 2774, 7, 37, 10, 2, -31 },
  { 2807, 14, 28, 14, 0, -26 },
  { 2856, 6, 37, 10, 1, -31 },
  { 2884, 12, 13, 14, 1, -26 },
  { 2904, 14, 4, 15, 0, 0 },
  { 2911, 9, 6, 12, 1, -28 },
  { 2918, 15, 20, 18, 1, -20 },
  { 2956, 15, 28, 18, 2, -28 },
  { 3009, 15, 20, 17, 1, -20 },
  { 3047, 15, 28, 18, 1, -28 },
  { 3100, 15, 20, 18, 1, -20 },
  { 3138, 11, 28, 12, 1, -28 },
  { 3177, 16, 28, 19, 1, -20 },
  { 3233, 14, 28, 18, 2, -28 },
  { 3282, 5, 28, 9, 2, -28 },
  { 3300, 8, 36, 9, -1, -28 },
  { 3336, 15, 28, 17, 2, -28 },
  { 3389, 5, 28, 9, 2, -28 },
  { 3407, 24, 20, 28, 2, -20 },
  { 3467, 14, 20, 18, 2, -20 },
  { 3502, 16, 20, 18, 1, -20 },
  { 3542, 15, 28, 18, 2, -20 },
  { 3595, 15, 28, 18, 1, -20 },
  { 3648, 9, 20, 12, 2, -20 },
  { 3671, 14, 20, 17, 1, -20 },
  { 3706, 10, 24, 11, 0, -24 },
  { 3736, 14, 20, 18, 2, -20 },
  { 3771, 15, 20, 16, 1, -20 },
  { 3809, 22, 20, 24, 1, -20 },
  { 3864, 15, 20, 17, 1, -20 },
  { 3902, 16, 28, 16, 0, -20 },
  { 3958, 13, 20, 17, 2, -20 },
  { 3991, 9, 36, 11, 1, -29 },
  { 4032, 3, 31, 9, 3, -26 },
  { 4044, 9, 36, 11, 1, -29 },
  { 4085, 17, 8, 21, 2, -15 },
};

const GFXfont RobotoCondensed_SemiBold37pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_SemiBold37pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_SemiBold37pt7bGlyphs,
  0x20, 0x7E, 43
};

#endif // _ROBOTOCONDENSED_SEMIBOLD37PT7B_H_
