#ifndef _ROBOTOCONDENSED_SEMIBOLD16PT7B_H_
#define _ROBOTOCONDENSED_SEMIBOLD16PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-SemiBold.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_SemiBold16pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xCF, 0xBB, 0xAA, 0x34, 0x48, 0x91, 0x6F, 0xE5, 0x1A,
  0x7F, 0x48, 0xB1, 0x62, 0x80, 0x10, 0x47, 0x9F, 0xCF, 0x3E, 0x1C, 0x3C,
  0x3C, 0xF3, 0xFD, 0xE1, 0x04, 0xE0, 0x58, 0x25, 0x96, 0x8E, 0xC0, 0x40,
  0x60, 0x2E, 0x3D, 0x16, 0xDB, 0x40, 0xE0, 0x78, 0x78, 0xCC, 0xC8, 0x78,
  0x70, 0x72, 0xDE, 0xDE, 0xCE, 0xFE, 0x7F, 0xF0, 0x12, 0x64, 0xCC, 0xCC,
  0xCC, 0xCC, 0xC4, 0x62, 0x10, 0x44, 0x62, 0x33, 0x33, 0x33, 0x33, 0x32,
  0x64, 0x40, 0x10, 0x23, 0x5B, 0xE3, 0x8D, 0x81, 0x00, 0x30, 0xC3, 0x3F,
  0xFC, 0xC3, 0x0C, 0x6D, 0xA4, 0xFC, 0xF0, 0x18, 0xC4, 0x23, 0x18, 0x84,
  0x63, 0x11, 0x8C, 0x00, 0x7B, 0xFC, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3F,
  0xDE, 0x17, 0xF3, 0x33, 0x33, 0x33, 0x33, 0x7B, 0xFC, 0xF3, 0x0C, 0x71,
  0x8C, 0x71, 0x8F, 0xFF, 0x7B, 0xFC, 0xC3, 0x0C, 0xE3, 0x83, 0x0F, 0x3F,
  0xDE, 0x0C, 0x0C, 0x1C, 0x1C, 0x3C, 0x2C, 0x6C, 0x7F, 0x7F, 0x0C, 0x0C,
  0x0C, 0x7D, 0xFC, 0x30, 0xFB, 0xF0, 0xC3, 0x0F, 0x3F, 0xDE, 0x19, 0xE6,
  0x30, 0xFB, 0xFC, 0xF3, 0xCF, 0x37, 0xCE, 0xFF, 0xF0, 0xC3, 0x18, 0x61,
  0x8C, 0x31, 0xC6, 0x18, 0x7B, 0xFC, 0xF3, 0xCD, 0xE7, 0xB3, 0xCF, 0x3F,
  0xDE, 0x7B, 0xEC, 0xF3, 0xCF, 0x3F, 0xDF, 0x0C, 0x67, 0x9C, 0xF0, 0x03,
  0xC0, 0x6C, 0x00, 0x03, 0x6D, 0xA0, 0x09, 0xDF, 0xCC, 0x3C, 0xE1, 0xFF,
  0xF0, 0x00, 0xFF, 0xF0, 0x83, 0x87, 0x87, 0x1D, 0xEE, 0x20, 0x39, 0xFE,
  0xC3, 0x0C, 0x61, 0x8C, 0x00, 0x03, 0x0C, 0x1F, 0x06, 0x31, 0x83, 0x27,
  0x2D, 0xB5, 0x26, 0xE4, 0x9C, 0x93, 0x92, 0x53, 0xCA, 0x7E, 0x60, 0x04,
  0x00, 0xE4, 0x07, 0x80, 0x0C, 0x0E, 0x07, 0x03, 0xC3, 0x61, 0xB0, 0xCC,
  0x7E, 0x7F, 0x31, 0xD8, 0x7C, 0x30, 0xFD, 0xFF, 0x1E, 0x3C, 0x7F, 0xBF,
  0x63, 0xC7, 0x8F, 0xFF, 0xE0, 0x3C, 0x7E, 0xC6, 0xC7, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC7, 0xC6, 0x7E, 0x3C, 0xF9, 0xFB, 0x1E, 0x3C, 0x78, 0xF1, 0xE3,
  0xC7, 0x8F, 0xF7, 0xC0, 0xFF, 0xFC, 0x30, 0xC3, 0xFF, 0xF0, 0xC3, 0x0F,
  0xFF, 0xFF, 0xFC, 0x30, 0xC3, 0xFF, 0xF0, 0xC3, 0x0C, 0x30, 0x3C, 0x7E,
  0xC6, 0xC7, 0xC0, 0xCF, 0xCF, 0xC7, 0xC7, 0xC7, 0x7E, 0x3C, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xFF, 0xFF, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xFF, 0xFF,
  0xFF, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x07, 0xCD, 0xF1, 0xC0,
  0xC6, 0xCE, 0xCC, 0xDC, 0xD8, 0xF8, 0xF8, 0xFC, 0xCC, 0xCE, 0xC6, 0xC7,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0F, 0xFF, 0xE1, 0xF8, 0x7E,
  0x1F, 0xC7, 0xF3, 0xFC, 0xFD, 0x2F, 0x7B, 0xDE, 0xF3, 0xBC, 0xCF, 0x33,
  0xC3, 0xE3, 0xE3, 0xF3, 0xF3, 0xDB, 0xDB, 0xCF, 0xCF, 0xC7, 0xC7, 0xC3,
  0x3C, 0x7E, 0xC6, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC6, 0x7E, 0x3C,
  0xFD, 0xFF, 0x1E, 0x3C, 0x78, 0xFF, 0xFE, 0xC1, 0x83, 0x06, 0x00, 0x3C,
  0x7E, 0xC6, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC6, 0x7E, 0x3E, 0x07,
  0x02, 0xFD, 0xFF, 0x1E, 0x3C, 0x7F, 0xFE, 0x66, 0xCD, 0x9F, 0x1E, 0x30,
  0x79, 0xFB, 0x1E, 0x0E, 0x0F, 0x0F, 0x07, 0xC7, 0x8F, 0xF3, 0xC0, 0xFF,
  0xFF, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0xC7,
  0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0xFB, 0xE0, 0xE1, 0xB1,
  0xD8, 0xCC, 0x67, 0x31, 0xB0, 0xD8, 0x6C, 0x16, 0x0E, 0x07, 0x03, 0x80,
  0xE6, 0x36, 0x66, 0x66, 0x66, 0x76, 0x6F, 0x66, 0xF6, 0x2F, 0x63, 0x94,
  0x39, 0xC3, 0x9C, 0x39, 0xC3, 0x9C, 0x63, 0x31, 0x8D, 0x86, 0xC1, 0xC0,
  0xE0, 0x70, 0x78, 0x36, 0x1B, 0x18, 0xCC, 0x60, 0xE3, 0x63, 0x66, 0x36,
  0x36, 0x3C, 0x1C, 0x18, 0x18, 0x18, 0x18, 0x18, 0xFF, 0xFC, 0x30, 0x61,
  0x87, 0x0C, 0x30, 0x61, 0x83, 0xFF, 0xF0, 0xFF, 0x6D, 0xB6, 0xDB, 0x6D,
  0xBF, 0xC1, 0x86, 0x18, 0x30, 0xC3, 0x0C, 0x18, 0x61, 0x83, 0x0C, 0xFD,
  0xB6, 0xDB, 0x6D, 0xB6, 0xFF, 0x30, 0xC3, 0x9E, 0x49, 0x30, 0xFF, 0xF0,
  0x63, 0x7B, 0xEC, 0xC3, 0x7F, 0x3C, 0xFF, 0x6C, 0xC3, 0x0C, 0x3E, 0xFF,
  0x3C, 0xF3, 0xCF, 0x3F, 0xFE, 0x7B, 0xFC, 0xF0, 0xC3, 0x0C, 0xFF, 0x78,
  0x0C, 0x30, 0xDF, 0xFF, 0x3C, 0xF3, 0xCF, 0x3F, 0xDF, 0x7B, 0xFC, 0xF3,
  0xFF, 0x0C, 0x3F, 0x78, 0x39, 0xD9, 0xFF, 0xB1, 0x8C, 0x63, 0x18, 0xC0,
  0x7F, 0xFC, 0xF3, 0xCF, 0x3C, 0xFF, 0x7C, 0x3F, 0xDE, 0xC3, 0x0C, 0x3E,
  0xFF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xF3, 0xFF, 0xFF, 0x6C, 0x36, 0xDB,
  0x6D, 0xB7, 0xF0, 0xC1, 0x83, 0x06, 0x6D, 0x9F, 0x3C, 0x78, 0xD9, 0xB3,
  0x36, 0x60, 0xFF, 0xFF, 0xFF, 0xFB, 0xBF, 0xFC, 0xCF, 0x33, 0xCC, 0xF3,
  0x3C, 0xCF, 0x33, 0xCC, 0xC0, 0xFB, 0xFC, 0xF3, 0xCF, 0x3C, 0xF3, 0xCC,
  0x7B, 0xFC, 0xF3, 0xCF, 0x3C, 0xFF, 0x78, 0xFB, 0xFC, 0xF3, 0xCF, 0x3C,
  0xFF, 0xFB, 0x0C, 0x30, 0x7F, 0xFC, 0xF3, 0xCF, 0x3C, 0xFF, 0x7C, 0x30,
  0xC3, 0xFF, 0xCC, 0xCC, 0xCC, 0xC0, 0x7B, 0xEC, 0xF8, 0x78, 0x78, 0xFE,
  0x78, 0x66, 0xFF, 0x66, 0x66, 0x67, 0x30, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C,
  0xFF, 0x7C, 0xC6, 0xD9, 0xB3, 0x66, 0xC5, 0x0E, 0x1C, 0x38, 0xCC, 0xD3,
  0x36, 0xC9, 0xBE, 0x7F, 0x9E, 0xE3, 0x38, 0xCC, 0x33, 0x00, 0x6E, 0xD8,
  0xF1, 0xC3, 0x87, 0x0F, 0x36, 0x66, 0xC6, 0xD9, 0xB3, 0x66, 0xC7, 0x0E,
  0x1C, 0x10, 0x61, 0xC3, 0x00, 0xFB, 0xE1, 0x8C, 0x31, 0x8C, 0x3F, 0xFC,
  0x13, 0x32, 0x22, 0xEE, 0x62, 0x22, 0x33, 0x10, 0xFF, 0xFF, 0xFF, 0xF0,
  0x46, 0x66, 0x66, 0x33, 0x26, 0x66, 0x66, 0x40, 0x73, 0xFE, 0x30,
};

const GFXglyph RobotoCondensed_SemiBold16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 2, 12, 4, 1, -12 },
  { 4, 4, 4, 5, 1, -12 },
  { 6, 7, 12, 9, 1, -12 },
  { 17, 6, 16, 8, 1, -14 },
  { 29, 9, 12, 10, 1, -12 },
  { 43, 8, 12, 9, 1, -12 },
  { 55, 1, 4, 3, 1, -12 },
  { 56, 4, 17, 5, 1, -13 },
  { 65, 4, 17, 5, 0, -13 },
  { 74, 7, 7, 7, 0, -12 },
  { 81, 6, 8, 8, 1, -9 },
  { 87, 3, 5, 4, 0, -2 },
  { 89, 3, 2, 5, 1, -6 },
  { 90, 2, 2, 5, 1, -2 },
  { 91, 5, 13, 5, 0, -12 },
  { 100, 6, 12, 8, 1, -12 },
  { 109, 4, 12, 8, 1, -12 },
  { 115, 6, 12, 8, 1, -12 },
  { 124, 6, 12, 8, 1, -12 },
  { 133, 8, 12, 8, 0, -12 },
  { 145, 6, 12, 8, 1, -12 },
  { 154, 6, 12, 8, 1, -12 },
  { 163, 6, 12, 8, 1, -12 },
  { 172, 6, 12, 8, 1, -12 },
  { 181, 6, 12, 8, 1, -12 },
  { 190, 2, 9, 4, 1, -9 },
  { 193, 3, 12, 4, 0, -9 },
  { 198, 5, 8, 7, 1, -9 },
  { 203, 6, 6, 8, 1, -8 },
  { 208, 6, 8, 7, 1, -9 },
  { 214, 6, 12, 7, 0, -12 },
  { 223, 11, 15, 12, 1, -11 },
  { 244, 9, 12, 9, 0, -12 },
  { 258, 7, 12, 9, 1, -12 },
  { 269, 8, 12, 9, 1, -12 },
  { 281, 7, 12, 9, 1, -12 },
  { 292, 6, 12, 8, 1, -12 },
  { 301, 6, 12, 8, 1, -12 },
  { 310, 8, 12, 9, 1, -12 },
  { 322, 8, 12, 10, 1, -12 },
  { 334, 2, 12, 4, 1, -12 },
  { 337, 7, 12, 8, 0, -12 },
  { 348, 8, 12, 9, 1, -12 },
  { 360, 6, 12, 8, 1, -12 },
  { 369, 10, 12, 12, 1, -12 },
  { 384, 8, 12, 10, 1, -12 },
  { 396, 8, 12, 10, 1, -12 },
  { 408, 7, 12, 9, 1, -12 },
  { 419, 8, 14, 10, 1, -12 },
  { 433, 7, 12, 9, 1, -12 },
  { 444, 7, 12, 9, 1, -12 },
  { 455, 8, 12, 9, 0, -12 },
  { 467, 7, 12, 9, 1, -12 },
  { 478, 9, 12, 9, 0, -12 },
  { 492, 12, 12, 12, 0, -12 },
  { 510, 9, 12, 9, 0, -12 },
  { 524, 8, 12, 9, 0, -12 },
  { 536, 7, 12, 8, 1, -12 },
  { 547, 3, 16, 4, 1, -13 },
  { 553, 6, 13, 6, 0, -12 },
  { 563, 3, 16, 4, 0, -13 },
  { 569, 6, 6, 6, 0, -12 },
  { 574, 6, 2, 6, 0, 0 },
  { 576, 4, 2, 5, 0, -12 },
  { 577, 6, 9, 8, 1, -9 },
  { 584, 6, 12, 8, 1, -12 },
  { 593, 6, 9, 7, 1, -9 },
  { 600, 6, 12, 8, 1, -12 },
  { 609, 6, 9, 8, 1, -9 },
  { 616, 5, 12, 5, 0, -12 },
  { 624, 6, 12, 8, 1, -9 },
  { 633, 6, 12, 8, 1, -12 },
  { 642, 2, 12, 4, 1, -12 },
  { 645, 3, 15, 4, 0, -12 },
  { 651, 7, 12, 8, 1, -12 },
  { 662, 2, 12, 4, 1, -12 },
  { 665, 10, 9, 12, 1, -9 },
  { 677, 6, 9, 8, 1, -9 },
  { 684, 6, 9, 8, 1, -9 },
  { 691, 6, 12, 8, 1, -9 },
  { 700, 6, 12, 8, 1, -9 },
  { 709, 4, 9, 5, 1, -9 },
  { 714, 6, 9, 7, 1, -9 },
  { 721, 4, 11, 5, 0, -11 },
  { 727, 6, 9, 8, 1, -9 },
  { 734, 7, 9, 7, 0, -9 },
  { 742, 10, 9, 10, 0, -9 },
  { 754, 7, 9, 7, 0, -9 },
  { 762, 7, 12, 7, 0, -9 },
  { 773, 6, 9, 7, 1, -9 },
  { 780, 4, 15, 5, 0, -12 },
  { 788, 2, 14, 4, 1, -12 },
  { 792, 4, 15, 5, 0, -12 },
  { 800, 7, 3, 9, 1, -6 },
};

const GFXfont RobotoCondensed_SemiBold16pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_SemiBold16pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_SemiBold16pt7bGlyphs,
  0x20, 0x7E, 19
};

#endif // _ROBOTOCONDENSED_SEMIBOLD16PT7B_H_
