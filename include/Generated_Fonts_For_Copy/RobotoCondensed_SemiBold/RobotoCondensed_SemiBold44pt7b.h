#ifndef _ROBOTOCONDENSED_SEMIBOLD44PT7B_H_
#define _ROBOTOCONDENSED_SEMIBOLD44PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-SemiBold.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_SemiBold44pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF,
  0xBE, 0xFB, 0xEF, 0xBE, 0xF8, 0x00, 0x00, 0x01, 0xEF, 0xBF, 0xFF, 0xE7,
  0x80, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFE, 0x3F, 0x8F, 0xE3,
  0xF8, 0xFE, 0x3F, 0x8F, 0x01, 0xE3, 0xC0, 0x1E, 0x38, 0x01, 0xC3, 0x80,
  0x1C, 0x38, 0x01, 0xC7, 0x80, 0x3C, 0x78, 0x03, 0xC7, 0x80, 0x3C, 0x78,
  0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x07, 0x8F,
  0x00, 0x78, 0xF0, 0x07, 0x8E, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0x71,
  0xE0, 0x0F, 0x1E, 0x0F, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xE0, 0xE3, 0xC0, 0x0E, 0x3C, 0x01, 0xE3, 0xC0, 0x1E, 0x3C, 0x01,
  0xE3, 0x80, 0x1E, 0x38, 0x01, 0xC3, 0x80, 0x1C, 0x78, 0x00, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0xFE, 0x00,
  0xFF, 0xC0, 0x7F, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0xE7, 0xE1, 0xF9, 0xF8,
  0x3F, 0x7E, 0x0F, 0xDF, 0x83, 0xF7, 0xE0, 0xFD, 0xF8, 0x00, 0x3F, 0x00,
  0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xC0,
  0x0F, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0xC0, 0xFF, 0xF0,
  0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xF7, 0xE1, 0xFD, 0xFF, 0xFE, 0x3F, 0xFF,
  0x87, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xE0, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x1F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x7F, 0xE0, 0x00, 0xF0, 0xE0, 0xE0, 0xF0, 0xF0, 0xE0, 0xF0, 0xF1,
  0xE0, 0xF0, 0xF1, 0xC0, 0xF0, 0xF3, 0xC0, 0xF0, 0xF3, 0x80, 0xF0, 0xE7,
  0x80, 0x7F, 0xE7, 0x00, 0x7F, 0xEF, 0x00, 0x3F, 0xCE, 0x00, 0x1F, 0x1C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0xF8, 0x00, 0x7B, 0xFC, 0x00, 0x73,
  0xFE, 0x00, 0xF7, 0xDF, 0x00, 0xE7, 0x8F, 0x01, 0xE7, 0x0F, 0x01, 0xC7,
  0x0F, 0x03, 0xC7, 0x0F, 0x07, 0x87, 0x0F, 0x07, 0x07, 0x0F, 0x0F, 0x07,
  0x8F, 0x02, 0x07, 0xDF, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xF8, 0x03, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80,
  0x3F, 0xFF, 0x00, 0xFC, 0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x3E,
  0x1F, 0x00, 0xF8, 0x7C, 0x03, 0xF3, 0xE0, 0x07, 0xDF, 0x80, 0x1F, 0xFC,
  0x00, 0x3F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF8, 0x3E, 0x3F, 0xF0, 0xF9,
  0xFF, 0xE3, 0xE7, 0xDF, 0x8F, 0xBF, 0x3F, 0x7C, 0xF8, 0x7F, 0xF3, 0xE1,
  0xFF, 0xCF, 0x83, 0xFF, 0x3E, 0x07, 0xF8, 0xFC, 0x0F, 0xE3, 0xF8, 0x7F,
  0x07, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x7F, 0xF7, 0xE0,
  0x7F, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFE, 0xEE, 0xE0, 0x00, 0x80, 0x60,
  0x3C, 0x1F, 0x0F, 0x83, 0xC1, 0xF0, 0x78, 0x3E, 0x0F, 0x07, 0xC1, 0xF0,
  0x78, 0x1E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x81,
  0xE0, 0x78, 0x1F, 0x03, 0xC0, 0xF0, 0x3E, 0x07, 0x81, 0xE0, 0x3C, 0x0F,
  0x81, 0xF0, 0x3C, 0x06, 0x00, 0x80, 0x40, 0x0C, 0x03, 0xC0, 0x3C, 0x07,
  0xC0, 0x78, 0x07, 0x80, 0xF8, 0x1F, 0x01, 0xE0, 0x3E, 0x07, 0xC0, 0x78,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x83, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0x81, 0xF0, 0x3E, 0x07, 0x81, 0xF0, 0x3E, 0x07, 0x81,
  0xE0, 0x7C, 0x0F, 0x03, 0xC0, 0x30, 0x04, 0x00, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x10, 0x78, 0x2F, 0x9E, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xC0, 0x3F, 0x80, 0x0F, 0xC0, 0x07,
  0xF8, 0x03, 0xDF, 0x01, 0xF3, 0xC0, 0xF8, 0x78, 0x3C, 0x1F, 0x07, 0x03,
  0x80, 0x00, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0xBE, 0x7C, 0xF3, 0xE7, 0x82, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7B, 0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0x3C, 0x00, 0xF0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0x01,
  0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0xFF, 0x1F, 0x87, 0xE7, 0xE0, 0xF9, 0xF0,
  0x3E, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F,
  0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF,
  0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFD, 0xF0,
  0x3E, 0x7E, 0x0F, 0x9F, 0x87, 0xE3, 0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xFE,
  0x03, 0xFF, 0x00, 0x3F, 0x00, 0x00, 0x30, 0x0F, 0x07, 0xF1, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xC1, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF,
  0xFC, 0x7F, 0xFF, 0x9F, 0x87, 0xEF, 0xC0, 0xFB, 0xE0, 0x3E, 0xF8, 0x0F,
  0xFE, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x03, 0xF0, 0x03, 0xFF, 0x03, 0xFF, 0xE1, 0xFF, 0xFC, 0x7F,
  0xFF, 0xBF, 0x87, 0xEF, 0xC0, 0xFB, 0xF0, 0x3E, 0xF8, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xC0,
  0x1F, 0xF8, 0x07, 0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xBF, 0x07,
  0xE7, 0xFF, 0xF9, 0xFF, 0xFC, 0x3F, 0xFE, 0x07, 0xFF, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x3F,
  0xF8, 0x03, 0xDF, 0x80, 0x7D, 0xF8, 0x07, 0x9F, 0x80, 0xF9, 0xF8, 0x1F,
  0x1F, 0x81, 0xF1, 0xF8, 0x3E, 0x1F, 0x83, 0xE1, 0xF8, 0x7C, 0x1F, 0x87,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x3F, 0xFF, 0x8F, 0xFF, 0xE3, 0xFF,
  0xF8, 0xFF, 0xFE, 0x3F, 0xFF, 0x8F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x07, 0xEF, 0x81, 0xFF, 0xF8, 0x7F, 0xFF, 0x1F,
  0xFF, 0xE7, 0xF7, 0xF8, 0x70, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F,
  0x7C, 0x0F, 0xDF, 0x87, 0xE7, 0xFF, 0xF8, 0xFF, 0xFC, 0x1F, 0xFE, 0x03,
  0xFF, 0x00, 0x3F, 0x00, 0x00, 0x3C, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x1F,
  0xF0, 0x0F, 0xFC, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00,
  0x1F, 0x80, 0x07, 0xCF, 0xC1, 0xF7, 0xF8, 0x7F, 0xFF, 0x3F, 0xFF, 0xEF,
  0xFF, 0xFB, 0xF8, 0x7F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xF0,
  0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xF7, 0xC0, 0x7D, 0xF0, 0x3F, 0x7E, 0x0F,
  0xCF, 0x87, 0xE3, 0xFF, 0xF8, 0x7F, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0x00,
  0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00,
  0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x7F, 0xFF, 0x9F,
  0x87, 0xE7, 0xE0, 0xF9, 0xF0, 0x3E, 0x7C, 0x0F, 0x9F, 0x03, 0xE7, 0xE0,
  0xF9, 0xF8, 0x7E, 0x3F, 0xFF, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xF8,
  0x3F, 0xFF, 0x1F, 0x87, 0xE7, 0xE0, 0xF9, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF,
  0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xDF, 0x87, 0xE7, 0xFF,
  0xF8, 0xFF, 0xFC, 0x3F, 0xFF, 0x03, 0xFF, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x03, 0xFE, 0x01, 0xFF, 0xE0, 0xFF, 0xF8, 0x7F, 0xFF, 0x1F, 0x87, 0xC7,
  0xC1, 0xFB, 0xF0, 0x3E, 0xFC, 0x0F, 0xBF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0,
  0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFD, 0xF8, 0x7F, 0x7F, 0xFF,
  0xCF, 0xFF, 0xF3, 0xFF, 0xF8, 0x7F, 0xBE, 0x07, 0xCF, 0x80, 0x03, 0xE0,
  0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0xFF, 0xC0, 0x3F,
  0xF0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xF0, 0x00, 0x7B, 0xFF, 0xFF, 0xFD,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xBF, 0xFF,
  0xFF, 0xDE, 0x1E, 0x3F, 0x7F, 0x7F, 0x3F, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x3E, 0x3E,
  0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3C, 0x7C, 0x78, 0x78, 0x30, 0x00, 0x01,
  0x00, 0x07, 0x00, 0x1F, 0x00, 0x7F, 0x01, 0xFF, 0x07, 0xFF, 0x1F, 0xFC,
  0x3F, 0xF0, 0xFF, 0xC0, 0xFF, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0xC0,
  0x3F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0x1F,
  0x00, 0x07, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xC0, 0x03,
  0xE0, 0x07, 0xE0, 0x0F, 0xF0, 0x1F, 0xF8, 0x1F, 0xFC, 0x07, 0xFE, 0x03,
  0xFE, 0x01, 0xFC, 0x00, 0xF8, 0x07, 0xF0, 0x3F, 0xE1, 0xFF, 0x9F, 0xFC,
  0x7F, 0xE0, 0xFF, 0x01, 0xFC, 0x03, 0xE0, 0x07, 0x00, 0x08, 0x00, 0x00,
  0x07, 0xF0, 0x07, 0xFE, 0x0F, 0xFF, 0x87, 0xFF, 0xE7, 0xFF, 0xF3, 0xF1,
  0xFB, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0x1F, 0xE0, 0x03, 0xE0, 0x07,
  0xC0, 0x1F, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x3C,
  0x1E, 0x00, 0x00, 0x70, 0xF0, 0x0F, 0x81, 0xE3, 0xC0, 0xFF, 0x87, 0x8E,
  0x07, 0xFF, 0x0E, 0x78, 0x3F, 0xFC, 0x39, 0xE0, 0xF0, 0xF0, 0xF7, 0x87,
  0xC3, 0x83, 0xDC, 0x1E, 0x0E, 0x0F, 0xF0, 0x78, 0x78, 0x3F, 0xC3, 0xE1,
  0xE0, 0xFF, 0x0F, 0x07, 0x83, 0xFC, 0x3C, 0x1E, 0x0F, 0xF0, 0xF0, 0x78,
  0x3F, 0xC3, 0xC1, 0xE0, 0xFF, 0x0F, 0x07, 0x83, 0xBC, 0x3C, 0x1E, 0x0E,
  0xF0, 0xF0, 0x78, 0x3B, 0xC3, 0xC3, 0xE1, 0xEF, 0x0F, 0x8F, 0x87, 0x3C,
  0x3F, 0xFF, 0x3C, 0x70, 0x7F, 0xBF, 0xE1, 0xE0, 0xFC, 0xFF, 0x07, 0x81,
  0xE0, 0xF8, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x18,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFB, 0xE0, 0x00,
  0xF9, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x7E, 0x7E, 0x00, 0x3E, 0x1F, 0x00,
  0x1F, 0x0F, 0x80, 0x1F, 0x87, 0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xC0, 0xF8,
  0x03, 0xE0, 0x7E, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3E, 0x00, 0x7C, 0x3F, 0x00,
  0x3F, 0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0x0F, 0xCF, 0xC0, 0x03, 0xF7, 0xE0,
  0x01, 0xFB, 0xF0, 0x00, 0xFC, 0xFF, 0xF8, 0x1F, 0xFF, 0xE3, 0xFF, 0xFE,
  0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xF0, 0x1F, 0xBE, 0x01, 0xFF, 0xC0, 0x3F,
  0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x07, 0xEF, 0x83, 0xFD,
  0xFF, 0xFF, 0x3F, 0xFF, 0x87, 0xFF, 0xFC, 0xFF, 0xFF, 0xDF, 0x01, 0xFB,
  0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF,
  0xFF, 0xF9, 0xFF, 0xFE, 0x3F, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xFE,
  0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFC, 0x0F, 0xC7,
  0xE0, 0x1F, 0x9F, 0x80, 0x7E, 0x7C, 0x00, 0xFB, 0xF0, 0x03, 0xEF, 0xC0,
  0x0F, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xE7, 0xC0, 0x0F, 0x9F, 0x80,
  0x7E, 0x7E, 0x01, 0xF8, 0xFC, 0x0F, 0xC3, 0xFF, 0xFF, 0x07, 0xFF, 0xF8,
  0x0F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xF0, 0x0F,
  0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0x8F, 0x81, 0xFC,
  0xF8, 0x0F, 0xCF, 0x80, 0x7E, 0xF8, 0x07, 0xEF, 0x80, 0x3E, 0xF8, 0x03,
  0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80,
  0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8,
  0x03, 0xFF, 0x80, 0x3E, 0xF8, 0x07, 0xEF, 0x80, 0x7E, 0xF8, 0x0F, 0xCF,
  0x81, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFD, 0xFF,
  0xFE, 0xFF, 0xFF, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xFF, 0xF3, 0xFF, 0xF9, 0xFF, 0xFC, 0xFF, 0xFE, 0x7F, 0xFF, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFE, 0x07,
  0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFC, 0x0F, 0xE7, 0xE0, 0x1F, 0x9F, 0x80,
  0x7E, 0x7C, 0x00, 0xFB, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xF0, 0x03, 0xF7, 0xE0, 0x0F, 0xDF, 0x80, 0x3F, 0x7F, 0x00, 0xFC,
  0xFE, 0x07, 0xF3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x1F,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x1F, 0xDF,
  0x87, 0xE7, 0xFF, 0xF8, 0xFF, 0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0x00, 0x3F,
  0x00, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xBE, 0x01, 0xF9, 0xF0, 0x1F, 0xCF,
  0x81, 0xFC, 0x7C, 0x0F, 0xC3, 0xE0, 0xFE, 0x1F, 0x0F, 0xE0, 0xF8, 0x7E,
  0x07, 0xC7, 0xF0, 0x3E, 0x3F, 0x01, 0xF3, 0xF0, 0x0F, 0xBF, 0x80, 0x7D,
  0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x3F, 0xFF, 0x01, 0xFC, 0xFC, 0x0F, 0xC7, 0xF0, 0x7E, 0x1F, 0x83, 0xE0,
  0xFE, 0x1F, 0x03, 0xF0, 0xF8, 0x1F, 0xC7, 0xC0, 0x7E, 0x3E, 0x03, 0xF9,
  0xF0, 0x0F, 0xCF, 0x80, 0x7F, 0x7C, 0x01, 0xFF, 0xE0, 0x0F, 0xE0, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFB,
  0xE0, 0x7B, 0xFF, 0xBE, 0x0F, 0xBF, 0xFB, 0xE0, 0xFB, 0xFF, 0x9F, 0x0F,
  0x3F, 0xF9, 0xF1, 0xF3, 0xFF, 0x9F, 0x1F, 0x3F, 0xF8, 0xF9, 0xF3, 0xFF,
  0x8F, 0xBE, 0x3F, 0xF8, 0xFB, 0xE3, 0xFF, 0x87, 0xBE, 0x3F, 0xF8, 0x7F,
  0xC3, 0xFF, 0x87, 0xFC, 0x3F, 0xF8, 0x7F, 0xC3, 0xFF, 0x83, 0xF8, 0x3F,
  0xF8, 0x3F, 0x83, 0xFF, 0x83, 0xF8, 0x3F, 0xF8, 0x1F, 0x83, 0xFF, 0x81,
  0xF0, 0x3F, 0xF8, 0x1F, 0x03, 0xF0, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF,
  0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFE, 0x03,
  0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0xF7,
  0xC1, 0xFF, 0xBF, 0x0F, 0xFC, 0xF8, 0x7F, 0xE7, 0xE3, 0xFF, 0x1F, 0x1F,
  0xF8, 0xFC, 0xFF, 0xC3, 0xE7, 0xFE, 0x1F, 0xBF, 0xF0, 0x7D, 0xFF, 0x83,
  0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x00,
  0xFF, 0xE0, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC,
  0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFE, 0x0F, 0xE7, 0xF0, 0x1F, 0x9F,
  0x80, 0x3F, 0x7C, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F,
  0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xF7, 0xC0, 0x0F, 0xDF, 0x80, 0x3F, 0x7E, 0x01,
  0xF8, 0xFE, 0x0F, 0xE3, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0,
  0x1F, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0x80, 0x7E, 0xF8, 0x07, 0xFF,
  0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F,
  0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x07, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xC0, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF0, 0xFE, 0x0F, 0xE7, 0xE0, 0x1F, 0x9F, 0x80, 0x3F, 0x7C, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0,
  0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xF7, 0xC0, 0x0F, 0xDF, 0x80, 0x3F, 0x7E, 0x01, 0xF8, 0xFE, 0x0F, 0xE3,
  0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0x20, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xC0, 0xFE, 0xFC, 0x07, 0xEF,
  0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0x3E, 0xFC, 0x07, 0xEF, 0xC0, 0x7E,
  0xFC, 0x07, 0xEF, 0xC0, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF,
  0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xC7, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x1F, 0x8F, 0xC1, 0xF8, 0xFC, 0x1F, 0xCF, 0xC0, 0xFC, 0xFC,
  0x0F, 0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0x3F, 0xFC, 0x03, 0xF0,
  0x03, 0xF8, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0xFF,
  0xC7, 0xE0, 0xFE, 0xFC, 0x07, 0xEF, 0xC0, 0x3E, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x80, 0x1F,
  0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0x7E, 0x00, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xF7, 0xE0, 0x7E, 0x7F, 0xFF, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF,
  0x80, 0xFF, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x01, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03,
  0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xEF, 0x80, 0x3F, 0x7E,
  0x03, 0xF3, 0xF8, 0x3F, 0x8F, 0xFF, 0xFC, 0x7F, 0xFF, 0xC1, 0xFF, 0xFC,
  0x07, 0xFF, 0xC0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7E,
  0xFC, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xFC,
  0x3E, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x01, 0xF8, 0x3F, 0x01, 0xF8,
  0x1F, 0x01, 0xF8, 0x1F, 0x81, 0xF0, 0x1F, 0x83, 0xF0, 0x0F, 0x83, 0xF0,
  0x0F, 0x83, 0xE0, 0x0F, 0xC3, 0xE0, 0x0F, 0xC7, 0xE0, 0x07, 0xC7, 0xE0,
  0x07, 0xC7, 0xC0, 0x07, 0xE7, 0xC0, 0x03, 0xEF, 0xC0, 0x03, 0xEF, 0x80,
  0x03, 0xEF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7E, 0x00, 0xFC, 0x07, 0xC0, 0x7F, 0xF8, 0x0F, 0x80, 0xFD, 0xF0,
  0x1F, 0x81, 0xFB, 0xE0, 0x3F, 0x03, 0xF7, 0xE0, 0xFE, 0x07, 0xCF, 0xC1,
  0xFC, 0x0F, 0x9F, 0x83, 0xF8, 0x3F, 0x3F, 0x07, 0xF8, 0x7E, 0x3E, 0x0F,
  0xF0, 0xFC, 0x7C, 0x3F, 0xE1, 0xF0, 0xF8, 0x7F, 0xC3, 0xE1, 0xF8, 0xFF,
  0x87, 0xC3, 0xF1, 0xEF, 0x1F, 0x83, 0xE3, 0xDF, 0x3F, 0x07, 0xCF, 0xBE,
  0x7C, 0x0F, 0x9F, 0x3C, 0xF8, 0x1F, 0x3E, 0x79, 0xF0, 0x3F, 0x78, 0xF3,
  0xE0, 0x3E, 0xF1, 0xFF, 0xC0, 0x7F, 0xE3, 0xFF, 0x80, 0xFF, 0xC3, 0xFE,
  0x01, 0xFF, 0x07, 0xFC, 0x03, 0xFE, 0x0F, 0xF8, 0x07, 0xFC, 0x1F, 0xF0,
  0x07, 0xF8, 0x3F, 0xE0, 0x0F, 0xF0, 0x3F, 0x80, 0x1F, 0xC0, 0x7F, 0x00,
  0x3F, 0x80, 0xFE, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x7E, 0x03, 0xF8, 0x00,
  0xFC, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0xFC, 0xFC, 0x03, 0xF9, 0xFC, 0x07,
  0xE1, 0xF8, 0x0F, 0xC3, 0xF8, 0x3F, 0x03, 0xF0, 0x7E, 0x07, 0xF1, 0xF8,
  0x07, 0xE3, 0xF0, 0x0F, 0xCF, 0xC0, 0x0F, 0xDF, 0x80, 0x1F, 0xBE, 0x00,
  0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFD, 0xF8, 0x03, 0xF3, 0xF0, 0x07, 0xE3,
  0xF0, 0x1F, 0x87, 0xE0, 0x3F, 0x07, 0xE0, 0xFC, 0x0F, 0xC1, 0xF8, 0x1F,
  0xC7, 0xF0, 0x1F, 0x8F, 0xC0, 0x3F, 0xBF, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0x7E, 0xFC, 0x01, 0xFD, 0xFC, 0x03, 0xF1, 0xF8, 0x07, 0xE3, 0xF0, 0x1F,
  0x83, 0xF0, 0x3F, 0x07, 0xE0, 0x7C, 0x07, 0xC1, 0xF8, 0x0F, 0xC3, 0xF0,
  0x0F, 0x87, 0xC0, 0x1F, 0x1F, 0x80, 0x3F, 0x3E, 0x00, 0x3E, 0xFC, 0x00,
  0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3E,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0x3F,
  0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F,
  0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F,
  0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7F, 0x00, 0xFE, 0x01, 0xFC,
  0x07, 0xBC, 0x0F, 0x78, 0x1E, 0xF0, 0x7C, 0xF0, 0xF1, 0xE1, 0xE3, 0xC7,
  0xC7, 0xCF, 0x07, 0x9E, 0x0F, 0x7C, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x7E, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xF8, 0x0F,
  0x80, 0xF0, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0xE7, 0xF7,
  0xF7, 0xE0, 0xFB, 0xF0, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x03, 0xFF, 0x87,
  0xFF, 0xC7, 0xFF, 0xE7, 0xF9, 0xF7, 0xE0, 0xFB, 0xF0, 0x7D, 0xF0, 0x3E,
  0xF8, 0x1F, 0x7E, 0x1F, 0xBF, 0xFF, 0xDF, 0xFF, 0xE7, 0xFF, 0xF9, 0xFE,
  0xFC, 0x3E, 0x7E, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xCF, 0xC3, 0xF7, 0xF8, 0xFF, 0xFF, 0x3F, 0xFF, 0xEF, 0xFF,
  0xFB, 0xF8, 0x7F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F,
  0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF,
  0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF,
  0xF3, 0xF7, 0xF8, 0xFC, 0xFC, 0x00, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF,
  0x8F, 0xFF, 0xE7, 0xFF, 0xF7, 0xE0, 0xFB, 0xF0, 0x7F, 0xF0, 0x1F, 0xF8,
  0x0F, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x1F, 0xFC, 0x0F, 0xFE, 0x0F, 0xDF, 0xFF, 0xCF, 0xFF,
  0xE3, 0xFF, 0xE0, 0xFF, 0xE0, 0x1F, 0xC0, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC3, 0xF3, 0xE3, 0xFD, 0xF3, 0xFF, 0xFB, 0xFF,
  0xFD, 0xFF, 0xFF, 0xF8, 0x3F, 0xFC, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF,
  0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F,
  0xFC, 0x07, 0xFF, 0x03, 0xFF, 0x83, 0xF7, 0xFF, 0xFB, 0xFF, 0xFC, 0xFF,
  0xFE, 0x3F, 0xDF, 0x0F, 0xCF, 0x80, 0x03, 0xF0, 0x03, 0xFF, 0x03, 0xFF,
  0xE0, 0xFF, 0xFC, 0x7F, 0xFF, 0x9F, 0x87, 0xEF, 0xC0, 0xFB, 0xF0, 0x3E,
  0xF8, 0x0F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x81, 0xC7, 0xFF,
  0xF8, 0xFF, 0xFE, 0x3F, 0xFF, 0x03, 0xFF, 0x80, 0x3F, 0x80, 0x01, 0xF8,
  0x3F, 0xC3, 0xFE, 0x1F, 0xF1, 0xFF, 0x8F, 0xC0, 0x7E, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x3F, 0xFD, 0xFF, 0xEF, 0xFF, 0x7F, 0xF8, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0x07, 0xC7, 0xC7, 0xFD, 0xF3, 0xFF, 0xFD, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xF8, 0x0F,
  0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF,
  0x80, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xFF, 0x87, 0xF7, 0xFF, 0xFD, 0xFF,
  0xFF, 0x3F, 0xFF, 0xC7, 0xFB, 0xF0, 0x7C, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xE1, 0x81, 0xF8, 0xFF, 0xFE, 0x3F, 0xFF, 0x1F, 0xFF, 0x81,
  0xFF, 0xC0, 0x1F, 0xC0, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x3F, 0x1F, 0xBF, 0xCF, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFC, 0x1F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0,
  0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF,
  0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F,
  0xFC, 0x0F, 0x80, 0x39, 0xFF, 0xFF, 0x7C, 0xE0, 0x00, 0x01, 0xF7, 0xDF,
  0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF,
  0x7D, 0xF7, 0xDF, 0x0F, 0x07, 0xC7, 0xE3, 0xF0, 0xF8, 0x78, 0x00, 0x00,
  0x00, 0x07, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8,
  0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE3, 0xFF, 0xFF, 0xFB, 0xFD, 0xFC,
  0xF8, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x7F, 0x7E, 0x1F, 0xCF, 0xC3, 0xF1, 0xF8, 0xFC, 0x3F,
  0x1F, 0x87, 0xE7, 0xE0, 0xFD, 0xF8, 0x1F, 0xBF, 0x03, 0xFF, 0xC0, 0x7F,
  0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFE,
  0xFC, 0x1F, 0x8F, 0x83, 0xF1, 0xF8, 0x7E, 0x1F, 0x8F, 0xC3, 0xF1, 0xF8,
  0x3F, 0x3F, 0x07, 0xE7, 0xE0, 0x7E, 0xFC, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFC, 0xFC, 0x1F, 0x8F, 0xDF, 0xE3,
  0xFC, 0xFF, 0xFF, 0x7F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE1, 0xFC, 0x3F, 0xFC, 0x1F, 0x81, 0xFF, 0xC0, 0xF8, 0x1F, 0xFC, 0x0F,
  0x81, 0xFF, 0xC0, 0xF8, 0x1F, 0xFC, 0x0F, 0x81, 0xFF, 0xC0, 0xF8, 0x1F,
  0xFC, 0x0F, 0x81, 0xFF, 0xC0, 0xF8, 0x1F, 0xFC, 0x0F, 0x81, 0xFF, 0xC0,
  0xF8, 0x1F, 0xFC, 0x0F, 0x81, 0xFF, 0xC0, 0xF8, 0x1F, 0xFC, 0x0F, 0x81,
  0xFF, 0xC0, 0xF8, 0x1F, 0xFC, 0x0F, 0x81, 0xFF, 0xC0, 0xF8, 0x1F, 0xFC,
  0x0F, 0x81, 0xF0, 0xF8, 0xFC, 0x7E, 0xFF, 0x3F, 0xFF, 0xDF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xF0, 0x7F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07,
  0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8,
  0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF,
  0xE0, 0x7F, 0xF0, 0x3E, 0x03, 0xF0, 0x03, 0xFF, 0x03, 0xFF, 0xE0, 0xFF,
  0xFC, 0x7F, 0xFF, 0x9F, 0x87, 0xEF, 0xC0, 0xFF, 0xF0, 0x3F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xF0, 0x3F, 0xFC, 0x0F, 0xDF, 0x87, 0xE7, 0xFF, 0xF8, 0xFF,
  0xFC, 0x3F, 0xFE, 0x03, 0xFF, 0x00, 0x3F, 0x00, 0xFC, 0xFC, 0x3F, 0x7F,
  0x8F, 0xFF, 0xF3, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0x87, 0xFF, 0xC0, 0xFF,
  0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC,
  0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x87,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0x3F, 0x7F, 0x8F, 0xCF, 0xC3,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x0F, 0xCF, 0x8F, 0xF7,
  0xCF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xF0,
  0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFE, 0x0F, 0xDF, 0xFF,
  0xEF, 0xFF, 0xF3, 0xFF, 0xF8, 0xFF, 0x7C, 0x3F, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0xFC, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x87, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x00,
  0x03, 0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x87, 0xFF, 0xE7, 0xF3, 0xFB, 0xF0,
  0xFD, 0xF0, 0x3E, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x07, 0xFE, 0x01,
  0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0xF8, 0x3F, 0x7C, 0x0F,
  0xBE, 0x07, 0xDF, 0xCF, 0xE7, 0xFF, 0xF1, 0xFF, 0xF0, 0x7F, 0xF0, 0x0F,
  0xE0, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x1F, 0xE3,
  0xFC, 0x7F, 0x87, 0xF0, 0x3E, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF,
  0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F,
  0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0,
  0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x0F, 0xDF, 0xFF, 0xEF, 0xFF, 0xF3,
  0xFF, 0xF9, 0xFF, 0x7C, 0x3E, 0x3E, 0xFC, 0x0F, 0xFF, 0x03, 0xEF, 0xC0,
  0xF9, 0xF0, 0x7E, 0x7C, 0x1F, 0x9F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0xFC,
  0x3E, 0x3E, 0x0F, 0xCF, 0x81, 0xF3, 0xE0, 0x7C, 0xF8, 0x1F, 0x7C, 0x07,
  0xDF, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0xF8, 0x1E,
  0x07, 0xFE, 0x07, 0x81, 0xFF, 0xC3, 0xF0, 0xFD, 0xF0, 0xFC, 0x3E, 0x7C,
  0x3F, 0x0F, 0x9F, 0x0F, 0xC3, 0xE7, 0xC7, 0xF8, 0xF9, 0xF1, 0xFE, 0x3E,
  0x3E, 0x7F, 0x9F, 0x0F, 0x9F, 0xE7, 0xC3, 0xEF, 0xFD, 0xF0, 0xFB, 0xCF,
  0x7C, 0x1E, 0xF3, 0xDE, 0x07, 0xFC, 0xFF, 0x81, 0xFF, 0x3F, 0xE0, 0x7F,
  0x87, 0xF8, 0x1F, 0xE1, 0xFE, 0x03, 0xF8, 0x7F, 0x00, 0xFE, 0x1F, 0xC0,
  0x3F, 0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x01, 0xF0, 0x3E, 0x00, 0x7C, 0x0F,
  0x80, 0xFC, 0x0F, 0xDF, 0x87, 0xE7, 0xE1, 0xF8, 0xFC, 0xFC, 0x3F, 0x3E,
  0x07, 0xFF, 0x81, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x01, 0xFE, 0x00,
  0x7F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0xFF, 0xC0, 0x3F,
  0xF0, 0x1F, 0xFE, 0x07, 0xDF, 0x83, 0xF3, 0xF0, 0xF8, 0xFC, 0x7E, 0x1F,
  0x9F, 0x87, 0xEF, 0xC0, 0xFC, 0x7E, 0x07, 0xEF, 0xC0, 0xF9, 0xF8, 0x3F,
  0x3F, 0x07, 0xE3, 0xE0, 0xFC, 0x7E, 0x1F, 0x0F, 0xC7, 0xE0, 0xF8, 0xFC,
  0x1F, 0x1F, 0x03, 0xF3, 0xE0, 0x3E, 0xFC, 0x07, 0xDF, 0x00, 0xFB, 0xE0,
  0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x1F, 0xF0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F,
  0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x40, 0x3C, 0x0F, 0x83,
  0xF0, 0xFC, 0x1F, 0x03, 0xE0, 0x7C, 0x1F, 0x83, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0xF8, 0x7F, 0x0F, 0xC1,
  0xF8, 0x3F, 0x81, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0xF8, 0x0F, 0x81,
  0xF8, 0x1F, 0x01, 0xE0, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x40, 0x0E, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x7C, 0x0F, 0x80, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x3E, 0x07, 0xF0, 0x7E,
  0x0F, 0xC3, 0xF8, 0x7C, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x1F, 0x03, 0xE0, 0x7C, 0x1F,
  0x07, 0xC0, 0x70, 0x08, 0x00, 0x0F, 0x80, 0x00, 0xFE, 0x07, 0xCF, 0xF8,
  0x3E, 0xFF, 0xE1, 0xE7, 0xFF, 0xFF, 0x3C, 0x7F, 0xFB, 0xE1, 0xFF, 0x9F,
  0x03, 0xF8, 0x00, 0x0F, 0x80,
};

const GFXglyph RobotoCondensed_SemiBold44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 6, 31, 11, 3, -31 },
  { 25, 10, 12, 14, 2, -33 },
  { 40, 20, 31, 23, 2, -31 },
  { 118, 18, 40, 22, 2, -36 },
  { 208, 24, 31, 28, 2, -31 },
  { 301, 22, 31, 25, 2, -31 },
  { 387, 4, 11, 7, 2, -33 },
  { 393, 10, 45, 14, 3, -35 },
  { 450, 11, 45, 14, 1, -35 },
  { 512, 18, 19, 20, 1, -31 },
  { 555, 18, 23, 21, 2, -26 },
  { 607, 7, 13, 10, 1, -5 },
  { 619, 10, 5, 15, 2, -16 },
  { 626, 6, 6, 13, 3, -6 },
  { 631, 14, 34, 15, 0, -31 },
  { 691, 18, 31, 22, 2, -31 },
  { 761, 12, 31, 22, 3, -31 },
  { 808, 18, 31, 22, 2, -31 },
  { 878, 18, 31, 22, 2, -31 },
  { 948, 20, 31, 22, 1, -31 },
  { 1026, 18, 31, 22, 2, -31 },
  { 1096, 18, 31, 22, 2, -31 },
  { 1166, 18, 31, 22, 2, -31 },
  { 1236, 18, 31, 22, 2, -31 },
  { 1306, 18, 31, 22, 2, -31 },
  { 1376, 6, 24, 12, 3, -24 },
  { 1394, 8, 32, 11, 1, -24 },
  { 1426, 16, 21, 20, 1, -24 },
  { 1468, 16, 14, 22, 3, -21 },
  { 1496, 15, 21, 20, 3, -24 },
  { 1536, 17, 31, 19, 1, -31 },
  { 1602, 30, 41, 34, 2, -31 },
  { 1756, 25, 31, 26, 1, -31 },
  { 1853, 19, 31, 25, 3, -31 },
  { 1927, 22, 31, 25, 2, -31 },
  { 2013, 20, 31, 25, 3, -31 },
  { 2091, 17, 31, 22, 3, -31 },
  { 2157, 17, 31, 21, 3, -31 },
  { 2223, 22, 31, 26, 2, -31 },
  { 2309, 21, 31, 27, 3, -31 },
  { 2391, 6, 31, 12, 3, -31 },
  { 2415, 18, 31, 22, 1, -31 },
  { 2485, 21, 31, 24, 3, -31 },
  { 2567, 17, 31, 21, 3, -31 },
  { 2633, 28, 31, 33, 3, -31 },
  { 2742, 21, 31, 27, 3, -31 },
  { 2824, 22, 31, 27, 2, -31 },
  { 2910, 20, 31, 25, 3, -31 },
  { 2988, 22, 37, 27, 2, -31 },
  { 3090, 20, 31, 24, 3, -31 },
  { 3168, 20, 31, 24, 2, -31 },
  { 3246, 22, 31, 24, 1, -31 },
  { 3332, 21, 31, 25, 2, -31 },
  { 3414, 24, 31, 25, 1, -31 },
  { 3507, 31, 31, 33, 1, -31 },
  { 3628, 23, 31, 25, 1, -31 },
  { 3718, 23, 31, 24, 0, -31 },
  { 3808, 20, 31, 23, 2, -31 },
  { 3886, 8, 43, 11, 3, -36 },
  { 3929, 17, 34, 17, 0, -31 },
  { 4002, 8, 43, 11, 1, -36 },
  { 4045, 15, 16, 17, 1, -31 },
  { 4075, 17, 4, 18, 0, 0 },
  { 4084, 11, 7, 14, 1, -33 },
  { 4094, 17, 23, 21, 2, -23 },
  { 4143, 18, 33, 22, 2, -33 },
  { 4218, 17, 23, 20, 2, -23 },
  { 4267, 17, 33, 22, 2, -33 },
  { 4338, 18, 23, 21, 2, -23 },
  { 4390, 13, 33, 14, 1, -33 },
  { 4444, 18, 32, 22, 2, -23 },
  { 4516, 17, 33, 22, 2, -33 },
  { 4587, 6, 32, 11, 2, -32 },
  { 4611, 9, 41, 11, -1, -32 },
  { 4658, 19, 33, 21, 2, -33 },
  { 4737, 5, 33, 11, 3, -33 },
  { 4758, 28, 23, 33, 2, -23 },
  { 4839, 17, 23, 22, 2, -23 },
  { 4888, 18, 23, 22, 2, -23 },
  { 4940, 18, 32, 22, 2, -23 },
  { 5012, 17, 32, 22, 2, -23 },
  { 5080, 11, 23, 14, 2, -23 },
  { 5112, 17, 23, 20, 1, -23 },
  { 5161, 11, 29, 13, 1, -29 },
  { 5201, 17, 23, 22, 2, -23 },
  { 5250, 18, 23, 20, 1, -23 },
  { 5302, 26, 23, 28, 1, -23 },
  { 5377, 18, 23, 20, 1, -23 },
  { 5429, 19, 32, 19, 0, -23 },
  { 5505, 16, 23, 20, 2, -23 },
  { 5551, 11, 42, 13, 1, -34 },
  { 5609, 3, 37, 11, 4, -31 },
  { 5623, 11, 42, 13, 1, -34 },
  { 5681, 21, 9, 25, 2, -17 },
};

const GFXfont RobotoCondensed_SemiBold44pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_SemiBold44pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_SemiBold44pt7bGlyphs,
  0x20, 0x7E, 52
};

#endif // _ROBOTOCONDENSED_SEMIBOLD44PT7B_H_
