#ifndef _ROBOTOCONDENSED_SEMIBOLD66PT7B_H_
#define _ROBOTOCONDENSED_SEMIBOLD66PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-SemiBold.ttf
// Size: 66pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_SemiBold66pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xBF,
  0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F, 0xBF, 0xDF, 0xEF, 0xF7,
  0xFB, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC,
  0xFE, 0x7F, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x7F, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFD, 0xFC, 0x38, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xF8, 0x3F, 0xF8, 0x3E, 0xF8,
  0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8,
  0x3E, 0xF8, 0x3E, 0xF0, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x1F,
  0x00, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x3F, 0x0F, 0xC0,
  0x00, 0xF8, 0x3F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x00,
  0x3E, 0x0F, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x1F,
  0x87, 0xE0, 0x00, 0x7C, 0x1F, 0x80, 0x01, 0xF0, 0x7C, 0x03, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0xC0, 0x3E, 0x0F, 0xC0, 0x00, 0xF8, 0x3E, 0x00,
  0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7E, 0x0F, 0x80, 0x01,
  0xF8, 0x7E, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C,
  0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x83, 0xE0,
  0x00, 0x3E, 0x0F, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xE0, 0xF8, 0x00,
  0x1F, 0x87, 0xE0, 0x00, 0x7C, 0x1F, 0x80, 0x01, 0xF0, 0x7E, 0x00, 0x07,
  0xC1, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xF0,
  0x7C, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0xF8, 0x3E,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80,
  0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0x07, 0xFE, 0x7F, 0xF1, 0xFF, 0x03, 0xFE, 0x3F, 0xE0, 0x3F, 0xC7,
  0xF8, 0x07, 0xFC, 0xFF, 0x00, 0xFF, 0x9F, 0xE0, 0x1F, 0xF3, 0xFC, 0x01,
  0xFE, 0x7F, 0x80, 0x3F, 0xCF, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFE,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x01, 0xFE, 0xFF, 0x00,
  0x7F, 0xDF, 0xF0, 0x0F, 0xFB, 0xFE, 0x03, 0xFE, 0x3F, 0xF0, 0xFF, 0xC7,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x00, 0x7E,
  0x1F, 0x80, 0x70, 0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0xFC, 0x0F, 0x80, 0xF8,
  0x0F, 0xC0, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0xC1, 0xF0, 0x0F, 0xC0, 0xFC,
  0x3F, 0x00, 0xFC, 0x0F, 0xC3, 0xE0, 0x0F, 0xC0, 0xF8, 0x7E, 0x00, 0xFC,
  0x0F, 0x87, 0xC0, 0x07, 0xC1, 0xF8, 0xFC, 0x00, 0x7E, 0x1F, 0x8F, 0x80,
  0x07, 0xFF, 0xF1, 0xF8, 0x00, 0x3F, 0xFF, 0x1F, 0x00, 0x01, 0xFF, 0xE3,
  0xF0, 0x00, 0x0F, 0xFC, 0x3E, 0x00, 0x00, 0x7F, 0x87, 0xC0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E,
  0x0F, 0xE0, 0x00, 0x03, 0xE3, 0xFF, 0x80, 0x00, 0x7C, 0x7F, 0xFC, 0x00,
  0x0F, 0xCF, 0xFF, 0xE0, 0x00, 0xF8, 0xFF, 0xFE, 0x00, 0x1F, 0x9F, 0xC7,
  0xF0, 0x01, 0xF1, 0xF8, 0x3F, 0x00, 0x3F, 0x1F, 0x83, 0xF0, 0x03, 0xE1,
  0xF0, 0x1F, 0x00, 0x7E, 0x1F, 0x01, 0xF0, 0x07, 0xC1, 0xF0, 0x1F, 0x00,
  0xFC, 0x1F, 0x01, 0xF0, 0x0F, 0x81, 0xF0, 0x1F, 0x01, 0xF8, 0x1F, 0x83,
  0xF0, 0x1F, 0x01, 0xF8, 0x3F, 0x01, 0xF0, 0x1F, 0x83, 0xF0, 0x06, 0x00,
  0xFE, 0x7E, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x1F,
  0xE0, 0xFF, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x01, 0xFE, 0x07, 0xF0, 0x00,
  0x7F, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x07, 0xF0, 0x1F, 0xC0,
  0x01, 0xFE, 0x07, 0xF0, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x1F, 0xF1, 0xFE,
  0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xF0, 0x3F, 0x81, 0xFF, 0xFC, 0x0F, 0xE0, 0xFF, 0xFF, 0x83, 0xF8,
  0x3F, 0xDF, 0xF0, 0xFE, 0x1F, 0xE7, 0xFE, 0x3F, 0x8F, 0xF8, 0xFF, 0x8F,
  0xE3, 0xFC, 0x1F, 0xF7, 0xF8, 0xFF, 0x07, 0xFF, 0xFC, 0x3F, 0xC0, 0xFF,
  0xFF, 0x0F, 0xF0, 0x1F, 0xFF, 0xC3, 0xFC, 0x07, 0xFF, 0xF0, 0xFF, 0x00,
  0xFF, 0xF8, 0x3F, 0xC0, 0x1F, 0xFE, 0x0F, 0xF8, 0x03, 0xFF, 0x03, 0xFE,
  0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xF8, 0x7F, 0xFE, 0x07,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0x9F, 0xF8, 0x07, 0xFF, 0x83,
  0xFE, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFC, 0x00, 0x04, 0x00,
  0x18, 0x00, 0x78, 0x01, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x7F, 0x00, 0xFC, 0x01, 0xF8, 0x07,
  0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x1E, 0x00,
  0x18, 0x00, 0x10, 0x40, 0x00, 0x70, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x03,
  0xF8, 0x03, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01,
  0xFE, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x01,
  0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F,
  0x80, 0x3F, 0x80, 0x7F, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8,
  0x00, 0x70, 0x00, 0x40, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x02, 0x01, 0xF8, 0x00, 0x78, 0x0F, 0x80,
  0xE7, 0xF0, 0xF8, 0x7E, 0x7F, 0xCF, 0x9F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x1F, 0xBF, 0x80, 0x03, 0xF9, 0xF8, 0x00, 0x7F, 0x0F, 0xC0, 0x07, 0xE0,
  0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x00, 0x78, 0x03, 0xE0,
  0x03, 0x80, 0x1C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1,
  0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xF8, 0x7F, 0x0F, 0xE3, 0xF8,
  0x7F, 0x1F, 0xC3, 0xF8, 0xFE, 0x07, 0x80, 0x20, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x04,
  0x0F, 0xC7, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFE, 0x3F, 0x83, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xC1, 0xFF, 0x8F, 0xFC, 0x3F, 0xE0, 0x7F, 0x87, 0xF8, 0x0F, 0xF1,
  0xFF, 0x00, 0xFF, 0x3F, 0xC0, 0x1F, 0xE7, 0xF8, 0x03, 0xFC, 0xFF, 0x00,
  0x7F, 0x9F, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x03, 0xFD, 0xFE, 0x00, 0xFF,
  0xBF, 0xC0, 0x1F, 0xE7, 0xF8, 0x03, 0xFC, 0xFF, 0x00, 0x7F, 0x9F, 0xF0,
  0x0F, 0xF1, 0xFE, 0x03, 0xFC, 0x3F, 0xE0, 0xFF, 0x87, 0xFE, 0x3F, 0xF0,
  0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x01, 0xF0, 0x01, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0xC7,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF1, 0xFF, 0xF0, 0x7F, 0xE0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x07,
  0xFE, 0x1F, 0xF8, 0x3F, 0xE0, 0x7F, 0xE3, 0xFE, 0x01, 0xFF, 0x1F, 0xF0,
  0x0F, 0xF8, 0xFF, 0x00, 0x3F, 0xC7, 0xF8, 0x01, 0xFE, 0x3F, 0xC0, 0x0F,
  0xF3, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0x0F, 0xFC, 0x7F, 0xE0, 0x7F, 0xC7,
  0xFC, 0x03, 0xFE, 0x7F, 0x80, 0x3F, 0xE7, 0xF8, 0x01, 0xFE, 0x7F, 0x80,
  0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFE,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80,
  0x1F, 0xF7, 0xF8, 0x01, 0xFE, 0x7F, 0x80, 0x1F, 0xE7, 0xFC, 0x03, 0xFE,
  0x7F, 0xE0, 0x7F, 0xE3, 0xFF, 0x0F, 0xFC, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01,
  0xFB, 0xFE, 0x00, 0x1F, 0xDF, 0xF0, 0x00, 0xFE, 0xFF, 0x80, 0x0F, 0xE7,
  0xFC, 0x00, 0x7F, 0x3F, 0xE0, 0x07, 0xF1, 0xFF, 0x00, 0x3F, 0x8F, 0xF8,
  0x03, 0xF8, 0x7F, 0xC0, 0x1F, 0xC3, 0xFE, 0x01, 0xFC, 0x1F, 0xF0, 0x0F,
  0xE0, 0xFF, 0x80, 0xFE, 0x07, 0xFC, 0x07, 0xF0, 0x3F, 0xE0, 0x7F, 0x81,
  0xFF, 0x03, 0xF8, 0x0F, 0xF8, 0x3F, 0xC0, 0x7F, 0xC1, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xCF, 0xE0, 0x07, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xF1, 0xFE, 0x07, 0xFE, 0x07, 0x80, 0x7F, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xBF, 0xC0, 0x0F,
  0xF7, 0xF8, 0x03, 0xFE, 0xFF, 0x00, 0x7F, 0xDF, 0xF0, 0x0F, 0xF1, 0xFF,
  0x03, 0xFE, 0x3F, 0xF0, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x87, 0xF0, 0x07, 0xF9, 0xFF, 0xC0, 0x7F, 0xBF, 0xFE, 0x07,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFF, 0xC7, 0xFF, 0x0F, 0xFC, 0xFF, 0xC0, 0x7F, 0xEF, 0xFC, 0x03, 0xFE,
  0xFF, 0x80, 0x3F, 0xEF, 0xF8, 0x01, 0xFE, 0xFF, 0x80, 0x1F, 0xEF, 0xF8,
  0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xF7, 0xF8, 0x01, 0xFF, 0x7F, 0x80, 0x1F,
  0xF7, 0xF8, 0x01, 0xFF, 0x7F, 0x80, 0x1F, 0xE7, 0xF8, 0x01, 0xFE, 0x7F,
  0xC0, 0x1F, 0xE3, 0xFC, 0x03, 0xFE, 0x3F, 0xC0, 0x3F, 0xE3, 0xFE, 0x07,
  0xFC, 0x1F, 0xF8, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xE1, 0xFF, 0x8F, 0xFC, 0x3F, 0xE0, 0xFF, 0x8F, 0xF8, 0x0F, 0xF9,
  0xFF, 0x01, 0xFF, 0x3F, 0xE0, 0x1F, 0xE7, 0xF8, 0x03, 0xFC, 0xFF, 0x00,
  0x7F, 0x9F, 0xE0, 0x0F, 0xF3, 0xFE, 0x01, 0xFE, 0x7F, 0xC0, 0x7F, 0xC7,
  0xF8, 0x0F, 0xF0, 0xFF, 0x81, 0xFE, 0x0F, 0xF8, 0x7F, 0x81, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x07,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x1F, 0xF0, 0x7F,
  0xC3, 0xFC, 0x07, 0xF8, 0xFF, 0x80, 0xFF, 0x9F, 0xE0, 0x0F, 0xF3, 0xFC,
  0x01, 0xFE, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xDF, 0xE0,
  0x0F, 0xFB, 0xFE, 0x03, 0xFE, 0x7F, 0xC0, 0x7F, 0xCF, 0xFE, 0x3F, 0xF8,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC1,
  0xFF, 0x8F, 0xF8, 0x3F, 0xE0, 0xFF, 0x8F, 0xF8, 0x0F, 0xF1, 0xFE, 0x01,
  0xFE, 0x3F, 0xC0, 0x3F, 0xEF, 0xF8, 0x03, 0xFD, 0xFE, 0x00, 0x7F, 0xBF,
  0xC0, 0x0F, 0xF7, 0xF8, 0x01, 0xFE, 0xFF, 0x00, 0x3F, 0xDF, 0xE0, 0x07,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0x00, 0x7F, 0xDF, 0xE0, 0x0F, 0xFB, 0xFE, 0x03, 0xFF, 0x7F, 0xE0, 0xFF,
  0xE7, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0x7F, 0x80, 0xFF, 0xCF, 0xF0, 0x07, 0xE1, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF,
  0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC7, 0xFB, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFD, 0xFE, 0x3F, 0x83, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x10, 0x3F, 0x1F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF7, 0xF8, 0xFE, 0x0E, 0x00, 0x02, 0x03, 0xF8, 0xFF, 0x9F, 0xF3, 0xFE,
  0x7F, 0xCF, 0xF9, 0xFF, 0x1F, 0xC0, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x3F, 0xC7, 0xF8,
  0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF1, 0xFC,
  0x3F, 0x8F, 0xF1, 0xFC, 0x7F, 0x0F, 0xE0, 0x78, 0x06, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x1F,
  0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xE0, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x1F,
  0xFF, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x1F,
  0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0xE0, 0x01, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xF8, 0xFF, 0xC7, 0xFE, 0xFF, 0xC1, 0xFF, 0x7F, 0xC0, 0x7F, 0xBF,
  0xE0, 0x3F, 0xDF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x07, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0xFE, 0x00,
  0x00, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x1F,
  0xC0, 0x0F, 0x83, 0xF0, 0x03, 0xFF, 0x80, 0x7C, 0x1F, 0x00, 0x3F, 0xFE,
  0x03, 0xF1, 0xF8, 0x03, 0xFF, 0xFC, 0x0F, 0x8F, 0xC0, 0x3F, 0xFF, 0xE0,
  0x7C, 0x7C, 0x01, 0xFC, 0x7E, 0x03, 0xE7, 0xE0, 0x1F, 0xC1, 0xF0, 0x1F,
  0x3F, 0x01, 0xFC, 0x1F, 0x80, 0xF9, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xEF,
  0x80, 0x7E, 0x07, 0xE0, 0x1F, 0x7C, 0x07, 0xE0, 0x3F, 0x00, 0xFF, 0xE0,
  0x3F, 0x01, 0xF8, 0x07, 0xFF, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0xF8, 0x1F,
  0xC0, 0x7E, 0x01, 0xFF, 0xC0, 0xFC, 0x03, 0xF0, 0x0F, 0xFE, 0x07, 0xE0,
  0x1F, 0x80, 0x7F, 0xF0, 0x3F, 0x00, 0xFC, 0x03, 0xFF, 0x81, 0xF8, 0x07,
  0xE0, 0x3F, 0xFC, 0x0F, 0xC0, 0x3E, 0x01, 0xF7, 0xE0, 0x7E, 0x01, 0xF0,
  0x0F, 0xBF, 0x03, 0xF0, 0x1F, 0x80, 0x7D, 0xF8, 0x1F, 0x80, 0xFC, 0x03,
  0xEF, 0xC0, 0xFC, 0x07, 0xE0, 0x1F, 0x7E, 0x07, 0xE0, 0x3F, 0x01, 0xF3,
  0xF0, 0x3F, 0x83, 0xF8, 0x0F, 0x9F, 0x81, 0xFC, 0x1F, 0xC0, 0xFC, 0xFC,
  0x0F, 0xF1, 0xFF, 0x07, 0xC3, 0xE0, 0x3F, 0xFF, 0xF8, 0xFE, 0x1F, 0x81,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFC, 0x07, 0xFF, 0x3F, 0xFE, 0x07, 0xE0, 0x3F,
  0xF0, 0xFF, 0xE0, 0x1F, 0x00, 0x7F, 0x03, 0xFE, 0x00, 0xFC, 0x00, 0xE0,
  0x07, 0x80, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x18, 0x00, 0x00,
  0x3F, 0xFC, 0x0F, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0x1F,
  0xEF, 0xF0, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x07, 0xF9, 0xFC, 0x00,
  0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0x1F, 0xE3,
  0xFC, 0x00, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00,
  0x7F, 0x83, 0xFC, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x7F,
  0x80, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0xFF,
  0x80, 0x7F, 0x80, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x1F, 0xE0,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF,
  0xFC, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0xFF, 0x87, 0xFC,
  0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x3F, 0xE1, 0xFE, 0x00, 0x00, 0xFF,
  0x9F, 0xF0, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0x3F, 0xE7, 0xFC, 0x00,
  0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xFF, 0x3F, 0xE0, 0x1F, 0xFC, 0xFF, 0x80, 0x1F, 0xF3, 0xFE, 0x00,
  0x7F, 0xCF, 0xF8, 0x00, 0xFF, 0xBF, 0xE0, 0x03, 0xFE, 0xFF, 0x80, 0x0F,
  0xFB, 0xFE, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0xFF, 0xBF, 0xE0, 0x03, 0xFC,
  0xFF, 0x80, 0x0F, 0xF3, 0xFE, 0x00, 0x7F, 0xCF, 0xF8, 0x03, 0xFE, 0x3F,
  0xE0, 0x7F, 0xF8, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xFF, 0x8F, 0xF8, 0x03, 0xFF, 0x3F, 0xE0, 0x07, 0xFC, 0xFF, 0x80, 0x0F,
  0xFB, 0xFE, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x7F, 0xBF, 0xE0, 0x01, 0xFE,
  0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xBF,
  0xE0, 0x01, 0xFE, 0xFF, 0x80, 0x0F, 0xFB, 0xFE, 0x00, 0x3F, 0xEF, 0xF8,
  0x01, 0xFF, 0xBF, 0xE0, 0x1F, 0xFC, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0x7F, 0xFC, 0x1F, 0xF8, 0x07, 0xFE, 0x3F, 0xE0, 0x03,
  0xFE, 0x3F, 0xE0, 0x01, 0xFE, 0x7F, 0xC0, 0x01, 0xFF, 0x7F, 0xC0, 0x01,
  0xFF, 0x7F, 0x80, 0x01, 0xFF, 0x7F, 0x80, 0x00, 0xFF, 0x7F, 0x80, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x7F, 0x80, 0x00, 0xFF, 0x7F, 0x80, 0x01, 0xFF, 0x7F, 0xC0, 0x01,
  0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0x3F, 0xC0, 0x01, 0xFE, 0x3F, 0xE0, 0x03,
  0xFE, 0x1F, 0xF0, 0x07, 0xFE, 0x1F, 0xFE, 0x3F, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xFC, 0x3F, 0xE0, 0x7F, 0xF8, 0xFF, 0x80, 0x3F, 0xF3, 0xFE,
  0x00, 0x7F, 0xCF, 0xF8, 0x00, 0xFF, 0x3F, 0xE0, 0x03, 0xFE, 0xFF, 0x80,
  0x07, 0xFB, 0xFE, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x7F,
  0xBF, 0xE0, 0x03, 0xFE, 0xFF, 0x80, 0x0F, 0xF3, 0xFE, 0x00, 0x7F, 0xCF,
  0xF8, 0x03, 0xFF, 0x3F, 0xE0, 0x7F, 0xF8, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF7, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xE3, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xFE, 0x3F, 0xF0,
  0x03, 0xFE, 0x3F, 0xE0, 0x01, 0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0x7F, 0xC0,
  0x00, 0xFF, 0x7F, 0xC0, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0xFF, 0x7F, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0x7F, 0x80,
  0x00, 0xFF, 0x7F, 0x80, 0x00, 0xFF, 0x7F, 0xC0, 0x00, 0xFF, 0x7F, 0xC0,
  0x00, 0xFF, 0x7F, 0xE0, 0x00, 0xFF, 0x3F, 0xE0, 0x00, 0xFF, 0x3F, 0xF0,
  0x00, 0xFF, 0x1F, 0xF8, 0x03, 0xFF, 0x1F, 0xFF, 0xBF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFD, 0xFF, 0x03,
  0xFE, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x78, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0x7F, 0xC0, 0x03, 0xFF, 0x3F,
  0xE0, 0x03, 0xFF, 0x1F, 0xF0, 0x03, 0xFF, 0x8F, 0xF8, 0x01, 0xFF, 0x87,
  0xFC, 0x01, 0xFF, 0x83, 0xFE, 0x00, 0xFF, 0xC1, 0xFF, 0x00, 0xFF, 0xC0,
  0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xC0, 0x7F, 0xE0, 0x3F, 0xE0, 0x7F, 0xE0,
  0x1F, 0xF0, 0x3F, 0xE0, 0x0F, 0xF8, 0x3F, 0xF0, 0x07, 0xFC, 0x3F, 0xF0,
  0x03, 0xFE, 0x1F, 0xF0, 0x01, 0xFF, 0x1F, 0xF8, 0x00, 0xFF, 0x8F, 0xF8,
  0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x1F, 0xF7, 0xFC,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0x7F, 0xC0, 0x07, 0xFF, 0x3F, 0xF0, 0x03, 0xFF, 0x8F, 0xFC, 0x01, 0xFF,
  0x87, 0xFE, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0x3F,
  0xE0, 0x3F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x07, 0xFE, 0x07,
  0xFC, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0xC1, 0xFF, 0x00, 0x3F, 0xE0,
  0xFF, 0x80, 0x1F, 0xF8, 0x7F, 0xC0, 0x07, 0xFE, 0x3F, 0xE0, 0x03, 0xFF,
  0x1F, 0xF0, 0x00, 0xFF, 0xCF, 0xF8, 0x00, 0x7F, 0xE7, 0xFC, 0x00, 0x1F,
  0xFB, 0xFE, 0x00, 0x0F, 0xFC, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xBF, 0xFF, 0xDF, 0xC0, 0x0F, 0xEF,
  0xFF, 0xF7, 0xF0, 0x03, 0xFB, 0xFF, 0xFD, 0xFE, 0x01, 0xFC, 0xFF, 0xFF,
  0x7F, 0x80, 0x7F, 0x3F, 0xFF, 0xCF, 0xE0, 0x1F, 0xCF, 0xFF, 0xF3, 0xFC,
  0x0F, 0xE3, 0xFF, 0xFC, 0xFF, 0x03, 0xF8, 0xFF, 0xFF, 0x1F, 0xC0, 0xFE,
  0x3F, 0xFF, 0xC7, 0xF8, 0x7F, 0x8F, 0xFF, 0xF1, 0xFE, 0x1F, 0xC3, 0xFF,
  0xFC, 0x3F, 0x87, 0xF0, 0xFF, 0xFF, 0x0F, 0xE1, 0xFC, 0x3F, 0xFF, 0xC3,
  0xFC, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0x3F, 0x87, 0xFF, 0xFC, 0x1F, 0xCF,
  0xE1, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0xC0, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xC1, 0xFF, 0xFF,
  0x03, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0xF8, 0x1F, 0xFF, 0xF0, 0x1F,
  0xFE, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xC0,
  0x7F, 0xFF, 0xC0, 0x3F, 0xF0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFC, 0x07, 0xFF,
  0xFC, 0x01, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0xFF, 0xC0,
  0x1F, 0xE0, 0x1F, 0xFF, 0xF0, 0x03, 0xF0, 0x07, 0xFC, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x7F, 0x80, 0xFF, 0xFF, 0x7F, 0x80, 0xFF, 0xFF, 0x3F, 0xC0,
  0xFF, 0xFF, 0x3F, 0xC0, 0xFF, 0xFF, 0x1F, 0xE0, 0xFF, 0xFF, 0x1F, 0xE0,
  0xFF, 0xFF, 0x0F, 0xF0, 0xFF, 0xFF, 0x0F, 0xF0, 0xFF, 0xFF, 0x07, 0xF8,
  0xFF, 0xFF, 0x07, 0xF8, 0xFF, 0xFF, 0x03, 0xFC, 0xFF, 0xFF, 0x03, 0xFC,
  0xFF, 0xFF, 0x01, 0xFE, 0xFF, 0xFF, 0x01, 0xFE, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xF8, 0x1F, 0xF8, 0x07, 0xFE, 0x1F, 0xF8, 0x01, 0xFF, 0x0F, 0xF8,
  0x00, 0x7F, 0xC7, 0xF8, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x0F, 0xF3, 0xFE,
  0x00, 0x07, 0xFD, 0xFE, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xBF, 0xC0, 0x00,
  0x3F, 0xDF, 0xE0, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x1F, 0xF7, 0xFC, 0x00,
  0x0F, 0xFB, 0xFE, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x07, 0xFC, 0x7F, 0xE0,
  0x07, 0xFE, 0x1F, 0xF8, 0x07, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xC0, 0x1F, 0xFC, 0xFF,
  0x80, 0x0F, 0xFD, 0xFF, 0x00, 0x1F, 0xFB, 0xFE, 0x00, 0x1F, 0xF7, 0xFC,
  0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xEF, 0xF8, 0x00,
  0x7F, 0xDF, 0xF0, 0x01, 0xFF, 0xBF, 0xE0, 0x0F, 0xFE, 0x7F, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xF8, 0x07, 0xFE, 0x0F, 0xFC, 0x00,
  0xFF, 0x83, 0xFE, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x07, 0xFC, 0x7F, 0xC0,
  0x00, 0xFF, 0x1F, 0xF0, 0x00, 0x3F, 0xE7, 0xF8, 0x00, 0x0F, 0xFB, 0xFE,
  0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0x7F, 0xBF, 0xE0, 0x00, 0x1F, 0xEF,
  0xF8, 0x00, 0x07, 0xFB, 0xFE, 0x00, 0x01, 0xFE, 0xFF, 0x80, 0x00, 0x7F,
  0xBF, 0xE0, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x07, 0xFB, 0xFE, 0x00, 0x01,
  0xFE, 0xFF, 0x80, 0x00, 0x7F, 0xBF, 0xE0, 0x00, 0x1F, 0xEF, 0xF8, 0x00,
  0x07, 0xFB, 0xFE, 0x00, 0x01, 0xFE, 0xFF, 0x80, 0x00, 0x7F, 0xBF, 0xE0,
  0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x07, 0xFB, 0xFE, 0x00, 0x01, 0xFE, 0xFF,
  0x80, 0x00, 0x7F, 0xBF, 0xE0, 0x00, 0x3F, 0xE7, 0xF8, 0x00, 0x0F, 0xF9,
  0xFF, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0xFF, 0x1F, 0xF0, 0x00, 0x7F,
  0xC3, 0xFE, 0x00, 0x1F, 0xF0, 0xFF, 0xC0, 0x0F, 0xF8, 0x1F, 0xF8, 0x07,
  0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x20, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xC0, 0x3F, 0xF8,
  0xFF, 0x80, 0x1F, 0xF9, 0xFF, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x3F, 0xE7,
  0xFC, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x7F, 0x9F, 0xF0, 0x00, 0xFF, 0x3F,
  0xE0, 0x01, 0xFE, 0x7F, 0xC0, 0x03, 0xFC, 0xFF, 0x80, 0x07, 0xF9, 0xFF,
  0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0xFF, 0xCF, 0xF8,
  0x01, 0xFF, 0x1F, 0xF0, 0x0F, 0xFE, 0x3F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xF0, 0x3F,
  0xE0, 0x3F, 0xE0, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF, 0xC0, 0xFF, 0x80, 0xFF,
  0x81, 0xFF, 0x01, 0xFF, 0x03, 0xFE, 0x01, 0xFF, 0x07, 0xFC, 0x03, 0xFE,
  0x0F, 0xF8, 0x07, 0xFE, 0x1F, 0xF0, 0x07, 0xFC, 0x3F, 0xE0, 0x0F, 0xF8,
  0x7F, 0xC0, 0x0F, 0xF8, 0xFF, 0x80, 0x1F, 0xF1, 0xFF, 0x00, 0x3F, 0xF3,
  0xFE, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x7F, 0xEF, 0xF8, 0x00, 0x7F, 0xDF,
  0xF0, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFE, 0x3F, 0xFC, 0x3F, 0xF0, 0x1F, 0xF8, 0x7F, 0xC0, 0x1F, 0xF8, 0xFF,
  0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x3F, 0xCF, 0xF8,
  0x00, 0x7F, 0x9F, 0xF0, 0x00, 0xFF, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFB,
  0xFC, 0x00, 0x1F, 0xF7, 0xF8, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x7F, 0xDF,
  0xF0, 0x00, 0xFF, 0x3F, 0xF0, 0x03, 0xFE, 0x3F, 0xF0, 0x0F, 0xFC, 0x7F,
  0xFC, 0x7F, 0xF8, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0xFF, 0x9F, 0xF8, 0x07, 0xFE, 0x7F, 0xFC, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x7F,
  0xC0, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x3F,
  0xE7, 0xFE, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x7F, 0xC3, 0xFE, 0x00,
  0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x0F, 0xF8, 0x1F,
  0xF0, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x0F, 0xF8, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0x1F, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x07,
  0xFC, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x03, 0xFC, 0x03, 0xFC,
  0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x7F, 0x80, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x00,
  0xFF, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xF0,
  0x00, 0x0F, 0xF9, 0xFE, 0x00, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x07, 0xF9,
  0xFE, 0x00, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xFF, 0xF8, 0x01,
  0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x3F,
  0xE0, 0x07, 0xF9, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xE7, 0xF8, 0x03, 0xFF,
  0x00, 0x7F, 0x9F, 0xE0, 0x0F, 0xFC, 0x03, 0xFE, 0x7F, 0xC0, 0x3F, 0xF0,
  0x0F, 0xF9, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xC3, 0xFC, 0x07, 0xFF, 0x80,
  0xFF, 0x0F, 0xF0, 0x1F, 0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0x7F, 0xF8, 0x0F,
  0xF0, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xC3, 0xFC, 0x07, 0xFF, 0x81, 0xFF,
  0x0F, 0xF8, 0x3F, 0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0xFC, 0x1F, 0xE0,
  0x7F, 0x83, 0xFF, 0xF0, 0x7F, 0x81, 0xFE, 0x0F, 0xFF, 0xC1, 0xFE, 0x07,
  0xF8, 0x3F, 0x3F, 0x07, 0xF8, 0x1F, 0xE1, 0xFC, 0xFE, 0x3F, 0xC0, 0x3F,
  0xC7, 0xF3, 0xF8, 0xFF, 0x00, 0xFF, 0x1F, 0xCF, 0xE3, 0xFC, 0x03, 0xFC,
  0x7F, 0x3F, 0x8F, 0xF0, 0x0F, 0xF1, 0xF8, 0x7E, 0x3F, 0xC0, 0x3F, 0xCF,
  0xE1, 0xFC, 0xFF, 0x00, 0x7F, 0x3F, 0x87, 0xF3, 0xF8, 0x01, 0xFE, 0xFE,
  0x1F, 0xDF, 0xE0, 0x07, 0xFB, 0xF8, 0x7F, 0x7F, 0x80, 0x1F, 0xEF, 0xC0,
  0xFD, 0xFE, 0x00, 0x7F, 0xFF, 0x03, 0xF7, 0xF8, 0x01, 0xFF, 0xFC, 0x0F,
  0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0xFF,
  0xFC, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x07, 0xFF,
  0xC0, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x7F, 0xF8,
  0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80,
  0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x00,
  0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xDF, 0xF8, 0x00,
  0x3F, 0xF3, 0xFF, 0x00, 0x0F, 0xF8, 0xFF, 0xC0, 0x07, 0xFE, 0x1F, 0xF0,
  0x01, 0xFF, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x3F, 0xE0, 0x3F,
  0xF0, 0x1F, 0xF8, 0x07, 0xFC, 0x07, 0xFC, 0x01, 0xFF, 0x81, 0xFF, 0x00,
  0x3F, 0xE0, 0xFF, 0x80, 0x0F, 0xFC, 0x3F, 0xE0, 0x01, 0xFF, 0x1F, 0xF0,
  0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x03, 0xFE, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0xFF, 0x3F,
  0xE0, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x0F, 0xF8,
  0x3F, 0xE0, 0x03, 0xFE, 0x0F, 0xF8, 0x01, 0xFF, 0x03, 0xFF, 0x00, 0x7F,
  0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF8, 0x0F, 0xF8, 0x03, 0xFE, 0x07,
  0xFE, 0x00, 0xFF, 0xC1, 0xFF, 0x00, 0x1F, 0xF0, 0xFF, 0xC0, 0x07, 0xFE,
  0x3F, 0xE0, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x3F, 0xF7, 0xFC, 0x00, 0x0F,
  0xFC, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xE7, 0xFC, 0x00,
  0x0F, 0xF9, 0xFF, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x01, 0xFF, 0x0F, 0xF8,
  0x00, 0xFF, 0xC3, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x0F, 0xF8, 0x1F,
  0xF0, 0x07, 0xFC, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0x80,
  0x1F, 0xE0, 0x3F, 0xE0, 0x07, 0xF8, 0x0F, 0xF8, 0x01, 0xFF, 0x03, 0xFC,
  0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x01, 0xFE, 0x1F,
  0xE0, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x03, 0xFC,
  0xFF, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x3F, 0x7E, 0x00, 0xFD,
  0xF8, 0x03, 0xF3, 0xF0, 0x1F, 0xCF, 0xC0, 0x7E, 0x3F, 0x01, 0xF8, 0x7E,
  0x0F, 0xE1, 0xF8, 0x3F, 0x07, 0xF0, 0xFC, 0x0F, 0xC7, 0xF0, 0x3F, 0x1F,
  0xC0, 0xFE, 0x7E, 0x03, 0xFB, 0xF8, 0x07, 0xEF, 0xE0, 0x1F, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xC0, 0x7F,
  0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xF8, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xF1, 0xFF, 0x07, 0xFC, 0x7F, 0x80, 0xFF, 0x3F, 0xE0,
  0x3F, 0xCF, 0xF8, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x7F, 0xF0,
  0xFF, 0x9F, 0xF0, 0x3F, 0xEF, 0xF8, 0x0F, 0xFB, 0xFC, 0x03, 0xFE, 0xFF,
  0x00, 0xFF, 0xBF, 0xC0, 0x3F, 0xEF, 0xF0, 0x0F, 0xFB, 0xFC, 0x03, 0xFE,
  0xFF, 0x80, 0xFF, 0xBF, 0xE0, 0xFF, 0xEF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xDF, 0xE1, 0xFF, 0xF7, 0xF8, 0x1F,
  0xF1, 0xFF, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x78, 0x03, 0xFC, 0xFF, 0xC0, 0xFF, 0x7F,
  0xFC, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xBF, 0xF8, 0xFF, 0xEF, 0xF8, 0x0F, 0xFB, 0xFC, 0x01, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8,
  0x0F, 0xFB, 0xFF, 0x87, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xF3, 0xFB, 0xFF, 0xF8, 0xFE, 0x7F, 0xFC, 0x3F, 0x8F, 0xFC,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xF8, 0xFF, 0xC3, 0xFE, 0x3F, 0xE0, 0x7F, 0xDF, 0xF0, 0x0F,
  0xF7, 0xF8, 0x03, 0xFD, 0xFE, 0x00, 0xFF, 0x7F, 0x80, 0x1F, 0xDF, 0xE0,
  0x07, 0xF7, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x1F, 0xDF, 0xE0, 0x07, 0xF7, 0xF8, 0x03, 0xFD, 0xFF, 0x00, 0xFF, 0x3F,
  0xC0, 0x7F, 0xCF, 0xFC, 0x3F, 0xE1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x1F, 0x07, 0xF8, 0x0F, 0xF8, 0xFF, 0x07,
  0xFF, 0xDF, 0xE1, 0xFF, 0xFB, 0xFC, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFE, 0x7F, 0xE1, 0xFF, 0xDF, 0xF8, 0x1F, 0xFB, 0xFE,
  0x01, 0xFF, 0x7F, 0xC0, 0x1F, 0xEF, 0xF0, 0x03, 0xFD, 0xFE, 0x00, 0x7F,
  0xBF, 0xC0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0,
  0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x01, 0xFE, 0xFF, 0x00,
  0x3F, 0xDF, 0xE0, 0x07, 0xFB, 0xFC, 0x00, 0xFF, 0x7F, 0x80, 0x1F, 0xEF,
  0xF8, 0x07, 0xFD, 0xFF, 0x81, 0xFF, 0x9F, 0xF8, 0x7F, 0xF3, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF8, 0x7F, 0xFE, 0xFF, 0x07,
  0xFF, 0xDF, 0xE0, 0x3F, 0xE1, 0xFC, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0xFF, 0x87, 0xFE,
  0x7F, 0xC0, 0x7F, 0x9F, 0xE0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x21, 0xFF, 0x00, 0x18, 0x7F, 0xC0, 0x0F, 0x1F, 0xFE, 0x0F, 0xE3,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xF0,
  0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x7F, 0xF1, 0x07, 0xFC, 0x00, 0x7F, 0xC0,
  0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8,
  0x00, 0x7F, 0x80, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00,
  0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80,
  0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8,
  0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F,
  0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0xF8, 0xFF, 0x07, 0xFF, 0xCF, 0xF0, 0xFF, 0xFE, 0xFF, 0x0F, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0x8F, 0xFF, 0x3F,
  0xE0, 0x3F, 0xF7, 0xFC, 0x01, 0xFF, 0x7F, 0xC0, 0x1F, 0xF7, 0xF8, 0x01,
  0xFF, 0x7F, 0x80, 0x1F, 0xF7, 0xF8, 0x01, 0xFF, 0x7F, 0x80, 0x1F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF,
  0x7F, 0x80, 0x1F, 0xF7, 0xF8, 0x01, 0xFF, 0x7F, 0x80, 0x1F, 0xF7, 0xF8,
  0x01, 0xFF, 0x7F, 0xC0, 0x1F, 0xF7, 0xFC, 0x01, 0xFF, 0x3F, 0xE0, 0x3F,
  0xF3, 0xFF, 0x8F, 0xFF, 0x3F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xDF, 0xF0, 0x1F, 0xF9,
  0xFF, 0x00, 0x3C, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x40, 0x03, 0xFE, 0x06, 0x00, 0x3F, 0xE0, 0xF8, 0x07, 0xFE, 0x0F, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x3E, 0x03,
  0xFE, 0x3F, 0xE0, 0xFF, 0xBF, 0xFC, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xBF, 0xFC, 0x7F, 0xEF, 0xFC,
  0x0F, 0xFB, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xF0, 0x3C, 0x3F, 0xBF, 0xDF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFE, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFD, 0xFE,
  0xFF, 0x7F, 0xBF, 0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F, 0xBF,
  0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F, 0xBF, 0xDF, 0xEF, 0xF7,
  0xFB, 0xFD, 0xFE, 0xFF, 0x7F, 0xBF, 0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE,
  0xFF, 0x00, 0x00, 0xF0, 0x0F, 0xE0, 0x3F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F,
  0xF0, 0x3F, 0xC0, 0xFE, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x1F,
  0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0x3F, 0xF8, 0xFF,
  0xC1, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x07, 0xFE, 0xFF, 0x01, 0xFF,
  0x9F, 0xE0, 0x3F, 0xE3, 0xFC, 0x0F, 0xFC, 0x7F, 0x83, 0xFF, 0x0F, 0xF0,
  0x7F, 0xC1, 0xFE, 0x1F, 0xF0, 0x3F, 0xC7, 0xFE, 0x07, 0xF8, 0xFF, 0x80,
  0xFF, 0x3F, 0xE0, 0x1F, 0xEF, 0xF8, 0x03, 0xFD, 0xFF, 0x00, 0x7F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFD, 0xFF, 0x01, 0xFF, 0x3F, 0xE0, 0x3F,
  0xC3, 0xFE, 0x07, 0xF8, 0x7F, 0xC0, 0xFF, 0x07, 0xFC, 0x1F, 0xE0, 0xFF,
  0x83, 0xFC, 0x0F, 0xF8, 0x7F, 0x81, 0xFF, 0x0F, 0xF0, 0x1F, 0xF1, 0xFE,
  0x03, 0xFF, 0x3F, 0xC0, 0x3F, 0xE7, 0xF8, 0x07, 0xFE, 0xFF, 0x00, 0x7F,
  0xDF, 0xE0, 0x0F, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x3F,
  0x87, 0xFC, 0x07, 0xFE, 0x0F, 0xE7, 0xFF, 0xC3, 0xFF, 0xC3, 0xFF, 0xFF,
  0xF3, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0x8F, 0xFF, 0xC7, 0xFE,
  0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xBF, 0xC0, 0x3F, 0xE0, 0x1F, 0xEF, 0xF0,
  0x0F, 0xF8, 0x07, 0xFB, 0xFC, 0x03, 0xFE, 0x01, 0xFE, 0xFF, 0x00, 0xFF,
  0x80, 0x7F, 0xBF, 0xC0, 0x3F, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xF8, 0x07,
  0xFF, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xFF,
  0xC0, 0x3F, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xF8, 0x07, 0xFF, 0xFC, 0x03,
  0xFE, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xE0,
  0x1F, 0xFF, 0xF0, 0x0F, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFE, 0x01, 0xFF,
  0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xFF, 0xF0,
  0x0F, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0xFF,
  0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xF8, 0x07,
  0xFF, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xFF,
  0xC0, 0x3F, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xF8, 0x07, 0xFF, 0xFC, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0x01, 0xE0, 0x3F, 0xC3, 0xFE, 0x0F, 0xF3, 0xFF,
  0xE3, 0xFD, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xC7, 0xFE, 0xFF, 0xC0, 0xFF, 0xBF, 0xE0, 0x1F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xC3, 0xFF, 0x8F, 0xFC, 0x3F, 0xE0, 0x3F, 0xE3, 0xFC, 0x03, 0xFE, 0x7F,
  0xC0, 0x1F, 0xF7, 0xF8, 0x01, 0xFF, 0x7F, 0x80, 0x0F, 0xF7, 0xF8, 0x00,
  0xFF, 0x7F, 0x80, 0x0F, 0xF7, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80,
  0x0F, 0xF7, 0xF8, 0x00, 0xFF, 0x7F, 0x80, 0x0F, 0xF7, 0xF8, 0x00, 0xFF,
  0x7F, 0x80, 0x0F, 0xF7, 0xF8, 0x01, 0xFF, 0x7F, 0xC0, 0x1F, 0xF3, 0xFC,
  0x01, 0xFE, 0x3F, 0xE0, 0x3F, 0xE3, 0xFF, 0x8F, 0xFC, 0x1F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x3F, 0x8F, 0xFC, 0x0F, 0xE7, 0xFF, 0xC3, 0xFB, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFB, 0xFF, 0x8F, 0xFE,
  0xFF, 0x80, 0xFF, 0xBF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFC, 0x01, 0xFE, 0xFF, 0x80, 0xFF, 0xBF, 0xF0, 0xFF, 0xEF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0x8F, 0xF7, 0xFF, 0xC3, 0xFC, 0xFF, 0xC0, 0xFF, 0x07, 0xC0, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0xE1, 0xFC, 0x1F, 0xFF, 0x3F,
  0x87, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xF9, 0xFF, 0x87, 0xFF, 0x7F, 0xE0, 0x3F, 0xEF, 0xF8, 0x07, 0xFD,
  0xFF, 0x00, 0x7F, 0xBF, 0xC0, 0x0F, 0xF7, 0xF8, 0x01, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFB, 0xFC, 0x00, 0xFF, 0x7F,
  0x80, 0x1F, 0xEF, 0xF0, 0x03, 0xFD, 0xFE, 0x00, 0x7F, 0xBF, 0xE0, 0x0F,
  0xF7, 0xFE, 0x03, 0xFE, 0x7F, 0xE1, 0xFF, 0xCF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0x7F,
  0x80, 0xFF, 0x8F, 0xF0, 0x07, 0xC1, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xFE, 0x3F, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x7F, 0x81,
  0xFF, 0x7F, 0xC0, 0xFF, 0xBF, 0xC0, 0x3F, 0xDF, 0xE0, 0x1F, 0xEF, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x7F,
  0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xE0, 0x0F, 0xF7, 0xF8, 0x07, 0xFB, 0xFE, 0x07, 0xFD, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x01, 0xFF,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFF,
  0x00, 0xFF, 0xC0, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0x81,
  0xFF, 0xC0, 0x3F, 0xE0, 0x07, 0xC0, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x80, 0x3F, 0xDF, 0xE0, 0x0F, 0xF7, 0xF8, 0x07, 0xFD, 0xFF, 0x03,
  0xFF, 0x7F, 0xE3, 0xFF, 0xDF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xBF, 0xC3, 0xFF, 0xCF, 0xF0, 0x7F, 0xE3, 0xFC,
  0x03, 0xE0, 0x00, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFD, 0xFE, 0x00,
  0xFF, 0xBF, 0xC0, 0x1F, 0xE7, 0xFC, 0x03, 0xFC, 0x7F, 0x80, 0xFF, 0x8F,
  0xF0, 0x1F, 0xE1, 0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0x7F, 0x83, 0xFC, 0x0F,
  0xF0, 0x7F, 0x83, 0xFC, 0x0F, 0xF0, 0x7F, 0x81, 0xFE, 0x0F, 0xF0, 0x1F,
  0xE1, 0xFC, 0x03, 0xFC, 0x7F, 0x80, 0x7F, 0x8F, 0xF0, 0x07, 0xF1, 0xFE,
  0x00, 0xFE, 0x3F, 0x80, 0x1F, 0xE7, 0xF0, 0x03, 0xFD, 0xFE, 0x00, 0x3F,
  0xBF, 0x80, 0x07, 0xF7, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0,
  0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F,
  0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x7E, 0x00, 0xFF, 0x7F, 0x00, 0x7E, 0x01, 0xFE,
  0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x7F, 0x80,
  0xFF, 0x01, 0xFE, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x3F, 0x81, 0xFF, 0x81,
  0xFC, 0x3F, 0xC1, 0xFF, 0x83, 0xFC, 0x3F, 0xC1, 0xFF, 0x83, 0xFC, 0x3F,
  0xC1, 0xFF, 0x83, 0xFC, 0x3F, 0xC3, 0xFF, 0xC3, 0xFC, 0x1F, 0xC3, 0xFF,
  0xC3, 0xF8, 0x1F, 0xC3, 0xFF, 0xC3, 0xF8, 0x1F, 0xE3, 0xFF, 0xC7, 0xF8,
  0x1F, 0xE7, 0xFF, 0xE7, 0xF8, 0x0F, 0xE7, 0xFF, 0xE7, 0xF0, 0x0F, 0xE7,
  0xE7, 0xE7, 0xF0, 0x0F, 0xE7, 0xE7, 0xE7, 0xF0, 0x0F, 0xEF, 0xE7, 0xF7,
  0xF0, 0x0F, 0xFF, 0xE7, 0xFF, 0xF0, 0x07, 0xFF, 0xC3, 0xFF, 0xE0, 0x07,
  0xFF, 0xC3, 0xFF, 0xE0, 0x07, 0xFF, 0xC3, 0xFF, 0xE0, 0x07, 0xFF, 0xC3,
  0xFF, 0xE0, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x03, 0xFF, 0x81, 0xFF, 0xC0,
  0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x03, 0xFF,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0xC0, 0x3F,
  0xE7, 0xFC, 0x03, 0xFC, 0x3F, 0xE0, 0x7F, 0xC3, 0xFE, 0x07, 0xF8, 0x1F,
  0xF0, 0xFF, 0x81, 0xFF, 0x0F, 0xF0, 0x0F, 0xF8, 0xFF, 0x00, 0xFF, 0x9F,
  0xE0, 0x07, 0xFD, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xF9, 0xFE, 0x00, 0xFF, 0x9F, 0xF0, 0x1F,
  0xF0, 0xFF, 0x01, 0xFF, 0x0F, 0xF8, 0x3F, 0xE0, 0x7F, 0x83, 0xFE, 0x07,
  0xFC, 0x7F, 0xC0, 0x7F, 0xC7, 0xFC, 0x03, 0xFE, 0xFF, 0x80, 0x3F, 0xE0,
  0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0x3F, 0xC0,
  0x1F, 0xE7, 0xFC, 0x07, 0xFC, 0xFF, 0x80, 0xFF, 0x8F, 0xF0, 0x1F, 0xE1,
  0xFE, 0x03, 0xFC, 0x3F, 0xE0, 0xFF, 0x87, 0xFC, 0x1F, 0xE0, 0x7F, 0x83,
  0xFC, 0x0F, 0xF0, 0x7F, 0x81, 0xFE, 0x1F, 0xF0, 0x1F, 0xE3, 0xFC, 0x03,
  0xFC, 0x7F, 0x80, 0x7F, 0x8F, 0xF0, 0x07, 0xF1, 0xFC, 0x00, 0xFF, 0x7F,
  0x80, 0x1F, 0xEF, 0xF0, 0x03, 0xFD, 0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x07,
  0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0,
  0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F,
  0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF0,
  0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x06, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7F, 0x00,
  0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF8, 0x07,
  0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0xE0, 0x7F,
  0xE0, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0xFF,
  0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x06, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x60, 0x00, 0x78, 0x00,
  0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x3F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x07, 0xFC, 0x07, 0xF8, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x3F, 0xC0,
  0x3F, 0x80, 0x7F, 0x80, 0xFF, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x78, 0x00,
  0x60, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0xFC, 0x3F, 0xFC,
  0x01, 0xF8, 0xFF, 0xFC, 0x07, 0xF3, 0xFF, 0xFC, 0x0F, 0xE7, 0xFF, 0xF8,
  0x1F, 0x9F, 0xFF, 0xFC, 0x7F, 0x3F, 0xC7, 0xFF, 0xFE, 0x7F, 0x07, 0xFF,
  0xF8, 0xFC, 0x07, 0xFF, 0xF1, 0xF8, 0x07, 0xFF, 0xC7, 0xF0, 0x07, 0xFF,
  0x0F, 0xE0, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00,
};

const GFXglyph RobotoCondensed_SemiBold66pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 9, 48, 17, 4, -47 },
  { 55, 16, 17, 21, 3, -50 },
  { 89, 30, 47, 35, 3, -47 },
  { 266, 27, 62, 33, 3, -55 },
  { 476, 36, 49, 42, 3, -48 },
  { 697, 34, 49, 38, 3, -48 },
  { 906, 7, 17, 11, 2, -50 },
  { 921, 15, 67, 21, 4, -52 },
  { 1047, 16, 67, 21, 2, -52 },
  { 1181, 28, 28, 30, 1, -47 },
  { 1279, 27, 35, 32, 2, -39 },
  { 1398, 11, 19, 15, 1, -8 },
  { 1425, 16, 7, 22, 3, -24 },
  { 1439, 10, 10, 19, 4, -9 },
  { 1452, 21, 51, 23, 0, -47 },
  { 1586, 27, 49, 33, 3, -48 },
  { 1752, 18, 47, 33, 5, -47 },
  { 1858, 29, 48, 33, 2, -48 },
  { 2032, 28, 49, 33, 2, -48 },
  { 2204, 29, 47, 33, 2, -47 },
  { 2375, 27, 48, 33, 3, -47 },
  { 2537, 28, 48, 33, 3, -47 },
  { 2705, 28, 47, 33, 2, -47 },
  { 2870, 27, 49, 33, 3, -48 },
  { 3036, 27, 48, 33, 3, -48 },
  { 3198, 10, 37, 17, 4, -36 },
  { 3245, 11, 47, 16, 2, -36 },
  { 3310, 23, 31, 29, 2, -36 },
  { 3400, 24, 21, 33, 4, -32 },
  { 3463, 24, 31, 30, 4, -36 },
  { 3556, 25, 49, 29, 2, -48 },
  { 3710, 45, 61, 51, 3, -46 },
  { 4054, 37, 47, 39, 1, -47 },
  { 4272, 30, 47, 37, 4, -47 },
  { 4449, 32, 49, 38, 3, -48 },
  { 4645, 30, 47, 37, 4, -47 },
  { 4822, 27, 47, 32, 4, -47 },
  { 4981, 26, 47, 31, 4, -47 },
  { 5134, 32, 49, 39, 3, -48 },
  { 5330, 32, 47, 41, 4, -47 },
  { 5518, 9, 47, 18, 4, -47 },
  { 5571, 26, 48, 32, 2, -47 },
  { 5727, 33, 47, 36, 4, -47 },
  { 5921, 26, 47, 32, 4, -47 },
  { 6074, 42, 47, 50, 4, -47 },
  { 6321, 32, 47, 41, 4, -47 },
  { 6509, 33, 49, 40, 3, -48 },
  { 6712, 31, 47, 37, 4, -47 },
  { 6895, 34, 56, 40, 3, -48 },
  { 7133, 31, 47, 36, 4, -47 },
  { 7316, 31, 49, 35, 2, -48 },
  { 7506, 32, 47, 35, 2, -47 },
  { 7694, 30, 48, 38, 4, -47 },
  { 7874, 36, 47, 38, 1, -47 },
  { 8086, 46, 47, 50, 2, -47 },
  { 8357, 34, 47, 37, 1, -47 },
  { 8557, 34, 47, 36, 1, -47 },
  { 8757, 30, 47, 35, 3, -47 },
  { 8934, 12, 65, 17, 4, -54 },
  { 9032, 24, 51, 25, 1, -47 },
  { 9185, 12, 65, 17, 1, -54 },
  { 9283, 22, 23, 25, 2, -47 },
  { 9347, 25, 7, 26, 1, 0 },
  { 9369, 16, 10, 22, 2, -50 },
  { 9389, 26, 37, 31, 3, -36 },
  { 9510, 26, 51, 33, 4, -50 },
  { 9676, 26, 37, 30, 2, -36 },
  { 9797, 27, 51, 33, 2, -50 },
  { 9970, 26, 37, 31, 3, -36 },
  { 10091, 20, 51, 21, 1, -51 },
  { 10219, 28, 49, 33, 2, -36 },
  { 10391, 26, 50, 32, 3, -50 },
  { 10554, 9, 49, 16, 4, -49 },
  { 10610, 14, 62, 16, -2, -49 },
  { 10719, 27, 50, 31, 4, -50 },
  { 10888, 8, 50, 16, 4, -50 },
  { 10938, 42, 36, 49, 4, -36 },
  { 11127, 26, 36, 32, 3, -36 },
  { 11244, 28, 37, 33, 2, -36 },
  { 11374, 26, 49, 33, 4, -36 },
  { 11534, 27, 49, 33, 2, -36 },
  { 11700, 16, 36, 21, 4, -36 },
  { 11772, 25, 37, 30, 2, -36 },
  { 11888, 17, 44, 20, 1, -43 },
  { 11982, 26, 36, 32, 3, -35 },
  { 12099, 27, 35, 29, 1, -35 },
  { 12218, 40, 35, 42, 1, -35 },
  { 12393, 28, 35, 30, 1, -35 },
  { 12516, 27, 48, 29, 1, -35 },
  { 12678, 24, 35, 30, 3, -35 },
  { 12783, 16, 63, 20, 2, -51 },
  { 12909, 5, 56, 17, 6, -47 },
  { 12944, 16, 63, 20, 2, -51 },
  { 13070, 31, 14, 37, 3, -26 },
};

const GFXfont RobotoCondensed_SemiBold66pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_SemiBold66pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_SemiBold66pt7bGlyphs,
  0x20, 0x7E, 77
};

#endif // _ROBOTOCONDENSED_SEMIBOLD66PT7B_H_
