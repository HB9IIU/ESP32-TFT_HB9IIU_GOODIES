#ifndef _ROBOTOCONDENSED_SEMIBOLD24PT7B_H_
#define _ROBOTOCONDENSED_SEMIBOLD24PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-SemiBold.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_SemiBold24pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x60, 0x37, 0xC0, 0xCF, 0x3C, 0xF3, 0xCF,
  0x20, 0x0C, 0xC1, 0x98, 0x36, 0x04, 0xC1, 0x98, 0xFF, 0xDF, 0xF8, 0xCC,
  0x1B, 0x03, 0x63, 0xFF, 0x7F, 0xE3, 0x30, 0x66, 0x0C, 0xC1, 0xB0, 0x36,
  0x00, 0x04, 0x01, 0x01, 0xE0, 0xFE, 0x7F, 0x9C, 0xF7, 0x1D, 0xC7, 0x78,
  0x0F, 0x01, 0xF0, 0x3E, 0x03, 0xF8, 0x7E, 0x1F, 0xC7, 0x7F, 0x8F, 0xE1,
  0xF0, 0x30, 0x0C, 0x00, 0x38, 0x03, 0xE0, 0x33, 0x19, 0x99, 0x8C, 0xCC,
  0x66, 0xC1, 0xF6, 0x07, 0x60, 0x03, 0x00, 0x37, 0x81, 0xFE, 0x1B, 0x30,
  0xD9, 0x8C, 0xCC, 0xC6, 0x60, 0x3F, 0x00, 0xF0, 0x1E, 0x03, 0xF0, 0x7F,
  0x87, 0x38, 0x73, 0x87, 0x38, 0x3F, 0x03, 0xE0, 0x3C, 0x67, 0xE6, 0xEF,
  0x6E, 0x7E, 0xE3, 0xEE, 0x3C, 0xFF, 0xE7, 0xFE, 0x3E, 0x70, 0xFF, 0xF0,
  0x04, 0x31, 0x8E, 0x31, 0xC7, 0x18, 0x61, 0x8E, 0x38, 0xE3, 0x86, 0x18,
  0x61, 0xC7, 0x0C, 0x38, 0x60, 0xC1, 0x86, 0x38, 0xC7, 0x18, 0xE7, 0x38,
  0xC6, 0x31, 0x8C, 0x67, 0x39, 0xCC, 0xE6, 0x73, 0x10, 0x0E, 0x01, 0xC0,
  0x10, 0x32, 0x6F, 0xFE, 0x1E, 0x07, 0x81, 0xD8, 0x31, 0x82, 0x20, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x3F, 0xFF, 0xFF, 0xFF, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x00, 0x33, 0x37, 0x76, 0x60, 0xFF, 0xFF, 0xC0, 0xFF,
  0x80, 0x07, 0x06, 0x06, 0x0E, 0x0C, 0x0C, 0x1C, 0x18, 0x18, 0x18, 0x38,
  0x30, 0x30, 0x70, 0x60, 0x60, 0x60, 0xE0, 0x1E, 0x0F, 0xC7, 0xF9, 0xCE,
  0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xDC,
  0xE7, 0xF8, 0xFC, 0x1E, 0x00, 0x04, 0xFF, 0xFF, 0x9C, 0x71, 0xC7, 0x1C,
  0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x1E, 0x1F, 0xE7, 0xFB, 0x8F, 0xE1,
  0xF8, 0x70, 0x38, 0x0E, 0x07, 0x03, 0xC0, 0xE0, 0x70, 0x38, 0x1E, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1E, 0x1F, 0xC7, 0xFB, 0x8E, 0xE1, 0xC0, 0x70,
  0x38, 0x1E, 0x1F, 0x07, 0xE0, 0x38, 0x07, 0xE1, 0xF8, 0xFF, 0xF9, 0xFE,
  0x3E, 0x00, 0x07, 0x81, 0xE0, 0xF8, 0x3E, 0x1F, 0x86, 0xE3, 0xB8, 0xCE,
  0x73, 0x98, 0xEF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0x7F, 0xDF, 0xF7, 0xFD, 0xC0, 0x70, 0x1C, 0x07, 0xF1, 0xFE, 0x7F, 0x80,
  0x70, 0x1C, 0x07, 0xE1, 0xFC, 0x77, 0xF8, 0xFE, 0x1E, 0x00, 0x07, 0x07,
  0xC3, 0xF1, 0xE0, 0x70, 0x1C, 0x0E, 0xF3, 0xFE, 0xFF, 0xFC, 0x7E, 0x1F,
  0x87, 0xE1, 0xDC, 0x77, 0xF8, 0xFE, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFC,
  0x0E, 0x03, 0x80, 0xE0, 0x70, 0x1C, 0x07, 0x03, 0x80, 0xE0, 0x78, 0x1C,
  0x07, 0x03, 0x80, 0xE0, 0x38, 0x00, 0x1E, 0x1F, 0xE7, 0xF9, 0xCE, 0xF1,
  0xDC, 0xE7, 0xF8, 0xFC, 0x7F, 0x9C, 0xEE, 0x1F, 0x87, 0xE1, 0xFC, 0xF7,
  0xF9, 0xFE, 0x1E, 0x00, 0x1E, 0x0F, 0xC7, 0xFB, 0xCE, 0xE1, 0xF8, 0x7E,
  0x1F, 0x87, 0x7F, 0xDF, 0xF3, 0xDC, 0x0E, 0x03, 0x81, 0xE3, 0xF0, 0xF8,
  0x38, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0xFF, 0x60, 0x00, 0x00, 0x00,
  0x77, 0x76, 0xEE, 0xC0, 0x01, 0x07, 0x1F, 0x7E, 0xF8, 0xE0, 0xF8, 0x7E,
  0x1F, 0x07, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x78, 0x3F, 0x07, 0xE0, 0xF8, 0x1C, 0x3E, 0x7E, 0xFC, 0x78, 0x30,
  0x00, 0x3E, 0x3F, 0xBF, 0xDC, 0xFE, 0x38, 0x1C, 0x1C, 0x1E, 0x1E, 0x0E,
  0x07, 0x03, 0x00, 0x00, 0x00, 0x60, 0x78, 0x18, 0x00, 0x03, 0xE0, 0x0F,
  0xF8, 0x1C, 0x1C, 0x38, 0x06, 0x30, 0x06, 0x61, 0xE3, 0x63, 0xF3, 0x67,
  0x33, 0xC6, 0x33, 0xC6, 0x31, 0xCE, 0x33, 0xCE, 0x73, 0xCE, 0x63, 0xCE,
  0x63, 0xCE, 0x73, 0xE7, 0xFE, 0x63, 0xBC, 0x60, 0x00, 0x30, 0x00, 0x38,
  0x00, 0x1F, 0xF0, 0x07, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xCE, 0x07, 0x38, 0x1C, 0xE0, 0x71, 0xC3, 0xFF,
  0x0F, 0xFC, 0x3F, 0xF1, 0xE0, 0xE7, 0x03, 0x9C, 0x0E, 0xF0, 0x3C, 0xFF,
  0x9F, 0xFB, 0xFF, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x77, 0xFC, 0xFF, 0xDE,
  0x3F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFF, 0xFF, 0xFE, 0xFF, 0x80, 0x0F,
  0x83, 0xFC, 0x7F, 0xE7, 0x0E, 0xF0, 0xFE, 0x07, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x07, 0xF0, 0x77, 0x0E, 0x7F, 0xE3, 0xFC, 0x1F,
  0x80, 0xFF, 0x1F, 0xF3, 0xFF, 0x78, 0xFF, 0x0F, 0xE1, 0xFC, 0x3F, 0x87,
  0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE3, 0xFF, 0xF7, 0xFC, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xFE, 0xFF,
  0xBF, 0xEF, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xFE, 0xFF, 0xBF, 0xEF,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x83, 0xFC,
  0x7F, 0xE7, 0x0E, 0xF0, 0x7E, 0x07, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x3F,
  0xE3, 0xFF, 0x07, 0xF0, 0x77, 0x07, 0x7F, 0xF3, 0xFE, 0x0F, 0x80, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x7E, 0x3F, 0x1F,
  0xFE, 0xFE, 0x3E, 0x00, 0xF0, 0xFF, 0x1E, 0xF1, 0xCF, 0x3C, 0xF3, 0x8F,
  0x70, 0xFF, 0x0F, 0xE0, 0xFF, 0x0F, 0xF0, 0xFF, 0x8F, 0x38, 0xF3, 0xCF,
  0x1C, 0xF1, 0xEF, 0x0E, 0xF0, 0xF0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x0F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xEC, 0x37, 0xEE, 0x77, 0xEE, 0x77, 0xE6, 0x67,
  0xF7, 0x67, 0xF7, 0xE7, 0xF7, 0xE7, 0xF3, 0xC7, 0xF3, 0xC7, 0xF3, 0xC7,
  0xF1, 0x87, 0xF0, 0x7F, 0x07, 0xF8, 0x7F, 0x87, 0xFC, 0x7F, 0xC7, 0xEE,
  0x7E, 0xE7, 0xE7, 0x7E, 0x77, 0xE3, 0xFE, 0x3F, 0xE1, 0xFE, 0x1F, 0xE0,
  0xFE, 0x0F, 0xE0, 0x70, 0x0F, 0x83, 0xFC, 0x7F, 0xE7, 0x0F, 0xF0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xF0, 0x77,
  0x0F, 0x7F, 0xE3, 0xFC, 0x0F, 0x80, 0xFF, 0x8F, 0xFC, 0xFF, 0xEF, 0x0E,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0E, 0xFF, 0xEF, 0xFC, 0xFF, 0x8F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x00, 0x0F, 0x83, 0xFC, 0x7F,
  0xE7, 0x0F, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xF0, 0x77, 0x0F, 0x7F, 0xE3, 0xFC, 0x0F, 0xE0, 0x0F, 0x00,
  0x70, 0x02, 0xFF, 0x0F, 0xFC, 0xFF, 0xEF, 0x0E, 0xF0, 0xEF, 0x0E, 0xF0,
  0xEF, 0x1E, 0xFF, 0xCF, 0xFC, 0xFF, 0x8F, 0x38, 0xF3, 0xCF, 0x1C, 0xF1,
  0xEF, 0x0E, 0xF0, 0xF0, 0x1F, 0x0F, 0xF1, 0xFF, 0x78, 0xFE, 0x0F, 0xE0,
  0x1E, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xF0, 0x7E, 0x0F, 0xE1, 0xDF,
  0xF1, 0xFE, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x00, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0E, 0xE1, 0xDF,
  0xF9, 0xFE, 0x1F, 0x80, 0xF0, 0x3B, 0x81, 0xDC, 0x1E, 0xF0, 0xE3, 0x87,
  0x1C, 0x38, 0xE3, 0xC3, 0x9C, 0x1C, 0xE0, 0xE7, 0x07, 0x70, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0xE1, 0x87, 0x71, 0xE3,
  0xB8, 0xF1, 0xDC, 0x78, 0xEE, 0x3C, 0x73, 0x9E, 0x39, 0xDF, 0xB8, 0xEF,
  0xDC, 0x77, 0x6E, 0x3B, 0x37, 0x0D, 0x9B, 0x87, 0xCF, 0x83, 0xE7, 0xC1,
  0xF1, 0xE0, 0xF0, 0xF0, 0x78, 0x78, 0x1C, 0x3C, 0x00, 0x70, 0x7B, 0xC3,
  0x8E, 0x3C, 0x79, 0xC1, 0xDE, 0x0F, 0xE0, 0x3F, 0x01, 0xF0, 0x07, 0x80,
  0x7C, 0x03, 0xF0, 0x3B, 0x81, 0xDE, 0x1E, 0x70, 0xE3, 0xCF, 0x0E, 0x70,
  0x78, 0xF0, 0x73, 0x83, 0x9E, 0x3C, 0x71, 0xC3, 0x8E, 0x0E, 0xE0, 0x77,
  0x03, 0xB0, 0x0F, 0x80, 0x7C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xE0, 0x38,
  0x0F, 0x01, 0xC0, 0x78, 0x0E, 0x03, 0x80, 0x70, 0x1C, 0x07, 0x80, 0xE0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xF9, 0xCE, 0x73, 0x9C, 0xE7, 0x39,
  0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0xFF, 0xE0, 0x38, 0x1C, 0x0E,
  0x03, 0x81, 0xC0, 0xE0, 0x38, 0x1C, 0x0E, 0x03, 0x81, 0xC0, 0xE0, 0x38,
  0x1C, 0x0E, 0x03, 0x81, 0xC0, 0xFF, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE,
  0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9F, 0xFF, 0x38, 0x38, 0x3C, 0x7C,
  0x6C, 0x6E, 0xE6, 0xE6, 0xC6, 0xFF, 0xFF, 0xC0, 0xE3, 0x8E, 0x70, 0x3E,
  0x3F, 0xBD, 0xFC, 0x70, 0x39, 0xFD, 0xFF, 0xE7, 0xE3, 0xF1, 0xFD, 0xEF,
  0xF3, 0xB8, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x3B, 0xCF, 0xFB, 0xFE,
  0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0xFE, 0xFF, 0xBB,
  0xC0, 0x3E, 0x3F, 0x9F, 0xFC, 0x7E, 0x3F, 0x03, 0x81, 0xC0, 0xE3, 0xF1,
  0xDF, 0xEF, 0xE1, 0xE0, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xCF, 0x77,
  0xFF, 0xFF, 0xE3, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x3F, 0xFF,
  0x7F, 0xCF, 0x70, 0x1E, 0x1F, 0xE7, 0xFB, 0x86, 0xE1, 0xFF, 0xFF, 0xFF,
  0x80, 0xE0, 0x3C, 0x07, 0xF9, 0xFE, 0x1F, 0x00, 0x1E, 0x7D, 0xFB, 0x87,
  0x1F, 0xBF, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE0,
  0x3D, 0xDF, 0xFF, 0xFF, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8,
  0x7F, 0xFD, 0xFF, 0x3D, 0xC0, 0x70, 0x3D, 0xDE, 0x7F, 0x8F, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x3B, 0xCF, 0xFB, 0xFE, 0xE3, 0xB8, 0xEE,
  0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xF0, 0xEF, 0x60,
  0x0E, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0x38, 0xF1, 0x80, 0x00, 0xE3,
  0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0xFB, 0xEF,
  0x00, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0xFE, 0x7B, 0x9C, 0xEE,
  0x3F, 0x8F, 0xC3, 0xF8, 0xFE, 0x3D, 0xCE, 0x73, 0x8E, 0xE3, 0xB8, 0x70,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xEF, 0x3C, 0xFF, 0xFE, 0xFF,
  0xFE, 0xE3, 0xCE, 0xE3, 0x87, 0xE3, 0x87, 0xE3, 0x87, 0xE3, 0x87, 0xE3,
  0x87, 0xE3, 0x87, 0xE3, 0x87, 0xE3, 0x87, 0xE3, 0x87, 0xEF, 0x3F, 0xEF,
  0xFB, 0x8E, 0xE3, 0xB8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F,
  0xE3, 0xC0, 0x1E, 0x1F, 0xE7, 0xFB, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87,
  0xE1, 0xF8, 0x77, 0xF9, 0xFE, 0x1E, 0x00, 0xEF, 0x3F, 0xEF, 0xFB, 0x87,
  0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7F, 0xFB, 0xFE, 0xEF, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x00, 0x3D, 0xDF, 0xFF, 0xFF, 0x87, 0xE1,
  0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7F, 0xFD, 0xFF, 0x3D, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0xEF, 0xFF, 0xFC, 0xE3, 0x8E, 0x38, 0xE3,
  0x8E, 0x38, 0xE0, 0x3E, 0x3F, 0xBD, 0xFC, 0x7F, 0x03, 0xE0, 0xFC, 0x1F,
  0x03, 0xF1, 0xFD, 0xEF, 0xE3, 0xE0, 0x38, 0x70, 0xE7, 0xFF, 0xE7, 0x0E,
  0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0xCF, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F,
  0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xF7, 0xFD, 0xFF, 0x3D,
  0xC0, 0xF1, 0xDC, 0x77, 0x1D, 0xCE, 0x33, 0x8E, 0xE3, 0xB0, 0xEC, 0x1F,
  0x07, 0xC1, 0xE0, 0x38, 0x0E, 0x00, 0x63, 0x8E, 0xE7, 0x1D, 0xCE, 0x73,
  0x9E, 0xE7, 0x7D, 0xC6, 0xFB, 0x8D, 0xB6, 0x1F, 0x7C, 0x3E, 0xF8, 0x7C,
  0xF0, 0x71, 0xE0, 0xE3, 0x81, 0xC7, 0x00, 0x71, 0xDE, 0xF3, 0xB8, 0xEC,
  0x1F, 0x07, 0x80, 0xE0, 0x7C, 0x1F, 0x0E, 0xE3, 0xB9, 0xCF, 0x71, 0xC0,
  0xF1, 0xDC, 0x77, 0x1D, 0xCE, 0x3B, 0x8E, 0xE3, 0xB0, 0xFC, 0x1F, 0x07,
  0xC1, 0xE0, 0x38, 0x0E, 0x03, 0x01, 0xC1, 0xF0, 0x78, 0x1C, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0xE0, 0xE0, 0xF0, 0x70, 0x70, 0x38, 0x38, 0x3F, 0xFF,
  0xFF, 0xF8, 0x08, 0x73, 0x8C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x38, 0xE1,
  0xC7, 0x1C, 0x71, 0xC7, 0x0C, 0x38, 0x70, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x83, 0x8E, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC3, 0x8F, 0x3D, 0xC7,
  0x1C, 0x71, 0xC7, 0x1C, 0xE3, 0x88, 0x00, 0x38, 0x6F, 0x8D, 0xFF, 0xF3,
  0xEE, 0x38,
};

const GFXglyph RobotoCondensed_SemiBold24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 3, 17, 6, 2, -17 },
  { 8, 6, 6, 8, 1, -18 },
  { 13, 11, 17, 13, 1, -17 },
  { 37, 10, 21, 12, 1, -19 },
  { 64, 13, 17, 15, 1, -17 },
  { 92, 12, 17, 14, 1, -17 },
  { 118, 2, 6, 4, 1, -18 },
  { 120, 6, 24, 8, 1, -19 },
  { 138, 5, 24, 8, 1, -19 },
  { 153, 11, 10, 11, 0, -17 },
  { 167, 10, 13, 12, 1, -15 },
  { 184, 4, 7, 6, 0, -3 },
  { 188, 6, 3, 8, 1, -9 },
  { 191, 3, 3, 7, 2, -3 },
  { 193, 8, 18, 8, 0, -17 },
  { 211, 10, 17, 12, 1, -17 },
  { 233, 6, 17, 12, 2, -17 },
  { 246, 10, 17, 12, 1, -17 },
  { 268, 10, 17, 12, 1, -17 },
  { 290, 10, 17, 12, 1, -17 },
  { 312, 10, 17, 12, 1, -17 },
  { 334, 10, 17, 12, 1, -17 },
  { 356, 10, 17, 12, 1, -17 },
  { 378, 10, 17, 12, 1, -17 },
  { 400, 10, 17, 12, 1, -17 },
  { 422, 3, 13, 6, 2, -13 },
  { 427, 4, 17, 6, 1, -13 },
  { 436, 8, 11, 11, 1, -13 },
  { 447, 8, 9, 12, 2, -12 },
  { 456, 9, 11, 11, 1, -13 },
  { 469, 9, 17, 11, 1, -17 },
  { 489, 16, 22, 18, 1, -17 },
  { 533, 14, 17, 14, 0, -17 },
  { 563, 11, 17, 13, 1, -17 },
  { 587, 12, 17, 14, 1, -17 },
  { 613, 11, 17, 14, 1, -17 },
  { 637, 10, 17, 12, 1, -17 },
  { 659, 10, 17, 11, 1, -17 },
  { 681, 12, 17, 14, 1, -17 },
  { 707, 12, 17, 15, 1, -17 },
  { 733, 3, 17, 6, 2, -17 },
  { 740, 9, 17, 12, 1, -17 },
  { 760, 12, 17, 13, 1, -17 },
  { 786, 10, 17, 11, 1, -17 },
  { 808, 16, 17, 18, 1, -17 },
  { 842, 12, 17, 15, 1, -17 },
  { 868, 12, 17, 14, 1, -17 },
  { 894, 12, 17, 14, 1, -17 },
  { 920, 12, 20, 14, 1, -17 },
  { 950, 12, 17, 13, 1, -17 },
  { 976, 11, 17, 13, 1, -17 },
  { 1000, 11, 17, 13, 1, -17 },
  { 1024, 11, 17, 14, 1, -17 },
  { 1048, 13, 17, 14, 0, -17 },
  { 1076, 17, 17, 18, 1, -17 },
  { 1113, 13, 17, 13, 0, -17 },
  { 1141, 13, 17, 13, 0, -17 },
  { 1169, 11, 17, 13, 1, -17 },
  { 1193, 5, 24, 6, 1, -20 },
  { 1208, 9, 18, 9, 0, -17 },
  { 1229, 5, 24, 6, 0, -20 },
  { 1244, 8, 9, 9, 1, -17 },
  { 1253, 9, 2, 10, 0, 0 },
  { 1256, 5, 4, 8, 1, -18 },
  { 1259, 9, 13, 11, 1, -13 },
  { 1274, 10, 18, 12, 1, -18 },
  { 1297, 9, 13, 11, 1, -13 },
  { 1312, 10, 18, 12, 1, -18 },
  { 1335, 10, 13, 11, 1, -13 },
  { 1352, 7, 18, 8, 1, -18 },
  { 1368, 10, 18, 12, 1, -13 },
  { 1391, 10, 18, 12, 1, -18 },
  { 1414, 4, 18, 6, 1, -18 },
  { 1423, 6, 23, 6, -1, -18 },
  { 1441, 10, 18, 11, 1, -18 },
  { 1464, 3, 18, 6, 1, -18 },
  { 1471, 16, 13, 18, 1, -13 },
  { 1497, 10, 13, 12, 1, -13 },
  { 1514, 10, 13, 12, 1, -13 },
  { 1531, 10, 18, 12, 1, -13 },
  { 1554, 10, 18, 12, 1, -13 },
  { 1577, 6, 13, 8, 1, -13 },
  { 1587, 9, 13, 11, 1, -13 },
  { 1602, 7, 16, 7, 0, -16 },
  { 1616, 10, 13, 12, 1, -13 },
  { 1633, 10, 13, 11, 0, -13 },
  { 1650, 15, 13, 15, 0, -13 },
  { 1675, 10, 13, 11, 0, -13 },
  { 1692, 10, 18, 11, 0, -13 },
  { 1715, 9, 13, 11, 1, -13 },
  { 1730, 6, 23, 7, 1, -19 },
  { 1748, 2, 20, 6, 2, -17 },
  { 1753, 6, 23, 7, 1, -19 },
  { 1771, 11, 5, 14, 1, -9 },
};

const GFXfont RobotoCondensed_SemiBold24pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_SemiBold24pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_SemiBold24pt7bGlyphs,
  0x20, 0x7E, 28
};

#endif // _ROBOTOCONDENSED_SEMIBOLD24PT7B_H_
