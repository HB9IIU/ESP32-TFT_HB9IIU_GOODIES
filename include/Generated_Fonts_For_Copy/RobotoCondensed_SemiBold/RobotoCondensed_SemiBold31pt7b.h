#ifndef _ROBOTOCONDENSED_SEMIBOLD31PT7B_H_
#define _ROBOTOCONDENSED_SEMIBOLD31PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-SemiBold.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_SemiBold31pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xF7,
  0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE6, 0xE6, 0xE6, 0x07, 0x38, 0x0E, 0x70,
  0x1C, 0xC0, 0x39, 0x80, 0x63, 0x00, 0xCE, 0x1F, 0xFF, 0xBF, 0xFF, 0x7F,
  0xFE, 0x1C, 0xC0, 0x31, 0x80, 0x63, 0x00, 0xCE, 0x1F, 0xFF, 0xBF, 0xFF,
  0x7F, 0xFE, 0x1C, 0xC0, 0x31, 0x80, 0x63, 0x00, 0xCE, 0x03, 0x9C, 0x07,
  0x38, 0x00, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0F, 0x81, 0xFE, 0x1F, 0xF8,
  0xF3, 0xCF, 0x0F, 0x78, 0x7B, 0xC3, 0xDE, 0x00, 0x78, 0x03, 0xF0, 0x0F,
  0xE0, 0x3F, 0x80, 0x7E, 0x00, 0xF8, 0x03, 0xFC, 0x1E, 0xE0, 0xF7, 0x87,
  0xBE, 0x7C, 0xFF, 0xC3, 0xFC, 0x0F, 0xC0, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x3C, 0x00, 0xFE, 0x00, 0xEE, 0x10, 0xC7, 0x18, 0xC7, 0x38, 0xC7, 0x30,
  0xC7, 0x70, 0xEE, 0x60, 0xFE, 0xE0, 0x7C, 0xC0, 0x01, 0xC0, 0x03, 0x80,
  0x03, 0x3C, 0x07, 0x7E, 0x06, 0x77, 0x0E, 0xE3, 0x0C, 0xE3, 0x1C, 0xE3,
  0x18, 0xE3, 0x18, 0x77, 0x00, 0x7E, 0x00, 0x3C, 0x07, 0x80, 0x1F, 0xC0,
  0x3F, 0xE0, 0x3C, 0xF0, 0x38, 0xF0, 0x38, 0xF0, 0x38, 0xF0, 0x3D, 0xE0,
  0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x8E, 0x7F, 0x8E, 0x7B, 0xDE,
  0xF1, 0xFE, 0xF1, 0xFC, 0xF0, 0xFC, 0xF8, 0x7C, 0x7C, 0xFC, 0x7F, 0xFC,
  0x3F, 0xFE, 0x0F, 0x9F, 0xFF, 0xFF, 0xFF, 0x02, 0x0C, 0x38, 0xE3, 0x87,
  0x0E, 0x38, 0x70, 0xE3, 0xC7, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87,
  0x0E, 0x1E, 0x1C, 0x38, 0x70, 0x70, 0xE1, 0xC1, 0xC1, 0xC1, 0x81, 0x81,
  0x83, 0x83, 0x87, 0x87, 0x0F, 0x0E, 0x1C, 0x3C, 0x78, 0xF0, 0xE1, 0xC3,
  0x87, 0x0E, 0x1C, 0x38, 0x71, 0xE3, 0xC7, 0x8E, 0x1C, 0x78, 0xE3, 0xC7,
  0x1C, 0x30, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x10, 0xC0, 0x73, 0x39,
  0xFF, 0xE3, 0xFF, 0x01, 0xE0, 0x0F, 0xC0, 0x77, 0x81, 0xCE, 0x0E, 0x1C,
  0x00, 0x40, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x83,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x7B, 0xDE, 0xF7, 0x3B, 0xDC, 0x40, 0xFF, 0xFF,
  0xF8, 0xF7, 0xFC, 0xE0, 0x01, 0xC0, 0x70, 0x38, 0x0E, 0x03, 0x81, 0xC0,
  0x70, 0x1C, 0x06, 0x03, 0x80, 0xE0, 0x38, 0x1C, 0x07, 0x01, 0xC0, 0x60,
  0x38, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0x1C, 0x06, 0x03, 0x80, 0x1F, 0x03,
  0xFC, 0x7F, 0xEF, 0x9E, 0xF0, 0xEF, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0E, 0xF9, 0xE7, 0xFE, 0x3F, 0xC1, 0xF0, 0x01, 0x83, 0xCF, 0xFF, 0xFF,
  0xFF, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x0F, 0xC1, 0xFF, 0x0F,
  0xFC, 0xFB, 0xE7, 0x8F, 0xF8, 0x3F, 0xC1, 0xE0, 0x0F, 0x00, 0xF0, 0x07,
  0x80, 0x78, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3E, 0x03, 0xE0, 0x1E, 0x01,
  0xE0, 0x1F, 0x00, 0xFF, 0xF7, 0xFF, 0xBF, 0xFC, 0x0F, 0x81, 0xFF, 0x1F,
  0xFC, 0xFB, 0xEF, 0x87, 0xF8, 0x3C, 0x01, 0xE0, 0x1E, 0x01, 0xF0, 0x7F,
  0x03, 0xF0, 0x1F, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0xF0, 0x7F,
  0x83, 0xDF, 0x7C, 0xFF, 0xE3, 0xFE, 0x07, 0xC0, 0x01, 0xF0, 0x07, 0xC0,
  0x3F, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0xEF, 0x03, 0xBC, 0x1C, 0xF0,
  0x73, 0xC3, 0x8F, 0x0E, 0x3C, 0x70, 0xF3, 0xC3, 0xCF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x7F,
  0xF7, 0xFF, 0x7F, 0xF7, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x78, 0xFF,
  0xCF, 0xFE, 0xF1, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF9, 0xE7, 0xFE, 0x3F, 0xC1, 0xF8, 0x03, 0xC0, 0xFC, 0x1F,
  0xC3, 0xF0, 0x7C, 0x07, 0x80, 0xF0, 0x0F, 0x78, 0xFF, 0xEF, 0xFE, 0xF9,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0x7F, 0x0F, 0xF0, 0xFF, 0x0F, 0x79,
  0xF7, 0xFE, 0x3F, 0xC0, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xF0,
  0x07, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x1E, 0x00, 0x1F, 0x03, 0xFC, 0x7F, 0xEF, 0x9E, 0xF1,
  0xFF, 0x0F, 0xF0, 0xFF, 0x1E, 0x79, 0xE7, 0xFC, 0x3F, 0x87, 0xFE, 0xF1,
  0xEF, 0x0F, 0xF0, 0xFE, 0x0F, 0xF0, 0xFF, 0x0F, 0xF9, 0xF7, 0xFE, 0x7F,
  0xC1, 0xF0, 0x0F, 0x80, 0xFE, 0x0F, 0xF8, 0xFB, 0xE7, 0x8F, 0x3C, 0x3F,
  0xC1, 0xFE, 0x0F, 0xF0, 0x7B, 0x83, 0xDE, 0x1E, 0xF9, 0xF3, 0xFF, 0x9F,
  0xFC, 0x3D, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x03, 0xF8, 0x3F, 0x81, 0xF8,
  0x0F, 0x00, 0xF7, 0xFC, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7B, 0xFE,
  0x70, 0x7B, 0xDE, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3D, 0xEF, 0x7B,
  0xDC, 0xEE, 0x20, 0x00, 0x20, 0x1C, 0x0F, 0x87, 0xF3, 0xFC, 0xFE, 0x3F,
  0x07, 0x80, 0xFC, 0x0F, 0xE0, 0xFF, 0x07, 0xF0, 0x3E, 0x01, 0xC0, 0x08,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFC, 0x80, 0x1C, 0x03, 0xE0, 0x7F, 0x07, 0xF8, 0x3F, 0x81, 0xF8,
  0x0F, 0x07, 0xE3, 0xF9, 0xFE, 0x7F, 0x0F, 0x81, 0xC0, 0x20, 0x00, 0x1F,
  0x07, 0xF9, 0xFF, 0xFD, 0xFF, 0x1F, 0xE1, 0xC0, 0x38, 0x0F, 0x01, 0xE0,
  0x78, 0x1E, 0x07, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x0F, 0x81, 0xF0, 0x1C, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFE, 0x00,
  0x7C, 0x7C, 0x03, 0xC0, 0x78, 0x1E, 0x00, 0x70, 0x70, 0x01, 0xC3, 0x80,
  0x03, 0x0E, 0x0F, 0x0E, 0x70, 0x7F, 0x19, 0xC3, 0xFC, 0x67, 0x1C, 0x71,
  0x98, 0x71, 0xC6, 0x63, 0x86, 0x1B, 0x8E, 0x18, 0x6E, 0x38, 0x61, 0xB8,
  0xE3, 0x86, 0xE3, 0x8E, 0x1B, 0x8E, 0x38, 0xE6, 0x38, 0xE3, 0x18, 0xFF,
  0xDC, 0x71, 0xF7, 0xE1, 0xC3, 0x8F, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFD, 0xE0, 0x01, 0xFF, 0x80, 0x01,
  0xFC, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1E, 0xE0, 0x07, 0x3C, 0x03, 0xCF,
  0x00, 0xF1, 0xC0, 0x3C, 0x78, 0x1E, 0x1E, 0x07, 0x87, 0x81, 0xFF, 0xF0,
  0xFF, 0xFC, 0x3F, 0xFF, 0x0F, 0x03, 0xE7, 0xC0, 0x79, 0xE0, 0x1E, 0x78,
  0x07, 0xDE, 0x00, 0xF0, 0xFF, 0xC3, 0xFF, 0xCF, 0xFF, 0xBC, 0x7E, 0xF0,
  0x7B, 0xC1, 0xEF, 0x07, 0xBC, 0x1E, 0xF0, 0xFB, 0xFF, 0xCF, 0xFE, 0x3F,
  0xFC, 0xF0, 0x7B, 0xC1, 0xEF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC1, 0xFF,
  0x1F, 0xBF, 0xFE, 0xFF, 0xF3, 0xFF, 0x00, 0x0F, 0xC0, 0x7F, 0xE1, 0xFF,
  0xE3, 0xF7, 0xEF, 0x83, 0xDE, 0x07, 0xBC, 0x0F, 0x78, 0x0F, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x0F, 0xF8,
  0x1E, 0xF0, 0x3D, 0xE0, 0x79, 0xF3, 0xF3, 0xFF, 0xC3, 0xFF, 0x01, 0xF8,
  0x00, 0xFF, 0x83, 0xFF, 0x8F, 0xFF, 0x3C, 0xFE, 0xF0, 0x7B, 0xC1, 0xEF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x7B, 0xC1, 0xEF, 0x1F, 0xBF, 0xFC,
  0xFF, 0xE3, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0xFE, 0xFF, 0xEF, 0xFE, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x0F, 0xE0,
  0x7F, 0xE1, 0xFF, 0xE3, 0xF7, 0xEF, 0x83, 0xDE, 0x07, 0xBC, 0x07, 0xF8,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x8F, 0xFF, 0x1F, 0xFE, 0x3F,
  0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xF0, 0x3D, 0xF9, 0xFB, 0xFF, 0xE1,
  0xFF, 0x81, 0xFC, 0x00, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xFF, 0xF7, 0xFE, 0x3F, 0xC1, 0xF8, 0xF0, 0x3F, 0xE0, 0xFB, 0xC3, 0xE7,
  0x87, 0xCF, 0x1F, 0x1E, 0x3C, 0x3C, 0xF8, 0x7B, 0xE0, 0xF7, 0x81, 0xFF,
  0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xFC, 0x1F, 0xFC, 0x3E, 0x78, 0x78, 0xF8,
  0xF0, 0xF1, 0xE1, 0xF3, 0xC1, 0xE7, 0x83, 0xEF, 0x03, 0xDE, 0x07, 0xC0,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0x80, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x7F,
  0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFF, 0x0E, 0xFF, 0xF0, 0xEF, 0xF7, 0x1E,
  0xFF, 0x71, 0xCF, 0xF7, 0x9C, 0xFF, 0x3B, 0xCF, 0xF3, 0xB8, 0xFF, 0x3F,
  0x8F, 0xF3, 0xF8, 0xFF, 0x1F, 0x8F, 0xF1, 0xF0, 0xFF, 0x1F, 0x0F, 0xF0,
  0xF0, 0xFF, 0x0E, 0x0F, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xE0, 0xFF,
  0xC1, 0xFF, 0xC3, 0xFF, 0x87, 0xFF, 0x8F, 0xFF, 0x1F, 0xEF, 0x3F, 0xDE,
  0x7F, 0x9E, 0xFF, 0x3D, 0xFE, 0x3F, 0xFC, 0x7F, 0xF8, 0x7F, 0xF0, 0xFF,
  0xE0, 0xFF, 0xC1, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x03, 0xC0, 0x0F, 0xC0,
  0x3F, 0xE0, 0xFF, 0xE3, 0xF7, 0xEF, 0x83, 0xDE, 0x07, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03,
  0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xF0, 0x79, 0xFB, 0xF3, 0xFF, 0xC1,
  0xFF, 0x01, 0xF8, 0x00, 0xFF, 0xC3, 0xFF, 0xCF, 0xFF, 0xBC, 0x3F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x0F, 0xFF,
  0xFE, 0xFF, 0xF3, 0xFF, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x07, 0xE0, 0x0F, 0xF8, 0x3F,
  0xFC, 0x3F, 0x7E, 0x7C, 0x1E, 0x78, 0x1F, 0x78, 0x0F, 0x78, 0x0F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0x78,
  0x0F, 0x78, 0x0F, 0x78, 0x1F, 0x7C, 0x1E, 0x3F, 0x7E, 0x3F, 0xFC, 0x0F,
  0xF8, 0x07, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0E, 0x00, 0x04, 0xFF,
  0xC3, 0xFF, 0xCF, 0xFF, 0xBC, 0x7E, 0xF0, 0x7B, 0xC1, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x7F, 0xC1, 0xEF, 0x1F, 0xBF, 0xFC, 0xFF, 0xE3, 0xFF, 0x8F,
  0x1E, 0x3C, 0x7C, 0xF0, 0xF3, 0xC3, 0xCF, 0x07, 0xBC, 0x1E, 0xF0, 0x7F,
  0xC0, 0xF0, 0x0F, 0xC0, 0x7F, 0xC3, 0xFF, 0x9F, 0xBE, 0x78, 0x3D, 0xE0,
  0xF7, 0x83, 0xDE, 0x00, 0x7E, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x01,
  0xF8, 0x01, 0xF0, 0x03, 0xFC, 0x0F, 0xF0, 0x3D, 0xE0, 0xF7, 0xCF, 0xCF,
  0xFE, 0x1F, 0xF0, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC1, 0xFF, 0xCF, 0x9F, 0xFE, 0x3F, 0xF0,
  0x3F, 0x00, 0x78, 0x07, 0xBC, 0x03, 0xDE, 0x03, 0xEF, 0x81, 0xE3, 0xC0,
  0xF1, 0xE0, 0x78, 0xF0, 0x7C, 0x3C, 0x3C, 0x1E, 0x1E, 0x0F, 0x0F, 0x07,
  0x8F, 0x01, 0xE7, 0x80, 0xF3, 0xC0, 0x79, 0xC0, 0x1D, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x0F,
  0x00, 0xF0, 0x78, 0x3F, 0xC1, 0xE1, 0xEF, 0x07, 0x87, 0xBC, 0x3E, 0x1E,
  0x78, 0xF8, 0x79, 0xE3, 0xE1, 0xE7, 0x8F, 0xC7, 0x1E, 0x3F, 0x3C, 0x79,
  0xFC, 0xF0, 0xE7, 0x73, 0xC3, 0x9D, 0xCF, 0x0F, 0x77, 0xBC, 0x3D, 0xCE,
  0xE0, 0xFF, 0x3F, 0x83, 0xF8, 0xFE, 0x07, 0xE3, 0xF8, 0x1F, 0x8F, 0xE0,
  0x7E, 0x1F, 0x01, 0xF8, 0x7C, 0x07, 0xC1, 0xF0, 0x0F, 0x07, 0xC0, 0x3C,
  0x0F, 0x00, 0xF8, 0x1E, 0x78, 0x3E, 0x7C, 0x3C, 0x3C, 0x3C, 0x3C, 0x78,
  0x1E, 0x78, 0x1E, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xC0,
  0x07, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1E, 0xF0, 0x1E, 0xF0, 0x3E, 0x78,
  0x3C, 0x78, 0x7C, 0x7C, 0x78, 0x3C, 0xF8, 0x3E, 0xF0, 0x1E, 0xF8, 0x0F,
  0x78, 0x1F, 0x7C, 0x1E, 0x3C, 0x1E, 0x3C, 0x3C, 0x1E, 0x3C, 0x1E, 0x3C,
  0x0E, 0x78, 0x0F, 0x78, 0x0F, 0x70, 0x07, 0xF0, 0x07, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00,
  0x7C, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x01,
  0xF0, 0x07, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xEF,
  0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE,
  0xF7, 0xBD, 0xEF, 0xFF, 0xE0, 0xF0, 0x07, 0x80, 0x78, 0x07, 0x80, 0x3C,
  0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0x78, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x1C, 0x01,
  0xE0, 0x1E, 0x00, 0xE0, 0x0F, 0xFF, 0xFE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE,
  0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xFF, 0xFF,
  0xE0, 0x1E, 0x07, 0x81, 0xE0, 0xFC, 0x3F, 0x0F, 0xC7, 0x39, 0xCE, 0x73,
  0xB8, 0x7E, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0xF0, 0xF0, 0xE0,
  0xE0, 0x0F, 0x81, 0xFF, 0x1F, 0xF8, 0xF3, 0xE7, 0x8F, 0x00, 0x78, 0x03,
  0xC1, 0xFE, 0x3F, 0xF3, 0xE7, 0xBE, 0x3D, 0xE1, 0xEF, 0x0F, 0x7C, 0xF9,
  0xFF, 0xCF, 0xFE, 0x1E, 0xF0, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF7, 0x8F, 0xFE, 0xFF, 0xEF, 0x9F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x9F, 0xFF,
  0xEE, 0xFE, 0xE7, 0x80, 0x0F, 0x83, 0xFE, 0x7F, 0xE7, 0xDF, 0x70, 0xFF,
  0x07, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x07, 0x70, 0xF7,
  0x8F, 0x7F, 0xE3, 0xFE, 0x0F, 0x80, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x79, 0xE7, 0xFF, 0x7F, 0xFB, 0xEF, 0xFE, 0x1F,
  0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFE,
  0x1E, 0xFB, 0xF7, 0xFF, 0x9F, 0xFC, 0x79, 0xE0, 0x0F, 0x81, 0xFF, 0x0F,
  0xFC, 0xFB, 0xE7, 0x87, 0x78, 0x3F, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x38, 0xFF, 0xE3, 0xFE, 0x0F, 0xC0,
  0x07, 0x8F, 0xCF, 0xE7, 0xC3, 0xC1, 0xE3, 0xFD, 0xFE, 0xFF, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x1F, 0x79, 0xFF, 0xDF, 0xFE, 0xF9, 0xFF, 0x87, 0xF8, 0x3F,
  0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xF7, 0x87, 0xBE,
  0xFD, 0xFF, 0xE7, 0xFF, 0x1F, 0x78, 0x03, 0xC0, 0x1E, 0x61, 0xE3, 0xFF,
  0x1F, 0xF0, 0x3E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE7, 0x8E, 0xFC, 0xFF, 0xEF, 0xBE, 0xF1, 0xEE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xF0, 0xEF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1C, 0x3C, 0x78, 0xE0, 0x00, 0x07, 0x8F, 0x1E, 0x3C,
  0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F,
  0x1E, 0x7F, 0xF7, 0xEF, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC7, 0xDE, 0x3C, 0xF3, 0xC7, 0xBE, 0x3D, 0xE1, 0xFE,
  0x0F, 0xF0, 0x7F, 0x03, 0xFC, 0x1F, 0xF0, 0xF7, 0x87, 0xBE, 0x3C, 0xF1,
  0xE7, 0xCF, 0x1E, 0x78, 0xFB, 0xC3, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE7, 0x87, 0x9D, 0xFB, 0xFB,
  0xFF, 0xFF, 0xFD, 0xFD, 0xFF, 0x1F, 0x1F, 0xE1, 0xC3, 0xFC, 0x38, 0x7F,
  0x87, 0x0F, 0xF0, 0xE1, 0xFE, 0x1C, 0x3F, 0xC3, 0x87, 0xF8, 0x70, 0xFF,
  0x0E, 0x1F, 0xE1, 0xC3, 0xFC, 0x38, 0x7F, 0x87, 0x0F, 0xF0, 0xE1, 0xE0,
  0xE7, 0x8E, 0xFC, 0xFF, 0xEF, 0xBE, 0xF1, 0xEF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xF0, 0x0F, 0x81, 0xFF, 0x0F, 0xFC, 0xF9, 0xE7, 0x87, 0xF8, 0x3F,
  0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xF7, 0x87, 0xBE,
  0x78, 0xFF, 0xC7, 0xFC, 0x0F, 0x80, 0xE7, 0x8E, 0xFE, 0xFF, 0xEF, 0x9F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x9F, 0xFF, 0xEF, 0xFC, 0xF7, 0x8F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x00, 0x1F, 0x79, 0xFF, 0xDF, 0xFE, 0xF9, 0xFF,
  0x87, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0,
  0xFF, 0x87, 0xBC, 0xFD, 0xFF, 0xE7, 0xFF, 0x1E, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0xE7, 0xDF, 0xFF, 0xFF, 0x1E,
  0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF0, 0x1F, 0x83,
  0xFC, 0x7F, 0xE7, 0x9F, 0xF0, 0xF7, 0x80, 0x7C, 0x07, 0xF0, 0x3F, 0xC0,
  0xFE, 0x03, 0xF0, 0x0F, 0xF0, 0xFF, 0x8F, 0x7F, 0xE3, 0xFC, 0x1F, 0x80,
  0x3C, 0x1E, 0x0F, 0x1F, 0xFF, 0xFF, 0xFC, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3E, 0x0F, 0xC7, 0xE1, 0xF0, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFF, 0x0F, 0xF0, 0xFF, 0x3F, 0xFF, 0xF7, 0xFF, 0x3C,
  0xF0, 0x78, 0x7B, 0xC3, 0xDE, 0x1E, 0xF1, 0xE3, 0x8F, 0x1E, 0x78, 0xF3,
  0xC7, 0x9C, 0x1D, 0xE0, 0xFF, 0x07, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3E, 0x00, 0xF0, 0x07, 0x80, 0xE1, 0xC3, 0xFC, 0x78, 0xFF, 0x1E, 0x3F,
  0xC7, 0x8E, 0x73, 0xE3, 0x9C, 0xFD, 0xE7, 0x3F, 0x79, 0xEF, 0xDE, 0x7F,
  0x77, 0x0F, 0xCF, 0xC3, 0xF3, 0xF0, 0xFC, 0xFC, 0x3E, 0x3F, 0x0F, 0x87,
  0x81, 0xE1, 0xE0, 0x78, 0x78, 0x1C, 0x1E, 0x00, 0xF0, 0xFF, 0x9F, 0x79,
  0xE7, 0xDE, 0x3F, 0xC3, 0xF8, 0x1F, 0x81, 0xF0, 0x0F, 0x01, 0xF8, 0x1F,
  0x83, 0xFC, 0x3F, 0xC7, 0x9E, 0x79, 0xEF, 0x0F, 0xF0, 0xF0, 0xF8, 0x7B,
  0xC3, 0xDE, 0x1E, 0xF1, 0xE3, 0xCF, 0x1E, 0x78, 0xF3, 0x87, 0xBC, 0x1D,
  0xE0, 0xFF, 0x07, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x38, 0x03, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x00, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1E, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0xF8,
  0x0F, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x02, 0x0E, 0x1E, 0x1C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x38, 0x78, 0xF8, 0xE0, 0xF0, 0x78, 0x38, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x1C, 0x1E, 0x0E, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xC1, 0xC3, 0xC3, 0xC7, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1,
  0xC3, 0xC3, 0xC3, 0x8F, 0x3C, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x78,
  0xF3, 0xC7, 0x0C, 0x00, 0x3C, 0x1D, 0xF8, 0x7F, 0xF1, 0xFD, 0xEE, 0xE3,
  0xFB, 0x87, 0xC0, 0x0E, 0x00,
};

const GFXglyph RobotoCondensed_SemiBold31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 4, 22, 8, 2, -22 },
  { 12, 8, 8, 10, 1, -23 },
  { 20, 15, 22, 17, 1, -22 },
  { 62, 13, 28, 16, 1, -25 },
  { 108, 16, 22, 20, 2, -22 },
  { 152, 16, 22, 18, 1, -22 },
  { 196, 3, 8, 5, 1, -23 },
  { 199, 7, 32, 10, 2, -25 },
  { 227, 7, 32, 10, 1, -25 },
  { 255, 14, 13, 14, 0, -22 },
  { 278, 13, 16, 15, 1, -19 },
  { 304, 5, 9, 7, 1, -4 },
  { 310, 7, 3, 10, 2, -11 },
  { 313, 5, 4, 9, 2, -4 },
  { 316, 10, 24, 11, 0, -22 },
  { 346, 12, 22, 16, 2, -22 },
  { 379, 9, 22, 16, 2, -22 },
  { 404, 13, 22, 16, 1, -22 },
  { 440, 13, 22, 16, 1, -22 },
  { 476, 14, 22, 16, 1, -22 },
  { 515, 12, 22, 16, 2, -22 },
  { 548, 12, 22, 16, 2, -22 },
  { 581, 13, 22, 16, 1, -22 },
  { 617, 12, 22, 16, 2, -22 },
  { 650, 13, 22, 16, 1, -22 },
  { 686, 5, 17, 8, 2, -17 },
  { 697, 5, 22, 8, 1, -17 },
  { 711, 11, 15, 14, 1, -17 },
  { 732, 11, 10, 15, 2, -15 },
  { 746, 11, 15, 14, 2, -17 },
  { 767, 11, 22, 14, 1, -22 },
  { 798, 22, 29, 24, 1, -22 },
  { 878, 18, 22, 18, 0, -22 },
  { 928, 14, 22, 17, 2, -22 },
  { 967, 15, 22, 18, 2, -22 },
  { 1009, 14, 22, 18, 2, -22 },
  { 1048, 12, 22, 15, 2, -22 },
  { 1081, 12, 22, 15, 2, -22 },
  { 1114, 15, 22, 18, 2, -22 },
  { 1156, 15, 22, 19, 2, -22 },
  { 1198, 4, 22, 8, 2, -22 },
  { 1209, 12, 22, 15, 1, -22 },
  { 1242, 15, 22, 17, 2, -22 },
  { 1284, 12, 22, 15, 2, -22 },
  { 1317, 20, 22, 23, 2, -22 },
  { 1372, 15, 22, 19, 2, -22 },
  { 1414, 15, 22, 19, 2, -22 },
  { 1456, 14, 22, 18, 2, -22 },
  { 1495, 16, 26, 19, 1, -22 },
  { 1547, 14, 22, 17, 2, -22 },
  { 1586, 14, 22, 17, 1, -22 },
  { 1625, 15, 22, 17, 1, -22 },
  { 1667, 14, 22, 18, 2, -22 },
  { 1706, 17, 22, 18, 0, -22 },
  { 1753, 22, 22, 23, 1, -22 },
  { 1814, 16, 22, 17, 1, -22 },
  { 1858, 16, 22, 17, 0, -22 },
  { 1902, 14, 22, 16, 1, -22 },
  { 1941, 5, 31, 8, 2, -26 },
  { 1961, 12, 24, 12, 0, -22 },
  { 1997, 5, 31, 8, 1, -26 },
  { 2017, 10, 11, 12, 1, -22 },
  { 2031, 12, 3, 12, 0, 0 },
  { 2036, 7, 5, 10, 1, -24 },
  { 2041, 13, 17, 15, 1, -17 },
  { 2069, 12, 23, 15, 2, -23 },
  { 2104, 12, 17, 14, 1, -17 },
  { 2130, 13, 23, 15, 1, -23 },
  { 2168, 13, 17, 15, 1, -17 },
  { 2196, 9, 23, 10, 1, -23 },
  { 2222, 13, 23, 16, 1, -17 },
  { 2260, 12, 23, 15, 2, -23 },
  { 2295, 4, 23, 8, 2, -23 },
  { 2307, 7, 29, 7, -1, -23 },
  { 2333, 13, 23, 15, 2, -23 },
  { 2371, 4, 23, 8, 2, -23 },
  { 2383, 19, 17, 23, 2, -17 },
  { 2424, 12, 17, 15, 2, -17 },
  { 2450, 13, 17, 15, 1, -17 },
  { 2478, 12, 23, 15, 2, -17 },
  { 2513, 13, 23, 15, 1, -17 },
  { 2551, 7, 17, 10, 2, -17 },
  { 2566, 12, 17, 14, 1, -17 },
  { 2592, 9, 20, 9, 0, -20 },
  { 2615, 12, 17, 15, 2, -17 },
  { 2641, 13, 17, 14, 0, -17 },
  { 2669, 18, 17, 20, 1, -17 },
  { 2708, 12, 17, 14, 1, -17 },
  { 2734, 13, 23, 14, 0, -17 },
  { 2772, 12, 17, 14, 1, -17 },
  { 2798, 8, 29, 9, 1, -24 },
  { 2827, 2, 26, 8, 3, -22 },
  { 2834, 7, 29, 9, 1, -24 },
  { 2860, 14, 7, 18, 2, -13 },
};

const GFXfont RobotoCondensed_SemiBold31pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_SemiBold31pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_SemiBold31pt7bGlyphs,
  0x20, 0x7E, 36
};

#endif // _ROBOTOCONDENSED_SEMIBOLD31PT7B_H_
