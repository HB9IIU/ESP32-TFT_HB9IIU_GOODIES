#ifndef _ROBOTOCONDENSED_SEMIBOLD32PT7B_H_
#define _ROBOTOCONDENSED_SEMIBOLD32PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-SemiBold.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_SemiBold32pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0x00, 0x07, 0xFF,
  0x70, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0x03, 0x18, 0x06,
  0x70, 0x1C, 0xE0, 0x39, 0xC0, 0x73, 0x80, 0xE6, 0x1F, 0xFF, 0xBF, 0xFF,
  0x7F, 0xFE, 0x1C, 0xE0, 0x39, 0xC0, 0x73, 0x80, 0xC6, 0x01, 0x8C, 0x3F,
  0xFF, 0x7F, 0xFE, 0xFF, 0xFC, 0x39, 0xC0, 0x73, 0x80, 0xC6, 0x01, 0x8C,
  0x03, 0x38, 0x0E, 0x70, 0x00, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1F, 0x03,
  0xFE, 0x3F, 0xF1, 0xF7, 0xDF, 0x1E, 0xF0, 0xF7, 0x87, 0xBC, 0x00, 0xF0,
  0x07, 0xC0, 0x1F, 0x80, 0x7F, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0x80, 0x3D,
  0xE0, 0xFF, 0x0F, 0xF8, 0x7B, 0xE7, 0xCF, 0xFE, 0x3F, 0xE0, 0xFC, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x18,
  0xE3, 0x8C, 0x71, 0x86, 0x39, 0xC3, 0x1C, 0xC1, 0x8E, 0xE0, 0xFF, 0x60,
  0x3F, 0x70, 0x0F, 0x30, 0x00, 0x38, 0x00, 0x39, 0xE0, 0x1D, 0xF8, 0x1D,
  0xFE, 0x0C, 0xE7, 0x0E, 0x63, 0x86, 0x31, 0xC7, 0x18, 0xE3, 0x0E, 0x70,
  0x87, 0xF8, 0x01, 0xF8, 0x00, 0x78, 0x07, 0x80, 0x0F, 0xF0, 0x07, 0xFC,
  0x07, 0xDE, 0x03, 0xC7, 0x01, 0xC3, 0x80, 0xF1, 0xC0, 0x79, 0xE0, 0x3F,
  0xE0, 0x0F, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x03, 0xF8, 0xF3, 0xDE, 0x79,
  0xEF, 0xB9, 0xE3, 0xDC, 0xF0, 0xFE, 0x78, 0x7F, 0x3E, 0x1F, 0x0F, 0x9F,
  0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x3E, 0x3C, 0xFF, 0xFF, 0xFF, 0x02, 0x0C,
  0x38, 0xE1, 0xC7, 0x0E, 0x38, 0x70, 0xE3, 0xC7, 0x8F, 0x1C, 0x38, 0x70,
  0xE1, 0xC3, 0x87, 0x8F, 0x1E, 0x1C, 0x38, 0x70, 0x70, 0xE0, 0xE1, 0xC1,
  0xC1, 0x81, 0x80, 0xE0, 0xE0, 0x70, 0x78, 0x38, 0x3C, 0x1C, 0x1C, 0x1E,
  0x1E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0F, 0x0F, 0x0F, 0x0E, 0x0E, 0x0E, 0x1E,
  0x1E, 0x1C, 0x1C, 0x3C, 0x38, 0x38, 0x70, 0xE0, 0xE0, 0x80, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x73, 0x99, 0xFF, 0xF7, 0xFF, 0xC3, 0xF8,
  0x07, 0xC0, 0x3F, 0x01, 0xCE, 0x0F, 0x3C, 0x38, 0x70, 0x20, 0x80, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC3, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC1, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x7B, 0xDE, 0xF7, 0xBB, 0xDC, 0x40, 0xFF, 0xFF, 0xF8,
  0x27, 0xBF, 0xF7, 0x00, 0x01, 0xC0, 0x70, 0x1C, 0x0E, 0x03, 0x80, 0xE0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x0E, 0x03, 0x80, 0xE0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0xE0, 0x00,
  0x0F, 0x81, 0xFE, 0x1F, 0xF8, 0xFB, 0xCF, 0x0F, 0x78, 0x7B, 0xC3, 0xDE,
  0x1E, 0xF0, 0xF7, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC3,
  0xDE, 0x1E, 0xF0, 0xF7, 0x87, 0xBC, 0x3C, 0xF3, 0xC7, 0xFE, 0x1F, 0xE0,
  0x7E, 0x00, 0x01, 0x83, 0xC7, 0xFF, 0xFF, 0xFF, 0xBE, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0xC0, 0x7F, 0x83, 0xFF, 0x1F, 0x7E, 0x78,
  0x7B, 0xC1, 0xEF, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00,
  0x7C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xE0, 0x1F, 0x00, 0x78, 0x03,
  0xE0, 0x1F, 0x00, 0x7F, 0xFD, 0xFF, 0xF7, 0xFF, 0xC0, 0x0F, 0x81, 0xFF,
  0x1F, 0xFC, 0xFB, 0xF7, 0x87, 0xF8, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x0F, 0x83, 0xF8, 0x1F, 0xC0, 0xFF, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0xF0,
  0x7F, 0x83, 0xFE, 0x1E, 0xFB, 0xF7, 0xFF, 0x1F, 0xF0, 0x3E, 0x00, 0x00,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0x7F, 0x03,
  0xBC, 0x1E, 0xF0, 0x73, 0xC3, 0xCF, 0x0E, 0x3C, 0x78, 0xF1, 0xE3, 0xCF,
  0x0F, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x7F, 0xF3, 0xFF, 0x9F, 0xFC, 0xFF, 0xE7, 0x80,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF7, 0x87, 0xFF, 0x3F, 0xFD, 0xF3, 0xE0,
  0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0xF0, 0x7F, 0x87, 0xFC, 0x3D, 0xFB,
  0xE7, 0xFE, 0x1F, 0xE0, 0x3E, 0x00, 0x03, 0xC0, 0x7E, 0x07, 0xF0, 0x7F,
  0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF7, 0xC7, 0xFF, 0x3F, 0xFD,
  0xF3, 0xEF, 0x0F, 0x78, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFE,
  0x3C, 0xFB, 0xE7, 0xFE, 0x1F, 0xE0, 0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xE0,
  0x00, 0x1F, 0x83, 0xFC, 0x7F, 0xEF, 0xFF, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xF7, 0xFE, 0x3F, 0xC3, 0xFC, 0x7F, 0xEF, 0x9F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0xDF, 0x7F, 0xE3, 0xFE, 0x1F, 0x80,
  0x0F, 0x80, 0xFF, 0x0F, 0xFC, 0xFB, 0xE7, 0x8F, 0xBC, 0x3D, 0xE1, 0xFE,
  0x0F, 0xF0, 0x7B, 0xC3, 0xDE, 0x1E, 0xF9, 0xF3, 0xFF, 0x9F, 0xFC, 0x3D,
  0xE0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x7C, 0x1F, 0xC1, 0xFC, 0x0F, 0xC0,
  0x78, 0x00, 0x27, 0xBF, 0xF7, 0x00, 0x00, 0x00, 0x00, 0x00, 0x13, 0xDF,
  0xFB, 0x80, 0x11, 0xE7, 0x9E, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x9E, 0x79, 0xE7, 0x9E, 0x73, 0x86, 0x00, 0x00, 0x20, 0x1C, 0x0F,
  0x87, 0xF1, 0xFC, 0xFE, 0x3F, 0x07, 0x80, 0xFC, 0x0F, 0xE0, 0xFF, 0x07,
  0xF0, 0x3E, 0x01, 0xC0, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x1C, 0x03, 0xE0, 0x7F,
  0x07, 0xF8, 0x3F, 0xC1, 0xF8, 0x0F, 0x07, 0xE3, 0xFD, 0xFE, 0x7F, 0x0F,
  0x81, 0xC0, 0x20, 0x00, 0x1F, 0x83, 0xFC, 0x7F, 0xEF, 0xFE, 0xF0, 0xFF,
  0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x78, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x1F, 0x00,
  0xF0, 0x0E, 0x00, 0x00, 0x7E, 0x00, 0x07, 0xFE, 0x00, 0x7E, 0x7E, 0x03,
  0xC0, 0x38, 0x1E, 0x00, 0x70, 0x70, 0x00, 0xE3, 0x80, 0x03, 0x8E, 0x0F,
  0x86, 0x70, 0x7F, 0x1D, 0xC3, 0xFC, 0x77, 0x1E, 0x70, 0xDC, 0x71, 0xC3,
  0x61, 0xC7, 0x0F, 0x8E, 0x1C, 0x3E, 0x38, 0x70, 0xF8, 0xE1, 0xC7, 0xE3,
  0x87, 0x1F, 0x8E, 0x1C, 0x76, 0x3C, 0xF1, 0x98, 0x7F, 0xDE, 0x71, 0xFF,
  0xF1, 0xC3, 0xCF, 0x87, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xEE, 0x00, 0x3D, 0xE0, 0x07, 0xBC, 0x00, 0xE3, 0x80, 0x3C,
  0x78, 0x07, 0x8F, 0x00, 0xF1, 0xE0, 0x3C, 0x1E, 0x07, 0x83, 0xC0, 0xFF,
  0xF8, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0xF0, 0x1E, 0x3E, 0x03, 0xC7, 0xC0,
  0x7C, 0xF0, 0x07, 0x9E, 0x00, 0xF0, 0xFF, 0xC3, 0xFF, 0xCF, 0xFF, 0xBF,
  0xFE, 0xF0, 0x7F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x7F, 0xC3, 0xEF,
  0xFF, 0x3F, 0xFC, 0xFF, 0xFB, 0xC1, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x7F, 0xFF, 0xFB, 0xFF, 0xCF, 0xFE, 0x00, 0x07,
  0xE0, 0x3F, 0xE0, 0xFF, 0xE3, 0xFF, 0xEF, 0x83, 0xDE, 0x03, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xE0, 0xF3, 0xF7,
  0xE3, 0xFF, 0x83, 0xFE, 0x01, 0xF8, 0x00, 0xFF, 0x81, 0xFF, 0xC3, 0xFF,
  0xC7, 0xFF, 0xCF, 0x07, 0x9E, 0x07, 0xBC, 0x0F, 0x78, 0x1E, 0xF0, 0x3D,
  0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0x78,
  0x1E, 0xF0, 0x3D, 0xE0, 0x7B, 0xC1, 0xE7, 0x9F, 0xCF, 0xFF, 0x1F, 0xFC,
  0x3F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3F, 0xFD, 0xFF, 0xEF, 0xFF,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xFF, 0xEF, 0xFE, 0xFF,
  0xEF, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x00, 0x0F, 0xE0, 0x3F, 0xF0, 0xFF, 0xF3, 0xFF, 0xEF,
  0x83, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x87, 0xFF, 0x0F, 0xFE, 0x1F, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F,
  0xF0, 0x3F, 0xE0, 0x7B, 0xFF, 0xF3, 0xFF, 0xE3, 0xFF, 0x01, 0xF8, 0x00,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0xF0, 0xFF, 0x87, 0xFC, 0x3D, 0xFF, 0xE7, 0xFE, 0x1F, 0xE0, 0x7E, 0x00,
  0xF0, 0x3E, 0xF0, 0x3E, 0xF0, 0x7C, 0xF0, 0xF8, 0xF0, 0xF8, 0xF1, 0xF0,
  0xF3, 0xE0, 0xF3, 0xE0, 0xF7, 0xC0, 0xF7, 0x80, 0xFF, 0x80, 0xFF, 0xC0,
  0xFF, 0xC0, 0xFF, 0xE0, 0xF9, 0xE0, 0xF9, 0xF0, 0xF0, 0xF0, 0xF0, 0xF8,
  0xF0, 0x78, 0xF0, 0x7C, 0xF0, 0x3C, 0xF0, 0x3E, 0xF0, 0x1E, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x01, 0xFF,
  0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x7F,
  0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xF7, 0x0E,
  0xFF, 0x78, 0xEF, 0xF7, 0x9E, 0xFF, 0x39, 0xCF, 0xF3, 0xDC, 0xFF, 0x3F,
  0xCF, 0xF1, 0xFC, 0xFF, 0x1F, 0x8F, 0xF1, 0xF8, 0xFF, 0x1F, 0x8F, 0xF0,
  0xF0, 0xFF, 0x0F, 0x0F, 0xF0, 0xF0, 0xF0, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xFC, 0x0F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0xFF, 0x0F, 0xFF,
  0x0F, 0xF7, 0x8F, 0xF7, 0x8F, 0xF3, 0xCF, 0xF3, 0xCF, 0xF1, 0xEF, 0xF1,
  0xEF, 0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF0,
  0x3F, 0xF0, 0x1F, 0xF0, 0x1F, 0x07, 0xE0, 0x1F, 0xF0, 0x3F, 0xFC, 0x7F,
  0xFC, 0x78, 0x3E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1E, 0xF0, 0x1E, 0xF8, 0x3E, 0x7F, 0xFC, 0x3F, 0xFC, 0x1F,
  0xF8, 0x07, 0xE0, 0xFF, 0xE1, 0xFF, 0xE3, 0xFF, 0xE7, 0xFF, 0xEF, 0x03,
  0xDE, 0x07, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0xC0, 0xF7,
  0xFF, 0xEF, 0xFF, 0x9F, 0xFE, 0x3F, 0xF8, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0xC0, 0x1F, 0xF0, 0x3F, 0xF8, 0x7F, 0xFC, 0xF8, 0x3E, 0xF0, 0x1E, 0xF0,
  0x1E, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1E, 0xF0, 0x1E, 0xF8,
  0x3E, 0x7F, 0xFC, 0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xFC, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0E, 0x00, 0x04, 0xFF, 0xC1, 0xFF, 0xE3, 0xFF, 0xE7, 0xFF,
  0xEF, 0x07, 0xDE, 0x07, 0xBC, 0x0F, 0x78, 0x1E, 0xF0, 0x3D, 0xE0, 0xFB,
  0xC7, 0xE7, 0xFF, 0xCF, 0xFF, 0x1F, 0xFC, 0x3C, 0x78, 0x78, 0xF8, 0xF0,
  0xF1, 0xE1, 0xF3, 0xC1, 0xE7, 0x83, 0xEF, 0x07, 0xDE, 0x07, 0xBC, 0x0F,
  0x80, 0x07, 0xE0, 0x3F, 0xE0, 0xFF, 0xE3, 0xF7, 0xE7, 0x83, 0xCF, 0x07,
  0xDE, 0x07, 0xBC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7F, 0x80, 0x7F, 0x80,
  0x3F, 0x80, 0x1F, 0x80, 0x0F, 0x80, 0x1F, 0xF0, 0x1F, 0xF0, 0x3D, 0xE0,
  0xFB, 0xF7, 0xE3, 0xFF, 0xC3, 0xFF, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x00, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81,
  0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F,
  0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0,
  0x3D, 0xE0, 0x7B, 0xE0, 0xF7, 0xFF, 0xE7, 0xFF, 0x87, 0xFE, 0x03, 0xF0,
  0x00, 0x78, 0x07, 0xDE, 0x01, 0xF7, 0xC0, 0x79, 0xF0, 0x1E, 0x3C, 0x0F,
  0x8F, 0x03, 0xC3, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x1F, 0x07, 0x87, 0x81,
  0xF1, 0xE0, 0x3C, 0x78, 0x0F, 0x3C, 0x03, 0xCF, 0x00, 0x7B, 0xC0, 0x1E,
  0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0x7C, 0x00, 0x1E, 0x00, 0xF0, 0x78, 0x3F, 0xC1, 0xE0, 0xFF, 0x07,
  0x83, 0xFC, 0x1F, 0x0F, 0x78, 0xFC, 0x3D, 0xE3, 0xF1, 0xE7, 0x8F, 0xC7,
  0x9E, 0x3F, 0x1E, 0x78, 0xFC, 0x78, 0xE3, 0xF9, 0xE3, 0xDE, 0xE7, 0x0F,
  0x73, 0xBC, 0x3D, 0xCE, 0xF0, 0xF7, 0x3B, 0xC3, 0xDC, 0xFF, 0x07, 0xF1,
  0xFC, 0x1F, 0x87, 0xE0, 0x7E, 0x1F, 0x81, 0xF8, 0x7E, 0x07, 0xE1, 0xF8,
  0x0F, 0x83, 0xE0, 0x3C, 0x0F, 0x00, 0xF0, 0x3C, 0x00, 0xF8, 0x1F, 0x78,
  0x1E, 0x7C, 0x3E, 0x3C, 0x3C, 0x3E, 0x3C, 0x1E, 0x78, 0x1E, 0x78, 0x0F,
  0xF0, 0x0F, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x1F, 0xF8, 0x1E, 0x78, 0x3E, 0x78, 0x3C, 0x7C, 0x7C,
  0x3C, 0x78, 0x3E, 0xF8, 0x1E, 0xF8, 0x1F, 0x78, 0x0F, 0xBC, 0x07, 0x9F,
  0x07, 0xC7, 0x83, 0xC3, 0xC1, 0xE0, 0xF1, 0xF0, 0x78, 0xF0, 0x3E, 0x78,
  0x0F, 0x78, 0x07, 0xBC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0,
  0x0F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF,
  0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF,
  0x3C, 0xFF, 0xFF, 0xC0, 0xF8, 0x07, 0x80, 0x78, 0x07, 0x80, 0x3C, 0x03,
  0xC0, 0x3C, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0x78, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xF0, 0x0F, 0x00, 0xF0, 0xFF, 0xFE, 0xF7, 0xBD, 0xEF, 0x7B,
  0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xFF,
  0xFF, 0xE0, 0x0E, 0x03, 0xC0, 0x7C, 0x0F, 0x83, 0xF0, 0x77, 0x1C, 0xE3,
  0x9C, 0x71, 0xDE, 0x3B, 0x87, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8,
  0x78, 0x3C, 0x1E, 0x0E, 0x0F, 0xC1, 0xFF, 0x1F, 0xFC, 0xF1, 0xE7, 0x8F,
  0x00, 0x78, 0x03, 0xC1, 0xFE, 0x3F, 0xF3, 0xFF, 0x9E, 0x3D, 0xE1, 0xEF,
  0x0F, 0x7C, 0xF9, 0xFF, 0xCF, 0xEF, 0x1E, 0x78, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0xF8, 0xFF, 0xE7, 0xFF,
  0xBF, 0x7D, 0xE1, 0xEF, 0x0F, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F,
  0x83, 0xFC, 0x3F, 0xE1, 0xEF, 0xDF, 0x7F, 0xFB, 0xFF, 0x9C, 0xF8, 0x0F,
  0xC1, 0xFF, 0x1F, 0xFC, 0xFB, 0xE7, 0x87, 0xF8, 0x3F, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0xF7, 0x87, 0xBE, 0xF9, 0xFF, 0xC7,
  0xFC, 0x0F, 0x80, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE3, 0xEF, 0x3F, 0xFB, 0xFF, 0xDF, 0x7F, 0xF0, 0xFF, 0x07,
  0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xF0, 0xF7,
  0xDF, 0xBF, 0xFC, 0xFF, 0xE3, 0xEF, 0x0F, 0xC0, 0xFF, 0x0F, 0xFC, 0xFB,
  0xE7, 0x87, 0xFC, 0x3F, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01,
  0xF0, 0x07, 0x81, 0x3F, 0x78, 0xFF, 0xE3, 0xFE, 0x0F, 0xC0, 0x07, 0x8F,
  0xC7, 0xE7, 0xC3, 0xC1, 0xE0, 0xF1, 0xFF, 0xFF, 0xFF, 0xCF, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x1F, 0x39, 0xFD, 0xDF, 0xFE, 0xF9, 0xF7, 0x87, 0xF8, 0x3F, 0xC1,
  0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xF7, 0x87, 0xBF, 0xFD,
  0xFF, 0xE7, 0xFF, 0x1F, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF3, 0x8F, 0x9F,
  0xF8, 0xFF, 0x81, 0xF8, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x7C, 0xFF, 0xEF, 0xFE, 0xFB, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1E, 0x3C, 0x78, 0xE0, 0x00, 0x07, 0x8F, 0x1E,
  0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7,
  0x8F, 0x1E, 0x3E, 0xFF, 0xEF, 0xDE, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x3E, 0xF1, 0xF7, 0x9F, 0x3C,
  0xF1, 0xEF, 0x0F, 0xF8, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x87, 0xFC,
  0x3C, 0xF1, 0xE7, 0xCF, 0x1E, 0x78, 0xFB, 0xC3, 0xDE, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xC7,
  0xCF, 0xFE, 0xFE, 0xFF, 0xFF, 0xEF, 0xBF, 0xDF, 0xF0, 0xF0, 0xFF, 0x0F,
  0x0F, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0xF0,
  0xF0, 0xFF, 0x0F, 0x0F, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0xF0, 0xF0, 0xFF,
  0x0F, 0x0F, 0xF0, 0xF0, 0xF0, 0xE7, 0xCF, 0xFE, 0xFF, 0xEF, 0xBF, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xF0, 0x0F, 0xC0, 0x7F, 0x83, 0xFF,
  0x1F, 0x3E, 0x78, 0x7B, 0xE1, 0xEF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x1F, 0x78, 0x79, 0xF3, 0xE3, 0xFF, 0x07, 0xF8, 0x0F,
  0xC0, 0xE7, 0xC7, 0xFF, 0x3F, 0xFD, 0xF3, 0xEF, 0x0F, 0x78, 0x7F, 0xC1,
  0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE1, 0xFF, 0x0F, 0x7C, 0xFB,
  0xFF, 0xDF, 0xFC, 0xF7, 0xC7, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0x1F, 0x79, 0xFF, 0xDF, 0xFE, 0xF9, 0xFF, 0x87,
  0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF,
  0x87, 0xBE, 0xFD, 0xFF, 0xE7, 0xFF, 0x1F, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0xF7, 0xFF, 0xFF, 0xFF, 0xF8,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0x0F, 0x83, 0xFE, 0x7F, 0xE7, 0x9F, 0x70, 0xF7, 0x80, 0x7C, 0x07, 0xF8,
  0x3F, 0xC0, 0xFE, 0x01, 0xFF, 0x0F, 0xF0, 0xFF, 0x8F, 0x7F, 0xF3, 0xFE,
  0x1F, 0x80, 0x3C, 0x1E, 0x0F, 0x07, 0x8F, 0xFF, 0xFF, 0xFE, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3E, 0x0F, 0x87, 0xE3,
  0xF0, 0xF8, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0xBF, 0xFF,
  0xF7, 0xFF, 0x3E, 0xF0, 0x78, 0x7D, 0xE1, 0xE7, 0x87, 0x9E, 0x1E, 0x3C,
  0x70, 0xF3, 0xC3, 0xCF, 0x07, 0x3C, 0x1E, 0xE0, 0x7F, 0x81, 0xFE, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0xF0, 0xE1,
  0xFE, 0x3C, 0x3B, 0xC7, 0x8F, 0x78, 0xF1, 0xE7, 0x1F, 0x3C, 0xE7, 0xE7,
  0x9E, 0xFC, 0xE3, 0xDF, 0x9C, 0x7B, 0xBF, 0x87, 0xE7, 0xF0, 0xFC, 0xFE,
  0x1F, 0x9F, 0x83, 0xF1, 0xF0, 0x3C, 0x3E, 0x07, 0x87, 0xC0, 0xF0, 0xF0,
  0x1E, 0x0E, 0x00, 0xF0, 0xF3, 0xC7, 0x9E, 0x78, 0x7B, 0xC3, 0xFC, 0x0F,
  0xE0, 0x7E, 0x01, 0xF0, 0x0F, 0x00, 0xFC, 0x07, 0xE0, 0x7F, 0x83, 0xFE,
  0x3E, 0xF1, 0xE7, 0xDF, 0x1E, 0xF0, 0xF8, 0xF8, 0x7D, 0xE1, 0xE7, 0x87,
  0x9E, 0x1E, 0x3C, 0xF0, 0xF3, 0xC3, 0xCF, 0x0F, 0x3C, 0x1F, 0xE0, 0x7F,
  0x81, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1E, 0x03, 0xE0, 0x3C, 0x07, 0x80,
  0x78, 0x0F, 0x01, 0xF0, 0x1E, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x02, 0x0F, 0x1F, 0x1E, 0x1C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x78, 0xF8, 0xE0, 0xF8, 0x78, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x1C, 0x1E, 0x1F, 0x0F, 0x02, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0xE0, 0xF0, 0x78, 0x78, 0x38, 0x38,
  0x38, 0x38, 0x38, 0x38, 0x38, 0x3C, 0x3C, 0x1F, 0x0F, 0x1F, 0x3C, 0x3C,
  0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x78, 0x78, 0xF0, 0xE0, 0xC0,
  0x3C, 0x1D, 0xF8, 0x7F, 0xF1, 0xFF, 0xFF, 0xE3, 0xFB, 0x87, 0xE0, 0x0F,
  0x00,
};

const GFXglyph RobotoCondensed_SemiBold32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 4, 23, 8, 2, -23 },
  { 13, 8, 8, 10, 1, -24 },
  { 21, 15, 23, 17, 1, -23 },
  { 65, 13, 29, 16, 2, -26 },
  { 113, 17, 23, 20, 2, -23 },
  { 162, 17, 23, 18, 1, -23 },
  { 211, 3, 8, 5, 1, -24 },
  { 214, 7, 32, 10, 2, -25 },
  { 242, 8, 32, 10, 1, -25 },
  { 274, 14, 14, 14, 0, -23 },
  { 299, 13, 17, 15, 1, -19 },
  { 327, 5, 9, 7, 1, -4 },
  { 333, 7, 3, 11, 2, -11 },
  { 336, 5, 5, 9, 2, -5 },
  { 340, 10, 25, 11, 0, -23 },
  { 372, 13, 23, 16, 2, -23 },
  { 410, 9, 23, 16, 2, -23 },
  { 436, 14, 23, 16, 1, -23 },
  { 477, 13, 23, 16, 1, -23 },
  { 515, 14, 23, 16, 1, -23 },
  { 556, 13, 23, 16, 2, -23 },
  { 594, 13, 23, 16, 2, -23 },
  { 632, 14, 23, 16, 1, -23 },
  { 673, 12, 23, 16, 2, -23 },
  { 708, 13, 23, 16, 1, -23 },
  { 746, 5, 18, 8, 2, -18 },
  { 758, 6, 23, 8, 1, -18 },
  { 776, 11, 15, 14, 1, -17 },
  { 797, 12, 9, 16, 2, -15 },
  { 811, 11, 15, 15, 2, -17 },
  { 832, 12, 23, 14, 1, -23 },
  { 867, 22, 29, 25, 1, -22 },
  { 947, 19, 23, 19, 0, -23 },
  { 1002, 14, 23, 18, 2, -23 },
  { 1043, 15, 23, 18, 2, -23 },
  { 1087, 15, 23, 18, 2, -23 },
  { 1131, 13, 23, 16, 2, -23 },
  { 1169, 12, 23, 15, 2, -23 },
  { 1204, 15, 23, 19, 2, -23 },
  { 1248, 16, 23, 20, 2, -23 },
  { 1294, 4, 23, 9, 2, -23 },
  { 1306, 13, 23, 16, 1, -23 },
  { 1344, 16, 23, 18, 2, -23 },
  { 1390, 12, 23, 15, 2, -23 },
  { 1425, 20, 23, 24, 2, -23 },
  { 1483, 16, 23, 20, 2, -23 },
  { 1529, 16, 23, 19, 2, -23 },
  { 1575, 15, 23, 18, 2, -23 },
  { 1619, 16, 27, 19, 2, -23 },
  { 1673, 15, 23, 18, 2, -23 },
  { 1717, 15, 23, 17, 1, -23 },
  { 1761, 15, 23, 17, 1, -23 },
  { 1805, 15, 23, 18, 2, -23 },
  { 1849, 18, 23, 18, 0, -23 },
  { 1901, 22, 23, 24, 1, -23 },
  { 1965, 16, 23, 18, 1, -23 },
  { 2011, 17, 23, 17, 0, -23 },
  { 2060, 15, 23, 17, 1, -23 },
  { 2104, 6, 31, 8, 2, -26 },
  { 2128, 12, 25, 12, 0, -23 },
  { 2166, 5, 31, 8, 1, -26 },
  { 2186, 11, 11, 12, 1, -23 },
  { 2202, 12, 3, 13, 0, 0 },
  { 2207, 8, 5, 10, 1, -24 },
  { 2212, 13, 17, 15, 1, -17 },
  { 2240, 13, 24, 16, 2, -24 },
  { 2279, 13, 17, 15, 1, -17 },
  { 2307, 13, 24, 16, 1, -24 },
  { 2346, 13, 17, 15, 1, -17 },
  { 2374, 9, 24, 10, 1, -24 },
  { 2401, 13, 24, 16, 1, -17 },
  { 2440, 12, 24, 16, 2, -24 },
  { 2476, 4, 23, 8, 2, -23 },
  { 2488, 7, 30, 8, -1, -23 },
  { 2515, 13, 24, 15, 2, -24 },
  { 2554, 4, 24, 8, 2, -24 },
  { 2566, 20, 17, 24, 2, -17 },
  { 2609, 12, 17, 16, 2, -17 },
  { 2635, 14, 17, 16, 1, -17 },
  { 2665, 13, 24, 16, 2, -17 },
  { 2704, 13, 24, 16, 1, -17 },
  { 2743, 8, 17, 10, 2, -17 },
  { 2760, 12, 17, 15, 1, -17 },
  { 2786, 9, 21, 10, 0, -21 },
  { 2810, 12, 17, 16, 2, -17 },
  { 2836, 14, 17, 14, 0, -17 },
  { 2866, 19, 17, 20, 1, -17 },
  { 2907, 13, 17, 14, 1, -17 },
  { 2935, 14, 24, 14, 0, -17 },
  { 2977, 12, 17, 14, 1, -17 },
  { 3003, 8, 31, 10, 1, -25 },
  { 3034, 2, 27, 8, 3, -23 },
  { 3041, 8, 31, 10, 1, -25 },
  { 3072, 14, 7, 18, 2, -13 },
};

const GFXfont RobotoCondensed_SemiBold32pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_SemiBold32pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_SemiBold32pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _ROBOTOCONDENSED_SEMIBOLD32PT7B_H_
