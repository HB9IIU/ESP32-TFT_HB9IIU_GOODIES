#ifndef _ROBOTOCONDENSED_SEMIBOLD56PT7B_H_
#define _ROBOTOCONDENSED_SEMIBOLD56PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-SemiBold.ttf
// Size: 56pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_SemiBold56pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0x7E, 0xFD, 0xFB,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x10, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xBE,
  0x00, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF,
  0x87, 0xFE, 0x1F, 0xF8, 0x7B, 0xE1, 0xEF, 0x87, 0xBE, 0x1E, 0xF8, 0x7B,
  0xC1, 0xEF, 0x07, 0x80, 0x00, 0x3C, 0x3E, 0x00, 0x0F, 0x0F, 0x80, 0x07,
  0xC3, 0xE0, 0x01, 0xF0, 0xF0, 0x00, 0x7C, 0x3C, 0x00, 0x1F, 0x0F, 0x00,
  0x07, 0x87, 0xC0, 0x01, 0xE1, 0xF0, 0x00, 0x78, 0x7C, 0x00, 0x3E, 0x1F,
  0x00, 0x0F, 0x87, 0x80, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0xF8, 0x00,
  0x7C, 0x3C, 0x00, 0x1F, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xE1, 0xF0,
  0x00, 0x78, 0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x87, 0x80, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x3C, 0x00, 0x1F, 0x0F, 0x00,
  0x07, 0x83, 0xC0, 0x01, 0xE1, 0xF0, 0x00, 0x78, 0x7C, 0x00, 0x3E, 0x1F,
  0x00, 0x0F, 0x87, 0xC0, 0x03, 0xE1, 0xE0, 0x00, 0xF8, 0x78, 0x00, 0x3C,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x7F, 0xC0,
  0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x81, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x3F,
  0xEF, 0xF8, 0xFE, 0x0F, 0xF7, 0xF0, 0x1F, 0xDF, 0xC0, 0x7F, 0x7F, 0x01,
  0xFD, 0xFC, 0x07, 0xF7, 0xF0, 0x1F, 0xDF, 0xC0, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x03, 0xFD, 0xFF, 0xBF, 0xF7, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x3F, 0xF0, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xE1,
  0xF0, 0x18, 0x0F, 0x87, 0xC0, 0xF0, 0x3E, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x1F, 0x03, 0xC0, 0xF0, 0x78, 0x0F, 0x03, 0xC3, 0xE0, 0x3C, 0x0F, 0x0F,
  0x00, 0xF8, 0x3C, 0x7C, 0x03, 0xE1, 0xF1, 0xE0, 0x0F, 0x87, 0xCF, 0x80,
  0x1F, 0xFE, 0x3C, 0x00, 0x7F, 0xF9, 0xF0, 0x00, 0xFF, 0xC7, 0x80, 0x01,
  0xFE, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC7, 0xF8, 0x00, 0x1E,
  0x3F, 0xF0, 0x00, 0xF9, 0xFF, 0xE0, 0x03, 0xCF, 0xFF, 0x80, 0x1F, 0x3E,
  0x3F, 0x00, 0x78, 0xF8, 0x7C, 0x03, 0xE3, 0xC1, 0xF0, 0x0F, 0x0F, 0x07,
  0xC0, 0x7C, 0x3C, 0x0F, 0x01, 0xE0, 0xF0, 0x3C, 0x0F, 0x83, 0xC1, 0xF0,
  0x3C, 0x0F, 0x07, 0xC1, 0xF0, 0x3E, 0x1F, 0x03, 0x80, 0xF8, 0x7C, 0x02,
  0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x3F, 0x9F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x1F,
  0xC1, 0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0x7E, 0x00, 0x3F, 0x03,
  0xF0, 0x01, 0xFC, 0x1F, 0x80, 0x0F, 0xE1, 0xF8, 0x00, 0x3F, 0x9F, 0xC0,
  0x01, 0xFD, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x7F, 0xFC, 0x1F, 0x83, 0xFF, 0xF0, 0xFC, 0x3F, 0xBF, 0x87,
  0xE3, 0xF9, 0xFE, 0x3F, 0x1F, 0xC7, 0xFB, 0xF9, 0xFE, 0x1F, 0xFF, 0xCF,
  0xE0, 0xFF, 0xFC, 0x7F, 0x03, 0xFF, 0xE3, 0xF8, 0x0F, 0xFF, 0x1F, 0xC0,
  0x7F, 0xF0, 0xFF, 0x01, 0xFF, 0x83, 0xF8, 0x07, 0xF8, 0x1F, 0xE0, 0x7F,
  0xE0, 0xFF, 0xDF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xF9, 0xFE, 0x03, 0xFF, 0x07, 0xF8, 0x01,
  0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x10, 0x01, 0xC0, 0x1E, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x0F,
  0x80, 0xFC, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFE, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x3E,
  0x01, 0xF8, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x00, 0xF8,
  0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xE0, 0x07, 0x00, 0x10, 0x20, 0x01,
  0xC0, 0x07, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xF0, 0x0F, 0x80,
  0x7E, 0x01, 0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xF0, 0x07, 0x80, 0x1C, 0x00,
  0x20, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x40, 0x3C, 0x00, 0x78,
  0x3C, 0x1C, 0x7E, 0x3C, 0x7E, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x03, 0xEF, 0x80, 0x07, 0xEF, 0xC0, 0x0F, 0xC7, 0xE0, 0x0F,
  0x83, 0xE0, 0x1F, 0x83, 0xF0, 0x1F, 0x01, 0xF0, 0x06, 0x00, 0xE0, 0x02,
  0x00, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC,
  0x7E, 0x3F, 0x3F, 0x9F, 0x8F, 0xCF, 0xC7, 0xE7, 0xE1, 0xE0, 0x20, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x7E, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFE, 0x7E, 0x10, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x0F, 0xFC, 0x00,
  0x7F, 0xF8, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xFC,
  0xFF, 0x1F, 0xE0, 0xFE, 0x7F, 0x03, 0xF9, 0xFC, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80,
  0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F,
  0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE,
  0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0x7F, 0x01,
  0xF9, 0xFC, 0x0F, 0xE7, 0xF8, 0x3F, 0x8F, 0xFB, 0xFC, 0x3F, 0xFF, 0xF0,
  0x7F, 0xFF, 0x80, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x3C, 0x03, 0xF8, 0x1F, 0xF0, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xC3, 0xFC, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x07,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F,
  0xE7, 0xFC, 0x7F, 0x83, 0xFC, 0x7F, 0x01, 0xFE, 0xFF, 0x01, 0xFE, 0xFE,
  0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x00, 0x10, 0x00, 0x07,
  0xFF, 0x00, 0x1F, 0xFF, 0x80, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0x1F, 0xFB, 0xFF, 0x3F, 0xC1, 0xFE, 0x7F, 0x01, 0xFD, 0xFE, 0x03,
  0xFF, 0xF8, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x03, 0xFF, 0xF0,
  0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFF, 0x80,
  0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFE, 0x03, 0xFD, 0xFE, 0x0F,
  0xF3, 0xFF, 0x3F, 0xE3, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x07, 0xFF, 0xFC,
  0x03, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0x20, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF8,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFB, 0xF8, 0x01, 0xFB, 0xF8,
  0x03, 0xF3, 0xF8, 0x03, 0xF3, 0xF8, 0x07, 0xE3, 0xF8, 0x07, 0xE3, 0xF8,
  0x0F, 0xC3, 0xF8, 0x0F, 0xC3, 0xF8, 0x1F, 0x83, 0xF8, 0x1F, 0x83, 0xF8,
  0x3F, 0x03, 0xF8, 0x3F, 0x03, 0xF8, 0x7F, 0x03, 0xF8, 0x7E, 0x03, 0xF8,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x1F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0x8F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xCF, 0xC0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xC7, 0xF0, 0x7F, 0xC0, 0xC0, 0x7F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF,
  0x80, 0x7F, 0x7F, 0x00, 0xFE, 0xFF, 0x01, 0xFC, 0xFF, 0x07, 0xF9, 0xFF,
  0x3F, 0xE1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x01, 0xFF,
  0xF0, 0x01, 0xFF, 0x80, 0x00, 0x30, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x7F,
  0x80, 0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF8,
  0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0x87, 0xC0, 0x7F, 0x3F, 0xE0, 0xFE, 0xFF, 0xF1, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xCF, 0xF8, 0x7F, 0xDF, 0xE0, 0x7F, 0xBF, 0x80,
  0x7F, 0x7F, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03,
  0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xDF, 0xC0, 0x3F,
  0xBF, 0x80, 0xFE, 0x7F, 0x01, 0xFC, 0x7F, 0x07, 0xF8, 0xFF, 0xBF, 0xE0,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x00,
  0xFF, 0x80, 0x00, 0x10, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0xFF,
  0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC7, 0xFC, 0xFF,
  0x9F, 0xE1, 0xFE, 0x7F, 0x03, 0xF9, 0xFC, 0x0F, 0xF7, 0xF0, 0x1F, 0xFF,
  0xC0, 0x7F, 0x7F, 0x03, 0xFD, 0xFC, 0x0F, 0xE7, 0xF0, 0x3F, 0x9F, 0xC0,
  0xFE, 0x3F, 0x87, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xF0,
  0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0x83, 0xFF, 0xFF, 0x1F, 0xE1, 0xFE, 0x7F,
  0x03, 0xF9, 0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01,
  0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xDF, 0xF3, 0xFE, 0x7F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xF0,
  0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x87, 0xFD, 0xFF, 0x1F, 0xE1, 0xFC, 0x7F,
  0x03, 0xFB, 0xF8, 0x0F, 0xEF, 0xE0, 0x1F, 0xBF, 0x80, 0x7F, 0xFE, 0x01,
  0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x03, 0xFD, 0xFE,
  0x1F, 0xF7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xF0, 0xFF, 0xDF, 0x80, 0xFC, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x0F,
  0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x7F, 0xC0,
  0x01, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE,
  0x7E, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x7E,
  0x10, 0x3F, 0x1F, 0xDF, 0xEF, 0xF7, 0xF9, 0xFC, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFC,
  0x7E, 0x3F, 0x3F, 0x1F, 0x9F, 0x8F, 0xC3, 0xC0, 0xC0, 0x00, 0x00, 0x20,
  0x00, 0x1C, 0x00, 0x07, 0x80, 0x03, 0xF0, 0x01, 0xFE, 0x00, 0xFF, 0xC0,
  0x7F, 0xF8, 0x3F, 0xFF, 0x1F, 0xFF, 0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0x7F,
  0xE0, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x80, 0x7F,
  0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x07, 0xFE, 0x00,
  0x3F, 0xC0, 0x01, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x04, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x3E, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xF0, 0x03,
  0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F,
  0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0xFF, 0xE0,
  0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x1F, 0xFF, 0x81, 0xFF, 0xF0,
  0x0F, 0xFE, 0x00, 0x7F, 0xC0, 0x03, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0xE0,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x3F, 0xF0, 0x07, 0xFF,
  0xE0, 0x7F, 0xFF, 0x87, 0xFF, 0xFE, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0xDF,
  0xE1, 0xFE, 0xFE, 0x07, 0xF7, 0xF0, 0x3F, 0xBF, 0x81, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x01, 0xF0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x07,
  0xE0, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x00,
  0x03, 0xC0, 0x7C, 0x00, 0x00, 0x07, 0xC1, 0xF0, 0x03, 0xF0, 0x07, 0x83,
  0xE0, 0x0F, 0xF8, 0x0F, 0x07, 0x80, 0x7F, 0xFC, 0x1F, 0x1F, 0x00, 0xFF,
  0xF8, 0x3E, 0x3E, 0x03, 0xFF, 0xF0, 0x3C, 0x78, 0x0F, 0xC3, 0xE0, 0x79,
  0xF0, 0x1F, 0x07, 0xC0, 0xF3, 0xE0, 0x7E, 0x0F, 0x81, 0xE7, 0xC0, 0xF8,
  0x1F, 0x03, 0xCF, 0x81, 0xF0, 0x3E, 0x07, 0xDF, 0x07, 0xE0, 0x7C, 0x0F,
  0xBC, 0x0F, 0x80, 0xF8, 0x1F, 0x78, 0x1F, 0x01, 0xE0, 0x3F, 0xF0, 0x3E,
  0x07, 0xC0, 0x7B, 0xE0, 0xFC, 0x0F, 0x80, 0xF7, 0xC1, 0xF8, 0x1F, 0x01,
  0xEF, 0x83, 0xF0, 0x3E, 0x03, 0xDF, 0x07, 0xE0, 0x7C, 0x07, 0x9E, 0x0F,
  0xC0, 0xF8, 0x1F, 0x3C, 0x1F, 0x81, 0xF0, 0x3C, 0x7C, 0x1F, 0x07, 0xE0,
  0x78, 0xF8, 0x3F, 0x0F, 0xC1, 0xF1, 0xF0, 0x7F, 0x3F, 0xC7, 0xC3, 0xE0,
  0xFF, 0xFF, 0xFF, 0x87, 0xC0, 0xFF, 0xDF, 0xFE, 0x07, 0xC0, 0xFF, 0x1F,
  0xF8, 0x0F, 0x80, 0xFC, 0x1F, 0xE0, 0x1F, 0x80, 0x40, 0x06, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x0C, 0x00, 0x00, 0x7F, 0xF3, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFB, 0xF0, 0x00,
  0x03, 0xF7, 0xF0, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x1F, 0xCF, 0xC0, 0x00,
  0x3F, 0x1F, 0x80, 0x00, 0xFE, 0x3F, 0x80, 0x01, 0xFC, 0x7F, 0x00, 0x03,
  0xF8, 0x7E, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x3F,
  0x83, 0xF8, 0x00, 0x7E, 0x03, 0xF8, 0x01, 0xFC, 0x07, 0xF0, 0x03, 0xF8,
  0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x1F, 0xE0, 0x03, 0xFC, 0x3F, 0x80, 0x03,
  0xF8, 0x7F, 0x00, 0x07, 0xF1, 0xFE, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x0F,
  0xE7, 0xF0, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFB, 0xFC,
  0x07, 0xFD, 0xFE, 0x01, 0xFE, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFB,
  0xFC, 0x01, 0xFD, 0xFE, 0x01, 0xFE, 0xFF, 0x07, 0xFE, 0x7F, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xF3, 0xFC, 0x03, 0xFD, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80,
  0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8,
  0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE1, 0xFE, 0x03, 0xFC,
  0x7F, 0x80, 0x3F, 0xCF, 0xE0, 0x03, 0xF9, 0xFC, 0x00, 0x7F, 0x7F, 0x80,
  0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFB, 0xF8, 0x00, 0xFE, 0x7F, 0x00, 0x1F,
  0xCF, 0xF0, 0x07, 0xF8, 0xFF, 0x01, 0xFE, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xC0,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0x8F, 0xF0, 0x3F, 0xE3, 0xFC, 0x03, 0xFC, 0xFF, 0x00, 0x7F,
  0x3F, 0xC0, 0x1F, 0xEF, 0xF0, 0x03, 0xFB, 0xFC, 0x00, 0xFE, 0xFF, 0x00,
  0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xBF, 0xC0, 0x0F, 0xEF, 0xF0, 0x07, 0xFB,
  0xFC, 0x01, 0xFC, 0xFF, 0x00, 0xFF, 0x3F, 0xC0, 0xFF, 0x8F, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFC, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xE1, 0xFE, 0x03, 0xFE, 0x7F, 0x80, 0x3F, 0xCF, 0xF0, 0x03, 0xF9,
  0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x3F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFB, 0xF8,
  0x00, 0x7F, 0x7F, 0x80, 0x0F, 0xEF, 0xF0, 0x01, 0xFC, 0xFF, 0x80, 0xFF,
  0x9F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xC0, 0x00,
  0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x7F,
  0xBF, 0x80, 0xFF, 0x7F, 0x81, 0xFC, 0xFF, 0x07, 0xF8, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x00,
  0xFF, 0xC0, 0x00, 0x10, 0x00, 0xFF, 0x00, 0x3F, 0xEF, 0xF0, 0x03, 0xFE,
  0xFF, 0x00, 0x7F, 0xCF, 0xF0, 0x07, 0xF8, 0xFF, 0x00, 0xFF, 0x8F, 0xF0,
  0x1F, 0xF0, 0xFF, 0x01, 0xFE, 0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x0F, 0xF8, 0x0F, 0xF0, 0xFF, 0x00, 0xFF,
  0x1F, 0xE0, 0x0F, 0xF1, 0xFE, 0x00, 0xFF, 0x3F, 0xC0, 0x0F, 0xF7, 0xF8,
  0x00, 0xFF, 0x7F, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xEF, 0xF0, 0x0F, 0xFC, 0xFF, 0x00,
  0xFF, 0x87, 0xF8, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x01, 0xFE, 0x0F, 0xF0, 0x1F, 0xE0, 0xFF, 0x00, 0xFF,
  0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0x7F, 0x8F, 0xF0, 0x07, 0xFC, 0xFF,
  0x00, 0x3F, 0xCF, 0xF0, 0x03, 0xFE, 0xFF, 0x00, 0x1F, 0xEF, 0xF0, 0x01,
  0xFF, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0xFC, 0x03, 0xF7, 0xFF, 0xEF,
  0xC0, 0x3F, 0x7F, 0xFE, 0xFE, 0x03, 0xF7, 0xFF, 0xEF, 0xE0, 0x3F, 0x7F,
  0xFE, 0x7E, 0x07, 0xE7, 0xFF, 0xE7, 0xE0, 0x7E, 0x7F, 0xFE, 0x7F, 0x07,
  0xE7, 0xFF, 0xE3, 0xF0, 0xFC, 0x7F, 0xFE, 0x3F, 0x0F, 0xC7, 0xFF, 0xE3,
  0xF8, 0xFC, 0x7F, 0xFF, 0x1F, 0x9F, 0xC7, 0xFF, 0xF1, 0xF9, 0xF8, 0x7F,
  0xFF, 0x1F, 0xDF, 0x87, 0xFF, 0xF0, 0xFD, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF,
  0x07, 0xFF, 0xF0, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0x07, 0xFF, 0xF0,
  0x7F, 0xE0, 0x7F, 0xFF, 0x07, 0xFE, 0x07, 0xFF, 0xF0, 0x7F, 0xE0, 0x7F,
  0xFF, 0x03, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xC0, 0x7F, 0xFF, 0x03, 0xFC,
  0x07, 0xFF, 0xF0, 0x1F, 0xC0, 0x7F, 0xFF, 0x01, 0xF8, 0x07, 0xFF, 0xF0,
  0x1F, 0x80, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80,
  0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFE, 0xFE, 0x07, 0xFF, 0xEF, 0xE0, 0x7F, 0xFE,
  0x7F, 0x07, 0xFF, 0xE7, 0xF0, 0x7F, 0xFE, 0x3F, 0x87, 0xFF, 0xE3, 0xF8,
  0x7F, 0xFE, 0x1F, 0xC7, 0xFF, 0xE1, 0xFC, 0x7F, 0xFE, 0x0F, 0xE7, 0xFF,
  0xE0, 0xFE, 0x7F, 0xFE, 0x07, 0xF7, 0xFF, 0xE0, 0x7F, 0x7F, 0xFE, 0x03,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0,
  0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x83,
  0xFE, 0x07, 0xFC, 0x7F, 0x80, 0x3F, 0xC7, 0xF8, 0x01, 0xFE, 0x7F, 0x00,
  0x0F, 0xEF, 0xF0, 0x00, 0xFE, 0xFF, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xE7,
  0xF0, 0x00, 0xFE, 0x7F, 0x80, 0x1F, 0xE7, 0xF8, 0x03, 0xFC, 0x3F, 0xE0,
  0x7F, 0xC3, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x40, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x3F, 0xC0,
  0x3F, 0xE7, 0xF8, 0x03, 0xFC, 0xFF, 0x00, 0x3F, 0xDF, 0xE0, 0x07, 0xFB,
  0xFC, 0x00, 0x7F, 0x7F, 0x80, 0x0F, 0xEF, 0xF0, 0x01, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xC0, 0x07, 0xF7, 0xF8, 0x00, 0xFE, 0xFF, 0x00, 0x1F, 0xDF,
  0xE0, 0x07, 0xFB, 0xFC, 0x01, 0xFF, 0x7F, 0x80, 0x7F, 0xCF, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x83, 0xFE, 0x07, 0xFC, 0x7F, 0x80, 0x3F,
  0xC7, 0xF8, 0x01, 0xFE, 0x7F, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0xFE, 0xFE,
  0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F,
  0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0xFE, 0xFF, 0x00, 0x0F, 0xE7, 0xF0, 0x01, 0xFE, 0x7F, 0x80, 0x1F,
  0xE7, 0xF8, 0x03, 0xFC, 0x3F, 0xE0, 0x7F, 0xC3, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x4F, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xFE, 0x3F, 0xC0, 0x7F, 0xC7, 0xF8, 0x03, 0xFC, 0xFF, 0x00, 0x7F, 0x9F,
  0xE0, 0x07, 0xF3, 0xFC, 0x00, 0xFE, 0x7F, 0x80, 0x1F, 0xCF, 0xF0, 0x03,
  0xF9, 0xFE, 0x00, 0x7F, 0x3F, 0xC0, 0x0F, 0xE7, 0xF8, 0x01, 0xFC, 0xFF,
  0x00, 0x7F, 0x9F, 0xE0, 0x1F, 0xE3, 0xFC, 0x07, 0xFC, 0x7F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xE0, 0xFF, 0x03, 0xFC, 0x1F, 0xE0,
  0x7F, 0x81, 0xFC, 0x0F, 0xF0, 0x3F, 0xC1, 0xFE, 0x07, 0xF8, 0x3F, 0xC0,
  0x7F, 0x87, 0xF8, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x1F, 0xE0, 0x1F, 0xE3,
  0xFC, 0x01, 0xFC, 0x7F, 0x80, 0x3F, 0xCF, 0xF0, 0x07, 0xF9, 0xFE, 0x00,
  0x7F, 0xBF, 0xC0, 0x0F, 0xF7, 0xF8, 0x00, 0xFF, 0x00, 0x04, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0xFF, 0x03, 0xFC, 0x7F, 0x80,
  0x7F, 0x9F, 0xC0, 0x0F, 0xE7, 0xF0, 0x03, 0xF9, 0xFC, 0x00, 0xFE, 0x7F,
  0x00, 0x3F, 0x9F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0x80, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xDF, 0xE0, 0x0F, 0xE7, 0xFC,
  0x07, 0xF8, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x1F,
  0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00,
  0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F,
  0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00,
  0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8,
  0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF,
  0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01,
  0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFC, 0x00, 0xFF, 0x7F, 0x00, 0x3F, 0x9F, 0xE0, 0x1F, 0xE7,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x00, 0x08, 0x00, 0x00, 0xFF,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xDF, 0xC0,
  0x00, 0xFE, 0x7F, 0x80, 0x07, 0xF9, 0xFE, 0x00, 0x1F, 0xE3, 0xF8, 0x00,
  0x7F, 0x8F, 0xE0, 0x01, 0xFC, 0x3F, 0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x3F,
  0xC1, 0xFC, 0x00, 0xFE, 0x07, 0xF0, 0x03, 0xF8, 0x1F, 0xE0, 0x1F, 0xE0,
  0x3F, 0x80, 0x7F, 0x80, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x07,
  0xF0, 0x3F, 0xC0, 0x1F, 0xC0, 0xFE, 0x00, 0x7F, 0x03, 0xF8, 0x01, 0xFC,
  0x0F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x3F, 0x87,
  0xF0, 0x00, 0x7E, 0x1F, 0xC0, 0x01, 0xFC, 0xFE, 0x00, 0x07, 0xF3, 0xF8,
  0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x7E, 0x00, 0x7F, 0x7F, 0x00,
  0x7F, 0x00, 0xFF, 0x7F, 0x00, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFF, 0x00,
  0xFE, 0x7F, 0x00, 0xFF, 0x00, 0xFE, 0x7F, 0x80, 0xFF, 0x00, 0xFE, 0x3F,
  0x80, 0xFF, 0x00, 0xFE, 0x3F, 0x80, 0xFF, 0x81, 0xFE, 0x3F, 0x81, 0xFF,
  0x81, 0xFC, 0x3F, 0x81, 0xFF, 0x81, 0xFC, 0x3F, 0x81, 0xFF, 0x81, 0xFC,
  0x3F, 0x81, 0xFF, 0x81, 0xFC, 0x1F, 0xC1, 0xFF, 0xC1, 0xFC, 0x1F, 0xC3,
  0xFF, 0xC1, 0xF8, 0x1F, 0xC3, 0xFF, 0xC3, 0xF8, 0x1F, 0xC3, 0xFF, 0xC3,
  0xF8, 0x1F, 0xC3, 0xF7, 0xC3, 0xF8, 0x0F, 0xC3, 0xF7, 0xE3, 0xF8, 0x0F,
  0xE3, 0xE7, 0xE3, 0xF8, 0x0F, 0xE7, 0xE7, 0xE3, 0xF0, 0x0F, 0xE7, 0xE7,
  0xE7, 0xF0, 0x0F, 0xE7, 0xE3, 0xE7, 0xF0, 0x07, 0xE7, 0xE3, 0xF7, 0xF0,
  0x07, 0xE7, 0xC3, 0xF7, 0xF0, 0x07, 0xEF, 0xC3, 0xF7, 0xE0, 0x07, 0xFF,
  0xC3, 0xF7, 0xE0, 0x07, 0xFF, 0xC1, 0xF7, 0xE0, 0x07, 0xFF, 0x81, 0xFF,
  0xE0, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x03,
  0xFF, 0x80, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x03, 0xFF, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x01, 0xFE,
  0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x7F,
  0x80, 0x7F, 0x80, 0x07, 0xFB, 0xFC, 0x00, 0x7F, 0x8F, 0xF0, 0x03, 0xFC,
  0x7F, 0x80, 0x3F, 0xC1, 0xFE, 0x01, 0xFE, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0xFF, 0x01, 0xFE, 0x07, 0xF0, 0x07, 0xF8, 0x7F, 0x80, 0x3F, 0xC3,
  0xF8, 0x00, 0xFE, 0x3F, 0xC0, 0x07, 0xF9, 0xFC, 0x00, 0x1F, 0xDF, 0xE0,
  0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x7F, 0x7F, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xFC,
  0x7F, 0x80, 0x1F, 0xE1, 0xFC, 0x01, 0xFE, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F,
  0x80, 0xFF, 0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0xC3,
  0xFC, 0x01, 0xFE, 0x3F, 0xE0, 0x07, 0xF9, 0xFE, 0x00, 0x3F, 0xDF, 0xF0,
  0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x7F, 0x9F, 0xC0, 0x03,
  0xFC, 0xFF, 0x00, 0x3F, 0xC7, 0xF8, 0x01, 0xFE, 0x1F, 0xC0, 0x0F, 0xE0,
  0xFF, 0x00, 0xFF, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0x7F,
  0x03, 0xFC, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0xE0, 0xFE, 0x00, 0x7F, 0x0F,
  0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x7F, 0x3F, 0x80,
  0x01, 0xF9, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xF8, 0xFE,
  0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F,
  0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8,
  0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F,
  0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3,
  0xF8, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xFC,
  0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F,
  0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1,
  0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F,
  0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7,
  0xF1, 0xFC, 0x7F, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFE, 0x01, 0xF3, 0xE0,
  0x3E, 0x7C, 0x0F, 0xCF, 0x81, 0xF1, 0xF8, 0x3E, 0x1F, 0x0F, 0xC3, 0xE1,
  0xF0, 0x7E, 0x3E, 0x07, 0xCF, 0xC0, 0xF9, 0xF8, 0x1F, 0xBE, 0x03, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0x80, 0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0x00, 0x10, 0x00, 0x0F, 0xFE, 0x00,
  0x7F, 0xFC, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE7, 0xF8,
  0x7F, 0x9F, 0xC0, 0xFE, 0x7F, 0x03, 0xF9, 0xFC, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x03, 0xFF, 0xE0, 0x7F, 0xFF, 0x87,
  0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xCF, 0xE7, 0xF8, 0x3F, 0x9F, 0xC0,
  0xFE, 0xFF, 0x03, 0xFB, 0xF8, 0x0F, 0xEF, 0xE0, 0x3F, 0xBF, 0x80, 0xFE,
  0xFF, 0x03, 0xF9, 0xFE, 0x3F, 0xE7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFC, 0x7F, 0xF7, 0xF0, 0x7F, 0x9F, 0xC0, 0x20, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE7, 0xFC, 0x1F,
  0xDF, 0xFC, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF,
  0x9F, 0xF3, 0xFC, 0x0F, 0xF7, 0xF0, 0x0F, 0xEF, 0xE0, 0x1F, 0xDF, 0xC0,
  0x3F, 0xBF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01,
  0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F,
  0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x01, 0xFD, 0xFC, 0x03, 0xFB,
  0xF8, 0x07, 0xF7, 0xF8, 0x1F, 0xEF, 0xFC, 0xFF, 0xDF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFE, 0x7F, 0xFF, 0xF8, 0xFE, 0xFF, 0xE1, 0xFC, 0xFF, 0x80, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xFC, 0x03, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE3, 0xFC, 0x7F, 0x9F, 0xE0, 0xFF,
  0x7F, 0x01, 0xFD, 0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x07, 0xF7, 0xF0, 0x1F, 0xDF, 0xC0, 0x7F, 0x7F, 0x83, 0xFC, 0xFF,
  0x3F, 0xE3, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF,
  0x00, 0x3F, 0xF0, 0x00, 0x04, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x7F, 0x8F, 0xE1, 0xFF, 0xDF, 0xC7, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0xFF, 0xDF, 0xFD, 0xFE, 0x0F,
  0xFB, 0xF8, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F,
  0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF,
  0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF,
  0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFE, 0x01, 0xFD, 0xFC, 0x07, 0xFB, 0xFC,
  0x0F, 0xF7, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0x0F, 0xFE, 0xFE, 0x0F, 0xF1, 0xFC, 0x01, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x81, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0x0F, 0xF9, 0xFF, 0x3F, 0xC0, 0xFE, 0x7F, 0x01, 0xFC,
  0xFE, 0x01, 0xF9, 0xFC, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x08, 0x7F, 0x80, 0x38, 0x7F, 0xE3,
  0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE,
  0x00, 0x7F, 0xF0, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x3F, 0xC0, 0x7F,
  0xE0, 0x7F, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x3F, 0xF6, 0x1F, 0xE0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x07, 0xFF, 0xFB,
  0xFF, 0xFD, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0x83, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0xFC, 0x3F, 0xFB, 0xF8, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xDF, 0xF9, 0xFF, 0xBF, 0xC0,
  0xFF, 0x7F, 0x00, 0xFE, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x07,
  0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F,
  0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF,
  0xE0, 0x0F, 0xFF, 0xE0, 0x1F, 0xDF, 0xC0, 0x3F, 0xBF, 0x80, 0x7F, 0x7F,
  0x81, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xE1, 0xFF, 0xDF, 0xC0, 0xFF, 0x3F, 0x80, 0x20, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x30, 0x07, 0xF8, 0x70, 0x1F, 0xE1, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xC0,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x81, 0x00,
  0xFE, 0x7F, 0x83, 0xFB, 0xFF, 0x8F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFB, 0xFF, 0x3F, 0xEF, 0xF0, 0x7F, 0xBF, 0x80, 0xFE, 0xFE, 0x03,
  0xFB, 0xF8, 0x0F, 0xEF, 0xE0, 0x3F, 0xBF, 0x80, 0xFF, 0xFE, 0x03, 0xFF,
  0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8,
  0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F,
  0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xF0, 0x18,
  0x7E, 0xFE, 0xFF, 0xFF, 0xFF, 0x7E, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xFE,
  0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE,
  0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE,
  0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0x01, 0x00, 0x7E, 0x0F, 0xE0, 0xFE, 0x0F,
  0xF0, 0xFE, 0x07, 0xE0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFE, 0x1F, 0xEF, 0xFE, 0xFF, 0xCF, 0xFC, 0xFF, 0x8F, 0xF0, 0xFC,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x3F, 0xDF, 0xC0, 0xFF, 0x3F, 0x83, 0xFE, 0x7F, 0x07, 0xF8, 0xFE,
  0x1F, 0xE1, 0xFC, 0x3F, 0xC3, 0xF8, 0xFF, 0x07, 0xF3, 0xFC, 0x0F, 0xE7,
  0xF0, 0x1F, 0xDF, 0xE0, 0x3F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0xFF, 0xFC,
  0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xE0, 0x3F, 0xEF, 0xE0, 0x7F, 0x9F, 0xE0, 0xFE, 0x1F, 0xC1,
  0xFC, 0x3F, 0xC3, 0xF8, 0x3F, 0x87, 0xF0, 0x7F, 0x8F, 0xE0, 0x7F, 0x1F,
  0xC0, 0xFF, 0x3F, 0x80, 0xFE, 0x7F, 0x01, 0xFE, 0xFE, 0x01, 0xFF, 0xFC,
  0x03, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE3, 0xFC, 0x1F, 0xF0,
  0xFE, 0xFF, 0xE3, 0xFF, 0x8F, 0xFF, 0xFF, 0x7F, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xDF, 0xFF, 0x7F, 0xEF, 0xF0,
  0x7F, 0xE0, 0xFE, 0xFE, 0x03, 0xFC, 0x0F, 0xEF, 0xE0, 0x3F, 0x80, 0xFF,
  0xFE, 0x03, 0xF8, 0x07, 0xFF, 0xE0, 0x3F, 0x80, 0x7F, 0xFE, 0x03, 0xF8,
  0x07, 0xFF, 0xE0, 0x3F, 0x80, 0x7F, 0xFE, 0x03, 0xF8, 0x07, 0xFF, 0xE0,
  0x3F, 0x80, 0x7F, 0xFE, 0x03, 0xF8, 0x07, 0xFF, 0xE0, 0x3F, 0x80, 0x7F,
  0xFE, 0x03, 0xF8, 0x07, 0xFF, 0xE0, 0x3F, 0x80, 0x7F, 0xFE, 0x03, 0xF8,
  0x07, 0xFF, 0xE0, 0x3F, 0x80, 0x7F, 0xFE, 0x03, 0xF8, 0x07, 0xFF, 0xE0,
  0x3F, 0x80, 0x7F, 0xFE, 0x03, 0xF8, 0x07, 0xFF, 0xE0, 0x3F, 0x80, 0x7F,
  0xFE, 0x03, 0xF8, 0x07, 0xFF, 0xE0, 0x3F, 0x80, 0x7F, 0xFE, 0x03, 0xF8,
  0x07, 0xFF, 0xE0, 0x3F, 0x80, 0x7F, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0xFF, 0x0F, 0xEF, 0xFE, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xEF, 0xFD, 0xFF, 0xBF, 0xC1, 0xFE, 0xFE, 0x03, 0xFB,
  0xF8, 0x0F, 0xEF, 0xE0, 0x3F, 0xBF, 0x80, 0xFE, 0xFE, 0x03, 0xFF, 0xF8,
  0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F,
  0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0,
  0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xE7, 0xFC, 0x7F, 0x81,
  0xFE, 0x7F, 0x01, 0xFE, 0x7F, 0x00, 0xFE, 0xFF, 0x00, 0xFE, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00,
  0xFE, 0x7F, 0x81, 0xFE, 0x3F, 0xE7, 0xFC, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0xFF, 0x83, 0xFB, 0xFF, 0x87, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x7F, 0x81, 0xFE,
  0xFE, 0x01, 0xFD, 0xFC, 0x03, 0xFB, 0xF8, 0x07, 0xF7, 0xF0, 0x0F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE,
  0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0,
  0x1F, 0xFF, 0xC0, 0x3F, 0xBF, 0x80, 0x7F, 0x7F, 0x00, 0xFE, 0xFF, 0x03,
  0xFD, 0xFF, 0x9F, 0xF3, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0x1F, 0xDF, 0xFC, 0x3F, 0x9F, 0xE0, 0x7F, 0x02, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF9, 0xFC, 0x3F, 0xFB, 0xF8, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xDF, 0xF9, 0xFF, 0xBF, 0xC0,
  0xFF, 0x7F, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07,
  0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F,
  0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF,
  0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x3F, 0xBF, 0x80, 0xFF, 0x7F,
  0x81, 0xFE, 0xFF, 0x8F, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xE1, 0xFF, 0xDF, 0xC1, 0xFE, 0x3F, 0x80, 0x20, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF9, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFC, 0x0F, 0xE0, 0x3F, 0x80,
  0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xC3, 0xFF, 0xFF, 0x1F,
  0xFF, 0xF9, 0xFE, 0x1F, 0xEF, 0xE0, 0x7F, 0x7F, 0x03, 0xFB, 0xF8, 0x1F,
  0xDF, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0xFF,
  0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x1F, 0xFC,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0,
  0x7F, 0xFE, 0x03, 0xFB, 0xF8, 0x3F, 0xDF, 0xFF, 0xFC, 0x7F, 0xFF, 0xE1,
  0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x04, 0x00, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x7F,
  0xFE, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xE1, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F,
  0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF8, 0x07, 0xFF, 0x0F, 0xFE,
  0x1F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x1F, 0xE0, 0x04, 0x00, 0xFE, 0x03,
  0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF,
  0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8,
  0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F,
  0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0x1F, 0xFD, 0xFC, 0x3F, 0xC7, 0xF0, 0x10, 0x00, 0x00,
  0xFE, 0x00, 0xFF, 0xFC, 0x03, 0xFD, 0xFC, 0x07, 0xF3, 0xF8, 0x0F, 0xE7,
  0xF0, 0x1F, 0xCF, 0xE0, 0x7F, 0x0F, 0xE0, 0xFE, 0x1F, 0xC1, 0xFC, 0x3F,
  0x83, 0xF8, 0x7F, 0x07, 0xE0, 0x7E, 0x1F, 0xC0, 0xFE, 0x3F, 0x81, 0xFC,
  0x7E, 0x01, 0xF8, 0xFC, 0x03, 0xF1, 0xF8, 0x07, 0xF7, 0xF0, 0x0F, 0xEF,
  0xC0, 0x0F, 0xDF, 0x80, 0x1F, 0xBF, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0xF8,
  0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x03, 0xE0, 0x1F, 0xBF, 0x80, 0xFC, 0x07, 0xE7,
  0xE0, 0x3F, 0x03, 0xF9, 0xF8, 0x1F, 0xC0, 0xFE, 0x7F, 0x07, 0xF0, 0x3F,
  0x9F, 0xC1, 0xFE, 0x0F, 0xC7, 0xF0, 0x7F, 0x83, 0xF0, 0xFC, 0x3F, 0xE1,
  0xFC, 0x3F, 0x0F, 0xF8, 0x7F, 0x0F, 0xC3, 0xFF, 0x1F, 0xC3, 0xF8, 0xFF,
  0xC7, 0xE0, 0x7E, 0x7F, 0xF1, 0xF8, 0x1F, 0x9F, 0xFC, 0x7E, 0x07, 0xE7,
  0xDF, 0xBF, 0x81, 0xF9, 0xF3, 0xEF, 0xE0, 0x7F, 0xFC, 0xFB, 0xF0, 0x0F,
  0xFF, 0x3E, 0xFC, 0x03, 0xFF, 0x8F, 0xFF, 0x00, 0xFF, 0xE1, 0xFF, 0xC0,
  0x3F, 0xF8, 0x7F, 0xE0, 0x0F, 0xFE, 0x1F, 0xF8, 0x01, 0xFF, 0x07, 0xFE,
  0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x1F, 0xF0, 0x3F, 0xE0, 0x07, 0xFC, 0x0F,
  0xF0, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x0F, 0xE0,
  0x1F, 0xC0, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x7F,
  0x01, 0xFE, 0xFF, 0x03, 0xF8, 0xFE, 0x0F, 0xF1, 0xFE, 0x1F, 0xC1, 0xFC,
  0x3F, 0x83, 0xFC, 0xFE, 0x03, 0xF9, 0xFC, 0x07, 0xF7, 0xF0, 0x07, 0xFF,
  0xE0, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x01,
  0xFF, 0xFC, 0x03, 0xFB, 0xF8, 0x0F, 0xF3, 0xF8, 0x1F, 0xC7, 0xF0, 0x7F,
  0x87, 0xF0, 0xFE, 0x0F, 0xE3, 0xFC, 0x1F, 0xE7, 0xF0, 0x1F, 0xDF, 0xE0,
  0x3F, 0xC0, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x07, 0xF3, 0xF8,
  0x0F, 0xE7, 0xF0, 0x3F, 0xCF, 0xE0, 0x7F, 0x1F, 0xE0, 0xFE, 0x1F, 0xC1,
  0xFC, 0x3F, 0x83, 0xF0, 0x7F, 0x0F, 0xE0, 0x7F, 0x1F, 0xC0, 0xFE, 0x3F,
  0x81, 0xFC, 0x7E, 0x01, 0xF9, 0xFC, 0x03, 0xF3, 0xF8, 0x07, 0xF7, 0xE0,
  0x0F, 0xEF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x00, 0x00,
  0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xBF, 0xFF, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0,
  0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x10, 0x03, 0xC0, 0x3E,
  0x03, 0xF0, 0x3F, 0x83, 0xF8, 0x1F, 0x81, 0xFC, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0xE0, 0x7E, 0x07, 0xF0, 0x7F, 0x87,
  0xF8, 0x3F, 0x81, 0xF8, 0x0F, 0xE0, 0x7F, 0x80, 0xFE, 0x03, 0xF0, 0x1F,
  0xC0, 0xFE, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x80,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0xFE, 0x03, 0xF0, 0x07, 0x80, 0x08, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x20,
  0x01, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFE, 0x01, 0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F,
  0x01, 0xFC, 0x0F, 0xF0, 0x7F, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0x01, 0xF8, 0x07, 0xE0, 0x3F,
  0x81, 0xFC, 0x07, 0xE0, 0x1F, 0x00, 0x78, 0x00, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xFC, 0x01, 0xF1, 0xFF, 0x80, 0xFC, 0xFF, 0xF0, 0x3F, 0x7F,
  0xFE, 0x0F, 0x9F, 0xFF, 0xC7, 0xEF, 0xE3, 0xFF, 0xFB, 0xF0, 0x7F, 0xFC,
  0xFC, 0x0F, 0xFF, 0x3E, 0x01, 0xFF, 0x8F, 0x80, 0x3F, 0xC0, 0x00, 0x07,
  0xC0,
};

const GFXglyph RobotoCondensed_SemiBold56pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 7, 41, 14, 4, -40 },
  { 37, 14, 15, 18, 2, -42 },
  { 64, 26, 40, 30, 2, -40 },
  { 194, 22, 53, 28, 3, -47 },
  { 340, 30, 42, 36, 3, -41 },
  { 498, 29, 42, 32, 2, -41 },
  { 651, 5, 15, 9, 2, -42 },
  { 661, 13, 57, 18, 3, -44 },
  { 754, 14, 57, 18, 1, -44 },
  { 854, 24, 24, 25, 1, -40 },
  { 926, 23, 30, 27, 2, -34 },
  { 1013, 9, 16, 13, 1, -7 },
  { 1031, 13, 6, 19, 3, -20 },
  { 1041, 8, 8, 16, 4, -7 },
  { 1049, 18, 43, 19, 0, -40 },
  { 1146, 22, 42, 28, 3, -41 },
  { 1262, 15, 40, 28, 4, -40 },
  { 1337, 24, 41, 28, 2, -41 },
  { 1460, 23, 42, 28, 2, -41 },
  { 1581, 24, 40, 28, 2, -40 },
  { 1701, 23, 41, 28, 3, -40 },
  { 1819, 23, 41, 28, 3, -40 },
  { 1937, 24, 40, 28, 2, -40 },
  { 2057, 22, 42, 28, 3, -41 },
  { 2173, 22, 41, 28, 3, -41 },
  { 2286, 8, 31, 15, 4, -30 },
  { 2317, 9, 39, 14, 2, -30 },
  { 2361, 19, 26, 25, 2, -30 },
  { 2423, 20, 18, 28, 4, -27 },
  { 2468, 21, 26, 26, 3, -30 },
  { 2537, 21, 42, 25, 2, -41 },
  { 2648, 39, 51, 43, 2, -39 },
  { 2897, 31, 40, 33, 1, -40 },
  { 3052, 25, 40, 31, 3, -40 },
  { 3177, 27, 42, 32, 3, -41 },
  { 3319, 26, 40, 32, 3, -40 },
  { 3449, 23, 40, 28, 3, -40 },
  { 3564, 22, 40, 27, 3, -40 },
  { 3674, 27, 42, 33, 3, -41 },
  { 3816, 28, 40, 34, 3, -40 },
  { 3956, 7, 40, 15, 4, -40 },
  { 3991, 23, 41, 27, 1, -40 },
  { 4109, 28, 40, 31, 3, -40 },
  { 4249, 22, 40, 27, 3, -40 },
  { 4359, 36, 40, 42, 3, -40 },
  { 4539, 28, 40, 34, 3, -40 },
  { 4679, 28, 42, 34, 3, -41 },
  { 4826, 27, 40, 32, 3, -40 },
  { 4961, 28, 48, 34, 3, -41 },
  { 5129, 27, 40, 31, 3, -40 },
  { 5264, 26, 42, 30, 2, -41 },
  { 5401, 28, 40, 30, 1, -40 },
  { 5541, 26, 41, 32, 3, -40 },
  { 5675, 30, 40, 32, 1, -40 },
  { 5825, 40, 40, 42, 1, -40 },
  { 6025, 29, 40, 31, 1, -40 },
  { 6170, 29, 40, 30, 1, -40 },
  { 6315, 26, 40, 30, 2, -40 },
  { 6445, 10, 55, 15, 3, -46 },
  { 6514, 21, 43, 21, 1, -40 },
  { 6627, 10, 55, 15, 1, -46 },
  { 6696, 19, 20, 22, 1, -40 },
  { 6744, 21, 6, 22, 1, 0 },
  { 6760, 14, 8, 18, 1, -42 },
  { 6774, 22, 32, 27, 2, -31 },
  { 6862, 23, 43, 28, 3, -42 },
  { 6986, 22, 32, 26, 2, -31 },
  { 7074, 23, 43, 28, 2, -42 },
  { 7198, 23, 32, 27, 2, -31 },
  { 7290, 17, 43, 18, 1, -43 },
  { 7382, 23, 42, 28, 2, -31 },
  { 7503, 22, 42, 27, 3, -42 },
  { 7619, 8, 42, 14, 3, -42 },
  { 7661, 12, 53, 13, -1, -42 },
  { 7741, 23, 42, 26, 3, -42 },
  { 7862, 7, 42, 14, 3, -42 },
  { 7899, 36, 31, 42, 3, -31 },
  { 8039, 22, 31, 27, 3, -31 },
  { 8125, 24, 32, 28, 2, -31 },
  { 8221, 23, 42, 28, 3, -31 },
  { 8342, 23, 42, 28, 2, -31 },
  { 8463, 14, 31, 18, 3, -31 },
  { 8518, 21, 32, 25, 2, -31 },
  { 8602, 15, 38, 17, 1, -37 },
  { 8674, 22, 31, 27, 3, -30 },
  { 8760, 23, 30, 25, 1, -30 },
  { 8847, 34, 30, 36, 1, -30 },
  { 8975, 23, 30, 25, 1, -30 },
  { 9062, 23, 41, 25, 1, -30 },
  { 9180, 21, 30, 25, 2, -30 },
  { 9259, 13, 54, 17, 2, -44 },
  { 9347, 4, 47, 14, 5, -40 },
  { 9371, 14, 54, 17, 1, -44 },
  { 9466, 26, 12, 32, 3, -22 },
};

const GFXfont RobotoCondensed_SemiBold56pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_SemiBold56pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_SemiBold56pt7bGlyphs,
  0x20, 0x7E, 66
};

#endif // _ROBOTOCONDENSED_SEMIBOLD56PT7B_H_
