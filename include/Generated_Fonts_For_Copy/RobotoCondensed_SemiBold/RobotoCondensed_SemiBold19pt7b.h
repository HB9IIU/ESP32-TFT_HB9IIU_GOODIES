#ifndef _ROBOTOCONDENSED_SEMIBOLD19PT7B_H_
#define _ROBOTOCONDENSED_SEMIBOLD19PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-SemiBold.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_SemiBold19pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x3E, 0xC0, 0xD9, 0x99, 0x90, 0x12, 0x09,
  0x04, 0x82, 0xCF, 0xFF, 0xFC, 0xD8, 0x48, 0xFF, 0x7F, 0x9B, 0x0D, 0x86,
  0xC3, 0x60, 0x18, 0x18, 0x3C, 0x7E, 0x66, 0xE7, 0xE0, 0x70, 0x78, 0x1E,
  0x0E, 0x07, 0xC7, 0xE6, 0x7E, 0x3C, 0x18, 0x18, 0x70, 0x36, 0x0D, 0x93,
  0x6C, 0xDA, 0x1D, 0x80, 0x40, 0x30, 0x0B, 0x86, 0xB1, 0x64, 0xD9, 0x23,
  0xC0, 0xE0, 0x3C, 0x1F, 0x06, 0x61, 0x98, 0x6E, 0x1F, 0x03, 0x81, 0xE6,
  0xFD, 0xB3, 0xEC, 0xF3, 0x9C, 0xFF, 0x9F, 0xE0, 0xEA, 0x80, 0x10, 0x8C,
  0xC6, 0x33, 0x18, 0xC6, 0x31, 0x8C, 0x31, 0x8C, 0x30, 0x84, 0x8C, 0xC6,
  0x63, 0x33, 0x33, 0x33, 0x33, 0x66, 0xCC, 0x80, 0x08, 0x08, 0x49, 0xFF,
  0x1C, 0x3C, 0x26, 0x22, 0x38, 0x70, 0xE1, 0xCF, 0xFF, 0xCE, 0x1C, 0x38,
  0x70, 0x6D, 0xB4, 0xFF, 0x5F, 0x80, 0x0C, 0x30, 0x86, 0x18, 0x63, 0x0C,
  0x30, 0x86, 0x18, 0x63, 0x0C, 0x00, 0x3C, 0x7E, 0xE6, 0xC6, 0xC7, 0xC7,
  0xC7, 0xC7, 0xC7, 0xC7, 0xC6, 0xE6, 0x7E, 0x3C, 0x0C, 0xFF, 0xF7, 0x1C,
  0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x70, 0x3C, 0x7E, 0xE6, 0xC6, 0x06,
  0x06, 0x0E, 0x0C, 0x18, 0x38, 0x70, 0x60, 0xFF, 0xFF, 0x3C, 0x7E, 0xE6,
  0xC6, 0x06, 0x06, 0x3C, 0x3E, 0x06, 0x07, 0xC7, 0xE6, 0xFE, 0x3C, 0x0E,
  0x0E, 0x1E, 0x1E, 0x3E, 0x3E, 0x6E, 0x6E, 0xCE, 0xFF, 0xFF, 0x0E, 0x0E,
  0x0E, 0x7E, 0x7E, 0x60, 0x60, 0x60, 0xFC, 0xFE, 0x06, 0x07, 0x07, 0xC7,
  0xE6, 0x7E, 0x3C, 0x1C, 0x3C, 0x70, 0x60, 0xE0, 0xDC, 0xFE, 0xE7, 0xC7,
  0xC7, 0xE7, 0x66, 0x7E, 0x3C, 0xFF, 0xFF, 0x06, 0x06, 0x0E, 0x0C, 0x0C,
  0x1C, 0x18, 0x18, 0x38, 0x30, 0x70, 0x70, 0x3C, 0x7E, 0xE6, 0xE6, 0xE6,
  0x66, 0x7C, 0x7E, 0xE6, 0xC7, 0xC7, 0xE6, 0x7E, 0x3C, 0x38, 0x7C, 0xE6,
  0xC6, 0xC6, 0xC7, 0xE7, 0x7E, 0x7E, 0x06, 0x06, 0x0C, 0x3C, 0x30, 0x5F,
  0x80, 0x00, 0x5F, 0x80, 0x5F, 0x80, 0x00, 0x1F, 0xED, 0x00, 0x04, 0x77,
  0xFC, 0xC3, 0xC7, 0xC7, 0x04, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x81,
  0xC3, 0xE1, 0xF0, 0x67, 0xFE, 0x70, 0x80, 0x79, 0xFB, 0x3E, 0x70, 0xE1,
  0x87, 0x1C, 0x30, 0x60, 0x01, 0x83, 0x06, 0x00, 0x0F, 0x80, 0xEF, 0x0C,
  0x08, 0xC0, 0x64, 0x79, 0x67, 0xCF, 0x36, 0x7B, 0x33, 0x99, 0x9C, 0xCC,
  0xF6, 0x65, 0xBF, 0x6C, 0xEE, 0x20, 0x01, 0x80, 0x07, 0xF0, 0x1F, 0x00,
  0x0E, 0x01, 0xC0, 0x3C, 0x0F, 0x81, 0xB0, 0x36, 0x06, 0xE1, 0xCC, 0x31,
  0x87, 0xF9, 0xFF, 0x38, 0x66, 0x0F, 0xC1, 0xC0, 0xFE, 0x7F, 0xB8, 0xDC,
  0x6E, 0x37, 0x1B, 0xF9, 0xFE, 0xE3, 0x71, 0xF8, 0xFC, 0x6F, 0xF7, 0xF0,
  0x3E, 0x3F, 0x98, 0xFC, 0x3C, 0x1E, 0x03, 0x01, 0x80, 0xC0, 0x60, 0xF8,
  0x6C, 0x77, 0xF1, 0xF0, 0xFC, 0x7F, 0x39, 0xDC, 0x6E, 0x3F, 0x1F, 0x8F,
  0xC7, 0xE3, 0xF1, 0xF8, 0xDC, 0xEF, 0xE7, 0xE0, 0xFF, 0xFF, 0xE0, 0xE0,
  0xE0, 0xE0, 0xFE, 0xFE, 0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xE0, 0xE0, 0xE0, 0xFE, 0xFE, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0x3E, 0x3F, 0x98, 0xFC, 0x3E, 0x06, 0x03, 0x01, 0x8F, 0xC7, 0xF0, 0xF8,
  0x6C, 0x37, 0xF8, 0xF8, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7F,
  0xFF, 0xFF, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x70, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0xE3, 0x67, 0x7E, 0x3C, 0xE3, 0xB9, 0xCE, 0x73, 0xB8, 0xEC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFE, 0x3B, 0x8E, 0x73, 0x9C, 0xE3, 0xB8, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xFF, 0xFF, 0xE0, 0x7F, 0x07, 0xF0, 0xFF, 0x0F, 0xF8, 0xFD, 0x8F, 0xF9,
  0xBF, 0x9B, 0xED, 0xBE, 0xF3, 0xEF, 0x3E, 0x73, 0xE7, 0x3E, 0x63, 0xE1,
  0xF0, 0xFC, 0x7E, 0x3F, 0x9F, 0xCF, 0xF7, 0xDB, 0xEF, 0xF3, 0xF9, 0xFC,
  0x7E, 0x3F, 0x0C, 0x1E, 0x1F, 0xC6, 0x3B, 0x86, 0xE1, 0xB0, 0x6C, 0x1F,
  0x07, 0xC1, 0xB8, 0x6E, 0x19, 0x8E, 0x7F, 0x07, 0x80, 0xFE, 0x7F, 0xB8,
  0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xFE, 0xFE, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x00, 0x3E, 0x1F, 0xC6, 0x3B, 0x86, 0xC1, 0xB0, 0x6C, 0x1B, 0x06, 0xC1,
  0xB0, 0x6E, 0x19, 0x8E, 0x7F, 0x0F, 0xC0, 0x38, 0x06, 0xFE, 0x7F, 0xB8,
  0xDC, 0x7E, 0x3F, 0x1F, 0x9D, 0xFE, 0xFE, 0x77, 0x39, 0xDC, 0xEE, 0x37,
  0x1C, 0x3C, 0x7F, 0xE7, 0xC3, 0xE0, 0xF0, 0x7C, 0x1E, 0x07, 0x03, 0xC3,
  0xE3, 0x7F, 0x3E, 0xFF, 0xFF, 0xF0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xE3, 0xF1, 0xF8,
  0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x77, 0xF1,
  0xF0, 0xE0, 0xEC, 0x19, 0xC7, 0x38, 0xE3, 0x18, 0x63, 0x0C, 0xE1, 0xDC,
  0x1B, 0x03, 0x60, 0x7C, 0x0F, 0x00, 0xE0, 0x1C, 0x00, 0x63, 0x1D, 0x8E,
  0x76, 0x39, 0x99, 0xE6, 0x77, 0x99, 0xDE, 0x63, 0x7B, 0x8D, 0xBE, 0x34,
  0xF0, 0xF3, 0xC3, 0xCF, 0x07, 0x3C, 0x1C, 0x70, 0x61, 0x80, 0x71, 0xDC,
  0x63, 0x38, 0xEC, 0x1B, 0x07, 0xC0, 0xE0, 0x38, 0x1F, 0x07, 0xC3, 0xB8,
  0xCE, 0x71, 0x98, 0x70, 0xE1, 0xD8, 0x67, 0x38, 0xCE, 0x33, 0x0F, 0xC1,
  0xE0, 0x78, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xFF, 0xFF,
  0x07, 0x06, 0x0E, 0x0C, 0x1C, 0x38, 0x30, 0x70, 0x60, 0xE0, 0xFF, 0xFF,
  0xFF, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCF, 0xF0, 0xE0, 0xC1,
  0x83, 0x83, 0x06, 0x0E, 0x0C, 0x18, 0x38, 0x30, 0x60, 0xE1, 0xC1, 0x80,
  0xFF, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x7F, 0xF0, 0x18, 0x70,
  0xE1, 0x66, 0xCC, 0x99, 0x80, 0xFF, 0xFC, 0x71, 0x86, 0x3D, 0xFF, 0x38,
  0x37, 0xFE, 0xF1, 0xE7, 0xFE, 0xEC, 0xC0, 0xC0, 0xC0, 0xC0, 0xDC, 0xFE,
  0xE6, 0xC7, 0xC7, 0xC7, 0xC7, 0xE6, 0xFE, 0xDC, 0x3D, 0xFF, 0x1E, 0x3C,
  0x18, 0x31, 0xE3, 0xFC, 0x70, 0x06, 0x0C, 0x18, 0x37, 0x7F, 0xF9, 0xE3,
  0xC7, 0x8F, 0x1F, 0x3F, 0xEE, 0xC0, 0x3C, 0xFF, 0x9E, 0x3F, 0xFF, 0xF0,
  0x71, 0x7E, 0x78, 0x1C, 0xF3, 0x0C, 0xFF, 0xF3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC0, 0x7F, 0xFF, 0xE7, 0xC7, 0xC7, 0xC7, 0xC7, 0xE7, 0xFF, 0x7F,
  0x06, 0x46, 0x7E, 0x7C, 0xC1, 0x83, 0x06, 0x0D, 0xDF, 0xF9, 0xE3, 0xC7,
  0x8F, 0x1E, 0x3C, 0x78, 0xC0, 0x5F, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x27,
  0x60, 0x77, 0x77, 0x77, 0x77, 0x77, 0x76, 0xEC, 0xC0, 0xC0, 0xC0, 0xC0,
  0xCE, 0xCE, 0xDC, 0xD8, 0xF8, 0xF8, 0xFC, 0xCE, 0xCE, 0xC7, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xDC, 0xEF, 0xFF, 0xE7, 0x7C, 0x63, 0xC6, 0x3C,
  0x63, 0xC6, 0x3C, 0x63, 0xC6, 0x3C, 0x63, 0xDD, 0xFF, 0x9E, 0x3C, 0x78,
  0xF1, 0xE3, 0xC7, 0x8C, 0x3C, 0x7E, 0xE6, 0xC7, 0xC7, 0xC7, 0xC7, 0xE6,
  0x7E, 0x3C, 0xDC, 0xFE, 0xE6, 0xC7, 0xC7, 0xC7, 0xC7, 0xE6, 0xFE, 0xDC,
  0xC0, 0xC0, 0xC0, 0xC0, 0x7F, 0xFF, 0x9E, 0x3C, 0x78, 0xF1, 0xF3, 0xFE,
  0xFC, 0x18, 0x30, 0x60, 0xC0, 0xDF, 0xF9, 0x8C, 0x63, 0x18, 0xC6, 0x00,
  0x79, 0xFB, 0x3F, 0x0F, 0x87, 0x83, 0xE3, 0xFE, 0xF8, 0x73, 0x9D, 0xFF,
  0xB9, 0xCE, 0x73, 0x8C, 0x73, 0x80, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1,
  0xF3, 0xFE, 0xEC, 0xE3, 0x67, 0x66, 0x76, 0x36, 0x3E, 0x3C, 0x3C, 0x1C,
  0x18, 0xE6, 0x76, 0x66, 0x67, 0x66, 0xF6, 0x6F, 0x63, 0xFE, 0x39, 0xC3,
  0x9C, 0x39, 0xC3, 0x9C, 0x67, 0x76, 0x3E, 0x3C, 0x1C, 0x1C, 0x3C, 0x3E,
  0x76, 0x67, 0xE3, 0x67, 0x66, 0x76, 0x36, 0x3E, 0x3C, 0x3C, 0x1C, 0x18,
  0x18, 0x18, 0x70, 0x70, 0xFF, 0xFC, 0x30, 0xC3, 0x86, 0x1C, 0x70, 0xFF,
  0xFC, 0x13, 0x66, 0x66, 0x66, 0xCC, 0x66, 0x66, 0x66, 0x31, 0xFF, 0xFF,
  0x80, 0x43, 0x1C, 0x63, 0x18, 0xC6, 0x38, 0xCC, 0x63, 0x18, 0xCE, 0x62,
  0x00, 0x71, 0xFC, 0xF3, 0xD8, 0xC0,
};

const GFXglyph RobotoCondensed_SemiBold19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 3, 14, 5, 1, -14 },
  { 7, 4, 5, 6, 1, -14 },
  { 10, 9, 14, 10, 1, -14 },
  { 26, 8, 18, 10, 1, -16 },
  { 44, 10, 14, 12, 1, -14 },
  { 62, 10, 14, 11, 1, -14 },
  { 80, 2, 5, 3, 1, -14 },
  { 82, 5, 19, 6, 1, -15 },
  { 94, 4, 19, 6, 1, -15 },
  { 104, 8, 8, 9, 0, -14 },
  { 112, 7, 10, 9, 1, -11 },
  { 121, 3, 5, 4, 0, -2 },
  { 123, 4, 2, 6, 1, -7 },
  { 124, 3, 3, 5, 1, -3 },
  { 126, 6, 15, 6, 0, -14 },
  { 138, 8, 14, 10, 1, -14 },
  { 152, 6, 14, 10, 1, -14 },
  { 163, 8, 14, 10, 1, -14 },
  { 177, 8, 14, 10, 1, -14 },
  { 191, 8, 14, 10, 1, -14 },
  { 205, 8, 14, 10, 1, -14 },
  { 219, 8, 14, 10, 1, -14 },
  { 233, 8, 14, 10, 1, -14 },
  { 247, 8, 14, 10, 1, -14 },
  { 261, 8, 14, 10, 1, -14 },
  { 275, 3, 11, 5, 1, -11 },
  { 280, 3, 14, 5, 1, -11 },
  { 286, 6, 9, 8, 1, -10 },
  { 293, 7, 6, 9, 1, -9 },
  { 299, 7, 9, 9, 1, -10 },
  { 307, 7, 14, 8, 1, -14 },
  { 320, 13, 17, 15, 1, -13 },
  { 348, 11, 14, 11, 0, -14 },
  { 368, 9, 14, 11, 1, -14 },
  { 384, 9, 14, 11, 1, -14 },
  { 400, 9, 14, 11, 1, -14 },
  { 416, 8, 14, 9, 1, -14 },
  { 430, 8, 14, 9, 1, -14 },
  { 444, 9, 14, 11, 1, -14 },
  { 460, 10, 14, 12, 1, -14 },
  { 478, 3, 14, 5, 1, -14 },
  { 484, 8, 14, 9, 0, -14 },
  { 498, 10, 14, 10, 1, -14 },
  { 516, 8, 14, 9, 1, -14 },
  { 530, 12, 14, 14, 1, -14 },
  { 551, 9, 14, 12, 1, -14 },
  { 567, 10, 14, 11, 1, -14 },
  { 585, 9, 14, 11, 1, -14 },
  { 601, 10, 16, 11, 1, -14 },
  { 621, 9, 14, 10, 1, -14 },
  { 637, 8, 14, 10, 1, -14 },
  { 651, 10, 14, 10, 0, -14 },
  { 669, 9, 14, 11, 1, -14 },
  { 685, 11, 14, 11, 0, -14 },
  { 705, 14, 14, 14, 0, -14 },
  { 730, 10, 14, 11, 0, -14 },
  { 748, 10, 14, 10, 0, -14 },
  { 766, 8, 14, 10, 1, -14 },
  { 780, 4, 19, 5, 1, -16 },
  { 790, 7, 15, 7, 0, -14 },
  { 804, 4, 19, 5, 0, -16 },
  { 814, 7, 7, 7, 0, -14 },
  { 821, 7, 2, 8, 0, 0 },
  { 823, 5, 3, 6, 0, -14 },
  { 825, 7, 10, 9, 1, -10 },
  { 834, 8, 14, 9, 1, -14 },
  { 848, 7, 10, 9, 1, -10 },
  { 857, 7, 14, 9, 1, -14 },
  { 870, 7, 10, 9, 1, -10 },
  { 879, 6, 14, 6, 0, -14 },
  { 890, 8, 14, 10, 1, -10 },
  { 904, 7, 14, 9, 1, -14 },
  { 917, 3, 14, 5, 1, -14 },
  { 923, 4, 18, 5, 0, -14 },
  { 932, 8, 14, 9, 1, -14 },
  { 946, 3, 14, 5, 1, -14 },
  { 952, 12, 10, 14, 1, -10 },
  { 967, 7, 10, 9, 1, -10 },
  { 976, 8, 10, 9, 1, -10 },
  { 986, 8, 14, 9, 1, -10 },
  { 1000, 7, 14, 9, 1, -10 },
  { 1013, 5, 10, 6, 1, -10 },
  { 1020, 7, 10, 9, 1, -10 },
  { 1029, 5, 13, 6, 0, -13 },
  { 1038, 7, 10, 9, 1, -10 },
  { 1047, 8, 10, 8, 0, -10 },
  { 1057, 12, 10, 12, 0, -10 },
  { 1072, 8, 10, 9, 0, -10 },
  { 1082, 8, 14, 8, 0, -10 },
  { 1096, 7, 10, 9, 1, -10 },
  { 1105, 4, 18, 6, 1, -15 },
  { 1114, 1, 17, 5, 2, -14 },
  { 1117, 5, 18, 6, 0, -15 },
  { 1129, 9, 4, 11, 1, -8 },
};

const GFXfont RobotoCondensed_SemiBold19pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_SemiBold19pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_SemiBold19pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _ROBOTOCONDENSED_SEMIBOLD19PT7B_H_
