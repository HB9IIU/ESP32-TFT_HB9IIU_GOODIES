#ifndef _ROBOTOCONDENSED_SEMIBOLD9PT7B_H_
#define _ROBOTOCONDENSED_SEMIBOLD9PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-SemiBold.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_SemiBold9pt7bBitmaps[] PROGMEM = {
  0x00, 0xFA, 0xB4, 0x31, 0x9E, 0xAF, 0x31, 0x80, 0x27, 0x54, 0x61, 0xD7,
  0x20, 0x65, 0x9C, 0x43, 0xAC, 0x60, 0x62, 0x98, 0xCE, 0xE9, 0xE0, 0xC0,
  0x6A, 0xAA, 0x40, 0x95, 0x55, 0x80, 0x2B, 0x66, 0x22, 0xF2, 0x20, 0x58,
  0xE0, 0x80, 0x25, 0x24, 0xA4, 0x65, 0xDD, 0xD5, 0x60, 0x75, 0x54, 0x7D,
  0x13, 0x24, 0xF0, 0x6D, 0x12, 0x1D, 0x60, 0x33, 0x55, 0xF1, 0x10, 0x74,
  0x71, 0x15, 0x60, 0x24, 0x7D, 0xD5, 0x60, 0xF1, 0x32, 0x26, 0x40, 0x65,
  0x56, 0x5D, 0x70, 0x65, 0xD5, 0x71, 0x60, 0x88, 0x40, 0x58, 0x3F, 0x90,
  0xE3, 0x80, 0x8D, 0xC0, 0x6B, 0x32, 0x40, 0x40, 0x38, 0x89, 0x6D, 0x5A,
  0xB7, 0x90, 0x1C, 0x21, 0x94, 0xA7, 0x26, 0x20, 0xEA, 0xAE, 0xBB, 0xE0,
  0x72, 0x71, 0x8C, 0x25, 0xC0, 0xEA, 0xBB, 0xBA, 0xE0, 0xF2, 0x79, 0x38,
  0xF2, 0x79, 0x20, 0x72, 0x71, 0xBC, 0xA5, 0xC0, 0x99, 0x9F, 0x99, 0x90,
  0xFE, 0x11, 0x11, 0x19, 0x60, 0xBA, 0xCC, 0xEA, 0xB0, 0x92, 0x49, 0x38,
  0x8C, 0xF7, 0xBD, 0xD6, 0xA0, 0x99, 0xDD, 0xBB, 0x90, 0x72, 0x73, 0x9C,
  0xA5, 0xC0, 0xEB, 0xBE, 0x88, 0x80, 0x72, 0x73, 0x9C, 0xA5, 0xC1, 0xEB,
  0xBE, 0xAA, 0xB0, 0x7D, 0x47, 0x1D, 0x70, 0xF9, 0x08, 0x42, 0x10, 0x80,
  0xDE, 0xF7, 0xBD, 0xAD, 0xC0, 0x8A, 0xD4, 0xA5, 0x18, 0x80, 0x95, 0xA9,
  0xD3, 0x66, 0xCD, 0x9A, 0x00, 0xDA, 0x9C, 0x47, 0x2B, 0x60, 0xDA, 0x94,
  0xC2, 0x10, 0x80, 0xF1, 0x22, 0x44, 0xF0, 0xFF, 0x89, 0x24, 0x49, 0xD5,
  0x57, 0x4E, 0x80, 0xF0, 0x50, 0x61, 0x7D, 0x70, 0xCC, 0xFD, 0xDD, 0xF0,
  0x6D, 0x8D, 0x60, 0x11, 0x7D, 0x9D, 0x70, 0x6D, 0xFC, 0x70, 0x6B, 0xA4,
  0x90, 0x7D, 0x9D, 0x71, 0x70, 0xCC, 0xFD, 0xDD, 0xD0, 0xC5, 0x54, 0xC5,
  0x55, 0x80, 0xCC, 0xFE, 0xEE, 0xD0, 0xFE, 0xFF, 0x5D, 0x75, 0xD4, 0xFD,
  0xDD, 0xD0, 0x7D, 0x9D, 0x70, 0xFD, 0xDD, 0xFC, 0xC0, 0x7D, 0x9D, 0x71,
  0x10, 0xFB, 0x6C, 0x6C, 0x69, 0x60, 0x59, 0x24, 0xC0, 0xDD, 0xDD, 0x70,
  0x96, 0x66, 0x60, 0xAB, 0xE7, 0x96, 0x58, 0xF6, 0x66, 0xF0, 0x96, 0x66,
  0x64, 0xC0, 0xF2, 0x64, 0xF0, 0x55, 0x95, 0x40, 0xFF, 0x95, 0x55, 0x80,
  0x6D, 0x80,
};

const GFXglyph RobotoCondensed_SemiBold9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 7, 2, 1, -7 },
  { 2, 3, 2, 3, 0, -7 },
  { 3, 5, 7, 5, 0, -7 },
  { 8, 4, 9, 5, 0, -8 },
  { 13, 5, 7, 6, 0, -7 },
  { 18, 5, 7, 5, 0, -7 },
  { 23, 1, 2, 1, 0, -7 },
  { 24, 2, 9, 3, 1, -7 },
  { 27, 2, 9, 3, 0, -7 },
  { 30, 4, 4, 4, 0, -7 },
  { 32, 4, 5, 4, 0, -5 },
  { 35, 2, 3, 2, 0, -1 },
  { 36, 3, 1, 3, 0, -3 },
  { 37, 1, 1, 3, 1, -1 },
  { 38, 3, 8, 3, 0, -7 },
  { 41, 4, 7, 5, 0, -7 },
  { 45, 2, 7, 5, 1, -7 },
  { 47, 4, 7, 5, 0, -7 },
  { 51, 4, 7, 5, 0, -7 },
  { 55, 4, 7, 5, 0, -7 },
  { 59, 4, 7, 5, 0, -7 },
  { 63, 4, 7, 5, 0, -7 },
  { 67, 4, 7, 5, 0, -7 },
  { 71, 4, 7, 5, 0, -7 },
  { 75, 4, 7, 5, 0, -7 },
  { 79, 1, 5, 2, 1, -5 },
  { 80, 2, 7, 2, 0, -5 },
  { 82, 3, 4, 4, 0, -5 },
  { 84, 3, 3, 4, 1, -4 },
  { 86, 3, 4, 4, 1, -5 },
  { 88, 4, 7, 4, 0, -7 },
  { 92, 7, 8, 7, 0, -6 },
  { 99, 5, 7, 5, 0, -7 },
  { 104, 4, 7, 5, 1, -7 },
  { 108, 5, 7, 5, 0, -7 },
  { 113, 4, 7, 5, 1, -7 },
  { 117, 3, 7, 4, 1, -7 },
  { 120, 3, 7, 4, 1, -7 },
  { 123, 5, 7, 5, 0, -7 },
  { 128, 4, 7, 6, 1, -7 },
  { 132, 1, 7, 2, 1, -7 },
  { 133, 4, 7, 4, 0, -7 },
  { 137, 4, 7, 5, 1, -7 },
  { 141, 3, 7, 4, 1, -7 },
  { 144, 5, 7, 7, 1, -7 },
  { 149, 4, 7, 6, 1, -7 },
  { 153, 5, 7, 5, 0, -7 },
  { 158, 4, 7, 5, 1, -7 },
  { 162, 5, 8, 5, 0, -7 },
  { 167, 4, 7, 5, 1, -7 },
  { 171, 4, 7, 5, 0, -7 },
  { 175, 5, 7, 5, 0, -7 },
  { 180, 5, 7, 5, 0, -7 },
  { 185, 5, 7, 5, 0, -7 },
  { 190, 7, 7, 7, 0, -7 },
  { 197, 5, 7, 5, 0, -7 },
  { 202, 5, 7, 5, 0, -7 },
  { 207, 4, 7, 5, 0, -7 },
  { 211, 1, 8, 2, 1, -7 },
  { 212, 3, 8, 3, 0, -7 },
  { 215, 2, 8, 2, 0, -7 },
  { 217, 3, 3, 3, 0, -7 },
  { 219, 4, 1, 4, 0, 0 },
  { 220, 2, 2, 3, 0, -7 },
  { 221, 4, 5, 4, 0, -5 },
  { 224, 4, 7, 4, 0, -7 },
  { 228, 4, 5, 4, 0, -5 },
  { 231, 4, 7, 4, 0, -7 },
  { 235, 4, 5, 4, 0, -5 },
  { 238, 3, 7, 3, 0, -7 },
  { 241, 4, 7, 5, 0, -5 },
  { 245, 4, 7, 4, 0, -7 },
  { 249, 2, 7, 2, 0, -7 },
  { 251, 2, 9, 2, 0, -7 },
  { 254, 4, 7, 4, 0, -7 },
  { 258, 1, 7, 2, 1, -7 },
  { 259, 6, 5, 7, 0, -5 },
  { 263, 4, 5, 4, 0, -5 },
  { 266, 4, 5, 4, 0, -5 },
  { 269, 4, 7, 4, 0, -5 },
  { 273, 4, 7, 4, 0, -5 },
  { 277, 3, 5, 3, 0, -5 },
  { 279, 4, 5, 4, 0, -5 },
  { 282, 3, 6, 3, 0, -6 },
  { 285, 4, 5, 4, 0, -5 },
  { 288, 4, 5, 4, 0, -5 },
  { 291, 6, 5, 6, 0, -5 },
  { 295, 4, 5, 4, 0, -5 },
  { 298, 4, 7, 4, 0, -5 },
  { 302, 4, 5, 4, 0, -5 },
  { 305, 2, 9, 3, 0, -7 },
  { 308, 1, 8, 2, 1, -7 },
  { 309, 2, 9, 3, 0, -7 },
  { 312, 5, 2, 5, 0, -4 },
};

const GFXfont RobotoCondensed_SemiBold9pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_SemiBold9pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_SemiBold9pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _ROBOTOCONDENSED_SEMIBOLD9PT7B_H_
