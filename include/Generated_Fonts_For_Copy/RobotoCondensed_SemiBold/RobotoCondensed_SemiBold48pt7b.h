#ifndef _ROBOTOCONDENSED_SEMIBOLD48PT7B_H_
#define _ROBOTOCONDENSED_SEMIBOLD48PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-SemiBold.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_SemiBold48pt7bBitmaps[] PROGMEM = {
  0x00, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x00, 0x00, 0x00,
  0x01, 0xC7, 0xDF, 0xFF, 0xFF, 0x7C, 0xF0, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF,
  0x1F, 0xF1, 0xFF, 0x1E, 0xF1, 0xEF, 0x1E, 0xF1, 0xEF, 0x1E, 0xF1, 0xEF,
  0x1E, 0xE1, 0xE0, 0x00, 0xF1, 0xE0, 0x03, 0xC7, 0x80, 0x0F, 0x1E, 0x00,
  0x38, 0x78, 0x01, 0xE1, 0xE0, 0x07, 0x87, 0x80, 0x1E, 0x1C, 0x00, 0x78,
  0xF0, 0x01, 0xE3, 0xC0, 0x07, 0x8F, 0x03, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF0, 0x3C, 0x78, 0x00, 0xF1, 0xE0, 0x03,
  0xC7, 0x80, 0x1E, 0x1E, 0x00, 0x78, 0x78, 0x01, 0xE1, 0xC0, 0x07, 0x8F,
  0x03, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF8,
  0x3C, 0x3C, 0x00, 0xF0, 0xE0, 0x03, 0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x3C,
  0x78, 0x00, 0xE1, 0xE0, 0x07, 0x87, 0x80, 0x1E, 0x1E, 0x00, 0x78, 0xF0,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x1F, 0xC0, 0x07, 0xFF, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3,
  0xFF, 0xFC, 0x3F, 0x8F, 0xE3, 0xF0, 0x7E, 0x7F, 0x07, 0xE7, 0xE0, 0x3F,
  0x7E, 0x03, 0xF7, 0xF0, 0x3F, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x03, 0xF7, 0xE0, 0x3F, 0x7E, 0x07, 0xF7,
  0xF8, 0xFE, 0x3F, 0xFF, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0x7F, 0xF0,
  0x01, 0xFC, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x78, 0xF8, 0x30, 0x3E, 0x1E, 0x0F, 0x0F, 0x07,
  0x87, 0x83, 0xC1, 0xE1, 0xE0, 0xF0, 0x78, 0xF0, 0x3C, 0x1E, 0x3C, 0x0F,
  0x87, 0x9E, 0x01, 0xE3, 0xE7, 0x00, 0x7F, 0xF3, 0xC0, 0x0F, 0xFD, 0xE0,
  0x03, 0xFE, 0x78, 0x00, 0x3E, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0xF3, 0xFC, 0x00, 0x3D, 0xFF, 0x80,
  0x1E, 0x7F, 0xF0, 0x07, 0x3E, 0x3C, 0x03, 0xCF, 0x0F, 0x01, 0xE3, 0xC3,
  0xC0, 0x78, 0xF0, 0xF0, 0x3C, 0x3C, 0x3C, 0x0F, 0x0F, 0x0F, 0x07, 0x83,
  0xC3, 0xC1, 0xE0, 0xF8, 0xF0, 0x10, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFC, 0x7E,
  0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x0F, 0x80, 0x3F, 0x07, 0xC0, 0x1F, 0x87,
  0xE0, 0x0F, 0xC3, 0xE0, 0x03, 0xF3, 0xF0, 0x01, 0xFB, 0xF0, 0x00, 0x7F,
  0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xFC, 0x1F, 0x0F, 0xFF, 0x0F, 0x87, 0xFF, 0xC7, 0xC7, 0xEF, 0xE7, 0xE7,
  0xE3, 0xFB, 0xE3, 0xF0, 0xFF, 0xF1, 0xF8, 0x3F, 0xF8, 0xFC, 0x1F, 0xFC,
  0x7E, 0x07, 0xFC, 0x3F, 0x01, 0xFE, 0x1F, 0xC0, 0xFF, 0x07, 0xF0, 0xFF,
  0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x0F, 0xFE,
  0x7F, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x40, 0x18, 0x07, 0x81, 0xF0, 0x7C, 0x0F, 0x03, 0xE0, 0x78, 0x1F,
  0x03, 0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x03, 0xC0, 0x7C, 0x0F, 0x80, 0xF0, 0x1F, 0x01, 0xE0, 0x3E, 0x03,
  0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x06, 0x00, 0x40, 0x40, 0x06, 0x00, 0x70,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x0F,
  0x80, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x07,
  0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x0F, 0x01, 0xF0, 0x1E,
  0x03, 0xE0, 0x7C, 0x0F, 0x80, 0x70, 0x06, 0x00, 0x40, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x70, 0xF0, 0x6F, 0xCF, 0x3E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xC0, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x07, 0xBE, 0x00,
  0xF9, 0xE0, 0x1F, 0x1F, 0x01, 0xF0, 0xF8, 0x3E, 0x0F, 0x80, 0xC0, 0x70,
  0x04, 0x02, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3E, 0x3E, 0x3E,
  0x7C, 0x7C, 0xF8, 0xF8, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x38, 0xFF, 0xFF, 0xFF, 0xEF, 0xCF, 0x00, 0x00, 0x1E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x01,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0,
  0x03, 0xC0, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0xE0, 0x0F, 0xFF,
  0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0xC3, 0xF0, 0xFC, 0x7F, 0x07, 0xE7, 0xE0,
  0x7E, 0x7E, 0x07, 0xE7, 0xE0, 0x3E, 0x7C, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xF7, 0xE0, 0x3F, 0x7E, 0x03, 0xE7, 0xE0, 0x7E, 0x7E, 0x07,
  0xE7, 0xF0, 0x7E, 0x3F, 0x8F, 0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0xFF,
  0xF0, 0x07, 0xFE, 0x00, 0x1F, 0x80, 0x00, 0x30, 0x0F, 0x03, 0xF1, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xF8, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x01, 0xFC, 0x00,
  0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xC7, 0xF1, 0xFE,
  0x7E, 0x0F, 0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xF8,
  0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x7F, 0xFF, 0xC7, 0xF1,
  0xFE, 0xFE, 0x0F, 0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x03, 0xFF, 0x80,
  0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x01, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xEF, 0xE0, 0x7E, 0x7F, 0x1F, 0xE7, 0xFF,
  0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFB, 0xF0, 0x03, 0xEF, 0xC0, 0x1F,
  0x3F, 0x00, 0x7C, 0xFC, 0x03, 0xE3, 0xF0, 0x1F, 0x8F, 0xC0, 0x7C, 0x3F,
  0x03, 0xF0, 0xFC, 0x0F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF0, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x3F, 0xFF, 0xC7,
  0xFF, 0xF8, 0xFF, 0xFF, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xCF, 0x80, 0xFF, 0xFC, 0x1F, 0xFF, 0xC7, 0xFF, 0xFC, 0xFF,
  0xFF, 0xDF, 0x83, 0xF8, 0x20, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0x80, 0xFF, 0xF0,
  0x3F, 0xFF, 0x07, 0xE7, 0xF1, 0xFC, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF,
  0xF8, 0x0F, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x3E, 0x00, 0x3F, 0xC0, 0x0F,
  0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xE0, 0x0F, 0xF0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x7E, 0x0F, 0xDF,
  0xF1, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xFE, 0xFF, 0x1F, 0xDF, 0xC1,
  0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01,
  0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xBF, 0x07,
  0xE7, 0xF1, 0xFC, 0x7F, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xFE,
  0x00, 0x7F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0x81,
  0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xF8, 0xFE, 0x7F, 0x0F, 0xE7, 0xE0, 0x7E,
  0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0x3F, 0x0F,
  0xE3, 0xF8, 0xFC, 0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x07, 0xFE, 0x01, 0xFF,
  0xF8, 0x3F, 0xFF, 0xC3, 0xF0, 0xFC, 0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0x7E,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0x7E, 0x07, 0xF7,
  0xE0, 0x7E, 0x7F, 0x0F, 0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8,
  0x0F, 0xFF, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x7F, 0xE0, 0x0F, 0xFF,
  0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0x83, 0xF1, 0xFC, 0x7E, 0x0F, 0xC7, 0xE0,
  0x7E, 0x7E, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFC,
  0x03, 0xEF, 0xC0, 0x3F, 0xFC, 0x03, 0xF7, 0xE0, 0x7F, 0x7E, 0x07, 0xF7,
  0xF0, 0xFE, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0xFF, 0x7E,
  0x03, 0xE7, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF8, 0x01, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xFF,
  0x80, 0x0F, 0xF0, 0x00, 0xF8, 0x00, 0x38, 0xFB, 0xFF, 0xFF, 0xEF, 0xCF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x8F, 0xFF, 0xFF, 0xFE, 0xFC, 0xF0, 0x0E, 0x1F, 0x8F, 0xE7, 0xF3, 0xF9,
  0xF8, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87,
  0xC3, 0xE3, 0xF1, 0xF0, 0xF8, 0xF8, 0x7C, 0x3C, 0x04, 0x00, 0x00, 0x01,
  0x00, 0x07, 0x00, 0x1F, 0x00, 0x7F, 0x01, 0xFF, 0x07, 0xFF, 0x1F, 0xFE,
  0x3F, 0xF8, 0xFF, 0xE0, 0xFF, 0x80, 0xFE, 0x00, 0xFC, 0x00, 0xFF, 0x80,
  0xFF, 0xE0, 0x3F, 0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0x00, 0x7F,
  0x00, 0x1F, 0x00, 0x07, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x70, 0x00, 0x3E, 0x00, 0x1F, 0xC0,
  0x0F, 0xF8, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0x80,
  0x7F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xF8, 0x1F, 0xFC, 0x7F, 0xF8,
  0xFF, 0xF0, 0xFF, 0xE0, 0x7F, 0xC0, 0x3F, 0x80, 0x1F, 0x00, 0x0E, 0x00,
  0x04, 0x00, 0x00, 0x03, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xFF, 0xFE,
  0x7F, 0xFF, 0xDF, 0xC7, 0xF7, 0xE0, 0xFF, 0xF8, 0x3F, 0xFC, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x1F, 0x80, 0x3F, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x01,
  0xF0, 0x1F, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x1E, 0x0F, 0x80, 0x00,
  0x0F, 0x07, 0x80, 0x7E, 0x03, 0x87, 0xC0, 0x7F, 0xC1, 0xE3, 0xC0, 0x7F,
  0xF0, 0xF1, 0xE0, 0x7F, 0xF8, 0x39, 0xE0, 0x7C, 0x3C, 0x1C, 0xF0, 0x3C,
  0x3E, 0x0F, 0x78, 0x3E, 0x1F, 0x07, 0xBC, 0x1E, 0x0F, 0x83, 0xFE, 0x1F,
  0x07, 0x81, 0xFE, 0x0F, 0x83, 0xC0, 0xFF, 0x07, 0xC1, 0xE0, 0x7F, 0x83,
  0xC0, 0xF0, 0x3F, 0xC1, 0xE0, 0x78, 0x1F, 0xE0, 0xF0, 0x3C, 0x0E, 0xF0,
  0x78, 0x1E, 0x07, 0x78, 0x3C, 0x0F, 0x07, 0xBC, 0x1E, 0x0F, 0x83, 0xDE,
  0x0F, 0x87, 0xC3, 0xCF, 0x87, 0xE7, 0xE1, 0xE3, 0xC3, 0xFF, 0xFF, 0xE1,
  0xE0, 0xFF, 0xBF, 0xF0, 0xF0, 0x3F, 0x9F, 0xF0, 0x78, 0x0F, 0x03, 0xE0,
  0x3E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x1C, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0x7C, 0x00, 0x07, 0xEF, 0x80, 0x00,
  0xF9, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0xFC, 0x7E,
  0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x1F, 0x80, 0x1F,
  0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xFC,
  0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0x80, 0x1F, 0xC7, 0xF0, 0x01, 0xF8,
  0xFC, 0x00, 0x3F, 0x1F, 0x80, 0x07, 0xF7, 0xF0, 0x00, 0x7E, 0xFE, 0x00,
  0x0F, 0xDF, 0x80, 0x01, 0xFC, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x7E, 0x07, 0xFB, 0xF0, 0x0F, 0xFF,
  0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x07,
  0xFF, 0xC0, 0x3F, 0x7E, 0x03, 0xFB, 0xFF, 0xFF, 0x9F, 0xFF, 0xF8, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0x3F, 0xFF, 0xFD, 0xF8, 0x0F, 0xEF, 0xC0, 0x3F,
  0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFC, 0xFF, 0xFF, 0x87, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFC, 0x3F, 0xC3, 0xFC, 0x3F, 0x80, 0xFE, 0x7F, 0x00, 0x7E, 0x7E,
  0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x7E,
  0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7F, 0x00, 0x7E, 0x3F, 0x00, 0xFE, 0x3F,
  0xC3, 0xFC, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE3, 0xF0, 0x7F, 0xCF, 0xC0, 0x7F,
  0x3F, 0x00, 0xFE, 0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xEF, 0xC0, 0x1F, 0xBF,
  0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F,
  0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7E, 0xFC,
  0x01, 0xFB, 0xF0, 0x07, 0xEF, 0xC0, 0x3F, 0xBF, 0x01, 0xFC, 0xFC, 0x1F,
  0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFE, 0x03,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xFF, 0xF3, 0xFF, 0xFE,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0xCF,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC,
  0x3F, 0xE3, 0xFC, 0x3F, 0x80, 0xFE, 0x7F, 0x00, 0x7E, 0x7E, 0x00, 0x7E,
  0x7E, 0x00, 0x7F, 0x7E, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x0F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFE, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x7E, 0x00, 0x7F,
  0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x3F, 0x80, 0x7F, 0x3F, 0xF1, 0xFF,
  0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xF0,
  0x00, 0x7F, 0x80, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x7E, 0xFE, 0x07, 0xE7, 0xE0,
  0xFE, 0x7F, 0x9F, 0xE7, 0xFF, 0xFC, 0x3F, 0xFF, 0x81, 0xFF, 0xF0, 0x0F,
  0xFE, 0x00, 0x3F, 0x80, 0xFC, 0x01, 0xFE, 0xFC, 0x01, 0xFC, 0xFC, 0x03,
  0xFC, 0xFC, 0x07, 0xF8, 0xFC, 0x07, 0xF0, 0xFC, 0x0F, 0xF0, 0xFC, 0x0F,
  0xE0, 0xFC, 0x1F, 0xC0, 0xFC, 0x3F, 0xC0, 0xFC, 0x3F, 0x80, 0xFC, 0x7F,
  0x00, 0xFC, 0x7F, 0x00, 0xFC, 0xFE, 0x00, 0xFD, 0xFC, 0x00, 0xFD, 0xF8,
  0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0x3F, 0x80, 0xFE, 0x3F,
  0x80, 0xFC, 0x1F, 0xC0, 0xFC, 0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0xFC, 0x0F,
  0xE0, 0xFC, 0x07, 0xF0, 0xFC, 0x07, 0xF8, 0xFC, 0x03, 0xF8, 0xFC, 0x03,
  0xFC, 0xFC, 0x01, 0xFC, 0xFC, 0x01, 0xFE, 0xFC, 0x00, 0xFE, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xF8, 0x07, 0xDF, 0xFF, 0xF0, 0x1F, 0x7F, 0xFF, 0xC0, 0xFD, 0xFF,
  0xDF, 0x03, 0xE7, 0xFF, 0x7E, 0x0F, 0xBF, 0xFD, 0xF8, 0x3E, 0xFF, 0xF3,
  0xE1, 0xF3, 0xFF, 0xCF, 0x87, 0xCF, 0xFF, 0x3F, 0x1F, 0x3F, 0xFC, 0x7C,
  0xFC, 0xFF, 0xF1, 0xF3, 0xE3, 0xFF, 0xC7, 0xEF, 0x8F, 0xFF, 0x0F, 0xFE,
  0x3F, 0xFC, 0x3F, 0xF0, 0xFF, 0xF0, 0xFF, 0xC3, 0xFF, 0xC3, 0xFF, 0x0F,
  0xFF, 0x07, 0xF8, 0x3F, 0xFC, 0x1F, 0xE0, 0xFF, 0xF0, 0x7F, 0x83, 0xFF,
  0xC0, 0xFE, 0x0F, 0xFF, 0x03, 0xF0, 0x3F, 0xFC, 0x0F, 0xC0, 0xFF, 0xF0,
  0x1F, 0x03, 0xF0, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF,
  0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xBF, 0x0F, 0xFF, 0x7E, 0x1F, 0xFE, 0x7E,
  0x3F, 0xFC, 0xFC, 0x7F, 0xF8, 0xFC, 0xFF, 0xF1, 0xF9, 0xFF, 0xE1, 0xFB,
  0xFF, 0xC3, 0xF7, 0xFF, 0x83, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF,
  0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xF0, 0x01,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC1, 0xFF, 0x1F, 0xF0,
  0xFE, 0x03, 0xF8, 0xFE, 0x00, 0xFC, 0x7F, 0x00, 0x7F, 0x3F, 0x00, 0x1F,
  0x9F, 0x80, 0x0F, 0xDF, 0xC0, 0x07, 0xEF, 0xE0, 0x03, 0xF7, 0xF0, 0x01,
  0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00,
  0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0,
  0x01, 0xFB, 0xF8, 0x00, 0xFC, 0xFC, 0x00, 0x7E, 0x7E, 0x00, 0x3F, 0x3F,
  0x00, 0x3F, 0x9F, 0xC0, 0x1F, 0xC7, 0xF0, 0x1F, 0xC3, 0xFE, 0x3F, 0xE0,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xF0, 0x1F, 0xEF, 0xC0, 0x3F, 0xBF,
  0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F,
  0xFC, 0x07, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xC3, 0xFF, 0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC1, 0xFF, 0x1F, 0xE0, 0xFE, 0x03, 0xF8,
  0xFE, 0x00, 0xFC, 0x7E, 0x00, 0x7F, 0x3F, 0x00, 0x1F, 0x9F, 0x80, 0x0F,
  0xDF, 0xC0, 0x07, 0xEF, 0xE0, 0x03, 0xF7, 0xF0, 0x01, 0xFB, 0xF8, 0x00,
  0xFD, 0xFC, 0x00, 0x7E, 0xFE, 0x00, 0x3F, 0x7F, 0x00, 0x1F, 0xBF, 0x80,
  0x0F, 0xDF, 0xC0, 0x07, 0xEF, 0xE0, 0x03, 0xF7, 0xF0, 0x01, 0xFB, 0xF8,
  0x00, 0xFC, 0xFC, 0x00, 0x7E, 0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x9F,
  0xC0, 0x1F, 0x87, 0xF0, 0x1F, 0xC3, 0xFE, 0x3F, 0xE0, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x10, 0xFF, 0xFE, 0x03, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF3, 0xF0, 0x3F, 0xCF,
  0xC0, 0x3F, 0xBF, 0x00, 0xFE, 0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xEF, 0xC0,
  0x1F, 0xBF, 0x00, 0x7E, 0xFC, 0x01, 0xFB, 0xF0, 0x0F, 0xEF, 0xC0, 0x3F,
  0xBF, 0x03, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xFC, 0x3F, 0x07,
  0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0x8F, 0xC0, 0x7E, 0x3F, 0x01, 0xFC,
  0xFC, 0x07, 0xF3, 0xF0, 0x0F, 0xEF, 0xC0, 0x3F, 0xBF, 0x00, 0x7E, 0xFC,
  0x01, 0xFF, 0xF0, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x01, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xFE, 0x1F, 0xE7, 0xF0, 0x3F,
  0x9F, 0x80, 0x7E, 0xFE, 0x01, 0xFB, 0xF8, 0x07, 0xFF, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x07, 0xFF,
  0x80, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFC,
  0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x1F, 0xDF, 0x80, 0x7E, 0x7F, 0x87,
  0xF8, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xFF,
  0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0,
  0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07,
  0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF,
  0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0,
  0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F,
  0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xBF,
  0x80, 0xFE, 0x7F, 0x8F, 0xF9, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x07, 0xFF,
  0xF8, 0x0F, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0xFC, 0x00, 0x1F, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0xFE, 0x7E, 0x00, 0x3F, 0x9F,
  0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x7E,
  0x0F, 0xE0, 0x1F, 0x81, 0xF8, 0x07, 0xE0, 0x7E, 0x03, 0xF8, 0x1F, 0xC0,
  0xFC, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x0F,
  0xE1, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x3F, 0x80, 0x1F, 0x8F, 0xC0,
  0x03, 0xF3, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x07, 0xDF,
  0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x03,
  0xF0, 0x0F, 0xFF, 0x80, 0xFC, 0x03, 0xF7, 0xE0, 0x3F, 0x01, 0xFD, 0xF8,
  0x0F, 0xC0, 0x7E, 0x7E, 0x03, 0xF8, 0x1F, 0x9F, 0x81, 0xFE, 0x07, 0xE7,
  0xE0, 0x7F, 0x81, 0xF8, 0xFC, 0x1F, 0xE0, 0x7E, 0x3F, 0x07, 0xF8, 0x1F,
  0x8F, 0xC1, 0xFF, 0x0F, 0xC3, 0xF0, 0xFF, 0xC3, 0xF0, 0xFC, 0x3F, 0xF0,
  0xFC, 0x1F, 0x0F, 0xFC, 0x3F, 0x07, 0xE3, 0xFF, 0x0F, 0xC1, 0xF8, 0xFB,
  0xE3, 0xE0, 0x7E, 0x7C, 0xF9, 0xF8, 0x1F, 0x9F, 0x3E, 0x7E, 0x07, 0xE7,
  0xCF, 0x9F, 0x80, 0xF9, 0xF3, 0xE7, 0xE0, 0x3F, 0x7C, 0x7D, 0xF0, 0x0F,
  0xDE, 0x1F, 0x7C, 0x03, 0xFF, 0x87, 0xFF, 0x00, 0xFF, 0xE1, 0xFF, 0xC0,
  0x1F, 0xF8, 0x7F, 0xF0, 0x07, 0xFE, 0x0F, 0xFC, 0x01, 0xFF, 0x03, 0xFE,
  0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x1F, 0xF0, 0x3F, 0xE0, 0x07, 0xFC, 0x07,
  0xF8, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x0F, 0xE0,
  0x1F, 0xC0, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFF,
  0x00, 0x7F, 0x3F, 0x80, 0x3F, 0x9F, 0xC0, 0x1F, 0x87, 0xF0, 0x1F, 0xC3,
  0xF8, 0x0F, 0xC0, 0xFE, 0x0F, 0xE0, 0x7F, 0x07, 0xE0, 0x1F, 0xC7, 0xF0,
  0x0F, 0xE3, 0xF0, 0x03, 0xF9, 0xF8, 0x01, 0xFD, 0xF8, 0x00, 0x7E, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F,
  0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xDF, 0x80, 0x0F,
  0xEF, 0xE0, 0x07, 0xE7, 0xF0, 0x07, 0xF1, 0xFC, 0x03, 0xF0, 0xFE, 0x03,
  0xF8, 0x3F, 0x81, 0xFC, 0x1F, 0xC1, 0xFC, 0x07, 0xF0, 0xFE, 0x03, 0xF8,
  0xFE, 0x01, 0xFE, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x3F, 0xC0, 0x7E, 0x00,
  0x3F, 0xBF, 0x80, 0x1F, 0xCF, 0xC0, 0x0F, 0xC7, 0xF0, 0x0F, 0xE3, 0xF8,
  0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x7F, 0x03, 0xF8, 0x1F, 0x81, 0xF8, 0x0F,
  0xC1, 0xFC, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x7E, 0x00,
  0x3F, 0x3F, 0x00, 0x1F, 0x9F, 0x80, 0x07, 0xDF, 0x80, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1,
  0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E,
  0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F,
  0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFC,
  0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F,
  0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3,
  0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC,
  0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03,
  0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF8, 0x0F, 0x78, 0x1F, 0x78, 0x1E, 0x7C, 0x1E, 0x3C, 0x3E, 0x3C, 0x3C,
  0x3E, 0x7C, 0x3E, 0x7C, 0x1E, 0x7C, 0x1F, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x03, 0xF8, 0x01, 0xFF,
  0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFC, 0x3F, 0x9F, 0x83,
  0xF7, 0xE0, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x0F, 0xFF, 0x07, 0xFF,
  0xE3, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xC3, 0xF7, 0xF0, 0x7E, 0xFC, 0x0F,
  0xDF, 0x81, 0xFB, 0xF0, 0x3F, 0x7E, 0x07, 0xEF, 0xE1, 0xFD, 0xFF, 0xFF,
  0x9F, 0xFF, 0xF1, 0xFF, 0xFE, 0x1F, 0xEF, 0xE1, 0xF8, 0xFC, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF3, 0xF0,
  0x7E, 0xFF, 0x8F, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0xF7, 0xF0, 0xFE,
  0xFC, 0x0F, 0xDF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F,
  0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF,
  0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x1F, 0xBF, 0x87, 0xF7,
  0xFF, 0xFE, 0xFF, 0xFF, 0x9F, 0x7F, 0xF3, 0xE7, 0xFC, 0x7C, 0x7E, 0x00,
  0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC7, 0xFF, 0xFC,
  0xFE, 0x3F, 0x9F, 0x83, 0xF7, 0xE0, 0x3E, 0xFC, 0x07, 0xFF, 0x80, 0xFF,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0xFF, 0xF0, 0x1F, 0xBF, 0x07, 0xE7,
  0xF0, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xFE, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x1F, 0x9F, 0x8F, 0xFB, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0xDF,
  0xFF, 0xFB, 0xF8, 0xFF, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE,
  0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC,
  0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xFC,
  0x0F, 0xDF, 0xC3, 0xFB, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0x7F,
  0xCF, 0x83, 0xE1, 0xF0, 0x01, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFE, 0x1F,
  0xFF, 0xC3, 0xFF, 0xFC, 0xFE, 0x1F, 0x9F, 0x81, 0xFF, 0xF0, 0x3F, 0xFC,
  0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8,
  0x00, 0x3F, 0x00, 0xC7, 0xF8, 0x3C, 0x7F, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF,
  0xFE, 0x07, 0xFF, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x0F, 0xF0, 0x7F, 0xC3,
  0xFF, 0x0F, 0xFC, 0x3F, 0x81, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x0F,
  0xFF, 0xBF, 0xFE, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0x87, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x07, 0xE3, 0xE3,
  0xFF, 0x7C, 0xFF, 0xFF, 0x9F, 0xFF, 0xF7, 0xFF, 0xFE, 0xFE, 0x1F, 0xFF,
  0x81, 0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE,
  0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC,
  0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xF7, 0xF0, 0xFE, 0xFF,
  0xFF, 0xCF, 0xFF, 0xF9, 0xFF, 0xFF, 0x0F, 0xF7, 0xE0, 0xFC, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x20, 0x0F, 0xC7, 0x03, 0xF9, 0xFF,
  0xFE, 0x3F, 0xFF, 0xC7, 0xFF, 0xF0, 0x7F, 0xF8, 0x01, 0xFC, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF1,
  0xF8, 0x7E, 0x7F, 0x8F, 0xDF, 0xF9, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xF8,
  0x7F, 0xFE, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0,
  0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80,
  0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01,
  0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03,
  0xF0, 0x33, 0xEF, 0xFF, 0xFF, 0xF7, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xE0, 0xFC, 0x7F, 0x1F, 0xC3, 0xF0,
  0x78, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x1F, 0xFF, 0xEF, 0xFB, 0xFC, 0xFE,
  0x3F, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x1F, 0xEF, 0xC1, 0xFC, 0xFC, 0x3F, 0x8F, 0xC7,
  0xF0, 0xFC, 0x7F, 0x0F, 0xCF, 0xE0, 0xFC, 0xFC, 0x0F, 0xDF, 0xC0, 0xFF,
  0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F,
  0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFE, 0xFC, 0x0F, 0xC7, 0xE0,
  0xFC, 0x7F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x8F, 0xC3, 0xF8, 0xFC, 0x1F,
  0xCF, 0xC1, 0xFC, 0xFC, 0x0F, 0xEF, 0xC0, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x7C, 0x0F, 0xC3, 0xE7, 0xF8, 0x7F, 0xCF, 0xBF, 0xF3, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFB, 0xF8, 0xFF, 0xC7, 0xFF, 0xC1, 0xFE,
  0x0F, 0xFF, 0x03, 0xF0, 0x3F, 0xFC, 0x0F, 0xC0, 0xFF, 0xF0, 0x3F, 0x03,
  0xFF, 0xC0, 0xFC, 0x0F, 0xFF, 0x03, 0xF0, 0x3F, 0xFC, 0x0F, 0xC0, 0xFF,
  0xF0, 0x3F, 0x03, 0xFF, 0xC0, 0xFC, 0x0F, 0xFF, 0x03, 0xF0, 0x3F, 0xFC,
  0x0F, 0xC0, 0xFF, 0xF0, 0x3F, 0x03, 0xFF, 0xC0, 0xFC, 0x0F, 0xFF, 0x03,
  0xF0, 0x3F, 0xFC, 0x0F, 0xC0, 0xFF, 0xF0, 0x3F, 0x03, 0xFF, 0xC0, 0xFC,
  0x0F, 0xFF, 0x03, 0xF0, 0x3F, 0xFC, 0x0F, 0xC0, 0xFF, 0xF0, 0x3F, 0x03,
  0xF0, 0xFC, 0x3E, 0x1F, 0x9F, 0xE3, 0xF7, 0xFE, 0x7F, 0xFF, 0xEF, 0xFF,
  0xFD, 0xFE, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0,
  0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81,
  0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03,
  0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x07,
  0xFF, 0xC0, 0xFC, 0x01, 0xF8, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x83, 0xFF,
  0xFC, 0x3F, 0xFF, 0xC7, 0xF0, 0xFE, 0x7E, 0x07, 0xEF, 0xE0, 0x7F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFE, 0x07, 0xF7, 0xE0, 0x7E, 0x7F, 0x0F, 0xE3, 0xFF, 0xFC, 0x3F, 0xFF,
  0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x1F, 0x80, 0xF8, 0xFC, 0x1F, 0x3F,
  0xE3, 0xEF, 0xFE, 0x7F, 0xFF, 0xCF, 0xFF, 0xFD, 0xFC, 0x3F, 0xBF, 0x03,
  0xF7, 0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03,
  0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07,
  0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xEF, 0xE1, 0xFD, 0xFF, 0xFF,
  0xBF, 0xFF, 0xE7, 0xFF, 0xF8, 0xFD, 0xFF, 0x1F, 0x9F, 0x83, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE3,
  0xE3, 0xFE, 0x7C, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFE, 0xFE, 0x1F,
  0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F,
  0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F,
  0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xF7, 0xF0, 0xFE,
  0xFF, 0xFF, 0xCF, 0xFF, 0xF9, 0xFF, 0xFF, 0x1F, 0xF7, 0xE0, 0xFC, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0xF8, 0xFF, 0x9F, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x07, 0xFF, 0x83, 0xFF, 0xF1, 0xFF, 0xFE,
  0x7F, 0xFF, 0x9F, 0x87, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0x1F,
  0xC0, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xF8, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x3F,
  0xFC, 0x1F, 0xDF, 0xFF, 0xE7, 0xFF, 0xF8, 0xFF, 0xFC, 0x1F, 0xFE, 0x01,
  0xFE, 0x00, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xF8, 0x1F, 0x81, 0xF8, 0x1F,
  0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F,
  0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xFF, 0x1F, 0xF0, 0xFF, 0x07,
  0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF,
  0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF,
  0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF,
  0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0xFD, 0xF8, 0x1F, 0xBF,
  0x07, 0xF7, 0xF1, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xF9, 0xFF, 0xFF, 0x1F,
  0xF7, 0xE0, 0xF8, 0xFC, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFE, 0x07, 0xE7,
  0xE0, 0x7E, 0x7E, 0x0F, 0xC7, 0xE0, 0xFC, 0x3E, 0x0F, 0xC3, 0xF0, 0xF8,
  0x3F, 0x1F, 0x83, 0xF1, 0xF8, 0x1F, 0x1F, 0x81, 0xF1, 0xF0, 0x1F, 0x9F,
  0x01, 0xFB, 0xF0, 0x0F, 0xBF, 0x00, 0xFB, 0xE0, 0x0F, 0xFE, 0x00, 0x7F,
  0xE0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0xFC, 0x0F, 0x81,
  0xFF, 0xE0, 0x7C, 0x0F, 0xBF, 0x07, 0xE0, 0xFC, 0xF8, 0x3F, 0x07, 0xE7,
  0xC1, 0xFC, 0x3F, 0x3F, 0x0F, 0xE1, 0xF9, 0xF8, 0x7F, 0x0F, 0x8F, 0xC7,
  0xF8, 0x7C, 0x3E, 0x3F, 0xC7, 0xE1, 0xF1, 0xFF, 0x3F, 0x0F, 0xCF, 0xF9,
  0xF0, 0x7E, 0xFB, 0xCF, 0x81, 0xF7, 0xDE, 0x7C, 0x0F, 0xBC, 0xFB, 0xE0,
  0x7D, 0xE7, 0xFF, 0x03, 0xFF, 0x1F, 0xF0, 0x1F, 0xF8, 0xFF, 0x80, 0x7F,
  0x87, 0xFC, 0x03, 0xFC, 0x3F, 0xE0, 0x1F, 0xE0, 0xFF, 0x00, 0xFF, 0x07,
  0xF0, 0x07, 0xF0, 0x3F, 0x80, 0x1F, 0x81, 0xFC, 0x00, 0xFC, 0x07, 0xE0,
  0x07, 0xE0, 0x3E, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0xFE, 0x07, 0xE7, 0xE0,
  0xFE, 0x7F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x9F, 0x81, 0xF9, 0xF8, 0x1F,
  0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00,
  0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x7F, 0xC0,
  0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x01, 0xFB, 0xF0, 0x1F, 0x9F,
  0x83, 0xF1, 0xF8, 0x3F, 0x0F, 0xC7, 0xF0, 0xFE, 0x7E, 0x07, 0xEF, 0xE0,
  0x7F, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFE, 0x07, 0xE7, 0xE0, 0xFE, 0x7E,
  0x0F, 0xC7, 0xE0, 0xFC, 0x7E, 0x0F, 0xC3, 0xF1, 0xF8, 0x3F, 0x1F, 0x83,
  0xF1, 0xF8, 0x3F, 0x1F, 0x81, 0xF9, 0xF0, 0x1F, 0xBF, 0x01, 0xFB, 0xF0,
  0x0F, 0xBE, 0x00, 0xFB, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFC,
  0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03,
  0xF8, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF,
  0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x01,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF0,
  0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x20, 0x0F, 0x01, 0xF0, 0x3F,
  0x07, 0xE0, 0x7C, 0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x1F, 0x81, 0xF8,
  0xFF, 0x0F, 0xE0, 0xFC, 0x0F, 0xE0, 0xFF, 0x03, 0xF0, 0x1F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xFC, 0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x0F,
  0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x60, 0x07,
  0x00, 0xFC, 0x0F, 0xE0, 0x3E, 0x03, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81,
  0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0xF0, 0x7F, 0x03, 0xF0, 0x3F, 0x07, 0xF0,
  0xFC, 0x0F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81,
  0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x01, 0xF0, 0x1F, 0x03, 0xF0, 0x3E, 0x0F,
  0xE0, 0x7C, 0x07, 0x00, 0x60, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0x01, 0xF7,
  0xFE, 0x07, 0xDF, 0xFC, 0x1E, 0xFF, 0xFC, 0xFB, 0xE7, 0xFF, 0xEF, 0x87,
  0xFF, 0x3C, 0x0F, 0xFC, 0xF0, 0x1F, 0xE0, 0x00, 0x3E, 0x00,
};

const GFXglyph RobotoCondensed_SemiBold48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 7, 34, 12, 3, -34 },
  { 31, 12, 13, 15, 2, -36 },
  { 51, 22, 34, 26, 2, -34 },
  { 145, 20, 44, 24, 2, -39 },
  { 255, 26, 34, 31, 2, -34 },
  { 366, 25, 34, 27, 2, -34 },
  { 473, 4, 13, 8, 2, -36 },
  { 480, 11, 49, 15, 3, -38 },
  { 548, 12, 49, 16, 1, -38 },
  { 622, 20, 21, 22, 1, -34 },
  { 675, 19, 25, 23, 2, -28 },
  { 735, 8, 14, 11, 1, -6 },
  { 749, 11, 5, 16, 2, -17 },
  { 756, 7, 7, 14, 3, -7 },
  { 763, 15, 37, 16, 0, -34 },
  { 833, 20, 34, 24, 2, -34 },
  { 918, 12, 34, 24, 4, -34 },
  { 969, 20, 34, 24, 2, -34 },
  { 1054, 20, 34, 24, 2, -34 },
  { 1139, 22, 34, 24, 1, -34 },
  { 1233, 19, 34, 24, 3, -34 },
  { 1314, 19, 34, 24, 3, -34 },
  { 1395, 20, 34, 24, 2, -34 },
  { 1480, 20, 34, 24, 2, -34 },
  { 1565, 20, 34, 24, 2, -34 },
  { 1650, 7, 27, 13, 3, -27 },
  { 1674, 9, 35, 12, 1, -27 },
  { 1714, 16, 22, 21, 2, -26 },
  { 1758, 18, 15, 24, 3, -23 },
  { 1792, 17, 22, 22, 3, -26 },
  { 1839, 18, 34, 21, 1, -34 },
  { 1916, 33, 44, 37, 2, -33 },
  { 2098, 27, 34, 28, 1, -34 },
  { 2213, 21, 34, 27, 3, -34 },
  { 2303, 24, 34, 27, 2, -34 },
  { 2405, 22, 34, 27, 3, -34 },
  { 2499, 19, 34, 24, 3, -34 },
  { 2580, 19, 34, 23, 3, -34 },
  { 2661, 24, 34, 28, 2, -34 },
  { 2763, 24, 34, 30, 3, -34 },
  { 2865, 7, 34, 13, 3, -34 },
  { 2895, 20, 34, 23, 1, -34 },
  { 2980, 24, 34, 26, 3, -34 },
  { 3082, 19, 34, 23, 3, -34 },
  { 3163, 30, 34, 36, 3, -34 },
  { 3291, 23, 34, 29, 3, -34 },
  { 3389, 25, 34, 29, 2, -34 },
  { 3496, 22, 34, 27, 3, -34 },
  { 3590, 25, 40, 29, 2, -34 },
  { 3715, 22, 34, 26, 3, -34 },
  { 3809, 22, 34, 26, 2, -34 },
  { 3903, 24, 34, 26, 1, -34 },
  { 4005, 22, 34, 27, 3, -34 },
  { 4099, 26, 34, 28, 1, -34 },
  { 4210, 34, 34, 36, 1, -34 },
  { 4355, 25, 34, 27, 1, -34 },
  { 4462, 25, 34, 26, 0, -34 },
  { 4569, 22, 34, 25, 2, -34 },
  { 4663, 9, 48, 13, 3, -40 },
  { 4717, 19, 37, 18, 0, -34 },
  { 4805, 9, 48, 13, 1, -40 },
  { 4859, 16, 17, 19, 1, -34 },
  { 4893, 18, 5, 19, 1, 0 },
  { 4905, 12, 7, 16, 1, -36 },
  { 4916, 19, 26, 23, 2, -26 },
  { 4978, 19, 36, 24, 3, -36 },
  { 5064, 19, 26, 22, 2, -26 },
  { 5126, 19, 36, 24, 2, -36 },
  { 5212, 19, 26, 23, 2, -26 },
  { 5274, 14, 36, 16, 1, -36 },
  { 5337, 19, 36, 24, 2, -26 },
  { 5423, 19, 36, 24, 2, -36 },
  { 5509, 6, 36, 12, 3, -36 },
  { 5536, 10, 46, 12, -1, -36 },
  { 5594, 20, 36, 23, 3, -36 },
  { 5684, 6, 36, 12, 3, -36 },
  { 5711, 30, 26, 36, 3, -26 },
  { 5809, 19, 26, 24, 2, -26 },
  { 5871, 20, 26, 24, 2, -26 },
  { 5936, 19, 36, 24, 3, -26 },
  { 6022, 19, 36, 24, 2, -26 },
  { 6108, 12, 26, 16, 3, -26 },
  { 6147, 18, 26, 22, 2, -26 },
  { 6206, 12, 32, 15, 1, -32 },
  { 6254, 19, 26, 24, 2, -26 },
  { 6316, 20, 26, 21, 1, -26 },
  { 6381, 29, 26, 31, 1, -26 },
  { 6476, 20, 26, 22, 1, -26 },
  { 6541, 20, 36, 21, 1, -26 },
  { 6631, 18, 26, 22, 2, -26 },
  { 6690, 12, 45, 14, 1, -37 },
  { 6758, 4, 40, 12, 4, -34 },
  { 6778, 12, 45, 14, 1, -37 },
  { 6846, 22, 10, 27, 3, -19 },
};

const GFXfont RobotoCondensed_SemiBold48pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_SemiBold48pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_SemiBold48pt7bGlyphs,
  0x20, 0x7E, 56
};

#endif // _ROBOTOCONDENSED_SEMIBOLD48PT7B_H_
