#ifndef _ROBOTOCONDENSED_SEMIBOLD23PT7B_H_
#define _ROBOTOCONDENSED_SEMIBOLD23PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-SemiBold.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_SemiBold23pt7bBitmaps[] PROGMEM = {
  0x00, 0x77, 0x66, 0x66, 0x66, 0x66, 0x66, 0x00, 0x6F, 0x60, 0xDF, 0x7D,
  0xB6, 0xDB, 0x60, 0x0D, 0x81, 0xB0, 0x66, 0x0C, 0xC1, 0x98, 0xFF, 0xDF,
  0xF8, 0xD8, 0x13, 0x06, 0x63, 0xFF, 0x7F, 0xE3, 0x20, 0x6C, 0x0D, 0x81,
  0x30, 0x66, 0x00, 0x0C, 0x06, 0x07, 0x87, 0xE7, 0xFB, 0x9D, 0xC6, 0xE0,
  0x70, 0x3E, 0x0F, 0xC1, 0xF0, 0x38, 0x1F, 0x87, 0xC7, 0x77, 0xBF, 0x87,
  0x81, 0x80, 0xC0, 0x78, 0x03, 0xE0, 0x33, 0x11, 0x99, 0x8C, 0xC8, 0x66,
  0xC1, 0xF4, 0x0F, 0x60, 0x06, 0x00, 0x37, 0x03, 0x7C, 0x1B, 0x31, 0x99,
  0x8C, 0xCC, 0xC6, 0x60, 0x3E, 0x00, 0xE0, 0x1E, 0x03, 0xF0, 0x77, 0x07,
  0x30, 0x73, 0x07, 0x70, 0x3F, 0x03, 0xC0, 0x3C, 0x07, 0xEE, 0xEE, 0xEE,
  0x7E, 0xE7, 0xCE, 0x3C, 0xF7, 0xC7, 0xFE, 0x3E, 0xE0, 0xFF, 0xF0, 0x08,
  0x71, 0x8C, 0x31, 0xC6, 0x18, 0x63, 0x8E, 0x38, 0xE3, 0x86, 0x18, 0x61,
  0xC3, 0x0C, 0x18, 0x70, 0x80, 0x86, 0x38, 0xC7, 0x18, 0xC7, 0x39, 0xCE,
  0x73, 0x9C, 0xE7, 0x31, 0x9C, 0xCE, 0x62, 0x00, 0x0C, 0x03, 0x00, 0xC1,
  0xB7, 0xFF, 0xC7, 0x81, 0xE0, 0xEC, 0x33, 0x80, 0x40, 0x1C, 0x0E, 0x07,
  0x03, 0x8F, 0xFF, 0xFF, 0xFE, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x80, 0x33,
  0x37, 0x76, 0x40, 0xFF, 0xC0, 0x7F, 0x60, 0x06, 0x0C, 0x38, 0x60, 0xC1,
  0x87, 0x0C, 0x18, 0x70, 0xC1, 0x83, 0x0E, 0x18, 0x30, 0x61, 0x80, 0x1E,
  0x1F, 0x9D, 0xEC, 0x7E, 0x3F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C,
  0x3E, 0x3B, 0x1D, 0xDE, 0x7E, 0x1E, 0x00, 0x0C, 0xFF, 0xFF, 0x9C, 0x71,
  0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x3E, 0x1F, 0xCF, 0x7B,
  0x8E, 0xE3, 0x80, 0xE0, 0x38, 0x0E, 0x07, 0x03, 0x81, 0xE0, 0x70, 0x38,
  0x1E, 0x0F, 0x03, 0xFF, 0xFF, 0xC0, 0x3E, 0x3F, 0xBD, 0xFC, 0x70, 0x38,
  0x1C, 0x0E, 0x0E, 0x1E, 0x0F, 0x80, 0xE0, 0x7E, 0x3F, 0x1F, 0xDE, 0xFE,
  0x3E, 0x00, 0x07, 0x01, 0xC0, 0xF0, 0x3C, 0x1F, 0x07, 0xC3, 0x70, 0xDC,
  0x77, 0x19, 0xCE, 0x73, 0xFF, 0xFF, 0xC1, 0xC0, 0x70, 0x1C, 0x07, 0x00,
  0x7F, 0x9F, 0xE7, 0xF9, 0xC0, 0x70, 0x18, 0x06, 0xE1, 0xFE, 0x77, 0x80,
  0xE0, 0x1C, 0x07, 0xE1, 0xF8, 0xE7, 0x79, 0xFC, 0x1E, 0x00, 0x0F, 0x07,
  0xC3, 0xE1, 0xE0, 0x70, 0x18, 0x0E, 0xF3, 0xFE, 0xF7, 0xB8, 0xEE, 0x1F,
  0x87, 0xE1, 0xDC, 0xE7, 0xF8, 0xFC, 0x1E, 0x00, 0xFF, 0xFF, 0xF0, 0x18,
  0x0E, 0x03, 0x81, 0xC0, 0x70, 0x1C, 0x0E, 0x03, 0x80, 0xE0, 0x70, 0x1C,
  0x07, 0x03, 0x80, 0xE0, 0x70, 0x00, 0x1E, 0x3F, 0x9D, 0xFC, 0x7E, 0x3B,
  0x1D, 0xDE, 0x7E, 0x7F, 0x39, 0xF8, 0xFC, 0x3E, 0x3F, 0x1D, 0xDE, 0xFE,
  0x1E, 0x00, 0x1E, 0x3F, 0x9D, 0xDC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0x77,
  0xBF, 0xCF, 0xE0, 0x70, 0x38, 0x38, 0xFC, 0x7C, 0x38, 0x00, 0x7F, 0x60,
  0x00, 0x00, 0x07, 0xF6, 0xEF, 0x60, 0x00, 0x00, 0x06, 0x66, 0x6E, 0xCC,
  0x01, 0x07, 0x1F, 0x7C, 0xF0, 0xF0, 0x7C, 0x1F, 0x07, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x78, 0x3F, 0x07, 0xE0, 0x78, 0x3C,
  0xFD, 0xF8, 0xF0, 0x40, 0x00, 0x3C, 0xFE, 0xFF, 0xE7, 0x07, 0x07, 0x07,
  0x0E, 0x1C, 0x1C, 0x18, 0x38, 0x00, 0x00, 0x38, 0x38, 0x18, 0x03, 0xE0,
  0x0F, 0xF8, 0x1C, 0x1C, 0x30, 0x0C, 0x70, 0x06, 0x61, 0xC6, 0x63, 0xE2,
  0xC6, 0x63, 0xC6, 0x63, 0xCE, 0x63, 0xCC, 0x63, 0xCC, 0x62, 0xCC, 0x66,
  0xCE, 0xE6, 0xC7, 0xFC, 0x67, 0x38, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1F, 0xE0, 0x07, 0xC0, 0x07, 0x00, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xFC,
  0x06, 0xE0, 0x77, 0x03, 0x98, 0x1C, 0xE0, 0xC7, 0x0F, 0xF8, 0x7F, 0xE3,
  0xFF, 0x38, 0x39, 0xC0, 0xEE, 0x07, 0xF0, 0x38, 0xFF, 0x1F, 0xFB, 0xFF,
  0x70, 0xEE, 0x1D, 0xC3, 0xB8, 0x77, 0xFC, 0xFF, 0xDC, 0x3B, 0x83, 0xF0,
  0x7E, 0x0F, 0xC3, 0xFF, 0xF7, 0xFE, 0xFF, 0x00, 0x1F, 0x07, 0xF9, 0xFF,
  0x38, 0x7E, 0x0F, 0xC1, 0xF8, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x7E, 0x0E, 0xE1, 0xDE, 0xF1, 0xFE, 0x1F, 0x00, 0xFE, 0x1F, 0xF3, 0xFF,
  0x70, 0xEE, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC3, 0xBF, 0xF7, 0xFC, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xFF, 0xBF, 0xEE, 0x03, 0x80, 0xE0,
  0x38, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x07,
  0x03, 0x81, 0xFF, 0xFF, 0xFF, 0xF8, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x00, 0x1F, 0x87, 0xF9, 0xFF, 0xB8, 0x7E, 0x0F, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x7F, 0x8F, 0xF0, 0x7E, 0x0E, 0xE1, 0xDF, 0xF9, 0xFF,
  0x1F, 0x80, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x7E, 0x3F, 0x1F, 0xFC, 0xFE, 0x3C, 0x00, 0xE0, 0xEE, 0x1E, 0xE3, 0xCE,
  0x38, 0xE7, 0x8E, 0x70, 0xEE, 0x0F, 0xE0, 0xFE, 0x0F, 0xF0, 0xFF, 0x0F,
  0x38, 0xE3, 0x8E, 0x3C, 0xE1, 0xCE, 0x1E, 0xE0, 0xE0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC1,
  0xFF, 0x83, 0xFF, 0x87, 0xFF, 0x1F, 0xF6, 0x3F, 0xEE, 0x6F, 0xDD, 0xDF,
  0x9B, 0xBF, 0x3E, 0x7E, 0x7C, 0xFC, 0x79, 0xF8, 0xF3, 0xF1, 0xC7, 0xE3,
  0x8E, 0xF0, 0x7F, 0x07, 0xF8, 0x7F, 0x87, 0xFC, 0x7F, 0xC7, 0xEC, 0x7E,
  0xE7, 0xE6, 0x7E, 0x77, 0xE3, 0x7E, 0x3F, 0xE1, 0xFE, 0x1F, 0xE0, 0xFE,
  0x0F, 0xE0, 0x70, 0x1F, 0x03, 0xFC, 0x7F, 0xE7, 0x0E, 0xE0, 0xEE, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xE7, 0x0E,
  0x7F, 0xE3, 0xFC, 0x1F, 0x00, 0xFF, 0x1F, 0xFB, 0xFF, 0x70, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xFF, 0xDF, 0xFB, 0xFC, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x00, 0x1F, 0x03, 0xFC, 0x7F, 0xE7, 0x0E, 0xE0,
  0xEE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0xE7, 0x0E, 0x7F, 0xE3, 0xFC, 0x1F, 0xC0, 0x1E, 0x00, 0xE0, 0x04, 0xFF,
  0x1F, 0xF3, 0xFF, 0x70, 0xEE, 0x0F, 0xC1, 0xF8, 0x3F, 0x0E, 0xFF, 0xDF,
  0xF3, 0xFC, 0x71, 0xCE, 0x39, 0xC7, 0xB8, 0x77, 0x0F, 0xE0, 0xE0, 0x1F,
  0x1F, 0xE7, 0xBF, 0x87, 0xE1, 0xF8, 0x07, 0x81, 0xF8, 0x1F, 0x81, 0xF0,
  0x3C, 0x07, 0xE1, 0xF8, 0x7F, 0xBD, 0xFE, 0x1F, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0x87, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x00, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xE1, 0xDF, 0xF1, 0xFE, 0x1F, 0x00, 0xF0, 0x3B, 0x83,
  0x9C, 0x1C, 0xE0, 0xE3, 0x87, 0x1C, 0x70, 0xE3, 0x87, 0x1C, 0x1C, 0xE0,
  0xEE, 0x07, 0x70, 0x1B, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0xF0, 0x07,
  0x00, 0xE3, 0x87, 0xE3, 0x87, 0xE3, 0x8E, 0xE3, 0xCE, 0xE3, 0xCE, 0x67,
  0xCE, 0x77, 0xCE, 0x76, 0xCC, 0x76, 0xEC, 0x76, 0xFC, 0x7E, 0x7C, 0x3E,
  0x7C, 0x3C, 0x7C, 0x3C, 0x78, 0x3C, 0x78, 0x3C, 0x38, 0x3C, 0x38, 0x70,
  0x77, 0x8F, 0x38, 0xE3, 0x9E, 0x1D, 0xC1, 0xDC, 0x0F, 0x80, 0xF8, 0x07,
  0x00, 0xF8, 0x0F, 0x81, 0xDC, 0x1D, 0xC3, 0x9E, 0x38, 0xE7, 0x8F, 0x70,
  0x70, 0xF0, 0x77, 0x0F, 0x70, 0xE3, 0x8E, 0x39, 0xC3, 0x9C, 0x1D, 0x81,
  0xF8, 0x0F, 0x80, 0xF0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x03, 0x81, 0xC0, 0x70,
  0x38, 0x0E, 0x07, 0x03, 0xC0, 0xE0, 0x70, 0x1C, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xF9, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7,
  0x39, 0xCE, 0x7F, 0xE0, 0xE0, 0x38, 0x1C, 0x0E, 0x03, 0x81, 0xC0, 0xE0,
  0x38, 0x1C, 0x0E, 0x03, 0x01, 0xC0, 0xE0, 0x30, 0x1C, 0x0E, 0x07, 0x01,
  0xC0, 0xFF, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39,
  0xCE, 0x73, 0xFF, 0xE0, 0x38, 0x70, 0xE3, 0x66, 0xDD, 0xB1, 0xE3, 0xFF,
  0xFF, 0xC0, 0xE3, 0x8E, 0x3E, 0x3F, 0xBD, 0xDC, 0x70, 0x39, 0xFD, 0xFF,
  0xC7, 0xE3, 0xF3, 0xFF, 0xEF, 0x70, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0xF3, 0xFE, 0xF7, 0xB8, 0xEE, 0x1F, 0x87, 0xE1, 0xF8, 0x7E,
  0x3B, 0xDE, 0xFF, 0xBB, 0xC0, 0x3E, 0x3F, 0xBD, 0xDC, 0x7E, 0x3F, 0x03,
  0x81, 0xC0, 0xE3, 0xFB, 0xDF, 0xC7, 0xC0, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0xFE, 0xFF, 0xF7, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F,
  0xEF, 0x7F, 0x9D, 0xC0, 0x3E, 0x3F, 0x9D, 0xFC, 0x7E, 0x3F, 0xFF, 0xFF,
  0xC0, 0xE0, 0x79, 0xDF, 0xE3, 0xC0, 0x1C, 0xF7, 0x9C, 0x71, 0xCF, 0xFF,
  0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC0, 0x3D, 0xBF, 0xFD, 0xFC,
  0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xFB, 0xDF, 0xE7, 0xF0, 0x38, 0x1D,
  0x9E, 0xFE, 0x3E, 0x00, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0xBD,
  0xFE, 0xF7, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1,
  0xC0, 0x7D, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x39, 0xC6, 0x00, 0x1C,
  0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCF, 0x7F, 0xF8, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x3B, 0x9C, 0xEF, 0x3B, 0x8F, 0xC3,
  0xF0, 0xFE, 0x3F, 0x8E, 0x73, 0x9C, 0xE3, 0xB8, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xEF, 0x39, 0xFE, 0xFB, 0xDF, 0x7F, 0x1C, 0x7E,
  0x38, 0xFC, 0x71, 0xF8, 0xE3, 0xF1, 0xC7, 0xE3, 0x8F, 0xC7, 0x1F, 0x8E,
  0x3F, 0x1C, 0x70, 0xEF, 0x7F, 0xBD, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7,
  0xE3, 0xF1, 0xF8, 0xFC, 0x70, 0x3E, 0x1F, 0xCF, 0x7B, 0x8E, 0xE1, 0xF8,
  0x7E, 0x1F, 0x87, 0xE3, 0xBD, 0xE7, 0xF0, 0xF8, 0xEF, 0x3F, 0xEF, 0x7B,
  0x8E, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE3, 0xBD, 0xEF, 0xFB, 0xBC, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x00, 0x3D, 0xBF, 0xFD, 0xFC, 0x7E, 0x3F,
  0x1F, 0x8F, 0xC7, 0xE3, 0xFB, 0xDF, 0xE7, 0xF0, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x80, 0xEF, 0xFF, 0xFC, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0x3E,
  0x3F, 0xB9, 0xDC, 0x6F, 0x03, 0xE0, 0xFC, 0x0E, 0xE3, 0xF3, 0x9F, 0xC7,
  0xC0, 0x38, 0xE3, 0xBF, 0xFC, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xF1,
  0xC0, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xFB,
  0xDF, 0xE7, 0x70, 0xE1, 0xDC, 0x67, 0x39, 0xCE, 0x33, 0x8E, 0xC3, 0xF0,
  0xFC, 0x1E, 0x07, 0x81, 0xE0, 0x38, 0x63, 0x1D, 0x8E, 0x77, 0x39, 0xDD,
  0xE6, 0x77, 0x98, 0xDB, 0xE3, 0x6F, 0x8F, 0xBE, 0x3C, 0xF0, 0x71, 0xC1,
  0xC7, 0x07, 0x1C, 0x71, 0xDC, 0xE3, 0xB8, 0xFC, 0x1E, 0x07, 0x81, 0xE0,
  0x7C, 0x3F, 0x0E, 0xE7, 0x39, 0xC7, 0xE1, 0xDC, 0xE7, 0x39, 0xCE, 0x33,
  0x8E, 0xC3, 0xF0, 0xFC, 0x1E, 0x07, 0x81, 0xE0, 0x38, 0x0C, 0x07, 0x03,
  0xC1, 0xE0, 0x70, 0x00, 0xFF, 0xFF, 0x07, 0x0E, 0x0E, 0x1C, 0x38, 0x38,
  0x70, 0xE0, 0xFF, 0xFF, 0x09, 0xCC, 0xE7, 0x39, 0xCE, 0x73, 0xB9, 0xC7,
  0x39, 0xCE, 0x73, 0x8C, 0x63, 0x84, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x86,
  0x38, 0xC7, 0x39, 0xCE, 0x73, 0x8E, 0x77, 0x39, 0xCE, 0x73, 0x99, 0xCC,
  0x40, 0x38, 0x6F, 0x9D, 0xBB, 0x73, 0xEC, 0x38,
};

const GFXglyph RobotoCondensed_SemiBold23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 4, 17, 6, 1, -17 },
  { 10, 6, 6, 7, 1, -17 },
  { 15, 11, 17, 12, 1, -17 },
  { 39, 9, 21, 12, 1, -19 },
  { 63, 13, 17, 15, 1, -17 },
  { 91, 12, 17, 13, 1, -17 },
  { 117, 2, 6, 4, 1, -17 },
  { 119, 6, 23, 7, 1, -18 },
  { 137, 5, 23, 7, 1, -18 },
  { 152, 10, 10, 10, 0, -17 },
  { 165, 9, 12, 11, 1, -13 },
  { 179, 4, 7, 5, 0, -3 },
  { 183, 5, 2, 8, 1, -8 },
  { 185, 4, 3, 7, 1, -3 },
  { 187, 7, 18, 8, 0, -17 },
  { 203, 9, 17, 12, 1, -17 },
  { 223, 6, 17, 12, 2, -17 },
  { 236, 10, 17, 12, 1, -17 },
  { 258, 9, 17, 12, 1, -17 },
  { 278, 10, 17, 12, 1, -17 },
  { 300, 10, 17, 12, 1, -17 },
  { 322, 10, 17, 12, 1, -17 },
  { 344, 10, 17, 12, 1, -17 },
  { 366, 9, 17, 12, 1, -17 },
  { 386, 9, 17, 12, 1, -17 },
  { 406, 4, 12, 6, 1, -12 },
  { 412, 4, 16, 6, 1, -12 },
  { 420, 8, 10, 10, 1, -12 },
  { 430, 8, 7, 11, 2, -11 },
  { 437, 9, 10, 10, 1, -12 },
  { 449, 8, 17, 10, 1, -17 },
  { 466, 16, 21, 18, 1, -16 },
  { 508, 13, 17, 14, 0, -17 },
  { 536, 11, 17, 13, 1, -17 },
  { 560, 11, 17, 13, 1, -17 },
  { 584, 11, 17, 13, 1, -17 },
  { 608, 10, 17, 11, 1, -17 },
  { 630, 9, 17, 11, 1, -17 },
  { 650, 11, 17, 13, 1, -17 },
  { 674, 12, 17, 14, 1, -17 },
  { 700, 3, 17, 6, 2, -17 },
  { 707, 9, 17, 11, 1, -17 },
  { 727, 12, 17, 13, 1, -17 },
  { 753, 9, 17, 11, 1, -17 },
  { 773, 15, 17, 17, 1, -17 },
  { 805, 12, 17, 14, 1, -17 },
  { 831, 12, 17, 14, 1, -17 },
  { 857, 11, 17, 13, 1, -17 },
  { 881, 12, 20, 14, 1, -17 },
  { 911, 11, 17, 13, 1, -17 },
  { 935, 10, 17, 12, 1, -17 },
  { 957, 11, 17, 12, 1, -17 },
  { 981, 11, 17, 13, 1, -17 },
  { 1005, 13, 17, 13, 0, -17 },
  { 1033, 16, 17, 17, 1, -17 },
  { 1067, 12, 17, 13, 0, -17 },
  { 1093, 12, 17, 12, 0, -17 },
  { 1119, 10, 17, 12, 1, -17 },
  { 1141, 5, 23, 6, 1, -19 },
  { 1156, 9, 18, 9, 0, -17 },
  { 1177, 5, 23, 6, 0, -19 },
  { 1192, 7, 8, 9, 1, -17 },
  { 1199, 9, 2, 9, 0, 0 },
  { 1202, 5, 3, 7, 1, -17 },
  { 1204, 9, 12, 11, 1, -12 },
  { 1218, 10, 18, 11, 1, -18 },
  { 1241, 9, 12, 11, 1, -12 },
  { 1255, 9, 18, 11, 1, -18 },
  { 1276, 9, 12, 11, 1, -12 },
  { 1290, 6, 18, 7, 1, -18 },
  { 1304, 9, 17, 12, 1, -12 },
  { 1324, 9, 18, 11, 1, -18 },
  { 1345, 3, 17, 6, 1, -17 },
  { 1352, 5, 22, 6, -1, -17 },
  { 1366, 10, 18, 11, 1, -18 },
  { 1389, 3, 18, 6, 1, -18 },
  { 1396, 15, 12, 17, 1, -12 },
  { 1419, 9, 12, 11, 1, -12 },
  { 1433, 10, 12, 11, 1, -12 },
  { 1448, 10, 17, 11, 1, -12 },
  { 1470, 9, 17, 11, 1, -12 },
  { 1490, 6, 12, 7, 1, -12 },
  { 1499, 9, 12, 10, 1, -12 },
  { 1513, 6, 15, 7, 0, -15 },
  { 1525, 9, 12, 11, 1, -12 },
  { 1539, 10, 12, 10, 0, -12 },
  { 1554, 14, 12, 15, 0, -12 },
  { 1575, 10, 12, 10, 0, -12 },
  { 1590, 10, 17, 10, 0, -12 },
  { 1612, 8, 12, 10, 1, -12 },
  { 1624, 5, 22, 7, 1, -18 },
  { 1638, 2, 20, 6, 2, -17 },
  { 1643, 5, 22, 7, 1, -18 },
  { 1657, 11, 5, 13, 1, -9 },
};

const GFXfont RobotoCondensed_SemiBold23pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_SemiBold23pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_SemiBold23pt7bGlyphs,
  0x20, 0x7E, 27
};

#endif // _ROBOTOCONDENSED_SEMIBOLD23PT7B_H_
