#ifndef _ROBOTOCONDENSED_SEMIBOLD52PT7B_H_
#define _ROBOTOCONDENSED_SEMIBOLD52PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-SemiBold.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_SemiBold52pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7,
  0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x7F, 0xFF, 0xFB, 0xF7, 0xC2, 0x00, 0xF8,
  0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFE, 0x1E,
  0xF0, 0xF7, 0x87, 0xBC, 0x3D, 0xE1, 0xEF, 0x0F, 0x78, 0x78, 0x00, 0x78,
  0x78, 0x00, 0x78, 0x78, 0x00, 0x78, 0x78, 0x00, 0xF8, 0xF8, 0x00, 0xF8,
  0xF8, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xF0,
  0xF0, 0x00, 0xF0, 0xF0, 0x01, 0xF1, 0xF0, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x01, 0xE1, 0xE0, 0x03, 0xE1,
  0xE0, 0x03, 0xE3, 0xE0, 0x03, 0xC3, 0xC0, 0x03, 0xC3, 0xC0, 0x03, 0xC3,
  0xC0, 0x03, 0xC3, 0xC0, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFC, 0x07, 0x87, 0x80, 0x07, 0x87, 0x80, 0x07, 0x87,
  0x80, 0x07, 0x87, 0x80, 0x0F, 0x8F, 0x80, 0x0F, 0x0F, 0x00, 0x0F, 0x0F,
  0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x1F, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xF0, 0x0F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xF1, 0xFE, 0x3F, 0x83,
  0xF8, 0xFC, 0x07, 0xE3, 0xF0, 0x1F, 0x8F, 0xC0, 0x7F, 0x3F, 0x01, 0xFC,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x07, 0xFF,
  0x80, 0x07, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7F, 0xFE, 0x01, 0xFD, 0xF8, 0x07, 0xF7, 0xE0,
  0x1F, 0xDF, 0xC0, 0x7E, 0x7F, 0x03, 0xF9, 0xFE, 0x1F, 0xE3, 0xFF, 0xFF,
  0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x3F, 0xF0, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x02, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x0F, 0x8F, 0x81,
  0x80, 0xF0, 0x78, 0x3E, 0x0F, 0x07, 0x83, 0xC0, 0xF0, 0x78, 0x7C, 0x0F,
  0x07, 0x87, 0x80, 0xF0, 0x78, 0xF8, 0x0F, 0x07, 0x8F, 0x00, 0xF8, 0xF9,
  0xF0, 0x0F, 0xDF, 0x1E, 0x00, 0x7F, 0xF3, 0xC0, 0x07, 0xFE, 0x3C, 0x00,
  0x1F, 0xC7, 0x80, 0x00, 0x20, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x7F,
  0x80, 0x03, 0xCF, 0xFC, 0x00, 0x79, 0xFF, 0xE0, 0x07, 0x9F, 0xFE, 0x00,
  0xF1, 0xE1, 0xF0, 0x1F, 0x3E, 0x1F, 0x01, 0xE3, 0xE1, 0xF0, 0x3E, 0x3E,
  0x1F, 0x03, 0xC3, 0xE1, 0xF0, 0x7C, 0x3E, 0x1F, 0x07, 0x83, 0xE1, 0xF0,
  0x78, 0x1E, 0x1F, 0x03, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xF1, 0xF8, 0x00, 0xFC, 0x1F, 0x00,
  0x1F, 0x83, 0xE0, 0x03, 0xF0, 0x7C, 0x00, 0x7E, 0x0F, 0x80, 0x0F, 0xC1,
  0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x9F, 0x80, 0x03, 0xF7, 0xF0, 0x00,
  0x7F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xC1, 0xF8, 0x7F, 0xFC, 0x3F, 0x0F,
  0xFF, 0xC7, 0xE3, 0xFB, 0xFC, 0xFC, 0x7E, 0x3F, 0x9F, 0x9F, 0xC3, 0xFB,
  0xE3, 0xF8, 0x7F, 0xFC, 0x7F, 0x07, 0xFF, 0x8F, 0xE0, 0x7F, 0xF1, 0xFC,
  0x0F, 0xFC, 0x3F, 0x80, 0xFF, 0x87, 0xF8, 0x0F, 0xE0, 0x7F, 0x87, 0xFE,
  0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFB, 0xFC, 0x0F, 0xFC, 0x3F, 0xC0, 0x08, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xBD, 0xEF, 0x78, 0x00, 0x20, 0x07, 0x00, 0xF0, 0x1F,
  0x03, 0xF0, 0x3E, 0x07, 0xC0, 0xFC, 0x0F, 0x81, 0xF8, 0x1F, 0x01, 0xF0,
  0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0x7C, 0x07, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x07, 0xC0, 0x7C, 0x07, 0xC0,
  0x7E, 0x07, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x01, 0xF8,
  0x0F, 0x80, 0xFC, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x00, 0xF0, 0x07,
  0x00, 0x20, 0x40, 0x03, 0x80, 0x1E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x03,
  0xF0, 0x0F, 0x80, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x03, 0xE0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x3E, 0x03, 0xF0,
  0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xE0, 0x1E,
  0x00, 0xE0, 0x04, 0x00, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x06, 0x07, 0x81,
  0x9F, 0x1E, 0x3E, 0xFF, 0x7B, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x81,
  0xFF, 0xF0, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xF7,
  0xC0, 0x0F, 0x8F, 0x80, 0x7E, 0x3F, 0x01, 0xF0, 0x7C, 0x07, 0xC0, 0xF8,
  0x0E, 0x03, 0x80, 0x00, 0x04, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F,
  0x3F, 0x3F, 0x3E, 0x7E, 0x7C, 0xFC, 0x78, 0x10, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0x7E, 0x7F, 0xFF, 0xFF, 0x7F, 0x7E, 0x00,
  0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0,
  0x00, 0x00, 0x20, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0x03,
  0xFF, 0xFC, 0x1F, 0xFF, 0xE1, 0xFC, 0x3F, 0x8F, 0xC0, 0xFC, 0xFE, 0x07,
  0xF7, 0xF0, 0x1F, 0xBF, 0x00, 0xFD, 0xF8, 0x07, 0xEF, 0xC0, 0x3F, 0x7E,
  0x01, 0xFB, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F,
  0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0,
  0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xBF, 0x00, 0xFD,
  0xF8, 0x07, 0xEF, 0xC0, 0x3F, 0x7F, 0x01, 0xFB, 0xF8, 0x1F, 0xCF, 0xC0,
  0xFC, 0x7F, 0x0F, 0xE1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x01, 0xF0,
  0x1F, 0xC1, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF,
  0xC7, 0xF8, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8,
  0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC7, 0xF8, 0x7F, 0x1F, 0xC0, 0xFE, 0xFE,
  0x03, 0xFB, 0xF8, 0x0F, 0xEF, 0xE0, 0x1F, 0xBF, 0x80, 0x7E, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF0, 0x00, 0x20,
  0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFE, 0x1F,
  0xFF, 0xF9, 0xFE, 0x3F, 0xCF, 0xE0, 0x7E, 0xFE, 0x03, 0xFF, 0xF0, 0x1F,
  0xFF, 0x80, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xFF,
  0xC0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0x7F, 0x87,
  0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0xFF, 0xF8, 0x03,
  0xFF, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0x7E, 0x00,
  0xFD, 0xF8, 0x03, 0xE7, 0xE0, 0x1F, 0x9F, 0x80, 0x7C, 0x7E, 0x03, 0xF1,
  0xF8, 0x0F, 0x87, 0xE0, 0x7E, 0x1F, 0x81, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE1, 0xF8, 0x1F, 0x87, 0xE0, 0x7E, 0x3F, 0x01, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x3F,
  0xFF, 0xF1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF,
  0x1F, 0xFF, 0xF8, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x3F, 0x01,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x1F, 0xC7,
  0xFC, 0x78, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xF8, 0x07,
  0xFF, 0xC0, 0x3F, 0xFF, 0x01, 0xFB, 0xF8, 0x1F, 0xCF, 0xE1, 0xFE, 0x7F,
  0xFF, 0xE1, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x3F, 0xE0,
  0x00, 0x10, 0x00, 0x00, 0x1F, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0xC0, 0x07,
  0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x80, 0x7F, 0xC0, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x7F, 0x3F, 0x03, 0xF3, 0xFE, 0x1F, 0xBF, 0xF8, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0x3F, 0xF7, 0xFD, 0xFE, 0x0F, 0xEF, 0xE0, 0x3F, 0xFE, 0x01,
  0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xBF, 0x01, 0xFD, 0xFC, 0x1F,
  0xCF, 0xF1, 0xFE, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xF0, 0x0F,
  0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x10, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0x03,
  0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xFC, 0x3F, 0x8F, 0xE0, 0xFC, 0xFE, 0x07,
  0xF7, 0xF0, 0x3F, 0xBF, 0x81, 0xFD, 0xFC, 0x0F, 0xEF, 0xE0, 0x7F, 0x3F,
  0x03, 0xF9, 0xF8, 0x1F, 0x8F, 0xE1, 0xFC, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE,
  0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xE1, 0xFC,
  0x3F, 0x8F, 0xC0, 0xFE, 0xFE, 0x07, 0xF7, 0xE0, 0x1F, 0xBF, 0x00, 0xFD,
  0xF8, 0x07, 0xEF, 0xC0, 0x3F, 0xFE, 0x01, 0xFB, 0xF8, 0x0F, 0xDF, 0xC0,
  0xFE, 0xFF, 0x0F, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0x81,
  0xFF, 0xF8, 0x03, 0xFF, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0x81, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0,
  0xFE, 0x3F, 0xCF, 0xE0, 0xFE, 0x7F, 0x03, 0xF3, 0xF0, 0x1F, 0xDF, 0x80,
  0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF,
  0xC0, 0x3F, 0x7E, 0x01, 0xFB, 0xF0, 0x0F, 0xDF, 0xC0, 0xFE, 0xFE, 0x0F,
  0xF3, 0xFC, 0xFF, 0x9F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x07,
  0xFD, 0xF8, 0x1F, 0x9F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x07, 0xFF, 0x80, 0x3F,
  0xFC, 0x01, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xE0, 0x00,
  0x3C, 0x7E, 0x7F, 0xFF, 0xFF, 0x7F, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x7E, 0x7F,
  0xFF, 0xFF, 0x7F, 0x7E, 0x00, 0x0F, 0x07, 0xE3, 0xF8, 0xFF, 0x3F, 0xCF,
  0xE1, 0xF8, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x7E, 0x1F,
  0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF0, 0xFC, 0x3E, 0x1F, 0x87,
  0xC1, 0xE0, 0x18, 0x00, 0x00, 0x00, 0x40, 0x00, 0x70, 0x00, 0x7C, 0x00,
  0x7F, 0x00, 0x7F, 0xC0, 0x7F, 0xF0, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC,
  0x3F, 0xFC, 0x0F, 0xF8, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xE0, 0x0F,
  0xFE, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFC, 0x01,
  0xFF, 0x00, 0x1F, 0xC0, 0x01, 0xF0, 0x00, 0x1C, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x80, 0x00, 0x1C, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0x00,
  0x0F, 0xF8, 0x01, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x07, 0xFF,
  0x80, 0x3F, 0xFC, 0x01, 0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0xFF,
  0xC0, 0x7F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFE, 0x1F, 0xFF, 0x03, 0xFF, 0x80,
  0x7F, 0xC0, 0x0F, 0xE0, 0x01, 0xF0, 0x00, 0x38, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0x81, 0xFF, 0xFC, 0x3F, 0xFF,
  0xC3, 0xFF, 0xFE, 0x7F, 0x8F, 0xE7, 0xF0, 0x7F, 0x7E, 0x07, 0xF7, 0xE0,
  0x7F, 0xFE, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x01, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFE, 0x01, 0xFC,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x7E, 0x00,
  0x00, 0xF0, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0x78, 0x0F,
  0x00, 0x00, 0x03, 0xC1, 0xF0, 0x07, 0xE0, 0x3C, 0x1E, 0x01, 0xFF, 0x03,
  0xE3, 0xE0, 0x3F, 0xFC, 0x1E, 0x3C, 0x07, 0xFF, 0xC1, 0xE3, 0xC0, 0xFC,
  0x7C, 0x1E, 0x7C, 0x0F, 0x87, 0xC1, 0xE7, 0xC1, 0xF0, 0x7C, 0x1E, 0x78,
  0x1F, 0x07, 0xC0, 0xF7, 0x81, 0xF0, 0x7C, 0x0F, 0x78, 0x3E, 0x07, 0xC0,
  0xFF, 0x83, 0xE0, 0x78, 0x0F, 0xF8, 0x3E, 0x07, 0x80, 0xFF, 0x83, 0xE0,
  0x78, 0x0F, 0xF8, 0x3E, 0x07, 0x81, 0xEF, 0x87, 0xE0, 0x78, 0x1E, 0xF8,
  0x7E, 0x0F, 0x81, 0xEF, 0x87, 0xE0, 0xF8, 0x1E, 0xF8, 0x7E, 0x0F, 0x81,
  0xEF, 0x83, 0xE0, 0xF8, 0x3C, 0xF8, 0x3E, 0x1F, 0x83, 0xC7, 0x83, 0xF1,
  0xF8, 0x7C, 0x78, 0x3F, 0xFF, 0xCF, 0x87, 0xC1, 0xFF, 0xFF, 0xF0, 0x7C,
  0x0F, 0xF3, 0xFE, 0x07, 0xC0, 0x7E, 0x1F, 0xC0, 0x3E, 0x01, 0x00, 0x20,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x80, 0x00, 0x3F, 0xC0, 0x78, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07,
  0xEF, 0x80, 0x00, 0x3F, 0x7E, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x1F, 0xDF,
  0x80, 0x00, 0xFC, 0x7E, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x7F, 0x1F, 0x80,
  0x03, 0xF0, 0xFE, 0x00, 0x1F, 0x83, 0xF0, 0x01, 0xFC, 0x1F, 0x80, 0x0F,
  0xE0, 0xFE, 0x00, 0x7E, 0x03, 0xF0, 0x03, 0xF0, 0x1F, 0x80, 0x3F, 0x80,
  0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x1F,
  0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xFC, 0x7F, 0x00,
  0x07, 0xF3, 0xF8, 0x00, 0x3F, 0xBF, 0xC0, 0x01, 0xFD, 0xFC, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x3F, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xBF, 0x80,
  0xFF, 0x7F, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03,
  0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xBF, 0x80, 0x7F,
  0x7F, 0x01, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xDF, 0xC0, 0x3F, 0xBF, 0x80, 0x3F, 0xFF,
  0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0,
  0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x08, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0xFF,
  0x07, 0xF8, 0xFF, 0x01, 0xFE, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x1F, 0xBF,
  0x80, 0x0F, 0xDF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x01, 0xFF,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0,
  0x03, 0xF9, 0xFC, 0x01, 0xFC, 0xFE, 0x01, 0xFE, 0x3F, 0xC1, 0xFE, 0x1F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x20, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8,
  0xFE, 0x03, 0xFC, 0xFE, 0x01, 0xFC, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE,
  0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7E, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x01, 0xFC,
  0xFE, 0x03, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xF0, 0xFF, 0x87, 0xF8, 0xFF, 0x00, 0xFE, 0x7F, 0x00, 0x7F,
  0x7F, 0x00, 0x1F, 0xBF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03,
  0xFF, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x81, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF,
  0xE0, 0x03, 0xFF, 0xF8, 0x01, 0xFD, 0xFC, 0x00, 0xFE, 0xFF, 0x00, 0x7F,
  0x3F, 0xE0, 0xFF, 0x9F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x00, 0x30, 0x00, 0xFE, 0x00,
  0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F,
  0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00,
  0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01,
  0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0,
  0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF,
  0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07,
  0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xFF,
  0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xBF, 0x81, 0xFD, 0xFC, 0x1F,
  0xEF, 0xF1, 0xFE, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x1F,
  0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x10, 0x00, 0xFE, 0x00, 0x7F, 0xBF, 0x80,
  0x3F, 0xCF, 0xE0, 0x0F, 0xF3, 0xF8, 0x07, 0xF8, 0xFE, 0x03, 0xFC, 0x3F,
  0x80, 0xFF, 0x0F, 0xE0, 0x7F, 0x83, 0xF8, 0x1F, 0xC0, 0xFE, 0x0F, 0xF0,
  0x3F, 0x87, 0xF8, 0x0F, 0xE1, 0xFC, 0x03, 0xF8, 0xFF, 0x00, 0xFE, 0x3F,
  0x80, 0x3F, 0x9F, 0xC0, 0x0F, 0xEF, 0xF0, 0x03, 0xFB, 0xF8, 0x00, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x03, 0xFE, 0x7F,
  0x00, 0xFF, 0x1F, 0xE0, 0x3F, 0x83, 0xFC, 0x0F, 0xE0, 0xFF, 0x03, 0xF8,
  0x1F, 0xE0, 0xFE, 0x07, 0xF8, 0x3F, 0x80, 0xFF, 0x0F, 0xE0, 0x3F, 0xC3,
  0xF8, 0x07, 0xF8, 0xFE, 0x01, 0xFE, 0x3F, 0x80, 0x3F, 0xCF, 0xE0, 0x0F,
  0xF3, 0xF8, 0x01, 0xFE, 0xFE, 0x00, 0x7F, 0xC0, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xEF,
  0xC0, 0x3E, 0xFF, 0xF7, 0xE0, 0x3F, 0x7F, 0xFF, 0xF0, 0x1F, 0xBF, 0xFE,
  0xFC, 0x0F, 0x9F, 0xFF, 0x7E, 0x0F, 0xCF, 0xFF, 0xBF, 0x07, 0xE7, 0xFF,
  0xCF, 0xC3, 0xE3, 0xFF, 0xE7, 0xE3, 0xF1, 0xFF, 0xF3, 0xF1, 0xF8, 0xFF,
  0xF8, 0xFC, 0xFC, 0x7F, 0xFC, 0x7E, 0x7C, 0x3F, 0xFE, 0x3F, 0x7E, 0x1F,
  0xFF, 0x0F, 0xBF, 0x0F, 0xFF, 0x87, 0xFF, 0x07, 0xFF, 0xC3, 0xFF, 0x83,
  0xFF, 0xE1, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xC0, 0xFF, 0xF8, 0x3F, 0xE0,
  0x7F, 0xFC, 0x1F, 0xF0, 0x3F, 0xFE, 0x07, 0xF8, 0x1F, 0xFF, 0x03, 0xF8,
  0x0F, 0xFF, 0x81, 0xFC, 0x07, 0xFF, 0xC0, 0x7E, 0x03, 0xFF, 0xE0, 0x3E,
  0x01, 0xF8, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x07, 0xFF,
  0xEF, 0xC1, 0xFF, 0xFB, 0xF8, 0x7F, 0xFE, 0x7E, 0x1F, 0xFF, 0x9F, 0xC7,
  0xFF, 0xE3, 0xF1, 0xFF, 0xF8, 0xFE, 0x7F, 0xFE, 0x1F, 0x9F, 0xFF, 0x87,
  0xF7, 0xFF, 0xE0, 0xFD, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFE,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFF,
  0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x83, 0xFE,
  0x3F, 0xE1, 0xFE, 0x03, 0xFC, 0x7F, 0x00, 0x7F, 0x1F, 0x80, 0x0F, 0xEF,
  0xE0, 0x03, 0xFB, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x1F, 0xBF, 0x00, 0x07,
  0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00,
  0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF,
  0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F,
  0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7E, 0xFE, 0x00,
  0x3F, 0xBF, 0x80, 0x0F, 0xE7, 0xF0, 0x07, 0xF9, 0xFE, 0x03, 0xFC, 0x3F,
  0xE1, 0xFF, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0,
  0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x80, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFE, 0xFE, 0x01, 0xFE, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xFC, 0x7F,
  0xC1, 0xFE, 0x03, 0xFC, 0x3F, 0x80, 0x3F, 0x8F, 0xE0, 0x03, 0xF9, 0xFC,
  0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xE7, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x1F,
  0xDF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0,
  0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0x7E, 0x00,
  0x0F, 0xEF, 0xC0, 0x01, 0xFD, 0xFC, 0x00, 0x3F, 0x3F, 0x80, 0x0F, 0xE7,
  0xF0, 0x01, 0xFC, 0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x0F, 0xE1, 0xFE, 0x03,
  0xFC, 0x1F, 0xF1, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0x3F,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x20, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xE3, 0xF8, 0x07, 0xF9, 0xFC, 0x01, 0xFC, 0xFE, 0x00,
  0xFE, 0x7F, 0x00, 0x7F, 0x3F, 0x80, 0x3F, 0x9F, 0xC0, 0x0F, 0xCF, 0xE0,
  0x0F, 0xE7, 0xF0, 0x07, 0xF3, 0xF8, 0x03, 0xF9, 0xFC, 0x03, 0xFC, 0xFE,
  0x03, 0xFC, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xFC, 0x1F, 0xC0,
  0xFE, 0x0F, 0xE0, 0x7F, 0x07, 0xF8, 0x3F, 0x81, 0xFC, 0x1F, 0xC0, 0xFF,
  0x0F, 0xE0, 0x3F, 0x87, 0xF0, 0x1F, 0xC3, 0xF8, 0x07, 0xF1, 0xFC, 0x03,
  0xF8, 0xFE, 0x01, 0xFE, 0x7F, 0x00, 0x7F, 0x3F, 0x80, 0x3F, 0xDF, 0xC0,
  0x0F, 0xEF, 0xE0, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x07,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x7F,
  0xC3, 0xFC, 0x7F, 0x01, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7E,
  0x00, 0x7E, 0x7E, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07,
  0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0x7F, 0x00, 0xFE, 0x7F, 0xC1, 0xFE, 0x3F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00,
  0x18, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFE, 0xFF, 0x00, 0xFE,
  0x7F, 0xC3, 0xFE, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x10, 0x00, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0xFE, 0x7F,
  0x00, 0x0F, 0xE7, 0xF0, 0x01, 0xFE, 0x3F, 0x80, 0x1F, 0xC3, 0xF8, 0x01,
  0xFC, 0x3F, 0x80, 0x1F, 0xC3, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x3F, 0x81,
  0xFC, 0x03, 0xF8, 0x1F, 0xC0, 0x3F, 0x80, 0xFC, 0x07, 0xF0, 0x0F, 0xE0,
  0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x0F, 0xE0,
  0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F,
  0x1F, 0xC0, 0x03, 0xF9, 0xFC, 0x00, 0x1F, 0x9F, 0x80, 0x01, 0xF9, 0xF8,
  0x00, 0x1F, 0xBF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0xFC, 0x03, 0xFB,
  0xF0, 0x07, 0xE0, 0x1F, 0xDF, 0x80, 0x7F, 0x00, 0xFE, 0xFE, 0x03, 0xF8,
  0x07, 0xE7, 0xF0, 0x1F, 0xC0, 0x3F, 0x3F, 0x80, 0xFF, 0x03, 0xF9, 0xFC,
  0x07, 0xF8, 0x1F, 0xC7, 0xE0, 0x7F, 0xC0, 0xFE, 0x3F, 0x03, 0xFE, 0x07,
  0xE1, 0xFC, 0x1F, 0xF0, 0x3F, 0x0F, 0xE0, 0xFF, 0xC1, 0xF8, 0x7F, 0x07,
  0xFE, 0x1F, 0xC1, 0xF8, 0x7F, 0xF0, 0xFE, 0x0F, 0xC3, 0xFF, 0x87, 0xF0,
  0x7E, 0x1F, 0x7C, 0x3F, 0x03, 0xF0, 0xFB, 0xF1, 0xF8, 0x1F, 0xC7, 0xDF,
  0x8F, 0xC0, 0x7E, 0x7E, 0x7C, 0xFE, 0x03, 0xF3, 0xF3, 0xE7, 0xF0, 0x1F,
  0x9F, 0x1F, 0x3F, 0x00, 0xFC, 0xF8, 0xF9, 0xF8, 0x07, 0xE7, 0xC7, 0xEF,
  0xC0, 0x3F, 0xFE, 0x1F, 0x7E, 0x00, 0xFF, 0xF0, 0xFB, 0xF0, 0x07, 0xFF,
  0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x3F, 0xF8, 0x01, 0xFF, 0xC1, 0xFF, 0xC0,
  0x0F, 0xFE, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x01, 0xFF, 0x01,
  0xFF, 0x80, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x03,
  0xFE, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x7F,
  0x80, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x1F, 0xEF, 0xF0, 0x03, 0xF8, 0xFE, 0x00, 0xFF, 0x1F, 0xE0, 0x1F,
  0xC1, 0xFC, 0x07, 0xF8, 0x3F, 0xC0, 0xFE, 0x03, 0xF8, 0x3F, 0xC0, 0x7F,
  0x07, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xE7, 0xF0,
  0x01, 0xFD, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x3F,
  0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFB, 0xF8, 0x00,
  0x7F, 0x7F, 0x00, 0x1F, 0xC7, 0xF0, 0x03, 0xF8, 0xFE, 0x00, 0xFE, 0x1F,
  0xE0, 0x1F, 0xC1, 0xFC, 0x07, 0xF8, 0x3F, 0xC0, 0xFE, 0x03, 0xF8, 0x3F,
  0xC0, 0x7F, 0x87, 0xF0, 0x07, 0xF1, 0xFE, 0x00, 0xFF, 0x3F, 0x80, 0x1F,
  0xEF, 0xF0, 0x01, 0xFE, 0x7F, 0x00, 0x0F, 0xE7, 0xF0, 0x01, 0xFE, 0x3F,
  0x80, 0x1F, 0xC3, 0xF8, 0x01, 0xFC, 0x3F, 0xC0, 0x3F, 0xC1, 0xFC, 0x03,
  0xF8, 0x1F, 0xC0, 0x3F, 0x80, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x00,
  0x7E, 0x07, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF0,
  0xFC, 0x00, 0x3F, 0x9F, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x1F, 0x9F, 0x80,
  0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3,
  0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE,
  0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F,
  0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8,
  0xFE, 0x3F, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F,
  0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC,
  0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F,
  0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3,
  0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF0,
  0x0F, 0xBC, 0x07, 0xCF, 0x81, 0xF3, 0xE0, 0x7C, 0x78, 0x3E, 0x1F, 0x0F,
  0x87, 0xC3, 0xE1, 0xF9, 0xF0, 0x3E, 0x7C, 0x0F, 0x9F, 0x03, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F,
  0x01, 0xFC, 0x07, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0x20, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFF,
  0xFE, 0x3F, 0xFF, 0xF1, 0xFC, 0x3F, 0x8F, 0xC0, 0xFE, 0x7E, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x1F, 0xFF, 0x07, 0xFF,
  0xF8, 0x7F, 0xFF, 0xC7, 0xFF, 0xFE, 0x7F, 0x87, 0xF3, 0xF8, 0x3F, 0xBF,
  0x81, 0xFD, 0xFC, 0x0F, 0xEF, 0xE0, 0x7F, 0x7F, 0x03, 0xFB, 0xF8, 0x3F,
  0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0x8F, 0xFE, 0xFC, 0x1F,
  0xE7, 0xF0, 0x10, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xCF, 0xF0, 0x7E, 0xFF, 0xE3, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF7, 0xF8, 0x7F, 0xBF, 0x81, 0xFD, 0xF8, 0x07, 0xEF, 0xC0, 0x3F,
  0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0,
  0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF,
  0xF0, 0x0F, 0xFF, 0x80, 0x7E, 0xFE, 0x07, 0xF7, 0xF8, 0x7F, 0xBF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7E, 0xFF, 0xE3, 0xF3, 0xFC, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0x81, 0xFF, 0xFC,
  0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x7F, 0x07, 0xF7, 0xE0, 0x7F, 0xFE, 0x03,
  0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x3F, 0xFE, 0x03, 0xF7, 0xE0, 0x3F, 0x7F, 0x07, 0xF3,
  0xFF, 0xFE, 0x3F, 0xFF, 0xE1, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x3F, 0xE0,
  0x00, 0x20, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x7F,
  0x3F, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB,
  0xFC, 0x3F, 0xDF, 0xC0, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01,
  0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF,
  0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F,
  0xFF, 0xC0, 0x7F, 0x7F, 0x03, 0xFB, 0xFC, 0x3F, 0xDF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xF3, 0xFF, 0xDF, 0x8F, 0xFE, 0xFC, 0x1F, 0xC7, 0xE0, 0x10, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x81, 0xFF,
  0xFE, 0x1F, 0xFF, 0xF9, 0xFE, 0x1F, 0xCF, 0xE0, 0x7E, 0x7E, 0x03, 0xFF,
  0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x31, 0xFE, 0x07,
  0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0x83, 0xFF, 0xF8, 0x07,
  0xFF, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x01, 0xFC, 0x0F, 0xF8, 0x3F,
  0xF0, 0x7F, 0xE1, 0xFF, 0xC3, 0xFC, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x1F, 0xFF, 0xBF, 0xFF, 0x7F, 0xFE, 0xFF,
  0xFD, 0xFF, 0xF8, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xCF, 0xC7, 0xFF, 0x7E, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD,
  0xFE, 0x1F, 0xEF, 0xE0, 0x7F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80,
  0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03,
  0xFF, 0xE0, 0x1F, 0xBF, 0x81, 0xFD, 0xFE, 0x1F, 0xEF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0x7E, 0x0F, 0xF3, 0xF0, 0x0C, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x1C, 0x07, 0xF8, 0xF8,
  0x7F, 0x8F, 0xFF, 0xFC, 0x7F, 0xFF, 0xC1, 0xFF, 0xFC, 0x07, 0xFF, 0xC0,
  0x07, 0xF0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x80, 0xFC, 0xFF, 0x0F,
  0xDF, 0xF8, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xF0, 0xFE,
  0xFE, 0x07, 0xEF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07,
  0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0,
  0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC,
  0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF,
  0xC0, 0x7F, 0xFC, 0x07, 0xF0, 0x7D, 0xFB, 0xFF, 0xFF, 0xFF, 0x9E, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x07, 0x81, 0xF8, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0x81,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8,
  0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F,
  0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F,
  0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1,
  0xFC, 0x3F, 0x7F, 0xEF, 0xFD, 0xFF, 0x3F, 0xE7, 0xF8, 0xFC, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x7F, 0x7E, 0x07, 0xFB,
  0xF0, 0x7F, 0x9F, 0x83, 0xF8, 0xFC, 0x3F, 0x87, 0xE3, 0xFC, 0x3F, 0x1F,
  0xC1, 0xF9, 0xFC, 0x0F, 0xDF, 0xC0, 0x7E, 0xFE, 0x03, 0xFF, 0xE0, 0x1F,
  0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xFC,
  0x0F, 0xF7, 0xF0, 0x7F, 0x3F, 0x83, 0xF0, 0xFE, 0x1F, 0x87, 0xF0, 0xFC,
  0x1F, 0xC7, 0xE0, 0xFE, 0x3F, 0x03, 0xF9, 0xF8, 0x1F, 0xEF, 0xC0, 0x7F,
  0x7E, 0x03, 0xFF, 0xF0, 0x0F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x40, 0x7E, 0x7F, 0x83,
  0xFC, 0x3F, 0x7F, 0xE3, 0xFF, 0x9F, 0xFF, 0xFB, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFB, 0xFC, 0x3F, 0xE1, 0xFD, 0xFC, 0x0F,
  0xE0, 0x7F, 0xFC, 0x07, 0xF0, 0x3F, 0xFE, 0x03, 0xF8, 0x1F, 0xFF, 0x01,
  0xFC, 0x0F, 0xFF, 0x80, 0xFE, 0x07, 0xFF, 0xC0, 0x7F, 0x03, 0xFF, 0xE0,
  0x3F, 0x81, 0xFF, 0xF0, 0x1F, 0xC0, 0xFF, 0xF8, 0x0F, 0xE0, 0x7F, 0xFC,
  0x07, 0xF0, 0x3F, 0xFE, 0x03, 0xF8, 0x1F, 0xFF, 0x01, 0xFC, 0x0F, 0xFF,
  0x80, 0xFE, 0x07, 0xFF, 0xC0, 0x7F, 0x03, 0xFF, 0xE0, 0x3F, 0x81, 0xFF,
  0xF0, 0x1F, 0xC0, 0xFF, 0xF8, 0x0F, 0xE0, 0x7F, 0xFC, 0x07, 0xF0, 0x3F,
  0xFE, 0x03, 0xF8, 0x1F, 0xFF, 0x01, 0xFC, 0x0F, 0xFF, 0x80, 0xFE, 0x07,
  0xF0, 0x00, 0x08, 0x0F, 0xC7, 0xF0, 0xFD, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0x0F, 0xEF, 0xE0, 0x7F, 0xFC, 0x07, 0xFF,
  0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F,
  0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07,
  0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0,
  0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x3F, 0xFF,
  0xE0, 0xFF, 0xFF, 0xC7, 0xF8, 0x7F, 0x9F, 0xC0, 0xFE, 0x7E, 0x01, 0xFB,
  0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF0,
  0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0x7E, 0x01, 0xF9, 0xFC, 0x0F, 0xE7,
  0xF8, 0x7F, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0xFF,
  0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x00, 0x07, 0xE7, 0xF8,
  0x3F, 0x7F, 0xF1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFB, 0xFC,
  0x3F, 0xDF, 0xC0, 0xFE, 0xFC, 0x03, 0xF7, 0xE0, 0x1F, 0xFF, 0x00, 0xFF,
  0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80,
  0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF,
  0xC0, 0x3F, 0x7F, 0x03, 0xFB, 0xFC, 0x3F, 0xDF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFE, 0x3F, 0x7F, 0xE1, 0xF9, 0xFE, 0x0F, 0xC1, 0x80, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xCF, 0xC7, 0xFF, 0x7E, 0x7F, 0xFF,
  0xF3, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFE, 0x1F, 0xFF, 0xE0, 0x7F, 0xFE,
  0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F,
  0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0,
  0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xBF, 0x81, 0xFD,
  0xFE, 0x1F, 0xEF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFE, 0x0F, 0xF7, 0xF0, 0x08, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE7,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFE, 0x07,
  0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x1F, 0xFF, 0x03, 0xFF, 0xFC, 0x3F, 0xFF, 0xC7, 0xFF, 0xFE, 0x7E, 0x0F,
  0xE7, 0xE0, 0x7E, 0x7E, 0x07, 0xE7, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xFC,
  0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x00,
  0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xFC, 0x07, 0xFF,
  0xC0, 0x7F, 0xFE, 0x07, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE3, 0xFF, 0xFC,
  0x1F, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x40, 0x00, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF1, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0,
  0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xFC, 0x3F, 0xE1, 0xFF,
  0x07, 0xF8, 0x1F, 0xC0, 0x10, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07,
  0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0,
  0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC,
  0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF,
  0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF3, 0xFF, 0xBF, 0x1F, 0xE3,
  0xF0, 0x10, 0x00, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFE, 0xFC,
  0x07, 0xE7, 0xF0, 0x7F, 0x3F, 0x83, 0xF8, 0xFC, 0x1F, 0x87, 0xE0, 0xFC,
  0x3F, 0x07, 0xE1, 0xFC, 0x7F, 0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0x81, 0xF8,
  0xFC, 0x07, 0xEF, 0xC0, 0x3F, 0x7E, 0x01, 0xFB, 0xF0, 0x07, 0xDF, 0x80,
  0x3E, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0xFC, 0x07, 0xC0, 0x7F, 0xFC, 0x0F, 0x80, 0xFD, 0xF8, 0x1F,
  0x83, 0xFB, 0xF0, 0x7F, 0x07, 0xE7, 0xE0, 0xFE, 0x0F, 0xCF, 0xC1, 0xFC,
  0x1F, 0x9F, 0x83, 0xFC, 0x3F, 0x1F, 0x8F, 0xF8, 0xFC, 0x3F, 0x1F, 0xF1,
  0xF8, 0x7E, 0x3F, 0xE3, 0xF0, 0xFC, 0x7F, 0xE7, 0xE0, 0xF9, 0xF7, 0xCF,
  0xC1, 0xFB, 0xEF, 0x9F, 0x03, 0xF7, 0xDF, 0x7E, 0x07, 0xEF, 0x9F, 0xFC,
  0x0F, 0xFE, 0x3F, 0xF8, 0x0F, 0xFC, 0x7F, 0xE0, 0x1F, 0xF8, 0xFF, 0xC0,
  0x3F, 0xF0, 0xFF, 0x80, 0x7F, 0xC1, 0xFF, 0x00, 0xFF, 0x83, 0xFE, 0x00,
  0xFF, 0x07, 0xF8, 0x01, 0xFC, 0x07, 0xF0, 0x03, 0xF8, 0x0F, 0xE0, 0x07,
  0xF0, 0x1F, 0xC0, 0x07, 0xE0, 0x3F, 0x80, 0x0F, 0x80, 0x3E, 0x00, 0xFF,
  0x03, 0xF9, 0xFC, 0x0F, 0xC7, 0xF0, 0x7F, 0x0F, 0xE1, 0xF8, 0x1F, 0x8F,
  0xE0, 0x7F, 0x3F, 0x00, 0xFD, 0xFC, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x80,
  0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x1F, 0xFC,
  0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x1F, 0xDF, 0xC0, 0x7F, 0x3F, 0x83,
  0xF8, 0xFE, 0x0F, 0xE1, 0xFC, 0x7F, 0x07, 0xF1, 0xFC, 0x0F, 0xEF, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFE, 0xFC, 0x07,
  0xE7, 0xF0, 0x7F, 0x3F, 0x83, 0xF9, 0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x3F,
  0x8F, 0xE1, 0xFC, 0x7E, 0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0x81, 0xF9, 0xFC,
  0x0F, 0xEF, 0xC0, 0x3F, 0x7E, 0x01, 0xFB, 0xF0, 0x0F, 0xFF, 0x00, 0x3F,
  0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80,
  0x03, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x20, 0x0F, 0x01, 0xF0, 0x3F, 0x07, 0xE0, 0xFC, 0x0F, 0xC0, 0xFC, 0x1F,
  0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F,
  0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x3F, 0x83, 0xF0, 0xFF, 0x0F, 0xE0, 0xF8,
  0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0x81, 0xF8, 0x1F,
  0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F,
  0x80, 0xF8, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x00,
  0xF0, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x60, 0x03, 0xC0, 0x1F, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x03,
  0xE0, 0x1F, 0x80, 0xFC, 0x07, 0xF0, 0x1F, 0xE0, 0x7F, 0x01, 0xF8, 0x1F,
  0xC1, 0xFE, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x3F, 0x83, 0xF8, 0x0F, 0x80,
  0x78, 0x03, 0x00, 0x00, 0x07, 0x80, 0x00, 0x1F, 0xE0, 0x1F, 0x3F, 0xF0,
  0x1F, 0x7F, 0xF8, 0x3F, 0x7F, 0xFC, 0x3E, 0xFF, 0xFF, 0xFE, 0xFC, 0x7F,
  0xFE, 0xF8, 0x3F, 0xFC, 0xF8, 0x1F, 0xF8, 0xF8, 0x0F, 0xF0, 0x00, 0x03,
  0xE0,
};

const GFXglyph RobotoCondensed_SemiBold52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 7, 38, 13, 3, -37 },
  { 35, 13, 14, 17, 2, -39 },
  { 58, 24, 37, 28, 2, -37 },
  { 169, 22, 49, 26, 2, -43 },
  { 304, 28, 39, 33, 3, -38 },
  { 441, 27, 39, 30, 2, -38 },
  { 573, 5, 14, 9, 2, -39 },
  { 582, 12, 53, 17, 3, -41 },
  { 662, 13, 53, 17, 1, -41 },
  { 749, 22, 22, 23, 1, -37 },
  { 810, 21, 27, 25, 2, -30 },
  { 881, 8, 15, 12, 1, -6 },
  { 896, 12, 5, 17, 3, -18 },
  { 904, 8, 8, 15, 3, -7 },
  { 912, 17, 40, 18, 0, -37 },
  { 997, 21, 39, 26, 3, -38 },
  { 1100, 14, 37, 26, 4, -37 },
  { 1165, 22, 38, 26, 2, -38 },
  { 1270, 21, 39, 26, 2, -38 },
  { 1373, 22, 37, 26, 2, -37 },
  { 1475, 21, 38, 26, 3, -37 },
  { 1575, 21, 38, 26, 3, -37 },
  { 1675, 22, 37, 26, 2, -37 },
  { 1777, 21, 39, 26, 3, -38 },
  { 1880, 21, 38, 26, 2, -38 },
  { 1980, 8, 29, 14, 3, -28 },
  { 2009, 10, 37, 13, 1, -28 },
  { 2056, 18, 24, 23, 2, -28 },
  { 2110, 19, 17, 26, 3, -25 },
  { 2151, 19, 24, 24, 3, -28 },
  { 2208, 20, 39, 23, 1, -38 },
  { 2306, 36, 48, 40, 2, -36 },
  { 2522, 29, 37, 31, 1, -37 },
  { 2657, 23, 37, 29, 3, -37 },
  { 2764, 25, 39, 30, 3, -38 },
  { 2886, 24, 37, 29, 3, -37 },
  { 2997, 21, 37, 26, 3, -37 },
  { 3095, 20, 37, 25, 3, -37 },
  { 3188, 25, 39, 31, 3, -38 },
  { 3310, 26, 37, 32, 3, -37 },
  { 3431, 6, 37, 14, 4, -37 },
  { 3459, 21, 38, 25, 1, -37 },
  { 3559, 26, 37, 29, 3, -37 },
  { 3680, 20, 37, 25, 3, -37 },
  { 3773, 33, 37, 39, 3, -37 },
  { 3926, 26, 37, 32, 3, -37 },
  { 4047, 26, 39, 31, 3, -38 },
  { 4174, 24, 37, 29, 3, -37 },
  { 4285, 27, 45, 31, 2, -38 },
  { 4437, 25, 37, 29, 3, -37 },
  { 4553, 24, 39, 28, 2, -38 },
  { 4670, 26, 37, 28, 1, -37 },
  { 4791, 24, 38, 30, 3, -37 },
  { 4905, 28, 37, 30, 1, -37 },
  { 5035, 37, 37, 39, 1, -37 },
  { 5207, 27, 37, 29, 1, -37 },
  { 5332, 28, 37, 28, 0, -37 },
  { 5462, 24, 37, 27, 2, -37 },
  { 5573, 10, 51, 14, 3, -43 },
  { 5637, 19, 40, 20, 1, -37 },
  { 5732, 9, 51, 14, 1, -43 },
  { 5790, 18, 18, 20, 1, -37 },
  { 5831, 19, 5, 21, 1, 0 },
  { 5843, 13, 8, 17, 1, -39 },
  { 5856, 21, 29, 25, 2, -28 },
  { 5933, 21, 40, 26, 3, -39 },
  { 6038, 20, 29, 24, 2, -28 },
  { 6111, 21, 40, 26, 2, -39 },
  { 6216, 21, 29, 25, 2, -28 },
  { 6293, 15, 40, 17, 1, -40 },
  { 6368, 21, 39, 26, 2, -28 },
  { 6471, 20, 39, 26, 3, -39 },
  { 6569, 7, 38, 13, 3, -38 },
  { 6603, 11, 49, 13, -1, -38 },
  { 6671, 21, 39, 25, 3, -39 },
  { 6774, 7, 39, 13, 3, -39 },
  { 6809, 33, 28, 39, 3, -28 },
  { 6925, 20, 28, 26, 3, -28 },
  { 6995, 22, 29, 26, 2, -28 },
  { 7075, 21, 39, 26, 3, -28 },
  { 7178, 21, 39, 26, 2, -28 },
  { 7281, 13, 28, 17, 3, -28 },
  { 7327, 20, 29, 24, 2, -28 },
  { 7400, 13, 35, 16, 1, -34 },
  { 7457, 20, 28, 25, 3, -27 },
  { 7527, 21, 27, 23, 1, -27 },
  { 7598, 31, 27, 33, 1, -27 },
  { 7703, 22, 27, 23, 1, -27 },
  { 7778, 21, 38, 23, 1, -27 },
  { 7878, 19, 27, 23, 2, -27 },
  { 7943, 12, 50, 16, 2, -41 },
  { 8018, 5, 44, 13, 4, -37 },
  { 8046, 13, 50, 16, 1, -41 },
  { 8128, 24, 11, 29, 3, -21 },
};

const GFXfont RobotoCondensed_SemiBold52pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_SemiBold52pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_SemiBold52pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _ROBOTOCONDENSED_SEMIBOLD52PT7B_H_
