#ifndef _ROBOTOCONDENSED_SEMIBOLD35PT7B_H_
#define _ROBOTOCONDENSED_SEMIBOLD35PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-SemiBold.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_SemiBold35pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEE, 0x70,
  0x00, 0x07, 0x7F, 0xFF, 0x70, 0xF3, 0xF9, 0xFC, 0xFC, 0x7E, 0x3F, 0x1F,
  0x8F, 0xC6, 0xE3, 0x00, 0x03, 0x8E, 0x01, 0xC6, 0x00, 0xE7, 0x00, 0x73,
  0x80, 0x39, 0xC0, 0x18, 0xE0, 0x1C, 0x70, 0x7F, 0xFF, 0x3F, 0xFF, 0x9F,
  0xFF, 0xC1, 0xCE, 0x00, 0xC7, 0x00, 0x63, 0x80, 0x71, 0xC0, 0x38, 0xC1,
  0xFF, 0xFC, 0xFF, 0xFE, 0x7F, 0xFF, 0x03, 0x1C, 0x03, 0x8E, 0x01, 0xC7,
  0x00, 0xE3, 0x00, 0x73, 0x80, 0x39, 0xC0, 0x1C, 0xE0, 0x00, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x0F, 0xC0, 0x7F, 0x83, 0xFF, 0x1F, 0xFE,
  0x78, 0x79, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0x78, 0x01, 0xF0, 0x07, 0xF0,
  0x0F, 0xF0, 0x1F, 0xE0, 0x1F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7F, 0xC1,
  0xFF, 0x07, 0xFC, 0x1F, 0xF8, 0x7D, 0xFF, 0xE7, 0xFF, 0x8F, 0xFC, 0x0F,
  0xC0, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x3C, 0x00, 0x0F, 0xE0, 0x03, 0xFC,
  0x00, 0x71, 0xC3, 0x0E, 0x38, 0xE1, 0xC7, 0x18, 0x38, 0xE7, 0x07, 0x1C,
  0xC0, 0xE3, 0xB8, 0x1F, 0xEE, 0x01, 0xFD, 0xC0, 0x1F, 0x70, 0x00, 0x0E,
  0x00, 0x03, 0x9E, 0x00, 0x77, 0xF0, 0x1D, 0xFE, 0x03, 0xB9, 0xE0, 0xE7,
  0x1C, 0x18, 0xE3, 0x87, 0x1C, 0x70, 0xC3, 0x8E, 0x38, 0x73, 0xC0, 0x0F,
  0xF0, 0x00, 0xFE, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x03, 0xFC, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x3E, 0x78, 0x0F, 0x0E, 0x03, 0xC3, 0x80, 0xF1, 0xE0,
  0x3E, 0xF8, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x0F,
  0xF1, 0xE7, 0xFE, 0x79, 0xE7, 0xDE, 0x78, 0xF7, 0xBE, 0x3F, 0xEF, 0x87,
  0xF3, 0xE0, 0xFC, 0x7C, 0x3E, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x7F, 0xFE,
  0x0F, 0xC7, 0xC0, 0xFF, 0xFF, 0xEE, 0xEE, 0xE0, 0x01, 0x03, 0x07, 0x0E,
  0x1E, 0x1C, 0x3C, 0x38, 0x38, 0x78, 0x78, 0x70, 0x70, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0x70, 0x70, 0x78, 0x78, 0x38,
  0x38, 0x3C, 0x1C, 0x1E, 0x0E, 0x07, 0x03, 0x01, 0x40, 0xE0, 0xF0, 0x70,
  0x78, 0x3C, 0x3C, 0x1C, 0x1E, 0x1E, 0x0E, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0E, 0x1E, 0x1E,
  0x1C, 0x3C, 0x3C, 0x78, 0x70, 0xF0, 0xE0, 0x40, 0x03, 0xC0, 0x03, 0x80,
  0x06, 0x00, 0x0C, 0x06, 0x18, 0x6F, 0xB3, 0xDF, 0xFF, 0x8F, 0xFE, 0x03,
  0xC0, 0x0F, 0xC0, 0x3F, 0xC0, 0xF3, 0x81, 0xC7, 0x83, 0x87, 0x02, 0x04,
  0x00, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x7B,
  0xDE, 0xF7, 0xBD, 0xFE, 0xE3, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x77, 0xFF,
  0xF7, 0x00, 0x00, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x80, 0xE0,
  0x1C, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0xF0,
  0x1C, 0x03, 0x80, 0x70, 0x1E, 0x03, 0x80, 0x70, 0x1E, 0x03, 0x80, 0x70,
  0x0E, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0xFF, 0x83, 0xFF, 0x1F, 0xFE, 0x78,
  0xFB, 0xE1, 0xEF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC,
  0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF,
  0x07, 0xFE, 0x1E, 0x78, 0xF9, 0xFF, 0xE3, 0xFF, 0x07, 0xF8, 0x0F, 0xC0,
  0x01, 0x83, 0xCF, 0xFF, 0xFF, 0xFF, 0xBF, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x80, 0x07, 0xE0, 0x3F, 0xE0, 0xFF, 0xE3, 0xFF,
  0xE7, 0xC7, 0xCF, 0x07, 0xBE, 0x0F, 0xFC, 0x1F, 0x00, 0x3C, 0x00, 0x78,
  0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xFF, 0xDF, 0xFF,
  0xBF, 0xFF, 0x7F, 0xFE, 0x07, 0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0xFF, 0xE7,
  0xC7, 0xCF, 0x07, 0xBE, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x1F,
  0xE0, 0x3F, 0x80, 0x7F, 0x00, 0xFF, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E,
  0x00, 0x7F, 0xE0, 0xFF, 0xC1, 0xF7, 0xC7, 0xCF, 0xFF, 0x8F, 0xFE, 0x0F,
  0xF8, 0x07, 0xC0, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F,
  0x80, 0x7F, 0x01, 0xFE, 0x03, 0xBC, 0x0F, 0x78, 0x1C, 0xF0, 0x79, 0xE0,
  0xE3, 0xC3, 0xC7, 0x8F, 0x0F, 0x1E, 0x1E, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x3F, 0xF9, 0xFF, 0xE7, 0xFF, 0x9F, 0xFE, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x7B, 0xC1, 0xFF, 0xC7, 0xFF, 0xBF, 0xFE, 0x30,
  0x7C, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xFF, 0x07, 0xFC,
  0x1F, 0xF8, 0x79, 0xFF, 0xE7, 0xFF, 0x0F, 0xF8, 0x0F, 0xC0, 0x01, 0xE0,
  0x1F, 0x80, 0xFE, 0x07, 0xF8, 0x3F, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00,
  0xFB, 0xE3, 0xDF, 0xCF, 0xFF, 0xBF, 0xFE, 0xF8, 0x7F, 0xC1, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x83, 0xFE, 0x1F, 0x78, 0x7D, 0xFF,
  0xE3, 0xFF, 0x07, 0xF8, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x01,
  0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0,
  0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x0F, 0xC0, 0xFF, 0x87, 0xFF, 0x1F, 0xFE,
  0xF8, 0xFB, 0xE1, 0xEF, 0x87, 0xBE, 0x1E, 0xF8, 0x79, 0xE3, 0xE7, 0xFF,
  0x0F, 0xF8, 0x3F, 0xE1, 0xFF, 0xC7, 0x8F, 0xBE, 0x1E, 0xF0, 0x7F, 0xC1,
  0xFF, 0x07, 0xFC, 0x1F, 0xF8, 0x7B, 0xFF, 0xE7, 0xFF, 0x0F, 0xF8, 0x0F,
  0xC0, 0x0F, 0x80, 0xFF, 0x83, 0xFF, 0x1F, 0xFC, 0xF8, 0xFB, 0xC1, 0xEF,
  0x07, 0xBC, 0x1E, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF8, 0x7D,
  0xFF, 0xF7, 0xFF, 0xCF, 0xFE, 0x1F, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3C,
  0x03, 0xF0, 0x7F, 0x81, 0xFC, 0x07, 0xE0, 0x1C, 0x00, 0x77, 0xFF, 0xF7,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xDF, 0xFF, 0xDC, 0x39, 0xF7, 0xDF,
  0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x3C, 0xF3, 0xCF,
  0x79, 0xE7, 0x3C, 0x60, 0x00, 0x10, 0x07, 0x01, 0xF0, 0x7F, 0x1F, 0xF7,
  0xFC, 0xFF, 0x0F, 0xC0, 0xF8, 0x0F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xF0,
  0x1F, 0x00, 0x70, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x80, 0x07, 0x00, 0x3E, 0x01, 0xFC, 0x0F, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0x01, 0xF8, 0x3F, 0xC7, 0xF9, 0xFF, 0x0F, 0xE0, 0x7C, 0x03, 0x80,
  0x10, 0x00, 0x0F, 0x81, 0xFF, 0x1F, 0xFC, 0xFF, 0xFF, 0x8F, 0xFC, 0x3F,
  0xC1, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x07, 0xC0, 0x7C, 0x03,
  0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x07, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0xF0, 0x07, 0xC0, 0x78, 0x0F, 0x00, 0x3C, 0x0E, 0x00,
  0x1C, 0x1C, 0x00, 0x0E, 0x3C, 0x1F, 0x06, 0x38, 0x3F, 0x87, 0x38, 0x7F,
  0xC7, 0x70, 0xF1, 0xC7, 0x70, 0xE1, 0xC3, 0x70, 0xE1, 0xC3, 0x71, 0xE3,
  0xC3, 0x71, 0xC3, 0x83, 0x71, 0xC3, 0x83, 0x71, 0xC3, 0x87, 0x71, 0xC3,
  0x87, 0x71, 0xC3, 0x87, 0x71, 0xC3, 0x86, 0x71, 0xE7, 0x8E, 0x71, 0xFF,
  0xFE, 0x70, 0xFD, 0xFC, 0x70, 0x78, 0xF0, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x80, 0x07, 0xFF,
  0x80, 0x03, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xFC,
  0x00, 0x3D, 0xE0, 0x03, 0xDE, 0x00, 0x7D, 0xE0, 0x07, 0x8F, 0x00, 0x78,
  0xF0, 0x0F, 0x8F, 0x00, 0xF0, 0xF8, 0x0F, 0x07, 0x81, 0xF0, 0x78, 0x1F,
  0xFF, 0xC1, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3E, 0x03, 0xE3,
  0xC0, 0x1E, 0x7C, 0x01, 0xF7, 0xC0, 0x1F, 0x78, 0x01, 0xF0, 0xFF, 0xE0,
  0xFF, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0xF8, 0x3E, 0xF8, 0x1E, 0xF8, 0x1E,
  0xF8, 0x1E, 0xF8, 0x1E, 0xF8, 0x3E, 0xF8, 0xFC, 0xFF, 0xF8, 0xFF, 0xF8,
  0xFF, 0xFC, 0xF8, 0x3E, 0xF8, 0x1E, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x3E, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xE0,
  0x07, 0xF0, 0x0F, 0xFC, 0x0F, 0xFF, 0x8F, 0xFF, 0xC7, 0xC1, 0xF7, 0xC0,
  0x7B, 0xE0, 0x3D, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x0F,
  0xF8, 0x07, 0xFE, 0x03, 0xDF, 0x01, 0xE7, 0xC1, 0xF3, 0xFF, 0xF0, 0xFF,
  0xF8, 0x3F, 0xF0, 0x07, 0xE0, 0x00, 0xFF, 0xC0, 0xFF, 0xF0, 0xFF, 0xF8,
  0xFF, 0xFC, 0xF8, 0x7E, 0xF8, 0x3E, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3E, 0xF8, 0x7E,
  0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0xFF, 0xBF, 0xFE, 0xFF, 0xFB, 0xFF, 0xEF, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3F,
  0xFE, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0xBE, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x00,
  0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0xE7, 0xC1, 0xF7, 0xC0,
  0x7B, 0xE0, 0x3F, 0xF0, 0x1F, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x1F, 0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE0, 0x1F, 0xF0, 0x0F,
  0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xF7, 0xC0, 0xFB, 0xFF, 0xFC, 0xFF,
  0xFC, 0x3F, 0xFC, 0x03, 0xF8, 0x00, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x07, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7F, 0xC1, 0xFF,
  0x87, 0xFE, 0x1F, 0xF8, 0xF9, 0xFF, 0xE7, 0xFF, 0x0F, 0xF8, 0x0F, 0xC0,
  0xF8, 0x1F, 0xFC, 0x0F, 0xBE, 0x0F, 0x9F, 0x0F, 0xCF, 0x87, 0xC7, 0xC7,
  0xC3, 0xE3, 0xE1, 0xF3, 0xE0, 0xFB, 0xE0, 0x7D, 0xF0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0xC1, 0xFB, 0xE0, 0xFC, 0xF8,
  0x7C, 0x7C, 0x3E, 0x1F, 0x1F, 0x0F, 0x8F, 0x83, 0xE7, 0xC1, 0xF3, 0xE0,
  0x7D, 0xF0, 0x3F, 0xF8, 0x0F, 0x80, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80,
  0x3F, 0xFE, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x03, 0xFF, 0xDE, 0x0F, 0xFF, 0x78, 0x7B, 0xFD, 0xE1, 0xEF, 0xF3,
  0xC7, 0xBF, 0xEF, 0x1C, 0xFF, 0xBC, 0xF3, 0xFE, 0x7B, 0xCF, 0xF9, 0xEE,
  0x3F, 0xE7, 0xF8, 0xFF, 0x8F, 0xE3, 0xFE, 0x3F, 0x8F, 0xF8, 0xFC, 0x3F,
  0xE3, 0xF0, 0xFF, 0x87, 0xC3, 0xFE, 0x1E, 0x0F, 0xF8, 0x78, 0x3C, 0xF8,
  0x07, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F,
  0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xFE, 0xF1, 0xFF, 0x78,
  0xFF, 0x9E, 0x7F, 0xCF, 0x3F, 0xE3, 0xDF, 0xF1, 0xEF, 0xF8, 0x7F, 0xFC,
  0x3F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F,
  0xF0, 0x1F, 0xF8, 0x07, 0x80, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x87,
  0xFF, 0xE7, 0xC1, 0xF3, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x0F, 0xF0, 0x07,
  0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xFC, 0x03, 0xFE, 0x03, 0xFF, 0x01, 0xF7,
  0xC1, 0xF3, 0xFF, 0xF8, 0xFF, 0xF8, 0x3F, 0xF8, 0x07, 0xF0, 0x00, 0xFF,
  0xF0, 0xFF, 0xF8, 0xFF, 0xFE, 0xFF, 0xFE, 0xF8, 0x3F, 0xF8, 0x1F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF0, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0xE7, 0xC1, 0xF7,
  0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xF7, 0xC1, 0xF3, 0xFF, 0xF8,
  0xFF, 0xF8, 0x3F, 0xF8, 0x07, 0xFE, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00,
  0xE0, 0x00, 0x20, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0xFF, 0x1F, 0xFF, 0xCF,
  0x83, 0xE7, 0xC0, 0xFB, 0xE0, 0x7D, 0xF0, 0x3E, 0xF8, 0x1F, 0x7C, 0x0F,
  0xBE, 0x07, 0x9F, 0x07, 0xCF, 0xFF, 0xE7, 0xFF, 0xE3, 0xFF, 0xE1, 0xFF,
  0xE0, 0xF8, 0xF8, 0x7C, 0x7C, 0x3E, 0x1F, 0x1F, 0x0F, 0x8F, 0x83, 0xE7,
  0xC1, 0xF3, 0xE0, 0x7D, 0xF0, 0x3E, 0xF8, 0x1F, 0x00, 0x07, 0xE0, 0x1F,
  0xF8, 0x3F, 0xFC, 0x3F, 0xFE, 0x7C, 0x3F, 0x7C, 0x1F, 0x78, 0x1F, 0x78,
  0x0F, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x0F, 0xFC, 0x03,
  0xFE, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0x78,
  0x0F, 0x7C, 0x1F, 0x7F, 0xFF, 0x3F, 0xFE, 0x1F, 0xFC, 0x07, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x3F, 0x7F,
  0xFE, 0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xE0, 0x78, 0x01, 0xF7, 0xC0, 0x3E,
  0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x3C, 0x03, 0xC3, 0xE0, 0x7C, 0x3E, 0x07,
  0xC1, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xF0, 0xF8, 0x0F, 0x0F, 0x80, 0xF0,
  0xF0, 0x0F, 0x0F, 0x00, 0xF9, 0xF0, 0x07, 0x9E, 0x00, 0x79, 0xE0, 0x07,
  0x9E, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0xF8, 0x3C,
  0x0F, 0x7C, 0x1E, 0x07, 0xBE, 0x0F, 0x83, 0xCF, 0x07, 0xC3, 0xE7, 0x87,
  0xE1, 0xF3, 0xC3, 0xF0, 0xF9, 0xE1, 0xF8, 0x78, 0xF8, 0xFE, 0x3C, 0x7C,
  0x7F, 0x1E, 0x1E, 0x7F, 0x8F, 0x0F, 0x3D, 0xCF, 0x87, 0x9E, 0xE7, 0x83,
  0xCF, 0x7B, 0xC1, 0xF7, 0x3D, 0xE0, 0x7F, 0x9E, 0xF0, 0x3F, 0xC7, 0x78,
  0x1F, 0xE3, 0xFC, 0x0F, 0xE1, 0xFC, 0x07, 0xF0, 0xFE, 0x03, 0xF8, 0x7F,
  0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x3E, 0x07, 0xC0, 0x1F, 0x03,
  0xE0, 0x0F, 0x81, 0xF0, 0x00, 0xF8, 0x0F, 0x9F, 0x03, 0xE7, 0xC0, 0xF0,
  0xF8, 0x7C, 0x3E, 0x1E, 0x07, 0xCF, 0x81, 0xF3, 0xC0, 0x3D, 0xF0, 0x0F,
  0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x0F, 0xFC, 0x07, 0xDF, 0x01, 0xF3, 0xE0,
  0xF8, 0xF8, 0x3E, 0x1F, 0x1F, 0x07, 0xC7, 0xC1, 0xFB, 0xF0, 0x3E, 0xF8,
  0x0F, 0xC0, 0x7C, 0x07, 0xCF, 0x80, 0xF9, 0xF0, 0x1E, 0x1F, 0x07, 0xC3,
  0xE0, 0xF8, 0x3C, 0x1E, 0x07, 0xC7, 0xC0, 0x78, 0xF0, 0x0F, 0x3E, 0x01,
  0xF7, 0x80, 0x1E, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0,
  0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00,
  0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF,
  0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF,
  0x3C, 0xF3, 0xCF, 0x3F, 0xFF, 0xFF, 0xC0, 0xF8, 0x03, 0xC0, 0x1F, 0x00,
  0xF8, 0x03, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0xF8, 0x03,
  0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x1E,
  0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0xF8,
  0x03, 0xC0, 0x1E, 0xFF, 0xFF, 0xFF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF,
  0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF,
  0x3C, 0xF3, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xF8,
  0x1F, 0x83, 0xB8, 0x3B, 0xC3, 0x9C, 0x79, 0xC7, 0x1E, 0xF0, 0xEF, 0x0E,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x7C, 0x3E, 0x1E, 0x0F,
  0x07, 0xC0, 0x7F, 0xC3, 0xFF, 0x9F, 0xFE, 0x78, 0x7D, 0xE1, 0xF0, 0x07,
  0xC3, 0xFF, 0x3F, 0xFD, 0xFF, 0xF7, 0xC7, 0xDE, 0x1F, 0xF8, 0x7F, 0xE1,
  0xF7, 0xFF, 0xDF, 0xFF, 0x3F, 0xFC, 0x7C, 0xF0, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF3, 0xE3,
  0xDF, 0xCF, 0xFF, 0xBF, 0xFE, 0xF8, 0x7F, 0xC1, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x7F, 0xE1, 0xFF, 0xFF,
  0xBF, 0xFE, 0xF7, 0xF3, 0xCF, 0x80, 0x07, 0xC0, 0x7F, 0xC3, 0xFF, 0x9F,
  0xFE, 0x78, 0x7D, 0xE0, 0xFF, 0x83, 0xFE, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x0F, 0x78, 0x3D, 0xE1, 0xF7, 0xFF, 0x8F, 0xFE, 0x1F, 0xF0,
  0x1F, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x0F, 0x3C, 0xFF, 0xF3, 0xFF, 0xDF, 0xFF, 0x7C,
  0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE,
  0x0F, 0xF8, 0x3D, 0xF0, 0xF7, 0xFF, 0xCF, 0xFF, 0x3F, 0xFC, 0x3C, 0xF0,
  0x07, 0xE0, 0x3F, 0xE0, 0xFF, 0xE3, 0xFF, 0xE7, 0xC3, 0xCF, 0x07, 0x9E,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xC0, 0x07, 0x80,
  0x0F, 0x83, 0x1F, 0xFF, 0x1F, 0xFE, 0x1F, 0xF8, 0x0F, 0xC0, 0x07, 0xC3,
  0xF1, 0xFC, 0xFF, 0x3E, 0x0F, 0x83, 0xC0, 0xF0, 0xFF, 0xBF, 0xEF, 0xF8,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x00, 0x0F, 0x9E, 0x7F, 0xBC, 0xFF,
  0xFB, 0xFF, 0xF7, 0xC3, 0xEF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F,
  0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xF7, 0x83, 0xEF, 0x87, 0xDF, 0xFF, 0x9F,
  0xFF, 0x1F, 0xFE, 0x1F, 0x7C, 0x00, 0xF8, 0x01, 0xF1, 0x03, 0xC7, 0xFF,
  0x8F, 0xFE, 0x1F, 0xF8, 0x0F, 0xC0, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF3, 0xC7, 0xBF, 0xBF, 0xFF,
  0xFF, 0xFF, 0x8F, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC,
  0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83,
  0xC0, 0x77, 0xBF, 0xF7, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0C, 0x1E, 0x1F, 0x1E, 0x0E, 0x00, 0x00,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1E, 0xFE, 0xFE, 0xFC,
  0xF8, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0xFF, 0xC3, 0xEF, 0x1F, 0x3C, 0xF8, 0xF3, 0xE3,
  0xDF, 0x0F, 0xF8, 0x3F, 0xC0, 0xFF, 0x83, 0xFF, 0x0F, 0xFC, 0x3E, 0xF8,
  0xF1, 0xE3, 0xC7, 0xCF, 0x0F, 0x3C, 0x3E, 0xF0, 0x7F, 0xC1, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xF3, 0xE1, 0xE3, 0xDF, 0xDF, 0xEF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xF8, 0xFC, 0x7F, 0xC1, 0xE0, 0xFF, 0x07, 0x83, 0xFC,
  0x1E, 0x0F, 0xF0, 0x78, 0x3F, 0xC1, 0xE0, 0xFF, 0x07, 0x83, 0xFC, 0x1E,
  0x0F, 0xF0, 0x78, 0x3F, 0xC1, 0xE0, 0xFF, 0x07, 0x83, 0xFC, 0x1E, 0x0F,
  0xF0, 0x78, 0x3F, 0xC1, 0xE0, 0xF0, 0xF3, 0xE7, 0xBF, 0xBF, 0xFF, 0xFF,
  0xFF, 0x8F, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F,
  0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xC0,
  0x07, 0xE0, 0x3F, 0xE0, 0xFF, 0xE3, 0xFF, 0xE7, 0xC3, 0xCF, 0x07, 0xFE,
  0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xF7, 0x83,
  0xEF, 0x87, 0x9F, 0xFF, 0x1F, 0xFC, 0x1F, 0xF0, 0x0F, 0xC0, 0xF3, 0xE3,
  0xFF, 0xCF, 0xFF, 0xBF, 0xFE, 0xF8, 0x7F, 0xC1, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x7F, 0xE1, 0xFF, 0xFF,
  0xBF, 0xFE, 0xF7, 0xF3, 0xCF, 0x8F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x0F, 0xBC, 0xFF, 0xF7, 0xFF, 0xDF,
  0xFF, 0x7C, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF,
  0x83, 0xFE, 0x0F, 0xF8, 0x3D, 0xE0, 0xF7, 0xFF, 0xCF, 0xFF, 0x3F, 0xFC,
  0x3C, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0xF3, 0xFB, 0xFF, 0xFF, 0xFF, 0xEF, 0xC3, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x00, 0x0F,
  0xC0, 0xFF, 0xC7, 0xFF, 0x9F, 0x7E, 0x78, 0x79, 0xE1, 0xE7, 0xC0, 0x1F,
  0xC0, 0x3F, 0xE0, 0x3F, 0xC0, 0x3F, 0x80, 0x3E, 0xF0, 0x7F, 0xE1, 0xF7,
  0xFF, 0x9F, 0xFE, 0x3F, 0xF0, 0x3F, 0x00, 0x1E, 0x07, 0x81, 0xE0, 0x78,
  0x1E, 0x3F, 0xFF, 0xFF, 0xFF, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07,
  0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x7F, 0x1F, 0xC3, 0xF0, 0x7C,
  0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE,
  0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xFC, 0x7F, 0xFF,
  0xEF, 0xFF, 0x7F, 0xF8, 0xF3, 0xC0, 0xF0, 0x7F, 0xC1, 0xFF, 0x87, 0x9E,
  0x1E, 0x78, 0xF9, 0xE3, 0xC7, 0xCF, 0x0F, 0x3C, 0x3C, 0xF0, 0xF7, 0x81,
  0xDE, 0x07, 0xF8, 0x1F, 0xC0, 0x7F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80,
  0x1E, 0x00, 0xF0, 0xF0, 0xFF, 0x87, 0x87, 0xBC, 0x3C, 0x3D, 0xF1, 0xF1,
  0xE7, 0x9F, 0x8F, 0x3C, 0xFC, 0xF1, 0xE7, 0xE7, 0x8F, 0x3F, 0xBC, 0x3B,
  0xDD, 0xE1, 0xFC, 0xEF, 0x0F, 0xE7, 0xF0, 0x7F, 0x3F, 0x83, 0xF8, 0xFC,
  0x0F, 0x87, 0xE0, 0x7C, 0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x07, 0x80, 0x70,
  0x3C, 0x00, 0xF8, 0x7D, 0xE1, 0xE7, 0xCF, 0x8F, 0x3C, 0x3F, 0xF0, 0x7F,
  0x81, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x3F, 0x00, 0xFC, 0x07, 0xF8, 0x1F,
  0xE0, 0xFF, 0xC7, 0xCF, 0x1F, 0x3E, 0xF8, 0x7B, 0xE1, 0xF0, 0x78, 0x3E,
  0xF0, 0x7D, 0xF0, 0xF3, 0xE3, 0xE3, 0xC7, 0xC7, 0x8F, 0x0F, 0x9E, 0x0F,
  0x7C, 0x1E, 0xF0, 0x3D, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFE, 0x01, 0xFC,
  0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00,
  0x78, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0x7F, 0xFB, 0xFF,
  0xDF, 0xFE, 0xFF, 0xF0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0x80,
  0x7C, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x3E, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x01, 0x03, 0x83, 0xE3, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x87, 0xC3, 0xC1, 0xE1, 0xF1, 0xF0, 0xF0, 0x7C, 0x1F,
  0x07, 0x83, 0xC0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x3E, 0x0E, 0x03, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x40, 0xF0, 0xF0, 0x78, 0x38, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x1F, 0x0F, 0x0F, 0x1F, 0x1E,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x38, 0x78, 0xF0,
  0xE0, 0x40, 0x1E, 0x00, 0x3F, 0x07, 0x7F, 0x8F, 0xFF, 0x8F, 0xF3, 0xFE,
  0xE1, 0xFE, 0xE0, 0xFC, 0x00, 0x78,
};

const GFXglyph RobotoCondensed_SemiBold35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 5, 25, 9, 2, -25 },
  { 17, 9, 9, 11, 1, -26 },
  { 28, 17, 25, 19, 1, -25 },
  { 82, 14, 32, 18, 2, -29 },
  { 138, 19, 25, 22, 2, -25 },
  { 198, 18, 25, 20, 1, -25 },
  { 255, 4, 9, 6, 1, -26 },
  { 260, 8, 36, 11, 2, -28 },
  { 296, 8, 36, 11, 1, -28 },
  { 332, 15, 15, 16, 0, -25 },
  { 361, 15, 18, 17, 1, -21 },
  { 395, 5, 10, 8, 1, -4 },
  { 402, 8, 4, 12, 2, -13 },
  { 406, 5, 5, 10, 2, -5 },
  { 410, 11, 27, 12, 0, -25 },
  { 448, 14, 25, 18, 2, -25 },
  { 492, 9, 25, 18, 3, -25 },
  { 521, 15, 25, 18, 1, -25 },
  { 568, 15, 25, 18, 1, -25 },
  { 615, 15, 25, 18, 1, -25 },
  { 662, 14, 25, 18, 2, -25 },
  { 706, 14, 25, 18, 2, -25 },
  { 750, 15, 25, 18, 1, -25 },
  { 797, 14, 25, 18, 2, -25 },
  { 841, 14, 25, 18, 2, -25 },
  { 885, 5, 19, 9, 2, -19 },
  { 897, 6, 25, 8, 1, -19 },
  { 916, 12, 16, 16, 1, -19 },
  { 940, 13, 12, 17, 2, -17 },
  { 960, 13, 16, 16, 2, -19 },
  { 986, 13, 25, 15, 1, -25 },
  { 1027, 24, 32, 27, 1, -24 },
  { 1123, 20, 25, 21, 0, -25 },
  { 1186, 16, 25, 20, 2, -25 },
  { 1236, 17, 25, 20, 2, -25 },
  { 1290, 16, 25, 20, 2, -25 },
  { 1340, 14, 25, 17, 2, -25 },
  { 1384, 14, 25, 17, 2, -25 },
  { 1428, 17, 25, 21, 2, -25 },
  { 1482, 17, 25, 22, 2, -25 },
  { 1536, 5, 25, 9, 2, -25 },
  { 1552, 14, 25, 17, 1, -25 },
  { 1596, 17, 25, 19, 2, -25 },
  { 1650, 14, 25, 17, 2, -25 },
  { 1694, 22, 25, 27, 2, -25 },
  { 1763, 17, 25, 22, 2, -25 },
  { 1817, 17, 25, 21, 2, -25 },
  { 1871, 16, 25, 20, 2, -25 },
  { 1921, 17, 29, 21, 2, -25 },
  { 1983, 17, 25, 19, 2, -25 },
  { 2037, 16, 25, 19, 1, -25 },
  { 2087, 17, 25, 19, 1, -25 },
  { 2141, 16, 25, 20, 2, -25 },
  { 2191, 20, 25, 20, 0, -25 },
  { 2254, 25, 25, 26, 1, -25 },
  { 2333, 18, 25, 20, 1, -25 },
  { 2390, 19, 25, 19, 0, -25 },
  { 2450, 16, 25, 18, 1, -25 },
  { 2500, 6, 35, 9, 2, -29 },
  { 2527, 13, 27, 13, 0, -25 },
  { 2571, 6, 35, 9, 1, -29 },
  { 2598, 12, 12, 14, 1, -25 },
  { 2616, 14, 4, 14, 0, 0 },
  { 2623, 8, 5, 11, 1, -26 },
  { 2628, 14, 18, 17, 1, -18 },
  { 2660, 14, 26, 17, 2, -26 },
  { 2706, 14, 18, 16, 1, -18 },
  { 2738, 14, 26, 17, 1, -26 },
  { 2784, 15, 18, 17, 1, -18 },
  { 2818, 10, 26, 11, 1, -26 },
  { 2851, 15, 25, 18, 1, -18 },
  { 2898, 13, 26, 17, 2, -26 },
  { 2941, 5, 25, 9, 2, -25 },
  { 2957, 8, 32, 8, -1, -25 },
  { 2989, 14, 26, 17, 2, -26 },
  { 3035, 5, 26, 9, 2, -26 },
  { 3052, 22, 18, 26, 2, -18 },
  { 3102, 13, 18, 17, 2, -18 },
  { 3132, 15, 18, 17, 1, -18 },
  { 3166, 14, 25, 17, 2, -18 },
  { 3210, 14, 25, 17, 1, -18 },
  { 3254, 9, 18, 11, 2, -18 },
  { 3275, 14, 18, 16, 1, -18 },
  { 3307, 10, 23, 11, 0, -23 },
  { 3336, 13, 18, 17, 2, -18 },
  { 3366, 14, 18, 16, 1, -18 },
  { 3398, 21, 18, 22, 1, -18 },
  { 3446, 14, 18, 16, 1, -18 },
  { 3478, 15, 25, 15, 0, -18 },
  { 3525, 13, 18, 16, 1, -18 },
  { 3555, 9, 33, 11, 1, -27 },
  { 3593, 3, 30, 9, 3, -25 },
  { 3605, 8, 33, 11, 1, -27 },
  { 3638, 16, 8, 20, 2, -15 },
};

const GFXfont RobotoCondensed_SemiBold35pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_SemiBold35pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_SemiBold35pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _ROBOTOCONDENSED_SEMIBOLD35PT7B_H_
