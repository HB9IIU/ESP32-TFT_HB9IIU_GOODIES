#ifndef _ROBOTOCONDENSED_SEMIBOLD29PT7B_H_
#define _ROBOTOCONDENSED_SEMIBOLD29PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-SemiBold.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_SemiBold29pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xEE, 0xEE, 0xE0, 0x0E, 0xFF, 0xE0,
  0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF1, 0xE3, 0x06, 0x30, 0x19, 0xC0, 0x67,
  0x01, 0x98, 0x0E, 0x60, 0x39, 0x87, 0xFF, 0xDF, 0xFF, 0x0C, 0xE0, 0x33,
  0x80, 0xCC, 0x07, 0x30, 0x1C, 0xC3, 0xFF, 0xEF, 0xFF, 0x86, 0x70, 0x19,
  0xC0, 0x66, 0x03, 0x98, 0x0E, 0x60, 0x31, 0x80, 0x03, 0x00, 0x30, 0x03,
  0x00, 0xF8, 0x1F, 0xC3, 0xFE, 0x78, 0xF7, 0x8F, 0x78, 0xF7, 0x87, 0x78,
  0x03, 0xC0, 0x3F, 0x01, 0xFC, 0x07, 0xE0, 0x1F, 0x00, 0xFF, 0x0F, 0xF0,
  0x77, 0x0F, 0x78, 0xF7, 0xFE, 0x3F, 0xE0, 0xF8, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x3C, 0x00, 0x7E, 0x00, 0x77, 0x10, 0xE7, 0x18, 0xE3, 0x38, 0xE3,
  0x30, 0xE7, 0x70, 0x67, 0x60, 0x7E, 0xE0, 0x3C, 0xC0, 0x01, 0xC0, 0x01,
  0x9C, 0x03, 0x7E, 0x03, 0x77, 0x06, 0x63, 0x06, 0x63, 0x0C, 0x63, 0x1C,
  0x63, 0x08, 0x77, 0x00, 0x7E, 0x00, 0x3C, 0x0F, 0x00, 0x3F, 0x80, 0xFF,
  0x01, 0xCF, 0x03, 0x8E, 0x07, 0x1C, 0x0E, 0x78, 0x1F, 0xE0, 0x3F, 0x80,
  0x3E, 0x00, 0x7C, 0x01, 0xF8, 0xE7, 0xF9, 0xDE, 0x7B, 0xBC, 0xFF, 0x78,
  0xFC, 0xF0, 0xF8, 0xF1, 0xF1, 0xFF, 0xE1, 0xFF, 0xE1, 0xF9, 0xE0, 0xFF,
  0xFF, 0xFE, 0x04, 0x18, 0x70, 0xC3, 0x86, 0x1C, 0x38, 0x61, 0xC3, 0x87,
  0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x0C, 0x1C, 0x38, 0x30,
  0x70, 0x60, 0xE0, 0xC0, 0x80, 0x81, 0x83, 0x83, 0x87, 0x07, 0x0E, 0x0E,
  0x1C, 0x38, 0x70, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xE1, 0xC3,
  0x87, 0x1C, 0x38, 0xE1, 0xC7, 0x0C, 0x10, 0x00, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x8E, 0x27, 0xB7, 0x7F, 0xFC, 0x3F, 0x01, 0xF0, 0x1D, 0xC0, 0xEE,
  0x0E, 0x38, 0x20, 0x80, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0x39, 0xCE, 0x73, 0xB9, 0xC4, 0xFF, 0xFF, 0xF8, 0xFF,
  0xF6, 0x03, 0x81, 0xC0, 0xE0, 0x60, 0x70, 0x38, 0x18, 0x1C, 0x0E, 0x07,
  0x03, 0x03, 0x81, 0xC0, 0xE0, 0xE0, 0x70, 0x38, 0x18, 0x1C, 0x0E, 0x07,
  0x03, 0x03, 0x80, 0x0F, 0x81, 0xFC, 0x3F, 0xE7, 0x9E, 0x78, 0xF7, 0x0F,
  0x70, 0xFF, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x0F,
  0x70, 0xF7, 0x0F, 0x78, 0xF7, 0x9E, 0x3F, 0xE1, 0xFC, 0x0F, 0x80, 0x03,
  0x0F, 0x3F, 0xFF, 0xFF, 0xCF, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x83, 0xFC, 0x7F,
  0xE7, 0x9F, 0xF0, 0xFF, 0x0F, 0xF0, 0xF0, 0x0F, 0x00, 0xE0, 0x1E, 0x03,
  0xC0, 0x3C, 0x07, 0x80, 0xF0, 0x1F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x83, 0xFC, 0x7F, 0xE7, 0x9E, 0xF0, 0xFF,
  0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xE0, 0xFC, 0x0F, 0x80, 0xFE, 0x01, 0xE0,
  0x0F, 0x00, 0xFF, 0x0F, 0xF0, 0xFF, 0x9F, 0x7F, 0xE3, 0xFC, 0x1F, 0x80,
  0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xF0, 0x3F, 0x83,
  0xBC, 0x1D, 0xE1, 0xCF, 0x0E, 0x78, 0xE3, 0xCF, 0x1E, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0x7F,
  0xEF, 0xFD, 0xFF, 0xB8, 0x07, 0x01, 0xE0, 0x3C, 0x07, 0xF8, 0xFF, 0xDF,
  0xF9, 0x87, 0x80, 0xF0, 0x0E, 0x01, 0xC0, 0x3F, 0x07, 0xE1, 0xFE, 0x3D,
  0xFF, 0x3F, 0xC1, 0xF0, 0x07, 0x83, 0xF0, 0xFE, 0x1E, 0x07, 0x81, 0xE0,
  0x3C, 0x07, 0x3C, 0xFF, 0xDF, 0xFB, 0xC7, 0xF0, 0xFE, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xF1, 0xFE, 0x3D, 0xFF, 0x1F, 0xC1, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x3C,
  0x03, 0x80, 0x78, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xF0, 0x0E, 0x01, 0xE0,
  0x1E, 0x03, 0xC0, 0x3C, 0x00, 0x0F, 0x83, 0xFC, 0x3F, 0xE7, 0x9E, 0x78,
  0xF7, 0x0F, 0x70, 0xF7, 0x8F, 0x79, 0xE3, 0xFC, 0x1F, 0x83, 0xFE, 0x78,
  0xE7, 0x0F, 0xF0, 0xFF, 0x0F, 0x70, 0xF7, 0x8F, 0x7F, 0xE3, 0xFC, 0x0F,
  0x80, 0x0F, 0x03, 0xFC, 0x3F, 0xE7, 0x9E, 0x70, 0xEF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xF7, 0x0F, 0x79, 0xF7, 0xFF, 0x3F, 0xF1, 0xEF, 0x00, 0xE0,
  0x0E, 0x01, 0xE0, 0x7C, 0x1F, 0x81, 0xF0, 0x1C, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xF6, 0x73, 0xDE, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3D, 0xEF, 0x73, 0x9D, 0xC4, 0x00, 0x00, 0x40, 0x70, 0x7C, 0x3F,
  0x3F, 0xBF, 0x8F, 0x83, 0xC0, 0xFE, 0x0F, 0xE1, 0xFC, 0x1F, 0x01, 0xC0,
  0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x80, 0x38, 0x0F, 0x83, 0xF8, 0x7F, 0x07, 0xF0, 0x3C, 0x1F,
  0x1F, 0xDF, 0xCF, 0xE3, 0xE0, 0xE0, 0x20, 0x00, 0x1F, 0x0F, 0xF1, 0xFF,
  0x79, 0xEF, 0x1F, 0xC3, 0xC0, 0x78, 0x0E, 0x03, 0xC0, 0xF0, 0x3E, 0x07,
  0x80, 0xE0, 0x3C, 0x07, 0x80, 0x00, 0x00, 0x01, 0x80, 0x78, 0x0F, 0x00,
  0xC0, 0x00, 0xFC, 0x00, 0x3F, 0xF0, 0x0F, 0x8F, 0x81, 0xE0, 0x1C, 0x1C,
  0x00, 0xC3, 0x80, 0x0E, 0x30, 0x78, 0x67, 0x0F, 0xE7, 0x71, 0xEE, 0x76,
  0x38, 0xE3, 0x63, 0x8C, 0x3E, 0x38, 0xC3, 0xE3, 0x0C, 0x3E, 0x70, 0xC3,
  0xE7, 0x0C, 0x3E, 0x71, 0xC7, 0xE3, 0x1C, 0x66, 0x3F, 0xCE, 0x63, 0xFF,
  0xC7, 0x1C, 0x78, 0x70, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF9,
  0xC0, 0x0F, 0xFC, 0x00, 0x3F, 0x80, 0x01, 0xC0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1D, 0xC0, 0x0E, 0xF0, 0x0F,
  0x38, 0x07, 0x1C, 0x03, 0x8F, 0x03, 0xC7, 0x81, 0xE1, 0xC0, 0xFF, 0xE0,
  0xFF, 0xF8, 0x7F, 0xFC, 0x3C, 0x0E, 0x3C, 0x07, 0x9E, 0x03, 0xCF, 0x01,
  0xE7, 0x80, 0x78, 0xFF, 0x87, 0xFF, 0x3F, 0xFD, 0xE1, 0xEF, 0x0F, 0x78,
  0x3B, 0xC1, 0xDE, 0x1E, 0xF0, 0xF7, 0xFF, 0x3F, 0xF1, 0xFF, 0xEF, 0x0F,
  0x78, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x87, 0xBF, 0xFD, 0xFF, 0xCF,
  0xFC, 0x00, 0x07, 0xE0, 0x3F, 0xE0, 0xFF, 0xE1, 0xE3, 0xE7, 0x83, 0xCF,
  0x03, 0x9C, 0x07, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x1C, 0x07, 0x3C, 0x0E, 0x78, 0x3C, 0xF8, 0xF8,
  0xFF, 0xE0, 0xFF, 0x80, 0x7C, 0x00, 0xFF, 0x07, 0xFE, 0x3F, 0xF9, 0xE3,
  0xEF, 0x0F, 0x78, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F,
  0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0xF7, 0x8F, 0xBF,
  0xF9, 0xFF, 0x8F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1F, 0xFB, 0xFF, 0x7F, 0xEF, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1F, 0xFB,
  0xFF, 0x7F, 0xEF, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x00, 0x07, 0xE0, 0x3F, 0xE0, 0xFF, 0xE3, 0xE3, 0xE7, 0x83,
  0xCF, 0x03, 0x9C, 0x07, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC3, 0xFF,
  0x87, 0xFF, 0x0F, 0xFE, 0x03, 0xDC, 0x07, 0xBC, 0x0F, 0x78, 0x1E, 0x78,
  0x7C, 0xFF, 0xF0, 0xFF, 0xC0, 0x7E, 0x00, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x3F, 0x87, 0xF1, 0xFE, 0x3D, 0xFF, 0x3F, 0xE1, 0xF0,
  0xF0, 0x7F, 0xC3, 0xEF, 0x0F, 0x3C, 0x7C, 0xF1, 0xE3, 0xCF, 0x0F, 0x7C,
  0x3D, 0xE0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0xC3, 0xEF,
  0x0F, 0x3E, 0x3C, 0x78, 0xF1, 0xF3, 0xC3, 0xCF, 0x0F, 0xBC, 0x1E, 0xF0,
  0x7C, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x77,
  0xEE, 0x1D, 0xFB, 0x87, 0x7E, 0xF3, 0x9F, 0x9C, 0xE7, 0xE7, 0x3B, 0xF9,
  0xFE, 0xFE, 0x3F, 0x3F, 0x8F, 0xCF, 0xE3, 0xF3, 0xF8, 0xF8, 0xFE, 0x1E,
  0x3F, 0x87, 0x8F, 0xE1, 0xE3, 0xC0, 0xF0, 0x3F, 0xC0, 0xFF, 0x83, 0xFE,
  0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xE3, 0xFB, 0x8F, 0xEF, 0x3F, 0x9C, 0xFE,
  0x7B, 0xF8, 0xEF, 0xE3, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x3F, 0xE0, 0xFF,
  0x81, 0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0x3C, 0x07, 0xE0, 0x3F, 0xE0, 0xFF,
  0xE1, 0xE3, 0xE7, 0x83, 0xCF, 0x03, 0xDC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xDC, 0x07, 0xBC,
  0x0F, 0x78, 0x3C, 0x78, 0xF8, 0xFF, 0xE0, 0xFF, 0x80, 0x7E, 0x00, 0xFF,
  0xC7, 0xFF, 0x3F, 0xFD, 0xE1, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F,
  0xF0, 0x7F, 0x87, 0xFF, 0xFD, 0xFF, 0xCF, 0xFC, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x07, 0xE0,
  0x3F, 0xE0, 0xFF, 0xE1, 0xE3, 0xE7, 0x83, 0xCF, 0x03, 0xDC, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03,
  0xDC, 0x07, 0xBC, 0x0F, 0x78, 0x3C, 0x78, 0xF8, 0xFF, 0xE0, 0xFF, 0x80,
  0x7F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0E, 0x00, 0x08, 0xFF, 0x87, 0xFF,
  0x3F, 0xFD, 0xE3, 0xEF, 0x0F, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0xF7,
  0x8F, 0xBF, 0xF9, 0xFF, 0x8F, 0xFC, 0x79, 0xE3, 0xC7, 0x9E, 0x3C, 0xF1,
  0xF7, 0x87, 0xBC, 0x3D, 0xE0, 0xFF, 0x07, 0x80, 0x0F, 0xC1, 0xFF, 0x1F,
  0xFC, 0xF1, 0xF7, 0x07, 0xF8, 0x3F, 0xC0, 0x0F, 0x00, 0x7E, 0x01, 0xFC,
  0x07, 0xF8, 0x0F, 0xE0, 0x0F, 0x80, 0x3F, 0xC0, 0xFE, 0x07, 0xF0, 0x7B,
  0xC3, 0xDF, 0xFE, 0x7F, 0xE0, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC1, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xF0, 0x7F,
  0xC7, 0x9F, 0xFC, 0x7F, 0xC1, 0xF8, 0x00, 0x78, 0x0F, 0x78, 0x0F, 0x78,
  0x0F, 0x78, 0x1E, 0x3C, 0x1E, 0x3C, 0x1E, 0x3C, 0x1C, 0x1C, 0x3C, 0x1E,
  0x3C, 0x1E, 0x3C, 0x1E, 0x38, 0x0E, 0x78, 0x0F, 0x78, 0x0F, 0x70, 0x07,
  0x70, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xC0, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0x70,
  0xF0, 0xE7, 0x1F, 0x8E, 0x71, 0xF9, 0xE7, 0x9F, 0x9E, 0x79, 0xF9, 0xE7,
  0x9F, 0x9C, 0x3B, 0x9D, 0xC3, 0xB9, 0xDC, 0x3B, 0x9F, 0xC3, 0xF9, 0xFC,
  0x3F, 0x9F, 0xC1, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F,
  0x81, 0xF0, 0xF8, 0x1E, 0x07, 0x80, 0xF0, 0x3D, 0xF0, 0x79, 0xE1, 0xE3,
  0xE3, 0xC3, 0xCF, 0x07, 0x9E, 0x07, 0xB8, 0x0F, 0xF0, 0x0F, 0xC0, 0x1F,
  0x80, 0x1E, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x1E, 0x78,
  0x3C, 0xF0, 0xF0, 0xF1, 0xE1, 0xE7, 0xC1, 0xEF, 0x03, 0xC0, 0xF8, 0x1E,
  0xF0, 0x3D, 0xE0, 0xF1, 0xE1, 0xE3, 0xC3, 0x83, 0x8F, 0x07, 0x9E, 0x0F,
  0x38, 0x0E, 0xF0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xF0, 0x0F, 0x00, 0x70,
  0x07, 0x80, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xE0, 0x0F,
  0x00, 0xF0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7,
  0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x3F, 0xFF, 0x80, 0xF0, 0x0E, 0x01, 0xE0,
  0x3C, 0x03, 0x80, 0x78, 0x0F, 0x00, 0xE0, 0x1E, 0x03, 0xC0, 0x38, 0x07,
  0x80, 0xF0, 0x0E, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0x70, 0x0F, 0x01, 0xE0,
  0x1C, 0x03, 0xC0, 0x78, 0xFF, 0xFF, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3,
  0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xFF,
  0xFF, 0xFC, 0x1C, 0x0E, 0x0F, 0x87, 0xC3, 0x73, 0xB9, 0xDC, 0xC7, 0xE3,
  0xF1, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0xF0, 0xF0, 0xE0, 0x1F,
  0x83, 0xFC, 0x7F, 0xE7, 0x1E, 0xF1, 0xE0, 0x1E, 0x1F, 0xE3, 0xFE, 0x79,
  0xEF, 0x1E, 0xF1, 0xEF, 0x1E, 0xF1, 0xE7, 0xFE, 0x7F, 0xE1, 0xCF, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x3B, 0xE7, 0xFE, 0xFF, 0xDE,
  0x3F, 0x87, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x3F,
  0xC7, 0xFF, 0xEF, 0xFD, 0xDF, 0x00, 0x1F, 0x83, 0xFC, 0x7F, 0xE7, 0x9E,
  0xF0, 0xEF, 0x0E, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x0E,
  0x79, 0xE7, 0xFE, 0x3F, 0xC1, 0xF8, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x1E, 0xF3, 0xFF, 0x7F, 0xF7, 0x9F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0x79, 0xF7, 0xFF,
  0x3F, 0xF1, 0xEF, 0x0F, 0x83, 0xFC, 0x7F, 0xE7, 0x8E, 0x70, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x67, 0xFF,
  0x3F, 0xE0, 0xF8, 0x0F, 0x1F, 0x3F, 0x3C, 0x38, 0x38, 0xFF, 0xFF, 0xFF,
  0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38,
  0x38, 0x1E, 0x73, 0xF7, 0x7F, 0xF7, 0x8F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0x78, 0xF7, 0xFF, 0x3F, 0xF1,
  0xEF, 0x00, 0xF0, 0x0F, 0x31, 0xF7, 0xFE, 0x7F, 0xC1, 0xF8, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF3, 0xCF, 0xFE, 0xFF, 0xEF,
  0x9E, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xEE, 0xFE, 0x00, 0xEE, 0xEE,
  0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0x1C, 0x71, 0xC7, 0x00, 0x01, 0xC7,
  0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7,
  0x3F, 0xFF, 0xBC, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE1, 0xEE, 0x3C, 0xE7, 0x8E, 0x78, 0xEF, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0,
  0xFF, 0x0F, 0xF0, 0xF7, 0x8E, 0x78, 0xE3, 0xCE, 0x3C, 0xE1, 0xEE, 0x1E,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE7, 0x8F, 0x3F,
  0xFF, 0xEF, 0xFF, 0xFB, 0xCF, 0x8F, 0xE1, 0xE3, 0xF8, 0x78, 0xFE, 0x1E,
  0x3F, 0x87, 0x8F, 0xE1, 0xE3, 0xF8, 0x78, 0xFE, 0x1E, 0x3F, 0x87, 0x8F,
  0xE1, 0xE3, 0xF8, 0x78, 0xFE, 0x1E, 0x3F, 0x87, 0x8F, 0xF3, 0xCF, 0xFE,
  0xFF, 0xEF, 0x9E, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0x0F, 0x83, 0xFC,
  0x7F, 0xE7, 0x9F, 0xF0, 0xFF, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x7F, 0x0F, 0x78, 0xF7, 0xFE, 0x3F, 0xC0, 0xF8, 0xEF, 0x9F, 0xFB,
  0xFF, 0x78, 0xFE, 0x1F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0xFF, 0x1F, 0xFF, 0xBF, 0xF7, 0x7C, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x00, 0x1E, 0xF3, 0xFF, 0x7F, 0xF7, 0x9F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0x78, 0xF7,
  0xFF, 0x3F, 0xF1, 0xEF, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0xEF, 0xFF, 0xFF, 0xFF, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E,
  0x1C, 0x38, 0x70, 0x1F, 0x07, 0xF9, 0xFF, 0x38, 0xFF, 0x1F, 0xE0, 0x1F,
  0x01, 0xFC, 0x1F, 0xC0, 0xFC, 0x07, 0xF8, 0xFF, 0x1E, 0xFF, 0xDF, 0xF0,
  0xF8, 0x3C, 0x3C, 0x3C, 0xFF, 0xFF, 0xFF, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3F, 0x1F, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xF7, 0x0F, 0x79, 0xF7, 0xFF, 0x3F, 0xF1, 0xEF, 0x70, 0xF7, 0x8F, 0x78,
  0xF7, 0x8E, 0x38, 0xE3, 0x9E, 0x3D, 0xE3, 0xDC, 0x1D, 0xC1, 0xDC, 0x1F,
  0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x70, 0xE1, 0xC7, 0xF0, 0xE3,
  0xF8, 0xF1, 0xDE, 0x78, 0xEF, 0x3E, 0x73, 0x9F, 0x79, 0xDF, 0xBC, 0xEE,
  0xDC, 0x77, 0x7E, 0x1F, 0x3F, 0x0F, 0x9F, 0x87, 0xCF, 0xC3, 0xE3, 0xC1,
  0xE1, 0xE0, 0x70, 0xF0, 0x38, 0x78, 0xF1, 0xEF, 0x1E, 0x7B, 0xC7, 0xBC,
  0x3F, 0x83, 0xF8, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x3F, 0x83, 0xB8,
  0x7B, 0xC7, 0xBC, 0xF1, 0xEF, 0x1E, 0xF0, 0xF7, 0x8F, 0x78, 0xF7, 0x8E,
  0x38, 0xE3, 0x9E, 0x3D, 0xE3, 0xDC, 0x1D, 0xC1, 0xFC, 0x1F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x0E, 0x03, 0xE0,
  0x3C, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xE0, 0x38, 0x0F, 0x03,
  0xC0, 0x78, 0x1E, 0x03, 0x80, 0xF0, 0x3C, 0x07, 0x81, 0xFF, 0xFF, 0xFF,
  0xFF, 0x04, 0x1C, 0x71, 0xE3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE3, 0xCF,
  0x1C, 0x3C, 0x3C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x3C, 0x38,
  0x38, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0xC1, 0xC3, 0xC3, 0x87, 0x8F, 0x1E, 0x3C, 0x78, 0xF0, 0xE1, 0xC3, 0xE3,
  0xC7, 0x9E, 0x38, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x71, 0xE3, 0x86,
  0x00, 0x38, 0x3B, 0xF1, 0xFF, 0xDF, 0xCF, 0xEC, 0x3F, 0x00, 0xF0,
};

const GFXglyph RobotoCondensed_SemiBold29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 4, 21, 7, 2, -21 },
  { 12, 7, 8, 9, 1, -22 },
  { 19, 14, 21, 15, 1, -21 },
  { 56, 12, 27, 15, 1, -24 },
  { 97, 16, 21, 18, 1, -21 },
  { 139, 15, 21, 17, 1, -21 },
  { 179, 3, 8, 5, 1, -22 },
  { 182, 7, 30, 9, 2, -23 },
  { 209, 7, 30, 9, 1, -23 },
  { 236, 13, 12, 13, 0, -21 },
  { 256, 12, 15, 14, 1, -17 },
  { 279, 5, 8, 7, 0, -3 },
  { 284, 7, 3, 10, 1, -10 },
  { 287, 4, 4, 8, 2, -4 },
  { 289, 9, 23, 10, 0, -21 },
  { 315, 12, 21, 15, 1, -21 },
  { 347, 8, 21, 15, 2, -21 },
  { 368, 12, 21, 15, 1, -21 },
  { 400, 12, 21, 15, 1, -21 },
  { 432, 13, 21, 15, 1, -21 },
  { 467, 11, 21, 15, 2, -21 },
  { 496, 11, 21, 15, 2, -21 },
  { 525, 12, 21, 15, 1, -21 },
  { 557, 12, 21, 15, 1, -21 },
  { 589, 12, 21, 15, 1, -21 },
  { 621, 4, 16, 8, 2, -16 },
  { 629, 5, 21, 7, 1, -16 },
  { 643, 10, 14, 13, 1, -16 },
  { 661, 11, 9, 14, 2, -14 },
  { 674, 10, 14, 13, 2, -16 },
  { 692, 11, 21, 13, 1, -21 },
  { 721, 20, 26, 22, 1, -20 },
  { 786, 17, 21, 17, 0, -21 },
  { 831, 13, 21, 16, 2, -21 },
  { 866, 15, 21, 17, 1, -21 },
  { 906, 13, 21, 16, 2, -21 },
  { 941, 11, 21, 14, 2, -21 },
  { 970, 11, 21, 14, 2, -21 },
  { 999, 15, 21, 17, 1, -21 },
  { 1039, 14, 21, 18, 2, -21 },
  { 1076, 4, 21, 8, 2, -21 },
  { 1087, 11, 21, 14, 1, -21 },
  { 1116, 14, 21, 16, 2, -21 },
  { 1153, 11, 21, 14, 2, -21 },
  { 1182, 18, 21, 22, 2, -21 },
  { 1230, 14, 21, 18, 2, -21 },
  { 1267, 15, 21, 17, 1, -21 },
  { 1307, 13, 21, 16, 2, -21 },
  { 1342, 15, 25, 17, 1, -21 },
  { 1389, 13, 21, 16, 2, -21 },
  { 1424, 13, 21, 16, 1, -21 },
  { 1459, 14, 21, 16, 1, -21 },
  { 1496, 13, 21, 17, 2, -21 },
  { 1531, 16, 21, 17, 0, -21 },
  { 1573, 20, 21, 22, 1, -21 },
  { 1626, 15, 21, 16, 1, -21 },
  { 1666, 15, 21, 16, 0, -21 },
  { 1706, 13, 21, 15, 1, -21 },
  { 1741, 5, 29, 8, 2, -24 },
  { 1760, 11, 23, 11, 0, -21 },
  { 1792, 6, 29, 8, 0, -24 },
  { 1814, 9, 10, 11, 1, -21 },
  { 1826, 11, 3, 12, 0, 0 },
  { 1831, 7, 4, 9, 1, -21 },
  { 1835, 12, 16, 14, 1, -16 },
  { 1859, 11, 22, 14, 2, -22 },
  { 1890, 12, 16, 13, 1, -16 },
  { 1914, 12, 22, 14, 1, -22 },
  { 1947, 12, 16, 14, 1, -16 },
  { 1971, 8, 22, 9, 1, -22 },
  { 1993, 12, 22, 15, 1, -16 },
  { 2026, 12, 22, 14, 1, -22 },
  { 2059, 4, 22, 7, 2, -22 },
  { 2070, 6, 28, 7, -1, -22 },
  { 2091, 12, 22, 14, 2, -22 },
  { 2124, 3, 22, 7, 2, -22 },
  { 2133, 18, 16, 22, 2, -16 },
  { 2169, 12, 16, 14, 1, -16 },
  { 2193, 12, 16, 14, 1, -16 },
  { 2217, 11, 22, 14, 2, -16 },
  { 2248, 12, 22, 14, 1, -16 },
  { 2281, 7, 16, 9, 2, -16 },
  { 2295, 11, 16, 13, 1, -16 },
  { 2317, 8, 19, 9, 0, -19 },
  { 2336, 12, 16, 14, 1, -16 },
  { 2360, 12, 16, 13, 0, -16 },
  { 2384, 17, 16, 18, 1, -16 },
  { 2418, 12, 16, 13, 1, -16 },
  { 2442, 12, 22, 13, 0, -16 },
  { 2475, 11, 16, 13, 1, -16 },
  { 2497, 7, 28, 9, 1, -23 },
  { 2522, 3, 25, 7, 2, -21 },
  { 2532, 7, 28, 9, 1, -23 },
  { 2557, 13, 6, 16, 2, -11 },
};

const GFXfont RobotoCondensed_SemiBold29pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_SemiBold29pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_SemiBold29pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _ROBOTOCONDENSED_SEMIBOLD29PT7B_H_
