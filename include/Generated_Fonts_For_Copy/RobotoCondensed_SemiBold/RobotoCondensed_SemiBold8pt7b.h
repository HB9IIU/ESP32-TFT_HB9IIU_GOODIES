#ifndef _ROBOTOCONDENSED_SEMIBOLD8PT7B_H_
#define _ROBOTOCONDENSED_SEMIBOLD8PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-SemiBold.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_SemiBold8pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x30, 0xF0, 0x15, 0x76, 0x66, 0x06, 0x54, 0x29, 0x60, 0x45,
  0x98, 0x66, 0xAC, 0x66, 0x67, 0xB7, 0xC0, 0x5A, 0x94, 0x95, 0x56, 0x4E,
  0x42, 0x44, 0xF4, 0x40, 0xC0, 0x80, 0x29, 0x29, 0x00, 0x65, 0x99, 0x96,
  0x75, 0x50, 0x6B, 0x22, 0x4F, 0x6B, 0x26, 0x96, 0x22, 0x6A, 0xF2, 0x74,
  0x61, 0x96, 0x24, 0xA9, 0x96, 0xF2, 0x22, 0x44, 0x66, 0x66, 0x96, 0x6A,
  0x97, 0x26, 0x90, 0x41, 0x80, 0x71, 0x80, 0xCC, 0xC7, 0x00, 0x74, 0xA0,
  0x80, 0x31, 0x27, 0x6D, 0xB6, 0xE4, 0x0C, 0x21, 0x14, 0xA7, 0x48, 0xED,
  0xDF, 0xDF, 0x65, 0x88, 0xD7, 0xED, 0xDD, 0xDE, 0xFC, 0xCE, 0xCF, 0xFC,
  0xCE, 0xCC, 0x75, 0x8B, 0xD7, 0xDD, 0xDF, 0xDD, 0xFC, 0x24, 0x9A, 0xC0,
  0xDF, 0xEE, 0xFD, 0xCC, 0xCC, 0xCF, 0xCF, 0x3C, 0xED, 0xF7, 0xD0, 0xDD,
  0xFF, 0xDD, 0x65, 0x99, 0xD7, 0xED, 0xDF, 0xCC, 0x65, 0x99, 0xD7, 0x10,
  0xED, 0xDE, 0xFD, 0x6D, 0x43, 0x97, 0xF2, 0x22, 0x22, 0x99, 0x99, 0x97,
  0x96, 0x94, 0xA6, 0x10, 0x96, 0xD7, 0x9E, 0x79, 0x20, 0x95, 0x66, 0x7D,
  0x95, 0x66, 0x22, 0xF1, 0x24, 0x4F, 0xEA, 0xAB, 0x91, 0x24, 0x40, 0xD5,
  0x57, 0x4A, 0x80, 0xE0, 0x40, 0x66, 0xAE, 0x88, 0xE9, 0x9E, 0x72, 0x30,
  0x11, 0xF9, 0x97, 0x6F, 0x86, 0x6B, 0x24, 0x80, 0x79, 0x97, 0x36, 0x88,
  0xEB, 0xBB, 0xCA, 0xA0, 0x8A, 0xAA, 0x88, 0xAC, 0xEA, 0xFC, 0xFA, 0x9A,
  0x69, 0xEB, 0xBB, 0x69, 0x96, 0xE9, 0x9E, 0x88, 0xF9, 0x97, 0x11, 0xEA,
  0xE8, 0xB0, 0x75, 0x40, 0xBB, 0xB7, 0xAD, 0xA0, 0xAD, 0x54, 0xA0, 0x6D,
  0xD0, 0xAD, 0xA5, 0x80, 0xED, 0x70, 0x56, 0x54, 0x7E, 0x95, 0x58, 0x70,
};

const GFXglyph RobotoCondensed_SemiBold8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 6, 2, 0, -6 },
  { 3, 2, 2, 3, 0, -6 },
  { 4, 4, 6, 4, 0, -6 },
  { 7, 4, 8, 4, 0, -7 },
  { 11, 5, 6, 5, 0, -6 },
  { 15, 4, 6, 5, 0, -6 },
  { 18, 1, 2, 1, 0, -6 },
  { 19, 2, 8, 3, 0, -6 },
  { 21, 2, 8, 3, 0, -6 },
  { 23, 4, 4, 4, 0, -6 },
  { 25, 4, 4, 4, 0, -5 },
  { 27, 1, 2, 2, 0, -1 },
  { 28, 2, 1, 3, 0, -3 },
  { 29, 1, 1, 2, 1, -1 },
  { 30, 3, 6, 3, 0, -6 },
  { 33, 4, 6, 4, 0, -6 },
  { 36, 2, 6, 4, 1, -6 },
  { 38, 4, 6, 4, 0, -6 },
  { 41, 4, 6, 4, 0, -6 },
  { 44, 4, 6, 4, 0, -6 },
  { 47, 4, 6, 4, 0, -6 },
  { 50, 4, 6, 4, 0, -6 },
  { 53, 4, 6, 4, 0, -6 },
  { 56, 4, 6, 4, 0, -6 },
  { 59, 4, 6, 4, 0, -6 },
  { 62, 1, 4, 2, 1, -4 },
  { 63, 2, 5, 2, 0, -4 },
  { 65, 3, 3, 4, 0, -4 },
  { 67, 2, 3, 4, 1, -4 },
  { 68, 3, 3, 4, 0, -4 },
  { 70, 3, 6, 4, 0, -6 },
  { 73, 6, 8, 6, 0, -6 },
  { 79, 5, 6, 5, 0, -6 },
  { 83, 4, 6, 4, 0, -6 },
  { 86, 4, 6, 5, 0, -6 },
  { 89, 4, 6, 5, 0, -6 },
  { 92, 4, 6, 4, 0, -6 },
  { 95, 4, 6, 4, 0, -6 },
  { 98, 4, 6, 5, 0, -6 },
  { 101, 4, 6, 5, 0, -6 },
  { 104, 1, 6, 2, 1, -6 },
  { 105, 3, 6, 4, 0, -6 },
  { 108, 4, 6, 4, 0, -6 },
  { 111, 4, 6, 4, 0, -6 },
  { 114, 6, 6, 6, 0, -6 },
  { 119, 4, 6, 5, 0, -6 },
  { 122, 4, 6, 5, 0, -6 },
  { 125, 4, 6, 5, 0, -6 },
  { 128, 4, 7, 5, 0, -6 },
  { 132, 4, 6, 4, 0, -6 },
  { 135, 4, 6, 4, 0, -6 },
  { 138, 4, 6, 4, 0, -6 },
  { 141, 4, 6, 5, 0, -6 },
  { 144, 5, 6, 5, 0, -6 },
  { 148, 6, 6, 6, 0, -6 },
  { 153, 4, 6, 4, 0, -6 },
  { 156, 4, 6, 4, 0, -6 },
  { 159, 4, 6, 4, 0, -6 },
  { 162, 2, 8, 2, 0, -7 },
  { 164, 3, 6, 3, 0, -6 },
  { 167, 2, 8, 2, 0, -7 },
  { 169, 3, 3, 3, 0, -6 },
  { 171, 3, 1, 3, 0, 0 },
  { 172, 2, 1, 3, 0, -6 },
  { 173, 4, 4, 4, 0, -4 },
  { 175, 4, 6, 4, 0, -6 },
  { 178, 3, 4, 4, 0, -4 },
  { 180, 4, 6, 4, 0, -6 },
  { 183, 4, 4, 4, 0, -4 },
  { 185, 3, 6, 3, 0, -6 },
  { 188, 4, 6, 4, 0, -4 },
  { 191, 4, 6, 4, 0, -6 },
  { 194, 2, 6, 2, 0, -6 },
  { 196, 2, 8, 2, 0, -6 },
  { 198, 4, 6, 4, 0, -6 },
  { 201, 1, 6, 2, 0, -6 },
  { 202, 6, 4, 6, 0, -4 },
  { 205, 4, 4, 4, 0, -4 },
  { 207, 4, 4, 4, 0, -4 },
  { 209, 4, 6, 4, 0, -4 },
  { 212, 4, 6, 4, 0, -4 },
  { 215, 2, 4, 3, 0, -4 },
  { 216, 3, 4, 4, 0, -4 },
  { 218, 2, 5, 2, 0, -5 },
  { 220, 4, 4, 4, 0, -4 },
  { 222, 3, 4, 4, 0, -4 },
  { 224, 5, 4, 5, 0, -4 },
  { 227, 3, 4, 4, 0, -4 },
  { 229, 3, 6, 4, 0, -4 },
  { 232, 3, 4, 4, 0, -4 },
  { 234, 2, 7, 2, 0, -6 },
  { 236, 1, 7, 2, 1, -6 },
  { 237, 2, 7, 2, 0, -6 },
  { 239, 4, 2, 5, 0, -3 },
};

const GFXfont RobotoCondensed_SemiBold8pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_SemiBold8pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_SemiBold8pt7bGlyphs,
  0x20, 0x7E, 9
};

#endif // _ROBOTOCONDENSED_SEMIBOLD8PT7B_H_
