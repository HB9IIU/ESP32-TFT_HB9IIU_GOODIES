#ifndef _ROBOTOCONDENSED_SEMIBOLD33PT7B_H_
#define _ROBOTOCONDENSED_SEMIBOLD33PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-SemiBold.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_SemiBold33pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xE7, 0x39, 0xC0, 0x00,
  0x1D, 0xEF, 0xF9, 0xC0, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7,
  0xE7, 0x03, 0x9C, 0x03, 0x1C, 0x03, 0x18, 0x07, 0x18, 0x07, 0x38, 0x07,
  0x38, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x06, 0x30, 0x0E, 0x70, 0x0E,
  0x70, 0x0E, 0x70, 0x0E, 0x70, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x1C,
  0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x18, 0xE0, 0x18, 0xC0, 0x18, 0xC0, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x1F, 0x03, 0xFE, 0x3F, 0xF9, 0xFF, 0xCF, 0x1E,
  0xF8, 0x7F, 0x83, 0xFE, 0x1E, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x7F, 0x00,
  0xFE, 0x01, 0xF0, 0x07, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xFC, 0x7F, 0xFF,
  0xEF, 0xFE, 0x3F, 0xE0, 0x7C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x00, 0x3C,
  0x00, 0x1F, 0x80, 0x0F, 0xF0, 0x03, 0x9C, 0x30, 0xC7, 0x1C, 0x31, 0xC6,
  0x0C, 0x73, 0x83, 0x9C, 0xC0, 0xFF, 0x70, 0x1F, 0xB8, 0x03, 0xCE, 0x00,
  0x07, 0x00, 0x01, 0x9E, 0x00, 0xEF, 0xE0, 0x37, 0xF8, 0x1D, 0xC6, 0x06,
  0x71, 0xC3, 0x9C, 0x71, 0xC7, 0x1C, 0x71, 0xC6, 0x08, 0x7F, 0x80, 0x0F,
  0xE0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x07, 0xDE, 0x03,
  0xC7, 0x81, 0xE3, 0xC0, 0xF1, 0xC0, 0x79, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x03, 0xE0, 0x03, 0xF0, 0xE3, 0xFC, 0xF3, 0xFE, 0x79, 0xE7, 0xBD, 0xF3,
  0xFE, 0xF0, 0xFE, 0x7C, 0x3F, 0x1E, 0x1F, 0x0F, 0xFF, 0xC7, 0xFF, 0xF1,
  0xFF, 0x78, 0x3E, 0x3E, 0xFF, 0xFF, 0xFF, 0xE0, 0x02, 0x06, 0x0F, 0x1E,
  0x1C, 0x3C, 0x38, 0x78, 0x70, 0x70, 0x70, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0x70, 0x70, 0x70, 0x78, 0x38, 0x3C,
  0x1C, 0x1E, 0x0E, 0x06, 0x02, 0x80, 0xE0, 0xE0, 0x70, 0x78, 0x38, 0x3C,
  0x1C, 0x1E, 0x1E, 0x0E, 0x0E, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0E, 0x0E, 0x1E, 0x1E, 0x1C, 0x3C, 0x38, 0x38, 0x70, 0xE0,
  0xE0, 0x80, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x07, 0x38, 0xCF,
  0xFF, 0x9F, 0xFF, 0x87, 0xF0, 0x07, 0xC0, 0x1F, 0xC0, 0x7B, 0x80, 0xE3,
  0x83, 0x87, 0x01, 0x04, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x7B,
  0xDE, 0xF7, 0xBB, 0xDC, 0x40, 0xFF, 0xFF, 0xF8, 0x37, 0xFF, 0xF7, 0x00,
  0x01, 0xC0, 0x38, 0x07, 0x01, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x38, 0x07,
  0x00, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x1C, 0x07,
  0x00, 0xE0, 0x1C, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0xE0, 0x00, 0x0F,
  0x81, 0xFE, 0x1F, 0xF8, 0xFB, 0xEF, 0x8F, 0x78, 0x7F, 0xC1, 0xFE, 0x0F,
  0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE,
  0x0F, 0xF0, 0x7F, 0x87, 0xFE, 0x3C, 0xFF, 0xE7, 0xFE, 0x1F, 0xE0, 0x3E,
  0x00, 0x01, 0x0F, 0x3F, 0xFF, 0xFF, 0xEF, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x07, 0xC0, 0x7F, 0xC3, 0xFF, 0x9F, 0xFE, 0x78, 0x79, 0xE1, 0xFF, 0x07,
  0xFC, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x1F, 0x00, 0x7F,
  0xFD, 0xFF, 0xF7, 0xFF, 0xC0, 0x0F, 0xC0, 0xFF, 0xC7, 0xFF, 0x1F, 0xFE,
  0x78, 0x7B, 0xE1, 0xE0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x07, 0xE0, 0x7F,
  0x01, 0xF8, 0x07, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0xF0, 0x3F, 0xE0,
  0xF7, 0x87, 0xDF, 0xFE, 0x3F, 0xF8, 0xFF, 0xC0, 0xFC, 0x00, 0x00, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0x7F, 0x03, 0xFC,
  0x0E, 0xF0, 0x7B, 0xC1, 0xCF, 0x0F, 0x3C, 0x38, 0xF1, 0xE3, 0xCF, 0x0F,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x7F, 0xF3, 0xFF, 0x9F, 0xFC, 0xFF, 0xE7, 0x80, 0x3C,
  0x01, 0xE0, 0x0E, 0x00, 0x77, 0xC7, 0xFF, 0x3F, 0xFD, 0xF3, 0xE1, 0x0F,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0xF0, 0x7F, 0x83, 0xFE, 0x3E, 0xFB, 0xE7,
  0xFF, 0x1F, 0xF0, 0x3E, 0x00, 0x03, 0xC0, 0x7E, 0x07, 0xF0, 0x7F, 0x83,
  0xE0, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF3, 0xC7, 0xFF, 0x3F, 0xFD, 0xFB,
  0xFF, 0x8F, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFE, 0x3E,
  0xFF, 0xE3, 0xFF, 0x1F, 0xF0, 0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x07,
  0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07,
  0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x00,
  0x0F, 0x81, 0xFF, 0x1F, 0xFC, 0xFF, 0xEF, 0x8F, 0x78, 0x7B, 0xC3, 0xFE,
  0x1E, 0xF8, 0xF3, 0xFF, 0x8F, 0xF8, 0x7F, 0x87, 0xFE, 0x7C, 0x7B, 0xC3,
  0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x3F, 0xFF, 0xE7, 0xFF, 0x1F, 0xF0,
  0x7E, 0x00, 0x0F, 0x81, 0xFE, 0x1F, 0xF9, 0xFF, 0xEF, 0x0F, 0x78, 0x7B,
  0xC3, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x3F, 0xFB, 0xF7, 0xFF, 0xBF,
  0xBC, 0x79, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0xF8, 0x7F, 0x83, 0xFC,
  0x1F, 0x80, 0xF0, 0x00, 0x37, 0xFF, 0xF7, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1B, 0xFF, 0xFB, 0x80, 0x31, 0xE7, 0xDF, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x8E, 0x38, 0xE7, 0x9E, 0x73, 0xC6, 0x00, 0x00, 0x10,
  0x07, 0x01, 0xF0, 0x7F, 0x1F, 0xE7, 0xF8, 0xFE, 0x0F, 0x80, 0xF8, 0x0F,
  0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF0, 0x1F, 0x00, 0x70, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x80, 0x0E, 0x00, 0xF8, 0x0F, 0xE0, 0xFF, 0x83, 0xFE,
  0x07, 0xF0, 0x1F, 0x01, 0xF0, 0x7F, 0x3F, 0xEF, 0xF8, 0xFE, 0x0F, 0x80,
  0xE0, 0x08, 0x00, 0x1F, 0x83, 0xFE, 0x7F, 0xEF, 0xFF, 0xF0, 0xFF, 0x0F,
  0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x1E, 0x03, 0xC0, 0x7C, 0x0F, 0x80, 0xF0,
  0x0F, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x04, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0E, 0x00, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x3C,
  0x07, 0x80, 0xE0, 0x03, 0x83, 0x80, 0x07, 0x07, 0x00, 0x07, 0x1C, 0x0F,
  0x0E, 0x38, 0x7F, 0x0C, 0xE1, 0xFF, 0x1D, 0xC3, 0x8E, 0x3B, 0x8E, 0x1C,
  0x77, 0x1C, 0x38, 0xEC, 0x38, 0x61, 0xF8, 0xF1, 0xC3, 0xF1, 0xE3, 0x87,
  0xE3, 0x87, 0x0F, 0xC7, 0x0E, 0x19, 0x8F, 0x1C, 0x33, 0x0E, 0x78, 0xE7,
  0x1F, 0xFB, 0x8E, 0x3F, 0x7E, 0x1C, 0x3C, 0x78, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x7C, 0x04, 0x00, 0x7F, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x3D, 0xE0,
  0x07, 0x9C, 0x00, 0xF3, 0xC0, 0x3C, 0x78, 0x07, 0x8F, 0x00, 0xF0, 0xF0,
  0x3E, 0x1E, 0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x1F, 0xFF, 0x87, 0xFF, 0xF0,
  0xF0, 0x1F, 0x1E, 0x01, 0xE7, 0xC0, 0x3C, 0xF0, 0x07, 0xDE, 0x00, 0xF8,
  0xFF, 0xE1, 0xFF, 0xE3, 0xFF, 0xE7, 0xFF, 0xEF, 0x07, 0xDE, 0x07, 0xBC,
  0x0F, 0x78, 0x1E, 0xF0, 0x3D, 0xE0, 0xFB, 0xFF, 0xE7, 0xFF, 0x8F, 0xFF,
  0x9E, 0x0F, 0xBC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF,
  0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0x3F, 0xF8, 0x00, 0x07, 0xE0, 0x1F, 0xF8,
  0x3F, 0xFC, 0x7F, 0xFE, 0x78, 0x3E, 0xF8, 0x1E, 0xF0, 0x1E, 0xF0, 0x1F,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1E, 0xF8, 0x3E, 0x7F, 0xFE,
  0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xE0, 0xFF, 0x81, 0xFF, 0xC3, 0xFF, 0xE7,
  0xFF, 0xCF, 0x07, 0xDE, 0x07, 0xBC, 0x0F, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x3F, 0xE0, 0x7B, 0xC1, 0xF7, 0xFF, 0xCF, 0xFF, 0x9F, 0xFC, 0x3F,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xFF, 0xBF, 0xFD, 0xFF, 0xEF, 0xFF, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xFF, 0xBF, 0xFD, 0xFF, 0xEF,
  0xFF, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC,
  0x7F, 0xFE, 0xF8, 0x3E, 0xF8, 0x1E, 0xF0, 0x1E, 0xF0, 0x1F, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0x7C, 0x1F, 0x7F, 0xFF, 0x3F, 0xFE,
  0x1F, 0xFC, 0x07, 0xF0, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0xF0, 0x7F, 0x83, 0xFE, 0x3F,
  0xFF, 0xE7, 0xFF, 0x1F, 0xF0, 0x3E, 0x00, 0xF0, 0x3F, 0xF0, 0x3E, 0xF0,
  0x7C, 0xF0, 0x7C, 0xF0, 0xF8, 0xF1, 0xF0, 0xF1, 0xF0, 0xF3, 0xE0, 0xF7,
  0xC0, 0xF7, 0xC0, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xE0, 0xFD,
  0xF0, 0xF9, 0xF0, 0xF0, 0xF8, 0xF0, 0xF8, 0xF0, 0x7C, 0xF0, 0x7C, 0xF0,
  0x3E, 0xF0, 0x3E, 0xF0, 0x1F, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFC, 0x01, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8,
  0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0x7F, 0xB8, 0x3B, 0xFD, 0xE3, 0xDF,
  0xEF, 0x1E, 0xFF, 0x38, 0xE7, 0xF9, 0xEF, 0x3F, 0xCF, 0x79, 0xFE, 0x7B,
  0x8F, 0xF1, 0xFC, 0x7F, 0x8F, 0xE3, 0xFC, 0x7E, 0x1F, 0xE1, 0xF0, 0xFF,
  0x0F, 0x87, 0xF8, 0x7C, 0x3F, 0xC1, 0xC1, 0xE0, 0xF0, 0x0F, 0xF8, 0x0F,
  0xF8, 0x0F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F,
  0xF7, 0x8F, 0xF7, 0x8F, 0xF3, 0xCF, 0xF3, 0xCF, 0xF1, 0xEF, 0xF1, 0xEF,
  0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF0, 0x3F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC,
  0x7F, 0xFE, 0x78, 0x3E, 0xF8, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0x78, 0x3E, 0x7F, 0xFE, 0x3F, 0xFC,
  0x1F, 0xF8, 0x07, 0xE0, 0xFF, 0xE1, 0xFF, 0xF3, 0xFF, 0xF7, 0xFF, 0xEF,
  0x03, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0x3F, 0xF8, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFE, 0x78, 0x3E, 0xF8, 0x1F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F,
  0x78, 0x3E, 0x7F, 0xFE, 0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xFC, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0E, 0x00, 0x04, 0xFF, 0xE1, 0xFF, 0xF3, 0xFF, 0xE7,
  0xFF, 0xEF, 0x03, 0xDE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0,
  0x7B, 0xFF, 0xF7, 0xFF, 0xCF, 0xFF, 0x1F, 0xFC, 0x3C, 0x7C, 0x78, 0x78,
  0xF0, 0xF9, 0xE0, 0xF3, 0xC1, 0xF7, 0x83, 0xEF, 0x03, 0xDE, 0x07, 0xFC,
  0x07, 0x80, 0x07, 0xE0, 0x3F, 0xF0, 0xFF, 0xF3, 0xFF, 0xE7, 0xC3, 0xEF,
  0x03, 0xDE, 0x07, 0xBC, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x7F,
  0xC0, 0x3F, 0xC0, 0x0F, 0xC0, 0x0F, 0xFC, 0x0F, 0xF8, 0x1E, 0xF0, 0x3D,
  0xF0, 0x7B, 0xFF, 0xF3, 0xFF, 0xC3, 0xFF, 0x01, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0xE0, 0xFB, 0xFF, 0xE7, 0xFF, 0xC7,
  0xFF, 0x03, 0xF8, 0x00, 0x78, 0x03, 0xCF, 0x00, 0xF9, 0xF0, 0x1F, 0x3E,
  0x03, 0xC3, 0xC0, 0x78, 0x78, 0x1F, 0x0F, 0x83, 0xE0, 0xF0, 0x78, 0x1E,
  0x0F, 0x03, 0xC3, 0xE0, 0x3C, 0x78, 0x07, 0x8F, 0x00, 0xF1, 0xE0, 0x1F,
  0x78, 0x01, 0xEF, 0x00, 0x3D, 0xE0, 0x07, 0xBC, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0xF0,
  0x38, 0x1F, 0xE0, 0xF8, 0x3F, 0xE1, 0xF0, 0xFF, 0xC3, 0xE1, 0xE7, 0x87,
  0xC3, 0xCF, 0x0F, 0x87, 0x9E, 0x3F, 0x8F, 0x3C, 0x7F, 0x1E, 0x78, 0xEE,
  0x7C, 0x79, 0xDC, 0xF0, 0xF3, 0xB9, 0xE1, 0xEF, 0x7B, 0xC3, 0xDE, 0xF7,
  0x87, 0xB8, 0xEF, 0x07, 0x71, 0xDC, 0x0F, 0xE3, 0xF8, 0x1F, 0xC7, 0xF0,
  0x3F, 0x8F, 0xE0, 0x7E, 0x0F, 0xC0, 0xFC, 0x1F, 0x00, 0xF8, 0x3E, 0x01,
  0xF0, 0x7C, 0x03, 0xC0, 0xF8, 0x00, 0xF8, 0x0F, 0x3C, 0x0F, 0x9F, 0x07,
  0x87, 0x87, 0xC3, 0xE3, 0xC0, 0xF3, 0xE0, 0x7D, 0xE0, 0x1E, 0xF0, 0x0F,
  0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x3F, 0xF0, 0x1E, 0x78, 0x1F, 0x3E, 0x0F, 0x8F, 0x0F, 0x87,
  0xC7, 0xC1, 0xE7, 0xC0, 0xFB, 0xE0, 0x3C, 0x78, 0x07, 0xBE, 0x07, 0xDF,
  0x03, 0xC7, 0x83, 0xE3, 0xE1, 0xE0, 0xF0, 0xF0, 0x78, 0xF8, 0x1E, 0x78,
  0x0F, 0x3C, 0x07, 0xBC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x01,
  0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0,
  0x0F, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF,
  0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF,
  0x3C, 0xF3, 0xFF, 0xFF, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xC0,
  0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x00,
  0xF8, 0x03, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0xF8, 0x03,
  0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0xF8, 0xFF, 0xFF, 0xDF,
  0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF,
  0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7F, 0xFF, 0xFF, 0x0E, 0x03, 0xC0,
  0x7C, 0x0F, 0x83, 0xF0, 0x77, 0x0E, 0xE3, 0xDC, 0x71, 0xCE, 0x3B, 0xC7,
  0x70, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF8, 0x7C, 0x3C, 0x1E, 0x0E,
  0x0F, 0xC1, 0xFF, 0x0F, 0xFC, 0xF9, 0xF7, 0x87, 0x80, 0x3C, 0x01, 0xE1,
  0xFF, 0x3F, 0xFB, 0xFF, 0xDE, 0x1F, 0xF0, 0xFF, 0x87, 0xFE, 0xFD, 0xFF,
  0xE7, 0xFF, 0x1E, 0x78, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF7, 0xC7, 0xFF, 0x3F, 0xFD, 0xFF, 0xFF,
  0x0F, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFC, 0xF7, 0xC0, 0x0F, 0xC1, 0xFF,
  0x0F, 0xFC, 0xFF, 0xF7, 0x87, 0xFC, 0x3F, 0xC1, 0xFE, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xF0, 0xF7, 0x87, 0xBF, 0xFC, 0xFF, 0xC7, 0xFC, 0x0F,
  0xC0, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x1F, 0x7C, 0xFF, 0xF7, 0xFF, 0xDF, 0xFF, 0x78, 0x7F,
  0xE1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFE, 0x1F,
  0x78, 0x7D, 0xFF, 0xF7, 0xFF, 0xCF, 0xEF, 0x1F, 0x3C, 0x0F, 0xC0, 0x7F,
  0xC3, 0xFF, 0x1F, 0xFE, 0x78, 0x79, 0xE0, 0xEF, 0x83, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x3E, 0x00, 0x78, 0x11, 0xFF, 0xE3, 0xFF, 0x87,
  0xFC, 0x0F, 0xE0, 0x07, 0x8F, 0xC7, 0xE7, 0xF3, 0xC1, 0xE0, 0xF0, 0x78,
  0xFF, 0xFF, 0xFF, 0xE7, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x00, 0x0F, 0x3C, 0xFF, 0xF7,
  0xFF, 0xDF, 0xFF, 0x78, 0x7F, 0xE0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFE, 0x0F, 0x78, 0x7D, 0xFF, 0xF7, 0xFF, 0xCF, 0xEF,
  0x0F, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x3D, 0xF8, 0xFF, 0xE3, 0xFF,
  0x03, 0xF0, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF3, 0xCF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xF0, 0x0F, 0xFF, 0x70, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x78, 0xF1, 0xC0, 0x00, 0x0F, 0x1E,
  0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7,
  0x8F, 0x1E, 0x3C, 0x7F, 0xFF, 0xFF, 0xBE, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0xFB,
  0xC7, 0xCF, 0x3E, 0x3C, 0xF0, 0xF7, 0xC3, 0xFE, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x83, 0xFE, 0x0F, 0xFC, 0x3C, 0xF0, 0xF3, 0xE3, 0xC7, 0xCF, 0x0F,
  0x3C, 0x3E, 0xF0, 0x78, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF3, 0xC3, 0xC7, 0xFF, 0x7F, 0xBF, 0xFF,
  0xFD, 0xFF, 0xFB, 0xEF, 0x0F, 0x8F, 0xF8, 0x78, 0x3F, 0xC3, 0xC1, 0xFE,
  0x1E, 0x0F, 0xF0, 0xF0, 0x7F, 0x87, 0x83, 0xFC, 0x3C, 0x1F, 0xE1, 0xE0,
  0xFF, 0x0F, 0x07, 0xF8, 0x78, 0x3F, 0xC3, 0xC1, 0xFE, 0x1E, 0x0F, 0xF0,
  0xF0, 0x78, 0xF3, 0xCF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xF0, 0x0F, 0xC0, 0x7F, 0xC3, 0xFF, 0x9F, 0xFE, 0x78,
  0x7F, 0xE0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFE,
  0x0F, 0x78, 0x7D, 0xFF, 0xE3, 0xFF, 0x87, 0xFC, 0x0F, 0xC0, 0xF7, 0xC7,
  0xFF, 0x3F, 0xFD, 0xFF, 0xFF, 0x0F, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0,
  0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x0F, 0xFF, 0xFB, 0xFF, 0xDF, 0xFC,
  0xF7, 0xC7, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0x1F, 0x3C, 0xFE, 0xF7, 0xFF, 0xDF, 0xFF, 0x78, 0x7F, 0xE1, 0xFF,
  0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFE, 0x1F, 0x78, 0x7D,
  0xFF, 0xF7, 0xFF, 0xCF, 0xFF, 0x1F, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0xF7, 0xFF, 0xFF, 0xFF, 0xF8,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0x0F, 0x81, 0xFF, 0x1F, 0xFC, 0xF1, 0xE7, 0x8F, 0xBC, 0x01, 0xF0, 0x0F,
  0xF0, 0x1F, 0xE0, 0x7F, 0x80, 0x7D, 0xE1, 0xFF, 0x07, 0xBC, 0x7D, 0xFF,
  0xC7, 0xFC, 0x0F, 0x80, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE7, 0xFF, 0xFF,
  0xFF, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0xE3, 0xF1, 0xF8, 0x3C, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0x3E, 0x70, 0x78, 0x3D, 0xE1, 0xF7, 0x87,
  0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xCF, 0x07, 0x3C, 0x1E, 0xF0, 0x7B,
  0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0x80, 0xF0, 0xE1, 0xFE, 0x1C, 0x3F, 0xC7, 0xC7, 0xF8, 0xF8, 0xF7, 0x1F,
  0x1C, 0xF3, 0xE7, 0x9E, 0xFE, 0xF3, 0xDD, 0xDE, 0x3B, 0xBB, 0xC7, 0x77,
  0x70, 0xFE, 0x7E, 0x1F, 0x8F, 0xC3, 0xF1, 0xF8, 0x3E, 0x3E, 0x07, 0x83,
  0xC0, 0xF0, 0x78, 0x1E, 0x0F, 0x00, 0xF0, 0xFB, 0xC7, 0x9E, 0x3C, 0x7B,
  0xC3, 0xDE, 0x0F, 0xE0, 0x7F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xF0,
  0x7F, 0x83, 0xDE, 0x3E, 0xF1, 0xE3, 0xDF, 0x1E, 0xF0, 0x78, 0x78, 0x3D,
  0xE1, 0xF7, 0x87, 0x9F, 0x1E, 0x3C, 0x78, 0xF3, 0xE3, 0xCF, 0x07, 0xBC,
  0x1E, 0xF0, 0x7F, 0x81, 0xFE, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xE0, 0x0F, 0x00, 0xFF, 0xF7, 0xFF, 0xBF, 0xFC, 0x03, 0xE0, 0x1E,
  0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0x80, 0x7C, 0x03,
  0xC0, 0x3C, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x02, 0x07, 0x0F, 0x1E,
  0x1C, 0x1C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x78, 0xF8,
  0xF0, 0xF8, 0x78, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x1C,
  0x1E, 0x0F, 0x07, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xC0, 0xE0, 0xF0, 0x78, 0x78, 0x38, 0x38, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x1E, 0x1F, 0x0F, 0x1F, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x38, 0x78, 0x78, 0xF0, 0xE0, 0xC0, 0x3C,
  0x0E, 0xFE, 0x1F, 0xFE, 0x7F, 0xFF, 0xEE, 0x3F, 0xDC, 0x3F, 0x00, 0x3C,
  0x00,
};

const GFXglyph RobotoCondensed_SemiBold33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 5, 23, 8, 2, -23 },
  { 16, 8, 9, 11, 1, -25 },
  { 25, 16, 23, 18, 1, -23 },
  { 71, 13, 29, 17, 2, -26 },
  { 119, 18, 23, 21, 2, -23 },
  { 171, 17, 23, 19, 1, -23 },
  { 220, 3, 9, 5, 1, -25 },
  { 224, 8, 33, 11, 2, -26 },
  { 257, 8, 33, 11, 1, -26 },
  { 290, 15, 14, 15, 0, -23 },
  { 317, 14, 17, 16, 1, -19 },
  { 347, 5, 9, 8, 1, -4 },
  { 353, 7, 3, 11, 2, -11 },
  { 356, 5, 5, 9, 2, -5 },
  { 360, 11, 25, 11, 0, -23 },
  { 395, 13, 23, 17, 2, -23 },
  { 433, 8, 23, 17, 3, -23 },
  { 456, 14, 23, 17, 1, -23 },
  { 497, 14, 23, 17, 1, -23 },
  { 538, 14, 23, 17, 1, -23 },
  { 579, 13, 23, 17, 2, -23 },
  { 617, 13, 23, 17, 2, -23 },
  { 655, 14, 23, 17, 1, -23 },
  { 696, 13, 23, 17, 2, -23 },
  { 734, 13, 23, 17, 2, -23 },
  { 772, 5, 18, 9, 2, -18 },
  { 784, 6, 23, 8, 1, -18 },
  { 802, 12, 16, 15, 1, -18 },
  { 826, 12, 11, 16, 2, -16 },
  { 843, 12, 16, 15, 2, -18 },
  { 867, 12, 23, 15, 1, -23 },
  { 902, 23, 30, 25, 1, -23 },
  { 989, 19, 23, 20, 0, -23 },
  { 1044, 15, 23, 18, 2, -23 },
  { 1088, 16, 23, 19, 2, -23 },
  { 1134, 15, 23, 19, 2, -23 },
  { 1178, 13, 23, 16, 2, -23 },
  { 1216, 13, 23, 16, 2, -23 },
  { 1254, 16, 23, 19, 2, -23 },
  { 1300, 16, 23, 20, 2, -23 },
  { 1346, 5, 23, 9, 2, -23 },
  { 1361, 13, 23, 16, 1, -23 },
  { 1399, 16, 23, 18, 2, -23 },
  { 1445, 13, 23, 16, 2, -23 },
  { 1483, 21, 23, 25, 2, -23 },
  { 1544, 16, 23, 20, 2, -23 },
  { 1590, 16, 23, 20, 2, -23 },
  { 1636, 15, 23, 19, 2, -23 },
  { 1680, 16, 27, 20, 2, -23 },
  { 1734, 15, 23, 18, 2, -23 },
  { 1778, 15, 23, 18, 1, -23 },
  { 1822, 16, 23, 18, 1, -23 },
  { 1868, 15, 23, 19, 2, -23 },
  { 1912, 19, 23, 19, 0, -23 },
  { 1967, 23, 23, 25, 1, -23 },
  { 2034, 17, 23, 18, 1, -23 },
  { 2083, 17, 23, 18, 0, -23 },
  { 2132, 15, 23, 17, 1, -23 },
  { 2176, 6, 32, 9, 2, -27 },
  { 2200, 13, 25, 12, 0, -23 },
  { 2241, 6, 32, 9, 1, -27 },
  { 2265, 11, 12, 13, 1, -23 },
  { 2282, 13, 3, 13, 0, 0 },
  { 2287, 8, 5, 11, 1, -25 },
  { 2292, 13, 17, 16, 1, -17 },
  { 2320, 13, 25, 16, 2, -25 },
  { 2361, 13, 17, 15, 1, -17 },
  { 2389, 14, 25, 16, 1, -25 },
  { 2433, 14, 17, 16, 1, -17 },
  { 2463, 9, 25, 11, 1, -25 },
  { 2492, 14, 24, 17, 1, -17 },
  { 2534, 12, 25, 16, 2, -25 },
  { 2572, 4, 24, 8, 2, -24 },
  { 2584, 7, 31, 8, -1, -24 },
  { 2612, 14, 25, 16, 2, -25 },
  { 2656, 4, 25, 8, 2, -25 },
  { 2669, 21, 17, 25, 2, -17 },
  { 2714, 12, 17, 16, 2, -17 },
  { 2740, 14, 17, 16, 1, -17 },
  { 2770, 13, 24, 16, 2, -17 },
  { 2809, 14, 24, 16, 1, -17 },
  { 2851, 8, 17, 11, 2, -17 },
  { 2868, 13, 17, 15, 1, -17 },
  { 2896, 9, 22, 10, 0, -22 },
  { 2921, 12, 17, 16, 2, -17 },
  { 2947, 14, 17, 15, 0, -17 },
  { 2977, 19, 17, 21, 1, -17 },
  { 3018, 13, 17, 15, 1, -17 },
  { 3046, 14, 24, 14, 0, -17 },
  { 3088, 13, 17, 15, 1, -17 },
  { 3116, 8, 32, 10, 1, -26 },
  { 3148, 3, 27, 8, 3, -23 },
  { 3159, 8, 32, 10, 1, -26 },
  { 3191, 15, 7, 19, 2, -13 },
};

const GFXfont RobotoCondensed_SemiBold33pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_SemiBold33pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_SemiBold33pt7bGlyphs,
  0x20, 0x7E, 39
};

#endif // _ROBOTOCONDENSED_SEMIBOLD33PT7B_H_
