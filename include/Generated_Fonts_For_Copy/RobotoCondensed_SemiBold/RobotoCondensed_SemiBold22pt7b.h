#ifndef _ROBOTOCONDENSED_SEMIBOLD22PT7B_H_
#define _ROBOTOCONDENSED_SEMIBOLD22PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-SemiBold.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_SemiBold22pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xB6, 0xDB, 0x6D, 0x80, 0xFB, 0xDE, 0xF7, 0xBD, 0xEC, 0x09,
  0x86, 0x61, 0x90, 0x64, 0x7F, 0xDF, 0xF1, 0x30, 0x4C, 0x33, 0x0C, 0x8F,
  0xFB, 0xFE, 0x36, 0x09, 0x82, 0x61, 0x98, 0x0C, 0x06, 0x07, 0x8F, 0xE7,
  0x7B, 0x1D, 0x8E, 0xE0, 0x78, 0x1F, 0x07, 0xC0, 0xF0, 0x3F, 0x1F, 0x8F,
  0xEF, 0x7F, 0x1F, 0x02, 0x01, 0x00, 0x78, 0x0F, 0x80, 0xCC, 0xCC, 0xC8,
  0xCD, 0x8F, 0x90, 0x7B, 0x00, 0x60, 0x06, 0x00, 0xDE, 0x0D, 0xF1, 0xB3,
  0x1B, 0x33, 0x33, 0x11, 0xF0, 0x1E, 0x1C, 0x07, 0xC1, 0xDC, 0x31, 0x87,
  0x30, 0xEE, 0x0F, 0x81, 0xE0, 0x7C, 0xDD, 0xDB, 0xBB, 0x73, 0xEE, 0x39,
  0xEF, 0x1F, 0xF1, 0xE7, 0xFF, 0xF0, 0x08, 0xC6, 0x67, 0x31, 0x8C, 0xE7,
  0x39, 0xCE, 0x71, 0x8C, 0x63, 0x8C, 0x31, 0x84, 0x86, 0x38, 0xC7, 0x18,
  0xC7, 0x39, 0xCE, 0x73, 0x9C, 0xE6, 0x33, 0x99, 0xCC, 0x40, 0x0C, 0x03,
  0x00, 0xC3, 0xFE, 0x3F, 0x87, 0x83, 0xE0, 0xCC, 0x21, 0x00, 0x1C, 0x0E,
  0x07, 0x03, 0x8F, 0xFF, 0xFF, 0xFE, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x80,
  0x77, 0x77, 0x64, 0xFF, 0xC0, 0x6F, 0x60, 0x06, 0x0C, 0x30, 0x60, 0xC3,
  0x06, 0x0C, 0x18, 0x60, 0xC1, 0x86, 0x0C, 0x18, 0x30, 0xC0, 0x3E, 0x3F,
  0x9D, 0xDC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E,
  0x3B, 0xB9, 0xFC, 0x3C, 0x0C, 0xFF, 0xFF, 0x1C, 0x71, 0xC7, 0x1C, 0x71,
  0xC7, 0x1C, 0x71, 0xC7, 0x3E, 0x3F, 0xBD, 0xDC, 0x7E, 0x38, 0x1C, 0x0C,
  0x0E, 0x0E, 0x07, 0x07, 0x07, 0x07, 0x07, 0x83, 0xFF, 0xFF, 0x3E, 0x3F,
  0xB9, 0xDC, 0x70, 0x38, 0x1C, 0x1C, 0x3C, 0x1F, 0x01, 0xC0, 0xE0, 0x7E,
  0x3F, 0x39, 0xFC, 0x7C, 0x07, 0x07, 0x83, 0xC3, 0xE1, 0xF1, 0xB8, 0xDC,
  0xCE, 0x67, 0x73, 0xBF, 0xFF, 0xF0, 0x70, 0x38, 0x1C, 0x0E, 0x7F, 0xBF,
  0xDC, 0x0C, 0x06, 0x03, 0xF1, 0xFC, 0xCF, 0x03, 0x81, 0xC0, 0xFC, 0x7E,
  0x3B, 0xBD, 0xFC, 0x3C, 0x0E, 0x0F, 0x0F, 0x0E, 0x06, 0x07, 0x73, 0xFD,
  0xEF, 0xE3, 0xF1, 0xF8, 0xFC, 0x76, 0x3B, 0xBC, 0xFC, 0x3C, 0xFF, 0xFF,
  0xC0, 0xE0, 0x60, 0x70, 0x38, 0x18, 0x1C, 0x0E, 0x06, 0x07, 0x03, 0x83,
  0x81, 0xC0, 0xE0, 0xE0, 0x3E, 0x3F, 0x9D, 0xDC, 0x7E, 0x3B, 0x1D, 0xDC,
  0x7C, 0x7F, 0x31, 0xB8, 0xFC, 0x7E, 0x3F, 0xBD, 0xFC, 0x7C, 0x3C, 0x3F,
  0x1D, 0xDC, 0x6E, 0x3F, 0x1F, 0x8F, 0xC7, 0xF7, 0xBF, 0xCE, 0xE0, 0x60,
  0x70, 0xF0, 0xF0, 0x70, 0x6F, 0x60, 0x00, 0x00, 0x06, 0xF6, 0x7D, 0x80,
  0x00, 0x0D, 0xBF, 0xB0, 0x02, 0x1C, 0xFF, 0xEF, 0x1C, 0x3F, 0x1F, 0x0E,
  0x04, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x80, 0xE0, 0xF8, 0x3E,
  0x0F, 0x0F, 0x3E, 0xF8, 0xE0, 0x80, 0x3C, 0xFE, 0xEF, 0xC7, 0x07, 0x07,
  0x0E, 0x1C, 0x1C, 0x38, 0x38, 0x00, 0x00, 0x38, 0x38, 0x38, 0x07, 0xE0,
  0x1F, 0xE0, 0x60, 0x61, 0x80, 0x66, 0x00, 0xCC, 0x78, 0xD1, 0xF9, 0xE3,
  0x33, 0xCC, 0x67, 0x98, 0xCF, 0x31, 0x1E, 0x66, 0x3C, 0xCC, 0xD9, 0xFF,
  0xB1, 0xDE, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0x7F, 0x00, 0x7E, 0x00,
  0x07, 0x00, 0x38, 0x03, 0xE0, 0x1F, 0x00, 0xD8, 0x06, 0xE0, 0x77, 0x03,
  0xB8, 0x18, 0xC1, 0xC7, 0x0F, 0xF8, 0x7F, 0xC7, 0x07, 0x38, 0x39, 0xC1,
  0xDC, 0x07, 0xFF, 0x3F, 0xEE, 0x3F, 0x87, 0xE1, 0xF8, 0x7E, 0x3B, 0xFC,
  0xFF, 0xB8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0xFF, 0xFB, 0xFC, 0x1F, 0x07,
  0xF9, 0xE7, 0x30, 0x7E, 0x0F, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x76, 0x0E, 0xF7, 0x8F, 0xF0, 0xF8, 0xFE, 0x3F, 0xCE, 0x7B,
  0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1,
  0xF9, 0xEF, 0xF3, 0xF8, 0xFF, 0xFF, 0xF8, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xFE, 0xFF, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xFE, 0xFF, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0x1F, 0x07, 0xF9, 0xE7, 0x38, 0x7E, 0x0F, 0xC0,
  0x38, 0x07, 0x00, 0xE3, 0xFC, 0x7F, 0x83, 0xF0, 0x77, 0x0E, 0xF3, 0xCF,
  0xF0, 0xFC, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F,
  0xFF, 0xFF, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0xC3, 0xE7, 0xEF, 0x7E, 0x3C, 0xE1, 0xFC,
  0x3B, 0x8E, 0x73, 0xCE, 0x71, 0xDC, 0x3B, 0x87, 0xF0, 0xFE, 0x1F, 0xE3,
  0xDC, 0x71, 0xCE, 0x39, 0xC3, 0xB8, 0x77, 0x07, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0xFF, 0xFF, 0xF0, 0x1F, 0xC0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x7F, 0xF1,
  0xBF, 0xC6, 0xFB, 0x3B, 0xEC, 0xEF, 0xBB, 0x3E, 0x6D, 0xF9, 0xF7, 0xE7,
  0x9F, 0x9E, 0x7E, 0x39, 0xF8, 0xE7, 0xE0, 0xFE, 0x1F, 0xC3, 0xFC, 0x7F,
  0x8F, 0xF9, 0xFB, 0x3F, 0x77, 0xE6, 0xFC, 0xFF, 0x8F, 0xF1, 0xFE, 0x1F,
  0xC3, 0xF8, 0x3F, 0x07, 0x1F, 0x07, 0xF1, 0xEF, 0x38, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x77, 0x0E, 0xF7, 0x8F,
  0xF0, 0xF8, 0xFF, 0x1F, 0xF3, 0x8F, 0x70, 0xEE, 0x0F, 0xC1, 0xF8, 0x77,
  0x1E, 0xFF, 0x9F, 0xE3, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0x1F, 0x07, 0xF1, 0xEF, 0x38, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x77, 0x0E, 0xF7, 0x8F, 0xE0, 0xFE, 0x01, 0xE0,
  0x1C, 0x01, 0x00, 0xFF, 0x1F, 0xF3, 0x8F, 0x70, 0xEE, 0x1D, 0xC3, 0xB8,
  0x77, 0x1E, 0xFF, 0x9F, 0xE3, 0x9C, 0x71, 0xCE, 0x39, 0xC3, 0xB8, 0x77,
  0x0E, 0x1E, 0x1F, 0xEF, 0x3B, 0x87, 0xE1, 0xF8, 0x07, 0x80, 0xF8, 0x1F,
  0x80, 0xE0, 0x1F, 0x87, 0xE1, 0xFC, 0xF7, 0xF8, 0x7C, 0xFF, 0xFF, 0xF1,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8,
  0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xDC, 0xF7, 0xF8,
  0x7C, 0xE0, 0x77, 0x07, 0x70, 0x77, 0x0E, 0x30, 0xE3, 0x8E, 0x38, 0xC3,
  0x9C, 0x19, 0xC1, 0xDC, 0x1D, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x00,
  0x70, 0xC3, 0x8F, 0xC7, 0x1F, 0x8E, 0x3F, 0x3C, 0x6E, 0x78, 0xCC, 0xFB,
  0x99, 0xF7, 0x3B, 0x6E, 0x7E, 0xDC, 0xFD, 0xB1, 0xF3, 0xE1, 0xE7, 0xC3,
  0xC7, 0x87, 0x8F, 0x0F, 0x1C, 0x1C, 0x38, 0x70, 0xF7, 0x0E, 0x38, 0xE3,
  0x9C, 0x1D, 0xC1, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF8, 0x1F, 0x81,
  0xDC, 0x39, 0xC3, 0x9E, 0x70, 0xE7, 0x0F, 0xF0, 0xE7, 0x0E, 0x70, 0xE3,
  0x9C, 0x39, 0xC1, 0x98, 0x1F, 0x81, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0xFF, 0xFF, 0xF0, 0x38, 0x0E,
  0x07, 0x01, 0xC0, 0xE0, 0x38, 0x1C, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0x38,
  0x0F, 0xFF, 0xFF, 0xFF, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE,
  0xEE, 0xFF, 0xE0, 0x60, 0x70, 0x70, 0x30, 0x38, 0x38, 0x18, 0x1C, 0x1C,
  0x0C, 0x0E, 0x0E, 0x06, 0x07, 0x07, 0x03, 0xFF, 0x33, 0x33, 0x33, 0x33,
  0x33, 0x33, 0x33, 0x33, 0x33, 0xFF, 0x30, 0x71, 0xE3, 0xC6, 0xDD, 0xB3,
  0x63, 0xFF, 0xFF, 0xC0, 0xE3, 0x8E, 0x3E, 0x3F, 0xB9, 0xDC, 0xE0, 0x71,
  0xF9, 0xFD, 0xCE, 0xE7, 0x73, 0xBF, 0xCF, 0x60, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x73, 0xFD, 0xEF, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F,
  0xDF, 0xFE, 0xEE, 0x00, 0x3E, 0x7F, 0xE7, 0xE3, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE3, 0xE7, 0x7F, 0x3C, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x39, 0xDD, 0xFF,
  0xEF, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0xDE, 0xFF, 0x3B, 0x80,
  0x3E, 0x3F, 0xBD, 0xDC, 0x7E, 0x3F, 0xFF, 0xFF, 0xC0, 0xE0, 0x79, 0x9F,
  0xC7, 0xC0, 0x0E, 0x3C, 0xE1, 0xC3, 0x9F, 0xFF, 0x9C, 0x38, 0x70, 0xE1,
  0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x3B, 0xBF, 0xFD, 0xFC, 0x7E, 0x3F, 0x1F,
  0x8F, 0xC7, 0xE3, 0xFB, 0xDF, 0xE7, 0x70, 0x3B, 0x3D, 0xFC, 0x7C, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x73, 0xFD, 0xEE, 0xE3, 0xF1, 0xF8, 0xFC,
  0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0x80, 0x7D, 0x81, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x39, 0xCE, 0x00, 0x1C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7,
  0x39, 0xCF, 0xFF, 0x00, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x3F, 0x9D,
  0xDC, 0xEE, 0x7E, 0x3F, 0x1F, 0x8F, 0xE7, 0x73, 0x9D, 0xCF, 0xE3, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xEE, 0x7B, 0xFF, 0xFF, 0x79,
  0xF8, 0xE7, 0xE3, 0x9F, 0x8E, 0x7E, 0x39, 0xF8, 0xE7, 0xE3, 0x9F, 0x8E,
  0x7E, 0x39, 0xF8, 0xE7, 0xEE, 0x7F, 0xBD, 0xDC, 0x7E, 0x3F, 0x1F, 0x8F,
  0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x70, 0x3E, 0x3F, 0xBD, 0xFC, 0x7E, 0x3F,
  0x1F, 0x8F, 0xC7, 0xE3, 0xFB, 0xDF, 0xC7, 0xC0, 0xEE, 0x7F, 0xBD, 0xFC,
  0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xFB, 0xFF, 0xDD, 0xCE, 0x07, 0x03,
  0x81, 0xC0, 0x3B, 0xBF, 0xFD, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3,
  0xFB, 0xDF, 0xE7, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0xEF, 0xFF, 0xF8, 0xE3,
  0x8E, 0x38, 0xE3, 0x8E, 0x38, 0x3C, 0x7E, 0xE7, 0xE7, 0xF0, 0x7C, 0x3E,
  0x0F, 0xC7, 0xE7, 0x7F, 0x3C, 0x30, 0xCF, 0xFF, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0E, 0x3C, 0x70, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F,
  0xC7, 0xE3, 0xFB, 0xDF, 0xE7, 0x70, 0xE3, 0xB9, 0xDC, 0xEE, 0x63, 0x31,
  0xB8, 0xFC, 0x7C, 0x1E, 0x0F, 0x07, 0x83, 0x80, 0x63, 0x19, 0x8C, 0x67,
  0x7B, 0x9D, 0xEE, 0x77, 0xB8, 0xDE, 0xC3, 0xFF, 0x0F, 0x3C, 0x3C, 0xF0,
  0xF3, 0xC1, 0xCE, 0x06, 0x18, 0x73, 0x9C, 0xE3, 0xF0, 0xFC, 0x1E, 0x07,
  0x81, 0xE0, 0x78, 0x3F, 0x0F, 0xC7, 0x39, 0xCE, 0xE3, 0xB9, 0xDC, 0xEE,
  0x63, 0x71, 0xB8, 0xFC, 0x7C, 0x1E, 0x0F, 0x07, 0x01, 0x81, 0xC1, 0xC1,
  0xE0, 0xE0, 0xFF, 0xFF, 0x06, 0x0E, 0x1C, 0x1C, 0x38, 0x30, 0x70, 0xE0,
  0xFF, 0xFF, 0x19, 0xCC, 0xE7, 0x39, 0xCE, 0x73, 0x39, 0xC6, 0x39, 0xCE,
  0x73, 0x8C, 0x71, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x86, 0x38, 0xC6,
  0x31, 0x8C, 0x63, 0x8E, 0x77, 0x31, 0x8C, 0x63, 0x39, 0x88, 0x00, 0x38,
  0xDF, 0x3E, 0xFF, 0x1E, 0xC3, 0x80,
};

const GFXglyph RobotoCondensed_SemiBold22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 3, 16, 6, 1, -16 },
  { 7, 5, 6, 7, 1, -17 },
  { 11, 10, 16, 12, 1, -16 },
  { 31, 9, 20, 11, 1, -18 },
  { 54, 12, 16, 14, 1, -16 },
  { 78, 11, 16, 13, 1, -16 },
  { 100, 2, 6, 4, 1, -17 },
  { 102, 5, 22, 7, 1, -17 },
  { 116, 5, 22, 7, 1, -17 },
  { 130, 10, 9, 10, 0, -16 },
  { 142, 9, 12, 11, 1, -13 },
  { 156, 4, 6, 5, 0, -3 },
  { 159, 5, 2, 7, 1, -8 },
  { 161, 4, 3, 6, 1, -3 },
  { 163, 7, 17, 8, 0, -16 },
  { 178, 9, 16, 11, 1, -16 },
  { 196, 6, 16, 11, 2, -16 },
  { 208, 9, 16, 11, 1, -16 },
  { 226, 9, 16, 11, 1, -16 },
  { 244, 9, 16, 11, 1, -16 },
  { 262, 9, 16, 11, 1, -16 },
  { 280, 9, 16, 11, 1, -16 },
  { 298, 9, 16, 11, 1, -16 },
  { 316, 9, 16, 11, 1, -16 },
  { 334, 9, 16, 11, 1, -16 },
  { 352, 4, 12, 6, 1, -12 },
  { 358, 3, 15, 5, 1, -12 },
  { 364, 7, 10, 10, 1, -12 },
  { 373, 9, 6, 11, 1, -10 },
  { 380, 8, 10, 10, 1, -12 },
  { 390, 8, 16, 10, 1, -16 },
  { 406, 15, 20, 17, 1, -15 },
  { 444, 13, 16, 13, 0, -16 },
  { 470, 10, 16, 12, 1, -16 },
  { 490, 11, 16, 13, 1, -16 },
  { 512, 10, 16, 12, 1, -16 },
  { 532, 9, 16, 11, 1, -16 },
  { 550, 9, 16, 11, 1, -16 },
  { 568, 11, 16, 13, 1, -16 },
  { 590, 11, 16, 14, 1, -16 },
  { 612, 3, 16, 6, 1, -16 },
  { 618, 8, 16, 11, 1, -16 },
  { 634, 11, 16, 12, 1, -16 },
  { 656, 9, 16, 11, 1, -16 },
  { 674, 14, 16, 17, 1, -16 },
  { 702, 11, 16, 14, 1, -16 },
  { 724, 11, 16, 13, 1, -16 },
  { 746, 11, 16, 12, 1, -16 },
  { 768, 11, 19, 13, 1, -16 },
  { 795, 11, 16, 12, 1, -16 },
  { 817, 10, 16, 12, 1, -16 },
  { 837, 10, 16, 12, 1, -16 },
  { 857, 10, 16, 13, 1, -16 },
  { 877, 12, 16, 13, 0, -16 },
  { 901, 15, 16, 17, 1, -16 },
  { 931, 12, 16, 12, 0, -16 },
  { 955, 12, 16, 12, 0, -16 },
  { 979, 10, 16, 12, 1, -16 },
  { 999, 4, 22, 6, 1, -18 },
  { 1010, 8, 17, 8, 0, -16 },
  { 1027, 4, 22, 6, 0, -18 },
  { 1038, 7, 8, 9, 1, -16 },
  { 1045, 9, 2, 9, 0, 0 },
  { 1048, 5, 3, 7, 1, -16 },
  { 1050, 9, 12, 10, 1, -12 },
  { 1064, 9, 17, 11, 1, -17 },
  { 1084, 8, 12, 10, 1, -12 },
  { 1096, 9, 17, 11, 1, -17 },
  { 1116, 9, 12, 10, 1, -12 },
  { 1130, 7, 17, 7, 0, -17 },
  { 1145, 9, 16, 11, 1, -12 },
  { 1163, 9, 17, 11, 1, -17 },
  { 1183, 3, 17, 5, 1, -17 },
  { 1190, 5, 21, 5, -1, -17 },
  { 1204, 9, 17, 10, 1, -17 },
  { 1224, 3, 17, 5, 1, -17 },
  { 1231, 14, 12, 16, 1, -12 },
  { 1252, 9, 12, 11, 1, -12 },
  { 1266, 9, 12, 11, 1, -12 },
  { 1280, 9, 16, 11, 1, -12 },
  { 1298, 9, 16, 11, 1, -12 },
  { 1316, 6, 12, 7, 1, -12 },
  { 1325, 8, 12, 10, 1, -12 },
  { 1337, 6, 14, 7, 0, -14 },
  { 1348, 9, 12, 11, 1, -12 },
  { 1362, 9, 12, 10, 0, -12 },
  { 1376, 14, 12, 14, 0, -12 },
  { 1397, 10, 12, 10, 0, -12 },
  { 1412, 9, 16, 10, 0, -12 },
  { 1430, 8, 12, 10, 1, -12 },
  { 1442, 5, 21, 7, 1, -17 },
  { 1456, 2, 19, 6, 2, -16 },
  { 1461, 5, 21, 7, 1, -17 },
  { 1475, 10, 5, 12, 1, -9 },
};

const GFXfont RobotoCondensed_SemiBold22pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_SemiBold22pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_SemiBold22pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _ROBOTOCONDENSED_SEMIBOLD22PT7B_H_
