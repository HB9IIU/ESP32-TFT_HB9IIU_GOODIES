#ifndef _ROBOTOCONDENSED_SEMIBOLD12PT7B_H_
#define _ROBOTOCONDENSED_SEMIBOLD12PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-SemiBold.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_SemiBold12pt7bBitmaps[] PROGMEM = {
  0x00, 0xFD, 0x80, 0xFE, 0x80, 0x52, 0x95, 0xF5, 0x7D, 0x94, 0xA0, 0x27,
  0xD9, 0xC7, 0x39, 0x97, 0x20, 0xC2, 0xAB, 0x34, 0x20, 0xF5, 0x55, 0x1C,
  0x30, 0xD1, 0x23, 0x87, 0x0A, 0xB7, 0x26, 0x7C, 0xF8, 0x2B, 0x49, 0x24,
  0x93, 0x22, 0x89, 0x12, 0x49, 0x25, 0x28, 0x25, 0x1E, 0xE5, 0x00, 0x31,
  0xBE, 0x63, 0x00, 0x5C, 0xC0, 0xA0, 0x12, 0x22, 0x24, 0x44, 0xC8, 0x6D,
  0x99, 0x99, 0x9D, 0x60, 0x3C, 0x92, 0x49, 0x20, 0x39, 0x6C, 0x82, 0x18,
  0xC2, 0x18, 0x7C, 0x72, 0xC2, 0x33, 0x04, 0x39, 0x70, 0x18, 0x63, 0x8E,
  0x59, 0x6F, 0xC6, 0x18, 0xF4, 0x21, 0xE9, 0x08, 0x52, 0xF0, 0x66, 0x21,
  0xE9, 0x4E, 0x7A, 0x70, 0xFC, 0x21, 0x86, 0x10, 0xC3, 0x08, 0x60, 0x7D,
  0x9D, 0x69, 0x99, 0xF0, 0x6B, 0x99, 0x9F, 0x13, 0x60, 0xA0, 0x28, 0x50,
  0x05, 0xC0, 0x0B, 0xB0, 0xE0, 0x80, 0xF0, 0xF0, 0x8E, 0x1E, 0x80, 0x76,
  0xC6, 0x23, 0x10, 0x04, 0x20, 0x1E, 0x10, 0x90, 0x49, 0x95, 0x4A, 0xA5,
  0x54, 0xBE, 0x40, 0x30, 0x0F, 0x00, 0x10, 0x70, 0xA1, 0x46, 0xCD, 0x9F,
  0x23, 0xC6, 0xF4, 0xE7, 0x3F, 0x4E, 0x33, 0xF0, 0x76, 0xE3, 0x08, 0x42,
  0x3B, 0x70, 0xF4, 0xE3, 0x18, 0xC6, 0x33, 0xF0, 0xFC, 0x21, 0x0F, 0x42,
  0x10, 0xF8, 0xF8, 0x88, 0xF8, 0x88, 0x80, 0x76, 0xE3, 0x08, 0x4E, 0x39,
  0x78, 0x8E, 0x38, 0xE3, 0xFE, 0x38, 0xE3, 0x8C, 0xFF, 0x80, 0x08, 0x42,
  0x10, 0x87, 0x2B, 0x70, 0x9A, 0x6B, 0x28, 0xE3, 0xC9, 0x26, 0x88, 0x88,
  0x88, 0x88, 0x88, 0xF0, 0xC7, 0x8F, 0x1F, 0x7A, 0xB5, 0x6E, 0xCD, 0x92,
  0x8F, 0x3C, 0xFB, 0xAE, 0xF9, 0xE7, 0x8C, 0x73, 0x68, 0xE3, 0x8E, 0x38,
  0xF6, 0x70, 0xF4, 0xE3, 0x19, 0xFA, 0x10, 0x80, 0x73, 0x68, 0xA3, 0x8E,
  0x38, 0xB6, 0x70, 0x60, 0x80, 0xF4, 0xE7, 0x39, 0xFA, 0x53, 0x98, 0x39,
  0xB4, 0xD8, 0x38, 0x3C, 0xDB, 0x38, 0xFC, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0x8C, 0x63, 0x18, 0xC6, 0x3B, 0x70, 0xC6, 0x89, 0x33, 0x66, 0x85,
  0x0E, 0x1C, 0x10, 0xC9, 0xA4, 0xD7, 0x4A, 0xA7, 0x53, 0xB9, 0xDC, 0x6C,
  0x32, 0x00, 0x4D, 0xB6, 0x8E, 0x30, 0xE6, 0x9B, 0xCC, 0xCD, 0x36, 0x8E,
  0x38, 0xC3, 0x0C, 0x30, 0xFC, 0x31, 0x84, 0x30, 0x86, 0x10, 0xFC, 0xEA,
  0xAA, 0xAB, 0xC2, 0x10, 0xC6, 0x10, 0xC6, 0x10, 0x80, 0xD5, 0x55, 0x57,
  0x26, 0x5D, 0xF8, 0x44, 0x72, 0xC2, 0xF4, 0xAD, 0xA0, 0x84, 0x3D, 0x29,
  0x4E, 0x52, 0xF0, 0x7A, 0x71, 0x8C, 0x25, 0xC0, 0x08, 0x5E, 0x9C, 0xE7,
  0x29, 0x78, 0x72, 0x53, 0xF4, 0x24, 0xE0, 0x36, 0xF6, 0x66, 0x66, 0x60,
  0x7A, 0x73, 0x9C, 0xA5, 0xE9, 0x78, 0x88, 0xF9, 0x99, 0x99, 0x90, 0xDF,
  0xC0, 0x51, 0x55, 0x57, 0x84, 0x2D, 0x4E, 0x72, 0x96, 0x90, 0xFF, 0x80,
  0xFF, 0x66, 0x4C, 0x99, 0x32, 0x64, 0x80, 0xF9, 0x99, 0x99, 0x90, 0x79,
  0x2C, 0xB3, 0xC9, 0x27, 0x80, 0xF4, 0xA5, 0x39, 0x4B, 0xD0, 0x80, 0x7A,
  0x73, 0x9C, 0xA5, 0xE1, 0x08, 0xFE, 0x49, 0x20, 0x72, 0xD0, 0xE1, 0xED,
  0xC0, 0x5D, 0x24, 0x9B, 0x99, 0x99, 0x9B, 0xF0, 0xDA, 0xD4, 0xA7, 0x18,
  0x80, 0xD2, 0xB5, 0x6B, 0xF6, 0xED, 0x99, 0x00, 0x5B, 0x9C, 0x67, 0x2B,
  0x60, 0xDA, 0xD4, 0xE7, 0x18, 0x84, 0x40, 0x78, 0xCC, 0x46, 0x23, 0xE0,
  0x2D, 0xB5, 0x93, 0x6C, 0x80, 0xFF, 0xE0, 0xC9, 0x26, 0x5A, 0x4B, 0x00,
  0xCD, 0x64,
};

const GFXglyph RobotoCondensed_SemiBold12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 1, 9, 3, 1, -9 },
  { 3, 3, 3, 4, 0, -9 },
  { 5, 5, 9, 6, 1, -9 },
  { 11, 4, 11, 6, 1, -10 },
  { 17, 6, 9, 8, 1, -9 },
  { 24, 7, 9, 7, 0, -9 },
  { 32, 2, 3, 2, 0, -9 },
  { 33, 3, 13, 4, 1, -10 },
  { 38, 3, 13, 4, 0, -10 },
  { 43, 5, 5, 5, 0, -9 },
  { 47, 5, 5, 6, 0, -6 },
  { 51, 2, 3, 3, 0, -1 },
  { 52, 2, 1, 4, 1, -4 },
  { 53, 2, 2, 3, 1, -2 },
  { 54, 4, 10, 4, 0, -9 },
  { 59, 4, 9, 6, 1, -9 },
  { 64, 3, 9, 6, 1, -9 },
  { 68, 6, 9, 6, 0, -9 },
  { 75, 5, 9, 6, 0, -9 },
  { 81, 6, 9, 6, 0, -9 },
  { 88, 5, 9, 6, 1, -9 },
  { 94, 5, 9, 6, 1, -9 },
  { 100, 6, 9, 6, 0, -9 },
  { 107, 4, 9, 6, 1, -9 },
  { 112, 4, 9, 6, 1, -9 },
  { 117, 2, 7, 3, 1, -7 },
  { 119, 2, 9, 3, 0, -7 },
  { 122, 5, 5, 5, 0, -6 },
  { 126, 4, 3, 6, 1, -5 },
  { 128, 4, 5, 5, 1, -6 },
  { 131, 5, 9, 5, 0, -9 },
  { 137, 9, 11, 9, 0, -8 },
  { 150, 7, 9, 7, 0, -9 },
  { 158, 5, 9, 7, 1, -9 },
  { 164, 5, 9, 7, 1, -9 },
  { 170, 5, 9, 7, 1, -9 },
  { 176, 5, 9, 6, 1, -9 },
  { 182, 4, 9, 6, 1, -9 },
  { 187, 5, 9, 7, 1, -9 },
  { 193, 6, 9, 7, 1, -9 },
  { 200, 1, 9, 3, 1, -9 },
  { 202, 5, 9, 6, 0, -9 },
  { 208, 6, 9, 7, 1, -9 },
  { 215, 4, 9, 6, 1, -9 },
  { 220, 7, 9, 9, 1, -9 },
  { 228, 6, 9, 7, 1, -9 },
  { 235, 6, 9, 7, 1, -9 },
  { 242, 5, 9, 7, 1, -9 },
  { 248, 6, 11, 7, 1, -9 },
  { 257, 5, 9, 7, 1, -9 },
  { 263, 6, 9, 6, 0, -9 },
  { 270, 6, 9, 6, 0, -9 },
  { 277, 5, 9, 7, 1, -9 },
  { 283, 7, 9, 7, 0, -9 },
  { 291, 9, 9, 9, 0, -9 },
  { 302, 6, 9, 7, 0, -9 },
  { 309, 6, 9, 6, 0, -9 },
  { 316, 6, 9, 6, 0, -9 },
  { 323, 2, 12, 3, 1, -10 },
  { 326, 5, 10, 5, 0, -9 },
  { 333, 2, 12, 3, 0, -10 },
  { 336, 4, 4, 5, 0, -9 },
  { 338, 5, 1, 5, 0, 0 },
  { 339, 3, 2, 4, 0, -9 },
  { 340, 5, 7, 6, 0, -7 },
  { 345, 5, 9, 6, 1, -9 },
  { 351, 5, 7, 6, 0, -7 },
  { 356, 5, 9, 6, 0, -9 },
  { 362, 5, 7, 6, 0, -7 },
  { 367, 4, 9, 4, 0, -9 },
  { 372, 5, 9, 6, 0, -7 },
  { 378, 4, 9, 6, 1, -9 },
  { 383, 1, 10, 3, 1, -10 },
  { 385, 2, 12, 3, 0, -10 },
  { 388, 5, 9, 6, 1, -9 },
  { 394, 1, 9, 3, 1, -9 },
  { 396, 7, 7, 9, 1, -7 },
  { 403, 4, 7, 6, 1, -7 },
  { 407, 6, 7, 6, 0, -7 },
  { 413, 5, 9, 6, 1, -7 },
  { 419, 5, 9, 6, 0, -7 },
  { 425, 3, 7, 4, 1, -7 },
  { 428, 5, 7, 5, 0, -7 },
  { 433, 3, 8, 4, 0, -8 },
  { 436, 4, 7, 6, 1, -7 },
  { 440, 5, 7, 5, 0, -7 },
  { 445, 7, 7, 8, 0, -7 },
  { 452, 5, 7, 5, 0, -7 },
  { 457, 5, 9, 5, 0, -7 },
  { 463, 5, 7, 5, 0, -7 },
  { 468, 3, 11, 4, 0, -9 },
  { 473, 1, 11, 3, 1, -9 },
  { 475, 3, 11, 4, 0, -9 },
  { 480, 5, 3, 7, 1, -5 },
};

const GFXfont RobotoCondensed_SemiBold12pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_SemiBold12pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_SemiBold12pt7bGlyphs,
  0x20, 0x7E, 14
};

#endif // _ROBOTOCONDENSED_SEMIBOLD12PT7B_H_
