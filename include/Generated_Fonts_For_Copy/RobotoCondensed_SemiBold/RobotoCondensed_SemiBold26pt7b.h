#ifndef _ROBOTOCONDENSED_SEMIBOLD26PT7B_H_
#define _ROBOTOCONDENSED_SEMIBOLD26PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-SemiBold.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_SemiBold26pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0x80, 0xCF, 0x3C, 0xF3,
  0xCF, 0x3C, 0xC0, 0x0E, 0xE0, 0xCC, 0x0C, 0xC0, 0xCC, 0x0C, 0xC0, 0xCC,
  0x7F, 0xF7, 0xFF, 0x19, 0x81, 0x98, 0x19, 0x8F, 0xFE, 0xFF, 0xE1, 0x98,
  0x33, 0x03, 0x30, 0x33, 0x03, 0x30, 0x33, 0x00, 0x06, 0x00, 0xC0, 0x18,
  0x07, 0x83, 0xF8, 0xFF, 0x9C, 0x73, 0x8F, 0x70, 0xEE, 0x01, 0xE0, 0x1F,
  0x01, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0xF0, 0xFE, 0x3D, 0xC7, 0xBF, 0xE3,
  0xFC, 0x3E, 0x01, 0x80, 0x30, 0x3C, 0x01, 0xF0, 0x0E, 0x62, 0x31, 0x9C,
  0xC6, 0x63, 0x1B, 0x8E, 0x6C, 0x1F, 0x60, 0x39, 0x80, 0x0C, 0x00, 0x37,
  0x81, 0xBF, 0x06, 0xCC, 0x33, 0x30, 0xCC, 0xC6, 0x33, 0x18, 0xCC, 0x03,
  0xF0, 0x07, 0x80, 0x0F, 0x01, 0xFC, 0x0F, 0xE0, 0xF3, 0x87, 0x1C, 0x38,
  0xE0, 0xEE, 0x07, 0xE0, 0x1E, 0x01, 0xF0, 0x1F, 0xCC, 0xEE, 0x6E, 0x7F,
  0x71, 0xFB, 0x87, 0xDE, 0x3C, 0x7F, 0xF3, 0xFF, 0x87, 0xDE, 0xFF, 0xFC,
  0x08, 0x61, 0x8C, 0x71, 0xC6, 0x38, 0xE3, 0x8C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x8E, 0x38, 0x61, 0xC7, 0x0C, 0x38, 0x70, 0x80, 0x83, 0x0E, 0x18,
  0x70, 0xC3, 0x8E, 0x18, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0x8E,
  0x38, 0xC7, 0x18, 0xE3, 0x08, 0x00, 0x06, 0x00, 0xC0, 0x18, 0x33, 0x37,
  0xFE, 0x7F, 0x83, 0xC0, 0xF8, 0x39, 0x86, 0x38, 0x42, 0x00, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x39, 0xCE, 0x67, 0x39, 0x80, 0xFF, 0xFF, 0xC0,
  0x4E, 0xEE, 0x03, 0x07, 0x07, 0x06, 0x06, 0x0E, 0x0E, 0x0C, 0x0C, 0x1C,
  0x18, 0x18, 0x38, 0x38, 0x30, 0x30, 0x70, 0x70, 0x60, 0xE0, 0xE0, 0x1F,
  0x07, 0xF1, 0xFF, 0x38, 0xE7, 0x1D, 0xE3, 0xFC, 0x3F, 0x87, 0xF0, 0xFE,
  0x1F, 0xC3, 0xF8, 0x7F, 0x1F, 0xE3, 0xDC, 0x73, 0x8E, 0x7F, 0xC7, 0xF0,
  0x7C, 0x00, 0x06, 0x3D, 0xFF, 0xFE, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38,
  0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x1F, 0x07, 0xF1, 0xFF, 0x78,
  0xEE, 0x1F, 0xC3, 0xC0, 0x70, 0x0E, 0x03, 0xC0, 0x70, 0x1E, 0x07, 0x81,
  0xE0, 0x38, 0x0F, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0x0F,
  0xF1, 0xFF, 0x78, 0xEE, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x1F, 0x83, 0xE0,
  0x7F, 0x00, 0xE0, 0x1E, 0x03, 0xF8, 0x7F, 0x8E, 0x7F, 0xCF, 0xF0, 0x7C,
  0x00, 0x03, 0xC0, 0xF8, 0x1F, 0x07, 0xE0, 0xFC, 0x3F, 0x87, 0xF1, 0xDE,
  0x3B, 0xCE, 0x79, 0xCF, 0x71, 0xEF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x00, 0x3F, 0xC7, 0xF9, 0xFF, 0x38, 0x07, 0x00, 0xE0,
  0x1F, 0xC3, 0xFE, 0x7F, 0xC2, 0x3C, 0x07, 0x80, 0x70, 0x0E, 0x01, 0xFC,
  0x7B, 0x8E, 0x7F, 0xC7, 0xF0, 0x7C, 0x00, 0x07, 0x81, 0xF0, 0x7E, 0x1E,
  0x07, 0x80, 0xE0, 0x1D, 0xE3, 0xFE, 0xFF, 0xDE, 0x3F, 0xC3, 0xF8, 0x7F,
  0x0F, 0xE1, 0xDC, 0x7B, 0x8F, 0x3F, 0xC7, 0xF0, 0x3C, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0x80, 0xE0,
  0x1C, 0x07, 0x80, 0xE0, 0x1C, 0x07, 0x80, 0xE0, 0x3C, 0x07, 0x80, 0xE0,
  0x00, 0x1F, 0x07, 0xF1, 0xFF, 0x38, 0xE7, 0x1C, 0xE3, 0x9C, 0x73, 0x8E,
  0x3F, 0x83, 0xE0, 0xFE, 0x38, 0xEF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0x7F,
  0xC7, 0xF0, 0x7C, 0x00, 0x1F, 0x07, 0xF1, 0xFE, 0x38, 0xEF, 0x1D, 0xE3,
  0xB8, 0x7F, 0x0F, 0xF1, 0xEE, 0x3D, 0xFF, 0x9F, 0xE1, 0xDC, 0x03, 0x80,
  0xF0, 0x3C, 0x3F, 0x87, 0xC0, 0xF0, 0x00, 0x4E, 0xEE, 0x00, 0x00, 0x00,
  0x04, 0xEE, 0xE0, 0x67, 0xF7, 0x00, 0x00, 0x00, 0x00, 0x77, 0x77, 0x6E,
  0x40, 0x00, 0x81, 0xC3, 0xE7, 0xEF, 0xC7, 0x83, 0xC1, 0xF8, 0x3F, 0x87,
  0xC0, 0xE0, 0x10, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0x80, 0x70, 0x3E, 0x1F, 0xC3, 0xF8, 0x3C, 0x1E, 0x7F, 0xFE,
  0x7C, 0x38, 0x10, 0x00, 0x3E, 0x3F, 0xBF, 0xFC, 0x7E, 0x38, 0x1C, 0x0E,
  0x0F, 0x0F, 0x07, 0x07, 0x03, 0x81, 0xC0, 0x00, 0x00, 0x10, 0x1C, 0x0E,
  0x07, 0x00, 0x01, 0xF0, 0x01, 0xFF, 0x00, 0xE0, 0xE0, 0x70, 0x0C, 0x38,
  0x03, 0x8C, 0x3C, 0x67, 0x1F, 0x99, 0x8E, 0x63, 0x63, 0x18, 0xF9, 0xCE,
  0x3E, 0x63, 0x8F, 0x18, 0xE3, 0xC6, 0x38, 0xF1, 0x8C, 0x7C, 0x63, 0x1B,
  0x9D, 0xE6, 0xE7, 0xDF, 0x18, 0xE7, 0x86, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x04, 0x00, 0xFF, 0x80, 0x0F, 0x80, 0x03, 0x80, 0x07, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7E, 0x01, 0xFC, 0x03, 0xB8, 0x07, 0x78, 0x0E,
  0x70, 0x38, 0xE0, 0x71, 0xC0, 0xE3, 0xC3, 0xFF, 0x87, 0xFF, 0x0F, 0xFF,
  0x3C, 0x0E, 0x78, 0x1C, 0xE0, 0x3F, 0xC0, 0x78, 0xFF, 0x1F, 0xFB, 0xFF,
  0x70, 0xFE, 0x1F, 0xC1, 0xF8, 0x7F, 0x0F, 0xFF, 0xDF, 0xF3, 0xFF, 0x70,
  0xFE, 0x0F, 0xC1, 0xF8, 0x3F, 0x0F, 0xFF, 0xFF, 0xFB, 0xFC, 0x00, 0x0F,
  0xC0, 0xFF, 0x0F, 0xFC, 0xF0, 0xE7, 0x07, 0xF8, 0x3F, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x3D, 0xC1, 0xEF,
  0x0E, 0x3F, 0xF1, 0xFF, 0x03, 0xF0, 0xFE, 0x1F, 0xF3, 0xFF, 0x70, 0xEE,
  0x1F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x7F, 0x0E, 0xFF, 0xDF, 0xF3, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xFF, 0xBF, 0xEF, 0xFB, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xFF, 0xBF, 0xEF, 0xFB, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x00, 0x0F, 0xC1, 0xFF,
  0x0F, 0xFC, 0xF0, 0xE7, 0x07, 0xF8, 0x1F, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x8F, 0xFC, 0x7F, 0xE3, 0xFF, 0x03, 0xF8, 0x1D, 0xC0, 0xEF, 0x0F, 0x3F,
  0xF8, 0xFF, 0x83, 0xF0, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x70, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xF8, 0x7E, 0x1F,
  0xCF, 0xFF, 0x9F, 0xE1, 0xE0, 0xE0, 0xFE, 0x1E, 0xE1, 0xEE, 0x3C, 0xE7,
  0x8E, 0x78, 0xEF, 0x0E, 0xE0, 0xFE, 0x0F, 0xE0, 0xFF, 0x0F, 0x70, 0xF7,
  0x8E, 0x38, 0xE3, 0xCE, 0x1E, 0xE1, 0xEE, 0x0F, 0xE0, 0xF0, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0x0F,
  0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xFC, 0x3F,
  0xFC, 0x37, 0xFC, 0x77, 0xEE, 0x77, 0xEE, 0x77, 0xEE, 0xE7, 0xE7, 0xE7,
  0xE7, 0xE7, 0xE7, 0xC7, 0xE7, 0xC7, 0xE3, 0xC7, 0xE3, 0xC7, 0xE3, 0x87,
  0xE0, 0x7F, 0x07, 0xF0, 0x7F, 0x87, 0xF8, 0x7F, 0xC7, 0xFC, 0x7F, 0xE7,
  0xEE, 0x7E, 0xF7, 0xE7, 0x7E, 0x7F, 0xE3, 0xFE, 0x3F, 0xE1, 0xFE, 0x1F,
  0xE0, 0xFE, 0x0F, 0xE0, 0x70, 0x0F, 0x80, 0xFF, 0x0F, 0xFC, 0xF0, 0xE7,
  0x07, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x1D, 0xC1, 0xEF, 0x0F, 0x3F, 0xF0, 0xFF, 0x03, 0xF0,
  0xFF, 0x0F, 0xFC, 0xFF, 0xEE, 0x1E, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE0, 0xEF, 0xFE, 0xFF, 0xCF, 0xF0, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x00, 0x0F, 0x80, 0xFF, 0x0F, 0xFC, 0xF0, 0xE7,
  0x07, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x1D, 0xC1, 0xEF, 0x0E, 0x3F, 0xF0, 0xFF, 0x03, 0xFC,
  0x00, 0xF0, 0x03, 0x80, 0x08, 0xFF, 0x0F, 0xFC, 0xFF, 0xCE, 0x1E, 0xE0,
  0xEE, 0x0E, 0xE0, 0xEE, 0x0E, 0xE1, 0xEF, 0xFC, 0xFF, 0x8F, 0xF8, 0xE7,
  0x8E, 0x38, 0xE3, 0xCE, 0x1C, 0xE1, 0xEE, 0x0E, 0xE0, 0xF0, 0x1F, 0x83,
  0xFC, 0x7F, 0xE7, 0x0E, 0xF0, 0xFF, 0x0F, 0xF0, 0x07, 0xC0, 0x3F, 0x01,
  0xFC, 0x07, 0xE0, 0x1E, 0x00, 0xFE, 0x0F, 0xF0, 0xFF, 0x0F, 0x7F, 0xE3,
  0xFC, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0x70, 0x77, 0x0F, 0x7F, 0xF3, 0xFE, 0x0F,
  0x80, 0xF0, 0x1C, 0xE0, 0x39, 0xE0, 0xF3, 0xC1, 0xE3, 0x83, 0x87, 0x07,
  0x0F, 0x1E, 0x1E, 0x38, 0x1C, 0x70, 0x38, 0xE0, 0x7B, 0xC0, 0x77, 0x00,
  0xEE, 0x01, 0xDC, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x0E,
  0x00, 0xE1, 0xC1, 0xF8, 0x78, 0xFE, 0x1E, 0x3F, 0xC7, 0x8E, 0xF1, 0xE3,
  0x9C, 0xF8, 0xE7, 0x3E, 0x39, 0xCF, 0xDE, 0x73, 0xF7, 0x1C, 0xDD, 0xC3,
  0xF3, 0x70, 0xFC, 0xDC, 0x3F, 0x3F, 0x0F, 0x8F, 0xC3, 0xE3, 0xE0, 0xF8,
  0x78, 0x1E, 0x1E, 0x07, 0x87, 0x81, 0xC1, 0xE0, 0xF0, 0x7F, 0x87, 0x9E,
  0x3C, 0xF1, 0xC3, 0x9E, 0x1E, 0xE0, 0x7F, 0x03, 0xF0, 0x0F, 0x80, 0x78,
  0x03, 0xE0, 0x3F, 0x01, 0xFC, 0x1E, 0xE0, 0xE7, 0x8F, 0x1C, 0x70, 0xF7,
  0x87, 0xBC, 0x1E, 0xF0, 0x3D, 0xC1, 0xE7, 0x87, 0x8E, 0x1C, 0x3C, 0xF0,
  0x73, 0x81, 0xCE, 0x07, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x03, 0x80,
  0x78, 0x07, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x3C, 0x03, 0x80, 0x78, 0x07,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xEF, 0x7B, 0xDE, 0xF7,
  0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xFF, 0xF8, 0xF0, 0x1C,
  0x07, 0x01, 0xE0, 0x38, 0x0E, 0x03, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xE0,
  0x38, 0x0E, 0x03, 0xC0, 0x70, 0x1C, 0x07, 0x80, 0xE0, 0x38, 0x0F, 0x01,
  0xC0, 0xFF, 0xFE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39,
  0xCE, 0x73, 0x9F, 0xFF, 0xF8, 0x18, 0x3C, 0x3C, 0x3C, 0x7E, 0x66, 0x66,
  0xE7, 0xC3, 0xFF, 0xFF, 0xFF, 0xFC, 0xF1, 0xC3, 0x87, 0x1F, 0x1F, 0xE7,
  0xFF, 0xCF, 0x01, 0xC0, 0x71, 0xFD, 0xFF, 0xF1, 0xF8, 0x7E, 0x1F, 0xFF,
  0x7F, 0xCF, 0x70, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3D,
  0xE7, 0xFE, 0xFF, 0xDE, 0x3F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F,
  0x87, 0xF1, 0xFF, 0xFB, 0xFF, 0x73, 0xC0, 0x1F, 0x1F, 0xE7, 0xFF, 0xC7,
  0xE1, 0xF8, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x7F, 0x1D, 0xFF, 0x7F, 0x87,
  0xC0, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x73, 0xDD, 0xFF, 0x7F,
  0xFC, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xF1, 0xDF, 0xF7,
  0xFC, 0xF7, 0x1F, 0x07, 0xF1, 0xFF, 0x38, 0xEF, 0x1D, 0xC3, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1E, 0x03, 0xC2, 0x3F, 0xE3, 0xFC, 0x3E, 0x00, 0x1E, 0x7C,
  0xFB, 0xC7, 0x8F, 0x3F, 0xFF, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C,
  0x78, 0xF1, 0xE3, 0xC0, 0x3E, 0xEF, 0xFD, 0xFF, 0xF8, 0xFE, 0x1F, 0xC3,
  0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0xC7, 0xBF, 0xF7, 0xFE, 0x7B, 0xC0,
  0x78, 0x0E, 0x7F, 0xCF, 0xF0, 0x7C, 0x00, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x7B, 0xFF, 0xFF, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC,
  0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0x07, 0xF7, 0x00, 0x77,
  0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x00, 0xF3, 0xC6, 0x00, 0x01, 0xC7,
  0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0xFF, 0xFE,
  0xF0, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x77, 0x9E,
  0xF7, 0x9E, 0xE3, 0xFC, 0x7F, 0x0F, 0xE1, 0xFE, 0x3F, 0xC7, 0xBC, 0xF3,
  0x9E, 0x7B, 0xC7, 0x78, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xF7, 0x9E, 0x7F, 0xFF, 0xBF, 0xFF, 0xFE, 0x3C, 0xFF, 0x1C, 0x3F,
  0x8E, 0x1F, 0xC7, 0x0F, 0xE3, 0x87, 0xF1, 0xC3, 0xF8, 0xE1, 0xFC, 0x70,
  0xFE, 0x38, 0x7F, 0x1C, 0x3F, 0x8E, 0x1C, 0xE7, 0xBF, 0xFF, 0xFF, 0xC7,
  0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC,
  0x70, 0x1F, 0x07, 0xF1, 0xFF, 0x78, 0xFE, 0x1F, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x3F, 0xC7, 0xBF, 0xE3, 0xF8, 0x3E, 0x00, 0xE7, 0x9F, 0xFB,
  0xFF, 0x78, 0xFF, 0x1F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x3F, 0xC7,
  0xFF, 0xEF, 0xFD, 0xEF, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x00,
  0x3D, 0xDF, 0xF7, 0xFF, 0xC7, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8,
  0x7F, 0x1D, 0xFF, 0x7F, 0xCF, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0xF7, 0xFF, 0xFF, 0xCF, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E,
  0x00, 0x1E, 0x1F, 0xE7, 0xFB, 0x8F, 0xF0, 0x1E, 0x07, 0xE0, 0x7E, 0x07,
  0xC0, 0xFE, 0x1F, 0xFF, 0x7F, 0x87, 0xC0, 0x38, 0x70, 0xE7, 0xFF, 0xE7,
  0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0F, 0x8F, 0x1E, 0xF1, 0xFC,
  0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1D,
  0xFF, 0x7F, 0xCF, 0x70, 0x70, 0xEE, 0x3D, 0xC7, 0x3C, 0xE3, 0x9C, 0x73,
  0x8E, 0xE1, 0xDC, 0x1F, 0x83, 0xF0, 0x7C, 0x07, 0x80, 0xF0, 0x1C, 0x00,
  0x71, 0xC7, 0x71, 0xC7, 0x73, 0xCF, 0x73, 0xCE, 0x73, 0xEE, 0x3B, 0xEE,
  0x3F, 0x6E, 0x3F, 0x6C, 0x3F, 0x7C, 0x1E, 0x7C, 0x1E, 0x3C, 0x1E, 0x3C,
  0x1E, 0x38, 0x1C, 0x38, 0x71, 0xEF, 0x38, 0xE7, 0x1F, 0xC1, 0xF8, 0x3E,
  0x03, 0xC0, 0x78, 0x1F, 0x03, 0xF0, 0xFE, 0x1C, 0xE7, 0x9C, 0xE1, 0xC0,
  0xF0, 0xEE, 0x3D, 0xC7, 0x3C, 0xE3, 0x9C, 0x77, 0x8E, 0xE1, 0xFC, 0x1F,
  0x83, 0xE0, 0x7C, 0x07, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x7C, 0x0F,
  0x81, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x1E, 0x07, 0x03, 0x81, 0xE0,
  0x70, 0x3C, 0x0E, 0x07, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x0C, 0x73, 0x8E,
  0x38, 0xE3, 0x8E, 0x38, 0xE7, 0x3C, 0xE3, 0xC7, 0x1C, 0x38, 0xE3, 0x8E,
  0x38, 0xE3, 0x87, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x83, 0x8E,
  0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x0F, 0x1C, 0xF3, 0x9C, 0x71, 0xC7,
  0x1C, 0x71, 0xCE, 0x38, 0x80, 0x3C, 0x37, 0xE3, 0x7E, 0x76, 0x7F, 0xE3,
  0xEE, 0x1C,
};

const GFXglyph RobotoCondensed_SemiBold26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 3, 19, 7, 2, -19 },
  { 9, 6, 7, 8, 1, -20 },
  { 15, 12, 19, 14, 1, -19 },
  { 44, 11, 24, 13, 1, -22 },
  { 77, 14, 19, 17, 1, -19 },
  { 111, 13, 19, 15, 1, -19 },
  { 142, 2, 7, 4, 1, -20 },
  { 144, 6, 27, 8, 2, -21 },
  { 165, 6, 27, 8, 1, -21 },
  { 186, 11, 11, 12, 0, -19 },
  { 202, 11, 13, 13, 1, -15 },
  { 220, 5, 7, 6, 0, -3 },
  { 225, 6, 3, 9, 1, -10 },
  { 228, 4, 4, 7, 2, -4 },
  { 230, 8, 21, 9, 0, -19 },
  { 251, 11, 19, 13, 1, -19 },
  { 278, 7, 19, 13, 2, -19 },
  { 295, 11, 19, 13, 1, -19 },
  { 322, 11, 19, 13, 1, -19 },
  { 349, 11, 19, 13, 1, -19 },
  { 376, 11, 19, 13, 1, -19 },
  { 403, 11, 19, 13, 1, -19 },
  { 430, 11, 19, 13, 1, -19 },
  { 457, 11, 19, 13, 1, -19 },
  { 484, 11, 19, 13, 1, -19 },
  { 511, 4, 15, 7, 2, -15 },
  { 519, 4, 19, 6, 1, -15 },
  { 529, 9, 12, 12, 1, -14 },
  { 543, 9, 9, 13, 2, -13 },
  { 554, 9, 12, 12, 2, -14 },
  { 568, 9, 19, 11, 1, -19 },
  { 590, 18, 24, 20, 1, -18 },
  { 644, 15, 19, 15, 0, -19 },
  { 680, 11, 19, 15, 2, -19 },
  { 707, 13, 19, 15, 1, -19 },
  { 738, 11, 19, 15, 2, -19 },
  { 765, 10, 19, 13, 2, -19 },
  { 789, 10, 19, 12, 2, -19 },
  { 813, 13, 19, 15, 1, -19 },
  { 844, 12, 19, 16, 2, -19 },
  { 873, 3, 19, 7, 2, -19 },
  { 881, 10, 19, 13, 1, -19 },
  { 905, 12, 19, 14, 2, -19 },
  { 934, 10, 19, 12, 2, -19 },
  { 958, 16, 19, 20, 2, -19 },
  { 996, 12, 19, 16, 2, -19 },
  { 1025, 13, 19, 16, 1, -19 },
  { 1056, 12, 19, 15, 2, -19 },
  { 1085, 13, 22, 16, 1, -19 },
  { 1121, 12, 19, 14, 2, -19 },
  { 1150, 12, 19, 14, 1, -19 },
  { 1179, 12, 19, 14, 1, -19 },
  { 1208, 12, 19, 15, 1, -19 },
  { 1237, 15, 19, 15, 0, -19 },
  { 1273, 18, 19, 20, 1, -19 },
  { 1316, 13, 19, 15, 1, -19 },
  { 1347, 14, 19, 14, 0, -19 },
  { 1381, 12, 19, 14, 1, -19 },
  { 1410, 5, 25, 7, 1, -21 },
  { 1426, 10, 21, 10, 0, -19 },
  { 1453, 5, 25, 7, 0, -21 },
  { 1469, 8, 9, 10, 1, -19 },
  { 1478, 10, 3, 10, 0, 0 },
  { 1482, 6, 4, 8, 1, -20 },
  { 1485, 10, 14, 12, 1, -14 },
  { 1503, 11, 20, 13, 1, -20 },
  { 1531, 10, 14, 12, 1, -14 },
  { 1549, 10, 20, 13, 1, -20 },
  { 1574, 11, 14, 12, 1, -14 },
  { 1594, 7, 20, 8, 1, -20 },
  { 1612, 11, 19, 13, 1, -14 },
  { 1639, 10, 20, 13, 1, -20 },
  { 1664, 4, 20, 6, 1, -20 },
  { 1674, 6, 25, 6, -1, -20 },
  { 1693, 11, 20, 12, 1, -20 },
  { 1721, 3, 20, 6, 2, -20 },
  { 1729, 17, 14, 19, 1, -14 },
  { 1759, 10, 14, 13, 1, -14 },
  { 1777, 11, 14, 13, 1, -14 },
  { 1797, 11, 19, 13, 1, -14 },
  { 1824, 10, 19, 13, 1, -14 },
  { 1848, 7, 14, 8, 1, -14 },
  { 1861, 10, 14, 12, 1, -14 },
  { 1879, 7, 17, 8, 0, -17 },
  { 1894, 10, 14, 13, 1, -14 },
  { 1912, 11, 14, 12, 0, -14 },
  { 1932, 16, 14, 17, 0, -14 },
  { 1960, 11, 14, 12, 0, -14 },
  { 1980, 11, 19, 11, 0, -14 },
  { 2007, 10, 14, 12, 1, -14 },
  { 2025, 6, 25, 8, 1, -20 },
  { 2044, 2, 22, 7, 2, -19 },
  { 2050, 6, 25, 8, 1, -20 },
  { 2069, 12, 6, 15, 1, -11 },
};

const GFXfont RobotoCondensed_SemiBold26pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_SemiBold26pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_SemiBold26pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _ROBOTOCONDENSED_SEMIBOLD26PT7B_H_
