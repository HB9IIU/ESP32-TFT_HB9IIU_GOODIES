#ifndef _ROBOTOCONDENSED_SEMIBOLD40PT7B_H_
#define _ROBOTOCONDENSED_SEMIBOLD40PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-SemiBold.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_SemiBold40pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF7,
  0xBC, 0x00, 0x01, 0xDF, 0xFF, 0xFE, 0xE0, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E,
  0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xC0, 0x03, 0xC7, 0x00, 0xE3, 0xC0,
  0x38, 0xE0, 0x0E, 0x38, 0x03, 0x8E, 0x00, 0xE3, 0x80, 0x78, 0xE0, 0x1E,
  0x78, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFC, 0x1C, 0x70, 0x07, 0x1C,
  0x03, 0xC7, 0x00, 0xE3, 0xC0, 0x38, 0xE0, 0x0E, 0x38, 0x3F, 0xFF, 0xEF,
  0xFF, 0xFB, 0xFF, 0xFE, 0x1E, 0x78, 0x07, 0x1E, 0x01, 0xC7, 0x00, 0x71,
  0xC0, 0x1C, 0x70, 0x07, 0x1C, 0x03, 0xC7, 0x00, 0xE3, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x07, 0xE0, 0x0F, 0xF8, 0x1F, 0xFC,
  0x3F, 0xFE, 0x7E, 0x7E, 0x7C, 0x3F, 0x7C, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F,
  0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x07, 0xFC,
  0x01, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xFC, 0x1F, 0x7E, 0x7F, 0x7F, 0xFE, 0x3F, 0xFC, 0x1F, 0xF8,
  0x07, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x1F, 0x00,
  0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x3C, 0xF0, 0x40, 0xE1, 0xC1, 0xC3,
  0x87, 0x0E, 0x0E, 0x1C, 0x78, 0x38, 0x71, 0xC0, 0xE1, 0xCF, 0x03, 0xCF,
  0x38, 0x07, 0xFD, 0xC0, 0x1F, 0xE7, 0x00, 0x1F, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x3C, 0xF8, 0x00, 0xE7, 0xF0, 0x07, 0xBF, 0xE0,
  0x1C, 0xE3, 0x80, 0xE7, 0x8F, 0x03, 0x9E, 0x3C, 0x1C, 0x78, 0xF0, 0x71,
  0xE3, 0xC3, 0x87, 0x8F, 0x0E, 0x0E, 0x38, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0x00, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0xFF, 0x00, 0x1F, 0xF8, 0x03, 0xFF,
  0xC0, 0x3E, 0x7C, 0x03, 0xC3, 0xC0, 0x3C, 0x3C, 0x03, 0xC3, 0xC0, 0x3C,
  0x3C, 0x03, 0xE7, 0xC0, 0x3F, 0xF8, 0x01, 0xFF, 0x00, 0x0F, 0xE0, 0x00,
  0xFC, 0x00, 0x3F, 0xC3, 0xE7, 0xFE, 0x3E, 0x7F, 0xF3, 0xEF, 0x9F, 0xBC,
  0xF8, 0xFB, 0xCF, 0x8F, 0xFC, 0xF8, 0x7F, 0xCF, 0x83, 0xF8, 0xF8, 0x1F,
  0x8F, 0xC7, 0xF8, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0xFE,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x80, 0x60, 0x3C, 0x1E, 0x0F,
  0x03, 0xC1, 0xE0, 0x78, 0x3C, 0x0F, 0x03, 0xC1, 0xF0, 0x78, 0x1E, 0x07,
  0x81, 0xE0, 0x78, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1F, 0x03, 0xC0, 0xF0, 0x3C, 0x07,
  0x81, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x3C, 0x06, 0x00, 0x80, 0x40, 0x18,
  0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x03, 0xE0, 0x78, 0x1E, 0x03, 0xC0, 0xF0,
  0x3E, 0x0F, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x0F, 0x83, 0xE0,
  0xF0, 0x3C, 0x1F, 0x07, 0x81, 0xE0, 0xF0, 0x78, 0x1E, 0x0F, 0x01, 0x80,
  0x40, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1C,
  0x07, 0x8E, 0x3B, 0xF7, 0xFD, 0xFF, 0xFE, 0x3F, 0xFE, 0x01, 0xF0, 0x01,
  0xF8, 0x01, 0xFE, 0x01, 0xE7, 0x81, 0xF3, 0xC0, 0xF0, 0xF0, 0x70, 0x38,
  0x08, 0x10, 0x00, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x3C, 0xF3, 0xCF, 0x3C, 0xF7, 0xDE, 0x7B, 0xCF, 0x08, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x23, 0xEF, 0xBE, 0xF9, 0xC0, 0x00, 0x78, 0x03, 0x80, 0x3C,
  0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x00, 0x07, 0xE0, 0x1F, 0xF8,
  0x3F, 0xFC, 0x3F, 0xFC, 0x7E, 0x7E, 0x7C, 0x3E, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0x7C, 0x1F, 0x7C, 0x3E, 0x7E, 0x7E, 0x3F, 0xFC, 0x3F, 0xFC,
  0x1F, 0xF8, 0x07, 0xE0, 0x00, 0x60, 0x7C, 0x3F, 0x9F, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFE, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x03, 0xF0, 0x03, 0xFF, 0x01,
  0xFF, 0xE0, 0xFF, 0xFC, 0x7F, 0x3F, 0x1F, 0x07, 0xE7, 0xC1, 0xF9, 0xF0,
  0x3E, 0xFC, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFF, 0x03, 0xF0,
  0x07, 0xFE, 0x07, 0xFF, 0x87, 0xFF, 0xE7, 0xF3, 0xF3, 0xE0, 0xF9, 0xF0,
  0x7E, 0xF8, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0,
  0x3F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xE0, 0x01, 0xFF, 0x80, 0xFB, 0xE0, 0x7D, 0xF0, 0x7E, 0xFE,
  0x7E, 0x3F, 0xFF, 0x1F, 0xFF, 0x07, 0xFF, 0x00, 0xFE, 0x00, 0x00, 0x3E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x80,
  0x1F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xEF, 0x80, 0x7B, 0xE0, 0x3C,
  0xF8, 0x0F, 0x3E, 0x07, 0x8F, 0x83, 0xE3, 0xE0, 0xF0, 0xF8, 0x7C, 0x3E,
  0x1E, 0x0F, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x3F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x3C, 0x00, 0x3C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7D, 0xF0, 0x7F, 0xFC, 0x7F,
  0xFC, 0x7F, 0xFE, 0x7C, 0x7F, 0x08, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x3F, 0x7E,
  0x7E, 0x7F, 0xFE, 0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xE0, 0x00, 0x78, 0x01,
  0xFC, 0x01, 0xFE, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0xF8, 0x1E, 0xFF, 0x1F, 0xFF, 0xCF, 0xFF,
  0xE7, 0xF3, 0xFB, 0xF0, 0x7D, 0xF0, 0x3E, 0xF8, 0x1F, 0x7C, 0x07, 0xFE,
  0x03, 0xFF, 0x01, 0xFF, 0x81, 0xF3, 0xE0, 0xF9, 0xF0, 0x7C, 0xFC, 0xFC,
  0x3F, 0xFE, 0x0F, 0xFE, 0x03, 0xFE, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x1F,
  0xF8, 0x3F, 0xFC, 0x7F, 0xFE, 0x7E, 0x7E, 0x7C, 0x3E, 0x7C, 0x3F, 0xFC,
  0x1F, 0x7C, 0x1F, 0x7C, 0x3E, 0x7C, 0x3E, 0x7E, 0x7E, 0x3F, 0xFC, 0x1F,
  0xF8, 0x1F, 0xF8, 0x3F, 0xFC, 0x7C, 0x3E, 0xFC, 0x3F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x3F, 0x7E, 0x7F, 0x7F, 0xFE, 0x3F,
  0xFC, 0x1F, 0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x1F, 0xF0, 0x3F, 0xF8, 0x3F,
  0xFC, 0x7E, 0x7E, 0x7C, 0x3E, 0xF8, 0x3E, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x3F, 0x7C, 0x7F, 0x7F,
  0xFF, 0x3F, 0xFF, 0x1F, 0xDF, 0x0F, 0x9E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xFC, 0x03, 0xF8, 0x1F, 0xF0, 0x1F, 0xE0, 0x1F, 0xC0, 0x1F,
  0x00, 0x23, 0xEF, 0xBE, 0xF9, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x23, 0xEF, 0xBE, 0xF9, 0xC0, 0x18, 0x7D, 0xFB, 0xF7, 0xE7, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0xF9, 0xF3,
  0xE7, 0xCF, 0x1E, 0x3C, 0xF1, 0xE7, 0x82, 0x00, 0x00, 0x04, 0x00, 0x70,
  0x03, 0xC0, 0x3F, 0x03, 0xFC, 0x3F, 0xF3, 0xFF, 0x3F, 0xE0, 0xFE, 0x03,
  0xE0, 0x0F, 0xE0, 0x3F, 0xE0, 0x3F, 0xF0, 0x3F, 0xF0, 0x3F, 0xC0, 0x3F,
  0x00, 0x3C, 0x00, 0x70, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xC0, 0x03, 0xE0, 0x07, 0xF0, 0x0F, 0xF8,
  0x0F, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0xFE, 0x00, 0x7C, 0x03, 0xF8,
  0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x3F, 0xE0, 0x7F, 0x00, 0xF8, 0x01, 0xC0,
  0x02, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0xF0, 0xFF, 0xF3, 0xFF, 0xE7, 0xEF,
  0xFF, 0x87, 0xFE, 0x0F, 0xFC, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x1C, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x01, 0xF0, 0x3F, 0x00, 0x78, 0x01,
  0xF0, 0x1E, 0x00, 0x0E, 0x07, 0x80, 0x01, 0xE0, 0xE0, 0x00, 0x1C, 0x3C,
  0x0F, 0x81, 0xC7, 0x03, 0xFC, 0x39, 0xE0, 0xFF, 0xC7, 0x38, 0x3E, 0x70,
  0xF7, 0x07, 0x0E, 0x0F, 0xE1, 0xE1, 0xC1, 0xFC, 0x3C, 0x38, 0x3F, 0x8F,
  0x07, 0x07, 0xE1, 0xE0, 0xE0, 0xFC, 0x3C, 0x3C, 0x1F, 0x87, 0x87, 0x83,
  0xF0, 0xF0, 0xF0, 0x7E, 0x1E, 0x1E, 0x1F, 0xC3, 0xC3, 0xC3, 0xB8, 0x78,
  0x78, 0x77, 0x0F, 0x1F, 0x1E, 0xF1, 0xF7, 0xE3, 0x9E, 0x1F, 0xFF, 0xF3,
  0xC3, 0xFB, 0xFC, 0x38, 0x1C, 0x1E, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xFC, 0x3C, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x03,
  0xDF, 0x00, 0x1F, 0x3C, 0x00, 0x7C, 0xF8, 0x01, 0xF3, 0xE0, 0x0F, 0x8F,
  0x80, 0x3E, 0x1F, 0x00, 0xF8, 0x7C, 0x03, 0xE1, 0xF0, 0x1F, 0x07, 0xE0,
  0x7C, 0x0F, 0x81, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xC7, 0xE0, 0x1F, 0x1F, 0x00, 0x7E, 0x7C, 0x00, 0xFB, 0xF0, 0x03,
  0xEF, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0x8F, 0xFF,
  0xF3, 0xFF, 0xFE, 0xFC, 0x3F, 0xBF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F,
  0xFC, 0x07, 0xFF, 0x03, 0xFF, 0xC0, 0xFB, 0xF0, 0x7E, 0xFF, 0xFF, 0x3F,
  0xFF, 0x8F, 0xFF, 0xF3, 0xFF, 0xFE, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xC0,
  0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xE3, 0xFF, 0xE0, 0x03, 0xF8, 0x01,
  0xFF, 0xC0, 0x7F, 0xFE, 0x1F, 0xFF, 0xC3, 0xF9, 0xFC, 0xFC, 0x0F, 0xDF,
  0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x3E, 0xF8,
  0x07, 0xDF, 0x81, 0xFB, 0xFC, 0xFE, 0x3F, 0xFF, 0x83, 0xFF, 0xF0, 0x3F,
  0xF8, 0x01, 0xFC, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x7F,
  0xFF, 0x8F, 0xC7, 0xF9, 0xF8, 0x1F, 0x3F, 0x03, 0xF7, 0xE0, 0x3E, 0xFC,
  0x07, 0xDF, 0x80, 0xFB, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8,
  0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0,
  0x1F, 0x7E, 0x03, 0xEF, 0xC0, 0x7D, 0xF8, 0x1F, 0xBF, 0x03, 0xE7, 0xE3,
  0xFC, 0xFF, 0xFF, 0x1F, 0xFF, 0xC3, 0xFF, 0xF0, 0x7F, 0xF0, 0x00, 0xFF,
  0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xFF, 0xE7, 0xFF, 0xF3, 0xFF, 0xF9, 0xFF, 0xFC, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x03, 0xFC, 0x01, 0xFF, 0xE0,
  0x7F, 0xFE, 0x1F, 0xFF, 0xE3, 0xF9, 0xFC, 0xFC, 0x0F, 0xDF, 0x00, 0xFF,
  0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF,
  0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3E, 0xF8, 0x07, 0xDF,
  0x80, 0xF9, 0xFE, 0x7F, 0x3F, 0xFF, 0xE3, 0xFF, 0xF8, 0x3F, 0xFE, 0x00,
  0xFE, 0x00, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F,
  0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01,
  0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC,
  0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF,
  0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xFC, 0x1F, 0xFC, 0x3F, 0x7F, 0x7E, 0x7F, 0xFE, 0x3F, 0xFC, 0x1F, 0xF8,
  0x07, 0xE0, 0xFC, 0x07, 0xFF, 0xC0, 0x7E, 0xFC, 0x0F, 0xCF, 0xC1, 0xFC,
  0xFC, 0x1F, 0x8F, 0xC3, 0xF0, 0xFC, 0x7E, 0x0F, 0xC7, 0xE0, 0xFC, 0xFC,
  0x0F, 0xCF, 0x80, 0xFD, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF,
  0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xFC, 0x0F, 0xE7, 0xC0, 0xFE,
  0x7E, 0x0F, 0xC3, 0xE0, 0xFC, 0x3F, 0x0F, 0xC1, 0xF8, 0xFC, 0x1F, 0x8F,
  0xC0, 0xFC, 0xFC, 0x0F, 0xCF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0x3F,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xBC, 0x0F, 0x7F, 0xEF, 0x83, 0xDF, 0xFB,
  0xE1, 0xF7, 0xFE, 0x78, 0x79, 0xFF, 0x9E, 0x1E, 0x7F, 0xE7, 0xC7, 0x9F,
  0xFC, 0xF3, 0xE7, 0xFF, 0x3C, 0xF1, 0xFF, 0xCF, 0xBC, 0x7F, 0xF3, 0xFF,
  0x1F, 0xFC, 0x7F, 0x87, 0xFF, 0x1F, 0xE1, 0xFF, 0xC7, 0xF8, 0x7F, 0xF0,
  0xFC, 0x1F, 0xFC, 0x3F, 0x07, 0xFF, 0x0F, 0xC1, 0xFF, 0xC1, 0xF0, 0x7F,
  0xF0, 0x78, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xFF, 0xE0,
  0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x81, 0xFF, 0xF8, 0x1F, 0xFF,
  0xC1, 0xFF, 0xFC, 0x1F, 0xFB, 0xE1, 0xFF, 0xBE, 0x1F, 0xF9, 0xF1, 0xFF,
  0x9F, 0x1F, 0xF8, 0xF9, 0xFF, 0x87, 0x9F, 0xF8, 0x7D, 0xFF, 0x83, 0xDF,
  0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F,
  0xFF, 0x80, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80,
  0x1F, 0x01, 0xF8, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F,
  0xDF, 0xC7, 0xE0, 0x7E, 0x7C, 0x03, 0xEF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xFC, 0x03, 0xF7, 0xC0, 0x3E, 0x7E, 0x07, 0xE3, 0xFD,
  0xFE, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x1F, 0xC0, 0xFF,
  0xF8, 0x1F, 0xFF, 0xC3, 0xFF, 0xFE, 0x7F, 0xFF, 0xCF, 0xC1, 0xFD, 0xF8,
  0x0F, 0xBF, 0x01, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0,
  0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xBF, 0xFF, 0xF7, 0xFF,
  0xFC, 0xFF, 0xFF, 0x1F, 0xFF, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xF0, 0x1F,
  0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xC7, 0xE0, 0x7E, 0x7C, 0x03, 0xEF,
  0xC0, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x03, 0xF7, 0xC0,
  0x3E, 0x7E, 0x07, 0xE3, 0xF9, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F,
  0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0,
  0x00, 0x1E, 0x00, 0x00, 0x80, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC,
  0x7F, 0xFF, 0xCF, 0xC3, 0xFD, 0xF8, 0x1F, 0xBF, 0x01, 0xF7, 0xE0, 0x3E,
  0xFC, 0x07, 0xDF, 0x80, 0xFB, 0xF0, 0x1F, 0x7E, 0x07, 0xEF, 0xC3, 0xF9,
  0xFF, 0xFF, 0x3F, 0xFF, 0xC7, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0x8F, 0xC3,
  0xF0, 0xF8, 0x7E, 0x1F, 0x8F, 0xC1, 0xF1, 0xF8, 0x3F, 0x3F, 0x07, 0xE7,
  0xE0, 0x7C, 0xFC, 0x0F, 0xDF, 0x80, 0xFB, 0xF0, 0x1F, 0xFE, 0x03, 0xF0,
  0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC3, 0xF9, 0xFC,
  0xFC, 0x1F, 0x9F, 0x01, 0xF3, 0xE0, 0x3F, 0x7C, 0x07, 0xEF, 0xC0, 0x00,
  0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xC0,
  0x07, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0xFE, 0x03, 0xF7,
  0xC0, 0x3E, 0xF8, 0x0F, 0xDF, 0x81, 0xFB, 0xFC, 0xFE, 0x3F, 0xFF, 0xC3,
  0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF,
  0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF,
  0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE,
  0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC,
  0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x0F, 0x9F, 0x01, 0xF3, 0xFD, 0xFE, 0x3F,
  0xFF, 0x87, 0xFF, 0xE0, 0x3F, 0xF8, 0x01, 0xFC, 0x00, 0xF8, 0x00, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x7E, 0xF8, 0x03, 0xE7, 0xC0, 0x1F, 0x3F, 0x01,
  0xF9, 0xF8, 0x0F, 0xC7, 0xC0, 0x7C, 0x3E, 0x03, 0xE1, 0xF8, 0x3F, 0x07,
  0xC1, 0xF0, 0x3E, 0x0F, 0x81, 0xF0, 0x7C, 0x07, 0xC7, 0xC0, 0x3E, 0x3E,
  0x01, 0xF1, 0xF0, 0x0F, 0x8F, 0x80, 0x3E, 0xF8, 0x01, 0xF7, 0xC0, 0x0F,
  0xBE, 0x00, 0x3D, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xF0, 0x00, 0xF8,
  0x0F, 0x01, 0xFF, 0x80, 0xF8, 0x1F, 0xFC, 0x1F, 0x81, 0xF7, 0xC1, 0xF8,
  0x3F, 0x7C, 0x1F, 0x83, 0xE7, 0xC1, 0xF8, 0x3E, 0x7C, 0x1F, 0xC3, 0xE7,
  0xC3, 0xFC, 0x3E, 0x3E, 0x3F, 0xC3, 0xE3, 0xE3, 0xFC, 0x3C, 0x3E, 0x3F,
  0xC7, 0xC3, 0xE3, 0xFE, 0x7C, 0x3E, 0x7D, 0xE7, 0xC1, 0xE7, 0x9E, 0x7C,
  0x1F, 0x79, 0xE7, 0xC1, 0xF7, 0x9E, 0x78, 0x1F, 0x79, 0xFF, 0x81, 0xFF,
  0x8F, 0xF8, 0x1F, 0xF0, 0xFF, 0x80, 0xFF, 0x0F, 0xF8, 0x0F, 0xF0, 0xFF,
  0x00, 0xFF, 0x07, 0xF0, 0x0F, 0xF0, 0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x07,
  0xE0, 0x7F, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x3E, 0x00, 0x7C, 0x03,
  0xE0, 0xFC, 0x03, 0xF3, 0xF0, 0x1F, 0x9F, 0x81, 0xF8, 0x7E, 0x0F, 0xC3,
  0xF0, 0x7C, 0x0F, 0x87, 0xE0, 0x7E, 0x3E, 0x01, 0xF3, 0xF0, 0x0F, 0xDF,
  0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0xC0, 0x1F, 0xBE, 0x00, 0xF9, 0xF8, 0x0F, 0xC7, 0xC0, 0x7C,
  0x3F, 0x07, 0xE1, 0xF8, 0x3E, 0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0x00, 0xFD,
  0xF8, 0x07, 0xE0, 0x7C, 0x01, 0xFB, 0xF0, 0x0F, 0xDF, 0x80, 0xFC, 0x7C,
  0x07, 0xE3, 0xF0, 0x3E, 0x0F, 0x83, 0xF0, 0x7C, 0x1F, 0x01, 0xF0, 0xF8,
  0x0F, 0x8F, 0x80, 0x3E, 0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0xBE, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00,
  0x7C, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0xFF, 0xFF, 0xFF,
  0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E,
  0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF,
  0x9F, 0x3E, 0x7C, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x81, 0xFC, 0x0F, 0xE0, 0x77, 0x87, 0xBC, 0x3C, 0xF1, 0xC7,
  0x9E, 0x3C, 0xF0, 0xF7, 0x87, 0xF8, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0x83, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x07,
  0xE0, 0x3F, 0xF0, 0xFF, 0xF3, 0xFF, 0xEF, 0xC7, 0xDF, 0x07, 0xFE, 0x0F,
  0x80, 0x1F, 0x0F, 0xFE, 0x7F, 0xFD, 0xFF, 0xFF, 0xE1, 0xFF, 0x83, 0xFF,
  0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x7F, 0xFF, 0xFD, 0xFF, 0xFB, 0xFD,
  0xF1, 0xF3, 0xE0, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF9, 0xF0, 0xFB,
  0xFC, 0xFF, 0xFE, 0xFF, 0xFE, 0xFE, 0x7F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFE, 0x3F, 0xFF, 0xFE, 0xFF, 0xFE, 0xFB,
  0xFC, 0xF9, 0xF0, 0x03, 0xF0, 0x0F, 0xFC, 0x1F, 0xFE, 0x3F, 0xFE, 0x7E,
  0x3F, 0x7C, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0x7C, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0x7E,
  0x3F, 0x3F, 0xFE, 0x1F, 0xFC, 0x0F, 0xF8, 0x03, 0xF0, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x83, 0xE7, 0xC7, 0xFB, 0xE7, 0xFF, 0xF3, 0xFF,
  0xFB, 0xF9, 0xFD, 0xF0, 0x7E, 0xF8, 0x1F, 0x7C, 0x0F, 0xFC, 0x07, 0xFE,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7D, 0xF0, 0x3E, 0xF8, 0x1F,
  0x7C, 0x1F, 0xBF, 0x9F, 0xCF, 0xFF, 0xE7, 0xFF, 0xF1, 0xFE, 0xF8, 0x3E,
  0x7C, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFE, 0x7E, 0x7E, 0xF8,
  0x3E, 0xF8, 0x1F, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x04, 0x7E, 0x1E, 0x7F,
  0xFE, 0x3F, 0xFE, 0x1F, 0xFC, 0x07, 0xF0, 0x03, 0xF0, 0x7F, 0x0F, 0xF1,
  0xFF, 0x1F, 0x81, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x0F, 0xFE, 0xFF, 0xEF,
  0xFE, 0xFF, 0xE1, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x07, 0xCF, 0x8F, 0xFF, 0xCF, 0xFF, 0xE7, 0xFF,
  0xF7, 0xF3, 0xFB, 0xE0, 0x7D, 0xF0, 0x3E, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE,
  0x07, 0xFF, 0x03, 0xFF, 0x81, 0xF7, 0xC0, 0xFB, 0xE0, 0x7D, 0xF0, 0x3E,
  0xF8, 0x1F, 0x7F, 0x3F, 0x9F, 0xFF, 0xCF, 0xFF, 0xE3, 0xFD, 0xF0, 0x7C,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x20, 0x3F, 0x1C, 0x3F, 0x1F, 0xFF, 0x8F,
  0xFF, 0x83, 0xFF, 0x80, 0x7F, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF9, 0xF0, 0xFB, 0xFC, 0xFF, 0xFC, 0xFF, 0xFE, 0xFE, 0x7E, 0xF8, 0x3E,
  0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F,
  0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F,
  0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0x7B, 0xFF, 0xFE, 0x78, 0x00, 0x00,
  0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE,
  0xFB, 0xEF, 0xBE, 0xF8, 0x0F, 0x0F, 0x87, 0xE3, 0xE0, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F,
  0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1,
  0xF0, 0xF8, 0x7C, 0x3E, 0x3F, 0x7F, 0xBF, 0x9F, 0xCF, 0x80, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x1F, 0xBE, 0x1F, 0x9F, 0x0F, 0x8F,
  0x8F, 0xC7, 0xCF, 0xC3, 0xE7, 0xC1, 0xF7, 0xE0, 0xFF, 0xE0, 0x7F, 0xE0,
  0x3F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xF7, 0xE1, 0xF1,
  0xF0, 0xF8, 0xFC, 0x7C, 0x3E, 0x3E, 0x1F, 0x9F, 0x07, 0xCF, 0x83, 0xF7,
  0xC0, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF9, 0xF0, 0x7C,
  0x3E, 0xFF, 0x3F, 0xCF, 0xFF, 0xDF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFE, 0x7F,
  0x9F, 0xBF, 0x0F, 0xC3, 0xEF, 0x83, 0xE0, 0xFF, 0xE0, 0xF8, 0x1F, 0xF8,
  0x3E, 0x07, 0xFE, 0x0F, 0x81, 0xFF, 0x83, 0xE0, 0x7F, 0xE0, 0xF8, 0x1F,
  0xF8, 0x3E, 0x07, 0xFE, 0x0F, 0x81, 0xFF, 0x83, 0xE0, 0x7F, 0xE0, 0xF8,
  0x1F, 0xF8, 0x3E, 0x07, 0xFE, 0x0F, 0x81, 0xFF, 0x83, 0xE0, 0x7F, 0xE0,
  0xF8, 0x1F, 0xF8, 0x3E, 0x07, 0xC0, 0xF9, 0xF0, 0xFB, 0xFC, 0xFF, 0xFC,
  0xFF, 0xFE, 0xFE, 0x7E, 0xFC, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3F,
  0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F,
  0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F,
  0x03, 0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x87, 0xFF, 0xE3, 0xF3, 0xF3, 0xF0,
  0xFD, 0xF0, 0x3E, 0xF8, 0x1F, 0x7C, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF,
  0x81, 0xF7, 0xC0, 0xFB, 0xE0, 0x7D, 0xF0, 0x3E, 0xF8, 0x3F, 0x3F, 0x3F,
  0x1F, 0xFF, 0x87, 0xFF, 0x81, 0xFF, 0x80, 0x3F, 0x00, 0xF9, 0xF0, 0xFB,
  0xFC, 0xFF, 0xFE, 0xFF, 0xFE, 0xFE, 0x7F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFE, 0x7F, 0xFF, 0xFE, 0xFF, 0xFE, 0xFB,
  0xFC, 0xF9, 0xF0, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x07, 0xCF, 0x8F, 0xF7, 0xCF,
  0xFF, 0xE7, 0xFF, 0xF7, 0xE3, 0xFB, 0xE0, 0xFD, 0xF0, 0x3E, 0xF8, 0x1F,
  0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFB, 0xE0,
  0x7D, 0xF0, 0x3E, 0xF8, 0x3F, 0x7E, 0x3F, 0x9F, 0xFF, 0xCF, 0xFF, 0xE3,
  0xFD, 0xF0, 0x7C, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0xF9, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xC3, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x00,
  0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFE, 0x7C, 0x3E, 0x7C, 0x3E,
  0x7C, 0x1F, 0x7E, 0x00, 0x7F, 0x80, 0x3F, 0xF0, 0x1F, 0xF8, 0x07, 0xFC,
  0x00, 0xFE, 0x00, 0x3E, 0xF8, 0x1F, 0xF8, 0x1F, 0x7C, 0x3E, 0x7F, 0xFE,
  0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xF0, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3F,
  0x07, 0xF8, 0x7F, 0x0F, 0xE0, 0x7C, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F,
  0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F,
  0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F,
  0xF8, 0x3F, 0xFC, 0x7F, 0x7F, 0xFF, 0x7F, 0xFF, 0x3F, 0xDF, 0x1F, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E,
  0x7C, 0x7C, 0x3C, 0x7C, 0x3E, 0x7C, 0x3E, 0x78, 0x1E, 0x78, 0x1E, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0xF8, 0x3C, 0x1F, 0xF8, 0x3C, 0x1E,
  0xF8, 0x7C, 0x3E, 0x78, 0x7C, 0x3E, 0x78, 0x7E, 0x3E, 0x7C, 0x7E, 0x3E,
  0x7C, 0xFE, 0x3C, 0x7C, 0xFE, 0x3C, 0x3C, 0xFF, 0x7C, 0x3C, 0xEF, 0x7C,
  0x3D, 0xEF, 0x78, 0x3F, 0xE7, 0x78, 0x3F, 0xE7, 0xF8, 0x1F, 0xC7, 0xF8,
  0x1F, 0xC7, 0xF8, 0x1F, 0xC3, 0xF0, 0x1F, 0xC3, 0xF0, 0x0F, 0x83, 0xF0,
  0x0F, 0x83, 0xF0, 0x0F, 0x81, 0xE0, 0x0F, 0x81, 0xE0, 0xFC, 0x1F, 0x7C,
  0x3E, 0x7E, 0x3E, 0x3E, 0x7C, 0x3F, 0x7C, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F,
  0xF0, 0x0F, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x3E, 0x7C, 0x3E, 0x7C, 0x7C, 0x3E, 0xFC,
  0x3F, 0xF8, 0x1F, 0x7C, 0x0F, 0xBE, 0x0F, 0xDF, 0x07, 0xCF, 0xC3, 0xE3,
  0xE1, 0xF1, 0xF1, 0xF8, 0xF8, 0xF8, 0x3E, 0x7C, 0x1F, 0x3E, 0x0F, 0x9E,
  0x03, 0xDF, 0x01, 0xEF, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x0F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xE0, 0x03, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xFC,
  0x03, 0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x80, 0xF0, 0x7C, 0x3E, 0x0F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xE0, 0x78, 0x3E, 0x3F, 0x0F, 0x83, 0xE0, 0xFC, 0x0F, 0x81, 0xE0, 0x78,
  0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x03,
  0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x40,
  0x3C, 0x0F, 0x81, 0xF0, 0x3C, 0x0F, 0x03, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0x78, 0x1F, 0x03, 0xF0, 0x7C, 0x1F,
  0x0F, 0xC7, 0xC1, 0xE0, 0x78, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F,
  0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x07, 0xC3, 0xE0, 0xF0, 0x10, 0x00, 0x0F,
  0x00, 0x07, 0xF0, 0x3D, 0xFF, 0x07, 0x3F, 0xF1, 0xE7, 0xBF, 0x7D, 0xE1,
  0xFF, 0xBC, 0x1F, 0xE7, 0x81, 0xF8, 0x00, 0x1E, 0x00,
};

const GFXglyph RobotoCondensed_SemiBold40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 5, 28, 10, 3, -28 },
  { 19, 9, 10, 13, 2, -30 },
  { 31, 18, 28, 21, 2, -28 },
  { 94, 16, 36, 20, 2, -32 },
  { 166, 22, 28, 25, 2, -28 },
  { 243, 20, 28, 23, 2, -28 },
  { 313, 4, 10, 7, 1, -30 },
  { 318, 10, 41, 13, 2, -32 },
  { 370, 10, 41, 13, 1, -32 },
  { 422, 17, 17, 18, 1, -28 },
  { 459, 17, 21, 19, 1, -24 },
  { 504, 6, 12, 9, 1, -5 },
  { 513, 9, 4, 13, 2, -14 },
  { 518, 6, 6, 11, 3, -6 },
  { 523, 13, 30, 14, 0, -28 },
  { 572, 16, 28, 20, 2, -28 },
  { 628, 11, 28, 20, 3, -28 },
  { 667, 18, 28, 20, 1, -28 },
  { 730, 17, 28, 20, 1, -28 },
  { 790, 18, 28, 20, 1, -28 },
  { 853, 16, 28, 20, 2, -28 },
  { 909, 17, 28, 20, 2, -28 },
  { 969, 17, 28, 20, 1, -28 },
  { 1029, 16, 28, 20, 2, -28 },
  { 1085, 16, 28, 20, 2, -28 },
  { 1141, 6, 22, 11, 3, -22 },
  { 1158, 7, 29, 10, 1, -22 },
  { 1184, 14, 19, 18, 1, -22 },
  { 1218, 14, 12, 20, 3, -19 },
  { 1239, 15, 19, 18, 2, -22 },
  { 1275, 15, 28, 18, 1, -28 },
  { 1328, 27, 37, 31, 2, -28 },
  { 1453, 22, 28, 24, 1, -28 },
  { 1530, 18, 28, 22, 2, -28 },
  { 1593, 19, 28, 23, 2, -28 },
  { 1660, 19, 28, 23, 2, -28 },
  { 1727, 17, 28, 20, 2, -28 },
  { 1787, 16, 28, 19, 2, -28 },
  { 1843, 19, 28, 23, 2, -28 },
  { 1910, 20, 28, 25, 2, -28 },
  { 1980, 5, 28, 11, 3, -28 },
  { 1998, 16, 28, 20, 1, -28 },
  { 2054, 20, 28, 22, 2, -28 },
  { 2124, 16, 28, 19, 2, -28 },
  { 2180, 26, 28, 30, 2, -28 },
  { 2271, 20, 28, 25, 2, -28 },
  { 2341, 20, 28, 24, 2, -28 },
  { 2411, 19, 28, 23, 2, -28 },
  { 2478, 20, 33, 24, 2, -28 },
  { 2561, 19, 28, 22, 2, -28 },
  { 2628, 19, 28, 21, 1, -28 },
  { 2695, 19, 28, 22, 1, -28 },
  { 2762, 19, 28, 23, 2, -28 },
  { 2829, 21, 28, 23, 1, -28 },
  { 2903, 28, 28, 30, 1, -28 },
  { 3001, 21, 28, 22, 1, -28 },
  { 3075, 21, 28, 22, 0, -28 },
  { 3149, 18, 28, 21, 2, -28 },
  { 3212, 8, 40, 10, 2, -33 },
  { 3252, 15, 30, 15, 0, -28 },
  { 3309, 7, 40, 10, 1, -33 },
  { 3344, 13, 14, 15, 1, -28 },
  { 3367, 16, 4, 16, 0, 0 },
  { 3375, 10, 6, 13, 1, -30 },
  { 3383, 15, 21, 19, 2, -21 },
  { 3423, 16, 30, 20, 2, -30 },
  { 3483, 16, 21, 18, 1, -21 },
  { 3525, 17, 30, 20, 1, -30 },
  { 3589, 16, 21, 19, 2, -21 },
  { 3631, 12, 30, 13, 1, -30 },
  { 3676, 17, 29, 20, 1, -21 },
  { 3738, 16, 30, 20, 2, -30 },
  { 3798, 6, 29, 10, 2, -29 },
  { 3820, 9, 37, 10, -1, -29 },
  { 3862, 17, 30, 19, 2, -30 },
  { 3926, 5, 30, 10, 2, -30 },
  { 3945, 26, 21, 30, 2, -21 },
  { 4014, 16, 21, 20, 2, -21 },
  { 4056, 17, 21, 20, 1, -21 },
  { 4101, 16, 29, 20, 2, -21 },
  { 4159, 17, 29, 20, 1, -21 },
  { 4221, 10, 21, 13, 2, -21 },
  { 4248, 16, 21, 18, 1, -21 },
  { 4290, 11, 26, 12, 0, -26 },
  { 4326, 16, 21, 20, 2, -21 },
  { 4368, 16, 21, 18, 1, -21 },
  { 4410, 24, 21, 25, 1, -21 },
  { 4473, 16, 21, 18, 1, -21 },
  { 4515, 17, 29, 18, 0, -21 },
  { 4577, 14, 21, 18, 2, -21 },
  { 4614, 10, 38, 12, 1, -31 },
  { 4662, 4, 33, 10, 3, -28 },
  { 4679, 10, 38, 12, 1, -31 },
  { 4727, 19, 9, 23, 2, -16 },
};

const GFXfont RobotoCondensed_SemiBold40pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_SemiBold40pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_SemiBold40pt7bGlyphs,
  0x20, 0x7E, 47
};

#endif // _ROBOTOCONDENSED_SEMIBOLD40PT7B_H_
