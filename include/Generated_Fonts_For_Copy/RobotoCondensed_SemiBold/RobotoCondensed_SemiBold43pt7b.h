#ifndef _ROBOTOCONDENSED_SEMIBOLD43PT7B_H_
#define _ROBOTOCONDENSED_SEMIBOLD43PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-SemiBold.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_SemiBold43pt7bBitmaps[] PROGMEM = {
  0x00, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF,
  0xBE, 0xFB, 0xEF, 0xBE, 0xF8, 0x00, 0x00, 0x01, 0xCF, 0xBF, 0xFF, 0xE7,
  0x00, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3,
  0xF8, 0xFE, 0x38, 0x01, 0xC3, 0x80, 0x1C, 0x78, 0x01, 0xC7, 0x80, 0x1C,
  0x78, 0x03, 0xC7, 0x80, 0x3C, 0x70, 0x03, 0xC7, 0x00, 0x38, 0x70, 0x03,
  0x8F, 0x07, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x07, 0x8E, 0x00,
  0x78, 0xE0, 0x07, 0x0E, 0x00, 0x71, 0xE0, 0x07, 0x1E, 0x00, 0xF1, 0xE0,
  0x0F, 0x1C, 0x0F, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x0E, 0x3C,
  0x00, 0xE3, 0xC0, 0x1E, 0x3C, 0x01, 0xE3, 0x80, 0x1E, 0x38, 0x01, 0xC3,
  0x80, 0x1C, 0x78, 0x01, 0xC7, 0x80, 0x1C, 0x78, 0x00, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF,
  0xE0, 0xFF, 0xFC, 0x3F, 0xFF, 0x1F, 0x87, 0xE7, 0xE0, 0xF9, 0xF0, 0x3E,
  0x7C, 0x0F, 0x9F, 0x83, 0xE7, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F,
  0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x03,
  0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xBE, 0x03, 0xEF, 0xC0, 0xFF, 0xF0, 0x3E,
  0xFC, 0x0F, 0x9F, 0x87, 0xE7, 0xFF, 0xF8, 0xFF, 0xFC, 0x1F, 0xFF, 0x03,
  0xFF, 0x00, 0x3F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x1F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7B, 0xE0,
  0x00, 0xF1, 0xE0, 0xE0, 0xF0, 0xE1, 0xE0, 0xF0, 0xE1, 0xC0, 0xF0, 0xE3,
  0xC0, 0xF0, 0xE3, 0x80, 0xF1, 0xE7, 0x80, 0x7B, 0xE7, 0x00, 0x7F, 0xCF,
  0x00, 0x3F, 0xCE, 0x00, 0x1F, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x79, 0xF0, 0x00, 0x73, 0xFC, 0x00, 0xE7,
  0xFE, 0x01, 0xE7, 0xBE, 0x01, 0xCF, 0x0E, 0x03, 0xCF, 0x0E, 0x03, 0x8F,
  0x0F, 0x07, 0x8F, 0x0F, 0x07, 0x0F, 0x0E, 0x0F, 0x0F, 0x0E, 0x06, 0x07,
  0x9E, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xF0, 0x03, 0xF0,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x00,
  0xF8, 0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x3E, 0x1F, 0x00, 0xF8,
  0x78, 0x03, 0xF3, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xF0, 0xF1, 0xFF, 0xC3, 0xC7,
  0xDF, 0x9F, 0x3F, 0x3F, 0x7C, 0xF8, 0xFF, 0xF3, 0xE1, 0xFF, 0xCF, 0x83,
  0xFE, 0x3E, 0x07, 0xF8, 0xFC, 0x1F, 0xC3, 0xF0, 0x7F, 0x07, 0xFF, 0xFE,
  0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xF7, 0xE0, 0x7E, 0x1F, 0xC0,
  0xFF, 0xFF, 0xFF, 0xEE, 0xEE, 0xE0, 0x00, 0x80, 0x60, 0x38, 0x1E, 0x0F,
  0x03, 0xC1, 0xE0, 0xF8, 0x3C, 0x0F, 0x07, 0xC1, 0xE0, 0x78, 0x3E, 0x0F,
  0x83, 0xE0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF8, 0x3E, 0x0F, 0x81, 0xE0, 0x78, 0x1F,
  0x03, 0xC0, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x80, 0xE0, 0x18,
  0x02, 0x40, 0x18, 0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x78, 0x1F,
  0x03, 0xC0, 0xF8, 0x3E, 0x07, 0x81, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1E, 0x0F, 0x83, 0xE0, 0xF0, 0x7C, 0x1E, 0x07,
  0x83, 0xC1, 0xF0, 0x78, 0x3C, 0x06, 0x01, 0x00, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x38, 0x78, 0x6F, 0xDC, 0xFB,
  0xFF, 0xFF, 0x7F, 0xFF, 0xC3, 0xFF, 0x00, 0x3E, 0x00, 0x1F, 0xC0, 0x0F,
  0x78, 0x07, 0xCF, 0x01, 0xE3, 0xE0, 0xF0, 0x78, 0x1C, 0x1E, 0x02, 0x02,
  0x00, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x3E, 0x79, 0xF3,
  0xC1, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7B, 0xFF, 0xFF,
  0xFD, 0xE0, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03,
  0xC0, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F,
  0xFF, 0x1F, 0x87, 0xC7, 0xC1, 0xF9, 0xF0, 0x3E, 0xFC, 0x0F, 0xBF, 0x03,
  0xEF, 0xC0, 0xFB, 0xE0, 0x3E, 0xF8, 0x0F, 0xBE, 0x03, 0xFF, 0x80, 0xFF,
  0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFB, 0xE0, 0x3E, 0xFC,
  0x0F, 0xBF, 0x03, 0xEF, 0xC0, 0xF9, 0xF0, 0x3E, 0x7C, 0x1F, 0x9F, 0x87,
  0xC3, 0xFF, 0xF0, 0xFF, 0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0x00, 0x3F, 0x00,
  0x00, 0x30, 0x1F, 0x07, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F,
  0xC3, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x03,
  0xF0, 0x03, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x7F, 0xFF, 0x3F, 0x07,
  0xEF, 0xC1, 0xFB, 0xE0, 0x3E, 0xF8, 0x0F, 0xBE, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xF0, 0x0F,
  0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0xE7, 0xFF, 0xF7, 0xE0, 0xFF, 0xE0, 0x7F,
  0xF0, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x07,
  0xF0, 0x3F, 0xF0, 0x1F, 0xE0, 0x0F, 0xFC, 0x07, 0xFF, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x1F, 0xFE, 0x0F, 0xDF, 0xFF, 0xCF, 0xFF, 0xE3, 0xFF, 0xE0, 0xFF,
  0xE0, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF,
  0x00, 0x7B, 0xE0, 0x1F, 0x7C, 0x03, 0xCF, 0x80, 0xF9, 0xF0, 0x1E, 0x3E,
  0x07, 0xC7, 0xC0, 0xF8, 0xF8, 0x3E, 0x1F, 0x07, 0xC3, 0xE1, 0xF0, 0x7C,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x3F, 0xFF, 0x8F, 0xFF, 0xE3, 0xFF, 0xF8,
  0xFF, 0xFE, 0x3F, 0xFF, 0x8F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x07, 0xCF, 0x81, 0xFF, 0xF0, 0x7F, 0xFF, 0x1F, 0xFF,
  0xC7, 0xE7, 0xF8, 0x70, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3E, 0x7C,
  0x0F, 0x9F, 0x87, 0xE7, 0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xFE, 0x03, 0xFF,
  0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x1F, 0xF0,
  0x0F, 0xFC, 0x07, 0xF0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x07, 0xCF, 0x81, 0xF7, 0xF8, 0x7F, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF,
  0xFB, 0xF8, 0x7E, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F,
  0xFC, 0x07, 0xFF, 0x01, 0xF7, 0xC0, 0xFD, 0xF0, 0x3F, 0x7E, 0x0F, 0x9F,
  0x87, 0xE3, 0xFF, 0xF8, 0x7F, 0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0x00, 0x3F,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0,
  0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0,
  0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x87, 0xFF, 0xE7, 0xFF, 0xF3, 0xF0, 0xFD,
  0xF0, 0x7E, 0xF8, 0x3F, 0x7C, 0x1F, 0xBE, 0x0F, 0xDF, 0x07, 0xEF, 0xC3,
  0xE3, 0xFF, 0xF0, 0xFF, 0xF0, 0x3F, 0xF0, 0x3F, 0xFC, 0x3F, 0xFF, 0x3F,
  0x1F, 0x9F, 0x07, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F,
  0xF8, 0x1F, 0xFC, 0x0F, 0xBF, 0x0F, 0xDF, 0xFF, 0xE7, 0xFF, 0xE3, 0xFF,
  0xE0, 0x7F, 0xE0, 0x0F, 0xC0, 0x03, 0xE0, 0x07, 0xFC, 0x07, 0xFF, 0x07,
  0xFF, 0xC7, 0xFF, 0xF3, 0xF1, 0xF9, 0xF0, 0x7D, 0xF8, 0x3F, 0xFC, 0x0F,
  0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xF0,
  0x3E, 0xFC, 0x3F, 0x7F, 0x7F, 0x9F, 0xFF, 0xCF, 0xFF, 0xE3, 0xFD, 0xF0,
  0x7C, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x7F,
  0x03, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3C, 0x00, 0x7B,
  0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xBF, 0xFF, 0xFF, 0xDE, 0x1E, 0x3E, 0x7F, 0x7F, 0x3E, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3C, 0x7C, 0x78, 0xF8, 0x30,
  0x00, 0x02, 0x00, 0x1C, 0x00, 0x78, 0x03, 0xF0, 0x1F, 0xE0, 0xFF, 0xC7,
  0xFE, 0x3F, 0xF0, 0xFF, 0x81, 0xFC, 0x03, 0xF8, 0x07, 0xFC, 0x07, 0xFE,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0x00, 0x7E, 0x00, 0x3C, 0x00, 0x38,
  0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xC0, 0x03, 0xE0, 0x07,
  0xF0, 0x0F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFE, 0x00,
  0xFC, 0x01, 0xF8, 0x1F, 0xF0, 0xFF, 0xE7, 0xFF, 0x3F, 0xF8, 0x7F, 0xC0,
  0xFE, 0x01, 0xF0, 0x03, 0x80, 0x04, 0x00, 0x00, 0x07, 0xF0, 0x1F, 0xF8,
  0x3F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFF, 0x7C, 0x3F, 0xFC, 0x1F, 0xFC, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFE,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x07, 0xC0, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xF0, 0x7E,
  0x00, 0x7E, 0x00, 0xF8, 0x03, 0xC0, 0x01, 0xE0, 0x3C, 0x00, 0x07, 0x83,
  0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0xF1, 0xE0, 0x3F, 0x03, 0x8F, 0x03,
  0xFC, 0x1C, 0xF0, 0x3F, 0xF0, 0xF7, 0x83, 0xFF, 0x87, 0xBC, 0x1E, 0x3C,
  0x1D, 0xC1, 0xE1, 0xE0, 0xFE, 0x0F, 0x0F, 0x07, 0xF0, 0xF0, 0x78, 0x3F,
  0x87, 0x83, 0xC1, 0xFC, 0x3C, 0x1E, 0x0F, 0xE1, 0xE0, 0xF0, 0x7F, 0x0F,
  0x07, 0x03, 0xF8, 0xF8, 0x38, 0x1F, 0xC7, 0xC1, 0xC1, 0xFE, 0x3E, 0x1E,
  0x0E, 0xF0, 0xF0, 0xF0, 0x77, 0x87, 0x8F, 0x87, 0xBC, 0x3F, 0xFE, 0x79,
  0xE0, 0xFF, 0xFF, 0x87, 0x07, 0xF3, 0xFC, 0x3C, 0x0F, 0x0F, 0x81, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x20, 0x00, 0x7F, 0x9F, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0x03, 0xEF, 0x80, 0x03, 0xE7, 0xC0, 0x03, 0xE7, 0xC0, 0x07,
  0xC7, 0xC0, 0x07, 0xC7, 0xC0, 0x07, 0xC3, 0xE0, 0x0F, 0xC3, 0xE0, 0x0F,
  0x83, 0xE0, 0x0F, 0x83, 0xF0, 0x1F, 0x81, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x3E,
  0x00, 0xFC, 0x7E, 0x00, 0x7C, 0x7E, 0x00, 0x7E, 0x7C, 0x00, 0x7E, 0xFC,
  0x00, 0x7E, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xC3, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0xFF, 0xFD, 0xF0, 0x1F, 0xBE, 0x03,
  0xF7, 0xC0, 0x3E, 0xF8, 0x07, 0xDF, 0x00, 0xFB, 0xE0, 0x3F, 0x7C, 0x07,
  0xEF, 0x83, 0xF9, 0xFF, 0xFE, 0x3F, 0xFF, 0x87, 0xFF, 0xF8, 0xFF, 0xFF,
  0x9F, 0x01, 0xFB, 0xE0, 0x1F, 0x7C, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F,
  0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x01, 0xFB, 0xFF, 0xFF,
  0x7F, 0xFF, 0xCF, 0xFF, 0xF9, 0xFF, 0xFC, 0x3F, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F,
  0x81, 0xF9, 0xF8, 0x07, 0xCF, 0x80, 0x3F, 0x7C, 0x01, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x1F, 0xFE, 0x00, 0xFD, 0xF0, 0x07, 0xEF, 0x80,
  0x3F, 0x7E, 0x03, 0xF3, 0xF8, 0x1F, 0x8F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0,
  0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x07, 0xF0, 0x00, 0xFF, 0xE0, 0x1F, 0xFF,
  0x83, 0xFF, 0xF8, 0x7F, 0xFF, 0x8F, 0xFF, 0xF9, 0xF0, 0x3F, 0xBE, 0x03,
  0xF7, 0xC0, 0x3E, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x0F,
  0xFE, 0x01, 0xFF, 0xC0, 0x3E, 0xF8, 0x0F, 0xDF, 0x03, 0xFB, 0xFF, 0xFE,
  0x7F, 0xFF, 0x8F, 0xFF, 0xE1, 0xFF, 0xF8, 0x3F, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0xFF, 0xE7, 0xFF, 0xF3, 0xFF, 0xF9, 0xFF, 0xFC, 0xFF, 0xFE, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFE, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xFC, 0x03,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC3, 0xFF, 0xFF, 0x3F, 0x81, 0xF9, 0xF8, 0x07,
  0xCF, 0xC0, 0x3F, 0x7C, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x83, 0xFF,
  0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xC0,
  0x1F, 0xFE, 0x00, 0xFD, 0xF0, 0x07, 0xEF, 0xC0, 0x3F, 0x7E, 0x01, 0xF9,
  0xF8, 0x0F, 0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xFE, 0x03, 0xFF,
  0xE0, 0x03, 0xF8, 0x00, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00,
  0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC,
  0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0,
  0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFF, 0x0F, 0xDF, 0xFF, 0xCF,
  0xFF, 0xE3, 0xFF, 0xE0, 0xFF, 0xE0, 0x1F, 0xC0, 0xF8, 0x07, 0xF7, 0xC0,
  0x3F, 0xBE, 0x03, 0xF9, 0xF0, 0x1F, 0x8F, 0x81, 0xFC, 0x7C, 0x1F, 0xC3,
  0xE0, 0xFC, 0x1F, 0x0F, 0xE0, 0xF8, 0x7E, 0x07, 0xC7, 0xE0, 0x3E, 0x7F,
  0x01, 0xF3, 0xF0, 0x0F, 0xBF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFD, 0xFC,
  0x0F, 0xC7, 0xE0, 0x7C, 0x3F, 0x83, 0xE0, 0xFC, 0x1F, 0x07, 0xF0, 0xF8,
  0x1F, 0x87, 0xC0, 0xFE, 0x3E, 0x03, 0xF1, 0xF0, 0x1F, 0xCF, 0x80, 0x7E,
  0x7C, 0x03, 0xFB, 0xE0, 0x0F, 0xE0, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xEF, 0xFF, 0xE0, 0x7D,
  0xFF, 0xFC, 0x0F, 0xBF, 0xF7, 0xC1, 0xF7, 0xFE, 0xF8, 0x3C, 0xFF, 0xDF,
  0x0F, 0x9F, 0xF9, 0xF1, 0xF3, 0xFF, 0x3E, 0x3C, 0xFF, 0xE7, 0xCF, 0x9F,
  0xFC, 0x7D, 0xF3, 0xFF, 0x8F, 0xBC, 0x7F, 0xF1, 0xFF, 0x8F, 0xFE, 0x1F,
  0xF1, 0xFF, 0xC3, 0xFE, 0x3F, 0xF8, 0x7F, 0x87, 0xFF, 0x0F, 0xF0, 0xFF,
  0xE0, 0xFE, 0x1F, 0xFC, 0x1F, 0x83, 0xFF, 0x83, 0xF0, 0x7F, 0xF0, 0x3E,
  0x0F, 0xFE, 0x07, 0xC1, 0xF8, 0xF8, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF,
  0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3,
  0xFF, 0xBE, 0x1F, 0xFD, 0xF8, 0xFF, 0xE7, 0xC7, 0xFF, 0x3F, 0x3F, 0xF8,
  0xF9, 0xFF, 0xC7, 0xEF, 0xFE, 0x1F, 0x7F, 0xF0, 0xFF, 0xFF, 0x83, 0xFF,
  0xFC, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0,
  0x7F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF,
  0xE0, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFC, 0x0F, 0xC7, 0xE0, 0x1F, 0x9F, 0x80,
  0x7E, 0x7C, 0x00, 0xFB, 0xF0, 0x03, 0xEF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xF0, 0x03, 0xF7, 0xC0, 0x0F, 0x9F, 0x80, 0x7E, 0x7E, 0x01, 0xF8,
  0xFC, 0x0F, 0xC3, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0x80, 0xFE, 0xF8, 0x07, 0xEF, 0x80,
  0x3E, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8,
  0x03, 0xEF, 0x80, 0x7E, 0xF8, 0x0F, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF,
  0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0x80, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF0, 0xFC, 0x0F, 0xC7, 0xE0, 0x1F, 0x9F, 0x80, 0x7E, 0xFC, 0x00, 0xFB,
  0xF0, 0x03, 0xEF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xE7,
  0xC0, 0x0F, 0x9F, 0x80, 0x7E, 0x7E, 0x01, 0xF8, 0xFC, 0x0F, 0xC3, 0xFF,
  0xFF, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x1F, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x08, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xCF, 0x80, 0xFC, 0xF8, 0x07, 0xCF, 0x80, 0x7E, 0xF8, 0x07,
  0xEF, 0x80, 0x7E, 0xF8, 0x07, 0xEF, 0x80, 0x7E, 0xF8, 0x0F, 0xCF, 0x80,
  0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xC0, 0xFF,
  0xFE, 0x0F, 0x87, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xF0, 0xF8, 0x3F, 0x0F,
  0x81, 0xF8, 0xF8, 0x1F, 0x8F, 0x80, 0xFC, 0xF8, 0x0F, 0xCF, 0x80, 0xFC,
  0xF8, 0x07, 0xEF, 0x80, 0x7E, 0xF8, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xFF,
  0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC7, 0xFF, 0xFC, 0xFC, 0x1F, 0xBF, 0x01,
  0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0xF0, 0x07,
  0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0xC0, 0xFD, 0xFF, 0xFF,
  0x1F, 0xFF, 0xE1, 0xFF, 0xF8, 0x1F, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x01, 0xFF, 0xC0,
  0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC,
  0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF,
  0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F,
  0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01,
  0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xF7, 0xC0, 0x3F, 0x7E, 0x03, 0xF7, 0xE0,
  0x7E, 0x7F, 0xFF, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0xFF, 0xF0, 0x03,
  0xFC, 0x00, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xF3, 0xE0,
  0x07, 0xE7, 0xE0, 0x0F, 0xCF, 0xC0, 0x1F, 0x9F, 0x80, 0x7E, 0x1F, 0x00,
  0xFC, 0x3F, 0x01, 0xF8, 0x7E, 0x03, 0xE0, 0x7C, 0x0F, 0xC0, 0xF8, 0x1F,
  0x81, 0xF8, 0x3F, 0x03, 0xF0, 0x7C, 0x03, 0xE1, 0xF8, 0x07, 0xC3, 0xF0,
  0x0F, 0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0x3F, 0x00, 0x3E, 0x7E, 0x00,
  0x7E, 0xF8, 0x00, 0x7D, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x07, 0xC0, 0x7F,
  0xF0, 0x1F, 0x01, 0xF7, 0xC0, 0xFC, 0x0F, 0xDF, 0x03, 0xF0, 0x3F, 0x7C,
  0x0F, 0xC0, 0xFD, 0xF8, 0x3F, 0x83, 0xE7, 0xE0, 0xFE, 0x0F, 0x9F, 0x87,
  0xF8, 0x3E, 0x3E, 0x1F, 0xE0, 0xF8, 0xF8, 0x7F, 0x87, 0xE3, 0xE1, 0xFF,
  0x1F, 0x8F, 0x87, 0xFC, 0x7C, 0x3F, 0x3E, 0xF1, 0xF0, 0x7C, 0xFB, 0xC7,
  0xC1, 0xF3, 0xEF, 0x1F, 0x07, 0xCF, 0x3E, 0xFC, 0x1F, 0x3C, 0xFB, 0xE0,
  0x7C, 0xF1, 0xEF, 0x81, 0xFF, 0xC7, 0xBE, 0x03, 0xFF, 0x1E, 0xF8, 0x0F,
  0xF8, 0x7F, 0xE0, 0x3F, 0xE1, 0xFF, 0x80, 0xFF, 0x83, 0xFC, 0x03, 0xFE,
  0x0F, 0xF0, 0x07, 0xF8, 0x3F, 0xC0, 0x1F, 0xC0, 0xFF, 0x00, 0x7F, 0x03,
  0xFC, 0x01, 0xFC, 0x07, 0xE0, 0x07, 0xF0, 0x1F, 0x80, 0x1F, 0xC0, 0x7E,
  0x00, 0x3E, 0x01, 0xF8, 0x00, 0xFE, 0x01, 0xFD, 0xF8, 0x07, 0xE7, 0xF0,
  0x1F, 0x8F, 0xC0, 0xFC, 0x3F, 0x03, 0xF0, 0x7E, 0x1F, 0x81, 0xF8, 0x7E,
  0x03, 0xF1, 0xF0, 0x0F, 0xCF, 0xC0, 0x1F, 0xBE, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x80, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0,
  0x07, 0xFF, 0x80, 0x1F, 0x3E, 0x00, 0xFC, 0xFC, 0x03, 0xE3, 0xF0, 0x1F,
  0x87, 0xE0, 0x7E, 0x1F, 0x83, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x7E, 0x01,
  0xF9, 0xF8, 0x07, 0xEF, 0xC0, 0x1F, 0xC0, 0x7E, 0x00, 0xFE, 0xFC, 0x01,
  0xF9, 0xF8, 0x03, 0xF1, 0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0x83, 0xE0, 0x3E,
  0x07, 0xE0, 0xFC, 0x07, 0xC1, 0xF8, 0x0F, 0xC3, 0xE0, 0x1F, 0x8F, 0xC0,
  0x1F, 0x1F, 0x00, 0x3F, 0x3E, 0x00, 0x3E, 0xF8, 0x00, 0x7D, 0xF0, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC,
  0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC,
  0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC,
  0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x3E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFC,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F,
  0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F,
  0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00,
  0xFE, 0x03, 0xFC, 0x07, 0xBC, 0x0F, 0x78, 0x3C, 0xF0, 0x78, 0xF0, 0xF1,
  0xE3, 0xE3, 0xC7, 0x87, 0xCF, 0x07, 0xBE, 0x0F, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7E, 0x0F, 0x83, 0xF0, 0x7E, 0x0F,
  0x81, 0xF0, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0xC7, 0xE7,
  0xF7, 0xE1, 0xFB, 0xF0, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x03, 0xFF, 0x87,
  0xFF, 0xCF, 0xFF, 0xE7, 0xF1, 0xF7, 0xE0, 0xFB, 0xE0, 0x7D, 0xF0, 0x3E,
  0xF8, 0x1F, 0x7C, 0x1F, 0xBF, 0xBF, 0xDF, 0xFF, 0xE7, 0xFF, 0xF1, 0xFE,
  0xF8, 0x3E, 0x7E, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x3E, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0xEF, 0xC1,
  0xFB, 0xF0, 0x3E, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F,
  0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF,
  0x03, 0xEF, 0xC1, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0xBF,
  0xE3, 0xE3, 0xE0, 0x07, 0xF0, 0x0F, 0xFC, 0x0F, 0xFF, 0x0F, 0xFF, 0xC7,
  0xFF, 0xF7, 0xE0, 0xFB, 0xE0, 0x7D, 0xF0, 0x3E, 0xF8, 0x1F, 0xFC, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x3F, 0xF8, 0x1F, 0x7E, 0x0F, 0x9F, 0xFF, 0xCF, 0xFF, 0xC3, 0xFF, 0xE0,
  0xFF, 0xC0, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x87,
  0xC7, 0xCF, 0xFB, 0xE7, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F,
  0xF8, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFF,
  0x07, 0xFF, 0xFF, 0xF7, 0xFF, 0xF9, 0xFF, 0xFC, 0x7F, 0xBE, 0x1F, 0x1F,
  0x03, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x87, 0xFF, 0xE7, 0xFF, 0xF3, 0xE0,
  0xFB, 0xF0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x02,
  0x7F, 0x03, 0x1F, 0xFF, 0xC7, 0xFF, 0xF3, 0xFF, 0xF0, 0x7F, 0xF0, 0x0F,
  0xE0, 0x01, 0xF8, 0x3F, 0xC3, 0xFC, 0x1F, 0xE1, 0xFF, 0x0F, 0xC0, 0x7C,
  0x03, 0xE0, 0x1F, 0x07, 0xFF, 0xBF, 0xFD, 0xFF, 0xEF, 0xFF, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x07, 0xCF, 0x8F, 0xF7, 0xCF, 0xFF, 0xEF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F,
  0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0,
  0x3F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFE, 0x0F, 0xDF, 0xFF, 0xEF, 0xFF, 0xF3,
  0xFF, 0xF8, 0xFF, 0x7C, 0x3F, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F,
  0xC4, 0x07, 0xE7, 0xCF, 0xE3, 0xFF, 0xF3, 0xFF, 0xF0, 0x7F, 0xF0, 0x0F,
  0xE0, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x7C, 0x3F, 0x7F,
  0x9F, 0xFF, 0xCF, 0xFF, 0xF7, 0xFF, 0xFB, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC,
  0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF,
  0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83,
  0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0x39, 0xFF, 0xFF,
  0x7D, 0xE0, 0x00, 0x01, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF,
  0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x07, 0x07, 0xC7,
  0xE3, 0xF1, 0xF8, 0x78, 0x00, 0x00, 0x00, 0x07, 0xC3, 0xE1, 0xF0, 0xF8,
  0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC7,
  0xE3, 0xFF, 0xFF, 0xFB, 0xFD, 0xFC, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x07, 0xEF, 0xC3, 0xFB, 0xF0, 0xFC, 0xFC,
  0x7E, 0x3F, 0x3F, 0x0F, 0xCF, 0xC3, 0xF7, 0xE0, 0xFF, 0xF0, 0x3F, 0xFC,
  0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x83,
  0xFB, 0xF0, 0xFC, 0xFC, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF0, 0xFC, 0xFC,
  0x3F, 0x3F, 0x07, 0xEF, 0xC1, 0xFB, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF8, 0x1F, 0x0F, 0x9F, 0xE7, 0xFC, 0xFF,
  0xFE, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xC1, 0xFC,
  0x3E, 0xFC, 0x1F, 0x83, 0xFF, 0xC1, 0xF8, 0x3F, 0xFC, 0x1F, 0x83, 0xFF,
  0xC1, 0xF8, 0x3F, 0xFC, 0x1F, 0x83, 0xFF, 0xC1, 0xF8, 0x3F, 0xFC, 0x1F,
  0x83, 0xFF, 0xC1, 0xF8, 0x3F, 0xFC, 0x1F, 0x83, 0xFF, 0xC1, 0xF8, 0x3F,
  0xFC, 0x1F, 0x83, 0xFF, 0xC1, 0xF8, 0x3F, 0xFC, 0x1F, 0x83, 0xFF, 0xC1,
  0xF8, 0x3F, 0xFC, 0x1F, 0x83, 0xFF, 0xC1, 0xF8, 0x3F, 0xFC, 0x1F, 0x83,
  0xF0, 0xF8, 0xF8, 0x7C, 0xFF, 0x3E, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF7,
  0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07,
  0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC,
  0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF,
  0xF0, 0x7E, 0x03, 0xF0, 0x03, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x7F,
  0xFF, 0x3F, 0x07, 0xEF, 0xC0, 0xFB, 0xE0, 0x3E, 0xF8, 0x0F, 0xFE, 0x03,
  0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF,
  0xE0, 0x3F, 0xFC, 0x0F, 0xBF, 0x07, 0xE7, 0xFF, 0xF8, 0xFF, 0xFC, 0x3F,
  0xFE, 0x07, 0xFF, 0x00, 0x7F, 0x00, 0xF8, 0xF8, 0x3E, 0xFF, 0x8F, 0xFF,
  0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0xBF, 0x07, 0xEF, 0xC0, 0xFB, 0xF0, 0x3F,
  0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF,
  0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3E, 0xFC, 0x0F, 0xBF, 0x07, 0xEF, 0xFF,
  0xFB, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0x8F, 0xCF, 0x83, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x0F, 0x8F, 0x9F, 0xF7, 0xCF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xF0, 0x1F, 0xF8,
  0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F,
  0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFE, 0x0F, 0xDF, 0xFF, 0xEF, 0xFF,
  0xF3, 0xFF, 0xF8, 0xFF, 0x7C, 0x3E, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x87,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x00, 0x03, 0xF0,
  0x07, 0xFE, 0x07, 0xFF, 0x87, 0xFF, 0xE7, 0xE3, 0xF3, 0xE0, 0xFD, 0xF0,
  0x7E, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xFC, 0x0F, 0xBE, 0x0F,
  0xDF, 0x8F, 0xE7, 0xFF, 0xE3, 0xFF, 0xE0, 0x7F, 0xE0, 0x1F, 0xC0, 0x1F,
  0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF1, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F,
  0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xFF, 0x0F,
  0xF0, 0xFF, 0x07, 0xF0, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF,
  0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F,
  0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0,
  0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xDF, 0xFF, 0xEF, 0xFF, 0xF3,
  0xFF, 0xF9, 0xFF, 0x7C, 0x3E, 0x3E, 0xF8, 0x0F, 0xFE, 0x0F, 0xFF, 0x07,
  0xEF, 0x83, 0xE7, 0xC1, 0xF3, 0xE0, 0xF9, 0xF8, 0xFC, 0x7C, 0x7C, 0x3E,
  0x3E, 0x1F, 0x1F, 0x07, 0xCF, 0x03, 0xEF, 0x81, 0xF7, 0xC0, 0xFB, 0xE0,
  0x3D, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0xF8, 0x1E, 0x0F, 0xBE, 0x0F,
  0x83, 0xEF, 0x83, 0xE0, 0xF9, 0xF0, 0xF8, 0x3E, 0x7C, 0x3F, 0x0F, 0x9F,
  0x1F, 0xC7, 0xC7, 0xC7, 0xF1, 0xF1, 0xF1, 0xFC, 0x7C, 0x3C, 0x7F, 0x9F,
  0x0F, 0xBF, 0xE7, 0xC3, 0xEF, 0x79, 0xE0, 0xFB, 0xDE, 0xF8, 0x3E, 0xF3,
  0xFE, 0x07, 0xFC, 0xFF, 0x81, 0xFE, 0x3F, 0xC0, 0x7F, 0x8F, 0xF0, 0x1F,
  0xE1, 0xFC, 0x03, 0xF8, 0x7F, 0x00, 0xFC, 0x1F, 0xC0, 0x3F, 0x07, 0xE0,
  0x0F, 0xC0, 0xF8, 0x03, 0xF0, 0x3E, 0x00, 0x78, 0x0F, 0x80, 0xFC, 0x1F,
  0x9F, 0x87, 0xE7, 0xE1, 0xF0, 0xF8, 0xFC, 0x3F, 0x3E, 0x07, 0xDF, 0x81,
  0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F,
  0xC0, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x1F, 0xFC,
  0x07, 0xDF, 0x83, 0xF3, 0xE0, 0xF8, 0xFC, 0x7E, 0x1F, 0x1F, 0x07, 0xEF,
  0xC0, 0xF8, 0x7C, 0x07, 0xDF, 0x83, 0xF7, 0xE0, 0xFD, 0xF8, 0x3E, 0x3E,
  0x0F, 0x8F, 0x87, 0xE3, 0xF1, 0xF8, 0x7C, 0x7C, 0x1F, 0x1F, 0x07, 0xCF,
  0xC1, 0xFB, 0xE0, 0x3E, 0xF8, 0x0F, 0xBE, 0x03, 0xEF, 0x80, 0x7F, 0xC0,
  0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xF8, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE,
  0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x07, 0xE0,
  0x07, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3E, 0x00,
  0x7E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x40, 0x38, 0x0F, 0x83, 0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0xF8, 0x7F, 0x0F, 0xC1, 0xF8, 0x3F, 0x81, 0xF0, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x3C,
  0x07, 0xC0, 0xF8, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xC0, 0x08, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x40, 0x0E, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x7C, 0x0F, 0x80, 0xF0, 0x1E,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x3E, 0x07, 0xF0, 0x7E, 0x0F, 0xC3, 0xF8, 0x7C, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x78, 0x1F, 0x07, 0xC0, 0x70, 0x08, 0x00, 0x0F, 0x00,
  0x01, 0xFC, 0x0F, 0x3F, 0xE0, 0xF7, 0xFF, 0x1F, 0x7F, 0xFF, 0xFF, 0x8F,
  0xFE, 0xF8, 0x7F, 0xEF, 0x03, 0xFC, 0x00, 0x0F, 0x00,
};

const GFXglyph RobotoCondensed_SemiBold43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 6, 31, 11, 3, -31 },
  { 25, 10, 11, 14, 2, -32 },
  { 39, 20, 31, 23, 2, -31 },
  { 117, 18, 39, 22, 2, -35 },
  { 205, 24, 31, 27, 2, -31 },
  { 298, 22, 31, 25, 2, -31 },
  { 384, 4, 11, 7, 2, -32 },
  { 390, 10, 44, 14, 3, -34 },
  { 445, 10, 44, 14, 1, -34 },
  { 500, 18, 18, 19, 1, -31 },
  { 541, 18, 22, 21, 1, -25 },
  { 591, 7, 12, 10, 1, -5 },
  { 602, 10, 5, 14, 2, -16 },
  { 609, 6, 6, 12, 3, -6 },
  { 614, 14, 34, 15, 0, -31 },
  { 674, 18, 31, 22, 2, -31 },
  { 744, 12, 31, 22, 3, -31 },
  { 791, 18, 31, 22, 2, -31 },
  { 861, 17, 31, 22, 2, -31 },
  { 927, 19, 31, 22, 1, -31 },
  { 1001, 18, 31, 22, 2, -31 },
  { 1071, 18, 31, 22, 2, -31 },
  { 1141, 18, 31, 22, 2, -31 },
  { 1211, 17, 31, 22, 2, -31 },
  { 1277, 17, 31, 22, 2, -31 },
  { 1343, 6, 24, 11, 3, -24 },
  { 1361, 8, 31, 10, 1, -24 },
  { 1392, 15, 20, 19, 1, -23 },
  { 1430, 16, 14, 21, 3, -21 },
  { 1458, 15, 20, 20, 3, -23 },
  { 1496, 16, 31, 19, 1, -31 },
  { 1558, 29, 40, 33, 2, -30 },
  { 1703, 24, 31, 25, 1, -31 },
  { 1796, 19, 31, 24, 3, -31 },
  { 1870, 21, 31, 24, 2, -31 },
  { 1952, 19, 31, 24, 3, -31 },
  { 2026, 17, 31, 21, 3, -31 },
  { 2092, 16, 31, 21, 3, -31 },
  { 2154, 21, 31, 25, 2, -31 },
  { 2236, 21, 31, 26, 3, -31 },
  { 2318, 6, 31, 11, 3, -31 },
  { 2342, 17, 31, 21, 1, -31 },
  { 2408, 21, 31, 24, 3, -31 },
  { 2490, 16, 31, 21, 3, -31 },
  { 2552, 27, 31, 33, 3, -31 },
  { 2657, 21, 31, 26, 3, -31 },
  { 2739, 22, 31, 26, 2, -31 },
  { 2825, 20, 31, 24, 3, -31 },
  { 2903, 22, 36, 26, 2, -31 },
  { 3002, 20, 31, 24, 3, -31 },
  { 3080, 19, 31, 23, 2, -31 },
  { 3154, 21, 31, 23, 1, -31 },
  { 3236, 20, 31, 24, 2, -31 },
  { 3314, 23, 31, 25, 1, -31 },
  { 3404, 30, 31, 32, 1, -31 },
  { 3521, 22, 31, 24, 1, -31 },
  { 3607, 23, 31, 23, 0, -31 },
  { 3697, 19, 31, 23, 2, -31 },
  { 3771, 8, 42, 11, 2, -35 },
  { 3813, 17, 34, 16, 0, -31 },
  { 3886, 8, 42, 11, 1, -35 },
  { 3928, 15, 15, 17, 1, -31 },
  { 3957, 17, 4, 17, 0, 0 },
  { 3966, 10, 6, 14, 1, -32 },
  { 3974, 17, 23, 20, 2, -23 },
  { 4023, 18, 32, 21, 2, -32 },
  { 4095, 17, 23, 20, 2, -23 },
  { 4144, 17, 32, 21, 2, -32 },
  { 4212, 17, 23, 21, 2, -23 },
  { 4261, 13, 32, 14, 1, -32 },
  { 4313, 17, 32, 22, 2, -23 },
  { 4381, 17, 32, 21, 2, -32 },
  { 4449, 6, 32, 11, 2, -32 },
  { 4473, 9, 41, 10, -1, -32 },
  { 4520, 18, 32, 20, 2, -32 },
  { 4592, 5, 32, 11, 3, -32 },
  { 4612, 28, 23, 32, 2, -23 },
  { 4693, 17, 23, 21, 2, -23 },
  { 4742, 18, 23, 21, 2, -23 },
  { 4794, 18, 32, 21, 2, -23 },
  { 4866, 17, 32, 21, 2, -23 },
  { 4934, 11, 23, 14, 2, -23 },
  { 4966, 17, 23, 20, 1, -23 },
  { 5015, 12, 28, 13, 0, -28 },
  { 5057, 17, 23, 21, 2, -23 },
  { 5106, 17, 23, 19, 1, -23 },
  { 5155, 26, 23, 27, 1, -23 },
  { 5230, 18, 23, 19, 1, -23 },
  { 5282, 18, 32, 19, 0, -23 },
  { 5354, 16, 23, 19, 2, -23 },
  { 5400, 11, 42, 13, 1, -34 },
  { 5458, 3, 37, 11, 4, -31 },
  { 5472, 11, 42, 13, 1, -34 },
  { 5530, 20, 9, 24, 2, -17 },
};

const GFXfont RobotoCondensed_SemiBold43pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_SemiBold43pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_SemiBold43pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _ROBOTOCONDENSED_SEMIBOLD43PT7B_H_
