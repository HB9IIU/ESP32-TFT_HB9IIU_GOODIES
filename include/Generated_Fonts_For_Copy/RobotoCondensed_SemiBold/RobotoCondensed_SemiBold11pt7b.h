#ifndef _ROBOTOCONDENSED_SEMIBOLD11PT7B_H_
#define _ROBOTOCONDENSED_SEMIBOLD11PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-SemiBold.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_SemiBold11pt7bBitmaps[] PROGMEM = {
  0x00, 0xFB, 0xB6, 0x80, 0x28, 0xA7, 0xCC, 0x33, 0xE5, 0x14, 0x4E, 0xB9,
  0xC3, 0x9B, 0xE4, 0xC3, 0x4D, 0x38, 0x39, 0x55, 0x46, 0x31, 0x65, 0x1C,
  0x7F, 0x74, 0x9F, 0xE0, 0x5A, 0xAA, 0x94, 0x89, 0x12, 0x49, 0x4A, 0x00,
  0x25, 0x5C, 0xA5, 0x00, 0x21, 0x3E, 0x42, 0x00, 0x58, 0xC0, 0xC0, 0x22,
  0x22, 0x44, 0x48, 0x80, 0xEB, 0x99, 0x99, 0xBE, 0x7D, 0xB6, 0xDB, 0x72,
  0xF6, 0x33, 0x11, 0x8F, 0x72, 0xC6, 0x61, 0x87, 0x6E, 0x11, 0x8C, 0xA5,
  0x7C, 0x42, 0xF8, 0x8E, 0x31, 0xBE, 0x6C, 0x8E, 0xB9, 0xB6, 0xF8, 0xC4,
  0x23, 0x10, 0x8C, 0xEB, 0xB6, 0xB9, 0xBE, 0x72, 0xD2, 0xB6, 0x8C, 0x4C,
  0xCC, 0x50, 0x17, 0x17, 0xC7, 0x10, 0xF0, 0xF0, 0x8E, 0x3E, 0x80, 0x7D,
  0x11, 0x22, 0x02, 0x1C, 0x22, 0x5D, 0x55, 0x95, 0xA5, 0x75, 0x5E, 0x40,
  0x3C, 0x30, 0xC3, 0x8A, 0x69, 0xF4, 0xF1, 0xF4, 0xA5, 0xE9, 0x4E, 0x5E,
  0x74, 0xE7, 0x08, 0x4E, 0x6E, 0xE4, 0xA7, 0x39, 0xCE, 0x5C, 0xF8, 0x8F,
  0x88, 0x8F, 0xF8, 0x88, 0xF8, 0x88, 0x74, 0xE7, 0x0B, 0xCF, 0x6E, 0x8C,
  0x63, 0x1F, 0xC6, 0x31, 0xFF, 0x18, 0xC6, 0x31, 0x8F, 0x6E, 0x9D, 0xA9,
  0xCE, 0x5A, 0x53, 0x88, 0x88, 0x88, 0x8F, 0xC7, 0x9F, 0x3F, 0x7A, 0xF6,
  0xED, 0xDB, 0x8E, 0x73, 0xDA, 0xDE, 0x73, 0x74, 0xE3, 0x18, 0xC6, 0x6E,
  0xF4, 0xE7, 0x3F, 0x42, 0x10, 0x74, 0xE3, 0x18, 0xC6, 0x6E, 0x08, 0xF4,
  0xA7, 0x2F, 0x5A, 0x53, 0x7A, 0x50, 0xE1, 0xE5, 0x2F, 0xFC, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x9C, 0xE7, 0x39, 0xCE, 0x7E, 0xC5, 0x34, 0x9A, 0x68,
  0xE3, 0x0C, 0xD9, 0x5B, 0x5B, 0x5A, 0x5E, 0x76, 0x66, 0x26, 0x4D, 0xA7,
  0x8C, 0x31, 0xE4, 0xB3, 0xCD, 0x27, 0x8C, 0x30, 0xC3, 0x0C, 0xF8, 0x44,
  0x62, 0x31, 0x1F, 0xEA, 0xAA, 0xAC, 0xC4, 0x46, 0x62, 0x23, 0x10, 0xD5,
  0x55, 0x5C, 0x66, 0x6D, 0xF0, 0x4C, 0x72, 0xDE, 0xBD, 0xBC, 0x88, 0x8E,
  0xB9, 0x9B, 0xE0, 0x72, 0xF1, 0x85, 0xB8, 0x18, 0xC6, 0xF5, 0xEF, 0x6B,
  0x68, 0x72, 0xFF, 0x84, 0x38, 0x29, 0x74, 0x92, 0x40, 0x7A, 0xF3, 0x95,
  0xB4, 0x6E, 0x88, 0x8E, 0xBB, 0xBB, 0xB0, 0x5F, 0x80, 0x11, 0x55, 0x5C,
  0x88, 0x8B, 0xEC, 0xEA, 0xB0, 0xFF, 0x80, 0xED, 0x6E, 0xDD, 0xBB, 0x76,
  0xC0, 0xEB, 0xBB, 0xBB, 0x72, 0xF3, 0x95, 0xB8, 0xEB, 0x99, 0xBE, 0x88,
  0x6A, 0xF7, 0xB5, 0xBC, 0x63, 0xEA, 0xA0, 0x72, 0xD8, 0x6D, 0xB8, 0x5D,
  0x24, 0x98, 0xBB, 0xBB, 0xBF, 0xDA, 0x94, 0xA6, 0x10, 0xD6, 0xA9, 0xB3,
  0x66, 0xCD, 0x80, 0xD2, 0x98, 0xC5, 0x6C, 0xDA, 0x94, 0xE6, 0x10, 0x88,
  0xF0, 0x88, 0xC4, 0x7C, 0x29, 0x25, 0x92, 0x48, 0x80, 0xFF, 0x80, 0x89,
  0x24, 0x52, 0x4A, 0x00, 0xCD, 0x80,
};

const GFXglyph RobotoCondensed_SemiBold11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 1, 8, 3, 1, -8 },
  { 2, 3, 3, 4, 0, -8 },
  { 4, 6, 8, 6, 0, -8 },
  { 10, 4, 10, 6, 1, -9 },
  { 15, 6, 8, 7, 1, -8 },
  { 21, 6, 8, 6, 0, -8 },
  { 27, 1, 3, 2, 0, -8 },
  { 28, 2, 11, 4, 1, -9 },
  { 31, 3, 11, 4, 0, -9 },
  { 36, 5, 5, 5, 0, -8 },
  { 40, 5, 5, 5, 0, -6 },
  { 44, 2, 3, 3, 0, -1 },
  { 45, 2, 1, 4, 1, -4 },
  { 46, 1, 2, 3, 1, -2 },
  { 47, 4, 9, 4, 0, -8 },
  { 52, 4, 8, 6, 1, -8 },
  { 56, 3, 8, 6, 1, -8 },
  { 59, 5, 8, 6, 0, -8 },
  { 64, 5, 8, 6, 0, -8 },
  { 69, 5, 8, 6, 0, -8 },
  { 74, 4, 8, 6, 1, -8 },
  { 78, 4, 8, 6, 1, -8 },
  { 82, 5, 8, 6, 0, -8 },
  { 87, 4, 8, 6, 1, -8 },
  { 91, 5, 8, 6, 0, -8 },
  { 96, 1, 6, 3, 1, -6 },
  { 97, 2, 8, 3, 0, -6 },
  { 99, 4, 5, 5, 0, -6 },
  { 102, 4, 3, 5, 1, -5 },
  { 104, 4, 5, 5, 1, -6 },
  { 107, 4, 8, 5, 0, -8 },
  { 111, 8, 10, 8, 0, -8 },
  { 121, 6, 8, 7, 0, -8 },
  { 127, 5, 8, 6, 1, -8 },
  { 132, 5, 8, 6, 1, -8 },
  { 137, 5, 8, 6, 1, -8 },
  { 142, 4, 8, 5, 1, -8 },
  { 146, 4, 8, 5, 1, -8 },
  { 150, 5, 8, 6, 1, -8 },
  { 155, 5, 8, 7, 1, -8 },
  { 160, 1, 8, 3, 1, -8 },
  { 161, 5, 8, 5, 0, -8 },
  { 166, 5, 8, 6, 1, -8 },
  { 171, 4, 8, 5, 1, -8 },
  { 175, 7, 8, 8, 1, -8 },
  { 182, 5, 8, 7, 1, -8 },
  { 187, 5, 8, 7, 1, -8 },
  { 192, 5, 8, 6, 1, -8 },
  { 197, 5, 9, 7, 1, -8 },
  { 203, 5, 8, 6, 1, -8 },
  { 208, 5, 8, 6, 0, -8 },
  { 213, 6, 8, 6, 0, -8 },
  { 219, 5, 8, 6, 1, -8 },
  { 224, 6, 8, 6, 0, -8 },
  { 230, 8, 8, 8, 0, -8 },
  { 238, 6, 8, 6, 0, -8 },
  { 244, 6, 8, 6, 0, -8 },
  { 250, 5, 8, 6, 0, -8 },
  { 255, 2, 11, 3, 1, -9 },
  { 258, 4, 9, 4, 0, -8 },
  { 263, 2, 11, 3, 0, -9 },
  { 266, 4, 4, 4, 0, -8 },
  { 268, 4, 1, 4, 0, 0 },
  { 269, 3, 2, 4, 0, -9 },
  { 270, 5, 6, 5, 0, -6 },
  { 274, 4, 9, 5, 1, -9 },
  { 279, 5, 6, 5, 0, -6 },
  { 283, 5, 9, 5, 0, -9 },
  { 289, 5, 6, 5, 0, -6 },
  { 293, 3, 9, 4, 0, -9 },
  { 297, 5, 8, 6, 0, -6 },
  { 302, 4, 9, 5, 1, -9 },
  { 307, 1, 9, 3, 1, -9 },
  { 309, 2, 11, 3, 0, -9 },
  { 312, 4, 9, 5, 1, -9 },
  { 317, 1, 9, 3, 1, -9 },
  { 319, 7, 6, 8, 1, -6 },
  { 325, 4, 6, 5, 1, -6 },
  { 328, 5, 6, 5, 0, -6 },
  { 332, 4, 8, 5, 1, -6 },
  { 336, 5, 8, 5, 0, -6 },
  { 341, 2, 6, 4, 1, -6 },
  { 343, 5, 6, 5, 0, -6 },
  { 347, 3, 7, 3, 0, -7 },
  { 350, 4, 6, 5, 1, -6 },
  { 353, 5, 6, 5, 0, -6 },
  { 357, 7, 6, 7, 0, -6 },
  { 363, 5, 6, 5, 0, -6 },
  { 367, 5, 8, 5, 0, -6 },
  { 372, 5, 6, 5, 0, -6 },
  { 376, 3, 11, 3, 0, -9 },
  { 381, 1, 9, 3, 1, -8 },
  { 383, 3, 11, 3, 0, -9 },
  { 388, 5, 2, 6, 1, -4 },
};

const GFXfont RobotoCondensed_SemiBold11pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_SemiBold11pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_SemiBold11pt7bGlyphs,
  0x20, 0x7E, 13
};

#endif // _ROBOTOCONDENSED_SEMIBOLD11PT7B_H_
