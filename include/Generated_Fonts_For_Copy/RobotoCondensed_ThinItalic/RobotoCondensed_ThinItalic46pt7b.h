#ifndef _ROBOTOCONDENSED_THINITALIC46PT7B_H_
#define _ROBOTOCONDENSED_THINITALIC46PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ThinItalic.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ThinItalic46pt7bBitmaps[] PROGMEM = {
  0x00, 0x02, 0x04, 0x18, 0x20, 0x40, 0x81, 0x02, 0x0C, 0x10, 0x20, 0x40,
  0x81, 0x06, 0x08, 0x10, 0x20, 0x40, 0x83, 0x04, 0x08, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x60, 0xC0, 0x22, 0xC5, 0x8A, 0x34, 0x68, 0xB1,
  0x62, 0x84, 0x00, 0x08, 0x08, 0x00, 0x10, 0x10, 0x00, 0x60, 0x40, 0x00,
  0x80, 0x80, 0x01, 0x01, 0x00, 0x06, 0x04, 0x00, 0x08, 0x08, 0x00, 0x10,
  0x10, 0x00, 0x60, 0x40, 0x00, 0x80, 0x80, 0x7F, 0xFF, 0xF8, 0x02, 0x06,
  0x00, 0x08, 0x08, 0x00, 0x10, 0x10, 0x00, 0x20, 0x60, 0x00, 0x80, 0x80,
  0x01, 0x01, 0x00, 0x02, 0x06, 0x00, 0x0C, 0x08, 0x00, 0x10, 0x10, 0x00,
  0x20, 0x60, 0x00, 0xC0, 0x80, 0x01, 0x01, 0x00, 0x7F, 0xFF, 0xF0, 0x0C,
  0x08, 0x00, 0x10, 0x10, 0x00, 0x20, 0x60, 0x00, 0xC0, 0x80, 0x01, 0x01,
  0x00, 0x02, 0x02, 0x00, 0x04, 0x08, 0x00, 0x10, 0x10, 0x00, 0x20, 0x20,
  0x00, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x07,
  0xE0, 0x03, 0x86, 0x00, 0xC0, 0x60, 0x30, 0x06, 0x04, 0x00, 0x41, 0x00,
  0x08, 0x20, 0x01, 0x0C, 0x00, 0x31, 0x00, 0x06, 0x20, 0x00, 0x84, 0x00,
  0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x40, 0x00, 0x88, 0x00, 0x11, 0x00, 0x02,
  0x20, 0x00, 0xC4, 0x00, 0x10, 0xC0, 0x06, 0x08, 0x00, 0x80, 0x80, 0x60,
  0x1C, 0x18, 0x00, 0xFC, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x07, 0x80, 0x00, 0x63, 0x00, 0x03, 0x04, 0x00, 0x08,
  0x08, 0x00, 0x60, 0x20, 0x11, 0x00, 0x80, 0x84, 0x02, 0x06, 0x10, 0x08,
  0x10, 0xC0, 0x60, 0x82, 0x01, 0x06, 0x0C, 0x04, 0x10, 0x10, 0x20, 0x80,
  0x41, 0x86, 0x01, 0x8C, 0x30, 0x03, 0xE0, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x80, 0x00, 0x04, 0x1F, 0x00, 0x30, 0xC6, 0x00, 0x86,
  0x08, 0x04, 0x10, 0x30, 0x20, 0x80, 0x41, 0x82, 0x01, 0x04, 0x18, 0x0C,
  0x20, 0x40, 0x21, 0x81, 0x00, 0x84, 0x04, 0x02, 0x20, 0x10, 0x18, 0x80,
  0x40, 0x40, 0x00, 0x83, 0x00, 0x03, 0x18, 0x00, 0x07, 0x80, 0x00, 0x3E,
  0x00, 0x03, 0x18, 0x00, 0x20, 0x60, 0x03, 0x01, 0x00, 0x10, 0x08, 0x01,
  0x80, 0x40, 0x08, 0x02, 0x00, 0x40, 0x30, 0x02, 0x01, 0x00, 0x10, 0x10,
  0x00, 0x81, 0x80, 0x06, 0x18, 0x00, 0x11, 0x00, 0x00, 0xD0, 0x00, 0x03,
  0x00, 0x00, 0x38, 0x00, 0x03, 0x40, 0x00, 0x23, 0x00, 0x02, 0x08, 0x06,
  0x30, 0x20, 0x23, 0x01, 0x01, 0x10, 0x04, 0x09, 0x80, 0x30, 0x88, 0x00,
  0x84, 0x40, 0x06, 0x62, 0x00, 0x12, 0x30, 0x00, 0xF0, 0x80, 0x03, 0x04,
  0x00, 0x18, 0x30, 0x01, 0x60, 0xC0, 0x31, 0x03, 0x06, 0x0C, 0x07, 0xC0,
  0x20, 0x69, 0x25, 0xB4, 0x80, 0x00, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0xC0, 0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x60, 0x01,
  0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x06, 0x00, 0x20, 0x03, 0x00, 0x10, 0x00, 0x80,
  0x08, 0x00, 0x40, 0x04, 0x00, 0x60, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x0C, 0x00, 0x06, 0x03, 0x02, 0x06, 0xE1, 0x0E, 0x1C, 0xB8, 0x01, 0xE0,
  0x00, 0x60, 0x00, 0x58, 0x00, 0x44, 0x00, 0x61, 0x00, 0x60, 0xC0, 0x60,
  0x20, 0x60, 0x18, 0x20, 0x04, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x7F, 0xFF, 0xF0, 0x0C,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x10, 0x84, 0x63, 0x11, 0x98, 0x80, 0xFF, 0x00, 0xF8, 0x00, 0x00,
  0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00,
  0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00,
  0x10, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x30, 0xC0, 0x30, 0x18, 0x08, 0x02, 0x04, 0x00, 0xC3,
  0x00, 0x10, 0x80, 0x04, 0x60, 0x01, 0x10, 0x00, 0x44, 0x00, 0x13, 0x00,
  0x04, 0x80, 0x01, 0x20, 0x00, 0x48, 0x00, 0x12, 0x00, 0x05, 0x80, 0x03,
  0x40, 0x00, 0x90, 0x00, 0x24, 0x00, 0x09, 0x00, 0x02, 0xC0, 0x01, 0xB0,
  0x00, 0x48, 0x00, 0x12, 0x00, 0x04, 0x80, 0x03, 0x30, 0x00, 0x8C, 0x00,
  0x61, 0x00, 0x10, 0x40, 0x0C, 0x18, 0x06, 0x02, 0x03, 0x00, 0x61, 0x80,
  0x0F, 0x80, 0x00, 0x00, 0xC0, 0xF0, 0xCD, 0xC2, 0xC0, 0x80, 0x20, 0x08,
  0x02, 0x01, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x30, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x18, 0x06, 0x01, 0x00, 0x40, 0x10, 0x04, 0x03, 0x00,
  0xC0, 0x20, 0x08, 0x02, 0x00, 0x80, 0x60, 0x10, 0x00, 0x00, 0x7E, 0x00,
  0x18, 0x70, 0x04, 0x03, 0x01, 0x00, 0x20, 0x60, 0x06, 0x08, 0x00, 0xC2,
  0x00, 0x08, 0x40, 0x01, 0x18, 0x00, 0x62, 0x00, 0x0C, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x02, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3E, 0x00, 0x0C, 0x18, 0x01, 0x80, 0xC0,
  0x20, 0x06, 0x06, 0x00, 0x20, 0x40, 0x02, 0x08, 0x00, 0x20, 0x80, 0x02,
  0x08, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0xF8, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x84, 0x00, 0x08, 0xC0, 0x00, 0x8C, 0x00, 0x08, 0x40, 0x01, 0x84,
  0x00, 0x10, 0x60, 0x03, 0x02, 0x00, 0x20, 0x30, 0x0C, 0x01, 0xC3, 0x80,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x05, 0x00, 0x01,
  0xA0, 0x00, 0x2C, 0x00, 0x09, 0x00, 0x03, 0x20, 0x00, 0x44, 0x00, 0x10,
  0x80, 0x04, 0x10, 0x01, 0x86, 0x00, 0x20, 0x80, 0x08, 0x10, 0x03, 0x02,
  0x00, 0x40, 0x40, 0x10, 0x08, 0x06, 0x03, 0x01, 0x80, 0x40, 0x20, 0x08,
  0x08, 0x01, 0x03, 0x00, 0x20, 0x40, 0x0C, 0x10, 0x01, 0x87, 0xFF, 0xFF,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0xFF,
  0xE0, 0x40, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00,
  0x08, 0x00, 0x01, 0x1F, 0x00, 0x3C, 0x38, 0x0E, 0x01, 0x80, 0x00, 0x10,
  0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x80, 0x02, 0x10, 0x00, 0x42,
  0x00, 0x08, 0x40, 0x02, 0x0C, 0x00, 0x40, 0x80, 0x10, 0x18, 0x04, 0x01,
  0xC3, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x10, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00,
  0x0C, 0x00, 0x04, 0x00, 0x02, 0x1F, 0x02, 0x30, 0xE1, 0x20, 0x18, 0xA0,
  0x04, 0xE0, 0x02, 0x60, 0x01, 0xA0, 0x00, 0x50, 0x00, 0x28, 0x00, 0x14,
  0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x02, 0x80, 0x01, 0x60, 0x00,
  0xB0, 0x00, 0x88, 0x00, 0x44, 0x00, 0x43, 0x00, 0x60, 0xC0, 0x60, 0x30,
  0x60, 0x07, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00,
  0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00,
  0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06,
  0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x0E, 0x18,
  0x01, 0x80, 0x40, 0x30, 0x06, 0x06, 0x00, 0x20, 0x40, 0x03, 0x0C, 0x00,
  0x10, 0x80, 0x01, 0x08, 0x00, 0x30, 0x80, 0x02, 0x08, 0x00, 0x20, 0x80,
  0x06, 0x08, 0x00, 0x40, 0x40, 0x08, 0x06, 0x01, 0x80, 0x38, 0x60, 0x01,
  0xF8, 0x00, 0x60, 0x60, 0x08, 0x03, 0x01, 0x00, 0x18, 0x20, 0x00, 0x86,
  0x00, 0x0C, 0x40, 0x00, 0xC4, 0x00, 0x0C, 0xC0, 0x00, 0xC8, 0x00, 0x08,
  0x80, 0x00, 0x8C, 0x00, 0x18, 0x40, 0x03, 0x06, 0x00, 0x20, 0x30, 0x0C,
  0x01, 0x83, 0x80, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x01, 0x87, 0x01, 0x00,
  0xC1, 0x00, 0x21, 0x80, 0x19, 0x80, 0x04, 0x80, 0x02, 0x40, 0x01, 0x40,
  0x00, 0xA0, 0x00, 0x50, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x02, 0x40, 0x03, 0x20, 0x02, 0x98, 0x03, 0x46, 0x03,
  0x61, 0x87, 0x20, 0x7E, 0x10, 0x00, 0x08, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x02, 0x00, 0x03, 0x00, 0x06, 0x00,
  0x0E, 0x00, 0x78, 0x00, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C,
  0x18, 0x00, 0x07, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x10, 0x30,
  0x30, 0x20, 0x20, 0x40, 0xC0, 0x80, 0x00, 0x00, 0x80, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x10, 0x00, 0x06, 0x00, 0x01,
  0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x40, 0x00, 0x00, 0x07, 0xE0,
  0x30, 0xC1, 0x01, 0x88, 0x02, 0x60, 0x09, 0x00, 0x24, 0x00, 0xE0, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x80, 0x08, 0x00, 0x60, 0x01, 0x00, 0x08, 0x00, 0x20,
  0x01, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x60, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x03, 0x80, 0x0C, 0x00, 0x03, 0x00, 0x01,
  0x00, 0x03, 0x00, 0x00, 0x40, 0x03, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00,
  0x08, 0x03, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x01, 0x01, 0x00, 0x3E,
  0x00, 0x81, 0x80, 0x71, 0x80, 0x40, 0x80, 0x60, 0x60, 0x20, 0xC0, 0x60,
  0x30, 0x10, 0x40, 0x20, 0x10, 0x08, 0x60, 0x20, 0x08, 0x04, 0x20, 0x10,
  0x04, 0x02, 0x30, 0x10, 0x02, 0x01, 0x10, 0x08, 0x03, 0x00, 0x88, 0x0C,
  0x01, 0x00, 0x44, 0x04, 0x00, 0x80, 0x26, 0x02, 0x00, 0x40, 0x32, 0x03,
  0x00, 0x60, 0x11, 0x01, 0x00, 0x20, 0x08, 0x80, 0x80, 0x10, 0x04, 0x40,
  0x40, 0x08, 0x04, 0x20, 0x20, 0x0C, 0x02, 0x10, 0x10, 0x0C, 0x03, 0x08,
  0x08, 0x06, 0x01, 0x04, 0x04, 0x05, 0x01, 0x82, 0x02, 0x04, 0x41, 0x81,
  0x00, 0x84, 0x31, 0x80, 0x80, 0x7C, 0x0F, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x40, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xA0, 0x00, 0x05,
  0x00, 0x00, 0x48, 0x00, 0x02, 0x60, 0x00, 0x21, 0x00, 0x01, 0x08, 0x00,
  0x18, 0x40, 0x00, 0x82, 0x00, 0x0C, 0x10, 0x00, 0x40, 0x80, 0x06, 0x04,
  0x00, 0x20, 0x30, 0x03, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x20, 0x08,
  0x01, 0x00, 0x40, 0x08, 0x04, 0x00, 0x40, 0x20, 0x03, 0x02, 0x00, 0x18,
  0x1F, 0xFF, 0xC1, 0x00, 0x02, 0x08, 0x00, 0x10, 0xC0, 0x00, 0x84, 0x00,
  0x04, 0x60, 0x00, 0x32, 0x00, 0x01, 0xB0, 0x00, 0x05, 0x00, 0x00, 0x38,
  0x00, 0x01, 0x80, 0x00, 0x08, 0x07, 0xFF, 0x00, 0x40, 0x1C, 0x04, 0x00,
  0x60, 0x40, 0x02, 0x04, 0x00, 0x30, 0xC0, 0x01, 0x08, 0x00, 0x10, 0x80,
  0x01, 0x08, 0x00, 0x10, 0x80, 0x01, 0x08, 0x00, 0x31, 0x80, 0x02, 0x10,
  0x00, 0x61, 0x00, 0x0C, 0x10, 0x01, 0x81, 0x00, 0x70, 0x1F, 0xFE, 0x03,
  0x00, 0x30, 0x20, 0x01, 0x82, 0x00, 0x0C, 0x20, 0x00, 0x42, 0x00, 0x06,
  0x20, 0x00, 0x66, 0x00, 0x06, 0x40, 0x00, 0x44, 0x00, 0x04, 0x40, 0x00,
  0x44, 0x00, 0x08, 0x40, 0x01, 0x8C, 0x00, 0x10, 0x80, 0x06, 0x08, 0x01,
  0xC0, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x06, 0x06, 0x00, 0xC0, 0x08,
  0x0C, 0x00, 0x20, 0xC0, 0x01, 0x04, 0x00, 0x0C, 0x60, 0x00, 0x22, 0x00,
  0x01, 0x30, 0x00, 0x09, 0x00, 0x00, 0x48, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x04, 0x80, 0x00, 0x44, 0x00, 0x02,
  0x20, 0x00, 0x31, 0x80, 0x01, 0x04, 0x00, 0x18, 0x30, 0x01, 0x80, 0x80,
  0x18, 0x03, 0x03, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x10, 0x07,
  0x00, 0x40, 0x06, 0x01, 0x00, 0x0C, 0x04, 0x00, 0x18, 0x30, 0x00, 0x20,
  0x80, 0x00, 0x82, 0x00, 0x03, 0x08, 0x00, 0x04, 0x20, 0x00, 0x10, 0x80,
  0x00, 0x46, 0x00, 0x01, 0x10, 0x00, 0x04, 0x40, 0x00, 0x31, 0x00, 0x00,
  0x84, 0x00, 0x02, 0x10, 0x00, 0x08, 0xC0, 0x00, 0x22, 0x00, 0x00, 0x88,
  0x00, 0x06, 0x20, 0x00, 0x10, 0x80, 0x00, 0x42, 0x00, 0x01, 0x18, 0x00,
  0x0C, 0x40, 0x00, 0x21, 0x00, 0x01, 0x84, 0x00, 0x04, 0x10, 0x00, 0x30,
  0x40, 0x01, 0x83, 0x00, 0x0C, 0x08, 0x00, 0x60, 0x20, 0x0E, 0x00, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC,
  0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0xC0, 0x00, 0x02, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x03, 0x83, 0x80, 0x18, 0x03,
  0x00, 0x80, 0x06, 0x06, 0x00, 0x08, 0x30, 0x00, 0x30, 0x80, 0x00, 0x46,
  0x00, 0x01, 0x10, 0x00, 0x04, 0x40, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x01, 0xFF, 0x10, 0x00, 0x04, 0xC0,
  0x00, 0x12, 0x00, 0x00, 0xC8, 0x00, 0x03, 0x20, 0x00, 0x08, 0x80, 0x00,
  0x23, 0x00, 0x00, 0x84, 0x00, 0x02, 0x10, 0x00, 0x18, 0x60, 0x00, 0x60,
  0x80, 0x03, 0x03, 0x00, 0x38, 0x03, 0x07, 0x80, 0x07, 0xF0, 0x00, 0x04,
  0x00, 0x01, 0x82, 0x00, 0x00, 0x81, 0x00, 0x00, 0x40, 0x80, 0x00, 0x20,
  0x40, 0x00, 0x10, 0x60, 0x00, 0x08, 0x20, 0x00, 0x0C, 0x10, 0x00, 0x04,
  0x08, 0x00, 0x02, 0x04, 0x00, 0x01, 0x02, 0x00, 0x00, 0x83, 0x00, 0x00,
  0x41, 0x00, 0x00, 0x60, 0x80, 0x00, 0x20, 0x40, 0x00, 0x10, 0x20, 0x00,
  0x08, 0x1F, 0xFF, 0xFC, 0x18, 0x00, 0x06, 0x08, 0x00, 0x03, 0x04, 0x00,
  0x01, 0x02, 0x00, 0x00, 0x81, 0x00, 0x00, 0x40, 0x80, 0x00, 0x20, 0xC0,
  0x00, 0x30, 0x40, 0x00, 0x10, 0x20, 0x00, 0x08, 0x10, 0x00, 0x04, 0x08,
  0x00, 0x02, 0x04, 0x00, 0x01, 0x06, 0x00, 0x01, 0x82, 0x00, 0x00, 0x81,
  0x00, 0x00, 0x40, 0x80, 0x00, 0x20, 0x00, 0x02, 0x04, 0x08, 0x30, 0x60,
  0x81, 0x02, 0x04, 0x18, 0x30, 0x40, 0x81, 0x02, 0x0C, 0x10, 0x20, 0x40,
  0x81, 0x06, 0x08, 0x10, 0x20, 0x40, 0x83, 0x04, 0x08, 0x10, 0x20, 0xC0,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10,
  0x80, 0x03, 0x08, 0x00, 0x20, 0x80, 0x02, 0x08, 0x00, 0x40, 0xC0, 0x04,
  0x04, 0x00, 0x80, 0x60, 0x10, 0x03, 0x06, 0x00, 0x0F, 0xC0, 0x00, 0x04,
  0x00, 0x06, 0x04, 0x00, 0x0C, 0x04, 0x00, 0x18, 0x04, 0x00, 0x30, 0x04,
  0x00, 0x20, 0x0C, 0x00, 0x40, 0x08, 0x00, 0x80, 0x08, 0x01, 0x00, 0x08,
  0x02, 0x00, 0x08, 0x04, 0x00, 0x08, 0x08, 0x00, 0x18, 0x10, 0x00, 0x10,
  0x20, 0x00, 0x10, 0x40, 0x00, 0x10, 0x80, 0x00, 0x11, 0x80, 0x00, 0x12,
  0x40, 0x00, 0x34, 0x60, 0x00, 0x28, 0x20, 0x00, 0x30, 0x30, 0x00, 0x20,
  0x10, 0x00, 0x20, 0x18, 0x00, 0x20, 0x08, 0x00, 0x60, 0x0C, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x06, 0x00, 0x40, 0x02, 0x00, 0x40, 0x03, 0x00, 0x40,
  0x01, 0x80, 0xC0, 0x00, 0x80, 0x80, 0x00, 0xC0, 0x80, 0x00, 0x40, 0x80,
  0x00, 0x60, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01,
  0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00,
  0x40, 0x00, 0xFF, 0xFE, 0x06, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x18,
  0x18, 0x00, 0x00, 0x30, 0x38, 0x00, 0x00, 0xA0, 0x50, 0x00, 0x01, 0x41,
  0xA0, 0x00, 0x05, 0x82, 0x40, 0x00, 0x1B, 0x04, 0x80, 0x00, 0x24, 0x09,
  0x80, 0x00, 0xC8, 0x11, 0x00, 0x01, 0x10, 0x22, 0x00, 0x06, 0x20, 0xC4,
  0x00, 0x08, 0xC1, 0x08, 0x00, 0x31, 0x02, 0x10, 0x00, 0x42, 0x04, 0x30,
  0x01, 0x84, 0x08, 0x20, 0x02, 0x08, 0x10, 0x40, 0x08, 0x10, 0x60, 0x80,
  0x10, 0x60, 0x81, 0x00, 0x40, 0x81, 0x03, 0x00, 0x81, 0x02, 0x02, 0x02,
  0x02, 0x04, 0x04, 0x04, 0x04, 0x08, 0x08, 0x10, 0x08, 0x30, 0x10, 0x20,
  0x30, 0x40, 0x20, 0x80, 0x40, 0x80, 0x23, 0x00, 0x81, 0x00, 0x44, 0x01,
  0x02, 0x00, 0x98, 0x02, 0x04, 0x01, 0x20, 0x04, 0x18, 0x02, 0xC0, 0x18,
  0x20, 0x05, 0x00, 0x20, 0x40, 0x06, 0x00, 0x40, 0x80, 0x08, 0x00, 0x80,
  0x06, 0x00, 0x00, 0x83, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x40, 0xA0, 0x00,
  0x20, 0x50, 0x00, 0x10, 0x64, 0x00, 0x08, 0x32, 0x00, 0x04, 0x11, 0x00,
  0x06, 0x08, 0x40, 0x02, 0x04, 0x20, 0x01, 0x02, 0x18, 0x00, 0x83, 0x04,
  0x00, 0x41, 0x82, 0x00, 0x60, 0x80, 0x80, 0x30, 0x40, 0x40, 0x10, 0x20,
  0x30, 0x08, 0x10, 0x08, 0x04, 0x18, 0x04, 0x02, 0x0C, 0x01, 0x03, 0x04,
  0x00, 0x81, 0x82, 0x00, 0x40, 0x81, 0x00, 0x10, 0x40, 0x80, 0x08, 0x20,
  0xC0, 0x06, 0x10, 0x40, 0x01, 0x18, 0x20, 0x00, 0x8C, 0x10, 0x00, 0x24,
  0x08, 0x00, 0x12, 0x04, 0x00, 0x0D, 0x06, 0x00, 0x02, 0x82, 0x00, 0x01,
  0xC1, 0x00, 0x00, 0x60, 0x80, 0x00, 0x20, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0xE0, 0xC0, 0x06, 0x00, 0x40, 0x18, 0x00, 0x40, 0x60, 0x00, 0xC0, 0x80,
  0x00, 0x83, 0x00, 0x01, 0x04, 0x00, 0x02, 0x18, 0x00, 0x06, 0x20, 0x00,
  0x0C, 0x40, 0x00, 0x19, 0x80, 0x00, 0x22, 0x00, 0x00, 0x44, 0x00, 0x00,
  0x88, 0x00, 0x01, 0x10, 0x00, 0x02, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x11,
  0x00, 0x00, 0x22, 0x00, 0x00, 0x44, 0x00, 0x00, 0x88, 0x00, 0x03, 0x10,
  0x00, 0x04, 0x20, 0x00, 0x08, 0x40, 0x00, 0x30, 0x80, 0x00, 0x41, 0x00,
  0x00, 0x82, 0x00, 0x02, 0x02, 0x00, 0x0C, 0x04, 0x00, 0x30, 0x04, 0x00,
  0xC0, 0x06, 0x0E, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x10, 0x03,
  0x80, 0x40, 0x03, 0x01, 0x00, 0x04, 0x04, 0x00, 0x18, 0x30, 0x00, 0x20,
  0x80, 0x00, 0x82, 0x00, 0x02, 0x08, 0x00, 0x08, 0x20, 0x00, 0x20, 0x80,
  0x00, 0x86, 0x00, 0x06, 0x10, 0x00, 0x10, 0x40, 0x00, 0xC1, 0x00, 0x02,
  0x04, 0x00, 0x10, 0x10, 0x01, 0xC0, 0xC0, 0x1C, 0x03, 0xFF, 0xC0, 0x08,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x40, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xE0, 0xC0, 0x06, 0x00, 0x40, 0x18,
  0x00, 0x40, 0x60, 0x00, 0xC0, 0x80, 0x00, 0x83, 0x00, 0x01, 0x04, 0x00,
  0x02, 0x18, 0x00, 0x04, 0x20, 0x00, 0x0C, 0x40, 0x00, 0x19, 0x80, 0x00,
  0x22, 0x00, 0x00, 0x44, 0x00, 0x00, 0x88, 0x00, 0x01, 0x10, 0x00, 0x02,
  0x60, 0x00, 0x0C, 0xC0, 0x00, 0x11, 0x00, 0x00, 0x22, 0x00, 0x00, 0x44,
  0x00, 0x00, 0x88, 0x00, 0x03, 0x10, 0x00, 0x04, 0x60, 0x00, 0x08, 0x40,
  0x00, 0x30, 0x80, 0x00, 0x41, 0x00, 0x01, 0x82, 0x00, 0x02, 0x06, 0x00,
  0x0C, 0x04, 0x00, 0x30, 0x04, 0x00, 0xC0, 0x06, 0x0E, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x07, 0xFF, 0x80, 0x10, 0x03,
  0x80, 0x40, 0x03, 0x01, 0x00, 0x04, 0x04, 0x00, 0x08, 0x30, 0x00, 0x20,
  0x80, 0x00, 0x82, 0x00, 0x02, 0x08, 0x00, 0x08, 0x20, 0x00, 0x21, 0x80,
  0x00, 0x86, 0x00, 0x02, 0x10, 0x00, 0x10, 0x40, 0x00, 0x41, 0x00, 0x02,
  0x04, 0x00, 0x18, 0x30, 0x00, 0x80, 0x80, 0x0C, 0x03, 0xFF, 0xC0, 0x08,
  0x03, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x06, 0x00, 0x60, 0x10, 0x00,
  0x80, 0x40, 0x03, 0x01, 0x00, 0x04, 0x04, 0x00, 0x10, 0x10, 0x00, 0x60,
  0xC0, 0x00, 0x82, 0x00, 0x02, 0x08, 0x00, 0x0C, 0x20, 0x00, 0x10, 0x80,
  0x00, 0x40, 0x00, 0x1F, 0x80, 0x03, 0x81, 0x80, 0x18, 0x01, 0x00, 0xC0,
  0x06, 0x06, 0x00, 0x08, 0x10, 0x00, 0x30, 0x80, 0x00, 0x42, 0x00, 0x01,
  0x08, 0x00, 0x04, 0x20, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x80, 0x00, 0x02, 0x30, 0x00, 0x0C, 0x80, 0x00, 0x23, 0x00,
  0x00, 0x8C, 0x00, 0x02, 0x10, 0x00, 0x18, 0x40, 0x00, 0xC0, 0x80, 0x06,
  0x03, 0x00, 0x30, 0x03, 0x03, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0xFF, 0xF0,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00,
  0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10,
  0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x04, 0x10,
  0x00, 0x08, 0x20, 0x00, 0x10, 0xC0, 0x00, 0x21, 0x80, 0x00, 0x42, 0x00,
  0x01, 0x84, 0x00, 0x02, 0x08, 0x00, 0x04, 0x10, 0x00, 0x08, 0x60, 0x00,
  0x10, 0x80, 0x00, 0x21, 0x00, 0x00, 0xC2, 0x00, 0x01, 0x04, 0x00, 0x02,
  0x08, 0x00, 0x04, 0x30, 0x00, 0x08, 0x40, 0x00, 0x10, 0x80, 0x00, 0x61,
  0x00, 0x00, 0x82, 0x00, 0x01, 0x04, 0x00, 0x02, 0x18, 0x00, 0x04, 0x20,
  0x00, 0x08, 0x40, 0x00, 0x20, 0x80, 0x00, 0x41, 0x00, 0x00, 0x82, 0x00,
  0x03, 0x06, 0x00, 0x04, 0x0C, 0x00, 0x10, 0x0C, 0x00, 0x60, 0x08, 0x01,
  0x80, 0x0C, 0x1C, 0x00, 0x07, 0xE0, 0x00, 0x80, 0x00, 0x0B, 0x00, 0x00,
  0x6C, 0x00, 0x01, 0x10, 0x00, 0x04, 0x40, 0x00, 0x21, 0x00, 0x00, 0x84,
  0x00, 0x06, 0x10, 0x00, 0x10, 0x60, 0x00, 0xC1, 0x80, 0x02, 0x02, 0x00,
  0x18, 0x08, 0x00, 0x40, 0x20, 0x01, 0x00, 0x80, 0x08, 0x02, 0x00, 0x20,
  0x0C, 0x01, 0x00, 0x10, 0x04, 0x00, 0x40, 0x20, 0x01, 0x00, 0x80, 0x04,
  0x06, 0x00, 0x10, 0x10, 0x00, 0x40, 0xC0, 0x01, 0x82, 0x00, 0x02, 0x08,
  0x00, 0x08, 0x40, 0x00, 0x21, 0x00, 0x00, 0x88, 0x00, 0x02, 0x20, 0x00,
  0x09, 0x00, 0x00, 0x34, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x40, 0x00, 0x80, 0x01, 0x20, 0x00, 0xC0, 0x00, 0x90, 0x00,
  0x60, 0x00, 0xC8, 0x00, 0x38, 0x00, 0x44, 0x00, 0x24, 0x00, 0x22, 0x00,
  0x12, 0x00, 0x31, 0x00, 0x11, 0x00, 0x10, 0x80, 0x08, 0x80, 0x18, 0x40,
  0x04, 0x40, 0x08, 0x20, 0x04, 0x20, 0x04, 0x10, 0x02, 0x10, 0x06, 0x0C,
  0x02, 0x08, 0x02, 0x06, 0x01, 0x04, 0x01, 0x03, 0x01, 0x82, 0x01, 0x81,
  0x80, 0x81, 0x80, 0x80, 0x40, 0x40, 0xC0, 0x40, 0x20, 0x40, 0x20, 0x40,
  0x10, 0x20, 0x10, 0x20, 0x08, 0x30, 0x08, 0x30, 0x04, 0x10, 0x04, 0x10,
  0x02, 0x08, 0x02, 0x08, 0x01, 0x0C, 0x01, 0x0C, 0x00, 0x84, 0x00, 0x84,
  0x00, 0x46, 0x00, 0x42, 0x00, 0x22, 0x00, 0x22, 0x00, 0x11, 0x00, 0x19,
  0x00, 0x09, 0x80, 0x0D, 0x80, 0x06, 0x80, 0x02, 0x80, 0x03, 0x40, 0x01,
  0x40, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x10, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x80, 0xC0,
  0x00, 0x60, 0x10, 0x00, 0x30, 0x06, 0x00, 0x08, 0x00, 0x80, 0x06, 0x00,
  0x20, 0x03, 0x00, 0x0C, 0x00, 0x80, 0x01, 0x00, 0x40, 0x00, 0x60, 0x30,
  0x00, 0x08, 0x18, 0x00, 0x02, 0x04, 0x00, 0x00, 0x42, 0x00, 0x00, 0x11,
  0x80, 0x00, 0x06, 0x40, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0x20, 0x00, 0x00, 0x88, 0x00,
  0x00, 0x61, 0x00, 0x00, 0x10, 0x40, 0x00, 0x08, 0x18, 0x00, 0x06, 0x02,
  0x00, 0x03, 0x00, 0x80, 0x00, 0x80, 0x10, 0x00, 0x40, 0x04, 0x00, 0x30,
  0x01, 0x80, 0x08, 0x00, 0x20, 0x04, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x01,
  0x80, 0x00, 0x40, 0x40, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x09, 0x00, 0x00,
  0x66, 0x00, 0x01, 0x18, 0x00, 0x08, 0x20, 0x00, 0x60, 0x80, 0x01, 0x03,
  0x00, 0x08, 0x04, 0x00, 0x60, 0x10, 0x01, 0x00, 0x60, 0x08, 0x00, 0x80,
  0x60, 0x02, 0x01, 0x00, 0x0C, 0x08, 0x00, 0x10, 0x60, 0x00, 0x41, 0x00,
  0x01, 0x88, 0x00, 0x02, 0x60, 0x00, 0x09, 0x00, 0x00, 0x28, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0,
  0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xF8, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x60, 0x03, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x03, 0x00,
  0x18, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0xF8, 0x00, 0x82, 0x08, 0x20, 0xC1, 0x04, 0x10, 0x41,
  0x04, 0x18, 0x20, 0x82, 0x08, 0x20, 0x83, 0x04, 0x10, 0x41, 0x04, 0x10,
  0x60, 0x82, 0x08, 0x20, 0x82, 0x0C, 0x10, 0x41, 0x01, 0xF0, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x30, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x60, 0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x18, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C,
  0x0F, 0xC0, 0x00, 0x80, 0x18, 0x01, 0x80, 0x2C, 0x02, 0x40, 0x44, 0x04,
  0x40, 0x84, 0x18, 0x41, 0x06, 0x30, 0x22, 0x02, 0x60, 0x24, 0x02, 0xC0,
  0x28, 0x03, 0xFF, 0xFF, 0x43, 0x08, 0x61, 0x04, 0x00, 0xFC, 0x01, 0xC3,
  0x81, 0x80, 0x41, 0x00, 0x31, 0x80, 0x08, 0x80, 0x04, 0x40, 0x02, 0x00,
  0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x7F, 0xE0, 0xE0, 0x11,
  0x80, 0x09, 0x80, 0x0C, 0x80, 0x04, 0x80, 0x02, 0x40, 0x01, 0x20, 0x01,
  0x90, 0x01, 0xC8, 0x01, 0xE6, 0x01, 0xA1, 0x83, 0x10, 0x7E, 0x08, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00,
  0x21, 0xF8, 0x09, 0xC3, 0x02, 0xC0, 0x20, 0xC0, 0x0C, 0x70, 0x01, 0x18,
  0x00, 0x44, 0x00, 0x11, 0x00, 0x04, 0x40, 0x01, 0x10, 0x00, 0x4C, 0x00,
  0x13, 0x00, 0x04, 0x80, 0x03, 0x20, 0x00, 0x88, 0x00, 0x22, 0x00, 0x09,
  0x80, 0x06, 0x40, 0x01, 0x10, 0x00, 0x46, 0x00, 0x21, 0x80, 0x18, 0x50,
  0x0C, 0x33, 0x06, 0x08, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0xE1, 0xC0, 0x60,
  0x10, 0x20, 0x02, 0x18, 0x00, 0x84, 0x00, 0x23, 0x00, 0x08, 0x80, 0x02,
  0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x01, 0x30, 0x00, 0x84, 0x00,
  0x21, 0x00, 0x18, 0x60, 0x04, 0x08, 0x06, 0x01, 0x83, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x1F, 0x84, 0x06, 0x0C, 0xC0, 0xC0, 0x28, 0x18,
  0x01, 0x81, 0x00, 0x18, 0x20, 0x00, 0x82, 0x00, 0x18, 0x60, 0x01, 0x04,
  0x00, 0x10, 0x40, 0x01, 0x04, 0x00, 0x10, 0xC0, 0x01, 0x0C, 0x00, 0x30,
  0x80, 0x02, 0x08, 0x00, 0x20, 0x80, 0x02, 0x08, 0x00, 0x20, 0x80, 0x02,
  0x08, 0x00, 0x60, 0x80, 0x04, 0x04, 0x00, 0xC0, 0x40, 0x14, 0x03, 0x0E,
  0x40, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0xE1, 0xC0, 0x60, 0x10, 0x30,
  0x02, 0x18, 0x00, 0x84, 0x00, 0x23, 0x00, 0x08, 0x80, 0x02, 0x60, 0x00,
  0x90, 0x00, 0x27, 0xFF, 0xF9, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x03, 0x01, 0x83, 0x80, 0x1F, 0x80, 0x00, 0x7C,
  0x06, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00,
  0x0C, 0x00, 0x20, 0x00, 0x80, 0x3F, 0xF0, 0x08, 0x00, 0x60, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x7E, 0x10, 0x18, 0x33, 0x03, 0x00, 0xA0, 0x60, 0x06, 0x04, 0x00,
  0x60, 0x80, 0x02, 0x08, 0x00, 0x21, 0x80, 0x06, 0x10, 0x00, 0x41, 0x00,
  0x04, 0x10, 0x00, 0x43, 0x00, 0x04, 0x20, 0x00, 0x42, 0x00, 0x0C, 0x20,
  0x00, 0x82, 0x00, 0x08, 0x20, 0x00, 0x82, 0x00, 0x08, 0x20, 0x01, 0x82,
  0x00, 0x18, 0x30, 0x03, 0x01, 0x00, 0x50, 0x0C, 0x39, 0x00, 0x7E, 0x10,
  0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04,
  0x0C, 0x00, 0xC0, 0x60, 0x18, 0x03, 0x07, 0x00, 0x0F, 0xC0, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00,
  0x20, 0xF8, 0x08, 0xC1, 0x02, 0x60, 0x20, 0xB0, 0x08, 0x28, 0x03, 0x1C,
  0x00, 0x46, 0x00, 0x11, 0x80, 0x0C, 0x40, 0x03, 0x10, 0x00, 0x8C, 0x00,
  0x23, 0x00, 0x08, 0x80, 0x02, 0x20, 0x01, 0x88, 0x00, 0x42, 0x00, 0x11,
  0x80, 0x04, 0x60, 0x01, 0x10, 0x00, 0x44, 0x00, 0x31, 0x00, 0x08, 0x40,
  0x02, 0x30, 0x00, 0x8C, 0x00, 0x20, 0x03, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x04, 0x0C, 0x08, 0x08, 0x08, 0x08, 0x18, 0x18, 0x10, 0x10,
  0x10, 0x10, 0x30, 0x30, 0x20, 0x20, 0x20, 0x20, 0x60, 0x40, 0x40, 0x40,
  0x40, 0x40, 0x00, 0x06, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00,
  0x40, 0x01, 0x00, 0x06, 0x00, 0xF0, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x60,
  0x80, 0x18, 0x10, 0x06, 0x02, 0x01, 0x80, 0x40, 0x60, 0x18, 0x18, 0x02,
  0x06, 0x00, 0x41, 0x00, 0x08, 0x40, 0x01, 0x10, 0x00, 0x66, 0x00, 0x0D,
  0x40, 0x01, 0xCC, 0x00, 0x30, 0x80, 0x04, 0x18, 0x00, 0x81, 0x00, 0x30,
  0x30, 0x06, 0x02, 0x00, 0x80, 0x20, 0x10, 0x04, 0x02, 0x00, 0x40, 0x40,
  0x0C, 0x18, 0x00, 0x82, 0x00, 0x18, 0x00, 0x03, 0x02, 0x02, 0x02, 0x02,
  0x06, 0x06, 0x04, 0x04, 0x04, 0x04, 0x0C, 0x0C, 0x08, 0x08, 0x08, 0x08,
  0x18, 0x10, 0x10, 0x10, 0x10, 0x10, 0x30, 0x20, 0x20, 0x20, 0x20, 0x20,
  0x60, 0x40, 0x40, 0x40, 0x40, 0x40, 0x08, 0x3E, 0x01, 0xF0, 0x11, 0x86,
  0x0E, 0x18, 0x24, 0x02, 0x30, 0x10, 0x50, 0x04, 0xC0, 0x11, 0xC0, 0x0F,
  0x00, 0x22, 0x80, 0x1C, 0x00, 0x46, 0x00, 0x30, 0x00, 0x8C, 0x00, 0x60,
  0x01, 0x10, 0x00, 0x80, 0x02, 0x20, 0x01, 0x00, 0x04, 0xC0, 0x02, 0x00,
  0x19, 0x00, 0x04, 0x00, 0x22, 0x00, 0x08, 0x00, 0x44, 0x00, 0x30, 0x00,
  0x88, 0x00, 0x40, 0x01, 0x30, 0x00, 0x80, 0x06, 0x60, 0x01, 0x00, 0x0C,
  0x80, 0x02, 0x00, 0x11, 0x00, 0x0C, 0x00, 0x22, 0x00, 0x10, 0x00, 0x44,
  0x00, 0x20, 0x00, 0x98, 0x00, 0x40, 0x03, 0x20, 0x00, 0x80, 0x04, 0x40,
  0x01, 0x00, 0x08, 0x08, 0x3E, 0x02, 0x30, 0xC0, 0x98, 0x08, 0x2C, 0x02,
  0x0A, 0x00, 0xC7, 0x00, 0x11, 0x80, 0x04, 0x60, 0x03, 0x10, 0x00, 0xC4,
  0x00, 0x21, 0x00, 0x08, 0xC0, 0x02, 0x20, 0x00, 0x88, 0x00, 0x62, 0x00,
  0x18, 0x80, 0x04, 0x20, 0x01, 0x18, 0x00, 0x44, 0x00, 0x11, 0x00, 0x0C,
  0x40, 0x02, 0x10, 0x00, 0x8C, 0x00, 0x23, 0x00, 0x08, 0x01, 0xFC, 0x03,
  0x83, 0x03, 0x00, 0xC3, 0x00, 0x31, 0x00, 0x09, 0x80, 0x04, 0x80, 0x02,
  0xC0, 0x01, 0x40, 0x00, 0xA0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x0E, 0x00, 0x05, 0x00, 0x02, 0x80, 0x03, 0x40, 0x01, 0x20,
  0x01, 0x98, 0x00, 0x84, 0x00, 0xC3, 0x00, 0xC0, 0xC1, 0xC0, 0x1F, 0x80,
  0x04, 0x3F, 0x00, 0x9C, 0x30, 0x16, 0x01, 0x03, 0x00, 0x30, 0x60, 0x02,
  0x18, 0x00, 0x42, 0x00, 0x08, 0x40, 0x01, 0x08, 0x00, 0x21, 0x00, 0x04,
  0x20, 0x00, 0x8C, 0x00, 0x11, 0x00, 0x02, 0x20, 0x00, 0xC4, 0x00, 0x10,
  0x80, 0x02, 0x30, 0x00, 0x44, 0x00, 0x10, 0x80, 0x02, 0x18, 0x00, 0x83,
  0x00, 0x30, 0x50, 0x0C, 0x19, 0x87, 0x02, 0x1F, 0x80, 0x40, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x41, 0xC3, 0x10,
  0xC0, 0x28, 0x60, 0x06, 0x10, 0x01, 0x88, 0x00, 0x22, 0x00, 0x09, 0x80,
  0x06, 0x40, 0x01, 0x10, 0x00, 0x44, 0x00, 0x13, 0x00, 0x04, 0xC0, 0x01,
  0x20, 0x00, 0xC8, 0x00, 0x22, 0x00, 0x08, 0x80, 0x02, 0x20, 0x00, 0x88,
  0x00, 0x62, 0x00, 0x10, 0xC0, 0x0C, 0x10, 0x05, 0x03, 0x0E, 0x40, 0x7E,
  0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x08, 0x78,
  0x23, 0x00, 0x90, 0x02, 0x80, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x01, 0xF8, 0x03, 0x87, 0x03, 0x00, 0xC3, 0x00,
  0x21, 0x00, 0x10, 0x80, 0x0C, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x20, 0x01, 0x90, 0x00, 0x8C, 0x00,
  0xC2, 0x00, 0xC0, 0xC1, 0xC0, 0x1F, 0x80, 0x04, 0x06, 0x03, 0x01, 0x00,
  0x80, 0x40, 0x21, 0xFF, 0x18, 0x08, 0x04, 0x02, 0x01, 0x01, 0x80, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x0C, 0x04, 0x02, 0x01, 0x00, 0x80, 0xC0, 0x60,
  0x20, 0x10, 0x0C, 0x02, 0x00, 0xF0, 0x10, 0x00, 0x44, 0x00, 0x31, 0x00,
  0x08, 0x40, 0x02, 0x10, 0x00, 0x8C, 0x00, 0x22, 0x00, 0x08, 0x80, 0x06,
  0x20, 0x01, 0x08, 0x00, 0x46, 0x00, 0x11, 0x00, 0x04, 0x40, 0x01, 0x10,
  0x00, 0xC4, 0x00, 0x21, 0x00, 0x08, 0xC0, 0x02, 0x30, 0x01, 0x8C, 0x00,
  0x61, 0x00, 0x38, 0x40, 0x1C, 0x18, 0x0D, 0x03, 0x0E, 0x40, 0x7E, 0x10,
  0x80, 0x01, 0x80, 0x01, 0xC0, 0x02, 0xC0, 0x02, 0x40, 0x04, 0x40, 0x04,
  0x40, 0x08, 0x40, 0x08, 0x60, 0x10, 0x60, 0x10, 0x20, 0x20, 0x20, 0x20,
  0x20, 0x40, 0x20, 0x40, 0x20, 0xC0, 0x30, 0x80, 0x11, 0x80, 0x11, 0x00,
  0x13, 0x00, 0x12, 0x00, 0x16, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x08, 0x00,
  0x80, 0x08, 0x00, 0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x50, 0x07, 0x00,
  0x68, 0x02, 0x80, 0x24, 0x01, 0x60, 0x12, 0x01, 0x30, 0x19, 0x80, 0x88,
  0x08, 0xC0, 0x84, 0x0C, 0x60, 0x42, 0x04, 0x30, 0x61, 0x06, 0x08, 0x20,
  0x83, 0x04, 0x30, 0x41, 0x02, 0x10, 0x21, 0x81, 0x18, 0x10, 0x80, 0x88,
  0x08, 0xC0, 0x44, 0x06, 0x40, 0x24, 0x03, 0x20, 0x12, 0x00, 0xB0, 0x0B,
  0x00, 0x50, 0x05, 0x00, 0x38, 0x03, 0x80, 0x18, 0x01, 0x80, 0x0C, 0x00,
  0xC0, 0x04, 0x00, 0x04, 0x00, 0x30, 0x60, 0x06, 0x02, 0x00, 0x40, 0x20,
  0x08, 0x03, 0x01, 0x00, 0x10, 0x30, 0x01, 0x82, 0x00, 0x08, 0x40, 0x00,
  0xC8, 0x00, 0x05, 0x80, 0x00, 0x50, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00,
  0x0D, 0x00, 0x01, 0x90, 0x00, 0x11, 0x80, 0x02, 0x08, 0x00, 0x60, 0xC0,
  0x0C, 0x04, 0x00, 0x80, 0x40, 0x10, 0x02, 0x03, 0x00, 0x20, 0x60, 0x03,
  0x04, 0x00, 0x10, 0x04, 0x00, 0x0C, 0x18, 0x00, 0x20, 0x60, 0x01, 0x80,
  0x80, 0x04, 0x02, 0x00, 0x30, 0x08, 0x00, 0x80, 0x20, 0x06, 0x00, 0x80,
  0x10, 0x03, 0x00, 0xC0, 0x04, 0x02, 0x00, 0x10, 0x18, 0x00, 0x40, 0x40,
  0x01, 0x03, 0x00, 0x04, 0x08, 0x00, 0x18, 0x60, 0x00, 0x21, 0x00, 0x00,
  0x8C, 0x00, 0x02, 0x20, 0x00, 0x09, 0x80, 0x00, 0x24, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00,
  0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x0C,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x04, 0x00, 0x60, 0x03, 0x00, 0x10, 0x00,
  0xC0, 0x02, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x03, 0x00, 0x08, 0x00, 0x40, 0x0E, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x08,
  0x00, 0x02, 0x04, 0x18, 0x30, 0x60, 0x81, 0x02, 0x04, 0x18, 0x30, 0x40,
  0x81, 0x02, 0x0C, 0x18, 0x30, 0x40, 0x81, 0x02, 0x0C, 0x18, 0x20, 0x40,
  0x81, 0x06, 0x0C, 0x18, 0x20, 0x40, 0x81, 0x06, 0x0C, 0x10, 0x20, 0x00,
  0x01, 0x00, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0xC0, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x08, 0x00,
  0x20, 0x00, 0xC0, 0x01, 0xC0, 0x03, 0x00, 0x30, 0x01, 0x80, 0x04, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x00, 0x0F, 0x00, 0x09,
  0x8C, 0x00, 0xD8, 0x10, 0x04, 0x80, 0x40, 0x24, 0x01, 0x02, 0x40, 0x04,
  0x22, 0x00, 0x1E, 0x00,
};

const GFXglyph RobotoCondensed_ThinItalic46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 7, 33, 8, 1, -33 },
  { 30, 7, 9, 12, 5, -35 },
  { 38, 23, 33, 22, 1, -33 },
  { 133, 19, 41, 22, 2, -37 },
  { 231, 22, 33, 29, 4, -33 },
  { 322, 21, 33, 24, 1, -33 },
  { 409, 3, 9, 7, 5, -35 },
  { 413, 13, 47, 12, 2, -36 },
  { 490, 13, 47, 12, -3, -36 },
  { 567, 17, 18, 19, 3, -33 },
  { 606, 19, 23, 22, 2, -27 },
  { 661, 5, 9, 8, -1, -4 },
  { 667, 9, 1, 12, 2, -15 },
  { 669, 3, 2, 10, 1, -2 },
  { 670, 19, 36, 15, -2, -33 },
  { 756, 18, 33, 22, 2, -33 },
  { 831, 10, 33, 22, 6, -33 },
  { 873, 19, 33, 22, 1, -33 },
  { 952, 20, 33, 22, 1, -33 },
  { 1035, 19, 33, 22, 1, -33 },
  { 1114, 19, 33, 22, 3, -33 },
  { 1193, 17, 33, 22, 2, -33 },
  { 1264, 18, 33, 22, 4, -33 },
  { 1339, 20, 33, 22, 1, -33 },
  { 1422, 17, 33, 22, 3, -33 },
  { 1493, 7, 23, 8, 0, -23 },
  { 1514, 8, 28, 8, -1, -23 },
  { 1542, 17, 18, 20, 2, -24 },
  { 1581, 17, 10, 22, 3, -20 },
  { 1603, 17, 18, 20, 1, -24 },
  { 1642, 14, 33, 17, 4, -33 },
  { 1700, 33, 42, 36, 1, -32 },
  { 1874, 21, 33, 24, -1, -33 },
  { 1961, 20, 33, 24, 2, -33 },
  { 2044, 21, 33, 25, 3, -33 },
  { 2131, 22, 33, 26, 2, -33 },
  { 2222, 22, 33, 22, 2, -33 },
  { 2313, 22, 33, 22, 2, -33 },
  { 2404, 22, 33, 27, 3, -33 },
  { 2495, 25, 33, 27, 2, -33 },
  { 2599, 7, 33, 11, 2, -33 },
  { 2628, 20, 33, 22, 1, -33 },
  { 2711, 24, 33, 25, 2, -33 },
  { 2810, 15, 33, 20, 2, -33 },
  { 2872, 31, 33, 33, 2, -33 },
  { 3000, 25, 33, 28, 2, -33 },
  { 3104, 23, 33, 26, 2, -33 },
  { 3199, 22, 33, 24, 2, -33 },
  { 3290, 23, 39, 26, 2, -33 },
  { 3403, 22, 33, 26, 2, -33 },
  { 3494, 22, 33, 23, 1, -33 },
  { 3585, 20, 33, 23, 5, -33 },
  { 3668, 23, 33, 26, 3, -33 },
  { 3763, 22, 33, 24, 4, -33 },
  { 3854, 33, 33, 35, 4, -33 },
  { 3991, 26, 33, 24, -1, -33 },
  { 4099, 22, 33, 23, 4, -33 },
  { 4190, 24, 33, 23, 0, -33 },
  { 4289, 13, 44, 9, 0, -37 },
  { 4361, 6, 36, 15, 5, -33 },
  { 4388, 12, 44, 9, -3, -37 },
  { 4454, 12, 16, 17, 3, -33 },
  { 4478, 16, 1, 17, -2, 0 },
  { 4480, 5, 6, 12, 6, -35 },
  { 4484, 17, 24, 21, 1, -24 },
  { 4535, 18, 35, 22, 1, -35 },
  { 4614, 18, 24, 20, 1, -24 },
  { 4668, 20, 35, 22, 2, -35 },
  { 4756, 18, 24, 20, 1, -24 },
  { 4810, 14, 35, 13, 3, -35 },
  { 4872, 20, 33, 22, 0, -24 },
  { 4955, 18, 35, 22, 1, -35 },
  { 5034, 8, 32, 9, 1, -32 },
  { 5066, 15, 41, 9, -6, -32 },
  { 5143, 19, 35, 19, 1, -35 },
  { 5227, 8, 35, 9, 1, -35 },
  { 5262, 31, 24, 35, 1, -24 },
  { 5355, 18, 24, 22, 1, -24 },
  { 5409, 17, 24, 22, 2, -24 },
  { 5460, 19, 33, 22, 0, -24 },
  { 5539, 18, 33, 22, 2, -24 },
  { 5614, 14, 24, 14, 1, -24 },
  { 5656, 17, 24, 20, 1, -24 },
  { 5707, 9, 31, 13, 3, -31 },
  { 5742, 18, 24, 22, 2, -24 },
  { 5796, 16, 24, 19, 3, -24 },
  { 5844, 25, 24, 29, 4, -24 },
  { 5919, 20, 24, 19, -1, -24 },
  { 5979, 22, 33, 19, -2, -24 },
  { 6070, 18, 24, 19, 0, -24 },
  { 6124, 14, 46, 13, 2, -36 },
  { 6205, 7, 39, 9, 1, -33 },
  { 6240, 14, 46, 13, -3, -36 },
  { 6321, 21, 7, 27, 3, -17 },
};

const GFXfont RobotoCondensed_ThinItalic46pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ThinItalic46pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ThinItalic46pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _ROBOTOCONDENSED_THINITALIC46PT7B_H_
