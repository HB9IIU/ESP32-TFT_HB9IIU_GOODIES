#ifndef _ROBOTOCONDENSED_THINITALIC29PT7B_H_
#define _ROBOTOCONDENSED_THINITALIC29PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ThinItalic.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ThinItalic29pt7bBitmaps[] PROGMEM = {
  0x00, 0x11, 0x11, 0x22, 0x22, 0x22, 0x44, 0x44, 0x40, 0x00, 0x08, 0x80,
  0x4A, 0x54, 0xA9, 0x48, 0x00, 0x84, 0x01, 0x08, 0x04, 0x20, 0x08, 0x40,
  0x10, 0x80, 0x42, 0x07, 0xFF, 0x81, 0x08, 0x02, 0x20, 0x08, 0x40, 0x10,
  0x80, 0x22, 0x00, 0x84, 0x01, 0x08, 0x3F, 0xFE, 0x08, 0x40, 0x10, 0x80,
  0x21, 0x00, 0x84, 0x01, 0x08, 0x02, 0x10, 0x00, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x7C, 0x08, 0x21, 0x01, 0x10, 0x12, 0x01, 0x20, 0x12, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x40, 0x02, 0x80,
  0x28, 0x04, 0x80, 0x44, 0x08, 0x41, 0x83, 0xE0, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x38, 0x02, 0x20, 0x21, 0x01, 0x04, 0x28, 0x42, 0x42, 0x22, 0x11,
  0x10, 0x90, 0x89, 0x03, 0x88, 0x00, 0x80, 0x08, 0xE0, 0x48, 0x84, 0x84,
  0x44, 0x24, 0x21, 0x22, 0x0A, 0x10, 0x40, 0x84, 0x02, 0x20, 0x0E, 0x00,
  0x03, 0x80, 0x22, 0x02, 0x08, 0x10, 0x41, 0x04, 0x08, 0x20, 0x42, 0x01,
  0x20, 0x0A, 0x00, 0x60, 0x05, 0x00, 0x44, 0x04, 0x20, 0xA0, 0x8A, 0x04,
  0x50, 0x12, 0x80, 0xA4, 0x02, 0x20, 0x38, 0x82, 0x43, 0xE1, 0x00, 0x56,
  0xA0, 0x01, 0x02, 0x04, 0x04, 0x08, 0x08, 0x10, 0x10, 0x20, 0x20, 0x20,
  0x40, 0x40, 0x40, 0x40, 0x40, 0x40, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x40, 0x40, 0x40, 0x40, 0x20, 0x20, 0x10, 0x04, 0x04, 0x02, 0x02, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x02, 0x02, 0x02, 0x04, 0x04, 0x04, 0x08, 0x08, 0x10, 0x10, 0x20, 0x40,
  0x80, 0x02, 0x00, 0x80, 0x10, 0x02, 0x0E, 0x4C, 0x3E, 0x03, 0x00, 0xA0,
  0x22, 0x08, 0x23, 0x04, 0x00, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x02, 0x0F, 0xFF, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x80, 0x08, 0x00, 0x24, 0xA5, 0x00, 0xFC, 0xC0, 0x00, 0x10, 0x02,
  0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x20,
  0x02, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80, 0x00, 0x03, 0xC0, 0xC2, 0x08,
  0x21, 0x01, 0x20, 0x12, 0x01, 0x20, 0x14, 0x01, 0x40, 0x14, 0x01, 0x40,
  0x24, 0x02, 0x40, 0x28, 0x02, 0x80, 0x28, 0x04, 0x80, 0x44, 0x08, 0x40,
  0x84, 0x10, 0x3E, 0x00, 0x0C, 0xDC, 0x41, 0x08, 0x20, 0x82, 0x08, 0x21,
  0x04, 0x10, 0x41, 0x04, 0x20, 0x82, 0x08, 0x20, 0x07, 0xC0, 0x82, 0x10,
  0x22, 0x01, 0x20, 0x12, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x00, 0xFF, 0xC0, 0x07, 0xC0, 0x82, 0x10, 0x21, 0x01, 0x20, 0x12,
  0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x0C, 0x0F, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x28, 0x02, 0x80, 0x48, 0x04, 0x80, 0x84, 0x10, 0x3E, 0x00,
  0x00, 0x20, 0x06, 0x00, 0xA0, 0x0A, 0x01, 0x20, 0x24, 0x02, 0x40, 0x44,
  0x08, 0x41, 0x04, 0x10, 0x42, 0x08, 0x40, 0x84, 0x08, 0xFF, 0xF0, 0x08,
  0x00, 0x80, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x1F, 0xF1, 0x00, 0x10,
  0x01, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x3F, 0x06, 0x08, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x48, 0x04, 0x80, 0x48, 0x08, 0x80,
  0x84, 0x10, 0x3E, 0x00, 0x01, 0xE0, 0x40, 0x10, 0x04, 0x01, 0x00, 0x20,
  0x08, 0x01, 0x7C, 0x50, 0x4C, 0x05, 0x00, 0xA0, 0x14, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x48, 0x09, 0x02, 0x10, 0x81, 0xE0, 0xFF, 0xE0, 0x08,
  0x01, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0x10,
  0x04, 0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x40,
  0x08, 0x00, 0x07, 0xC0, 0x82, 0x10, 0x11, 0x01, 0x20, 0x12, 0x01, 0x20,
  0x12, 0x02, 0x20, 0x21, 0x04, 0x0F, 0x83, 0x08, 0x40, 0x44, 0x02, 0x80,
  0x28, 0x02, 0x80, 0x28, 0x04, 0x80, 0x84, 0x18, 0x3E, 0x00, 0x0F, 0x82,
  0x08, 0x81, 0x20, 0x14, 0x02, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x50, 0x0A,
  0x01, 0x20, 0x64, 0x14, 0x7C, 0x80, 0x20, 0x04, 0x01, 0x00, 0x20, 0x08,
  0x06, 0x0F, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x84, 0x22, 0x11, 0x00,
  0x00, 0x20, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x04,
  0x00, 0x60, 0x02, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x20, 0x02, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x02, 0x00, 0x00, 0x3E, 0x42, 0x81, 0x81, 0x81, 0x01, 0x01,
  0x02, 0x02, 0x04, 0x08, 0x10, 0x20, 0x20, 0x40, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x7F, 0x00, 0x18, 0x0C, 0x02, 0x00, 0x40, 0x40, 0x02,
  0x08, 0x00, 0x11, 0x80, 0x01, 0x10, 0x3C, 0x12, 0x04, 0x21, 0x20, 0x82,
  0x14, 0x10, 0x41, 0x41, 0x04, 0x14, 0x20, 0x41, 0x82, 0x04, 0x18, 0x40,
  0x81, 0x84, 0x08, 0x28, 0x40, 0x82, 0x84, 0x18, 0x48, 0x41, 0x04, 0x84,
  0x28, 0x88, 0x3C, 0x70, 0x80, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x30, 0x00, 0xFC, 0x00, 0x00, 0x20, 0x01, 0x80, 0x06,
  0x00, 0x24, 0x00, 0x90, 0x04, 0x40, 0x11, 0x00, 0x84, 0x02, 0x10, 0x10,
  0x40, 0x41, 0x01, 0x02, 0x08, 0x08, 0x20, 0x21, 0xFF, 0x84, 0x02, 0x20,
  0x08, 0x80, 0x24, 0x00, 0x50, 0x01, 0x80, 0x04, 0x0F, 0xC0, 0x80, 0x84,
  0x02, 0x20, 0x11, 0x00, 0x88, 0x04, 0x80, 0x24, 0x02, 0x20, 0x11, 0x03,
  0x0F, 0xE0, 0x40, 0xC4, 0x01, 0x20, 0x09, 0x00, 0x48, 0x02, 0x40, 0x12,
  0x01, 0x20, 0x09, 0x01, 0x8F, 0xF0, 0x00, 0x07, 0xE0, 0x40, 0x84, 0x02,
  0x40, 0x12, 0x00, 0xA0, 0x05, 0x00, 0x28, 0x00, 0x40, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x50, 0x04, 0x80, 0x24, 0x01,
  0x20, 0x10, 0x81, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x40, 0x41, 0x00, 0x84,
  0x01, 0x10, 0x04, 0x40, 0x12, 0x00, 0x48, 0x01, 0x20, 0x04, 0x80, 0x12,
  0x00, 0x48, 0x02, 0x40, 0x09, 0x00, 0x24, 0x00, 0x90, 0x04, 0x40, 0x11,
  0x00, 0x88, 0x06, 0x20, 0x20, 0xFF, 0x00, 0x0F, 0xFC, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x03, 0xFE, 0x08, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x08, 0x00, 0x20, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x03, 0xFE, 0x08, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x00, 0x03, 0xE0, 0x30,
  0x41, 0x00, 0x84, 0x01, 0x20, 0x04, 0x80, 0x14, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x08, 0x00, 0x20, 0x7E, 0x80, 0x0A, 0x00, 0x48, 0x01, 0x20,
  0x04, 0x80, 0x12, 0x00, 0x44, 0x02, 0x08, 0x30, 0x1F, 0x00, 0x10, 0x01,
  0x10, 0x01, 0x10, 0x01, 0x10, 0x02, 0x10, 0x02, 0x10, 0x02, 0x20, 0x02,
  0x20, 0x02, 0x20, 0x04, 0x20, 0x04, 0x3F, 0xFC, 0x20, 0x04, 0x40, 0x04,
  0x40, 0x04, 0x40, 0x08, 0x40, 0x08, 0x40, 0x08, 0x40, 0x08, 0x80, 0x08,
  0x80, 0x08, 0x80, 0x10, 0x11, 0x12, 0x22, 0x22, 0x24, 0x44, 0x44, 0x48,
  0x88, 0x88, 0x80, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x48, 0x04, 0x80, 0x88, 0x08, 0x81, 0x0C, 0x20, 0x3C, 0x00, 0x10,
  0x02, 0x20, 0x08, 0x40, 0x20, 0x80, 0x81, 0x02, 0x02, 0x08, 0x08, 0x20,
  0x10, 0x80, 0x22, 0x00, 0x48, 0x00, 0xA8, 0x01, 0x90, 0x02, 0x10, 0x08,
  0x20, 0x10, 0x20, 0x20, 0x40, 0x40, 0x40, 0x80, 0x82, 0x00, 0x84, 0x01,
  0x08, 0x01, 0x00, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x08, 0x02, 0x00, 0xFF, 0xC0, 0x08, 0x00, 0x21, 0x80, 0x02, 0x18,
  0x00, 0x61, 0x80, 0x06, 0x14, 0x00, 0xA1, 0x40, 0x12, 0x24, 0x01, 0x22,
  0x40, 0x24, 0x24, 0x02, 0x42, 0x20, 0x44, 0x22, 0x04, 0x42, 0x20, 0x84,
  0x42, 0x08, 0x44, 0x21, 0x08, 0x42, 0x10, 0x84, 0x12, 0x08, 0x41, 0x20,
  0x84, 0x14, 0x08, 0x81, 0x40, 0x88, 0x08, 0x10, 0x80, 0x81, 0x00, 0x08,
  0x01, 0x18, 0x01, 0x18, 0x01, 0x14, 0x02, 0x14, 0x02, 0x12, 0x02, 0x22,
  0x02, 0x22, 0x02, 0x21, 0x02, 0x21, 0x04, 0x20, 0x84, 0x20, 0x84, 0x40,
  0x84, 0x40, 0x44, 0x40, 0x44, 0x40, 0x48, 0x40, 0x28, 0x40, 0x28, 0x80,
  0x18, 0x80, 0x18, 0x80, 0x18, 0x07, 0xE0, 0x20, 0x41, 0x00, 0x88, 0x02,
  0x20, 0x09, 0x00, 0x14, 0x00, 0x50, 0x02, 0x80, 0x0A, 0x00, 0x28, 0x00,
  0xA0, 0x02, 0x80, 0x0A, 0x00, 0x48, 0x01, 0x20, 0x04, 0x80, 0x22, 0x00,
  0x88, 0x04, 0x10, 0x20, 0x3E, 0x00, 0x0F, 0xE0, 0x40, 0x61, 0x00, 0x84,
  0x01, 0x10, 0x04, 0x40, 0x12, 0x00, 0x48, 0x02, 0x20, 0x08, 0x80, 0x42,
  0x02, 0x0F, 0xF0, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x00, 0x03, 0xF0, 0x08, 0x10, 0x20,
  0x10, 0x80, 0x21, 0x00, 0x44, 0x00, 0x48, 0x00, 0x90, 0x02, 0x40, 0x04,
  0x80, 0x09, 0x00, 0x12, 0x00, 0x24, 0x00, 0x48, 0x01, 0x20, 0x02, 0x40,
  0x04, 0x40, 0x10, 0x80, 0x21, 0x00, 0x81, 0x02, 0x01, 0xF8, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x0F, 0xE0, 0x40, 0x61, 0x00, 0x84,
  0x01, 0x10, 0x04, 0x40, 0x12, 0x00, 0x48, 0x02, 0x20, 0x08, 0x80, 0x42,
  0x02, 0x0F, 0xF0, 0x40, 0x81, 0x02, 0x04, 0x04, 0x10, 0x10, 0x40, 0x42,
  0x00, 0x88, 0x02, 0x20, 0x08, 0x80, 0x10, 0x03, 0xE0, 0x30, 0x41, 0x00,
  0x88, 0x02, 0x20, 0x08, 0x80, 0x22, 0x00, 0x08, 0x00, 0x10, 0x00, 0x30,
  0x00, 0x38, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x20, 0x04, 0x80,
  0x12, 0x00, 0x88, 0x02, 0x10, 0x30, 0x3F, 0x00, 0xFF, 0xF8, 0x10, 0x00,
  0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x00, 0x20, 0x04, 0x80, 0x12, 0x00,
  0x48, 0x01, 0x20, 0x09, 0x00, 0x24, 0x00, 0x90, 0x02, 0x40, 0x09, 0x00,
  0x24, 0x01, 0x20, 0x04, 0x80, 0x12, 0x00, 0x48, 0x01, 0x20, 0x04, 0x80,
  0x22, 0x00, 0x88, 0x04, 0x10, 0x20, 0x3F, 0x00, 0x80, 0x0C, 0x00, 0xA0,
  0x05, 0x00, 0x28, 0x02, 0x40, 0x12, 0x01, 0x08, 0x08, 0x40, 0x82, 0x04,
  0x10, 0x40, 0x82, 0x04, 0x10, 0x21, 0x00, 0x88, 0x04, 0x80, 0x24, 0x01,
  0x40, 0x0A, 0x00, 0x60, 0x01, 0x00, 0x00, 0x80, 0x40, 0x18, 0x04, 0x01,
  0x80, 0xA0, 0x28, 0x0A, 0x02, 0x80, 0xA0, 0x48, 0x12, 0x04, 0x81, 0x20,
  0x48, 0x22, 0x08, 0x82, 0x20, 0x88, 0x22, 0x08, 0x84, 0x21, 0x08, 0x41,
  0x10, 0x48, 0x11, 0x04, 0x81, 0x20, 0x48, 0x12, 0x05, 0x01, 0x40, 0x50,
  0x14, 0x06, 0x01, 0x40, 0x60, 0x18, 0x06, 0x01, 0x80, 0x40, 0x18, 0x00,
  0x10, 0x02, 0x08, 0x02, 0x08, 0x04, 0x08, 0x08, 0x04, 0x10, 0x04, 0x10,
  0x02, 0x20, 0x02, 0x40, 0x02, 0x40, 0x01, 0x80, 0x01, 0x00, 0x02, 0x80,
  0x02, 0x80, 0x04, 0x40, 0x08, 0x40, 0x10, 0x40, 0x10, 0x20, 0x20, 0x20,
  0x40, 0x10, 0x40, 0x10, 0x80, 0x10, 0x80, 0x0C, 0x00, 0xA0, 0x04, 0x80,
  0x44, 0x04, 0x20, 0x20, 0x82, 0x04, 0x20, 0x21, 0x00, 0x90, 0x05, 0x00,
  0x28, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x02, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0x08, 0x08,
  0x08, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x20, 0x20,
  0x20, 0x20, 0x20, 0x20, 0x20, 0x40, 0x40, 0x40, 0x40, 0x40, 0x40, 0x80,
  0xF0, 0x88, 0x88, 0x44, 0x44, 0x44, 0x44, 0x22, 0x22, 0x22, 0x21, 0x11,
  0x10, 0x0F, 0x01, 0x01, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x04,
  0x04, 0x04, 0x04, 0x04, 0x04, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08,
  0x10, 0x10, 0x10, 0x10, 0xF0, 0x04, 0x18, 0x50, 0xA2, 0x44, 0x50, 0xA1,
  0x83, 0x04, 0xFF, 0xC0, 0x89, 0x10, 0x07, 0xC0, 0x82, 0x10, 0x22, 0x01,
  0x00, 0x20, 0x02, 0x00, 0x20, 0xFE, 0x30, 0x24, 0x02, 0x40, 0x48, 0x04,
  0x80, 0x48, 0x0C, 0x43, 0x43, 0xC4, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x40, 0x09, 0xE1, 0x42, 0x30, 0x24, 0x05, 0x00, 0xA0, 0x14, 0x02,
  0x80, 0x50, 0x0A, 0x01, 0x80, 0x50, 0x0A, 0x01, 0x40, 0x4E, 0x11, 0x3C,
  0x00, 0x0F, 0x82, 0x08, 0x81, 0x20, 0x14, 0x02, 0x80, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x28, 0x09, 0x01, 0x10, 0x41, 0xE0, 0x00,
  0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x3E, 0x42, 0x0A,
  0x20, 0x21, 0x01, 0x10, 0x08, 0x80, 0x44, 0x02, 0x40, 0x22, 0x01, 0x10,
  0x08, 0x80, 0x44, 0x02, 0x20, 0x11, 0x01, 0x04, 0x18, 0x1F, 0x40, 0x0F,
  0x82, 0x08, 0x81, 0x20, 0x14, 0x02, 0x80, 0x7F, 0xF4, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x10, 0x41, 0xF0, 0x07, 0x08, 0x10,
  0x10, 0x10, 0x20, 0xFC, 0x20, 0x20, 0x20, 0x20, 0x40, 0x40, 0x40, 0x40,
  0x40, 0x40, 0x80, 0x80, 0x80, 0x80, 0x80, 0x07, 0xC8, 0x41, 0x84, 0x04,
  0x20, 0x22, 0x01, 0x10, 0x08, 0x80, 0x48, 0x04, 0x40, 0x22, 0x01, 0x10,
  0x08, 0x80, 0x44, 0x02, 0x20, 0x20, 0x83, 0x03, 0xE8, 0x00, 0x40, 0x02,
  0x00, 0x21, 0x01, 0x04, 0x10, 0x1F, 0x00, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x40, 0x09, 0xE1, 0x42, 0x30, 0x24, 0x04, 0x80, 0xA0, 0x14,
  0x02, 0x80, 0x50, 0x12, 0x02, 0x40, 0x50, 0x0A, 0x01, 0x40, 0x28, 0x09,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x00, 0x84, 0x21, 0x08, 0x44, 0x21, 0x08,
  0x42, 0x21, 0x08, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x20, 0x08, 0x02,
  0x01, 0x03, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x08,
  0x09, 0x02, 0x20, 0x84, 0x20, 0x88, 0x22, 0x04, 0x80, 0xB0, 0x1A, 0x02,
  0x20, 0x44, 0x10, 0x42, 0x08, 0x40, 0x88, 0x11, 0x01, 0x00, 0x11, 0x11,
  0x11, 0x22, 0x22, 0x22, 0x44, 0x44, 0x44, 0x88, 0x88, 0x27, 0x83, 0xC5,
  0x09, 0x84, 0xC0, 0xC0, 0x90, 0x18, 0x16, 0x02, 0x02, 0x80, 0x40, 0x50,
  0x08, 0x0A, 0x02, 0x01, 0x40, 0x40, 0x28, 0x08, 0x06, 0x01, 0x01, 0x40,
  0x20, 0x28, 0x04, 0x05, 0x01, 0x00, 0xA0, 0x20, 0x14, 0x04, 0x02, 0x27,
  0x85, 0x08, 0xC0, 0x90, 0x12, 0x02, 0x80, 0x50, 0x0A, 0x01, 0x40, 0x48,
  0x09, 0x01, 0x40, 0x28, 0x05, 0x00, 0xA0, 0x24, 0x04, 0x0F, 0x82, 0x08,
  0x80, 0x90, 0x14, 0x02, 0x80, 0x50, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01,
  0x40, 0x28, 0x05, 0x01, 0x10, 0x41, 0xF0, 0x13, 0xC1, 0x42, 0x18, 0x11,
  0x01, 0x20, 0x12, 0x01, 0x20, 0x12, 0x01, 0x20, 0x12, 0x01, 0x40, 0x24,
  0x02, 0x40, 0x24, 0x04, 0x70, 0x84, 0xF0, 0x40, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x0F, 0x91, 0x06, 0x20, 0x22, 0x02, 0x40, 0x24,
  0x02, 0x40, 0x28, 0x04, 0x80, 0x48, 0x04, 0x80, 0x48, 0x04, 0x80, 0x48,
  0x08, 0x41, 0x83, 0xE8, 0x00, 0x80, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00,
  0x10, 0x27, 0x28, 0x30, 0x20, 0x20, 0x40, 0x40, 0x40, 0x40, 0x40, 0x40,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x07, 0x83, 0x08, 0x40, 0x90, 0x12, 0x00,
  0x40, 0x06, 0x00, 0x30, 0x01, 0x00, 0x10, 0x01, 0x00, 0x28, 0x04, 0x81,
  0x10, 0x61, 0xF0, 0x10, 0x42, 0x3F, 0x20, 0x82, 0x10, 0x41, 0x04, 0x10,
  0x42, 0x08, 0x20, 0x82, 0x06, 0x00, 0x20, 0x12, 0x02, 0x20, 0x22, 0x02,
  0x40, 0x24, 0x02, 0x40, 0x24, 0x04, 0x40, 0x44, 0x04, 0x80, 0x48, 0x04,
  0x80, 0xC4, 0x18, 0x43, 0x83, 0xC8, 0x80, 0x60, 0x18, 0x0A, 0x02, 0x81,
  0x10, 0x44, 0x21, 0x08, 0x42, 0x11, 0x04, 0x41, 0x20, 0x28, 0x0C, 0x03,
  0x00, 0x80, 0x80, 0x81, 0x81, 0x81, 0x81, 0x81, 0x82, 0x82, 0x42, 0x82,
  0x42, 0x84, 0x44, 0x84, 0x44, 0x44, 0x48, 0x48, 0x48, 0x48, 0x48, 0x50,
  0x50, 0x50, 0x50, 0x50, 0x60, 0x60, 0x60, 0x60, 0x40, 0x40, 0x20, 0x11,
  0x02, 0x10, 0x40, 0x88, 0x08, 0x80, 0x90, 0x06, 0x00, 0x60, 0x06, 0x00,
  0xA0, 0x11, 0x01, 0x10, 0x21, 0x04, 0x08, 0x40, 0x88, 0x04, 0x10, 0x08,
  0x80, 0x44, 0x04, 0x20, 0x21, 0x02, 0x04, 0x10, 0x21, 0x01, 0x08, 0x08,
  0x40, 0x44, 0x02, 0x20, 0x0A, 0x00, 0x50, 0x03, 0x00, 0x18, 0x00, 0x80,
  0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x70, 0x00, 0x1F, 0xF0,
  0x02, 0x00, 0x40, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x0F, 0xFC, 0x00, 0x80,
  0x80, 0x80, 0x80, 0x40, 0x40, 0x20, 0x10, 0x08, 0x04, 0x04, 0x02, 0x01,
  0x01, 0x03, 0x00, 0x80, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x80, 0x40, 0x10, 0x08, 0x06, 0x01, 0x80, 0x11, 0x11, 0x12, 0x22, 0x22,
  0x22, 0x44, 0x44, 0x44, 0x88, 0x88, 0x88, 0x80, 0x0C, 0x01, 0x00, 0x80,
  0x20, 0x10, 0x08, 0x04, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x08,
  0x02, 0x06, 0x04, 0x02, 0x01, 0x00, 0x80, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x08, 0x04, 0x0C, 0x08, 0x00, 0x38, 0x0A, 0x20, 0x60, 0x83, 0x02, 0x28,
  0x0E, 0x00,
};

const GFXglyph RobotoCondensed_ThinItalic29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 4, 21, 5, 1, -21 },
  { 12, 5, 6, 7, 3, -22 },
  { 16, 15, 21, 14, 0, -21 },
  { 56, 12, 27, 14, 1, -24 },
  { 97, 13, 21, 18, 3, -21 },
  { 132, 13, 21, 15, 1, -21 },
  { 167, 2, 6, 5, 3, -22 },
  { 169, 8, 30, 8, 1, -23 },
  { 199, 8, 30, 8, -2, -23 },
  { 229, 11, 11, 12, 2, -21 },
  { 245, 12, 15, 14, 1, -17 },
  { 268, 3, 6, 5, -1, -2 },
  { 271, 6, 1, 8, 1, -10 },
  { 272, 1, 2, 6, 1, -2 },
  { 273, 12, 23, 10, -1, -21 },
  { 308, 12, 21, 14, 1, -21 },
  { 340, 6, 21, 14, 4, -21 },
  { 356, 12, 21, 14, 1, -21 },
  { 388, 12, 21, 14, 1, -21 },
  { 420, 12, 21, 14, 1, -21 },
  { 452, 12, 21, 14, 2, -21 },
  { 484, 11, 21, 14, 1, -21 },
  { 513, 11, 21, 14, 3, -21 },
  { 542, 12, 21, 14, 1, -21 },
  { 574, 11, 21, 14, 2, -21 },
  { 603, 4, 16, 5, 0, -16 },
  { 611, 5, 20, 5, -1, -16 },
  { 624, 11, 11, 13, 1, -15 },
  { 640, 10, 7, 14, 2, -13 },
  { 649, 11, 11, 13, 1, -15 },
  { 665, 8, 21, 11, 3, -21 },
  { 686, 20, 26, 23, 1, -20 },
  { 751, 14, 21, 15, -1, -21 },
  { 788, 13, 21, 15, 1, -21 },
  { 823, 13, 21, 16, 2, -21 },
  { 858, 14, 21, 16, 1, -21 },
  { 895, 14, 21, 14, 1, -21 },
  { 932, 14, 21, 14, 1, -21 },
  { 969, 14, 21, 17, 2, -21 },
  { 1006, 16, 21, 17, 1, -21 },
  { 1048, 4, 21, 7, 2, -21 },
  { 1059, 12, 21, 14, 1, -21 },
  { 1091, 15, 21, 16, 1, -21 },
  { 1131, 10, 21, 13, 1, -21 },
  { 1158, 20, 21, 21, 1, -21 },
  { 1211, 16, 21, 17, 1, -21 },
  { 1253, 14, 21, 16, 2, -21 },
  { 1290, 14, 21, 15, 1, -21 },
  { 1327, 15, 25, 16, 1, -21 },
  { 1374, 14, 21, 16, 1, -21 },
  { 1411, 14, 21, 15, 1, -21 },
  { 1448, 13, 21, 15, 3, -21 },
  { 1483, 14, 21, 16, 2, -21 },
  { 1520, 13, 21, 15, 3, -21 },
  { 1555, 20, 21, 22, 3, -21 },
  { 1608, 16, 21, 15, 0, -21 },
  { 1650, 13, 21, 15, 3, -21 },
  { 1685, 15, 21, 15, 0, -21 },
  { 1725, 8, 28, 6, 0, -24 },
  { 1753, 4, 23, 10, 3, -21 },
  { 1765, 8, 28, 6, -2, -24 },
  { 1793, 7, 10, 10, 2, -21 },
  { 1802, 10, 1, 10, -1, 0 },
  { 1804, 3, 4, 7, 4, -22 },
  { 1806, 12, 16, 13, 0, -16 },
  { 1830, 11, 22, 14, 1, -22 },
  { 1861, 11, 16, 13, 1, -16 },
  { 1883, 13, 22, 14, 1, -22 },
  { 1919, 11, 16, 13, 1, -16 },
  { 1941, 8, 22, 8, 2, -22 },
  { 1963, 13, 22, 14, 0, -16 },
  { 1999, 11, 22, 14, 1, -22 },
  { 2030, 5, 22, 5, 1, -22 },
  { 2044, 10, 28, 6, -4, -22 },
  { 2079, 11, 22, 12, 1, -22 },
  { 2110, 4, 22, 5, 1, -22 },
  { 2121, 19, 16, 22, 1, -16 },
  { 2159, 11, 16, 14, 1, -16 },
  { 2181, 11, 16, 14, 1, -16 },
  { 2203, 12, 22, 14, 0, -16 },
  { 2236, 12, 22, 14, 1, -16 },
  { 2269, 8, 16, 9, 1, -16 },
  { 2285, 11, 16, 12, 0, -16 },
  { 2307, 6, 19, 8, 2, -19 },
  { 2322, 12, 16, 14, 1, -16 },
  { 2346, 10, 16, 12, 2, -16 },
  { 2366, 16, 16, 19, 2, -16 },
  { 2398, 12, 16, 12, 0, -16 },
  { 2422, 13, 22, 12, -1, -16 },
  { 2458, 12, 16, 12, 0, -16 },
  { 2482, 9, 29, 8, 1, -23 },
  { 2515, 4, 25, 6, 1, -21 },
  { 2528, 9, 29, 8, -2, -23 },
  { 2561, 13, 5, 17, 2, -11 },
};

const GFXfont RobotoCondensed_ThinItalic29pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ThinItalic29pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ThinItalic29pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _ROBOTOCONDENSED_THINITALIC29PT7B_H_
