#ifndef _ROBOTOCONDENSED_THINITALIC59PT7B_H_
#define _ROBOTOCONDENSED_THINITALIC59PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ThinItalic.ttf
// Size: 59pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ThinItalic59pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x08, 0x04, 0x06, 0x03, 0x01,
  0x80, 0x80, 0x40, 0x20, 0x30, 0x18, 0x0C, 0x04, 0x02, 0x01, 0x01, 0x80,
  0xC0, 0x40, 0x20, 0x10, 0x18, 0x0C, 0x06, 0x02, 0x01, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x70,
  0x00, 0x00, 0x30, 0xCC, 0x33, 0x0C, 0xC2, 0x31, 0x88, 0x66, 0x19, 0x86,
  0x61, 0x18, 0x44, 0x31, 0x0C, 0x00, 0x00, 0x80, 0x20, 0x00, 0x0C, 0x03,
  0x00, 0x00, 0x60, 0x18, 0x00, 0x02, 0x00, 0x80, 0x00, 0x30, 0x0C, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x08, 0x02, 0x00, 0x00, 0x40, 0x30, 0x00, 0x06,
  0x01, 0x80, 0x00, 0x20, 0x08, 0x00, 0x01, 0x00, 0x40, 0x00, 0x18, 0x06,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x04, 0x01, 0x00, 0x00, 0x60, 0x18, 0x00,
  0x02, 0x00, 0x80, 0x00, 0x10, 0x04, 0x00, 0x01, 0x80, 0x60, 0x00, 0x0C,
  0x03, 0x00, 0x00, 0x40, 0x10, 0x00, 0x06, 0x01, 0x80, 0x00, 0x30, 0x0C,
  0x00, 0x01, 0x00, 0x40, 0x00, 0x18, 0x06, 0x00, 0x00, 0xC0, 0x30, 0x00,
  0x04, 0x01, 0x00, 0x00, 0x60, 0x18, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x10,
  0x04, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0C, 0x03, 0x00, 0x00, 0x40, 0x10,
  0x00, 0x02, 0x01, 0x80, 0x00, 0x30, 0x0C, 0x00, 0x01, 0x00, 0x40, 0x00,
  0x08, 0x06, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x04, 0x01, 0x00, 0x00, 0x20,
  0x18, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x10, 0x04, 0x00, 0x00, 0x80, 0x20,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x70, 0x38, 0x00, 0x60, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x60, 0x00,
  0xC0, 0x60, 0x00, 0x60, 0x20, 0x00, 0x30, 0x30, 0x00, 0x08, 0x18, 0x00,
  0x04, 0x08, 0x00, 0x02, 0x04, 0x00, 0x01, 0x02, 0x00, 0x00, 0x81, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x86, 0x00, 0x00,
  0x43, 0x00, 0x00, 0x21, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x18, 0x20, 0x00,
  0x18, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x03, 0x00, 0x0C, 0x00, 0xC0,
  0x0E, 0x00, 0x30, 0x1C, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0E, 0x18,
  0x00, 0x01, 0x80, 0x80, 0x00, 0x18, 0x0C, 0x00, 0x03, 0x00, 0x40, 0x00,
  0x20, 0x04, 0x00, 0xC6, 0x00, 0x40, 0x18, 0x60, 0x04, 0x01, 0x04, 0x00,
  0x40, 0x30, 0x40, 0x0C, 0x06, 0x04, 0x00, 0xC0, 0x40, 0x40, 0x0C, 0x0C,
  0x04, 0x00, 0x81, 0x80, 0x40, 0x18, 0x10, 0x04, 0x01, 0x03, 0x00, 0x60,
  0x30, 0x60, 0x06, 0x06, 0x04, 0x00, 0x30, 0xC0, 0xC0, 0x01, 0xF8, 0x18,
  0x00, 0x04, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x08, 0x1F, 0xC0, 0x01, 0x83, 0x06, 0x00, 0x30,
  0x60, 0x20, 0x02, 0x04, 0x03, 0x00, 0x60, 0xC0, 0x30, 0x0C, 0x08, 0x03,
  0x00, 0x81, 0x80, 0x10, 0x18, 0x18, 0x03, 0x03, 0x01, 0x00, 0x30, 0x60,
  0x10, 0x03, 0x04, 0x03, 0x00, 0x30, 0xC0, 0x30, 0x02, 0x18, 0x03, 0x00,
  0x61, 0x00, 0x30, 0x06, 0x10, 0x01, 0x00, 0x40, 0x00, 0x10, 0x0C, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x01, 0x83, 0x00, 0x00,
  0xC0, 0x60, 0x00, 0x60, 0x18, 0x00, 0x30, 0x02, 0x00, 0x0C, 0x00, 0x80,
  0x02, 0x00, 0x20, 0x01, 0x80, 0x08, 0x00, 0x60, 0x06, 0x00, 0x10, 0x01,
  0x80, 0x04, 0x00, 0xC0, 0x01, 0x00, 0x20, 0x00, 0x60, 0x18, 0x00, 0x18,
  0x0C, 0x00, 0x02, 0x06, 0x00, 0x00, 0x87, 0x00, 0x00, 0x33, 0x00, 0x00,
  0x05, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x31, 0x80, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x0C, 0x00, 0x02, 0x01,
  0x00, 0x31, 0x80, 0x60, 0x08, 0xC0, 0x0C, 0x02, 0x20, 0x03, 0x01, 0x98,
  0x00, 0x60, 0x64, 0x00, 0x18, 0x13, 0x00, 0x03, 0x0C, 0xC0, 0x00, 0x42,
  0x30, 0x00, 0x19, 0x8C, 0x00, 0x02, 0x43, 0x00, 0x00, 0xF0, 0xC0, 0x00,
  0x18, 0x30, 0x00, 0x0E, 0x06, 0x00, 0x06, 0xC1, 0x80, 0x03, 0x10, 0x30,
  0x01, 0x86, 0x07, 0x01, 0x80, 0x80, 0xFF, 0xC0, 0x30, 0x02, 0x00, 0x00,
  0x33, 0x32, 0x26, 0x66, 0x44, 0xCC, 0x00, 0x01, 0x00, 0x03, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x30, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0,
  0x00, 0x80, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00,
  0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x60, 0x00, 0x20, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80,
  0x00, 0x80, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x30, 0x00, 0x60, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60,
  0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x03,
  0x00, 0x04, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x01, 0xC0,
  0x30, 0x1D, 0xE0, 0xC3, 0xC1, 0xE2, 0x3C, 0x00, 0xFF, 0x80, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x19, 0x00, 0x00, 0x46, 0x00, 0x03, 0x08, 0x00,
  0x18, 0x30, 0x00, 0xC0, 0x60, 0x06, 0x01, 0x80, 0x30, 0x03, 0x01, 0xC0,
  0x0C, 0x06, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04,
  0x18, 0x30, 0x60, 0xC1, 0x06, 0x0C, 0x30, 0x61, 0x82, 0x00, 0xFF, 0xE0,
  0x27, 0xF4, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x01, 0xC0, 0xC0, 0x06, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x60,
  0x01, 0x80, 0xC0, 0x01, 0x03, 0x00, 0x03, 0x04, 0x00, 0x06, 0x18, 0x00,
  0x0C, 0x20, 0x00, 0x18, 0xC0, 0x00, 0x11, 0x80, 0x00, 0x22, 0x00, 0x00,
  0xC4, 0x00, 0x01, 0x98, 0x00, 0x03, 0x30, 0x00, 0x06, 0x40, 0x00, 0x0C,
  0x80, 0x00, 0x1B, 0x00, 0x00, 0x26, 0x00, 0x00, 0x4C, 0x00, 0x01, 0x98,
  0x00, 0x03, 0x20, 0x00, 0x06, 0x40, 0x00, 0x0D, 0x80, 0x00, 0x13, 0x00,
  0x00, 0x26, 0x00, 0x00, 0xCC, 0x00, 0x01, 0x90, 0x00, 0x02, 0x20, 0x00,
  0x04, 0x40, 0x00, 0x18, 0x80, 0x00, 0x31, 0x00, 0x00, 0xC3, 0x00, 0x01,
  0x86, 0x00, 0x02, 0x0C, 0x00, 0x0C, 0x08, 0x00, 0x30, 0x18, 0x00, 0x60,
  0x30, 0x01, 0x80, 0x30, 0x06, 0x00, 0x30, 0x38, 0x00, 0x3F, 0xC0, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x10, 0x07, 0x80, 0xF4, 0x1C, 0x67, 0x83, 0x60,
  0x18, 0x00, 0x80, 0x04, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x0E, 0x07, 0x00, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0x60, 0x0C, 0x00, 0x18, 0x04, 0x00, 0x0C, 0x06, 0x00,
  0x02, 0x02, 0x00, 0x01, 0x03, 0x00, 0x00, 0x81, 0x00, 0x00, 0x40, 0x80,
  0x00, 0x20, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x70, 0x38,
  0x00, 0xE0, 0x0C, 0x01, 0x80, 0x06, 0x03, 0x00, 0x02, 0x03, 0x00, 0x03,
  0x06, 0x00, 0x03, 0x04, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x03,
  0x08, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0xC0, 0x00, 0x0C, 0x80, 0x00, 0x08, 0xC0, 0x00, 0x08, 0xC0, 0x00, 0x18,
  0xC0, 0x00, 0x10, 0xC0, 0x00, 0x30, 0x40, 0x00, 0x20, 0x60, 0x00, 0x60,
  0x30, 0x00, 0xC0, 0x38, 0x01, 0x80, 0x1E, 0x07, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x40, 0x00, 0x01, 0x20, 0x00, 0x01, 0xB0, 0x00, 0x01,
  0x98, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x84, 0x00, 0x00, 0xC2, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x41, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x60, 0x60, 0x00,
  0x60, 0x20, 0x00, 0x20, 0x10, 0x00, 0x30, 0x18, 0x00, 0x30, 0x0C, 0x00,
  0x30, 0x06, 0x00, 0x10, 0x02, 0x00, 0x18, 0x01, 0x00, 0x18, 0x00, 0x80,
  0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x10,
  0x04, 0x00, 0x08, 0x06, 0x00, 0x04, 0x06, 0x00, 0x06, 0x07, 0xFF, 0xFF,
  0xFC, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x08, 0x7E, 0x00, 0x1B, 0xFF, 0x80, 0x1E, 0x00, 0xC0,
  0x18, 0x00, 0x60, 0x10, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30,
  0x80, 0x00, 0x30, 0x80, 0x00, 0x20, 0x80, 0x00, 0x20, 0x80, 0x00, 0x60,
  0xC0, 0x00, 0x40, 0xC0, 0x00, 0xC0, 0x40, 0x01, 0x80, 0x60, 0x01, 0x80,
  0x30, 0x07, 0x00, 0x1C, 0x0E, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0x80, 0x00, 0x70, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x02, 0x07, 0xE0, 0x30, 0xFF, 0xC1, 0x98, 0x07, 0x09,
  0x80, 0x0C, 0x58, 0x00, 0x67, 0x80, 0x01, 0xB8, 0x00, 0x0D, 0x80, 0x00,
  0x6C, 0x00, 0x01, 0x40, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x02,
  0x80, 0x00, 0x36, 0x00, 0x01, 0xB0, 0x00, 0x09, 0x80, 0x00, 0xC6, 0x00,
  0x0C, 0x30, 0x00, 0x60, 0xC0, 0x06, 0x07, 0x00, 0x60, 0x1C, 0x0E, 0x00,
  0x3F, 0xC0, 0x00, 0x30, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xC0, 0xE0, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x03, 0x00, 0x30,
  0x00, 0x60, 0x18, 0x00, 0x18, 0x04, 0x00, 0x02, 0x03, 0x00, 0x00, 0xC0,
  0x80, 0x00, 0x30, 0x60, 0x00, 0x0C, 0x18, 0x00, 0x02, 0x06, 0x00, 0x00,
  0x81, 0x80, 0x00, 0x60, 0x60, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x02, 0x00,
  0x02, 0x00, 0xC0, 0x01, 0x80, 0x18, 0x01, 0xC0, 0x03, 0x00, 0xE0, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1C, 0x0E, 0x00, 0x0C, 0x00, 0xC0,
  0x06, 0x00, 0x18, 0x03, 0x00, 0x03, 0x01, 0x80, 0x00, 0x40, 0xC0, 0x00,
  0x18, 0x20, 0x00, 0x06, 0x18, 0x00, 0x01, 0x86, 0x00, 0x00, 0x61, 0x00,
  0x00, 0x18, 0x40, 0x00, 0x06, 0x10, 0x00, 0x01, 0x04, 0x00, 0x00, 0x41,
  0x00, 0x00, 0x30, 0x40, 0x00, 0x08, 0x18, 0x00, 0x06, 0x06, 0x00, 0x03,
  0x00, 0xC0, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x03, 0x81, 0xE0, 0x00, 0x7F,
  0xE0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x1C,
  0x0E, 0x00, 0xC0, 0x1C, 0x06, 0x00, 0x30, 0x30, 0x00, 0x60, 0x80, 0x01,
  0x86, 0x00, 0x02, 0x10, 0x00, 0x0C, 0xC0, 0x00, 0x32, 0x00, 0x00, 0xD8,
  0x00, 0x03, 0x60, 0x00, 0x0D, 0x00, 0x00, 0x34, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x2C, 0x00, 0x00, 0xB0, 0x00, 0x06,
  0xC0, 0x00, 0x19, 0x00, 0x00, 0xE6, 0x00, 0x07, 0x98, 0x00, 0x14, 0x20,
  0x00, 0x90, 0xC0, 0x0E, 0xC1, 0x80, 0x63, 0x03, 0xDF, 0x08, 0x03, 0xF0,
  0x20, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x01, 0xFE, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x02, 0x07, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0xE0, 0xE0, 0x00,
  0x00, 0x40, 0x1C, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x00, 0xC0, 0x18, 0x02, 0x00, 0xC0,
  0x30, 0x06, 0x00, 0x80, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x04, 0x00, 0x3F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x10, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x70, 0x60, 0x30, 0x0C, 0x18, 0x01,
  0x8C, 0x00, 0x63, 0x00, 0x09, 0x80, 0x02, 0x60, 0x00, 0x90, 0x00, 0x2C,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00,
  0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x06,
  0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00,
  0x70, 0x00, 0x00, 0x10, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x70, 0x00,
  0x00, 0x02, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x00,
  0x40, 0x30, 0x00, 0x00, 0x00, 0x20, 0x30, 0x00, 0x7E, 0x00, 0x18, 0x18,
  0x00, 0x7F, 0x80, 0x0C, 0x18, 0x00, 0xE0, 0x60, 0x06, 0x0C, 0x00, 0xC0,
  0x18, 0x03, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0x86, 0x00, 0x40, 0x04, 0x00,
  0xC6, 0x00, 0x60, 0x02, 0x00, 0x63, 0x00, 0x20, 0x03, 0x00, 0x31, 0x00,
  0x30, 0x01, 0x80, 0x19, 0x80, 0x10, 0x00, 0x80, 0x0C, 0xC0, 0x18, 0x00,
  0x40, 0x06, 0x40, 0x08, 0x00, 0x60, 0x03, 0x20, 0x0C, 0x00, 0x30, 0x01,
  0x30, 0x06, 0x00, 0x18, 0x00, 0x98, 0x02, 0x00, 0x08, 0x00, 0xC8, 0x01,
  0x00, 0x04, 0x00, 0x64, 0x01, 0x80, 0x06, 0x00, 0x22, 0x00, 0xC0, 0x03,
  0x00, 0x13, 0x00, 0x40, 0x01, 0x00, 0x19, 0x80, 0x20, 0x01, 0x80, 0x08,
  0xC0, 0x10, 0x00, 0xC0, 0x04, 0x60, 0x08, 0x00, 0x60, 0x06, 0x30, 0x04,
  0x00, 0x70, 0x02, 0x18, 0x02, 0x00, 0x70, 0x03, 0x0C, 0x01, 0x00, 0x28,
  0x01, 0x06, 0x00, 0x80, 0x26, 0x01, 0x83, 0x00, 0x60, 0x33, 0x01, 0x81,
  0x80, 0x18, 0x60, 0xC3, 0x80, 0xC0, 0x0F, 0xE0, 0x3F, 0x00, 0x20, 0x00,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x02, 0x20, 0x00, 0x00, 0x62, 0x00, 0x00, 0x04, 0x20, 0x00, 0x00, 0xC2,
  0x00, 0x00, 0x08, 0x30, 0x00, 0x01, 0x83, 0x00, 0x00, 0x10, 0x30, 0x00,
  0x03, 0x03, 0x00, 0x00, 0x20, 0x10, 0x00, 0x02, 0x01, 0x00, 0x00, 0x60,
  0x10, 0x00, 0x04, 0x01, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x08, 0x01, 0x80,
  0x01, 0x80, 0x18, 0x00, 0x10, 0x00, 0x80, 0x03, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x06, 0x00, 0x08, 0x00, 0x40, 0x00, 0xC0, 0x0C, 0x00, 0x0C,
  0x00, 0x80, 0x00, 0xC0, 0x18, 0x00, 0x0C, 0x01, 0xFF, 0xFF, 0xC0, 0x30,
  0x00, 0x04, 0x02, 0x00, 0x00, 0x40, 0x60, 0x00, 0x06, 0x04, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x61, 0x80, 0x00, 0x06, 0x18,
  0x00, 0x00, 0x23, 0x00, 0x00, 0x02, 0x30, 0x00, 0x00, 0x32, 0x00, 0x00,
  0x03, 0x60, 0x00, 0x00, 0x34, 0x00, 0x00, 0x03, 0x01, 0xFF, 0xF0, 0x00,
  0x30, 0x0F, 0xC0, 0x06, 0x00, 0x1C, 0x00, 0x80, 0x00, 0xC0, 0x10, 0x00,
  0x0C, 0x02, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x10, 0x18, 0x00, 0x02, 0x03,
  0x00, 0x00, 0x40, 0x40, 0x00, 0x08, 0x08, 0x00, 0x01, 0x01, 0x00, 0x00,
  0x60, 0x60, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0x01, 0x80, 0x00, 0x60, 0x20,
  0x00, 0x08, 0x04, 0x00, 0x03, 0x01, 0x80, 0x01, 0xC0, 0x30, 0x00, 0x70,
  0x06, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x10, 0x00, 0x70, 0x02, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x30, 0x18, 0x00, 0x03, 0x03, 0x00, 0x00, 0x60,
  0x40, 0x00, 0x04, 0x08, 0x00, 0x00, 0x81, 0x00, 0x00, 0x10, 0x60, 0x00,
  0x02, 0x0C, 0x00, 0x00, 0x41, 0x80, 0x00, 0x08, 0x20, 0x00, 0x03, 0x04,
  0x00, 0x00, 0x40, 0x80, 0x00, 0x18, 0x30, 0x00, 0x03, 0x06, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x30, 0x10, 0x00, 0x0C, 0x02, 0x00, 0x07, 0x00, 0x40,
  0x0F, 0xC0, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x1C, 0x07, 0x00, 0x07, 0x00, 0x18, 0x00, 0xC0, 0x00, 0xC0,
  0x18, 0x00, 0x06, 0x01, 0x00, 0x00, 0x60, 0x30, 0x00, 0x02, 0x06, 0x00,
  0x00, 0x30, 0x40, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03,
  0x08, 0x00, 0x00, 0x31, 0x80, 0x00, 0x03, 0x18, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x84, 0x00, 0x00, 0x18, 0x40, 0x00,
  0x01, 0x04, 0x00, 0x00, 0x10, 0x40, 0x00, 0x03, 0x06, 0x00, 0x00, 0x20,
  0x60, 0x00, 0x06, 0x02, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x18, 0x01, 0x80,
  0x03, 0x80, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x1C, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0C, 0x03, 0xF0, 0x00,
  0x60, 0x00, 0xC0, 0x02, 0x00, 0x03, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x80,
  0x00, 0x30, 0x0C, 0x00, 0x00, 0x80, 0x60, 0x00, 0x06, 0x03, 0x00, 0x00,
  0x30, 0x10, 0x00, 0x00, 0x80, 0x80, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x30,
  0x60, 0x00, 0x01, 0x83, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x60, 0x80,
  0x00, 0x02, 0x04, 0x00, 0x00, 0x10, 0x60, 0x00, 0x00, 0x83, 0x00, 0x00,
  0x0C, 0x18, 0x00, 0x00, 0x60, 0x80, 0x00, 0x03, 0x04, 0x00, 0x00, 0x10,
  0x20, 0x00, 0x00, 0x83, 0x00, 0x00, 0x04, 0x18, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x03, 0x04, 0x00, 0x00, 0x18, 0x20, 0x00, 0x00, 0x81, 0x00, 0x00,
  0x04, 0x18, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x02, 0x06, 0x00, 0x00, 0x30,
  0x20, 0x00, 0x01, 0x01, 0x00, 0x00, 0x18, 0x08, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x0C, 0x06, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x0C, 0x01, 0x00, 0x01,
  0xC0, 0x08, 0x00, 0x38, 0x00, 0x40, 0x3F, 0x80, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xFF, 0xF8, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xE0, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x3C, 0x07, 0x00, 0x07, 0x00, 0x18, 0x00, 0xC0, 0x00,
  0xC0, 0x18, 0x00, 0x06, 0x03, 0x00, 0x00, 0x60, 0x20, 0x00, 0x02, 0x06,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x30, 0x80, 0x00,
  0x03, 0x18, 0x00, 0x00, 0x31, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x03, 0xFF, 0xC4, 0x00,
  0x00, 0x0C, 0x40, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x00,
  0x8C, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x01, 0x0C, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x03, 0x04, 0x00, 0x00,
  0x30, 0x60, 0x00, 0x03, 0x06, 0x00, 0x00, 0x30, 0x30, 0x00, 0x06, 0x03,
  0x00, 0x01, 0xC0, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x1E, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x01, 0x80, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x03, 0x01, 0x00, 0x00, 0x03, 0x01, 0x00, 0x00,
  0x02, 0x01, 0x00, 0x00, 0x02, 0x03, 0x00, 0x00, 0x02, 0x03, 0x00, 0x00,
  0x06, 0x03, 0x00, 0x00, 0x06, 0x02, 0x00, 0x00, 0x06, 0x02, 0x00, 0x00,
  0x04, 0x06, 0x00, 0x00, 0x04, 0x06, 0x00, 0x00, 0x04, 0x06, 0x00, 0x00,
  0x0C, 0x04, 0x00, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x0C, 0x04, 0x00, 0x00,
  0x08, 0x0C, 0x00, 0x00, 0x08, 0x0C, 0x00, 0x00, 0x08, 0x0C, 0x00, 0x00,
  0x18, 0x0F, 0xFF, 0xFF, 0xF8, 0x08, 0x00, 0x00, 0x18, 0x08, 0x00, 0x00,
  0x10, 0x18, 0x00, 0x00, 0x10, 0x18, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00,
  0x30, 0x10, 0x00, 0x00, 0x30, 0x10, 0x00, 0x00, 0x20, 0x10, 0x00, 0x00,
  0x20, 0x30, 0x00, 0x00, 0x20, 0x30, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00,
  0x60, 0x20, 0x00, 0x00, 0x60, 0x20, 0x00, 0x00, 0x40, 0x20, 0x00, 0x00,
  0x40, 0x60, 0x00, 0x00, 0x40, 0x60, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00,
  0xC0, 0x40, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x00, 0x80, 0x40, 0x00, 0x00,
  0x80, 0xC0, 0x00, 0x00, 0x80, 0x01, 0x80, 0xC0, 0x40, 0x20, 0x10, 0x18,
  0x0C, 0x06, 0x02, 0x01, 0x00, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x08, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0x80, 0x40, 0x60, 0x30, 0x18, 0x0C, 0x04, 0x02,
  0x03, 0x01, 0x80, 0xC0, 0x40, 0x20, 0x10, 0x18, 0x0C, 0x06, 0x02, 0x01,
  0x00, 0x80, 0xC0, 0x60, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x83, 0x00, 0x00,
  0x40, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x0C, 0x0C, 0x00, 0x02, 0x01, 0x00,
  0x01, 0x80, 0x40, 0x00, 0x40, 0x18, 0x00, 0x30, 0x06, 0x00, 0x18, 0x00,
  0xC0, 0x0C, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00,
  0xC0, 0x08, 0x00, 0x03, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x30,
  0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x0C, 0x00,
  0x04, 0x00, 0x30, 0x00, 0x08, 0x00, 0xE0, 0x00, 0x30, 0x03, 0x80, 0x00,
  0x60, 0x0E, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x01, 0x00, 0xE0, 0x00, 0x02,
  0x03, 0x80, 0x00, 0x04, 0x0E, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x30,
  0xE0, 0x00, 0x00, 0x63, 0xC0, 0x00, 0x00, 0x8D, 0x80, 0x00, 0x01, 0x31,
  0x80, 0x00, 0x02, 0xC3, 0x00, 0x00, 0x0F, 0x03, 0x00, 0x00, 0x1C, 0x06,
  0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x40, 0x04, 0x00, 0x00, 0x80, 0x0C,
  0x00, 0x01, 0x00, 0x08, 0x00, 0x06, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x20, 0x00, 0x30, 0x00, 0x40, 0x00, 0x60,
  0x00, 0x80, 0x00, 0x60, 0x03, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0xC0,
  0x0C, 0x00, 0x01, 0x80, 0x10, 0x00, 0x01, 0x80, 0x20, 0x00, 0x01, 0x00,
  0x40, 0x00, 0x03, 0x01, 0x80, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x0F, 0xFF, 0xFF, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x01, 0x40, 0x00, 0x00,
  0x0A, 0x01, 0x40, 0x00, 0x00, 0x1A, 0x01, 0x60, 0x00, 0x00, 0x16, 0x03,
  0x60, 0x00, 0x00, 0x36, 0x03, 0x60, 0x00, 0x00, 0x26, 0x03, 0x20, 0x00,
  0x00, 0x64, 0x02, 0x20, 0x00, 0x00, 0x44, 0x02, 0x20, 0x00, 0x00, 0xCC,
  0x02, 0x30, 0x00, 0x00, 0x8C, 0x06, 0x30, 0x00, 0x01, 0x8C, 0x06, 0x10,
  0x00, 0x03, 0x0C, 0x06, 0x10, 0x00, 0x03, 0x08, 0x04, 0x10, 0x00, 0x06,
  0x08, 0x04, 0x18, 0x00, 0x04, 0x18, 0x0C, 0x18, 0x00, 0x0C, 0x18, 0x0C,
  0x18, 0x00, 0x08, 0x18, 0x0C, 0x08, 0x00, 0x18, 0x10, 0x08, 0x08, 0x00,
  0x10, 0x10, 0x08, 0x08, 0x00, 0x30, 0x10, 0x08, 0x0C, 0x00, 0x20, 0x30,
  0x18, 0x0C, 0x00, 0x60, 0x30, 0x18, 0x04, 0x00, 0x40, 0x30, 0x18, 0x04,
  0x00, 0xC0, 0x20, 0x10, 0x04, 0x00, 0x80, 0x20, 0x10, 0x06, 0x01, 0x80,
  0x20, 0x10, 0x06, 0x01, 0x00, 0x60, 0x30, 0x02, 0x03, 0x00, 0x60, 0x30,
  0x02, 0x06, 0x00, 0x60, 0x30, 0x02, 0x06, 0x00, 0x40, 0x20, 0x02, 0x0C,
  0x00, 0x40, 0x20, 0x03, 0x0C, 0x00, 0x40, 0x20, 0x03, 0x18, 0x00, 0xC0,
  0x60, 0x01, 0x10, 0x00, 0xC0, 0x60, 0x01, 0x30, 0x00, 0xC0, 0x60, 0x01,
  0x20, 0x00, 0x80, 0x40, 0x01, 0xE0, 0x00, 0x80, 0x40, 0x01, 0xC0, 0x01,
  0x80, 0x40, 0x00, 0xC0, 0x01, 0x80, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x00, 0x01, 0x01, 0xC0, 0x00, 0x01, 0x01, 0xC0, 0x00, 0x03, 0x01,
  0xC0, 0x00, 0x03, 0x01, 0x60, 0x00, 0x03, 0x03, 0x20, 0x00, 0x03, 0x03,
  0x30, 0x00, 0x02, 0x03, 0x30, 0x00, 0x02, 0x03, 0x10, 0x00, 0x06, 0x03,
  0x18, 0x00, 0x06, 0x02, 0x08, 0x00, 0x06, 0x06, 0x08, 0x00, 0x06, 0x06,
  0x0C, 0x00, 0x04, 0x06, 0x04, 0x00, 0x04, 0x06, 0x06, 0x00, 0x0C, 0x04,
  0x02, 0x00, 0x0C, 0x04, 0x02, 0x00, 0x0C, 0x0C, 0x03, 0x00, 0x0C, 0x0C,
  0x01, 0x00, 0x08, 0x0C, 0x01, 0x80, 0x08, 0x0C, 0x01, 0x80, 0x18, 0x08,
  0x00, 0x80, 0x18, 0x08, 0x00, 0xC0, 0x18, 0x18, 0x00, 0x40, 0x10, 0x18,
  0x00, 0x60, 0x10, 0x18, 0x00, 0x60, 0x30, 0x18, 0x00, 0x20, 0x30, 0x10,
  0x00, 0x30, 0x30, 0x10, 0x00, 0x10, 0x30, 0x30, 0x00, 0x10, 0x20, 0x30,
  0x00, 0x18, 0x20, 0x30, 0x00, 0x08, 0x60, 0x30, 0x00, 0x0C, 0x60, 0x20,
  0x00, 0x04, 0x60, 0x20, 0x00, 0x04, 0x60, 0x60, 0x00, 0x06, 0x40, 0x60,
  0x00, 0x02, 0x40, 0x60, 0x00, 0x03, 0xC0, 0x40, 0x00, 0x03, 0xC0, 0x40,
  0x00, 0x01, 0xC0, 0x40, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0xE0,
  0x03, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0x00,
  0x80, 0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0x30, 0x20, 0x00, 0x00, 0x83,
  0x00, 0x00, 0x04, 0x10, 0x00, 0x00, 0x21, 0x80, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0x0C, 0x40, 0x00, 0x00, 0x42, 0x00, 0x00, 0x02, 0x30, 0x00, 0x00,
  0x11, 0x80, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x00, 0x62,
  0x00, 0x00, 0x03, 0x10, 0x00, 0x00, 0x11, 0x80, 0x00, 0x00, 0x8C, 0x00,
  0x00, 0x0C, 0x60, 0x00, 0x00, 0x62, 0x00, 0x00, 0x03, 0x10, 0x00, 0x00,
  0x18, 0x80, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x04, 0x60, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x01, 0x86, 0x00,
  0x00, 0x08, 0x10, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x04, 0x06, 0x00, 0x00,
  0x60, 0x30, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x60, 0x02, 0x00, 0x07, 0x00,
  0x1C, 0x00, 0x60, 0x00, 0x78, 0x1E, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x18, 0x01, 0xF0, 0x01, 0x80,
  0x03, 0x80, 0x10, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x60, 0x10, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x20, 0x30, 0x00, 0x03, 0x03, 0x00, 0x00, 0x30, 0x20,
  0x00, 0x03, 0x02, 0x00, 0x00, 0x30, 0x20, 0x00, 0x03, 0x06, 0x00, 0x00,
  0x20, 0x60, 0x00, 0x02, 0x06, 0x00, 0x00, 0x60, 0x40, 0x00, 0x06, 0x04,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x30, 0x08, 0x00, 0x06, 0x00, 0x80, 0x01, 0xC0, 0x0F, 0xC1, 0xF8, 0x01,
  0xFF, 0xFC, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0xC0, 0x00, 0x30, 0x04, 0x00, 0x00, 0x80, 0x60, 0x00, 0x06, 0x06,
  0x00, 0x00, 0x30, 0x20, 0x00, 0x00, 0x83, 0x00, 0x00, 0x04, 0x10, 0x00,
  0x00, 0x21, 0x80, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x08, 0x40, 0x00, 0x00,
  0x42, 0x00, 0x00, 0x02, 0x30, 0x00, 0x00, 0x11, 0x80, 0x00, 0x01, 0x8C,
  0x00, 0x00, 0x0C, 0x40, 0x00, 0x00, 0x62, 0x00, 0x00, 0x03, 0x10, 0x00,
  0x00, 0x11, 0x80, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00,
  0x62, 0x00, 0x00, 0x03, 0x10, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x8C,
  0x00, 0x00, 0x04, 0x60, 0x00, 0x00, 0x63, 0x00, 0x00, 0x03, 0x18, 0x00,
  0x00, 0x10, 0xC0, 0x00, 0x01, 0x86, 0x00, 0x00, 0x08, 0x10, 0x00, 0x00,
  0xC0, 0x80, 0x00, 0x04, 0x06, 0x00, 0x00, 0x60, 0x30, 0x00, 0x06, 0x00,
  0xC0, 0x00, 0x60, 0x02, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x00, 0x78,
  0x1E, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x18, 0x01, 0xF0, 0x01, 0x00, 0x03, 0x80, 0x10, 0x00,
  0x0C, 0x01, 0x00, 0x00, 0x60, 0x30, 0x00, 0x02, 0x03, 0x00, 0x00, 0x30,
  0x30, 0x00, 0x03, 0x02, 0x00, 0x00, 0x30, 0x20, 0x00, 0x03, 0x02, 0x00,
  0x00, 0x30, 0x60, 0x00, 0x03, 0x06, 0x00, 0x00, 0x30, 0x60, 0x00, 0x02,
  0x04, 0x00, 0x00, 0x20, 0x40, 0x00, 0x06, 0x04, 0x00, 0x00, 0x40, 0xC0,
  0x00, 0x0C, 0x0C, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x10, 0x08, 0x00, 0x06,
  0x00, 0x80, 0x00, 0xC0, 0x18, 0x00, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x18,
  0x00, 0x40, 0x01, 0x00, 0x06, 0x00, 0x10, 0x00, 0x60, 0x01, 0x00, 0x02,
  0x00, 0x30, 0x00, 0x30, 0x03, 0x00, 0x03, 0x00, 0x30, 0x00, 0x10, 0x02,
  0x00, 0x01, 0x80, 0x20, 0x00, 0x18, 0x02, 0x00, 0x00, 0x80, 0x60, 0x00,
  0x0C, 0x06, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x04, 0x04, 0x00, 0x00, 0x60,
  0x40, 0x00, 0x06, 0x04, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0x80,
  0xE0, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x06, 0x00, 0x60, 0x00, 0x10,
  0x06, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x06, 0x02, 0x00, 0x00, 0x10, 0x10,
  0x00, 0x00, 0x81, 0x80, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x20, 0x60, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x02, 0x08, 0x00, 0x00, 0x10, 0x40, 0x00,
  0x00, 0x82, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x60, 0x80, 0x00, 0x02,
  0x06, 0x00, 0x00, 0x30, 0x30, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x38, 0x03,
  0x00, 0x03, 0x80, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x0F, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x20, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x08, 0x00, 0x00, 0x30,
  0x20, 0x00, 0x00, 0x80, 0x80, 0x00, 0x02, 0x06, 0x00, 0x00, 0x08, 0x18,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x01, 0x81, 0x00, 0x00, 0x04, 0x04, 0x00,
  0x00, 0x10, 0x30, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x0C, 0x0C, 0x00, 0x00, 0x30, 0x20, 0x00, 0x00, 0x80, 0x80, 0x00, 0x02,
  0x06, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0x60, 0x60, 0x00, 0x01, 0x81,
  0x00, 0x00, 0x06, 0x04, 0x00, 0x00, 0x10, 0x10, 0x00, 0x00, 0x40, 0xC0,
  0x00, 0x01, 0x03, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x30, 0x20, 0x00,
  0x00, 0xC0, 0x80, 0x00, 0x02, 0x02, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00,
  0x20, 0x60, 0x00, 0x01, 0x81, 0x80, 0x00, 0x06, 0x04, 0x00, 0x00, 0x10,
  0x10, 0x00, 0x00, 0x40, 0x40, 0x00, 0x03, 0x01, 0x00, 0x00, 0x0C, 0x06,
  0x00, 0x00, 0x60, 0x18, 0x00, 0x01, 0x80, 0x60, 0x00, 0x0C, 0x00, 0xC0,
  0x00, 0x60, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x18, 0x00, 0x0E, 0x03,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x64, 0x00, 0x00, 0x0C,
  0x40, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x08, 0x60, 0x00, 0x01, 0x86, 0x00,
  0x00, 0x10, 0x60, 0x00, 0x03, 0x02, 0x00, 0x00, 0x20, 0x20, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x40, 0x30, 0x00, 0x0C, 0x03, 0x00, 0x00, 0xC0, 0x30,
  0x00, 0x18, 0x01, 0x00, 0x01, 0x80, 0x10, 0x00, 0x30, 0x01, 0x00, 0x03,
  0x00, 0x18, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x01,
  0x80, 0x0C, 0x00, 0x08, 0x00, 0x80, 0x00, 0x80, 0x18, 0x00, 0x08, 0x01,
  0x00, 0x00, 0xC0, 0x30, 0x00, 0x0C, 0x02, 0x00, 0x00, 0xC0, 0x60, 0x00,
  0x04, 0x06, 0x00, 0x00, 0x40, 0x40, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x40,
  0x80, 0x00, 0x06, 0x18, 0x00, 0x00, 0x61, 0x00, 0x00, 0x06, 0x30, 0x00,
  0x00, 0x22, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x24, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xB0,
  0x00, 0x06, 0x00, 0x00, 0xD8, 0x00, 0x07, 0x80, 0x00, 0x6C, 0x00, 0x02,
  0xC0, 0x00, 0x26, 0x00, 0x03, 0x60, 0x00, 0x33, 0x00, 0x01, 0x30, 0x00,
  0x11, 0x80, 0x00, 0x88, 0x00, 0x18, 0xC0, 0x00, 0xC4, 0x00, 0x0C, 0x60,
  0x00, 0x42, 0x00, 0x04, 0x30, 0x00, 0x61, 0x00, 0x06, 0x08, 0x00, 0x20,
  0x80, 0x03, 0x04, 0x00, 0x30, 0x40, 0x01, 0x02, 0x00, 0x18, 0x20, 0x01,
  0x81, 0x00, 0x08, 0x18, 0x00, 0x80, 0x80, 0x0C, 0x0C, 0x00, 0xC0, 0x40,
  0x04, 0x06, 0x00, 0x60, 0x30, 0x06, 0x03, 0x00, 0x20, 0x18, 0x03, 0x01,
  0x80, 0x30, 0x0C, 0x01, 0x00, 0x40, 0x18, 0x06, 0x01, 0x80, 0x20, 0x08,
  0x03, 0x00, 0x80, 0x10, 0x0C, 0x01, 0x80, 0xC0, 0x08, 0x04, 0x00, 0xC0,
  0x60, 0x04, 0x06, 0x00, 0x60, 0x20, 0x02, 0x03, 0x00, 0x30, 0x30, 0x01,
  0x81, 0x00, 0x08, 0x10, 0x00, 0xC1, 0x80, 0x04, 0x18, 0x00, 0x60, 0xC0,
  0x02, 0x0C, 0x00, 0x30, 0x40, 0x01, 0x04, 0x00, 0x18, 0x60, 0x00, 0x86,
  0x00, 0x0C, 0x20, 0x00, 0x42, 0x00, 0x02, 0x30, 0x00, 0x33, 0x00, 0x01,
  0x18, 0x00, 0x19, 0x80, 0x00, 0x88, 0x00, 0x0C, 0x80, 0x00, 0x4C, 0x00,
  0x06, 0xC0, 0x00, 0x26, 0x00, 0x03, 0x40, 0x00, 0x12, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x60, 0x00, 0x01, 0x80, 0x30, 0x00,
  0x01, 0x80, 0x08, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0x80, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x10,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x02, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x20, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x20, 0x30, 0x00, 0x00,
  0x18, 0x30, 0x00, 0x00, 0x04, 0x10, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00,
  0x00, 0x98, 0x00, 0x00, 0x00, 0x48, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0D, 0x00, 0x00,
  0x00, 0x04, 0xC0, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0x06, 0x18, 0x00,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0x02, 0x03, 0x00, 0x00, 0x03, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x40, 0x00, 0x03, 0x00, 0x30, 0x00, 0x01, 0x80, 0x08,
  0x00, 0x01, 0x80, 0x06, 0x00, 0x01, 0x80, 0x03, 0x00, 0x00, 0x80, 0x00,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x10, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x40, 0x00, 0x06, 0x00, 0x60, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x00, 0x20, 0x00, 0x60, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x06, 0x60, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x30, 0x10, 0x00, 0x03, 0x01, 0x80, 0x00, 0x60, 0x18,
  0x00, 0x0C, 0x00, 0x80, 0x00, 0xC0, 0x0C, 0x00, 0x18, 0x00, 0xC0, 0x01,
  0x00, 0x04, 0x00, 0x30, 0x00, 0x60, 0x06, 0x00, 0x06, 0x00, 0x40, 0x00,
  0x20, 0x0C, 0x00, 0x03, 0x01, 0x80, 0x00, 0x30, 0x10, 0x00, 0x01, 0x03,
  0x00, 0x00, 0x10, 0x60, 0x00, 0x01, 0x84, 0x00, 0x00, 0x08, 0xC0, 0x00,
  0x00, 0x98, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFE, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x40, 0x00, 0xFE, 0x00, 0xC0, 0xC0, 0xC0, 0x40, 0x40, 0x40, 0x60, 0x60,
  0x60, 0x60, 0x20, 0x20, 0x20, 0x30, 0x30, 0x30, 0x30, 0x10, 0x10, 0x10,
  0x18, 0x18, 0x18, 0x18, 0x08, 0x08, 0x08, 0x0C, 0x0C, 0x0C, 0x0C, 0x04,
  0x04, 0x04, 0x06, 0x06, 0x06, 0x06, 0x02, 0x02, 0x02, 0x03, 0x03, 0x03,
  0x03, 0x01, 0x00, 0x7F, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0xFE, 0x00, 0x00, 0x10, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x68, 0x00, 0x48, 0x00, 0xC8, 0x00, 0x88, 0x01, 0x8C,
  0x01, 0x0C, 0x03, 0x0C, 0x02, 0x04, 0x06, 0x04, 0x04, 0x04, 0x0C, 0x06,
  0x08, 0x06, 0x18, 0x06, 0x10, 0x02, 0x30, 0x02, 0x20, 0x02, 0x60, 0x03,
  0x40, 0x03, 0xFF, 0xFF, 0xF8, 0xE1, 0x83, 0x0C, 0x18, 0x60, 0xC3, 0x00,
  0x02, 0x00, 0x00, 0xFF, 0x80, 0x0E, 0x07, 0x00, 0x60, 0x06, 0x03, 0x00,
  0x0C, 0x18, 0x00, 0x30, 0xC0, 0x00, 0x43, 0x00, 0x01, 0x08, 0x00, 0x04,
  0x60, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x80, 0x1F, 0xFE, 0x03, 0xFF, 0xF8, 0x38, 0x00,
  0x61, 0x80, 0x01, 0x0C, 0x00, 0x04, 0x60, 0x00, 0x11, 0x80, 0x00, 0xCC,
  0x00, 0x03, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x22, 0x00, 0x01, 0x88, 0x00,
  0x0E, 0x30, 0x00, 0x78, 0xC0, 0x03, 0x61, 0x80, 0x19, 0x83, 0x03, 0xC6,
  0x07, 0xFC, 0x18, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x00, 0x83, 0xFC, 0x01, 0x1C,
  0x0C, 0x06, 0x60, 0x0C, 0x0F, 0x00, 0x0C, 0x1C, 0x00, 0x18, 0x30, 0x00,
  0x10, 0x60, 0x00, 0x20, 0x80, 0x00, 0x63, 0x00, 0x00, 0xC6, 0x00, 0x01,
  0x8C, 0x00, 0x03, 0x10, 0x00, 0x06, 0x20, 0x00, 0x08, 0x40, 0x00, 0x11,
  0x80, 0x00, 0x23, 0x00, 0x00, 0xC6, 0x00, 0x01, 0x88, 0x00, 0x03, 0x10,
  0x00, 0x04, 0x20, 0x00, 0x08, 0xC0, 0x00, 0x31, 0x80, 0x00, 0x63, 0x00,
  0x00, 0x84, 0x00, 0x03, 0x08, 0x00, 0x06, 0x30, 0x00, 0x18, 0x70, 0x00,
  0x20, 0xF0, 0x00, 0xC1, 0x30, 0x03, 0x02, 0x38, 0x1C, 0x04, 0x1F, 0xE0,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x1C, 0x0E,
  0x00, 0xC0, 0x0C, 0x06, 0x00, 0x18, 0x30, 0x00, 0x60, 0x80, 0x00, 0x86,
  0x00, 0x03, 0x10, 0x00, 0x0C, 0xC0, 0x00, 0x32, 0x00, 0x00, 0xC8, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x02, 0x20, 0x00, 0x08, 0xC0, 0x00,
  0x63, 0x00, 0x01, 0x0C, 0x00, 0x0C, 0x10, 0x00, 0x20, 0x60, 0x01, 0x80,
  0xC0, 0x0C, 0x01, 0xC0, 0xE0, 0x03, 0xFE, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x0C, 0x00, 0x04, 0x03, 0x00, 0x1F, 0xE0, 0xC0, 0x1C, 0x0E, 0x20,
  0x0C, 0x00, 0xC8, 0x06, 0x00, 0x16, 0x01, 0x00, 0x03, 0x80, 0xC0, 0x00,
  0xE0, 0x20, 0x00, 0x10, 0x18, 0x00, 0x04, 0x04, 0x00, 0x01, 0x03, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x30, 0x20, 0x00, 0x0C, 0x08, 0x00, 0x02, 0x06,
  0x00, 0x00, 0x81, 0x80, 0x00, 0x20, 0x60, 0x00, 0x18, 0x10, 0x00, 0x06,
  0x04, 0x00, 0x01, 0x81, 0x00, 0x00, 0x40, 0x40, 0x00, 0x10, 0x30, 0x00,
  0x04, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x30, 0x10,
  0x00, 0x08, 0x04, 0x00, 0x06, 0x01, 0x80, 0x03, 0x80, 0x60, 0x01, 0xE0,
  0x0C, 0x00, 0xD8, 0x01, 0x80, 0xC4, 0x00, 0x3F, 0xE1, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x1C, 0x0E, 0x00, 0xC0,
  0x0C, 0x06, 0x00, 0x18, 0x30, 0x00, 0x60, 0x80, 0x00, 0x86, 0x00, 0x03,
  0x10, 0x00, 0x0C, 0xC0, 0x00, 0x32, 0x00, 0x00, 0xD8, 0x00, 0x03, 0x60,
  0x00, 0x09, 0x00, 0x00, 0x2F, 0xFF, 0xFF, 0xB0, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0xC0, 0xC0, 0x06,
  0x01, 0xC0, 0x70, 0x03, 0xFF, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x03, 0xFF, 0xE1, 0xFF, 0xF0, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x07, 0xF8, 0x20, 0x07, 0x03, 0x88, 0x03, 0x00, 0x32, 0x01, 0x80,
  0x05, 0x80, 0x40, 0x00, 0xE0, 0x30, 0x00, 0x38, 0x18, 0x00, 0x0C, 0x06,
  0x00, 0x01, 0x01, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x0C,
  0x08, 0x00, 0x03, 0x02, 0x00, 0x00, 0x81, 0x80, 0x00, 0x20, 0x60, 0x00,
  0x08, 0x18, 0x00, 0x06, 0x04, 0x00, 0x01, 0x81, 0x00, 0x00, 0x60, 0x40,
  0x00, 0x10, 0x30, 0x00, 0x04, 0x0C, 0x00, 0x01, 0x03, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x30, 0x30, 0x00, 0x0C, 0x04, 0x00, 0x02, 0x01, 0x00, 0x01,
  0x80, 0x60, 0x00, 0xE0, 0x18, 0x00, 0x78, 0x03, 0x00, 0x36, 0x00, 0x60,
  0x39, 0x80, 0x0F, 0xF8, 0x40, 0x00, 0x60, 0x10, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x04, 0x00, 0x0C, 0x01, 0x00, 0x03, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x01,
  0xC0, 0x01, 0xE3, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x01, 0x00, 0x10, 0x7F, 0x80, 0x43,
  0x03, 0x03, 0x18, 0x06, 0x0C, 0x80, 0x08, 0x34, 0x00, 0x30, 0xF0, 0x00,
  0xC2, 0x80, 0x03, 0x0C, 0x00, 0x0C, 0x70, 0x00, 0x31, 0x80, 0x00, 0xC6,
  0x00, 0x03, 0x18, 0x00, 0x0C, 0x40, 0x00, 0x21, 0x00, 0x00, 0x8C, 0x00,
  0x02, 0x30, 0x00, 0x18, 0xC0, 0x00, 0x62, 0x00, 0x01, 0x88, 0x00, 0x04,
  0x20, 0x00, 0x11, 0x80, 0x00, 0x46, 0x00, 0x03, 0x18, 0x00, 0x0C, 0x40,
  0x00, 0x31, 0x00, 0x00, 0x84, 0x00, 0x02, 0x30, 0x00, 0x08, 0xC0, 0x00,
  0x63, 0x00, 0x01, 0x88, 0x00, 0x06, 0x20, 0x00, 0x10, 0x01, 0x81, 0xC0,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x60,
  0x20, 0x10, 0x18, 0x0C, 0x06, 0x02, 0x01, 0x00, 0x80, 0xC0, 0x60, 0x30,
  0x10, 0x08, 0x04, 0x06, 0x03, 0x01, 0x80, 0x80, 0x40, 0x20, 0x30, 0x18,
  0x0C, 0x04, 0x02, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x0F, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x01, 0x81, 0x00,
  0x06, 0x06, 0x00, 0x18, 0x0C, 0x00, 0x60, 0x18, 0x01, 0x80, 0x20, 0x06,
  0x00, 0x40, 0x18, 0x00, 0x80, 0x60, 0x03, 0x01, 0x80, 0x06, 0x06, 0x00,
  0x0C, 0x18, 0x00, 0x10, 0x60, 0x00, 0x21, 0x80, 0x00, 0x46, 0x00, 0x01,
  0x9E, 0x00, 0x03, 0xCC, 0x00, 0x07, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x10,
  0x18, 0x00, 0x20, 0x30, 0x00, 0xC0, 0x30, 0x01, 0x80, 0x20, 0x03, 0x00,
  0x60, 0x04, 0x00, 0x40, 0x08, 0x00, 0xC0, 0x10, 0x00, 0x80, 0x60, 0x01,
  0x80, 0xC0, 0x01, 0x01, 0x00, 0x03, 0x02, 0x00, 0x03, 0x04, 0x00, 0x06,
  0x00, 0x01, 0x80, 0xC0, 0x60, 0x20, 0x10, 0x08, 0x0C, 0x06, 0x03, 0x01,
  0x00, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x08, 0x04, 0x06, 0x03, 0x01, 0x80,
  0x80, 0x40, 0x20, 0x30, 0x18, 0x0C, 0x04, 0x02, 0x01, 0x01, 0x80, 0xC0,
  0x60, 0x20, 0x10, 0x08, 0x0C, 0x06, 0x03, 0x01, 0x00, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x02, 0x0F, 0xF0, 0x07,
  0xF8, 0x06, 0x38, 0x18, 0x1C, 0x0C, 0x06, 0x60, 0x0C, 0x38, 0x06, 0x06,
  0xC0, 0x04, 0x60, 0x03, 0x04, 0x80, 0x06, 0xC0, 0x03, 0x05, 0x00, 0x06,
  0x80, 0x03, 0x07, 0x00, 0x07, 0x80, 0x01, 0x0E, 0x00, 0x07, 0x00, 0x01,
  0x0E, 0x00, 0x06, 0x00, 0x01, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x08, 0x00, 0x04, 0x00, 0x03, 0x18, 0x00, 0x04, 0x00,
  0x03, 0x18, 0x00, 0x04, 0x00, 0x02, 0x18, 0x00, 0x0C, 0x00, 0x02, 0x18,
  0x00, 0x0C, 0x00, 0x02, 0x10, 0x00, 0x0C, 0x00, 0x06, 0x10, 0x00, 0x08,
  0x00, 0x06, 0x30, 0x00, 0x08, 0x00, 0x06, 0x30, 0x00, 0x08, 0x00, 0x04,
  0x30, 0x00, 0x18, 0x00, 0x04, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x20, 0x00,
  0x18, 0x00, 0x0C, 0x20, 0x00, 0x10, 0x00, 0x0C, 0x60, 0x00, 0x10, 0x00,
  0x0C, 0x60, 0x00, 0x10, 0x00, 0x08, 0x60, 0x00, 0x30, 0x00, 0x08, 0x40,
  0x00, 0x30, 0x00, 0x18, 0x40, 0x00, 0x30, 0x00, 0x18, 0x40, 0x00, 0x20,
  0x00, 0x18, 0xC0, 0x00, 0x20, 0x00, 0x10, 0x00, 0x01, 0x00, 0x10, 0x7F,
  0x80, 0x43, 0x03, 0x03, 0x18, 0x06, 0x0C, 0x80, 0x08, 0x34, 0x00, 0x30,
  0xF0, 0x00, 0xC2, 0x80, 0x03, 0x0C, 0x00, 0x0C, 0x70, 0x00, 0x31, 0x80,
  0x00, 0xC6, 0x00, 0x03, 0x18, 0x00, 0x0C, 0x40, 0x00, 0x21, 0x00, 0x00,
  0x8C, 0x00, 0x02, 0x30, 0x00, 0x18, 0xC0, 0x00, 0x62, 0x00, 0x01, 0x88,
  0x00, 0x04, 0x20, 0x00, 0x11, 0x80, 0x00, 0x46, 0x00, 0x03, 0x18, 0x00,
  0x0C, 0x40, 0x00, 0x31, 0x00, 0x00, 0x84, 0x00, 0x02, 0x30, 0x00, 0x08,
  0xC0, 0x00, 0x63, 0x00, 0x01, 0x88, 0x00, 0x06, 0x20, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x03, 0x81, 0xC0, 0x1C, 0x00, 0xC0, 0x70,
  0x00, 0x80, 0xC0, 0x01, 0x83, 0x00, 0x01, 0x04, 0x00, 0x02, 0x18, 0x00,
  0x06, 0x20, 0x00, 0x0C, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x32, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0xD8, 0x00, 0x01, 0x30, 0x00, 0x02, 0x40, 0x00, 0x04,
  0x80, 0x00, 0x09, 0x00, 0x00, 0x36, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x98,
  0x00, 0x03, 0x30, 0x00, 0x06, 0x60, 0x00, 0x08, 0xC0, 0x00, 0x30, 0x80,
  0x00, 0x41, 0x80, 0x01, 0x83, 0x00, 0x06, 0x03, 0x00, 0x1C, 0x07, 0x00,
  0x70, 0x07, 0x03, 0xC0, 0x07, 0xFE, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x20, 0xFF, 0x00, 0x08, 0xE0, 0x60, 0x06, 0x60, 0x0C, 0x01,
  0xE0, 0x01, 0x80, 0x70, 0x00, 0x60, 0x18, 0x00, 0x08, 0x06, 0x00, 0x02,
  0x01, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x0C, 0x0C, 0x00,
  0x03, 0x02, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x30, 0x20, 0x00, 0x08, 0x18,
  0x00, 0x02, 0x06, 0x00, 0x00, 0x81, 0x80, 0x00, 0x60, 0x40, 0x00, 0x18,
  0x10, 0x00, 0x06, 0x04, 0x00, 0x01, 0x03, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x30, 0x30, 0x00, 0x08, 0x08, 0x00, 0x06, 0x02, 0x00, 0x01, 0x81, 0xC0,
  0x00, 0xC0, 0x70, 0x00, 0x20, 0x1E, 0x00, 0x18, 0x04, 0xC0, 0x0C, 0x01,
  0x1C, 0x0E, 0x00, 0x41, 0xFE, 0x00, 0x30, 0x0C, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x7F, 0x82, 0x01, 0xC0, 0xE2, 0x03, 0x00, 0x32, 0x06, 0x00, 0x1E,
  0x04, 0x00, 0x0E, 0x0C, 0x00, 0x0E, 0x18, 0x00, 0x04, 0x18, 0x00, 0x04,
  0x10, 0x00, 0x04, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x20, 0x00, 0x0C,
  0x20, 0x00, 0x08, 0x60, 0x00, 0x08, 0x60, 0x00, 0x08, 0x60, 0x00, 0x18,
  0x60, 0x00, 0x18, 0x40, 0x00, 0x18, 0x40, 0x00, 0x10, 0x40, 0x00, 0x10,
  0xC0, 0x00, 0x10, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x30,
  0x40, 0x00, 0x20, 0x40, 0x00, 0x60, 0x60, 0x00, 0xE0, 0x60, 0x01, 0xE0,
  0x30, 0x03, 0x60, 0x18, 0x1E, 0x40, 0x0F, 0xF8, 0x40, 0x01, 0x80, 0x40,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x02,
  0x1F, 0x81, 0x1C, 0x01, 0x98, 0x00, 0xD8, 0x00, 0x78, 0x00, 0x38, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x01, 0xFF, 0x00, 0x1C,
  0x06, 0x00, 0xC0, 0x0C, 0x06, 0x00, 0x18, 0x30, 0x00, 0x20, 0xC0, 0x00,
  0x82, 0x00, 0x02, 0x08, 0x00, 0x08, 0x20, 0x00, 0x00, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0xC0,
  0x00, 0x63, 0x00, 0x01, 0x8C, 0x00, 0x04, 0x30, 0x00, 0x30, 0x60, 0x01,
  0x80, 0xC0, 0x0C, 0x01, 0xC0, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0xC0, 0x00,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40,
  0x0C, 0x0F, 0xFF, 0xFF, 0xF0, 0xC0, 0x08, 0x00, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x10, 0x01, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x20, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x04, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x07, 0xE0,
  0x08, 0x00, 0x08, 0x00, 0x04, 0x10, 0x00, 0x08, 0x60, 0x00, 0x10, 0xC0,
  0x00, 0x61, 0x80, 0x00, 0xC2, 0x00, 0x01, 0x84, 0x00, 0x02, 0x08, 0x00,
  0x04, 0x30, 0x00, 0x08, 0x60, 0x00, 0x30, 0xC0, 0x00, 0x61, 0x00, 0x00,
  0xC2, 0x00, 0x01, 0x0C, 0x00, 0x02, 0x18, 0x00, 0x04, 0x30, 0x00, 0x18,
  0x40, 0x00, 0x30, 0x80, 0x00, 0x61, 0x00, 0x00, 0x86, 0x00, 0x01, 0x0C,
  0x00, 0x06, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x60, 0x00, 0x60, 0xC0,
  0x00, 0xC1, 0x80, 0x03, 0x83, 0x00, 0x0F, 0x03, 0x00, 0x16, 0x06, 0x00,
  0xCC, 0x07, 0x07, 0x10, 0x07, 0xFC, 0x20, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0xB0, 0x00, 0x0D, 0x80, 0x00, 0x4C, 0x00, 0x06, 0x20,
  0x00, 0x21, 0x00, 0x03, 0x08, 0x00, 0x10, 0x60, 0x01, 0x83, 0x00, 0x08,
  0x18, 0x00, 0xC0, 0x40, 0x06, 0x02, 0x00, 0x60, 0x10, 0x03, 0x00, 0xC0,
  0x10, 0x06, 0x01, 0x80, 0x30, 0x08, 0x00, 0x80, 0xC0, 0x04, 0x04, 0x00,
  0x20, 0x60, 0x01, 0x82, 0x00, 0x0C, 0x30, 0x00, 0x61, 0x00, 0x01, 0x18,
  0x00, 0x08, 0x80, 0x00, 0x4C, 0x00, 0x03, 0x40, 0x00, 0x1E, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x01, 0x80, 0x01,
  0x60, 0x00, 0xC0, 0x01, 0xB0, 0x00, 0xE0, 0x00, 0xD8, 0x00, 0x50, 0x00,
  0xCC, 0x00, 0x68, 0x00, 0x66, 0x00, 0x34, 0x00, 0x23, 0x00, 0x12, 0x00,
  0x31, 0x80, 0x19, 0x80, 0x10, 0xC0, 0x08, 0xC0, 0x18, 0x60, 0x0C, 0x60,
  0x0C, 0x10, 0x04, 0x30, 0x0C, 0x08, 0x06, 0x18, 0x06, 0x04, 0x03, 0x0C,
  0x02, 0x02, 0x03, 0x02, 0x03, 0x01, 0x01, 0x81, 0x01, 0x80, 0x80, 0x80,
  0x81, 0x80, 0x60, 0xC0, 0x40, 0xC0, 0x30, 0x40, 0x20, 0xC0, 0x18, 0x60,
  0x18, 0x60, 0x0C, 0x20, 0x0C, 0x20, 0x06, 0x30, 0x06, 0x30, 0x03, 0x18,
  0x03, 0x18, 0x01, 0x88, 0x01, 0x98, 0x00, 0xCC, 0x00, 0x4C, 0x00, 0x64,
  0x00, 0x24, 0x00, 0x16, 0x00, 0x16, 0x00, 0x0A, 0x00, 0x0B, 0x00, 0x07,
  0x00, 0x05, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x01, 0x81, 0x80, 0x01, 0x80, 0xC0,
  0x01, 0x80, 0x30, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x06, 0x00, 0xC0, 0x03,
  0x00, 0x40, 0x00, 0x80, 0x60, 0x00, 0x60, 0x60, 0x00, 0x10, 0x60, 0x00,
  0x0C, 0x20, 0x00, 0x02, 0x30, 0x00, 0x01, 0xB0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1B, 0x00,
  0x00, 0x18, 0x80, 0x00, 0x08, 0x60, 0x00, 0x0C, 0x10, 0x00, 0x0C, 0x0C,
  0x00, 0x0C, 0x06, 0x00, 0x06, 0x01, 0x80, 0x06, 0x00, 0xC0, 0x06, 0x00,
  0x20, 0x06, 0x00, 0x18, 0x03, 0x00, 0x0C, 0x03, 0x00, 0x03, 0x03, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x60, 0x60, 0x00, 0x0C,
  0x0C, 0x00, 0x03, 0x01, 0x80, 0x00, 0x60, 0x10, 0x00, 0x18, 0x02, 0x00,
  0x03, 0x00, 0x60, 0x00, 0xC0, 0x0C, 0x00, 0x18, 0x01, 0x80, 0x06, 0x00,
  0x30, 0x00, 0xC0, 0x02, 0x00, 0x10, 0x00, 0x40, 0x06, 0x00, 0x08, 0x00,
  0x80, 0x01, 0x80, 0x30, 0x00, 0x30, 0x04, 0x00, 0x06, 0x01, 0x80, 0x00,
  0x40, 0x20, 0x00, 0x08, 0x0C, 0x00, 0x01, 0x01, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x06, 0x08, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x18, 0x40, 0x00, 0x01,
  0x18, 0x00, 0x00, 0x22, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x00, 0xD0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x13,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x07, 0xFF,
  0xFE, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x40, 0x00, 0x70, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x3C, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x20, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x04, 0x01, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x20,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x04, 0x01, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x20, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x04, 0x01,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x04, 0x03, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x40, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x60,
  0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xDC, 0x00, 0x0C,
  0xC0, 0xE0, 0x01, 0x30, 0x0C, 0x00, 0x64, 0x00, 0xC0, 0x0D, 0x80, 0x0C,
  0x03, 0x30, 0x00, 0xC0, 0xC4, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x7C, 0x00,
};

const GFXglyph RobotoCondensed_ThinItalic59pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 9, 43, 11, 1, -42 },
  { 50, 10, 12, 15, 6, -44 },
  { 65, 29, 42, 28, 1, -42 },
  { 218, 25, 54, 28, 2, -48 },
  { 387, 28, 44, 37, 5, -43 },
  { 541, 26, 44, 31, 2, -43 },
  { 684, 4, 12, 10, 6, -44 },
  { 690, 16, 60, 16, 3, -47 },
  { 810, 15, 61, 16, -3, -47 },
  { 925, 22, 23, 24, 4, -42 },
  { 989, 23, 31, 28, 3, -35 },
  { 1079, 7, 12, 11, -2, -5 },
  { 1090, 12, 1, 15, 2, -20 },
  { 1092, 4, 4, 12, 1, -3 },
  { 1094, 24, 46, 20, -2, -42 },
  { 1232, 23, 44, 28, 3, -43 },
  { 1359, 13, 42, 28, 8, -42 },
  { 1428, 25, 43, 28, 1, -43 },
  { 1563, 24, 44, 28, 2, -43 },
  { 1695, 25, 42, 28, 1, -42 },
  { 1827, 24, 43, 28, 4, -42 },
  { 1956, 21, 43, 28, 3, -42 },
  { 2069, 23, 42, 28, 5, -42 },
  { 2190, 26, 44, 28, 1, -43 },
  { 2333, 22, 43, 28, 4, -43 },
  { 2452, 8, 32, 10, 1, -31 },
  { 2484, 11, 38, 10, -2, -31 },
  { 2537, 22, 23, 26, 3, -31 },
  { 2601, 22, 13, 28, 3, -26 },
  { 2637, 22, 23, 26, 2, -31 },
  { 2701, 18, 44, 22, 5, -43 },
  { 2800, 41, 54, 46, 2, -41 },
  { 3077, 28, 42, 30, -2, -42 },
  { 3224, 27, 42, 30, 2, -42 },
  { 3366, 28, 44, 33, 3, -43 },
  { 3520, 29, 42, 33, 2, -42 },
  { 3673, 29, 42, 29, 2, -42 },
  { 3826, 29, 42, 29, 2, -42 },
  { 3979, 28, 44, 34, 4, -43 },
  { 4133, 32, 42, 35, 2, -42 },
  { 4301, 9, 42, 14, 3, -42 },
  { 4349, 26, 43, 28, 1, -42 },
  { 4489, 31, 42, 32, 2, -42 },
  { 4652, 20, 42, 26, 2, -42 },
  { 4757, 40, 42, 43, 2, -42 },
  { 4967, 32, 42, 35, 2, -42 },
  { 5135, 29, 44, 33, 3, -43 },
  { 5295, 28, 42, 30, 2, -42 },
  { 5442, 29, 51, 33, 3, -43 },
  { 5627, 28, 42, 33, 2, -42 },
  { 5774, 29, 44, 30, 1, -43 },
  { 5934, 27, 42, 30, 6, -42 },
  { 6076, 30, 43, 33, 3, -42 },
  { 6238, 28, 42, 30, 5, -42 },
  { 6385, 41, 42, 45, 6, -42 },
  { 6601, 33, 42, 30, -1, -42 },
  { 6775, 28, 42, 30, 5, -42 },
  { 6922, 31, 42, 30, 0, -42 },
  { 7085, 15, 57, 12, 1, -48 },
  { 7192, 8, 46, 19, 6, -42 },
  { 7238, 16, 57, 12, -4, -48 },
  { 7352, 16, 21, 21, 3, -42 },
  { 7394, 21, 1, 21, -3, 0 },
  { 7397, 6, 8, 15, 8, -45 },
  { 7403, 22, 33, 27, 1, -32 },
  { 7494, 23, 45, 28, 2, -44 },
  { 7624, 22, 33, 26, 2, -32 },
  { 7715, 26, 45, 28, 2, -44 },
  { 7862, 22, 33, 26, 2, -32 },
  { 7953, 17, 45, 16, 4, -45 },
  { 8049, 26, 44, 28, 0, -32 },
  { 8192, 22, 44, 28, 2, -44 },
  { 8313, 9, 42, 11, 2, -42 },
  { 8361, 19, 54, 12, -8, -42 },
  { 8490, 23, 44, 24, 2, -44 },
  { 8617, 9, 44, 11, 2, -44 },
  { 8667, 40, 32, 45, 1, -32 },
  { 8827, 22, 32, 28, 2, -32 },
  { 8915, 23, 33, 28, 2, -32 },
  { 9010, 26, 44, 28, -1, -32 },
  { 9153, 24, 44, 28, 2, -32 },
  { 9285, 17, 32, 17, 2, -32 },
  { 9353, 22, 33, 25, 1, -32 },
  { 9444, 12, 41, 16, 4, -40 },
  { 9506, 23, 32, 28, 3, -31 },
  { 9598, 21, 31, 24, 4, -31 },
  { 9680, 33, 31, 38, 5, -31 },
  { 9808, 25, 31, 24, -1, -31 },
  { 9905, 27, 43, 24, -2, -31 },
  { 10051, 24, 31, 24, 0, -31 },
  { 10144, 18, 59, 17, 2, -46 },
  { 10277, 10, 50, 12, 1, -42 },
  { 10340, 19, 59, 17, -4, -46 },
  { 10481, 27, 9, 35, 4, -22 },
};

const GFXfont RobotoCondensed_ThinItalic59pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ThinItalic59pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ThinItalic59pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _ROBOTOCONDENSED_THINITALIC59PT7B_H_
