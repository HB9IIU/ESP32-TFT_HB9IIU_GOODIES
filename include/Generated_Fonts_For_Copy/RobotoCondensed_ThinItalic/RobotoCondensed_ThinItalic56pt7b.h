#ifndef _ROBOTOCONDENSED_THINITALIC56PT7B_H_
#define _ROBOTOCONDENSED_THINITALIC56PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ThinItalic.ttf
// Size: 56pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ThinItalic56pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0x80, 0x80, 0x40, 0x20, 0x30, 0x18, 0x0C, 0x04, 0x02, 0x01,
  0x01, 0x80, 0xC0, 0x60, 0x20, 0x10, 0x08, 0x0C, 0x06, 0x03, 0x01, 0x00,
  0x80, 0x40, 0x60, 0x30, 0x18, 0x08, 0x04, 0x02, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x00,
  0x31, 0x90, 0xC8, 0x64, 0x36, 0x13, 0x09, 0x8C, 0x86, 0x43, 0x61, 0x30,
  0x80, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x10, 0x0C, 0x00, 0x03, 0x00, 0x80,
  0x00, 0x20, 0x18, 0x00, 0x02, 0x01, 0x80, 0x00, 0x60, 0x10, 0x00, 0x04,
  0x03, 0x00, 0x00, 0x40, 0x30, 0x00, 0x0C, 0x02, 0x00, 0x00, 0x80, 0x60,
  0x00, 0x08, 0x06, 0x00, 0x01, 0x80, 0x40, 0x0F, 0xFF, 0xFF, 0xF0, 0x01,
  0x00, 0xC0, 0x00, 0x30, 0x08, 0x00, 0x03, 0x00, 0x80, 0x00, 0x20, 0x18,
  0x00, 0x06, 0x01, 0x00, 0x00, 0x60, 0x10, 0x00, 0x04, 0x03, 0x00, 0x00,
  0x40, 0x20, 0x00, 0x0C, 0x02, 0x00, 0x00, 0x80, 0x60, 0x00, 0x08, 0x04,
  0x00, 0x01, 0x80, 0x40, 0x00, 0x10, 0x0C, 0x00, 0x01, 0x00, 0xC0, 0x0F,
  0xFF, 0xFF, 0xE0, 0x02, 0x01, 0x80, 0x00, 0x20, 0x18, 0x00, 0x06, 0x01,
  0x00, 0x00, 0x40, 0x30, 0x00, 0x04, 0x03, 0x00, 0x00, 0xC0, 0x20, 0x00,
  0x0C, 0x06, 0x00, 0x00, 0x80, 0x60, 0x00, 0x18, 0x04, 0x00, 0x01, 0x80,
  0x40, 0x00, 0x10, 0x0C, 0x00, 0x03, 0x00, 0x80, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x20, 0x00, 0x07, 0xF8, 0x00, 0x38, 0x1C, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x18, 0x0C, 0x00, 0x10, 0x10, 0x00, 0x30, 0x60, 0x00, 0x60, 0x80,
  0x00, 0x41, 0x00, 0x00, 0x86, 0x00, 0x01, 0x0C, 0x00, 0x06, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x46, 0x00, 0x00, 0x8C, 0x00, 0x01, 0x18, 0x00, 0x06, 0x30, 0x00,
  0x0C, 0x60, 0x00, 0x10, 0x40, 0x00, 0x60, 0xC0, 0x01, 0x80, 0x80, 0x07,
  0x01, 0x80, 0x1C, 0x01, 0xC0, 0x60, 0x00, 0xFF, 0x80, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x30, 0x18, 0x00, 0x08, 0x02, 0x00, 0x06, 0x00,
  0x80, 0x31, 0x80, 0x20, 0x08, 0x40, 0x08, 0x06, 0x10, 0x02, 0x03, 0x0C,
  0x01, 0x80, 0x83, 0x00, 0x60, 0x60, 0xC0, 0x10, 0x30, 0x30, 0x04, 0x08,
  0x0C, 0x03, 0x06, 0x01, 0x00, 0x83, 0x00, 0x60, 0x60, 0x80, 0x18, 0x30,
  0x40, 0x03, 0xF8, 0x30, 0x00, 0x10, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x40, 0x00, 0x40, 0xFC, 0x00, 0x30, 0x61,
  0x80, 0x18, 0x30, 0x30, 0x04, 0x18, 0x04, 0x03, 0x04, 0x01, 0x01, 0x83,
  0x00, 0x40, 0x40, 0xC0, 0x10, 0x30, 0x20, 0x04, 0x18, 0x08, 0x01, 0x04,
  0x02, 0x00, 0x42, 0x01, 0x80, 0x31, 0x80, 0x60, 0x08, 0x40, 0x18, 0x02,
  0x20, 0x06, 0x01, 0x80, 0x00, 0x80, 0x40, 0x00, 0x30, 0x30, 0x00, 0x06,
  0x18, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x60, 0x30, 0x00, 0xC0, 0x30, 0x00,
  0x80, 0x10, 0x01, 0x80, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x30, 0x01,
  0x00, 0x30, 0x03, 0x00, 0x20, 0x03, 0x00, 0x60, 0x01, 0x00, 0xC0, 0x01,
  0x01, 0x80, 0x01, 0x03, 0x00, 0x01, 0x86, 0x00, 0x00, 0x8C, 0x00, 0x00,
  0xD8, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xA0, 0x00, 0x03,
  0x30, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x0C, 0x01, 0x30,
  0x04, 0x01, 0x20, 0x06, 0x03, 0x60, 0x02, 0x03, 0x40, 0x03, 0x02, 0xC0,
  0x01, 0x06, 0xC0, 0x01, 0x84, 0x80, 0x00, 0xCC, 0x80, 0x00, 0xC8, 0x80,
  0x00, 0x78, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x50, 0x60,
  0x00, 0x98, 0x30, 0x03, 0x0C, 0x38, 0x0E, 0x0C, 0x0F, 0xF8, 0x06, 0x00,
  0x80, 0x00, 0x25, 0xB6, 0x96, 0xDA, 0x00, 0x00, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x40, 0x01, 0x80,
  0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80,
  0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x04, 0x00, 0x0C, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60,
  0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80,
  0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x40, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00,
  0x10, 0x04, 0x02, 0xF0, 0x30, 0x3C, 0xF0, 0xC7, 0x80, 0x7B, 0xF0, 0x00,
  0x3F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x40, 0x00, 0x19, 0x80, 0x00, 0xC2,
  0x00, 0x02, 0x0C, 0x00, 0x18, 0x18, 0x00, 0xC0, 0x60, 0x06, 0x00, 0xC0,
  0x30, 0x03, 0x00, 0x80, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x30, 0xC3, 0x08, 0x61, 0x8C,
  0x31, 0x84, 0x00, 0xFF, 0xE0, 0xEE, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x0E, 0x06, 0x00, 0x60, 0x0C, 0x03, 0x00,
  0x10, 0x08, 0x00, 0x60, 0x60, 0x00, 0x81, 0x00, 0x02, 0x0C, 0x00, 0x0C,
  0x20, 0x00, 0x31, 0x80, 0x00, 0xC4, 0x00, 0x03, 0x10, 0x00, 0x0C, 0xC0,
  0x00, 0x33, 0x00, 0x00, 0xC8, 0x00, 0x03, 0x20, 0x00, 0x09, 0x80, 0x00,
  0x26, 0x00, 0x00, 0x98, 0x00, 0x06, 0x40, 0x00, 0x19, 0x00, 0x00, 0x64,
  0x00, 0x01, 0x30, 0x00, 0x04, 0xC0, 0x00, 0x13, 0x00, 0x00, 0xC8, 0x00,
  0x03, 0x20, 0x00, 0x08, 0x80, 0x00, 0x22, 0x00, 0x01, 0x88, 0x00, 0x06,
  0x20, 0x00, 0x10, 0x80, 0x00, 0xC2, 0x00, 0x02, 0x0C, 0x00, 0x18, 0x30,
  0x00, 0x40, 0x40, 0x03, 0x01, 0x80, 0x18, 0x02, 0x00, 0xC0, 0x0E, 0x0E,
  0x00, 0x0F, 0xF0, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x1E, 0x07, 0x21,
  0xC6, 0xF0, 0x68, 0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0x80, 0x08, 0x00, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x60, 0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x18, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x3F,
  0xE0, 0x01, 0xC0, 0xE0, 0x06, 0x00, 0x60, 0x18, 0x00, 0xC0, 0x20, 0x00,
  0xC0, 0xC0, 0x01, 0x83, 0x00, 0x01, 0x06, 0x00, 0x02, 0x08, 0x00, 0x04,
  0x30, 0x00, 0x08, 0x60, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x01,
  0xC0, 0xC0, 0x06, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x60, 0x01, 0x81, 0x80,
  0x01, 0x02, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x20, 0x00,
  0x18, 0x40, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x20, 0x00, 0x04, 0x40, 0x00,
  0x08, 0x80, 0x00, 0x31, 0x00, 0x00, 0x43, 0x00, 0x01, 0x86, 0x00, 0x03,
  0x06, 0x00, 0x0C, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0xC0, 0x0E, 0x07, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x02, 0xC0, 0x00, 0x09, 0x80,
  0x00, 0x32, 0x00, 0x00, 0xC4, 0x00, 0x01, 0x08, 0x00, 0x06, 0x30, 0x00,
  0x18, 0x60, 0x00, 0x20, 0xC0, 0x00, 0x81, 0x00, 0x03, 0x02, 0x00, 0x0C,
  0x04, 0x00, 0x10, 0x18, 0x00, 0x60, 0x30, 0x01, 0x80, 0x60, 0x02, 0x00,
  0x80, 0x0C, 0x01, 0x00, 0x30, 0x02, 0x00, 0xC0, 0x0C, 0x01, 0x00, 0x18,
  0x06, 0x00, 0x30, 0x18, 0x00, 0x40, 0x60, 0x00, 0x80, 0xC0, 0x01, 0x03,
  0x00, 0x06, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x80, 0x00, 0xFF, 0xFF, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x7E,
  0x00, 0x09, 0xE7, 0x80, 0x0E, 0x00, 0xC0, 0x1C, 0x00, 0x60, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x30, 0x40, 0x00, 0x30, 0x40, 0x00, 0x20, 0x40, 0x00,
  0x20, 0x40, 0x00, 0x60, 0x40, 0x00, 0x40, 0x60, 0x00, 0xC0, 0x60, 0x00,
  0x80, 0x30, 0x01, 0x80, 0x18, 0x03, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0xFE, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00,
  0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x00, 0x00, 0x30, 0x7E, 0x03, 0x1E, 0x78, 0x23, 0x00, 0xC2, 0x40,
  0x06, 0x68, 0x00, 0x67, 0x00, 0x02, 0x60, 0x00, 0x36, 0x00, 0x03, 0x40,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x02, 0x80, 0x00, 0x68, 0x00, 0x06,
  0xC0, 0x00, 0x4C, 0x00, 0x0C, 0x40, 0x00, 0x86, 0x00, 0x18, 0x60, 0x03,
  0x03, 0x00, 0x60, 0x1C, 0x0C, 0x00, 0xFF, 0x80, 0x00, 0x80, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0,
  0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10,
  0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00,
  0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x0E, 0x07, 0x00, 0x0C,
  0x01, 0xC0, 0x0C, 0x00, 0x60, 0x0C, 0x00, 0x18, 0x04, 0x00, 0x0C, 0x06,
  0x00, 0x02, 0x02, 0x00, 0x01, 0x03, 0x00, 0x00, 0x81, 0x00, 0x00, 0x40,
  0x80, 0x00, 0x20, 0x40, 0x00, 0x30, 0x20, 0x00, 0x10, 0x10, 0x00, 0x18,
  0x0C, 0x00, 0x08, 0x02, 0x00, 0x0C, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x1C,
  0x00, 0x1E, 0x78, 0x00, 0x07, 0xF8, 0x00, 0x0E, 0x0E, 0x00, 0x18, 0x01,
  0x80, 0x18, 0x00, 0x60, 0x18, 0x00, 0x18, 0x08, 0x00, 0x04, 0x0C, 0x00,
  0x03, 0x04, 0x00, 0x01, 0x86, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x61, 0x00,
  0x00, 0x30, 0x80, 0x00, 0x10, 0xC0, 0x00, 0x08, 0x20, 0x00, 0x0C, 0x10,
  0x00, 0x04, 0x08, 0x00, 0x06, 0x06, 0x00, 0x06, 0x01, 0x80, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x18, 0x0E, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x60, 0x70, 0x0E, 0x00, 0xC0,
  0x40, 0x06, 0x06, 0x00, 0x18, 0x60, 0x00, 0xC2, 0x00, 0x02, 0x30, 0x00,
  0x11, 0x00, 0x00, 0xD8, 0x00, 0x06, 0xC0, 0x00, 0x34, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x58, 0x00, 0x02, 0xC0, 0x00, 0x16, 0x00, 0x01,
  0xB0, 0x00, 0x0D, 0x80, 0x00, 0x6C, 0x00, 0x07, 0x20, 0x00, 0x71, 0x00,
  0x02, 0x8C, 0x00, 0x2C, 0x30, 0x03, 0x61, 0xC0, 0x72, 0x07, 0x9E, 0x10,
  0x0F, 0xC1, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00,
  0x20, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x07, 0xF0, 0x00, 0x7C, 0x00,
  0x00, 0x06, 0x0E, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x01, 0xC0, 0x38, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x01, 0x80, 0x30, 0x06,
  0x01, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x20, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x10, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x03, 0x83, 0x83, 0x00, 0x43, 0x00, 0x31, 0x00, 0x09, 0x80, 0x04, 0x80,
  0x02, 0xC0, 0x01, 0x60, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x07, 0x80, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xE0,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x00, 0x10, 0x18, 0x00, 0x00, 0x00,
  0x20, 0x20, 0x00, 0xF8, 0x00, 0x40, 0xC0, 0x07, 0xBC, 0x00, 0xC1, 0x00,
  0x18, 0x0C, 0x01, 0x86, 0x00, 0x60, 0x08, 0x03, 0x08, 0x01, 0x80, 0x10,
  0x06, 0x30, 0x02, 0x00, 0x60, 0x0C, 0x40, 0x0C, 0x00, 0xC0, 0x19, 0x80,
  0x30, 0x01, 0x00, 0x33, 0x00, 0x60, 0x02, 0x00, 0x64, 0x00, 0x80, 0x0C,
  0x00, 0x98, 0x03, 0x00, 0x18, 0x01, 0x30, 0x04, 0x00, 0x20, 0x02, 0x40,
  0x18, 0x00, 0x40, 0x0C, 0x80, 0x30, 0x01, 0x80, 0x19, 0x00, 0x40, 0x03,
  0x00, 0x26, 0x00, 0x80, 0x04, 0x00, 0x4C, 0x03, 0x00, 0x08, 0x01, 0x98,
  0x06, 0x00, 0x30, 0x03, 0x20, 0x08, 0x00, 0x60, 0x04, 0x40, 0x10, 0x01,
  0x80, 0x18, 0x80, 0x20, 0x03, 0x00, 0x21, 0x00, 0x40, 0x0E, 0x00, 0xC2,
  0x00, 0x80, 0x14, 0x01, 0x06, 0x01, 0x00, 0x48, 0x06, 0x0C, 0x03, 0x01,
  0x18, 0x18, 0x18, 0x03, 0x0C, 0x30, 0x60, 0x30, 0x07, 0xF0, 0x3F, 0x80,
  0x20, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x0C, 0x00,
  0x00, 0x03, 0xFB, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x16,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x88, 0x00, 0x00, 0x31, 0x00, 0x00,
  0x04, 0x20, 0x00, 0x01, 0x84, 0x00, 0x00, 0x20, 0x80, 0x00, 0x04, 0x18,
  0x00, 0x01, 0x03, 0x00, 0x00, 0x20, 0x20, 0x00, 0x0C, 0x04, 0x00, 0x01,
  0x00, 0x80, 0x00, 0x60, 0x10, 0x00, 0x08, 0x02, 0x00, 0x03, 0x00, 0x60,
  0x00, 0x40, 0x0C, 0x00, 0x18, 0x01, 0x80, 0x02, 0x00, 0x10, 0x00, 0xC0,
  0x02, 0x00, 0x10, 0x00, 0x40, 0x06, 0x00, 0x08, 0x00, 0x80, 0x01, 0x80,
  0x30, 0x00, 0x30, 0x04, 0x00, 0x06, 0x01, 0xFF, 0xFF, 0xC0, 0x20, 0x00,
  0x08, 0x0C, 0x00, 0x01, 0x01, 0x00, 0x00, 0x20, 0x60, 0x00, 0x06, 0x0C,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x18, 0x60, 0x00, 0x03, 0x08, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x04, 0x40, 0x00, 0x00, 0x98, 0x00, 0x00, 0x12, 0x00,
  0x00, 0x03, 0x01, 0xFF, 0xE0, 0x00, 0x80, 0x3C, 0x00, 0x40, 0x03, 0x80,
  0x60, 0x00, 0x60, 0x30, 0x00, 0x30, 0x18, 0x00, 0x0C, 0x08, 0x00, 0x06,
  0x04, 0x00, 0x01, 0x02, 0x00, 0x01, 0x83, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x60, 0x80, 0x00, 0x20, 0x40, 0x00, 0x10, 0x20, 0x00, 0x18, 0x10, 0x00,
  0x18, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x04, 0x00, 0x1C, 0x02, 0x00,
  0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x80, 0x07, 0x00, 0xC0, 0x00, 0xC0, 0x60,
  0x00, 0x30, 0x20, 0x00, 0x08, 0x10, 0x00, 0x06, 0x08, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x86, 0x00, 0x00, 0x43, 0x00, 0x00, 0x21, 0x00, 0x00, 0x30,
  0x80, 0x00, 0x18, 0x40, 0x00, 0x08, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x04,
  0x18, 0x00, 0x06, 0x08, 0x00, 0x06, 0x04, 0x00, 0x06, 0x02, 0x00, 0x06,
  0x03, 0x00, 0x3E, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0xE0, 0x38, 0x00, 0x70, 0x01, 0x80, 0x18, 0x00, 0x18,
  0x02, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x06, 0x04, 0x00,
  0x00, 0x41, 0x80, 0x00, 0x08, 0x20, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x21,
  0x80, 0x00, 0x04, 0x20, 0x00, 0x00, 0x84, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x31, 0x80, 0x00, 0x04,
  0x30, 0x00, 0x00, 0x86, 0x00, 0x00, 0x30, 0x40, 0x00, 0x04, 0x08, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x20, 0x30, 0x00, 0x0C, 0x02, 0x00, 0x03, 0x00,
  0x60, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x00, 0x70, 0x1C, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x20, 0x0F, 0x80,
  0x04, 0x00, 0x18, 0x01, 0x80, 0x01, 0x80, 0x30, 0x00, 0x18, 0x06, 0x00,
  0x01, 0x80, 0x80, 0x00, 0x30, 0x10, 0x00, 0x02, 0x02, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x82, 0x00, 0x00, 0x10, 0x40, 0x00,
  0x02, 0x08, 0x00, 0x00, 0x43, 0x00, 0x00, 0x08, 0x60, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x61, 0x00, 0x00, 0x08, 0x20, 0x00, 0x01, 0x04, 0x00, 0x00,
  0x21, 0x80, 0x00, 0x04, 0x30, 0x00, 0x01, 0x86, 0x00, 0x00, 0x30, 0x80,
  0x00, 0x04, 0x10, 0x00, 0x00, 0x82, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x06,
  0x18, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x10, 0x40, 0x00, 0x06, 0x08, 0x00,
  0x00, 0x81, 0x00, 0x00, 0x30, 0x60, 0x00, 0x04, 0x0C, 0x00, 0x01, 0x81,
  0x80, 0x00, 0x60, 0x20, 0x00, 0x18, 0x04, 0x00, 0x0E, 0x00, 0x80, 0x03,
  0x80, 0x30, 0x07, 0xC0, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x07, 0xFF, 0xFC, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xE0, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x03, 0x80, 0xE0,
  0x03, 0x00, 0x0C, 0x01, 0x80, 0x01, 0x80, 0xC0, 0x00, 0x20, 0x60, 0x00,
  0x0C, 0x10, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x42, 0x00, 0x00, 0x11, 0x80,
  0x00, 0x04, 0x60, 0x00, 0x01, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x1F, 0xFC, 0xC0, 0x00, 0x01, 0x30,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x32, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x02,
  0x20, 0x00, 0x00, 0x88, 0x00, 0x00, 0x22, 0x00, 0x00, 0x18, 0xC0, 0x00,
  0x06, 0x30, 0x00, 0x01, 0x84, 0x00, 0x00, 0x41, 0x80, 0x00, 0x10, 0x60,
  0x00, 0x0C, 0x0C, 0x00, 0x0E, 0x01, 0x80, 0x07, 0x00, 0x38, 0x0F, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x04, 0x04,
  0x00, 0x00, 0x10, 0x10, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x0C, 0x0C, 0x00, 0x00, 0x30, 0x20, 0x00, 0x00, 0x80, 0x80, 0x00,
  0x02, 0x02, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0x60, 0x60, 0x00, 0x01,
  0x81, 0x00, 0x00, 0x04, 0x04, 0x00, 0x00, 0x10, 0x10, 0x00, 0x00, 0x40,
  0xC0, 0x00, 0x01, 0x03, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x30, 0x20,
  0x00, 0x00, 0x80, 0x80, 0x00, 0x02, 0x03, 0xFF, 0xFF, 0xF8, 0x18, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x01, 0x81, 0x80, 0x00, 0x06, 0x04, 0x00, 0x00,
  0x10, 0x10, 0x00, 0x00, 0x40, 0x40, 0x00, 0x01, 0x03, 0x00, 0x00, 0x0C,
  0x0C, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x02, 0x02,
  0x00, 0x00, 0x08, 0x08, 0x00, 0x00, 0x20, 0x60, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x06, 0x06, 0x00, 0x00, 0x18, 0x10, 0x00, 0x00, 0x40, 0x40, 0x00,
  0x01, 0x01, 0x00, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00,
  0xC0, 0x01, 0x01, 0x03, 0x03, 0x03, 0x02, 0x02, 0x02, 0x06, 0x06, 0x06,
  0x04, 0x04, 0x0C, 0x0C, 0x0C, 0x08, 0x08, 0x08, 0x18, 0x18, 0x18, 0x10,
  0x10, 0x10, 0x30, 0x30, 0x30, 0x20, 0x20, 0x20, 0x60, 0x60, 0x60, 0x40,
  0x40, 0x40, 0xC0, 0xC0, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x06,
  0x00, 0x01, 0x03, 0x00, 0x00, 0x81, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x40,
  0x60, 0x00, 0x60, 0x10, 0x00, 0x20, 0x08, 0x00, 0x30, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x30, 0x00, 0x60, 0x30, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x18, 0x08, 0x00, 0x01, 0x80, 0x40, 0x00,
  0x18, 0x06, 0x00, 0x01, 0x80, 0x30, 0x00, 0x18, 0x01, 0x80, 0x01, 0x80,
  0x08, 0x00, 0x18, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x18, 0x00, 0x30,
  0x01, 0x80, 0x01, 0x80, 0x18, 0x00, 0x08, 0x01, 0x80, 0x00, 0x40, 0x18,
  0x00, 0x02, 0x01, 0x80, 0x00, 0x30, 0x18, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x0C, 0x18, 0x00, 0x00, 0x41, 0x80, 0x00, 0x02, 0x1C, 0x00, 0x00, 0x11,
  0xA0, 0x00, 0x01, 0x99, 0x80, 0x00, 0x0D, 0x84, 0x00, 0x00, 0x78, 0x30,
  0x00, 0x03, 0x80, 0xC0, 0x00, 0x10, 0x06, 0x00, 0x00, 0x80, 0x18, 0x00,
  0x0C, 0x00, 0xC0, 0x00, 0x60, 0x03, 0x00, 0x03, 0x00, 0x18, 0x00, 0x10,
  0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x60, 0x00,
  0x20, 0x03, 0x00, 0x01, 0x80, 0x18, 0x00, 0x04, 0x00, 0x80, 0x00, 0x30,
  0x04, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x06, 0x03, 0x00, 0x00, 0x18, 0x18,
  0x00, 0x00, 0xC0, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x07,
  0xFF, 0xFE, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x18, 0x00, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x00, 0x0A, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x09, 0x00, 0x00, 0x01, 0x60, 0x24, 0x00, 0x00, 0x0D, 0x80,
  0x90, 0x00, 0x00, 0x24, 0x02, 0x60, 0x00, 0x01, 0x90, 0x19, 0x80, 0x00,
  0x04, 0x40, 0x66, 0x00, 0x00, 0x33, 0x01, 0x08, 0x00, 0x00, 0x8C, 0x04,
  0x20, 0x00, 0x06, 0x30, 0x10, 0x80, 0x00, 0x30, 0x80, 0x43, 0x00, 0x00,
  0x82, 0x03, 0x0C, 0x00, 0x06, 0x08, 0x0C, 0x10, 0x00, 0x10, 0x60, 0x20,
  0x40, 0x00, 0xC1, 0x80, 0x81, 0x00, 0x02, 0x06, 0x02, 0x06, 0x00, 0x18,
  0x10, 0x08, 0x18, 0x00, 0x40, 0x40, 0x60, 0x20, 0x03, 0x01, 0x01, 0x80,
  0x80, 0x08, 0x0C, 0x04, 0x02, 0x00, 0x60, 0x30, 0x10, 0x08, 0x01, 0x00,
  0xC0, 0x40, 0x30, 0x0C, 0x02, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x0C, 0x01,
  0x01, 0x80, 0x20, 0x30, 0x04, 0x04, 0x01, 0x80, 0x80, 0x10, 0x30, 0x06,
  0x02, 0x00, 0x41, 0x80, 0x10, 0x08, 0x01, 0x86, 0x00, 0x40, 0x60, 0x02,
  0x30, 0x01, 0x01, 0x80, 0x08, 0x80, 0x0C, 0x06, 0x00, 0x26, 0x00, 0x30,
  0x10, 0x00, 0x90, 0x00, 0xC0, 0x40, 0x03, 0xC0, 0x02, 0x01, 0x00, 0x0E,
  0x00, 0x08, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x30, 0x00, 0x40, 0x01, 0x80,
  0x01, 0x80, 0x00, 0x06, 0x03, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x10,
  0x1E, 0x00, 0x00, 0x20, 0x34, 0x00, 0x00, 0xC0, 0x6C, 0x00, 0x01, 0x80,
  0x88, 0x00, 0x03, 0x01, 0x10, 0x00, 0x04, 0x06, 0x30, 0x00, 0x08, 0x0C,
  0x20, 0x00, 0x10, 0x18, 0x60, 0x00, 0x60, 0x30, 0xC0, 0x00, 0xC0, 0x40,
  0x80, 0x01, 0x80, 0x81, 0x80, 0x02, 0x03, 0x01, 0x00, 0x04, 0x06, 0x02,
  0x00, 0x08, 0x0C, 0x06, 0x00, 0x30, 0x18, 0x04, 0x00, 0x60, 0x20, 0x0C,
  0x00, 0xC0, 0x40, 0x08, 0x01, 0x01, 0x80, 0x10, 0x02, 0x03, 0x00, 0x30,
  0x04, 0x06, 0x00, 0x20, 0x18, 0x0C, 0x00, 0x60, 0x30, 0x10, 0x00, 0x40,
  0x60, 0x20, 0x00, 0x80, 0x80, 0xC0, 0x01, 0x81, 0x01, 0x80, 0x01, 0x06,
  0x03, 0x00, 0x02, 0x0C, 0x04, 0x00, 0x06, 0x18, 0x08, 0x00, 0x04, 0x30,
  0x10, 0x00, 0x0C, 0x40, 0x60, 0x00, 0x08, 0x80, 0xC0, 0x00, 0x13, 0x01,
  0x80, 0x00, 0x36, 0x02, 0x00, 0x00, 0x2C, 0x04, 0x00, 0x00, 0x78, 0x08,
  0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xE0, 0x38, 0x00, 0x70, 0x01,
  0x80, 0x1C, 0x00, 0x18, 0x02, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x30, 0x30,
  0x00, 0x02, 0x04, 0x00, 0x00, 0x61, 0x80, 0x00, 0x0C, 0x20, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0x31, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x19, 0x80, 0x00, 0x03, 0x20, 0x00, 0x00, 0x64, 0x00, 0x00, 0x08,
  0x80, 0x00, 0x01, 0x10, 0x00, 0x00, 0x26, 0x00, 0x00, 0x0C, 0xC0, 0x00,
  0x01, 0x90, 0x00, 0x00, 0x22, 0x00, 0x00, 0x04, 0x40, 0x00, 0x00, 0x88,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0xCC, 0x00, 0x00,
  0x11, 0x80, 0x00, 0x06, 0x30, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x10, 0xC0,
  0x00, 0x06, 0x08, 0x00, 0x00, 0x81, 0x00, 0x00, 0x30, 0x30, 0x00, 0x0C,
  0x02, 0x00, 0x01, 0x00, 0x60, 0x00, 0xE0, 0x06, 0x00, 0x38, 0x00, 0x70,
  0x1C, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x20, 0x07, 0xC0, 0x04, 0x00, 0x1C, 0x01, 0x80, 0x00, 0xC0, 0x30,
  0x00, 0x18, 0x06, 0x00, 0x01, 0x80, 0x80, 0x00, 0x30, 0x10, 0x00, 0x02,
  0x02, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x08, 0x18, 0x00, 0x01, 0x02, 0x00,
  0x00, 0x20, 0x40, 0x00, 0x0C, 0x08, 0x00, 0x01, 0x81, 0x00, 0x00, 0x20,
  0x60, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0x01, 0x00, 0x00, 0x60, 0x20, 0x00,
  0x18, 0x04, 0x00, 0x06, 0x00, 0x80, 0x03, 0x80, 0x30, 0x07, 0xE0, 0x07,
  0xFF, 0xE0, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xE0, 0x38, 0x00, 0x70,
  0x01, 0x80, 0x18, 0x00, 0x18, 0x02, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x30,
  0x30, 0x00, 0x02, 0x04, 0x00, 0x00, 0x41, 0x80, 0x00, 0x0C, 0x20, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0x31, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x19, 0x80, 0x00, 0x03, 0x20, 0x00, 0x00, 0x44, 0x00, 0x00,
  0x08, 0x80, 0x00, 0x01, 0x30, 0x00, 0x00, 0x26, 0x00, 0x00, 0x0C, 0xC0,
  0x00, 0x01, 0x98, 0x00, 0x00, 0x22, 0x00, 0x00, 0x04, 0x40, 0x00, 0x00,
  0x98, 0x00, 0x00, 0x33, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x11, 0x80, 0x00, 0x06, 0x30, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x10,
  0xC0, 0x00, 0x06, 0x18, 0x00, 0x00, 0x81, 0x00, 0x00, 0x30, 0x30, 0x00,
  0x0C, 0x02, 0x00, 0x03, 0x00, 0x60, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x00,
  0x70, 0x1C, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x20, 0x07,
  0xC0, 0x0C, 0x00, 0x0C, 0x01, 0x80, 0x00, 0xC0, 0x30, 0x00, 0x08, 0x04,
  0x00, 0x01, 0x80, 0x80, 0x00, 0x10, 0x10, 0x00, 0x02, 0x06, 0x00, 0x00,
  0x40, 0xC0, 0x00, 0x08, 0x18, 0x00, 0x01, 0x02, 0x00, 0x00, 0x20, 0x40,
  0x00, 0x04, 0x08, 0x00, 0x01, 0x83, 0x00, 0x00, 0x20, 0x60, 0x00, 0x0C,
  0x08, 0x00, 0x01, 0x81, 0x00, 0x00, 0x60, 0x20, 0x00, 0x18, 0x04, 0x00,
  0x06, 0x01, 0x80, 0x01, 0x80, 0x30, 0x03, 0xE0, 0x07, 0xFF, 0xE0, 0x00,
  0x80, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0xC0, 0x01,
  0x00, 0x18, 0x00, 0x30, 0x02, 0x00, 0x06, 0x00, 0x40, 0x00, 0x40, 0x08,
  0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0x60, 0x00, 0x10, 0x0C, 0x00, 0x03,
  0x01, 0x00, 0x00, 0x60, 0x20, 0x00, 0x04, 0x04, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x18, 0x30, 0x00, 0x01, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0xF0, 0x1C, 0x00, 0x30, 0x00, 0xC0, 0x0C,
  0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x10, 0x10, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x0C, 0x10, 0x00, 0x01, 0x82, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x10, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x18, 0x40, 0x00, 0x03,
  0x08, 0x00, 0x00, 0x41, 0x00, 0x00, 0x18, 0x30, 0x00, 0x06, 0x02, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x30, 0x06, 0x00, 0x1C, 0x00, 0x70, 0x0E, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x10, 0x60, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x30, 0x60, 0x00, 0x03, 0x04, 0x00, 0x00, 0x20, 0x40,
  0x00, 0x02, 0x04, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00,
  0x60, 0x80, 0x00, 0x04, 0x08, 0x00, 0x00, 0x40, 0x80, 0x00, 0x04, 0x18,
  0x00, 0x00, 0x41, 0x80, 0x00, 0x0C, 0x18, 0x00, 0x00, 0xC1, 0x00, 0x00,
  0x08, 0x10, 0x00, 0x00, 0x81, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0x83,
  0x00, 0x00, 0x18, 0x30, 0x00, 0x01, 0x82, 0x00, 0x00, 0x10, 0x20, 0x00,
  0x01, 0x02, 0x00, 0x00, 0x10, 0x60, 0x00, 0x01, 0x06, 0x00, 0x00, 0x30,
  0x60, 0x00, 0x03, 0x04, 0x00, 0x00, 0x20, 0x40, 0x00, 0x02, 0x04, 0x00,
  0x00, 0x20, 0x40, 0x00, 0x06, 0x04, 0x00, 0x00, 0x40, 0x40, 0x00, 0x0C,
  0x04, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x18, 0x06, 0x00, 0x03, 0x00, 0x30,
  0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x2C,
  0x00, 0x00, 0x1B, 0x00, 0x00, 0x04, 0x40, 0x00, 0x03, 0x10, 0x00, 0x00,
  0xC4, 0x00, 0x00, 0x61, 0x80, 0x00, 0x18, 0x60, 0x00, 0x04, 0x18, 0x00,
  0x03, 0x06, 0x00, 0x00, 0x80, 0x80, 0x00, 0x60, 0x20, 0x00, 0x10, 0x08,
  0x00, 0x0C, 0x03, 0x00, 0x02, 0x00, 0xC0, 0x01, 0x80, 0x30, 0x00, 0x40,
  0x04, 0x00, 0x30, 0x01, 0x00, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01,
  0x80, 0x06, 0x00, 0x40, 0x01, 0x80, 0x30, 0x00, 0x60, 0x08, 0x00, 0x08,
  0x06, 0x00, 0x02, 0x01, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x30, 0x20, 0x00,
  0x0C, 0x18, 0x00, 0x03, 0x04, 0x00, 0x00, 0x41, 0x00, 0x00, 0x10, 0xC0,
  0x00, 0x04, 0x20, 0x00, 0x01, 0x18, 0x00, 0x00, 0x64, 0x00, 0x00, 0x1B,
  0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x40, 0x00, 0x18, 0x00,
  0x06, 0x40, 0x00, 0x38, 0x00, 0x06, 0x40, 0x00, 0x28, 0x00, 0x04, 0x40,
  0x00, 0x68, 0x00, 0x0C, 0x40, 0x00, 0x48, 0x00, 0x08, 0x40, 0x00, 0x48,
  0x00, 0x08, 0x60, 0x00, 0xC8, 0x00, 0x18, 0x60, 0x00, 0x8C, 0x00, 0x10,
  0x60, 0x01, 0x8C, 0x00, 0x30, 0x60, 0x01, 0x0C, 0x00, 0x30, 0x60, 0x01,
  0x04, 0x00, 0x20, 0x60, 0x03, 0x04, 0x00, 0x60, 0x60, 0x02, 0x04, 0x00,
  0x40, 0x60, 0x06, 0x04, 0x00, 0x40, 0x60, 0x04, 0x04, 0x00, 0xC0, 0x20,
  0x04, 0x04, 0x00, 0x80, 0x20, 0x0C, 0x04, 0x01, 0x80, 0x20, 0x08, 0x06,
  0x01, 0x80, 0x20, 0x18, 0x06, 0x01, 0x00, 0x20, 0x10, 0x06, 0x03, 0x00,
  0x20, 0x10, 0x06, 0x02, 0x00, 0x30, 0x30, 0x06, 0x02, 0x00, 0x30, 0x20,
  0x02, 0x06, 0x00, 0x30, 0x60, 0x02, 0x04, 0x00, 0x30, 0x40, 0x02, 0x0C,
  0x00, 0x30, 0x40, 0x02, 0x0C, 0x00, 0x30, 0xC0, 0x02, 0x08, 0x00, 0x30,
  0x80, 0x02, 0x18, 0x00, 0x31, 0x80, 0x03, 0x10, 0x00, 0x31, 0x00, 0x03,
  0x10, 0x00, 0x13, 0x00, 0x03, 0x30, 0x00, 0x13, 0x00, 0x03, 0x20, 0x00,
  0x12, 0x00, 0x03, 0x60, 0x00, 0x16, 0x00, 0x03, 0x60, 0x00, 0x14, 0x00,
  0x01, 0x40, 0x00, 0x14, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x03, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x20, 0x06,
  0x00, 0x00, 0xC0, 0x04, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x10, 0x00, 0x18, 0x00, 0x60, 0x00, 0x30, 0x01, 0x80, 0x00, 0x20,
  0x02, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x40, 0x30, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x01, 0x81, 0x00, 0x00, 0x01, 0x06, 0x00, 0x00, 0x03, 0x18,
  0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x58, 0x00,
  0x00, 0x01, 0x30, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0x18, 0x60, 0x00,
  0x00, 0x20, 0x40, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x03, 0x00, 0x80, 0x00,
  0x0C, 0x01, 0x80, 0x00, 0x10, 0x03, 0x00, 0x00, 0x60, 0x02, 0x00, 0x01,
  0x80, 0x06, 0x00, 0x02, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x18, 0x00, 0xC0, 0x00, 0x10, 0x01, 0x00, 0x00, 0x30, 0x06, 0x00,
  0x00, 0x20, 0x18, 0x00, 0x00, 0x60, 0x20, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x00, 0xD0, 0x00, 0x00, 0x26, 0x00, 0x00, 0x19, 0x80, 0x00, 0x0C, 0x20,
  0x00, 0x02, 0x0C, 0x00, 0x01, 0x83, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x20,
  0x18, 0x00, 0x18, 0x06, 0x00, 0x0C, 0x00, 0x80, 0x02, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0xC0, 0x01, 0x00, 0x20, 0x00, 0x40, 0x18, 0x00, 0x18,
  0x0C, 0x00, 0x02, 0x02, 0x00, 0x00, 0x81, 0x80, 0x00, 0x30, 0xC0, 0x00,
  0x04, 0x20, 0x00, 0x01, 0x18, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x0A, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0xFC, 0x01,
  0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x3F, 0x00, 0x00, 0x80, 0x80, 0xC0, 0xC0, 0xC0, 0x40, 0x40,
  0x40, 0x40, 0x60, 0x60, 0x60, 0x20, 0x20, 0x20, 0x30, 0x30, 0x30, 0x30,
  0x10, 0x10, 0x10, 0x18, 0x18, 0x18, 0x18, 0x08, 0x08, 0x08, 0x0C, 0x0C,
  0x0C, 0x04, 0x04, 0x04, 0x04, 0x06, 0x06, 0x06, 0x02, 0x02, 0x02, 0x02,
  0x00, 0x7E, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x1F, 0x80, 0x00, 0x00, 0x30, 0x00, 0xE0,
  0x01, 0x40, 0x06, 0x80, 0x09, 0x00, 0x33, 0x00, 0x46, 0x01, 0x8C, 0x02,
  0x08, 0x0C, 0x10, 0x10, 0x20, 0x60, 0x60, 0x80, 0xC3, 0x01, 0x84, 0x01,
  0x18, 0x02, 0x20, 0x04, 0xC0, 0x0D, 0x00, 0x1E, 0x00, 0x30, 0x7F, 0xFF,
  0xF0, 0xC1, 0x86, 0x0C, 0x30, 0x60, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x70, 0x18, 0x06, 0x00, 0x60, 0x60, 0x01, 0x06, 0x00, 0x0C, 0x30,
  0x00, 0x21, 0x00, 0x01, 0x18, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x03, 0xFF, 0xC0, 0x7C,
  0x06, 0x0E, 0x00, 0x30, 0xC0, 0x01, 0x0C, 0x00, 0x08, 0xC0, 0x00, 0x44,
  0x00, 0x06, 0x60, 0x00, 0x33, 0x00, 0x01, 0x90, 0x00, 0x08, 0x80, 0x00,
  0xC4, 0x00, 0x0E, 0x20, 0x00, 0xF1, 0x80, 0x0D, 0x86, 0x00, 0xCC, 0x38,
  0x1C, 0x60, 0x7F, 0x83, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x80, 0x00, 0x02, 0x1F, 0xE0, 0x19, 0xC0, 0xC0, 0x6C, 0x01,
  0x81, 0x60, 0x03, 0x07, 0x00, 0x0C, 0x18, 0x00, 0x10, 0x40, 0x00, 0x43,
  0x00, 0x01, 0x0C, 0x00, 0x04, 0x20, 0x00, 0x10, 0x80, 0x00, 0x42, 0x00,
  0x01, 0x18, 0x00, 0x04, 0x60, 0x00, 0x11, 0x80, 0x00, 0xC4, 0x00, 0x03,
  0x10, 0x00, 0x0C, 0x40, 0x00, 0x23, 0x00, 0x00, 0x8C, 0x00, 0x06, 0x30,
  0x00, 0x18, 0x80, 0x00, 0x42, 0x00, 0x03, 0x08, 0x00, 0x0C, 0x60, 0x00,
  0x61, 0xC0, 0x01, 0x85, 0x00, 0x0C, 0x12, 0x00, 0x60, 0x46, 0x07, 0x01,
  0x0F, 0xF8, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0xE0, 0x30, 0x0C, 0x00, 0xC0, 0xC0, 0x03, 0x04, 0x00, 0x18, 0x60, 0x00,
  0x42, 0x00, 0x02, 0x30, 0x00, 0x11, 0x00, 0x00, 0x88, 0x00, 0x04, 0xC0,
  0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x01, 0x10, 0x00, 0x08, 0x80, 0x00, 0xC6,
  0x00, 0x04, 0x10, 0x00, 0x60, 0xC0, 0x06, 0x02, 0x00, 0x60, 0x1C, 0x0E,
  0x00, 0x3F, 0xE0, 0x00, 0x20, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0xFF, 0x04, 0x01, 0x80, 0xC4,
  0x03, 0x00, 0x6C, 0x06, 0x00, 0x2C, 0x0C, 0x00, 0x1C, 0x08, 0x00, 0x18,
  0x18, 0x00, 0x18, 0x10, 0x00, 0x08, 0x30, 0x00, 0x18, 0x20, 0x00, 0x18,
  0x20, 0x00, 0x18, 0x20, 0x00, 0x10, 0x60, 0x00, 0x10, 0x60, 0x00, 0x10,
  0x40, 0x00, 0x30, 0x40, 0x00, 0x30, 0x40, 0x00, 0x30, 0x40, 0x00, 0x20,
  0xC0, 0x00, 0x20, 0xC0, 0x00, 0x20, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x60,
  0xC0, 0x00, 0x60, 0xC0, 0x00, 0x40, 0x40, 0x00, 0xC0, 0x40, 0x00, 0xC0,
  0x60, 0x01, 0xC0, 0x30, 0x06, 0xC0, 0x38, 0x1C, 0x80, 0x0F, 0xF0, 0x80,
  0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x0C, 0x06, 0x00,
  0x60, 0x0C, 0x03, 0x00, 0x18, 0x18, 0x00, 0x60, 0xC0, 0x00, 0x82, 0x00,
  0x02, 0x18, 0x00, 0x08, 0x40, 0x00, 0x23, 0x00, 0x00, 0x8C, 0x00, 0x02,
  0x20, 0x00, 0x09, 0x80, 0x00, 0x27, 0xFF, 0xFF, 0x98, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x10, 0x18, 0x01, 0x80, 0x38,
  0x1C, 0x00, 0x7F, 0xC0, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x1F, 0xC0,
  0x18, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x03, 0xFF,
  0xC0, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC1, 0x00, 0x60, 0x31,
  0x00, 0xC0, 0x1B, 0x01, 0x80, 0x0B, 0x03, 0x00, 0x06, 0x02, 0x00, 0x06,
  0x06, 0x00, 0x06, 0x04, 0x00, 0x02, 0x0C, 0x00, 0x06, 0x08, 0x00, 0x06,
  0x08, 0x00, 0x04, 0x18, 0x00, 0x04, 0x18, 0x00, 0x04, 0x18, 0x00, 0x04,
  0x10, 0x00, 0x0C, 0x10, 0x00, 0x0C, 0x10, 0x00, 0x08, 0x30, 0x00, 0x08,
  0x30, 0x00, 0x08, 0x30, 0x00, 0x18, 0x30, 0x00, 0x18, 0x30, 0x00, 0x18,
  0x30, 0x00, 0x10, 0x30, 0x00, 0x10, 0x10, 0x00, 0x30, 0x10, 0x00, 0x70,
  0x18, 0x00, 0xF0, 0x0C, 0x01, 0xB0, 0x0E, 0x07, 0x20, 0x03, 0xFC, 0x20,
  0x00, 0x40, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0xC0, 0x01, 0x80, 0x60, 0x03, 0x00,
  0x30, 0x06, 0x00, 0x1E, 0x3C, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x80, 0x40, 0x02, 0x1F, 0xE0, 0x18, 0xC0, 0xC0,
  0x66, 0x01, 0x81, 0xB0, 0x02, 0x05, 0x80, 0x0C, 0x14, 0x00, 0x30, 0x60,
  0x00, 0xC3, 0x80, 0x03, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x30, 0x80, 0x00,
  0xC2, 0x00, 0x02, 0x18, 0x00, 0x08, 0x60, 0x00, 0x21, 0x80, 0x01, 0x84,
  0x00, 0x06, 0x10, 0x00, 0x18, 0x40, 0x00, 0x43, 0x00, 0x01, 0x0C, 0x00,
  0x04, 0x30, 0x00, 0x30, 0x80, 0x00, 0xC2, 0x00, 0x03, 0x08, 0x00, 0x08,
  0x60, 0x00, 0x21, 0x80, 0x00, 0x86, 0x00, 0x06, 0x10, 0x00, 0x18, 0x40,
  0x00, 0x41, 0x00, 0x01, 0x00, 0x03, 0x01, 0xC0, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x40, 0x60, 0x30, 0x18, 0x08,
  0x04, 0x02, 0x03, 0x01, 0x80, 0xC0, 0x40, 0x20, 0x10, 0x18, 0x0C, 0x06,
  0x02, 0x01, 0x00, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x08, 0x04, 0x06, 0x03,
  0x01, 0x80, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x70, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x01, 0x80, 0x09, 0xC0, 0x03, 0xC0,
  0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x20, 0x00, 0xC0, 0xC0, 0x03, 0x01, 0x80, 0x0C, 0x02, 0x00, 0x30, 0x04,
  0x00, 0xC0, 0x08, 0x03, 0x00, 0x10, 0x0C, 0x00, 0x60, 0x30, 0x00, 0xC0,
  0xC0, 0x01, 0x03, 0x00, 0x02, 0x0C, 0x00, 0x04, 0x30, 0x00, 0x18, 0xC0,
  0x00, 0x33, 0x80, 0x00, 0x6D, 0x00, 0x00, 0xA3, 0x00, 0x01, 0x82, 0x00,
  0x02, 0x06, 0x00, 0x0C, 0x04, 0x00, 0x18, 0x0C, 0x00, 0x30, 0x08, 0x00,
  0x40, 0x18, 0x00, 0x80, 0x10, 0x01, 0x00, 0x30, 0x06, 0x00, 0x20, 0x0C,
  0x00, 0x60, 0x18, 0x00, 0x40, 0x20, 0x00, 0xC0, 0x40, 0x00, 0xC0, 0x80,
  0x01, 0x80, 0x01, 0x01, 0x01, 0x03, 0x03, 0x03, 0x02, 0x02, 0x02, 0x06,
  0x06, 0x04, 0x04, 0x04, 0x04, 0x0C, 0x0C, 0x08, 0x08, 0x08, 0x18, 0x18,
  0x18, 0x10, 0x10, 0x10, 0x30, 0x30, 0x30, 0x20, 0x20, 0x20, 0x60, 0x60,
  0x60, 0x40, 0x40, 0x40, 0xC0, 0xC0, 0xC0, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x18, 0x7F, 0x80, 0x7F, 0x80, 0x63, 0x03, 0x03, 0x83, 0x81, 0x18,
  0x06, 0x18, 0x06, 0x04, 0x80, 0x08, 0xC0, 0x0C, 0x14, 0x00, 0x26, 0x00,
  0x30, 0xF0, 0x00, 0xF0, 0x00, 0x43, 0x80, 0x03, 0x80, 0x01, 0x0E, 0x00,
  0x0C, 0x00, 0x04, 0x30, 0x00, 0x30, 0x00, 0x10, 0xC0, 0x00, 0xC0, 0x00,
  0xC2, 0x00, 0x02, 0x00, 0x03, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x60, 0x00,
  0x20, 0x00, 0x21, 0x80, 0x01, 0x80, 0x00, 0x84, 0x00, 0x06, 0x00, 0x02,
  0x10, 0x00, 0x18, 0x00, 0x18, 0xC0, 0x00, 0x40, 0x00, 0x63, 0x00, 0x01,
  0x00, 0x01, 0x8C, 0x00, 0x04, 0x00, 0x04, 0x30, 0x00, 0x30, 0x00, 0x10,
  0x80, 0x00, 0xC0, 0x00, 0x42, 0x00, 0x03, 0x00, 0x03, 0x18, 0x00, 0x08,
  0x00, 0x0C, 0x60, 0x00, 0x20, 0x00, 0x31, 0x80, 0x00, 0x80, 0x00, 0x84,
  0x00, 0x06, 0x00, 0x02, 0x10, 0x00, 0x18, 0x00, 0x08, 0x40, 0x00, 0x60,
  0x00, 0x63, 0x00, 0x01, 0x00, 0x01, 0x8C, 0x00, 0x04, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x00, 0x18, 0x3F, 0x80, 0x63, 0x03, 0x01, 0x98, 0x06, 0x04,
  0xC0, 0x08, 0x16, 0x00, 0x30, 0x50, 0x00, 0xC3, 0x80, 0x03, 0x0E, 0x00,
  0x0C, 0x30, 0x00, 0x30, 0xC0, 0x00, 0xC2, 0x00, 0x03, 0x08, 0x00, 0x08,
  0x60, 0x00, 0x21, 0x80, 0x00, 0x86, 0x00, 0x06, 0x10, 0x00, 0x18, 0x40,
  0x00, 0x61, 0x00, 0x01, 0x0C, 0x00, 0x04, 0x30, 0x00, 0x10, 0xC0, 0x00,
  0xC2, 0x00, 0x03, 0x08, 0x00, 0x0C, 0x20, 0x00, 0x21, 0x80, 0x00, 0x86,
  0x00, 0x02, 0x18, 0x00, 0x18, 0x40, 0x00, 0x61, 0x00, 0x01, 0x04, 0x00,
  0x04, 0x00, 0x00, 0x04, 0x00, 0x01, 0xFF, 0x00, 0x1C, 0x0E, 0x00, 0xC0,
  0x0C, 0x06, 0x00, 0x10, 0x30, 0x00, 0x60, 0x80, 0x01, 0x86, 0x00, 0x02,
  0x10, 0x00, 0x08, 0xC0, 0x00, 0x23, 0x00, 0x00, 0x88, 0x00, 0x02, 0x60,
  0x00, 0x09, 0x80, 0x00, 0x24, 0x00, 0x00, 0x90, 0x00, 0x02, 0x40, 0x00,
  0x19, 0x00, 0x00, 0x6C, 0x00, 0x01, 0xB0, 0x00, 0x04, 0xC0, 0x00, 0x33,
  0x00, 0x00, 0xCC, 0x00, 0x02, 0x30, 0x00, 0x18, 0xC0, 0x00, 0x41, 0x00,
  0x03, 0x06, 0x00, 0x08, 0x18, 0x00, 0x60, 0x30, 0x07, 0x00, 0x70, 0x38,
  0x00, 0xFF, 0x80, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x01, 0x87, 0xF8,
  0x01, 0x9C, 0x0C, 0x01, 0xB0, 0x06, 0x01, 0x60, 0x03, 0x01, 0xC0, 0x03,
  0x01, 0x80, 0x01, 0x03, 0x00, 0x01, 0x03, 0x00, 0x01, 0x03, 0x00, 0x01,
  0x02, 0x00, 0x01, 0x02, 0x00, 0x01, 0x02, 0x00, 0x01, 0x06, 0x00, 0x01,
  0x06, 0x00, 0x01, 0x04, 0x00, 0x03, 0x04, 0x00, 0x03, 0x04, 0x00, 0x03,
  0x04, 0x00, 0x02, 0x0C, 0x00, 0x02, 0x0C, 0x00, 0x06, 0x08, 0x00, 0x06,
  0x08, 0x00, 0x04, 0x08, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x18,
  0x1C, 0x00, 0x18, 0x14, 0x00, 0x30, 0x12, 0x00, 0x60, 0x11, 0x81, 0xC0,
  0x30, 0xFF, 0x80, 0x30, 0x08, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x10, 0x18, 0x1C, 0x40, 0xC0, 0x1B, 0x06,
  0x00, 0x2C, 0x30, 0x00, 0x60, 0x80, 0x01, 0x86, 0x00, 0x06, 0x10, 0x00,
  0x08, 0xC0, 0x00, 0x63, 0x00, 0x01, 0x88, 0x00, 0x04, 0x60, 0x00, 0x11,
  0x80, 0x00, 0x46, 0x00, 0x01, 0x10, 0x00, 0x0C, 0x40, 0x00, 0x31, 0x00,
  0x00, 0x84, 0x00, 0x02, 0x30, 0x00, 0x08, 0xC0, 0x00, 0x63, 0x00, 0x01,
  0x8C, 0x00, 0x06, 0x30, 0x00, 0x18, 0xC0, 0x00, 0x41, 0x00, 0x03, 0x04,
  0x00, 0x0C, 0x18, 0x00, 0x70, 0x20, 0x06, 0xC0, 0xE0, 0x72, 0x00, 0xFF,
  0x08, 0x00, 0x40, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x03, 0x0F,
  0x81, 0x9C, 0x00, 0xD8, 0x00, 0x48, 0x00, 0x28, 0x00, 0x18, 0x00, 0x1C,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0xF0, 0x38, 0x0E, 0x00,
  0xC0, 0x40, 0x03, 0x06, 0x00, 0x08, 0x20, 0x00, 0x43, 0x00, 0x02, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x00, 0x08, 0xC0, 0x00, 0xC6, 0x00, 0x06, 0x30, 0x00,
  0x20, 0x80, 0x02, 0x06, 0x00, 0x70, 0x1C, 0x0E, 0x00, 0x3F, 0xE0, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00, 0x60, 0x06,
  0x00, 0x60, 0xFF, 0xF0, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08,
  0x00, 0x80, 0x08, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0x01, 0x00, 0x10,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x06, 0x00, 0x60, 0x03, 0xF0, 0x04,
  0x00, 0x18, 0x00, 0x08, 0xC0, 0x00, 0x46, 0x00, 0x06, 0x20, 0x00, 0x31,
  0x00, 0x01, 0x88, 0x00, 0x08, 0xC0, 0x00, 0x46, 0x00, 0x02, 0x30, 0x00,
  0x31, 0x00, 0x01, 0x88, 0x00, 0x08, 0x40, 0x00, 0x46, 0x00, 0x02, 0x30,
  0x00, 0x11, 0x00, 0x01, 0x88, 0x00, 0x0C, 0x40, 0x00, 0x46, 0x00, 0x02,
  0x30, 0x00, 0x11, 0x80, 0x01, 0x8C, 0x00, 0x0C, 0x40, 0x00, 0x62, 0x00,
  0x02, 0x10, 0x00, 0x30, 0xC0, 0x03, 0x86, 0x00, 0x1C, 0x10, 0x01, 0xE0,
  0xC0, 0x1B, 0x03, 0x03, 0x90, 0x0F, 0xF0, 0x80, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x12, 0x00, 0x01, 0x90, 0x00, 0x0C, 0xC0, 0x00, 0x46, 0x00, 0x06,
  0x30, 0x00, 0x20, 0x80, 0x03, 0x04, 0x00, 0x10, 0x20, 0x01, 0x81, 0x80,
  0x08, 0x0C, 0x00, 0xC0, 0x60, 0x04, 0x01, 0x00, 0x60, 0x08, 0x02, 0x00,
  0x40, 0x30, 0x02, 0x01, 0x00, 0x18, 0x08, 0x00, 0xC0, 0xC0, 0x06, 0x04,
  0x00, 0x10, 0x60, 0x00, 0x82, 0x00, 0x04, 0x30, 0x00, 0x31, 0x00, 0x01,
  0x98, 0x00, 0x0C, 0x80, 0x00, 0x2C, 0x00, 0x01, 0x40, 0x00, 0x0E, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x80, 0x03, 0x00, 0x05, 0x00, 0x06,
  0x00, 0x1A, 0x00, 0x1C, 0x00, 0x34, 0x00, 0x28, 0x00, 0x48, 0x00, 0xD0,
  0x01, 0x90, 0x01, 0xA0, 0x02, 0x30, 0x02, 0x40, 0x0C, 0x60, 0x0C, 0x80,
  0x18, 0xC0, 0x11, 0x80, 0x21, 0x80, 0x63, 0x00, 0xC3, 0x00, 0x86, 0x01,
  0x06, 0x03, 0x0C, 0x06, 0x0C, 0x06, 0x18, 0x0C, 0x18, 0x08, 0x30, 0x30,
  0x10, 0x30, 0x20, 0x60, 0x20, 0x40, 0x40, 0x80, 0x41, 0x80, 0x83, 0x00,
  0x82, 0x01, 0x06, 0x01, 0x0C, 0x02, 0x18, 0x02, 0x18, 0x04, 0x30, 0x04,
  0x20, 0x0C, 0x40, 0x0C, 0xC0, 0x19, 0x80, 0x19, 0x00, 0x33, 0x00, 0x36,
  0x00, 0x6C, 0x00, 0x68, 0x00, 0x58, 0x00, 0xF0, 0x00, 0xA0, 0x01, 0xC0,
  0x01, 0xC0, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x04, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x03, 0x03, 0x00, 0x06, 0x03, 0x00, 0x0C,
  0x01, 0x00, 0x08, 0x01, 0x80, 0x18, 0x00, 0x80, 0x30, 0x00, 0xC0, 0x60,
  0x00, 0xC0, 0x40, 0x00, 0x40, 0xC0, 0x00, 0x61, 0x80, 0x00, 0x21, 0x00,
  0x00, 0x33, 0x00, 0x00, 0x16, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x64, 0x00, 0x00, 0x46, 0x00,
  0x00, 0xC2, 0x00, 0x01, 0x83, 0x00, 0x03, 0x01, 0x00, 0x02, 0x01, 0x80,
  0x06, 0x01, 0x80, 0x0C, 0x00, 0x80, 0x18, 0x00, 0xC0, 0x10, 0x00, 0x40,
  0x30, 0x00, 0x60, 0x60, 0x00, 0x60, 0xC0, 0x00, 0x30, 0x02, 0x00, 0x00,
  0xC0, 0x80, 0x00, 0x20, 0x30, 0x00, 0x18, 0x0C, 0x00, 0x04, 0x03, 0x00,
  0x03, 0x00, 0x40, 0x00, 0x80, 0x10, 0x00, 0x60, 0x04, 0x00, 0x10, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x18, 0x01, 0x80, 0x02, 0x00, 0x40,
  0x00, 0x80, 0x30, 0x00, 0x20, 0x08, 0x00, 0x08, 0x06, 0x00, 0x03, 0x01,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x30, 0x20, 0x00, 0x04, 0x18, 0x00, 0x01,
  0x06, 0x00, 0x00, 0x43, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x06, 0x60, 0x00,
  0x01, 0x98, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x80, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x1E,
  0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x03,
  0x00, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x08, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0x80, 0x40, 0x60, 0x30, 0x18, 0x0C, 0x04, 0x02, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x10, 0x08, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x80, 0x40,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x02, 0x01, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x10, 0x08, 0x0C, 0x06, 0x03, 0x00, 0x00, 0x40, 0x00, 0x1C, 0x00, 0x01,
  0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0F, 0x00, 0x01, 0xC0,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xBC, 0x00, 0x11, 0x81, 0x80, 0x0C, 0xC0, 0x30,
  0x02, 0x20, 0x0C, 0x00, 0x98, 0x01, 0x80, 0x44, 0x00, 0x30, 0x31, 0x00,
  0x07, 0x38, 0x00, 0x00, 0xF8, 0x00,
};

const GFXglyph RobotoCondensed_ThinItalic56pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 9, 41, 10, 1, -40 },
  { 48, 9, 11, 14, 6, -42 },
  { 61, 28, 40, 26, 1, -40 },
  { 201, 23, 52, 26, 2, -46 },
  { 351, 26, 42, 35, 5, -41 },
  { 488, 24, 42, 29, 2, -41 },
  { 614, 3, 11, 9, 6, -42 },
  { 619, 15, 57, 15, 3, -44 },
  { 726, 15, 57, 15, -3, -44 },
  { 833, 22, 22, 23, 3, -40 },
  { 894, 23, 29, 27, 2, -33 },
  { 978, 6, 11, 10, -2, -4 },
  { 987, 11, 1, 15, 2, -19 },
  { 989, 4, 3, 12, 1, -2 },
  { 991, 23, 43, 19, -2, -40 },
  { 1115, 22, 42, 26, 3, -41 },
  { 1231, 12, 40, 26, 8, -40 },
  { 1291, 23, 41, 26, 1, -41 },
  { 1409, 23, 42, 26, 2, -41 },
  { 1530, 23, 40, 26, 1, -40 },
  { 1645, 24, 41, 26, 3, -40 },
  { 1768, 20, 41, 26, 3, -40 },
  { 1871, 22, 40, 26, 5, -40 },
  { 1981, 25, 42, 26, 1, -41 },
  { 2113, 21, 41, 26, 4, -41 },
  { 2221, 8, 29, 10, 1, -28 },
  { 2250, 11, 35, 10, -2, -28 },
  { 2299, 21, 22, 25, 2, -29 },
  { 2357, 21, 12, 27, 3, -24 },
  { 2389, 20, 22, 25, 2, -29 },
  { 2444, 17, 42, 21, 5, -41 },
  { 2534, 39, 51, 44, 2, -39 },
  { 2783, 27, 40, 29, -2, -40 },
  { 2918, 25, 40, 29, 2, -40 },
  { 3043, 27, 42, 31, 3, -41 },
  { 3185, 27, 40, 31, 2, -40 },
  { 3320, 27, 40, 27, 2, -40 },
  { 3455, 27, 40, 27, 2, -40 },
  { 3590, 26, 42, 33, 4, -41 },
  { 3727, 30, 40, 33, 2, -40 },
  { 3877, 8, 40, 13, 3, -40 },
  { 3917, 25, 41, 26, 1, -40 },
  { 4046, 29, 40, 30, 2, -40 },
  { 4191, 19, 40, 25, 2, -40 },
  { 4286, 38, 40, 41, 2, -40 },
  { 4476, 31, 40, 34, 2, -40 },
  { 4631, 27, 42, 32, 3, -41 },
  { 4773, 27, 40, 29, 2, -40 },
  { 4908, 27, 48, 32, 3, -41 },
  { 5070, 27, 40, 31, 2, -40 },
  { 5205, 27, 42, 28, 1, -41 },
  { 5347, 26, 40, 29, 5, -40 },
  { 5477, 28, 41, 32, 3, -40 },
  { 5621, 26, 40, 29, 5, -40 },
  { 5751, 40, 40, 43, 5, -40 },
  { 5951, 31, 40, 29, -1, -40 },
  { 6106, 26, 40, 29, 5, -40 },
  { 6236, 29, 40, 29, 0, -40 },
  { 6381, 15, 55, 11, 1, -46 },
  { 6485, 8, 43, 18, 6, -40 },
  { 6528, 15, 55, 11, -4, -46 },
  { 6632, 15, 20, 20, 3, -40 },
  { 6670, 20, 1, 20, -3, 0 },
  { 6673, 6, 7, 14, 8, -42 },
  { 6679, 21, 32, 25, 1, -31 },
  { 6763, 22, 43, 26, 1, -42 },
  { 6882, 21, 32, 24, 2, -31 },
  { 6966, 24, 43, 26, 2, -42 },
  { 7095, 22, 32, 25, 1, -31 },
  { 7183, 17, 43, 16, 3, -43 },
  { 7275, 24, 42, 26, 0, -31 },
  { 7401, 22, 42, 26, 1, -42 },
  { 7517, 9, 41, 11, 2, -41 },
  { 7564, 18, 52, 11, -7, -41 },
  { 7681, 23, 42, 23, 1, -42 },
  { 7802, 8, 42, 11, 2, -42 },
  { 7844, 38, 31, 42, 1, -31 },
  { 7992, 22, 31, 26, 1, -31 },
  { 8078, 22, 32, 26, 2, -31 },
  { 8166, 24, 42, 26, -1, -31 },
  { 8292, 22, 42, 26, 2, -31 },
  { 8408, 17, 31, 16, 1, -31 },
  { 8474, 21, 32, 24, 1, -31 },
  { 8558, 12, 39, 16, 3, -38 },
  { 8617, 21, 31, 26, 3, -30 },
  { 8699, 21, 30, 23, 3, -30 },
  { 8778, 31, 30, 36, 5, -30 },
  { 8895, 24, 30, 23, -1, -30 },
  { 8985, 26, 41, 23, -2, -30 },
  { 9119, 23, 30, 23, 0, -30 },
  { 9206, 17, 56, 16, 2, -44 },
  { 9325, 9, 47, 11, 1, -40 },
  { 9378, 18, 56, 16, -4, -44 },
  { 9504, 26, 9, 33, 3, -21 },
};

const GFXfont RobotoCondensed_ThinItalic56pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ThinItalic56pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ThinItalic56pt7bGlyphs,
  0x20, 0x7E, 66
};

#endif // _ROBOTOCONDENSED_THINITALIC56PT7B_H_
