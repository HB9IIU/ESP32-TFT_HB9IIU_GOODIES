#ifndef _ROBOTOCONDENSED_THINITALIC55PT7B_H_
#define _ROBOTOCONDENSED_THINITALIC55PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ThinItalic.ttf
// Size: 55pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ThinItalic55pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0x00, 0x80, 0x40, 0x20, 0x30, 0x18, 0x08, 0x04, 0x02, 0x03,
  0x01, 0x80, 0xC0, 0x40, 0x20, 0x10, 0x18, 0x0C, 0x04, 0x02, 0x01, 0x00,
  0x80, 0xC0, 0x60, 0x20, 0x10, 0x08, 0x04, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x21, 0x90,
  0xC8, 0x4C, 0x26, 0x13, 0x19, 0x0C, 0x86, 0xC2, 0x61, 0x31, 0x80, 0x00,
  0x01, 0x00, 0x80, 0x00, 0x60, 0x10, 0x00, 0x08, 0x06, 0x00, 0x01, 0x00,
  0x80, 0x00, 0x60, 0x10, 0x00, 0x08, 0x06, 0x00, 0x01, 0x00, 0x80, 0x00,
  0x60, 0x10, 0x00, 0x08, 0x06, 0x00, 0x01, 0x00, 0x80, 0x00, 0x60, 0x10,
  0x07, 0xFF, 0xFF, 0xF0, 0x01, 0x00, 0xC0, 0x00, 0x60, 0x10, 0x00, 0x0C,
  0x06, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x60, 0x10, 0x00, 0x0C, 0x06, 0x00,
  0x01, 0x00, 0xC0, 0x00, 0x20, 0x10, 0x00, 0x0C, 0x06, 0x00, 0x01, 0x00,
  0xC0, 0x00, 0x20, 0x10, 0x00, 0x0C, 0x06, 0x00, 0x01, 0x00, 0xC0, 0x00,
  0x20, 0x10, 0x00, 0x0C, 0x02, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x20, 0x10,
  0x00, 0x0C, 0x02, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x20, 0x10, 0x00, 0x0C,
  0x02, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x20, 0x10, 0x00, 0x0C, 0x02, 0x00,
  0x01, 0x00, 0xC0, 0x00, 0x20, 0x10, 0x00, 0x0C, 0x02, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x60, 0x00, 0x0F, 0xF8, 0x00, 0x38, 0x18, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x18, 0x0C, 0x00, 0x30, 0x10, 0x00, 0x20, 0x60, 0x00,
  0x40, 0x80, 0x00, 0xC3, 0x00, 0x01, 0x86, 0x00, 0x03, 0x0C, 0x00, 0x04,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x63, 0x00, 0x00, 0xC6, 0x00, 0x01, 0x8C, 0x00, 0x03, 0x18, 0x00, 0x04,
  0x30, 0x00, 0x18, 0x20, 0x00, 0x20, 0x60, 0x00, 0xC0, 0xC0, 0x03, 0x00,
  0xC0, 0x0C, 0x00, 0xE0, 0x70, 0x00, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xC3, 0x00, 0x00,
  0x40, 0x40, 0x00, 0x30, 0x18, 0x00, 0x08, 0x06, 0x00, 0x06, 0x00, 0x80,
  0x21, 0x00, 0x20, 0x18, 0x40, 0x18, 0x0C, 0x30, 0x06, 0x02, 0x0C, 0x01,
  0x01, 0x83, 0x00, 0x40, 0xC0, 0xC0, 0x30, 0x20, 0x30, 0x0C, 0x18, 0x0C,
  0x06, 0x0C, 0x01, 0x01, 0x02, 0x00, 0x61, 0xC1, 0x80, 0x0F, 0xC0, 0xC0,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC1, 0xFC, 0x00, 0x60, 0xC1, 0x80,
  0x10, 0x20, 0x20, 0x0C, 0x10, 0x08, 0x06, 0x0C, 0x03, 0x01, 0x02, 0x00,
  0xC0, 0x80, 0x80, 0x30, 0x60, 0x60, 0x0C, 0x10, 0x18, 0x02, 0x08, 0x04,
  0x00, 0x86, 0x01, 0x00, 0x23, 0x00, 0x40, 0x18, 0x80, 0x10, 0x04, 0x00,
  0x06, 0x03, 0x00, 0x00, 0x81, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x06,
  0x0C, 0x00, 0x06, 0x02, 0x00, 0x06, 0x01, 0x80, 0x06, 0x00, 0xC0, 0x03,
  0x00, 0x60, 0x01, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x08, 0x00,
  0x60, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x18, 0x04, 0x00, 0x04, 0x04, 0x00,
  0x02, 0x04, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x19, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x18, 0x30, 0x00, 0x18, 0x18, 0x03, 0x08, 0x06, 0x01, 0x8C, 0x01,
  0x00, 0x8C, 0x00, 0xC0, 0x44, 0x00, 0x20, 0x66, 0x00, 0x18, 0x23, 0x00,
  0x06, 0x31, 0x00, 0x03, 0x18, 0x80, 0x00, 0xD8, 0x40, 0x00, 0x28, 0x20,
  0x00, 0x1C, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x0F, 0x03, 0x00, 0x0C, 0xC1,
  0xC0, 0x0C, 0x60, 0x70, 0x18, 0x18, 0x0F, 0xF8, 0x04, 0x00, 0x40, 0x00,
  0x00, 0x2D, 0xB6, 0x96, 0xD2, 0x00, 0x00, 0x04, 0x00, 0x18, 0x00, 0x60,
  0x00, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x20, 0x00,
  0x40, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01,
  0x00, 0x01, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x18,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x80, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80,
  0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x02,
  0x00, 0x0C, 0x00, 0x10, 0x00, 0x40, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x0C, 0x06,
  0x03, 0x78, 0x30, 0xF0, 0x71, 0x1C, 0x00, 0xFF, 0x80, 0x00, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0xC8, 0x00, 0x0C, 0x60, 0x00, 0x61, 0x80, 0x06, 0x0C,
  0x00, 0x60, 0x30, 0x06, 0x01, 0x80, 0x60, 0x06, 0x02, 0x00, 0x10, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x00, 0x00, 0x02, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x30, 0xC3, 0x08, 0x61, 0x8C, 0x31, 0x84, 0x00, 0xFF, 0xE0, 0xFD,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00,
  0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x38, 0x38, 0x03, 0x00, 0x60, 0x30, 0x03, 0x03, 0x00,
  0x08, 0x10, 0x00, 0x61, 0x80, 0x01, 0x08, 0x00, 0x08, 0xC0, 0x00, 0x46,
  0x00, 0x02, 0x20, 0x00, 0x13, 0x00, 0x00, 0x98, 0x00, 0x04, 0x80, 0x00,
  0x24, 0x00, 0x01, 0x60, 0x00, 0x1B, 0x00, 0x00, 0xD8, 0x00, 0x06, 0x80,
  0x00, 0x24, 0x00, 0x01, 0x20, 0x00, 0x0B, 0x00, 0x00, 0xD8, 0x00, 0x06,
  0xC0, 0x00, 0x34, 0x00, 0x01, 0x20, 0x00, 0x09, 0x00, 0x00, 0xC8, 0x00,
  0x06, 0x40, 0x00, 0x22, 0x00, 0x03, 0x10, 0x00, 0x18, 0x80, 0x00, 0x84,
  0x00, 0x0C, 0x30, 0x00, 0xC0, 0x80, 0x06, 0x06, 0x00, 0x60, 0x30, 0x06,
  0x00, 0xC0, 0xE0, 0x03, 0xFC, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x3C,
  0x1D, 0x9E, 0x3E, 0x05, 0x00, 0x80, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x02,
  0x00, 0x40, 0x08, 0x03, 0x00, 0x60, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01,
  0x80, 0x30, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0xC0, 0x18, 0x02, 0x00,
  0x40, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x04, 0x01, 0x80,
  0x30, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xC0, 0xC0,
  0x06, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x60, 0x00, 0x80, 0xC0, 0x01, 0x03,
  0x00, 0x03, 0x04, 0x00, 0x06, 0x08, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x40,
  0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x02,
  0x00, 0x00, 0x7F, 0xC0, 0x03, 0x81, 0xC0, 0x0C, 0x00, 0xC0, 0x30, 0x00,
  0x80, 0x40, 0x01, 0x81, 0x80, 0x03, 0x06, 0x00, 0x02, 0x0C, 0x00, 0x04,
  0x10, 0x00, 0x08, 0x60, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x10, 0x00, 0x02,
  0x20, 0x00, 0x0C, 0x40, 0x00, 0x10, 0x80, 0x00, 0x21, 0x80, 0x00, 0xC3,
  0x00, 0x01, 0x02, 0x00, 0x06, 0x06, 0x00, 0x18, 0x06, 0x00, 0x60, 0x07,
  0x03, 0x80, 0x07, 0xFC, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0x60, 0x00, 0x06, 0x80, 0x00,
  0x19, 0x00, 0x00, 0x22, 0x00, 0x00, 0xCC, 0x00, 0x03, 0x18, 0x00, 0x0C,
  0x30, 0x00, 0x10, 0x40, 0x00, 0x60, 0x80, 0x01, 0x81, 0x00, 0x02, 0x06,
  0x00, 0x08, 0x0C, 0x00, 0x30, 0x10, 0x00, 0xC0, 0x20, 0x01, 0x00, 0x40,
  0x06, 0x00, 0x80, 0x18, 0x03, 0x00, 0x60, 0x06, 0x00, 0x80, 0x08, 0x03,
  0x00, 0x10, 0x0C, 0x00, 0x20, 0x30, 0x00, 0xC0, 0x60, 0x01, 0x81, 0x80,
  0x03, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xFF, 0xFE, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x80, 0x00, 0x02, 0x1F, 0x80, 0x05, 0xE3, 0xC0, 0x0E,
  0x01, 0xC0, 0x30, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x02,
  0x08, 0x00, 0x04, 0x10, 0x00, 0x18, 0x20, 0x00, 0x20, 0x40, 0x00, 0xC0,
  0x80, 0x01, 0x01, 0x80, 0x06, 0x01, 0x00, 0x08, 0x03, 0x00, 0x20, 0x03,
  0x81, 0x80, 0x03, 0xFE, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0xFC, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01,
  0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x7E, 0x02, 0x1C, 0x78,
  0x26, 0x01, 0xC6, 0xC0, 0x0C, 0x78, 0x00, 0x65, 0x00, 0x02, 0x60, 0x00,
  0x26, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x28, 0x00, 0x02, 0x80, 0x00, 0x28, 0x00, 0x06, 0x80,
  0x00, 0x48, 0x00, 0x04, 0xC0, 0x00, 0xCC, 0x00, 0x18, 0x40, 0x01, 0x06,
  0x00, 0x30, 0x30, 0x06, 0x01, 0x81, 0xC0, 0x0F, 0xF0, 0x00, 0x08, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00,
  0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00,
  0x04, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00,
  0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x04,
  0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00,
  0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x38, 0x38, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x06, 0x01, 0x80,
  0x06, 0x03, 0x00, 0x03, 0x02, 0x00, 0x03, 0x06, 0x00, 0x03, 0x06, 0x00,
  0x03, 0x04, 0x00, 0x03, 0x04, 0x00, 0x03, 0x04, 0x00, 0x02, 0x04, 0x00,
  0x06, 0x04, 0x00, 0x06, 0x06, 0x00, 0x0C, 0x06, 0x00, 0x18, 0x03, 0x00,
  0x30, 0x01, 0x80, 0x60, 0x00, 0xF3, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0x81,
  0xC0, 0x06, 0x00, 0x60, 0x0C, 0x00, 0x30, 0x18, 0x00, 0x18, 0x30, 0x00,
  0x18, 0x20, 0x00, 0x08, 0x60, 0x00, 0x08, 0x60, 0x00, 0x08, 0x40, 0x00,
  0x08, 0x40, 0x00, 0x08, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18, 0x40, 0x00,
  0x10, 0x40, 0x00, 0x30, 0x60, 0x00, 0x60, 0x20, 0x00, 0xC0, 0x30, 0x01,
  0x80, 0x1C, 0x07, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x03, 0x81, 0x80, 0x60, 0x0C, 0x0C, 0x00, 0x60, 0x80,
  0x02, 0x18, 0x00, 0x33, 0x00, 0x03, 0x20, 0x00, 0x36, 0x00, 0x01, 0x60,
  0x00, 0x14, 0x00, 0x01, 0x40, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x6C, 0x00, 0x06,
  0xC0, 0x00, 0xA4, 0x00, 0x1E, 0x60, 0x01, 0x62, 0x00, 0x64, 0x30, 0x0C,
  0x41, 0xE7, 0x8C, 0x07, 0xE0, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00,
  0x10, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x3F, 0x00, 0x07,
  0x80, 0x00, 0x0E, 0x1C, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x87, 0x00, 0x00, 0x01, 0xC0, 0x70, 0x08, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x03,
  0x00, 0xC0, 0x20, 0x18, 0x06, 0x01, 0x00, 0xC0, 0x20, 0x18, 0x04, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x40, 0x3F, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x10, 0x00, 0x01, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x0E, 0x0C, 0x18, 0x06, 0x30, 0x02, 0x20,
  0x03, 0x60, 0x03, 0x40, 0x03, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x08, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x00, 0x80, 0x03, 0x00, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00,
  0x04, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x00, 0x20, 0x10,
  0x00, 0x00, 0x00, 0x80, 0xC0, 0x03, 0xE0, 0x03, 0x06, 0x00, 0x3D, 0xC0,
  0x0C, 0x18, 0x01, 0x81, 0x80, 0x10, 0xC0, 0x0C, 0x03, 0x00, 0x43, 0x00,
  0x60, 0x08, 0x01, 0x18, 0x03, 0x00, 0x20, 0x04, 0x60, 0x08, 0x00, 0x80,
  0x11, 0x00, 0x60, 0x06, 0x00, 0x4C, 0x01, 0x00, 0x10, 0x01, 0x20, 0x0C,
  0x00, 0x40, 0x0C, 0x80, 0x20, 0x01, 0x00, 0x36, 0x00, 0x80, 0x0C, 0x00,
  0xD0, 0x06, 0x00, 0x30, 0x02, 0x40, 0x10, 0x00, 0x80, 0x09, 0x00, 0x40,
  0x02, 0x00, 0x6C, 0x03, 0x00, 0x18, 0x01, 0xB0, 0x0C, 0x00, 0x60, 0x04,
  0xC0, 0x20, 0x01, 0x00, 0x12, 0x00, 0x80, 0x04, 0x00, 0xC8, 0x02, 0x00,
  0x30, 0x02, 0x20, 0x08, 0x00, 0xC0, 0x18, 0x80, 0x20, 0x07, 0x00, 0x42,
  0x00, 0x80, 0x3C, 0x03, 0x08, 0x02, 0x00, 0xB0, 0x08, 0x30, 0x0C, 0x04,
  0x40, 0x40, 0xC0, 0x10, 0x61, 0x87, 0x03, 0x00, 0x7F, 0x03, 0xF0, 0x0C,
  0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x40, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x01,
  0xF9, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x02, 0x80, 0x00, 0x00, 0xA0, 0x00, 0x00,
  0x48, 0x00, 0x00, 0x13, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x02, 0x10, 0x00,
  0x01, 0x84, 0x00, 0x00, 0x41, 0x00, 0x00, 0x30, 0x40, 0x00, 0x08, 0x10,
  0x00, 0x06, 0x06, 0x00, 0x01, 0x01, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x20,
  0x08, 0x00, 0x18, 0x02, 0x00, 0x04, 0x00, 0x80, 0x03, 0x00, 0x20, 0x00,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x00, 0xC0, 0x0C, 0x00, 0x10,
  0x02, 0x00, 0x04, 0x01, 0x80, 0x01, 0x00, 0x40, 0x00, 0x40, 0x3F, 0xFF,
  0xF0, 0x08, 0x00, 0x06, 0x06, 0x00, 0x01, 0x81, 0x80, 0x00, 0x60, 0x40,
  0x00, 0x08, 0x30, 0x00, 0x02, 0x08, 0x00, 0x00, 0x86, 0x00, 0x00, 0x21,
  0x00, 0x00, 0x0C, 0xC0, 0x00, 0x03, 0x20, 0x00, 0x00, 0xD8, 0x00, 0x00,
  0x34, 0x00, 0x00, 0x04, 0x01, 0xFF, 0xE0, 0x00, 0x80, 0x3C, 0x00, 0xC0,
  0x03, 0x00, 0x60, 0x00, 0xC0, 0x30, 0x00, 0x30, 0x10, 0x00, 0x08, 0x08,
  0x00, 0x04, 0x04, 0x00, 0x02, 0x06, 0x00, 0x01, 0x03, 0x00, 0x00, 0x81,
  0x00, 0x00, 0x40, 0x80, 0x00, 0x60, 0x40, 0x00, 0x30, 0x20, 0x00, 0x10,
  0x30, 0x00, 0x18, 0x18, 0x00, 0x18, 0x08, 0x00, 0x18, 0x04, 0x00, 0x18,
  0x02, 0x00, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0x80, 0x07, 0x00, 0xC0, 0x00,
  0xC0, 0x40, 0x00, 0x30, 0x20, 0x00, 0x18, 0x10, 0x00, 0x04, 0x18, 0x00,
  0x03, 0x0C, 0x00, 0x01, 0x86, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x61, 0x00,
  0x00, 0x20, 0x80, 0x00, 0x10, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x08, 0x20,
  0x00, 0x0C, 0x10, 0x00, 0x0C, 0x08, 0x00, 0x0C, 0x04, 0x00, 0x1C, 0x06,
  0x00, 0x7C, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x07, 0xFE,
  0x00, 0x07, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x01, 0x80, 0x01, 0x00, 0xC0,
  0x00, 0x60, 0x20, 0x00, 0x08, 0x18, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x30, 0x80, 0x00, 0x0C, 0x60, 0x00, 0x03, 0x10, 0x00, 0x00,
  0xC4, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x02, 0x30, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x10, 0x40, 0x00, 0x0C, 0x10, 0x00, 0x02, 0x06, 0x00, 0x01, 0x80,
  0x80, 0x00, 0xC0, 0x30, 0x00, 0x60, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x38,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x20, 0x0F, 0x00, 0x0C, 0x00, 0x38, 0x01, 0x80, 0x01, 0x80, 0x20, 0x00,
  0x18, 0x04, 0x00, 0x03, 0x00, 0x80, 0x00, 0x30, 0x10, 0x00, 0x06, 0x06,
  0x00, 0x00, 0x40, 0xC0, 0x00, 0x08, 0x10, 0x00, 0x01, 0x02, 0x00, 0x00,
  0x30, 0x40, 0x00, 0x06, 0x08, 0x00, 0x00, 0x83, 0x00, 0x00, 0x10, 0x60,
  0x00, 0x02, 0x08, 0x00, 0x00, 0x41, 0x00, 0x00, 0x18, 0x20, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x61, 0x80, 0x00, 0x08, 0x30, 0x00, 0x01, 0x04, 0x00,
  0x00, 0x20, 0x80, 0x00, 0x0C, 0x10, 0x00, 0x01, 0x86, 0x00, 0x00, 0x20,
  0xC0, 0x00, 0x04, 0x10, 0x00, 0x01, 0x82, 0x00, 0x00, 0x20, 0x40, 0x00,
  0x0C, 0x08, 0x00, 0x01, 0x83, 0x00, 0x00, 0x60, 0x60, 0x00, 0x08, 0x08,
  0x00, 0x03, 0x01, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x70, 0x04, 0x00, 0x18,
  0x01, 0x80, 0x3E, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x0F, 0xFF, 0xFC, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x0F, 0xFF, 0xFC, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x07, 0xFE, 0x00, 0x07, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x01, 0x80, 0x03,
  0x00, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x08, 0x10, 0x00, 0x02, 0x0C, 0x00,
  0x00, 0xC2, 0x00, 0x00, 0x31, 0x80, 0x00, 0x0C, 0x40, 0x00, 0x03, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00,
  0x1F, 0xFC, 0xC0, 0x00, 0x03, 0x30, 0x00, 0x00, 0x88, 0x00, 0x00, 0x22,
  0x00, 0x00, 0x08, 0x80, 0x00, 0x06, 0x20, 0x00, 0x01, 0x88, 0x00, 0x00,
  0x62, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x04, 0x30, 0x00, 0x03, 0x04, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x30, 0x30, 0x00, 0x38, 0x06, 0x00, 0x1C, 0x00,
  0xC0, 0x3C, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x0C, 0x04, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x80, 0xC0, 0x00,
  0x02, 0x02, 0x00, 0x00, 0x08, 0x08, 0x00, 0x00, 0x20, 0x20, 0x00, 0x01,
  0x80, 0x80, 0x00, 0x06, 0x06, 0x00, 0x00, 0x10, 0x18, 0x00, 0x00, 0x40,
  0x40, 0x00, 0x01, 0x01, 0x00, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x30, 0x10,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x02, 0x03, 0x00, 0x00, 0x08, 0x08, 0x00,
  0x00, 0x20, 0x20, 0x00, 0x01, 0x80, 0x80, 0x00, 0x06, 0x07, 0xFF, 0xFF,
  0xF0, 0x18, 0x00, 0x00, 0x40, 0x60, 0x00, 0x01, 0x01, 0x00, 0x00, 0x04,
  0x04, 0x00, 0x00, 0x30, 0x10, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x02, 0x03,
  0x00, 0x00, 0x08, 0x08, 0x00, 0x00, 0x20, 0x20, 0x00, 0x00, 0x80, 0x80,
  0x00, 0x06, 0x02, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x40, 0x60, 0x00,
  0x01, 0x01, 0x00, 0x00, 0x04, 0x04, 0x00, 0x00, 0x10, 0x10, 0x00, 0x00,
  0xC0, 0x40, 0x00, 0x03, 0x03, 0x00, 0x00, 0x08, 0x0C, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x03, 0x03, 0x02, 0x02, 0x02, 0x02, 0x06, 0x06, 0x04, 0x04,
  0x04, 0x0C, 0x0C, 0x0C, 0x08, 0x08, 0x08, 0x18, 0x18, 0x18, 0x10, 0x10,
  0x10, 0x30, 0x30, 0x30, 0x20, 0x20, 0x20, 0x60, 0x60, 0x40, 0x40, 0x40,
  0x40, 0xC0, 0xC0, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x20, 0xC0, 0x00, 0x60, 0xC0, 0x00,
  0x60, 0xC0, 0x00, 0x40, 0xC0, 0x00, 0xC0, 0x40, 0x00, 0x80, 0x40, 0x01,
  0x80, 0x60, 0x03, 0x00, 0x30, 0x06, 0x00, 0x18, 0x1C, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x30, 0x08, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x30, 0x06, 0x00, 0x03, 0x00, 0x20, 0x00, 0x30, 0x01, 0x00,
  0x03, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x03, 0x00, 0x06, 0x00, 0x30,
  0x00, 0x30, 0x03, 0x00, 0x01, 0x00, 0x30, 0x00, 0x08, 0x03, 0x00, 0x00,
  0x40, 0x30, 0x00, 0x02, 0x03, 0x00, 0x00, 0x30, 0x30, 0x00, 0x01, 0x83,
  0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0x43, 0x00, 0x00, 0x02, 0x3C, 0x00,
  0x00, 0x33, 0x20, 0x00, 0x01, 0xB1, 0x80, 0x00, 0x0F, 0x04, 0x00, 0x00,
  0x70, 0x30, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x10, 0x06, 0x00, 0x01, 0x80,
  0x18, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x40, 0x03, 0x00, 0x02, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x60, 0x00, 0x20, 0x02, 0x00, 0x01, 0x80, 0x10, 0x00, 0x06, 0x00, 0x80,
  0x00, 0x30, 0x04, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x06, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x30, 0x00, 0x0F, 0xFF, 0xFC, 0x01, 0x80, 0x00, 0x00, 0x18, 0x0C,
  0x00, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x2C, 0x00, 0x00, 0x05, 0x01, 0x60, 0x00, 0x00, 0x48, 0x09, 0x00,
  0x00, 0x06, 0xC0, 0x48, 0x00, 0x00, 0x26, 0x06, 0x40, 0x00, 0x03, 0x30,
  0x33, 0x00, 0x00, 0x11, 0x01, 0x18, 0x00, 0x01, 0x88, 0x08, 0xC0, 0x00,
  0x08, 0x40, 0x42, 0x00, 0x00, 0xC6, 0x02, 0x10, 0x00, 0x04, 0x30, 0x30,
  0x80, 0x00, 0x61, 0x01, 0x86, 0x00, 0x02, 0x08, 0x08, 0x30, 0x00, 0x30,
  0x40, 0x40, 0x80, 0x01, 0x02, 0x02, 0x04, 0x00, 0x18, 0x30, 0x30, 0x20,
  0x00, 0x81, 0x81, 0x81, 0x80, 0x0C, 0x08, 0x0C, 0x0C, 0x00, 0xC0, 0x40,
  0x40, 0x20, 0x04, 0x02, 0x02, 0x01, 0x00, 0x60, 0x30, 0x10, 0x08, 0x02,
  0x01, 0x81, 0x80, 0x40, 0x30, 0x0C, 0x0C, 0x03, 0x01, 0x00, 0x40, 0x60,
  0x08, 0x18, 0x02, 0x02, 0x00, 0x40, 0x80, 0x10, 0x10, 0x02, 0x0C, 0x01,
  0x80, 0x80, 0x10, 0x40, 0x0C, 0x0C, 0x00, 0x86, 0x00, 0x60, 0x60, 0x06,
  0x20, 0x02, 0x02, 0x00, 0x13, 0x00, 0x10, 0x10, 0x00, 0x90, 0x00, 0x80,
  0x80, 0x05, 0x80, 0x0C, 0x04, 0x00, 0x38, 0x00, 0x60, 0x60, 0x01, 0xC0,
  0x03, 0x03, 0x00, 0x04, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x04, 0x06,
  0x00, 0x00, 0x30, 0x38, 0x00, 0x00, 0xC0, 0xF0, 0x00, 0x03, 0x03, 0x40,
  0x00, 0x08, 0x09, 0x00, 0x00, 0x20, 0x26, 0x00, 0x00, 0x80, 0x88, 0x00,
  0x06, 0x06, 0x30, 0x00, 0x18, 0x18, 0x40, 0x00, 0x60, 0x61, 0x00, 0x01,
  0x01, 0x06, 0x00, 0x04, 0x04, 0x08, 0x00, 0x30, 0x30, 0x30, 0x00, 0xC0,
  0xC0, 0x40, 0x03, 0x03, 0x01, 0x00, 0x0C, 0x0C, 0x06, 0x00, 0x20, 0x20,
  0x08, 0x00, 0x80, 0x80, 0x20, 0x06, 0x06, 0x00, 0xC0, 0x18, 0x18, 0x01,
  0x00, 0x60, 0x60, 0x06, 0x01, 0x01, 0x00, 0x08, 0x04, 0x04, 0x00, 0x20,
  0x10, 0x10, 0x00, 0xC0, 0xC0, 0xC0, 0x01, 0x03, 0x03, 0x00, 0x06, 0x0C,
  0x0C, 0x00, 0x08, 0x20, 0x20, 0x00, 0x20, 0x80, 0x80, 0x00, 0xC2, 0x02,
  0x00, 0x01, 0x18, 0x18, 0x00, 0x06, 0x60, 0x60, 0x00, 0x09, 0x81, 0x80,
  0x00, 0x24, 0x04, 0x00, 0x00, 0xD0, 0x10, 0x00, 0x01, 0xC0, 0x40, 0x00,
  0x07, 0x03, 0x00, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x60, 0x01, 0x80,
  0x18, 0x00, 0x10, 0x06, 0x00, 0x03, 0x00, 0x80, 0x00, 0x20, 0x30, 0x00,
  0x06, 0x0C, 0x00, 0x00, 0x41, 0x00, 0x00, 0x08, 0x60, 0x00, 0x01, 0x0C,
  0x00, 0x00, 0x21, 0x00, 0x00, 0x04, 0x60, 0x00, 0x00, 0x8C, 0x00, 0x00,
  0x11, 0x00, 0x00, 0x02, 0x20, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x18, 0x80,
  0x00, 0x03, 0x30, 0x00, 0x00, 0x46, 0x00, 0x00, 0x08, 0x80, 0x00, 0x01,
  0x10, 0x00, 0x00, 0x62, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x01, 0x98, 0x00,
  0x00, 0x23, 0x00, 0x00, 0x04, 0x60, 0x00, 0x01, 0x88, 0x00, 0x00, 0x31,
  0x00, 0x00, 0x04, 0x30, 0x00, 0x01, 0x86, 0x00, 0x00, 0x20, 0xC0, 0x00,
  0x0C, 0x08, 0x00, 0x01, 0x01, 0x00, 0x00, 0x60, 0x30, 0x00, 0x18, 0x03,
  0x00, 0x06, 0x00, 0x30, 0x01, 0x80, 0x03, 0x80, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x40, 0x0F, 0x00,
  0x30, 0x00, 0x60, 0x0C, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0x80, 0x00,
  0x20, 0x20, 0x00, 0x08, 0x08, 0x00, 0x03, 0x06, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x30, 0x40, 0x00, 0x0C, 0x10, 0x00, 0x03, 0x04, 0x00, 0x00, 0x81,
  0x00, 0x00, 0x20, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x04, 0x08, 0x00, 0x03,
  0x02, 0x00, 0x00, 0x80, 0x80, 0x00, 0x60, 0x60, 0x00, 0x30, 0x18, 0x00,
  0x38, 0x06, 0x00, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x40, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x60,
  0x01, 0x80, 0x18, 0x00, 0x10, 0x06, 0x00, 0x03, 0x00, 0x80, 0x00, 0x20,
  0x30, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x41, 0x00, 0x00, 0x08, 0x60, 0x00,
  0x01, 0x0C, 0x00, 0x00, 0x21, 0x00, 0x00, 0x04, 0x60, 0x00, 0x00, 0x8C,
  0x00, 0x00, 0x11, 0x00, 0x00, 0x02, 0x20, 0x00, 0x00, 0xC4, 0x00, 0x00,
  0x19, 0x80, 0x00, 0x03, 0x30, 0x00, 0x00, 0x46, 0x00, 0x00, 0x08, 0x80,
  0x00, 0x01, 0x10, 0x00, 0x00, 0x62, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x01,
  0x98, 0x00, 0x00, 0x23, 0x00, 0x00, 0x04, 0x60, 0x00, 0x01, 0x88, 0x00,
  0x00, 0x31, 0x00, 0x00, 0x04, 0x30, 0x00, 0x01, 0x86, 0x00, 0x00, 0x20,
  0xC0, 0x00, 0x0C, 0x08, 0x00, 0x01, 0x01, 0x00, 0x00, 0x60, 0x30, 0x00,
  0x18, 0x03, 0x00, 0x06, 0x00, 0x30, 0x01, 0x80, 0x03, 0x00, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x04, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0xC0, 0x0F, 0x00, 0x30, 0x00,
  0x60, 0x0C, 0x00, 0x0C, 0x02, 0x00, 0x01, 0x80, 0x80, 0x00, 0x20, 0x20,
  0x00, 0x0C, 0x18, 0x00, 0x03, 0x06, 0x00, 0x00, 0x41, 0x00, 0x00, 0x10,
  0x40, 0x00, 0x0C, 0x10, 0x00, 0x03, 0x04, 0x00, 0x00, 0x83, 0x00, 0x00,
  0x20, 0xC0, 0x00, 0x18, 0x20, 0x00, 0x04, 0x08, 0x00, 0x03, 0x02, 0x00,
  0x01, 0x80, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x60, 0x18, 0x01, 0xE0, 0x07,
  0xFF, 0xE0, 0x01, 0x00, 0x18, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0xC0,
  0x0C, 0x00, 0x30, 0x03, 0x00, 0x04, 0x00, 0x80, 0x01, 0x80, 0x20, 0x00,
  0x60, 0x08, 0x00, 0x08, 0x06, 0x00, 0x03, 0x01, 0x80, 0x00, 0xC0, 0x60,
  0x00, 0x10, 0x10, 0x00, 0x06, 0x04, 0x00, 0x01, 0x81, 0x00, 0x00, 0x20,
  0xC0, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x08, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xE0, 0x1C, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x18, 0x03, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x30, 0x10, 0x00,
  0x02, 0x06, 0x00, 0x00, 0x40, 0x80, 0x00, 0x08, 0x10, 0x00, 0x01, 0x02,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30,
  0x80, 0x00, 0x06, 0x10, 0x00, 0x00, 0x82, 0x00, 0x00, 0x10, 0x40, 0x00,
  0x06, 0x08, 0x00, 0x00, 0x81, 0x80, 0x00, 0x30, 0x30, 0x00, 0x0C, 0x03,
  0x00, 0x03, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x80, 0x70, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x04, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x20, 0x60,
  0x00, 0x02, 0x04, 0x00, 0x00, 0x20, 0x40, 0x00, 0x02, 0x04, 0x00, 0x00,
  0x60, 0x40, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x04, 0x08,
  0x00, 0x00, 0x40, 0x80, 0x00, 0x04, 0x08, 0x00, 0x00, 0xC0, 0x80, 0x00,
  0x0C, 0x18, 0x00, 0x00, 0x81, 0x80, 0x00, 0x08, 0x10, 0x00, 0x00, 0x81,
  0x00, 0x00, 0x08, 0x10, 0x00, 0x01, 0x83, 0x00, 0x00, 0x18, 0x30, 0x00,
  0x01, 0x03, 0x00, 0x00, 0x10, 0x20, 0x00, 0x01, 0x02, 0x00, 0x00, 0x30,
  0x20, 0x00, 0x03, 0x06, 0x00, 0x00, 0x20, 0x60, 0x00, 0x02, 0x06, 0x00,
  0x00, 0x20, 0x40, 0x00, 0x02, 0x04, 0x00, 0x00, 0x60, 0x40, 0x00, 0x06,
  0x04, 0x00, 0x00, 0x40, 0x40, 0x00, 0x04, 0x04, 0x00, 0x00, 0xC0, 0x40,
  0x00, 0x08, 0x06, 0x00, 0x01, 0x80, 0x60, 0x00, 0x30, 0x03, 0x00, 0x06,
  0x00, 0x38, 0x00, 0xC0, 0x01, 0xC0, 0x38, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x13, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x02, 0x10, 0x00, 0x01, 0x84, 0x00,
  0x00, 0x61, 0x00, 0x00, 0x30, 0x60, 0x00, 0x0C, 0x18, 0x00, 0x02, 0x06,
  0x00, 0x01, 0x80, 0x80, 0x00, 0x40, 0x20, 0x00, 0x30, 0x08, 0x00, 0x08,
  0x03, 0x00, 0x06, 0x00, 0xC0, 0x01, 0x00, 0x30, 0x00, 0xC0, 0x0C, 0x00,
  0x20, 0x01, 0x00, 0x18, 0x00, 0x40, 0x04, 0x00, 0x10, 0x01, 0x00, 0x06,
  0x00, 0xC0, 0x01, 0x80, 0x20, 0x00, 0x60, 0x18, 0x00, 0x08, 0x04, 0x00,
  0x02, 0x03, 0x00, 0x00, 0x80, 0x80, 0x00, 0x20, 0x60, 0x00, 0x0C, 0x10,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x11, 0x80, 0x00, 0x04,
  0x40, 0x00, 0x01, 0x10, 0x00, 0x00, 0x48, 0x00, 0x00, 0x1A, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x10, 0x00, 0x07, 0x80, 0x00, 0x60, 0x00, 0x09, 0x00, 0x00, 0xE0, 0x00,
  0x32, 0x00, 0x03, 0xC0, 0x00, 0x44, 0x00, 0x04, 0x80, 0x01, 0x88, 0x00,
  0x09, 0x00, 0x03, 0x10, 0x00, 0x32, 0x00, 0x04, 0x20, 0x00, 0x44, 0x00,
  0x18, 0x40, 0x01, 0x88, 0x00, 0x30, 0xC0, 0x02, 0x10, 0x00, 0x41, 0x80,
  0x04, 0x20, 0x01, 0x83, 0x00, 0x18, 0x40, 0x02, 0x06, 0x00, 0x20, 0xC0,
  0x0C, 0x0C, 0x00, 0xC1, 0x80, 0x18, 0x18, 0x01, 0x03, 0x00, 0x20, 0x30,
  0x06, 0x06, 0x00, 0xC0, 0x60, 0x0C, 0x04, 0x01, 0x80, 0x40, 0x10, 0x08,
  0x02, 0x00, 0x80, 0x60, 0x10, 0x0C, 0x01, 0x00, 0x80, 0x20, 0x10, 0x02,
  0x03, 0x00, 0x40, 0x60, 0x04, 0x06, 0x00, 0x80, 0xC0, 0x08, 0x08, 0x01,
  0x01, 0x00, 0x10, 0x30, 0x03, 0x06, 0x00, 0x30, 0x40, 0x06, 0x08, 0x00,
  0x61, 0x80, 0x0C, 0x10, 0x00, 0xC3, 0x00, 0x18, 0x60, 0x01, 0x84, 0x00,
  0x30, 0x80, 0x03, 0x18, 0x00, 0x23, 0x00, 0x06, 0x20, 0x00, 0x46, 0x00,
  0x0C, 0xC0, 0x00, 0x88, 0x00, 0x19, 0x80, 0x01, 0x30, 0x00, 0x12, 0x00,
  0x02, 0x40, 0x00, 0x2C, 0x00, 0x04, 0x80, 0x00, 0x50, 0x00, 0x0B, 0x00,
  0x00, 0xA0, 0x00, 0x14, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x00,
  0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x03, 0x00, 0x00, 0x18, 0x02, 0x00, 0x00, 0x60, 0x06, 0x00, 0x01,
  0x80, 0x04, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x10, 0x00, 0xC0, 0x00, 0x30, 0x01, 0x00, 0x00, 0x20, 0x06, 0x00,
  0x00, 0x60, 0x18, 0x00, 0x00, 0x40, 0x60, 0x00, 0x00, 0xC0, 0x80, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x03, 0x10, 0x00, 0x00,
  0x02, 0x60, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x28, 0x00, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x03,
  0x30, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x00, 0x10, 0x60, 0x00, 0x00, 0x60,
  0x40, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x02, 0x01, 0x80, 0x00, 0x0C, 0x01,
  0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0xC0, 0x02, 0x00, 0x01, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x04, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x80, 0x00, 0x10, 0x03, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x20,
  0x10, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x00, 0x90, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x08, 0x20, 0x00, 0x06, 0x0C, 0x00, 0x03,
  0x03, 0x00, 0x00, 0x80, 0x40, 0x00, 0x60, 0x18, 0x00, 0x30, 0x06, 0x00,
  0x08, 0x00, 0x80, 0x06, 0x00, 0x20, 0x03, 0x00, 0x0C, 0x00, 0x80, 0x01,
  0x00, 0x60, 0x00, 0x40, 0x30, 0x00, 0x18, 0x08, 0x00, 0x02, 0x06, 0x00,
  0x00, 0x83, 0x00, 0x00, 0x30, 0x80, 0x00, 0x04, 0x60, 0x00, 0x01, 0x30,
  0x00, 0x00, 0x68, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFC,
  0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x08, 0x00, 0x20, 0x00, 0xFC, 0x00, 0x81, 0x02, 0x06, 0x0C, 0x18,
  0x10, 0x20, 0x40, 0xC1, 0x83, 0x02, 0x04, 0x08, 0x10, 0x30, 0x60, 0xC0,
  0x81, 0x02, 0x04, 0x0C, 0x18, 0x30, 0x20, 0x40, 0x81, 0x03, 0x06, 0x0C,
  0x08, 0x10, 0x20, 0x40, 0xC1, 0x83, 0x02, 0x04, 0x00, 0xFC, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0xFC, 0x00, 0x00, 0x20, 0x00, 0xE0, 0x01, 0xC0, 0x06,
  0x80, 0x09, 0x00, 0x32, 0x00, 0x44, 0x01, 0x0C, 0x02, 0x18, 0x08, 0x10,
  0x10, 0x20, 0x40, 0x41, 0x80, 0x82, 0x01, 0x8C, 0x03, 0x10, 0x02, 0x60,
  0x04, 0x80, 0x0B, 0x00, 0x18, 0x7F, 0xFF, 0xE0, 0xC2, 0x18, 0x43, 0x0C,
  0x20, 0x00, 0x04, 0x00, 0x03, 0xFE, 0x00, 0x70, 0x38, 0x06, 0x00, 0x60,
  0x60, 0x01, 0x06, 0x00, 0x08, 0x20, 0x00, 0x63, 0x00, 0x03, 0x18, 0x00,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x03, 0xFF, 0x80, 0xFC, 0x04, 0x0E, 0x00, 0x20, 0xC0, 0x01,
  0x0C, 0x00, 0x18, 0xC0, 0x00, 0xC4, 0x00, 0x04, 0x60, 0x00, 0x22, 0x00,
  0x01, 0x10, 0x00, 0x18, 0x80, 0x01, 0xC4, 0x00, 0x1E, 0x30, 0x01, 0xB0,
  0x80, 0x19, 0x87, 0x03, 0x8C, 0x1F, 0xF0, 0x40, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x06, 0x1F, 0xE0, 0x19,
  0x80, 0xC0, 0x4C, 0x01, 0x81, 0x40, 0x02, 0x06, 0x00, 0x0C, 0x30, 0x00,
  0x30, 0xC0, 0x00, 0xC3, 0x00, 0x01, 0x08, 0x00, 0x04, 0x20, 0x00, 0x10,
  0x80, 0x00, 0xC6, 0x00, 0x03, 0x18, 0x00, 0x0C, 0x60, 0x00, 0x31, 0x00,
  0x00, 0x84, 0x00, 0x02, 0x10, 0x00, 0x08, 0xC0, 0x00, 0x63, 0x00, 0x01,
  0x88, 0x00, 0x04, 0x20, 0x00, 0x10, 0x80, 0x00, 0xC2, 0x00, 0x02, 0x18,
  0x00, 0x18, 0x60, 0x00, 0x41, 0x40, 0x03, 0x04, 0x80, 0x18, 0x11, 0x81,
  0xC0, 0x43, 0xFC, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x03, 0x81, 0xC0, 0x60, 0x06, 0x0C, 0x00, 0x60, 0x80, 0x03, 0x18, 0x00,
  0x33, 0x00, 0x03, 0x30, 0x00, 0x12, 0x00, 0x01, 0x60, 0x00, 0x16, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x04, 0x80, 0x00, 0xC8, 0x00, 0x08, 0xC0, 0x01, 0x8C, 0x00, 0x10,
  0x60, 0x03, 0x06, 0x00, 0x60, 0x38, 0x1C, 0x01, 0xFF, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x08,
  0x04, 0x00, 0xFF, 0x0C, 0x03, 0x81, 0x8C, 0x06, 0x00, 0x48, 0x04, 0x00,
  0x28, 0x0C, 0x00, 0x38, 0x18, 0x00, 0x18, 0x10, 0x00, 0x18, 0x10, 0x00,
  0x18, 0x30, 0x00, 0x10, 0x20, 0x00, 0x10, 0x20, 0x00, 0x10, 0x60, 0x00,
  0x30, 0x60, 0x00, 0x30, 0x40, 0x00, 0x30, 0x40, 0x00, 0x20, 0x40, 0x00,
  0x20, 0x40, 0x00, 0x20, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x60, 0xC0, 0x00,
  0x60, 0xC0, 0x00, 0x40, 0xC0, 0x00, 0x40, 0xC0, 0x00, 0x40, 0x40, 0x00,
  0xC0, 0x40, 0x01, 0xC0, 0x60, 0x03, 0x80, 0x20, 0x06, 0x80, 0x38, 0x1C,
  0x80, 0x1F, 0xF0, 0x80, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x70, 0x38, 0x06, 0x00, 0x60, 0x60, 0x01, 0x02, 0x00, 0x0C, 0x30,
  0x00, 0x63, 0x00, 0x01, 0x18, 0x00, 0x08, 0x80, 0x00, 0x4C, 0x00, 0x02,
  0x40, 0x00, 0x32, 0x00, 0x01, 0xBF, 0xFF, 0xFD, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x00, 0x00, 0x0C, 0x00, 0x20, 0x30, 0x03, 0x00, 0xC0, 0x70, 0x03,
  0xFE, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x18, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x03, 0xFF, 0xC0, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x3F, 0xC3, 0x00, 0xE0, 0x63, 0x01, 0x80, 0x12, 0x01,
  0x00, 0x0A, 0x03, 0x00, 0x0E, 0x06, 0x00, 0x06, 0x04, 0x00, 0x06, 0x0C,
  0x00, 0x06, 0x0C, 0x00, 0x04, 0x08, 0x00, 0x04, 0x08, 0x00, 0x04, 0x18,
  0x00, 0x0C, 0x18, 0x00, 0x0C, 0x10, 0x00, 0x0C, 0x10, 0x00, 0x08, 0x10,
  0x00, 0x08, 0x10, 0x00, 0x08, 0x30, 0x00, 0x18, 0x30, 0x00, 0x18, 0x30,
  0x00, 0x10, 0x30, 0x00, 0x10, 0x30, 0x00, 0x10, 0x30, 0x00, 0x10, 0x30,
  0x00, 0x30, 0x10, 0x00, 0x70, 0x18, 0x00, 0xE0, 0x08, 0x01, 0xA0, 0x0E,
  0x07, 0x20, 0x07, 0xFC, 0x60, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x40,
  0x01, 0x80, 0x60, 0x03, 0x00, 0x30, 0x06, 0x00, 0x1C, 0x3C, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x61, 0xFE,
  0x03, 0x18, 0x18, 0x11, 0x80, 0x60, 0x90, 0x03, 0x05, 0x00, 0x08, 0x38,
  0x00, 0x43, 0x80, 0x02, 0x1C, 0x00, 0x10, 0xC0, 0x00, 0x86, 0x00, 0x04,
  0x20, 0x00, 0x23, 0x00, 0x03, 0x18, 0x00, 0x18, 0xC0, 0x00, 0xC4, 0x00,
  0x04, 0x20, 0x00, 0x21, 0x00, 0x01, 0x18, 0x00, 0x18, 0xC0, 0x00, 0xC6,
  0x00, 0x06, 0x20, 0x00, 0x21, 0x00, 0x01, 0x08, 0x00, 0x08, 0xC0, 0x00,
  0xC6, 0x00, 0x06, 0x20, 0x00, 0x21, 0x00, 0x01, 0x08, 0x00, 0x08, 0x40,
  0x00, 0x40, 0x03, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x08, 0x04, 0x06, 0x03,
  0x01, 0x80, 0x80, 0x40, 0x20, 0x30, 0x18, 0x0C, 0x04, 0x02, 0x01, 0x01,
  0x80, 0xC0, 0x40, 0x20, 0x10, 0x08, 0x0C, 0x06, 0x02, 0x01, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x70, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x27, 0x00, 0x0F, 0x80, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x00, 0x06, 0x00, 0x0C, 0x18, 0x00, 0x60, 0x40, 0x03, 0x01,
  0x00, 0x18, 0x04, 0x00, 0xC0, 0x10, 0x0C, 0x00, 0xC0, 0x60, 0x03, 0x03,
  0x00, 0x08, 0x18, 0x00, 0x20, 0xC0, 0x00, 0x86, 0x00, 0x06, 0x30, 0x00,
  0x19, 0x80, 0x00, 0x6F, 0x00, 0x01, 0x64, 0x00, 0x07, 0x18, 0x00, 0x10,
  0x20, 0x00, 0xC0, 0xC0, 0x03, 0x01, 0x00, 0x0C, 0x06, 0x00, 0x20, 0x08,
  0x00, 0x80, 0x30, 0x02, 0x00, 0x60, 0x18, 0x01, 0x80, 0x60, 0x03, 0x01,
  0x00, 0x0C, 0x04, 0x00, 0x18, 0x10, 0x00, 0x60, 0x40, 0x00, 0xC0, 0x01,
  0x01, 0x03, 0x03, 0x03, 0x02, 0x02, 0x02, 0x06, 0x06, 0x04, 0x04, 0x04,
  0x04, 0x0C, 0x0C, 0x08, 0x08, 0x08, 0x18, 0x18, 0x18, 0x10, 0x10, 0x10,
  0x30, 0x30, 0x30, 0x20, 0x20, 0x20, 0x60, 0x60, 0x60, 0x40, 0x40, 0x40,
  0xC0, 0xC0, 0x80, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0xFF, 0x00,
  0xFF, 0x01, 0x1C, 0x0C, 0x1C, 0x0C, 0x09, 0x80, 0x21, 0x80, 0x30, 0x48,
  0x01, 0x98, 0x01, 0x86, 0x80, 0x05, 0x80, 0x04, 0x38, 0x00, 0x28, 0x00,
  0x21, 0xC0, 0x01, 0xC0, 0x01, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x60, 0x00,
  0x40, 0x00, 0x42, 0x00, 0x02, 0x00, 0x02, 0x30, 0x00, 0x30, 0x00, 0x11,
  0x80, 0x01, 0x80, 0x01, 0x8C, 0x00, 0x0C, 0x00, 0x0C, 0x40, 0x00, 0x40,
  0x00, 0x62, 0x00, 0x02, 0x00, 0x02, 0x30, 0x00, 0x10, 0x00, 0x11, 0x80,
  0x01, 0x80, 0x00, 0x8C, 0x00, 0x0C, 0x00, 0x0C, 0x60, 0x00, 0x60, 0x00,
  0x62, 0x00, 0x02, 0x00, 0x03, 0x10, 0x00, 0x10, 0x00, 0x11, 0x80, 0x00,
  0x80, 0x00, 0x8C, 0x00, 0x0C, 0x00, 0x04, 0x60, 0x00, 0x60, 0x00, 0x62,
  0x00, 0x03, 0x00, 0x03, 0x10, 0x00, 0x10, 0x00, 0x10, 0x80, 0x00, 0x80,
  0x00, 0x8C, 0x00, 0x04, 0x00, 0x04, 0x60, 0x00, 0x60, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x30, 0xFF, 0x01, 0x8C, 0x0C, 0x08, 0xC0, 0x30, 0x48, 0x01,
  0x82, 0xC0, 0x04, 0x34, 0x00, 0x21, 0xC0, 0x01, 0x0C, 0x00, 0x08, 0x60,
  0x00, 0x43, 0x00, 0x02, 0x10, 0x00, 0x11, 0x80, 0x01, 0x8C, 0x00, 0x0C,
  0x60, 0x00, 0x62, 0x00, 0x02, 0x10, 0x00, 0x10, 0x80, 0x00, 0x8C, 0x00,
  0x0C, 0x60, 0x00, 0x63, 0x00, 0x03, 0x10, 0x00, 0x10, 0x80, 0x00, 0x84,
  0x00, 0x04, 0x60, 0x00, 0x63, 0x00, 0x03, 0x18, 0x00, 0x18, 0x80, 0x00,
  0x84, 0x00, 0x04, 0x20, 0x00, 0x20, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x60, 0x38, 0x06, 0x00, 0xC0, 0x60, 0x03, 0x06, 0x00, 0x08, 0x60, 0x00,
  0x63, 0x00, 0x03, 0x30, 0x00, 0x09, 0x80, 0x00, 0x48, 0x00, 0x02, 0xC0,
  0x00, 0x16, 0x00, 0x00, 0xA0, 0x00, 0x0D, 0x00, 0x00, 0x68, 0x00, 0x03,
  0x40, 0x00, 0x16, 0x00, 0x00, 0xB0, 0x00, 0x05, 0x80, 0x00, 0x6C, 0x00,
  0x02, 0x60, 0x00, 0x13, 0x00, 0x01, 0x98, 0x00, 0x08, 0x40, 0x00, 0xC2,
  0x00, 0x0C, 0x18, 0x00, 0xC0, 0x60, 0x0E, 0x01, 0x80, 0xE0, 0x07, 0xFC,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x87, 0xF8, 0x01, 0x9C,
  0x0C, 0x01, 0x30, 0x06, 0x01, 0x40, 0x02, 0x01, 0x80, 0x03, 0x03, 0x80,
  0x03, 0x03, 0x00, 0x01, 0x03, 0x00, 0x01, 0x02, 0x00, 0x01, 0x02, 0x00,
  0x01, 0x02, 0x00, 0x01, 0x06, 0x00, 0x03, 0x06, 0x00, 0x03, 0x06, 0x00,
  0x03, 0x04, 0x00, 0x02, 0x04, 0x00, 0x02, 0x04, 0x00, 0x02, 0x0C, 0x00,
  0x06, 0x0C, 0x00, 0x06, 0x08, 0x00, 0x04, 0x08, 0x00, 0x04, 0x08, 0x00,
  0x0C, 0x08, 0x00, 0x08, 0x18, 0x00, 0x18, 0x1C, 0x00, 0x10, 0x14, 0x00,
  0x30, 0x16, 0x00, 0x60, 0x13, 0x81, 0xC0, 0x30, 0xFF, 0x00, 0x30, 0x18,
  0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x08, 0x00, 0x03, 0xFC,
  0x30, 0x38, 0x18, 0xC1, 0x80, 0x12, 0x04, 0x00, 0x28, 0x30, 0x00, 0xE1,
  0x80, 0x01, 0x84, 0x00, 0x06, 0x30, 0x00, 0x10, 0xC0, 0x00, 0x42, 0x00,
  0x01, 0x08, 0x00, 0x04, 0x60, 0x00, 0x31, 0x80, 0x00, 0xC4, 0x00, 0x02,
  0x10, 0x00, 0x08, 0x40, 0x00, 0x21, 0x00, 0x00, 0x8C, 0x00, 0x06, 0x30,
  0x00, 0x18, 0xC0, 0x00, 0x63, 0x00, 0x01, 0x0C, 0x00, 0x04, 0x30, 0x00,
  0x10, 0x40, 0x00, 0xC1, 0x00, 0x07, 0x06, 0x00, 0x38, 0x08, 0x01, 0xA0,
  0x38, 0x1C, 0x80, 0x7F, 0xC6, 0x00, 0x30, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x06, 0x3F, 0x06, 0x60, 0x04, 0xC0, 0x05, 0x80, 0x05, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x00, 0x08, 0x00, 0x0F, 0xF8, 0x03, 0x80, 0xC0, 0x60, 0x06, 0x0C, 0x00,
  0x30, 0x80, 0x03, 0x08, 0x00, 0x31, 0x80, 0x03, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xCC, 0x00, 0x0C,
  0xC0, 0x00, 0x8C, 0x00, 0x18, 0x40, 0x01, 0x06, 0x00, 0x60, 0x38, 0x1C,
  0x00, 0xFF, 0x80, 0x01, 0x80, 0x00, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0xFF, 0xF0, 0x40, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0x80, 0x08, 0x00, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x06, 0x00,
  0x3E, 0x00, 0xC0, 0x18, 0x00, 0x18, 0xC0, 0x00, 0xC4, 0x00, 0x04, 0x20,
  0x00, 0x21, 0x00, 0x01, 0x18, 0x00, 0x18, 0xC0, 0x00, 0xC4, 0x00, 0x06,
  0x20, 0x00, 0x21, 0x00, 0x01, 0x08, 0x00, 0x08, 0xC0, 0x00, 0xC6, 0x00,
  0x06, 0x20, 0x00, 0x31, 0x00, 0x01, 0x08, 0x00, 0x08, 0x40, 0x00, 0x46,
  0x00, 0x06, 0x30, 0x00, 0x31, 0x00, 0x01, 0x08, 0x00, 0x08, 0x40, 0x00,
  0xC2, 0x00, 0x06, 0x10, 0x00, 0x70, 0xC0, 0x03, 0x86, 0x00, 0x28, 0x18,
  0x02, 0x40, 0xE0, 0x62, 0x01, 0xFE, 0x30, 0x03, 0x00, 0x00, 0x40, 0x00,
  0x14, 0x00, 0x03, 0x40, 0x00, 0x24, 0x00, 0x06, 0x60, 0x00, 0x46, 0x00,
  0x0C, 0x20, 0x00, 0x82, 0x00, 0x18, 0x20, 0x01, 0x02, 0x00, 0x30, 0x30,
  0x02, 0x03, 0x00, 0x60, 0x30, 0x04, 0x01, 0x00, 0xC0, 0x10, 0x08, 0x01,
  0x01, 0x80, 0x18, 0x10, 0x01, 0x81, 0x00, 0x18, 0x30, 0x00, 0x82, 0x00,
  0x08, 0x60, 0x00, 0x84, 0x00, 0x0C, 0xC0, 0x00, 0xC8, 0x00, 0x0D, 0x80,
  0x00, 0x50, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x01, 0x00, 0x06, 0x80, 0x07, 0x00, 0x09, 0x00, 0x0E, 0x00, 0x32, 0x00,
  0x1C, 0x00, 0x64, 0x00, 0x78, 0x00, 0x88, 0x00, 0xB0, 0x03, 0x10, 0x03,
  0x20, 0x04, 0x30, 0x04, 0x40, 0x18, 0x60, 0x18, 0x80, 0x30, 0xC0, 0x21,
  0x00, 0xC1, 0x80, 0xC2, 0x01, 0x83, 0x01, 0x84, 0x02, 0x06, 0x02, 0x0C,
  0x0C, 0x0C, 0x0C, 0x18, 0x10, 0x18, 0x10, 0x30, 0x60, 0x10, 0x60, 0x60,
  0xC0, 0x20, 0x80, 0xC1, 0x00, 0x43, 0x00, 0x86, 0x00, 0x84, 0x01, 0x08,
  0x01, 0x18, 0x02, 0x30, 0x02, 0x30, 0x04, 0x60, 0x04, 0x40, 0x08, 0x80,
  0x09, 0x80, 0x13, 0x00, 0x1A, 0x00, 0x24, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0x70, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03,
  0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x06, 0x02, 0x00, 0x04, 0x03, 0x00,
  0x0C, 0x01, 0x00, 0x18, 0x01, 0x80, 0x30, 0x00, 0x80, 0x20, 0x00, 0xC0,
  0x60, 0x00, 0xC0, 0xC0, 0x00, 0x40, 0x80, 0x00, 0x61, 0x00, 0x00, 0x23,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x14, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x44, 0x00, 0x00, 0xC6,
  0x00, 0x01, 0x82, 0x00, 0x03, 0x03, 0x00, 0x02, 0x01, 0x00, 0x06, 0x01,
  0x80, 0x0C, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x10, 0x00, 0xC0, 0x30, 0x00,
  0x40, 0x60, 0x00, 0x60, 0x40, 0x00, 0x20, 0x02, 0x00, 0x00, 0x80, 0x80,
  0x00, 0x60, 0x30, 0x00, 0x10, 0x0C, 0x00, 0x0C, 0x03, 0x00, 0x02, 0x00,
  0xC0, 0x01, 0x80, 0x10, 0x00, 0x40, 0x04, 0x00, 0x30, 0x01, 0x00, 0x08,
  0x00, 0x60, 0x06, 0x00, 0x18, 0x01, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x80,
  0x20, 0x00, 0x20, 0x18, 0x00, 0x08, 0x04, 0x00, 0x03, 0x03, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x04, 0x18, 0x00, 0x01, 0x0C, 0x00,
  0x00, 0x43, 0x00, 0x00, 0x11, 0x80, 0x00, 0x06, 0x60, 0x00, 0x01, 0xB0,
  0x00, 0x00, 0x2C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x80,
  0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x08, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x3C, 0x00, 0x1C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x02,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0xC0, 0x40, 0x20, 0x10, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x00, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x08, 0x04, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x20,
  0x10, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x00, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x08, 0x04, 0x02, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x20, 0x10, 0x18, 0x0C,
  0x06, 0x00, 0x00, 0x40, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00,
  0x0C, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x3C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x04, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x1C, 0x00, 0x04, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xB8, 0x00,
  0x31, 0x83, 0x00, 0x08, 0xC0, 0x60, 0x02, 0x60, 0x0C, 0x01, 0x98, 0x01,
  0x80, 0x44, 0x00, 0x30, 0x23, 0x00, 0x07, 0x30, 0x00, 0x00, 0xF8, 0x00,
};

const GFXglyph RobotoCondensed_ThinItalic55pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 9, 40, 10, 1, -39 },
  { 46, 9, 11, 14, 6, -41 },
  { 59, 27, 39, 26, 1, -39 },
  { 191, 23, 51, 26, 2, -45 },
  { 338, 26, 41, 35, 5, -40 },
  { 472, 25, 41, 29, 1, -40 },
  { 601, 3, 11, 9, 6, -41 },
  { 606, 15, 57, 15, 3, -44 },
  { 713, 15, 57, 15, -3, -44 },
  { 820, 21, 21, 22, 3, -39 },
  { 876, 23, 29, 26, 2, -32 },
  { 960, 6, 11, 10, -2, -4 },
  { 969, 11, 1, 14, 2, -18 },
  { 971, 3, 3, 12, 1, -2 },
  { 973, 22, 42, 18, -2, -39 },
  { 1089, 21, 41, 26, 3, -40 },
  { 1197, 11, 39, 26, 8, -39 },
  { 1251, 23, 40, 26, 1, -40 },
  { 1366, 23, 41, 26, 2, -40 },
  { 1484, 23, 39, 26, 1, -39 },
  { 1597, 23, 40, 26, 3, -39 },
  { 1712, 20, 40, 26, 3, -39 },
  { 1812, 21, 39, 26, 5, -39 },
  { 1915, 24, 41, 26, 1, -40 },
  { 2038, 20, 40, 26, 4, -40 },
  { 2138, 7, 29, 10, 1, -28 },
  { 2164, 10, 35, 9, -2, -28 },
  { 2208, 21, 22, 24, 2, -29 },
  { 2266, 21, 12, 26, 3, -24 },
  { 2298, 20, 22, 24, 2, -29 },
  { 2353, 16, 41, 21, 5, -40 },
  { 2435, 38, 50, 43, 2, -38 },
  { 2673, 26, 39, 28, -2, -39 },
  { 2800, 25, 39, 28, 2, -39 },
  { 2922, 26, 41, 30, 3, -40 },
  { 3056, 27, 39, 31, 2, -39 },
  { 3188, 27, 39, 27, 2, -39 },
  { 3320, 27, 39, 27, 2, -39 },
  { 3452, 26, 41, 32, 4, -40 },
  { 3586, 30, 39, 33, 2, -39 },
  { 3733, 8, 39, 13, 3, -39 },
  { 3772, 24, 40, 26, 1, -39 },
  { 3892, 29, 39, 30, 2, -39 },
  { 4034, 18, 39, 24, 2, -39 },
  { 4122, 37, 39, 40, 2, -39 },
  { 4303, 30, 39, 33, 2, -39 },
  { 4450, 27, 41, 31, 3, -40 },
  { 4589, 26, 39, 28, 2, -39 },
  { 4716, 27, 47, 31, 3, -40 },
  { 4875, 26, 39, 30, 2, -39 },
  { 5002, 27, 41, 28, 1, -40 },
  { 5141, 25, 39, 28, 5, -39 },
  { 5263, 28, 40, 31, 3, -39 },
  { 5403, 26, 39, 28, 5, -39 },
  { 5530, 39, 39, 42, 5, -39 },
  { 5721, 31, 39, 28, -1, -39 },
  { 5873, 26, 39, 28, 5, -39 },
  { 6000, 29, 39, 28, 0, -39 },
  { 6142, 14, 53, 11, 1, -45 },
  { 6235, 7, 42, 18, 6, -39 },
  { 6272, 14, 53, 11, -3, -45 },
  { 6365, 15, 19, 20, 3, -39 },
  { 6401, 19, 1, 20, -3, 0 },
  { 6404, 5, 7, 14, 8, -41 },
  { 6409, 21, 31, 25, 1, -30 },
  { 6491, 22, 42, 26, 1, -41 },
  { 6607, 20, 31, 24, 2, -30 },
  { 6685, 24, 42, 26, 2, -41 },
  { 6811, 21, 31, 24, 1, -30 },
  { 6893, 17, 42, 15, 3, -42 },
  { 6983, 24, 41, 26, 0, -30 },
  { 7106, 21, 41, 26, 1, -41 },
  { 7214, 9, 40, 10, 2, -40 },
  { 7259, 18, 51, 11, -7, -40 },
  { 7374, 22, 41, 23, 1, -41 },
  { 7487, 8, 41, 10, 2, -41 },
  { 7528, 37, 30, 42, 1, -30 },
  { 7667, 21, 30, 26, 1, -30 },
  { 7746, 21, 31, 26, 2, -30 },
  { 7828, 24, 41, 26, -1, -30 },
  { 7951, 22, 41, 26, 2, -30 },
  { 8064, 16, 30, 16, 1, -30 },
  { 8124, 20, 31, 24, 1, -30 },
  { 8202, 12, 38, 15, 3, -37 },
  { 8259, 21, 30, 26, 3, -29 },
  { 8338, 20, 29, 23, 3, -29 },
  { 8411, 31, 29, 35, 4, -29 },
  { 8524, 24, 29, 23, -1, -29 },
  { 8611, 26, 40, 23, -2, -29 },
  { 8741, 22, 29, 23, 0, -29 },
  { 8821, 17, 55, 16, 2, -43 },
  { 8938, 9, 46, 11, 1, -39 },
  { 8990, 18, 55, 16, -4, -43 },
  { 9114, 26, 9, 32, 3, -21 },
};

const GFXfont RobotoCondensed_ThinItalic55pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ThinItalic55pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ThinItalic55pt7bGlyphs,
  0x20, 0x7E, 64
};

#endif // _ROBOTOCONDENSED_THINITALIC55PT7B_H_
