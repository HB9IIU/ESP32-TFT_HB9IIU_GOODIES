#ifndef _ROBOTOCONDENSED_THINITALIC28PT7B_H_
#define _ROBOTOCONDENSED_THINITALIC28PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ThinItalic.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ThinItalic28pt7bBitmaps[] PROGMEM = {
  0x00, 0x11, 0x12, 0x22, 0x22, 0x24, 0x44, 0x44, 0x40, 0x00, 0x08, 0x4A,
  0x95, 0x29, 0x48, 0x00, 0x88, 0x04, 0x20, 0x10, 0x80, 0x42, 0x02, 0x10,
  0x7F, 0xF0, 0x21, 0x01, 0x08, 0x04, 0x20, 0x10, 0x80, 0x44, 0x02, 0x10,
  0x08, 0x40, 0x22, 0x0F, 0xFF, 0x04, 0x20, 0x11, 0x00, 0x84, 0x02, 0x10,
  0x08, 0x80, 0x01, 0x00, 0x10, 0x01, 0x00, 0x7C, 0x08, 0x21, 0x02, 0x20,
  0x12, 0x01, 0x20, 0x12, 0x00, 0x20, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x80, 0x04, 0x00, 0x48, 0x04, 0x80, 0x48, 0x04, 0x80, 0x84, 0x10, 0x3E,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x38, 0x02, 0x20, 0x21, 0x01, 0x08, 0x48,
  0x42, 0x42, 0x22, 0x12, 0x11, 0x20, 0x71, 0x00, 0x10, 0x01, 0x00, 0x09,
  0xE0, 0x91, 0x08, 0x84, 0x88, 0x24, 0x41, 0x42, 0x14, 0x10, 0x80, 0x88,
  0x03, 0x80, 0x07, 0x80, 0x84, 0x08, 0x41, 0x04, 0x10, 0x41, 0x08, 0x11,
  0x00, 0xA0, 0x0C, 0x00, 0xC0, 0x14, 0x02, 0x21, 0x42, 0x18, 0x11, 0x81,
  0x28, 0x0A, 0x80, 0x48, 0x0C, 0x41, 0x23, 0xE2, 0x5A, 0xA0, 0x01, 0x02,
  0x04, 0x08, 0x08, 0x10, 0x10, 0x20, 0x20, 0x20, 0x40, 0x40, 0x40, 0x40,
  0x40, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x40, 0x40, 0x40, 0x40,
  0x20, 0x10, 0x04, 0x04, 0x02, 0x02, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x02, 0x02, 0x02, 0x02, 0x04, 0x04, 0x08,
  0x08, 0x10, 0x10, 0x20, 0x40, 0x80, 0x04, 0x01, 0x00, 0x40, 0x10, 0xC5,
  0xCF, 0x80, 0xC0, 0x50, 0x22, 0x10, 0x88, 0x10, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x04, 0x0F, 0xFF, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x08, 0x00, 0x80, 0x08, 0x00, 0x24, 0xA5, 0x00, 0xF8, 0x80,
  0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x40, 0x08, 0x02,
  0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x10, 0x04,
  0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x00, 0x07, 0x81, 0x08, 0x40, 0x88,
  0x12, 0x02, 0x40, 0x48, 0x0A, 0x01, 0x40, 0x28, 0x05, 0x00, 0xA0, 0x18,
  0x05, 0x00, 0xA0, 0x14, 0x02, 0x80, 0x88, 0x21, 0x0C, 0x1E, 0x00, 0x0C,
  0xDC, 0x82, 0x08, 0x20, 0x82, 0x10, 0x41, 0x04, 0x10, 0x42, 0x08, 0x20,
  0x82, 0x08, 0x07, 0x81, 0x08, 0x40, 0x90, 0x12, 0x02, 0x80, 0x40, 0x08,
  0x02, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x7F, 0xE0, 0x07, 0xC0, 0x82, 0x10, 0x22, 0x02,
  0x20, 0x22, 0x02, 0x00, 0x20, 0x04, 0x00, 0x80, 0xF0, 0x00, 0x80, 0x04,
  0x00, 0x40, 0x04, 0x80, 0x48, 0x04, 0x80, 0x48, 0x08, 0x41, 0x03, 0xE0,
  0x00, 0x20, 0x0C, 0x03, 0x00, 0xA0, 0x24, 0x04, 0x81, 0x10, 0x42, 0x10,
  0x82, 0x10, 0x82, 0x20, 0x44, 0x09, 0xFF, 0xC0, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x1F, 0xE2, 0x00, 0x40, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x02, 0xF8, 0x60, 0x80, 0x10, 0x01, 0x00, 0x20, 0x04, 0x00, 0xA0,
  0x24, 0x04, 0x80, 0x90, 0x21, 0x08, 0x1E, 0x00, 0x01, 0xE0, 0xC0, 0x20,
  0x08, 0x01, 0x00, 0x40, 0x08, 0x02, 0x7C, 0x50, 0x4C, 0x09, 0x00, 0xA0,
  0x18, 0x03, 0x00, 0x60, 0x14, 0x02, 0x80, 0x48, 0x11, 0x84, 0x0F, 0x00,
  0x7F, 0xE0, 0x04, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x40, 0x08, 0x02,
  0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x20, 0x04,
  0x01, 0x00, 0x20, 0x00, 0x07, 0xC0, 0x82, 0x10, 0x22, 0x01, 0x20, 0x12,
  0x01, 0x20, 0x22, 0x02, 0x10, 0xC0, 0xF0, 0x30, 0x84, 0x04, 0x40, 0x48,
  0x02, 0x80, 0x48, 0x04, 0x80, 0x48, 0x08, 0x41, 0x03, 0xE0, 0x0F, 0x04,
  0x22, 0x05, 0x01, 0x40, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x38, 0x0D,
  0x0D, 0x3C, 0x80, 0x20, 0x08, 0x04, 0x02, 0x00, 0x80, 0xC3, 0xC0, 0x10,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x02, 0x10, 0x88, 0x44, 0x00, 0x00, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x01, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x02, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x20, 0x04, 0x00, 0xC0, 0x0C,
  0x00, 0x80, 0x10, 0x18, 0x18, 0x18, 0x18, 0x08, 0x00, 0x1E, 0x10, 0x90,
  0x28, 0x18, 0x08, 0x04, 0x04, 0x02, 0x02, 0x02, 0x02, 0x02, 0x01, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x7E, 0x00, 0x30,
  0x30, 0x08, 0x01, 0x02, 0x00, 0x10, 0x80, 0x02, 0x20, 0x00, 0x44, 0x1E,
  0x09, 0x04, 0x21, 0x21, 0x04, 0x28, 0x20, 0x85, 0x08, 0x10, 0xC1, 0x04,
  0x18, 0x40, 0x83, 0x08, 0x10, 0x61, 0x04, 0x14, 0x20, 0x82, 0x84, 0x30,
  0x90, 0x8A, 0x12, 0x0E, 0x3C, 0x40, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x81, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x20, 0x03, 0x00,
  0x28, 0x01, 0x40, 0x12, 0x00, 0x90, 0x04, 0x40, 0x42, 0x02, 0x10, 0x20,
  0x81, 0x04, 0x10, 0x20, 0x81, 0x0F, 0xF8, 0x40, 0x24, 0x01, 0x20, 0x0A,
  0x00, 0x50, 0x03, 0x00, 0x10, 0x1F, 0xC0, 0x81, 0x84, 0x04, 0x20, 0x11,
  0x00, 0x90, 0x08, 0x80, 0x44, 0x04, 0x20, 0x61, 0xFC, 0x08, 0x10, 0x80,
  0x44, 0x01, 0x20, 0x09, 0x00, 0x48, 0x04, 0x40, 0x24, 0x02, 0x20, 0x21,
  0xFE, 0x00, 0x07, 0xC0, 0x41, 0x84, 0x04, 0x40, 0x14, 0x00, 0xA0, 0x05,
  0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x90, 0x04, 0x80, 0x44, 0x02, 0x10, 0x20, 0x7E, 0x00, 0x1F,
  0xE0, 0x40, 0x41, 0x00, 0x84, 0x02, 0x10, 0x08, 0x80, 0x12, 0x00, 0x48,
  0x01, 0x20, 0x08, 0x80, 0x22, 0x00, 0x90, 0x02, 0x40, 0x09, 0x00, 0x44,
  0x01, 0x10, 0x04, 0x40, 0x22, 0x01, 0x08, 0x08, 0x3F, 0xC0, 0x1F, 0xF8,
  0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0xFF, 0x82, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x3F, 0xF0, 0x1F, 0xFC, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0xFF, 0x82, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x07, 0xE0, 0x40, 0x84,
  0x02, 0x40, 0x12, 0x00, 0xA0, 0x05, 0x00, 0x08, 0x00, 0x40, 0x04, 0x00,
  0x20, 0x01, 0x03, 0xE8, 0x01, 0x40, 0x0A, 0x00, 0x50, 0x02, 0x80, 0x22,
  0x01, 0x18, 0x30, 0x3E, 0x00, 0x10, 0x02, 0x20, 0x04, 0x40, 0x08, 0x80,
  0x11, 0x00, 0x24, 0x00, 0x88, 0x01, 0x10, 0x02, 0x20, 0x04, 0x7F, 0xF8,
  0x80, 0x12, 0x00, 0x44, 0x00, 0x88, 0x01, 0x10, 0x02, 0x20, 0x04, 0x40,
  0x09, 0x00, 0x22, 0x00, 0x44, 0x00, 0x80, 0x08, 0x44, 0x21, 0x08, 0x44,
  0x21, 0x08, 0x42, 0x21, 0x08, 0x42, 0x11, 0x00, 0x00, 0x08, 0x00, 0x40,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x11, 0x01, 0x10, 0x08, 0x40, 0x42,
  0x04, 0x10, 0x40, 0x7C, 0x00, 0x10, 0x04, 0x20, 0x10, 0x40, 0x40, 0x81,
  0x01, 0x04, 0x04, 0x10, 0x08, 0x40, 0x11, 0x00, 0x24, 0x00, 0x58, 0x00,
  0xC8, 0x01, 0x10, 0x04, 0x10, 0x08, 0x20, 0x10, 0x20, 0x20, 0x40, 0x40,
  0x41, 0x00, 0x82, 0x00, 0x84, 0x00, 0x80, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x40, 0x20, 0x1F, 0xF0, 0x18, 0x00, 0x23, 0x00, 0x0C, 0x60,
  0x02, 0x8C, 0x00, 0x61, 0x80, 0x14, 0x48, 0x02, 0x89, 0x00, 0x91, 0x20,
  0x12, 0x24, 0x04, 0x44, 0x80, 0x90, 0x88, 0x22, 0x21, 0x04, 0x44, 0x21,
  0x08, 0x84, 0x21, 0x10, 0x88, 0x42, 0x11, 0x08, 0x41, 0x41, 0x10, 0x30,
  0x22, 0x06, 0x04, 0x40, 0x80, 0x80, 0x10, 0x02, 0x30, 0x04, 0x60, 0x08,
  0xA0, 0x11, 0x40, 0x24, 0x80, 0x48, 0x81, 0x11, 0x02, 0x21, 0x04, 0x42,
  0x08, 0x84, 0x12, 0x04, 0x24, 0x08, 0x88, 0x09, 0x10, 0x12, 0x20, 0x24,
  0x40, 0x29, 0x00, 0x62, 0x00, 0x44, 0x00, 0x80, 0x03, 0xE0, 0x10, 0x60,
  0x80, 0x84, 0x01, 0x20, 0x04, 0x80, 0x12, 0x00, 0x50, 0x01, 0x40, 0x05,
  0x00, 0x14, 0x00, 0x90, 0x02, 0x40, 0x0A, 0x00, 0x28, 0x01, 0x20, 0x04,
  0x40, 0x11, 0x00, 0x82, 0x0C, 0x07, 0xC0, 0x1F, 0xE0, 0x80, 0x84, 0x02,
  0x20, 0x11, 0x00, 0x90, 0x04, 0x80, 0x24, 0x01, 0x20, 0x11, 0x00, 0x88,
  0x18, 0x7F, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x00, 0x03, 0xE0, 0x10, 0x60, 0x80, 0x84, 0x01, 0x20,
  0x04, 0x80, 0x12, 0x00, 0x50, 0x01, 0x40, 0x05, 0x00, 0x14, 0x00, 0x90,
  0x02, 0x40, 0x0A, 0x00, 0x28, 0x01, 0x20, 0x04, 0x40, 0x11, 0x00, 0x82,
  0x0C, 0x07, 0xC0, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x08, 0x1F, 0xE0,
  0x80, 0x84, 0x02, 0x20, 0x11, 0x00, 0x90, 0x04, 0x80, 0x24, 0x01, 0x20,
  0x11, 0x01, 0x0F, 0xF0, 0x81, 0x04, 0x08, 0x20, 0x41, 0x01, 0x08, 0x08,
  0x80, 0x44, 0x01, 0x20, 0x09, 0x00, 0x40, 0x07, 0xE0, 0x40, 0x84, 0x02,
  0x40, 0x12, 0x00, 0x90, 0x00, 0x80, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0x80, 0x02, 0x00, 0x0A, 0x00, 0x50, 0x04, 0x80, 0x24, 0x02,
  0x10, 0x20, 0x7E, 0x00, 0xFF, 0xF0, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x20, 0x04,
  0x80, 0x22, 0x00, 0x88, 0x02, 0x40, 0x09, 0x00, 0x24, 0x00, 0x90, 0x04,
  0x40, 0x11, 0x00, 0x48, 0x01, 0x20, 0x04, 0x80, 0x12, 0x00, 0x88, 0x02,
  0x20, 0x08, 0x80, 0x42, 0x01, 0x04, 0x18, 0x0F, 0x80, 0x80, 0x09, 0x00,
  0x24, 0x01, 0x10, 0x04, 0x40, 0x11, 0x00, 0x84, 0x02, 0x10, 0x10, 0x20,
  0x40, 0x82, 0x02, 0x08, 0x08, 0x40, 0x21, 0x00, 0x88, 0x01, 0x20, 0x04,
  0x80, 0x14, 0x00, 0x50, 0x01, 0x80, 0x06, 0x00, 0x80, 0x40, 0x30, 0x08,
  0x06, 0x03, 0x01, 0x40, 0x60, 0x28, 0x14, 0x05, 0x02, 0x41, 0x20, 0x88,
  0x24, 0x11, 0x04, 0x82, 0x21, 0x10, 0x84, 0x22, 0x10, 0x88, 0x44, 0x11,
  0x08, 0x82, 0x20, 0x90, 0x48, 0x14, 0x09, 0x02, 0x81, 0x20, 0x60, 0x18,
  0x0C, 0x03, 0x01, 0x00, 0x40, 0x20, 0x08, 0x00, 0x10, 0x02, 0x20, 0x08,
  0x20, 0x20, 0x40, 0x40, 0x41, 0x00, 0x84, 0x00, 0x90, 0x01, 0x20, 0x02,
  0x80, 0x02, 0x00, 0x0C, 0x00, 0x14, 0x00, 0x48, 0x01, 0x08, 0x04, 0x10,
  0x08, 0x20, 0x20, 0x20, 0x80, 0x41, 0x00, 0x44, 0x00, 0x80, 0x80, 0x14,
  0x00, 0xA0, 0x08, 0x80, 0x84, 0x04, 0x20, 0x40, 0x84, 0x04, 0x20, 0x22,
  0x00, 0xA0, 0x05, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x00, 0x0F, 0xFE, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x07, 0xFF, 0x80, 0x0F, 0x08, 0x08,
  0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20,
  0x20, 0x20, 0x20, 0x40, 0x40, 0x40, 0x40, 0x40, 0x40, 0x40, 0x80, 0xF0,
  0x88, 0x88, 0x84, 0x44, 0x44, 0x44, 0x22, 0x22, 0x22, 0x21, 0x11, 0x0F,
  0x01, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x04, 0x04, 0x04, 0x04, 0x04,
  0x04, 0x04, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10,
  0x10, 0xF0, 0x08, 0x18, 0x50, 0xA2, 0x44, 0x90, 0xA1, 0x83, 0x04, 0xFF,
  0x80, 0x89, 0x10, 0x07, 0xC1, 0x04, 0x40, 0x90, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x7E, 0x30, 0x48, 0x09, 0x01, 0x40, 0x28, 0x0C, 0x86, 0x8F, 0x20,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x09, 0xE1, 0xC2, 0x20,
  0x24, 0x05, 0x00, 0xA0, 0x14, 0x02, 0x80, 0x50, 0x14, 0x02, 0x80, 0x50,
  0x12, 0x02, 0x60, 0x8B, 0xE0, 0x0F, 0x84, 0x12, 0x05, 0x01, 0x40, 0x60,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x0A, 0x02, 0x81, 0x10, 0xC3, 0xC0,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x02, 0x0F, 0x21, 0x0A,
  0x20, 0x64, 0x02, 0x40, 0x44, 0x04, 0x80, 0x48, 0x04, 0x80, 0x48, 0x04,
  0x80, 0x88, 0x08, 0x80, 0x84, 0x38, 0x3C, 0x80, 0x0F, 0x84, 0x12, 0x05,
  0x01, 0x40, 0x60, 0x1F, 0xFE, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x10, 0x43, 0xE0, 0x07, 0x08, 0x10, 0x10, 0x20, 0x20, 0xFC, 0x20, 0x20,
  0x20, 0x40, 0x40, 0x40, 0x40, 0x40, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x07, 0x90, 0x85, 0x10, 0x32, 0x01, 0x20, 0x22, 0x02, 0x40, 0x24, 0x02,
  0x40, 0x24, 0x02, 0x40, 0x44, 0x04, 0x40, 0x42, 0x1C, 0x1E, 0x40, 0x04,
  0x00, 0x80, 0x08, 0x80, 0x84, 0x10, 0x3C, 0x00, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x20, 0x08, 0x02, 0x78, 0xA1, 0x30, 0x48, 0x12, 0x05, 0x01, 0x40,
  0x50, 0x14, 0x05, 0x01, 0x80, 0x60, 0x28, 0x0A, 0x02, 0x80, 0x80, 0x10,
  0x00, 0x02, 0x22, 0x22, 0x44, 0x44, 0x44, 0x88, 0x88, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x40, 0x20, 0x10,
  0x10, 0x70, 0x00, 0x10, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x08,
  0x11, 0x04, 0x21, 0x04, 0x41, 0x10, 0x24, 0x05, 0x00, 0xD0, 0x12, 0x02,
  0x20, 0x84, 0x10, 0x42, 0x08, 0x40, 0x88, 0x10, 0x11, 0x11, 0x12, 0x22,
  0x22, 0x24, 0x44, 0x44, 0x48, 0x88, 0x80, 0x27, 0x87, 0x85, 0x09, 0x08,
  0xC1, 0x40, 0x90, 0x10, 0x14, 0x04, 0x02, 0x80, 0x80, 0x50, 0x10, 0x12,
  0x02, 0x02, 0x40, 0x40, 0x50, 0x08, 0x0A, 0x02, 0x01, 0x40, 0x40, 0x48,
  0x08, 0x09, 0x01, 0x01, 0x20, 0x20, 0x20, 0x27, 0x8A, 0x13, 0x04, 0x81,
  0x60, 0x50, 0x14, 0x05, 0x01, 0x40, 0x50, 0x18, 0x06, 0x02, 0x80, 0xA0,
  0x28, 0x08, 0x0F, 0x82, 0x08, 0x81, 0x20, 0x14, 0x02, 0x80, 0x60, 0x0C,
  0x01, 0x80, 0x50, 0x0A, 0x01, 0x40, 0x48, 0x08, 0x82, 0x0F, 0x80, 0x13,
  0xC1, 0xC2, 0x10, 0x11, 0x01, 0x20, 0x12, 0x01, 0x20, 0x12, 0x01, 0x20,
  0x24, 0x02, 0x40, 0x24, 0x04, 0x40, 0x46, 0x08, 0x5F, 0x04, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x00, 0x0F, 0x22, 0x14, 0x81, 0xA0,
  0x14, 0x04, 0x80, 0xA0, 0x14, 0x02, 0x80, 0x50, 0x0A, 0x02, 0x40, 0x48,
  0x08, 0x87, 0x0F, 0x20, 0x04, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x27, 0x28, 0x30, 0x20, 0x40, 0x40, 0x40, 0x40, 0x40, 0x40, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x0F, 0x82, 0x08, 0x80, 0x90, 0x12, 0x00, 0x20, 0x02,
  0x00, 0x38, 0x00, 0x80, 0x10, 0x01, 0x00, 0x24, 0x08, 0x82, 0x0F, 0x80,
  0x21, 0x08, 0x4F, 0x91, 0x08, 0x42, 0x10, 0x88, 0x42, 0x10, 0x84, 0x18,
  0x20, 0x24, 0x04, 0x80, 0xA0, 0x14, 0x02, 0x80, 0x90, 0x12, 0x02, 0x40,
  0x50, 0x0A, 0x02, 0x40, 0x44, 0x18, 0x85, 0x0F, 0x20, 0x80, 0x60, 0x28,
  0x0A, 0x04, 0x81, 0x10, 0x84, 0x21, 0x10, 0x44, 0x11, 0x04, 0x81, 0x20,
  0x30, 0x0C, 0x02, 0x00, 0x81, 0x01, 0x81, 0x82, 0x82, 0x82, 0x82, 0x84,
  0x82, 0x84, 0x44, 0x84, 0x44, 0x88, 0x48, 0x88, 0x48, 0x90, 0x50, 0x90,
  0x50, 0x90, 0x50, 0x60, 0x60, 0x60, 0x60, 0x40, 0x40, 0x40, 0x20, 0x22,
  0x08, 0x41, 0x04, 0x40, 0x90, 0x12, 0x01, 0x80, 0x20, 0x0A, 0x01, 0x40,
  0x44, 0x10, 0x84, 0x10, 0x81, 0x20, 0x20, 0x10, 0x08, 0x80, 0x84, 0x04,
  0x20, 0x41, 0x02, 0x04, 0x20, 0x21, 0x01, 0x08, 0x08, 0x80, 0x44, 0x02,
  0x40, 0x12, 0x00, 0x60, 0x03, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40,
  0x04, 0x00, 0x20, 0x0E, 0x00, 0x00, 0x1F, 0xE0, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x02, 0x00, 0x80, 0x20, 0x08, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x3F, 0xE0, 0x01, 0x81, 0x01, 0x00, 0x80, 0x80, 0x40, 0x20, 0x10,
  0x10, 0x08, 0x04, 0x02, 0x02, 0x06, 0x01, 0x00, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x02, 0x01, 0x00, 0x80, 0x40, 0x10, 0x08, 0x03, 0x00, 0x11,
  0x11, 0x22, 0x22, 0x22, 0x24, 0x44, 0x44, 0x48, 0x88, 0x88, 0x88, 0x0C,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x0C, 0x0C, 0x08, 0x04, 0x02, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x20, 0x10, 0x10, 0x18, 0x10, 0x00, 0x38, 0x0A, 0x20, 0xA0, 0x85,
  0x04, 0x48, 0x1C, 0x00,
};

const GFXglyph RobotoCondensed_ThinItalic28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 4, 20, 5, 1, -20 },
  { 11, 5, 6, 7, 3, -21 },
  { 15, 14, 20, 13, 0, -20 },
  { 50, 12, 26, 13, 1, -23 },
  { 89, 13, 20, 18, 3, -20 },
  { 122, 12, 20, 15, 1, -20 },
  { 152, 2, 6, 5, 3, -21 },
  { 154, 8, 28, 7, 1, -22 },
  { 182, 8, 28, 8, -2, -22 },
  { 210, 10, 11, 11, 2, -20 },
  { 224, 12, 15, 13, 1, -17 },
  { 247, 3, 6, 5, -1, -2 },
  { 250, 5, 1, 7, 1, -10 },
  { 251, 1, 1, 6, 1, -1 },
  { 252, 11, 22, 9, -1, -20 },
  { 283, 11, 20, 13, 1, -20 },
  { 311, 6, 20, 13, 4, -20 },
  { 326, 11, 20, 13, 1, -20 },
  { 354, 12, 20, 13, 1, -20 },
  { 384, 11, 20, 13, 1, -20 },
  { 412, 11, 20, 13, 2, -20 },
  { 440, 11, 20, 13, 1, -20 },
  { 468, 11, 20, 13, 2, -20 },
  { 496, 12, 20, 13, 1, -20 },
  { 526, 10, 20, 13, 2, -20 },
  { 551, 4, 14, 5, 0, -14 },
  { 558, 5, 18, 5, -1, -14 },
  { 570, 11, 11, 12, 1, -15 },
  { 586, 10, 7, 13, 2, -13 },
  { 595, 10, 11, 12, 1, -15 },
  { 609, 9, 20, 11, 2, -20 },
  { 632, 19, 25, 22, 1, -19 },
  { 692, 13, 20, 14, -1, -20 },
  { 725, 13, 20, 14, 1, -20 },
  { 758, 13, 20, 15, 2, -20 },
  { 791, 14, 20, 16, 1, -20 },
  { 826, 14, 20, 14, 1, -20 },
  { 861, 14, 20, 14, 1, -20 },
  { 896, 13, 20, 16, 2, -20 },
  { 929, 15, 20, 17, 1, -20 },
  { 967, 5, 20, 7, 1, -20 },
  { 980, 13, 20, 13, 0, -20 },
  { 1013, 15, 20, 15, 1, -20 },
  { 1051, 9, 20, 12, 1, -20 },
  { 1074, 19, 20, 20, 1, -20 },
  { 1122, 15, 20, 17, 1, -20 },
  { 1160, 14, 20, 16, 1, -20 },
  { 1195, 13, 20, 14, 1, -20 },
  { 1228, 14, 24, 16, 1, -20 },
  { 1270, 13, 20, 16, 1, -20 },
  { 1303, 13, 20, 14, 1, -20 },
  { 1336, 12, 20, 14, 3, -20 },
  { 1366, 14, 20, 16, 2, -20 },
  { 1401, 14, 20, 14, 2, -20 },
  { 1436, 19, 20, 21, 3, -20 },
  { 1484, 15, 20, 14, 0, -20 },
  { 1522, 13, 20, 14, 3, -20 },
  { 1555, 15, 20, 14, 0, -20 },
  { 1593, 8, 27, 6, 0, -23 },
  { 1620, 4, 22, 9, 3, -20 },
  { 1631, 8, 27, 6, -2, -23 },
  { 1658, 7, 10, 10, 2, -20 },
  { 1667, 9, 1, 10, -1, 0 },
  { 1669, 3, 4, 7, 4, -21 },
  { 1671, 11, 15, 13, 0, -15 },
  { 1692, 11, 21, 13, 1, -21 },
  { 1721, 10, 15, 12, 1, -15 },
  { 1740, 12, 21, 13, 1, -21 },
  { 1772, 10, 15, 12, 1, -15 },
  { 1791, 8, 21, 8, 2, -21 },
  { 1812, 12, 21, 13, 0, -15 },
  { 1844, 10, 21, 13, 1, -21 },
  { 1871, 4, 20, 5, 1, -20 },
  { 1881, 9, 26, 6, -4, -20 },
  { 1911, 11, 21, 11, 1, -21 },
  { 1940, 4, 21, 5, 1, -21 },
  { 1951, 19, 15, 21, 1, -15 },
  { 1987, 10, 15, 13, 1, -15 },
  { 2006, 11, 15, 13, 1, -15 },
  { 2027, 12, 21, 13, 0, -15 },
  { 2059, 11, 21, 13, 1, -15 },
  { 2088, 8, 15, 8, 1, -15 },
  { 2103, 11, 15, 12, 0, -15 },
  { 2124, 5, 19, 8, 2, -19 },
  { 2136, 11, 15, 13, 1, -15 },
  { 2157, 10, 15, 12, 2, -15 },
  { 2176, 16, 15, 18, 2, -15 },
  { 2206, 11, 15, 12, 0, -15 },
  { 2227, 13, 21, 11, -1, -15 },
  { 2262, 11, 15, 12, 0, -15 },
  { 2283, 9, 28, 8, 1, -22 },
  { 2315, 4, 24, 5, 1, -20 },
  { 2327, 9, 28, 8, -2, -22 },
  { 2359, 13, 5, 16, 2, -11 },
};

const GFXfont RobotoCondensed_ThinItalic28pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ThinItalic28pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ThinItalic28pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _ROBOTOCONDENSED_THINITALIC28PT7B_H_
