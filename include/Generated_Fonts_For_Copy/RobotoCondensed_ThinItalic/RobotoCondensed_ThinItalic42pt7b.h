#ifndef _ROBOTOCONDENSED_THINITALIC42PT7B_H_
#define _ROBOTOCONDENSED_THINITALIC42PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ThinItalic.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ThinItalic42pt7bBitmaps[] PROGMEM = {
  0x00, 0x04, 0x10, 0x41, 0x0C, 0x20, 0x82, 0x08, 0x21, 0x84, 0x10, 0x41,
  0x04, 0x30, 0x82, 0x08, 0x20, 0x80, 0x00, 0x00, 0x00, 0x00, 0xC3, 0x00,
  0x45, 0x14, 0x71, 0x8E, 0x28, 0xA2, 0x00, 0x10, 0x20, 0x00, 0x81, 0x00,
  0x08, 0x10, 0x00, 0x40, 0x80, 0x02, 0x04, 0x00, 0x20, 0x60, 0x01, 0x02,
  0x00, 0x08, 0x10, 0x00, 0x81, 0x80, 0xFF, 0xFF, 0xC0, 0x20, 0x40, 0x02,
  0x06, 0x00, 0x10, 0x20, 0x00, 0x81, 0x00, 0x0C, 0x18, 0x00, 0x40, 0x80,
  0x02, 0x04, 0x00, 0x30, 0x20, 0x01, 0x02, 0x00, 0x08, 0x10, 0x00, 0x40,
  0x80, 0x7F, 0xFF, 0xC0, 0x20, 0x40, 0x01, 0x02, 0x00, 0x10, 0x20, 0x00,
  0x81, 0x00, 0x04, 0x08, 0x00, 0x40, 0x80, 0x02, 0x04, 0x00, 0x10, 0x20,
  0x00, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x0F, 0x80,
  0x18, 0x30, 0x18, 0x0C, 0x18, 0x02, 0x08, 0x01, 0x08, 0x00, 0x44, 0x00,
  0x22, 0x00, 0x11, 0x00, 0x08, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x06, 0x40, 0x01, 0x20, 0x01, 0x90, 0x00,
  0x88, 0x00, 0x44, 0x00, 0x63, 0x00, 0x20, 0x80, 0x20, 0x30, 0x60, 0x07,
  0xC0, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x0F, 0x00,
  0x01, 0x18, 0x00, 0x20, 0x80, 0x04, 0x08, 0x00, 0x40, 0x40, 0x4C, 0x04,
  0x08, 0x80, 0xC1, 0x08, 0x08, 0x30, 0x80, 0x82, 0x08, 0x08, 0x40, 0x81,
  0x0C, 0x0C, 0x10, 0x80, 0x46, 0x10, 0x03, 0xC2, 0x00, 0x00, 0x60, 0x00,
  0x04, 0x00, 0x00, 0x83, 0xC0, 0x18, 0xC6, 0x01, 0x08, 0x20, 0x21, 0x02,
  0x04, 0x10, 0x20, 0x42, 0x02, 0x08, 0x20, 0x21, 0x02, 0x02, 0x30, 0x20,
  0x22, 0x02, 0x02, 0x00, 0x20, 0x40, 0x02, 0x0C, 0x00, 0x11, 0x80, 0x00,
  0xF0, 0x00, 0x7C, 0x00, 0x18, 0xC0, 0x04, 0x08, 0x01, 0x81, 0x80, 0x20,
  0x10, 0x04, 0x06, 0x01, 0x80, 0x80, 0x20, 0x10, 0x04, 0x04, 0x00, 0x41,
  0x00, 0x08, 0x40, 0x01, 0x10, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xA0,
  0x00, 0x26, 0x00, 0x08, 0x40, 0x02, 0x0C, 0x04, 0x80, 0x81, 0x10, 0x08,
  0x24, 0x01, 0x04, 0x80, 0x11, 0x10, 0x02, 0x26, 0x00, 0x28, 0xC0, 0x07,
  0x08, 0x00, 0x41, 0x00, 0x1C, 0x30, 0x04, 0x83, 0x83, 0x08, 0x1F, 0x81,
  0x00, 0x25, 0xA4, 0x96, 0x00, 0x20, 0x0C, 0x03, 0x00, 0x40, 0x10, 0x04,
  0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x20, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x06,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10,
  0x02, 0x00, 0x20, 0x00, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x40, 0x18, 0x02, 0x00, 0x40, 0x18,
  0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0x10, 0x04, 0x01, 0x00, 0x60,
  0x18, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x0C, 0x02, 0x04, 0x09, 0xC2, 0x1C, 0x1D, 0x70, 0x03, 0xC0, 0x00,
  0xC0, 0x00, 0x90, 0x00, 0x88, 0x00, 0x82, 0x00, 0xC1, 0x80, 0xC0, 0x40,
  0x40, 0x30, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x3F,
  0xFF, 0xE0, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x11,
  0x33, 0x26, 0x48, 0xFF, 0xF0, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x02, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01,
  0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00,
  0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x08, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x00, 0x00, 0xF8, 0x00, 0xC3, 0x01, 0x80, 0x80, 0x80,
  0x20, 0x80, 0x10, 0x40, 0x08, 0x40, 0x04, 0x20, 0x03, 0x20, 0x01, 0x90,
  0x00, 0xC8, 0x00, 0x44, 0x00, 0x24, 0x00, 0x12, 0x00, 0x09, 0x00, 0x04,
  0x80, 0x02, 0x40, 0x02, 0x60, 0x01, 0x20, 0x00, 0x90, 0x00, 0x48, 0x00,
  0x64, 0x00, 0x22, 0x00, 0x11, 0x00, 0x18, 0x80, 0x08, 0x60, 0x0C, 0x10,
  0x04, 0x0C, 0x04, 0x03, 0x0C, 0x00, 0xF8, 0x00, 0x01, 0x83, 0x8E, 0x58,
  0x20, 0x10, 0x08, 0x0C, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x01, 0x80, 0x00, 0x7C, 0x00, 0xC3, 0x00, 0x80,
  0x40, 0x80, 0x30, 0xC0, 0x08, 0x40, 0x04, 0x60, 0x02, 0x20, 0x01, 0x10,
  0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x30,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7C,
  0x00, 0x60, 0xC0, 0x20, 0x18, 0x10, 0x02, 0x0C, 0x00, 0x82, 0x00, 0x21,
  0x80, 0x0C, 0x40, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x1F, 0x00, 0x00, 0x70, 0x00, 0x06,
  0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x30, 0x00, 0x48,
  0x00, 0x33, 0x00, 0x08, 0x40, 0x02, 0x10, 0x01, 0x06, 0x00, 0xC0, 0x80,
  0x60, 0x18, 0x30, 0x03, 0xF0, 0x00, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0xA0, 0x00, 0x90, 0x00, 0xC8, 0x00, 0x4C, 0x00, 0x44, 0x00,
  0x62, 0x00, 0x21, 0x00, 0x20, 0x80, 0x20, 0x40, 0x30, 0x60, 0x10, 0x20,
  0x10, 0x10, 0x18, 0x08, 0x08, 0x04, 0x08, 0x02, 0x0C, 0x03, 0x0C, 0x01,
  0x04, 0x00, 0x87, 0xFF, 0xFC, 0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x07, 0xFF,
  0x82, 0x00, 0x01, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x04, 0x7C, 0x02,
  0xC3, 0x01, 0x80, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x22, 0x00, 0x11, 0x00,
  0x10, 0x80, 0x08, 0x40, 0x0C, 0x30, 0x04, 0x08, 0x04, 0x03, 0x0C, 0x00,
  0xFC, 0x00, 0x00, 0x1E, 0x00, 0xE0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x00,
  0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0x87, 0xC1, 0x30,
  0xC2, 0x80, 0x4A, 0x00, 0xD8, 0x00, 0xA0, 0x01, 0x40, 0x02, 0x80, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x02, 0xC0,
  0x04, 0x80, 0x11, 0x00, 0x61, 0x01, 0x83, 0x06, 0x01, 0xF0, 0x00, 0xFF,
  0xFF, 0x00, 0x01, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00,
  0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x80, 0x00, 0x80, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x60, 0xC0, 0x30, 0x18, 0x18, 0x02, 0x04, 0x00, 0x42, 0x00,
  0x10, 0x80, 0x04, 0x60, 0x01, 0x10, 0x00, 0x44, 0x00, 0x20, 0x80, 0x08,
  0x20, 0x04, 0x0C, 0x02, 0x01, 0x83, 0x00, 0x3F, 0x00, 0x38, 0x30, 0x18,
  0x06, 0x0C, 0x00, 0x82, 0x00, 0x11, 0x00, 0x04, 0x40, 0x01, 0x20, 0x00,
  0x48, 0x00, 0x12, 0x00, 0x0C, 0x80, 0x02, 0x30, 0x01, 0x84, 0x00, 0x41,
  0x80, 0x60, 0x38, 0x70, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x0C, 0x30, 0x20,
  0x10, 0x80, 0x33, 0x00, 0x24, 0x00, 0x50, 0x00, 0xA0, 0x01, 0x40, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xE0,
  0x07, 0x40, 0x14, 0xC0, 0x68, 0xC3, 0x10, 0xFC, 0x60, 0x00, 0x80, 0x01,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0xE0, 0x0F, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x61, 0x80, 0x06, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x83, 0x06, 0x08, 0x10, 0x61, 0x82, 0x00, 0x00, 0x01, 0x00,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x00, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x08, 0x3F, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFE, 0x10, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x00, 0x80, 0x00, 0x0F,
  0x81, 0x86, 0x20, 0x24, 0x01, 0x40, 0x18, 0x01, 0x80, 0x10, 0x01, 0x00,
  0x30, 0x02, 0x00, 0x20, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x04, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1C, 0x0E, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00,
  0xC0, 0x00, 0x30, 0x06, 0x00, 0x00, 0x40, 0x10, 0x00, 0x00, 0x80, 0x80,
  0x00, 0x02, 0x06, 0x00, 0x00, 0x08, 0x10, 0x07, 0xC0, 0x20, 0x80, 0x31,
  0x80, 0xC2, 0x01, 0x03, 0x01, 0x10, 0x08, 0x08, 0x04, 0x40, 0x40, 0x20,
  0x13, 0x01, 0x00, 0x80, 0x88, 0x08, 0x02, 0x02, 0x20, 0x20, 0x10, 0x09,
  0x81, 0x00, 0x40, 0x24, 0x04, 0x01, 0x00, 0x90, 0x10, 0x04, 0x06, 0x40,
  0x80, 0x20, 0x11, 0x02, 0x00, 0x80, 0x44, 0x08, 0x02, 0x01, 0x30, 0x20,
  0x18, 0x08, 0xC0, 0x80, 0xA0, 0x23, 0x02, 0x02, 0x81, 0x04, 0x08, 0x12,
  0x0C, 0x10, 0x11, 0x8C, 0x60, 0x40, 0x7C, 0x1E, 0x01, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x07,
  0x03, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x50,
  0x00, 0x05, 0x00, 0x00, 0x90, 0x00, 0x09, 0x00, 0x00, 0x90, 0x00, 0x11,
  0x00, 0x01, 0x10, 0x00, 0x20, 0x80, 0x02, 0x08, 0x00, 0x40, 0x80, 0x04,
  0x08, 0x00, 0x80, 0x80, 0x08, 0x08, 0x01, 0x00, 0x80, 0x10, 0x0C, 0x02,
  0x00, 0x40, 0x20, 0x04, 0x04, 0x00, 0x40, 0x40, 0x04, 0x0F, 0xFF, 0xC0,
  0x80, 0x04, 0x18, 0x00, 0x41, 0x00, 0x06, 0x30, 0x00, 0x22, 0x00, 0x02,
  0x60, 0x00, 0x24, 0x00, 0x02, 0x40, 0x00, 0x28, 0x00, 0x02, 0x07, 0xFC,
  0x03, 0x00, 0xC0, 0x80, 0x08, 0x20, 0x03, 0x08, 0x00, 0x42, 0x00, 0x10,
  0x80, 0x04, 0x60, 0x01, 0x10, 0x00, 0x44, 0x00, 0x31, 0x00, 0x08, 0x40,
  0x06, 0x10, 0x03, 0x0C, 0x03, 0x03, 0xFF, 0x80, 0x80, 0x18, 0x20, 0x03,
  0x08, 0x00, 0x42, 0x00, 0x19, 0x80, 0x02, 0x40, 0x00, 0x90, 0x00, 0x24,
  0x00, 0x19, 0x00, 0x04, 0x40, 0x01, 0x20, 0x00, 0x88, 0x00, 0x62, 0x00,
  0x30, 0x80, 0x38, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x0C, 0x0C, 0x03,
  0x00, 0x60, 0x60, 0x02, 0x04, 0x00, 0x30, 0x80, 0x01, 0x18, 0x00, 0x11,
  0x00, 0x01, 0x10, 0x00, 0x12, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x44, 0x00,
  0x0C, 0x40, 0x00, 0x84, 0x00, 0x08, 0x40, 0x01, 0x04, 0x00, 0x10, 0x20,
  0x02, 0x03, 0x00, 0x40, 0x18, 0x18, 0x00, 0x7E, 0x00, 0x07, 0xFE, 0x00,
  0xC0, 0x30, 0x08, 0x00, 0xC0, 0x80, 0x04, 0x08, 0x00, 0x20, 0x80, 0x02,
  0x08, 0x00, 0x31, 0x80, 0x01, 0x10, 0x00, 0x11, 0x00, 0x01, 0x10, 0x00,
  0x11, 0x00, 0x01, 0x10, 0x00, 0x23, 0x00, 0x02, 0x20, 0x00, 0x22, 0x00,
  0x02, 0x20, 0x00, 0x22, 0x00, 0x02, 0x20, 0x00, 0x44, 0x00, 0x04, 0x40,
  0x00, 0x44, 0x00, 0x0C, 0x40, 0x00, 0x84, 0x00, 0x18, 0x40, 0x01, 0x08,
  0x00, 0x20, 0x80, 0x06, 0x08, 0x00, 0xC0, 0x80, 0x70, 0x0F, 0xFC, 0x00,
  0x07, 0xFF, 0xF0, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00,
  0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x3F,
  0xFF, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x10,
  0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03,
  0x00, 0x00, 0x3F, 0xFF, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x18, 0x18, 0x02,
  0x00, 0x40, 0x40, 0x02, 0x08, 0x00, 0x21, 0x80, 0x03, 0x10, 0x00, 0x13,
  0x00, 0x01, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x3F,
  0xC8, 0x00, 0x04, 0x80, 0x00, 0x48, 0x00, 0x04, 0x80, 0x00, 0xC8, 0x00,
  0x08, 0x80, 0x00, 0x88, 0x00, 0x08, 0x80, 0x00, 0x84, 0x00, 0x08, 0x40,
  0x01, 0x02, 0x00, 0x60, 0x18, 0x1C, 0x00, 0x7E, 0x00, 0x04, 0x00, 0x04,
  0x30, 0x00, 0x10, 0x80, 0x00, 0x42, 0x00, 0x01, 0x08, 0x00, 0x04, 0x20,
  0x00, 0x20, 0x80, 0x00, 0x86, 0x00, 0x02, 0x10, 0x00, 0x08, 0x40, 0x00,
  0x21, 0x00, 0x01, 0x84, 0x00, 0x04, 0x10, 0x00, 0x10, 0xC0, 0x00, 0x43,
  0xFF, 0xFF, 0x08, 0x00, 0x04, 0x20, 0x00, 0x30, 0x80, 0x00, 0x82, 0x00,
  0x02, 0x10, 0x00, 0x08, 0x40, 0x00, 0x21, 0x00, 0x00, 0x84, 0x00, 0x06,
  0x10, 0x00, 0x10, 0x40, 0x00, 0x42, 0x00, 0x01, 0x08, 0x00, 0x04, 0x20,
  0x00, 0x10, 0x80, 0x00, 0x82, 0x00, 0x02, 0x00, 0x04, 0x10, 0x41, 0x04,
  0x30, 0x82, 0x08, 0x20, 0x86, 0x10, 0x41, 0x04, 0x10, 0x82, 0x08, 0x20,
  0x86, 0x10, 0x41, 0x04, 0x10, 0xC2, 0x00, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x20, 0x01, 0x08, 0x00, 0x42, 0x00,
  0x10, 0x80, 0x08, 0x20, 0x02, 0x0C, 0x01, 0x01, 0x00, 0x80, 0x30, 0xC0,
  0x07, 0xE0, 0x00, 0x04, 0x00, 0x18, 0x60, 0x01, 0x82, 0x00, 0x18, 0x10,
  0x01, 0x80, 0x80, 0x18, 0x04, 0x01, 0x80, 0x20, 0x18, 0x03, 0x01, 0x80,
  0x10, 0x08, 0x00, 0x80, 0x80, 0x04, 0x08, 0x00, 0x20, 0x80, 0x01, 0x08,
  0x00, 0x18, 0x80, 0x00, 0x8E, 0x00, 0x04, 0x90, 0x00, 0x28, 0x40, 0x01,
  0x82, 0x00, 0x08, 0x08, 0x00, 0x80, 0x40, 0x04, 0x01, 0x00, 0x20, 0x08,
  0x01, 0x00, 0x20, 0x08, 0x01, 0x80, 0x40, 0x04, 0x04, 0x00, 0x30, 0x20,
  0x00, 0x81, 0x00, 0x06, 0x08, 0x00, 0x10, 0x40, 0x00, 0xC0, 0x04, 0x00,
  0x60, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x03, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x7F, 0xFC, 0x04,
  0x00, 0x00, 0x30, 0xE0, 0x00, 0x07, 0x0A, 0x00, 0x00, 0x60, 0xA0, 0x00,
  0x0A, 0x0A, 0x00, 0x00, 0xA0, 0xA0, 0x00, 0x12, 0x0A, 0x00, 0x01, 0x21,
  0x90, 0x00, 0x24, 0x11, 0x00, 0x02, 0x41, 0x10, 0x00, 0x44, 0x11, 0x00,
  0x04, 0x41, 0x10, 0x00, 0x84, 0x11, 0x80, 0x08, 0x43, 0x08, 0x01, 0x08,
  0x20, 0x80, 0x10, 0x82, 0x08, 0x02, 0x08, 0x20, 0x80, 0x60, 0x82, 0x08,
  0x04, 0x08, 0x20, 0x40, 0xC1, 0x84, 0x04, 0x08, 0x10, 0x40, 0x41, 0x81,
  0x04, 0x04, 0x10, 0x10, 0x40, 0x42, 0x01, 0x04, 0x04, 0x20, 0x10, 0x40,
  0x24, 0x03, 0x08, 0x02, 0x40, 0x20, 0x80, 0x28, 0x02, 0x08, 0x02, 0x80,
  0x20, 0x80, 0x30, 0x02, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x04, 0x18,
  0x00, 0x08, 0x38, 0x00, 0x10, 0x50, 0x00, 0x20, 0x90, 0x00, 0x41, 0x20,
  0x01, 0x82, 0x40, 0x02, 0x0C, 0x40, 0x04, 0x18, 0x80, 0x08, 0x21, 0x00,
  0x10, 0x41, 0x00, 0x20, 0x82, 0x00, 0xC1, 0x02, 0x01, 0x06, 0x04, 0x02,
  0x08, 0x08, 0x04, 0x10, 0x08, 0x08, 0x20, 0x10, 0x10, 0x40, 0x10, 0x60,
  0x80, 0x20, 0x83, 0x00, 0x41, 0x04, 0x00, 0x42, 0x08, 0x00, 0x84, 0x10,
  0x01, 0x98, 0x20, 0x01, 0x30, 0x40, 0x02, 0x41, 0x80, 0x02, 0x82, 0x00,
  0x05, 0x04, 0x00, 0x0A, 0x08, 0x00, 0x0C, 0x10, 0x00, 0x18, 0x00, 0x00,
  0x3F, 0x00, 0x06, 0x06, 0x00, 0xC0, 0x18, 0x0C, 0x00, 0x40, 0x40, 0x01,
  0x04, 0x00, 0x08, 0x60, 0x00, 0x42, 0x00, 0x02, 0x10, 0x00, 0x11, 0x00,
  0x00, 0x88, 0x00, 0x04, 0x40, 0x00, 0x22, 0x00, 0x01, 0x30, 0x00, 0x09,
  0x00, 0x00, 0x48, 0x00, 0x04, 0x40, 0x00, 0x22, 0x00, 0x01, 0x10, 0x00,
  0x09, 0x80, 0x00, 0x48, 0x00, 0x04, 0x40, 0x00, 0x22, 0x00, 0x01, 0x08,
  0x00, 0x10, 0x40, 0x00, 0x82, 0x00, 0x08, 0x08, 0x00, 0x80, 0x60, 0x0C,
  0x01, 0x81, 0x80, 0x03, 0xF0, 0x00, 0x07, 0xFE, 0x01, 0x80, 0x30, 0x20,
  0x03, 0x04, 0x00, 0x30, 0x80, 0x02, 0x10, 0x00, 0x42, 0x00, 0x08, 0xC0,
  0x01, 0x10, 0x00, 0x22, 0x00, 0x04, 0x40, 0x01, 0x88, 0x00, 0x21, 0x00,
  0x0C, 0x60, 0x03, 0x08, 0x00, 0xC1, 0x00, 0x70, 0x3F, 0xF8, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x06, 0x06, 0x00,
  0xC0, 0x18, 0x0C, 0x00, 0x40, 0x40, 0x01, 0x04, 0x00, 0x08, 0x60, 0x00,
  0x42, 0x00, 0x02, 0x10, 0x00, 0x11, 0x00, 0x00, 0x88, 0x00, 0x04, 0x40,
  0x00, 0x22, 0x00, 0x01, 0x30, 0x00, 0x09, 0x00, 0x00, 0x48, 0x00, 0x04,
  0x40, 0x00, 0x22, 0x00, 0x01, 0x10, 0x00, 0x09, 0x80, 0x00, 0x48, 0x00,
  0x04, 0x40, 0x00, 0x22, 0x00, 0x01, 0x18, 0x00, 0x10, 0x40, 0x00, 0x82,
  0x00, 0x08, 0x18, 0x00, 0x80, 0x60, 0x08, 0x01, 0x81, 0x80, 0x03, 0xF8,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x07, 0xFE, 0x00, 0x80, 0x18, 0x08, 0x00, 0xC0, 0x80, 0x06,
  0x08, 0x00, 0x20, 0x80, 0x02, 0x08, 0x00, 0x21, 0x00, 0x02, 0x10, 0x00,
  0x21, 0x00, 0x02, 0x10, 0x00, 0x21, 0x00, 0x04, 0x10, 0x00, 0x42, 0x00,
  0x08, 0x20, 0x01, 0x02, 0x00, 0x60, 0x3F, 0xF8, 0x02, 0x01, 0x00, 0x60,
  0x08, 0x04, 0x00, 0x80, 0x40, 0x08, 0x04, 0x00, 0x40, 0x40, 0x04, 0x04,
  0x00, 0x40, 0xC0, 0x02, 0x08, 0x00, 0x20, 0x80, 0x02, 0x08, 0x00, 0x10,
  0x80, 0x01, 0x08, 0x00, 0x10, 0x00, 0x3F, 0x00, 0x1C, 0x1C, 0x03, 0x00,
  0x60, 0x60, 0x02, 0x0C, 0x00, 0x30, 0x80, 0x01, 0x08, 0x00, 0x11, 0x80,
  0x01, 0x10, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x48, 0x00, 0x04,
  0x80, 0x00, 0xC8, 0x00, 0x08, 0xC0, 0x00, 0x84, 0x00, 0x18, 0x40, 0x03,
  0x02, 0x00, 0x60, 0x18, 0x1C, 0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xE0, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x08, 0x40,
  0x00, 0x42, 0x00, 0x02, 0x10, 0x00, 0x10, 0x80, 0x01, 0x84, 0x00, 0x08,
  0x40, 0x00, 0x42, 0x00, 0x02, 0x10, 0x00, 0x10, 0x80, 0x00, 0x84, 0x00,
  0x0C, 0x60, 0x00, 0x42, 0x00, 0x02, 0x10, 0x00, 0x10, 0x80, 0x00, 0x84,
  0x00, 0x04, 0x20, 0x00, 0x43, 0x00, 0x02, 0x10, 0x00, 0x10, 0x80, 0x00,
  0x84, 0x00, 0x04, 0x20, 0x00, 0x21, 0x00, 0x02, 0x08, 0x00, 0x10, 0x40,
  0x01, 0x82, 0x00, 0x08, 0x18, 0x00, 0x80, 0x60, 0x08, 0x01, 0x81, 0x80,
  0x03, 0xF0, 0x00, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x40, 0x00,
  0x6C, 0x00, 0x08, 0x80, 0x01, 0x10, 0x00, 0x42, 0x00, 0x08, 0x40, 0x02,
  0x08, 0x00, 0x41, 0x00, 0x10, 0x30, 0x02, 0x02, 0x00, 0xC0, 0x40, 0x10,
  0x08, 0x06, 0x01, 0x00, 0x80, 0x20, 0x10, 0x04, 0x04, 0x00, 0xC0, 0x80,
  0x08, 0x20, 0x01, 0x04, 0x00, 0x21, 0x00, 0x04, 0x20, 0x00, 0x88, 0x00,
  0x11, 0x00, 0x01, 0x60, 0x00, 0x28, 0x00, 0x05, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x00, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x01,
  0x40, 0x05, 0x00, 0x0A, 0x00, 0x2C, 0x00, 0x90, 0x01, 0x60, 0x04, 0x80,
  0x11, 0x00, 0x24, 0x00, 0x88, 0x02, 0x20, 0x0C, 0x40, 0x11, 0x00, 0x42,
  0x01, 0x08, 0x02, 0x10, 0x08, 0x40, 0x20, 0x80, 0x42, 0x01, 0x04, 0x04,
  0x18, 0x08, 0x20, 0x20, 0x40, 0x81, 0x02, 0x02, 0x04, 0x08, 0x10, 0x10,
  0x60, 0x41, 0x80, 0x82, 0x02, 0x08, 0x04, 0x10, 0x10, 0x40, 0x21, 0x00,
  0xC4, 0x01, 0x08, 0x06, 0x20, 0x08, 0x40, 0x13, 0x00, 0x44, 0x00, 0x90,
  0x02, 0x20, 0x04, 0x80, 0x1B, 0x00, 0x28, 0x00, 0x50, 0x01, 0x40, 0x02,
  0x80, 0x0A, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x06, 0x00, 0x02, 0x02, 0x00, 0x06, 0x03, 0x00,
  0x0C, 0x01, 0x00, 0x08, 0x01, 0x00, 0x10, 0x00, 0x80, 0x30, 0x00, 0x80,
  0x20, 0x00, 0xC0, 0x40, 0x00, 0x40, 0x80, 0x00, 0x61, 0x80, 0x00, 0x21,
  0x00, 0x00, 0x22, 0x00, 0x00, 0x16, 0x00, 0x00, 0x14, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x64, 0x00, 0x00, 0x44,
  0x00, 0x00, 0x82, 0x00, 0x01, 0x82, 0x00, 0x01, 0x01, 0x00, 0x02, 0x01,
  0x00, 0x04, 0x01, 0x80, 0x0C, 0x00, 0x80, 0x08, 0x00, 0x80, 0x10, 0x00,
  0x40, 0x20, 0x00, 0x40, 0x60, 0x00, 0x60, 0x40, 0x00, 0x20, 0x80, 0x00,
  0x38, 0x00, 0x0D, 0x00, 0x01, 0x20, 0x00, 0x46, 0x00, 0x18, 0x40, 0x02,
  0x08, 0x00, 0x81, 0x80, 0x30, 0x10, 0x04, 0x02, 0x01, 0x00, 0x60, 0x60,
  0x04, 0x08, 0x00, 0x82, 0x00, 0x10, 0xC0, 0x01, 0x10, 0x00, 0x24, 0x00,
  0x05, 0x80, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xF0, 0x10,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x07, 0x80, 0xC1, 0x04, 0x10,
  0x41, 0x04, 0x18, 0x20, 0x82, 0x08, 0x20, 0x83, 0x04, 0x10, 0x41, 0x04,
  0x10, 0x60, 0x82, 0x08, 0x20, 0x82, 0x0C, 0x10, 0x41, 0x04, 0x01, 0xE0,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x30, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x0F, 0x80, 0x00, 0x80,
  0x30, 0x06, 0x01, 0x20, 0x24, 0x08, 0x81, 0x10, 0x42, 0x08, 0x42, 0x0C,
  0x40, 0x90, 0x12, 0x02, 0x80, 0x50, 0x08, 0xFF, 0xFE, 0xC4, 0x62, 0x10,
  0x00, 0xFC, 0x01, 0x83, 0x01, 0x80, 0x41, 0x80, 0x20, 0x80, 0x10, 0x80,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0xFF, 0xC1,
  0xC0, 0x41, 0x80, 0x21, 0x00, 0x11, 0x80, 0x08, 0x80, 0x04, 0x40, 0x06,
  0x20, 0x02, 0x10, 0x03, 0x08, 0x06, 0x83, 0x0E, 0x40, 0xFC, 0x20, 0x06,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x3F, 0x01, 0x30,
  0xC1, 0x60, 0x30, 0xE0, 0x08, 0x60, 0x04, 0x20, 0x03, 0x10, 0x01, 0x88,
  0x00, 0xC8, 0x00, 0x44, 0x00, 0x22, 0x00, 0x11, 0x00, 0x08, 0x80, 0x04,
  0x40, 0x02, 0x40, 0x02, 0x20, 0x01, 0x10, 0x01, 0x88, 0x00, 0x86, 0x00,
  0xC7, 0x00, 0xC2, 0x60, 0xC1, 0x0F, 0x80, 0x01, 0xF8, 0x06, 0x0C, 0x0C,
  0x06, 0x18, 0x02, 0x10, 0x03, 0x20, 0x01, 0x20, 0x01, 0x20, 0x01, 0x40,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80,
  0x00, 0x80, 0x04, 0xC0, 0x04, 0x40, 0x08, 0x40, 0x08, 0x60, 0x10, 0x30,
  0x60, 0x0F, 0x80, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x3E, 0x10, 0x30, 0x64, 0x18, 0x05, 0x04, 0x01, 0xC2, 0x00,
  0x20, 0x80, 0x08, 0x40, 0x02, 0x10, 0x00, 0x84, 0x00, 0x23, 0x00, 0x18,
  0x80, 0x04, 0x20, 0x01, 0x08, 0x00, 0x42, 0x00, 0x10, 0x80, 0x04, 0x20,
  0x03, 0x08, 0x00, 0x82, 0x00, 0x20, 0x80, 0x18, 0x10, 0x0A, 0x06, 0x0C,
  0x80, 0x7C, 0x40, 0x01, 0xF8, 0x07, 0x0C, 0x0C, 0x02, 0x18, 0x02, 0x10,
  0x01, 0x20, 0x01, 0x20, 0x01, 0x60, 0x01, 0x40, 0x01, 0x7F, 0xFF, 0x40,
  0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0xC0,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x20, 0x08, 0x30, 0x70, 0x0F, 0xC0, 0x00,
  0xF0, 0x30, 0x06, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x08, 0x00, 0x80, 0x18,
  0x01, 0x00, 0xFF, 0x81, 0x00, 0x10, 0x01, 0x00, 0x30, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x04, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x00,
  0xF8, 0x40, 0xC1, 0x90, 0x60, 0x14, 0x10, 0x07, 0x08, 0x00, 0x82, 0x00,
  0x21, 0x00, 0x08, 0x40, 0x02, 0x10, 0x00, 0x88, 0x00, 0x62, 0x00, 0x10,
  0x80, 0x04, 0x20, 0x01, 0x08, 0x00, 0x42, 0x00, 0x10, 0x80, 0x0C, 0x20,
  0x02, 0x08, 0x00, 0x82, 0x00, 0x60, 0x40, 0x28, 0x18, 0x32, 0x01, 0xF1,
  0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x82,
  0x00, 0x60, 0x40, 0x30, 0x0C, 0x18, 0x00, 0xF8, 0x00, 0x06, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x7C, 0x09, 0x86, 0x1A, 0x03, 0x16,
  0x01, 0x14, 0x01, 0x18, 0x01, 0x18, 0x01, 0x10, 0x01, 0x30, 0x01, 0x20,
  0x01, 0x20, 0x02, 0x20, 0x02, 0x20, 0x02, 0x20, 0x02, 0x40, 0x02, 0x40,
  0x06, 0x40, 0x04, 0x40, 0x04, 0x40, 0x04, 0x40, 0x04, 0x80, 0x04, 0x80,
  0x0C, 0x06, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x10, 0x20, 0x41,
  0x02, 0x04, 0x08, 0x10, 0x60, 0x81, 0x02, 0x04, 0x08, 0x30, 0x40, 0x81,
  0x02, 0x04, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x0C, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x30, 0x0F, 0x00,
  0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x41, 0x00, 0x41, 0x80, 0x40, 0x80, 0x40, 0x40, 0xC0, 0x20, 0xC0, 0x10,
  0xC0, 0x08, 0xC0, 0x08, 0xC0, 0x04, 0xC0, 0x02, 0xE0, 0x01, 0x88, 0x00,
  0x84, 0x00, 0x41, 0x00, 0x40, 0x80, 0x20, 0x20, 0x10, 0x18, 0x08, 0x04,
  0x04, 0x03, 0x02, 0x00, 0x82, 0x00, 0x61, 0x00, 0x10, 0x02, 0x0C, 0x10,
  0x20, 0x40, 0x81, 0x06, 0x08, 0x10, 0x20, 0x40, 0x83, 0x04, 0x08, 0x10,
  0x20, 0x41, 0x82, 0x04, 0x08, 0x10, 0x20, 0xC1, 0x02, 0x04, 0x08, 0x10,
  0x60, 0x08, 0x7C, 0x07, 0xC1, 0x98, 0x61, 0x82, 0x12, 0x02, 0x30, 0x11,
  0x40, 0x14, 0x01, 0x14, 0x01, 0xC0, 0x11, 0x80, 0x18, 0x01, 0x10, 0x01,
  0x00, 0x13, 0x00, 0x10, 0x01, 0x20, 0x01, 0x00, 0x12, 0x00, 0x20, 0x01,
  0x20, 0x02, 0x00, 0x12, 0x00, 0x20, 0x02, 0x20, 0x02, 0x00, 0x26, 0x00,
  0x20, 0x02, 0x40, 0x02, 0x00, 0x24, 0x00, 0x40, 0x02, 0x40, 0x04, 0x00,
  0x64, 0x00, 0x40, 0x04, 0x40, 0x04, 0x00, 0x48, 0x00, 0x40, 0x04, 0x80,
  0x04, 0x00, 0x48, 0x00, 0x80, 0x04, 0x08, 0x7C, 0x09, 0x86, 0x1B, 0x03,
  0x16, 0x01, 0x14, 0x01, 0x18, 0x01, 0x18, 0x01, 0x10, 0x01, 0x30, 0x01,
  0x20, 0x01, 0x20, 0x02, 0x20, 0x02, 0x20, 0x02, 0x20, 0x02, 0x60, 0x02,
  0x40, 0x06, 0x40, 0x04, 0x40, 0x04, 0x40, 0x04, 0x40, 0x04, 0x80, 0x04,
  0x80, 0x0C, 0x03, 0xF0, 0x06, 0x0C, 0x08, 0x06, 0x10, 0x02, 0x20, 0x02,
  0x20, 0x03, 0x40, 0x01, 0x40, 0x01, 0x40, 0x03, 0x80, 0x02, 0x80, 0x02,
  0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x04, 0x80, 0x04, 0x80, 0x0C,
  0x80, 0x08, 0x80, 0x18, 0x40, 0x30, 0x30, 0xE0, 0x1F, 0x80, 0x04, 0x7E,
  0x01, 0x30, 0xC0, 0xF0, 0x18, 0x38, 0x02, 0x0C, 0x00, 0x82, 0x00, 0x30,
  0x80, 0x04, 0x20, 0x03, 0x18, 0x00, 0xC4, 0x00, 0x21, 0x00, 0x08, 0x40,
  0x02, 0x10, 0x00, 0x84, 0x00, 0x23, 0x00, 0x10, 0x80, 0x04, 0x20, 0x01,
  0x08, 0x00, 0x83, 0x00, 0x60, 0xC0, 0x30, 0x4C, 0x18, 0x10, 0xF8, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x00, 0x03, 0xE1, 0x0C, 0x19,
  0x18, 0x05, 0x10, 0x05, 0x20, 0x02, 0x20, 0x02, 0x40, 0x02, 0x40, 0x02,
  0x40, 0x02, 0xC0, 0x02, 0x80, 0x04, 0x80, 0x04, 0x80, 0x04, 0x80, 0x04,
  0x80, 0x04, 0x80, 0x0C, 0x80, 0x08, 0x80, 0x08, 0x80, 0x18, 0x40, 0x28,
  0x60, 0xC8, 0x1F, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x08, 0xF0,
  0x90, 0x1A, 0x01, 0x40, 0x18, 0x01, 0x80, 0x10, 0x01, 0x00, 0x30, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x00, 0x03, 0xF0, 0x0C, 0x18, 0x60,
  0x10, 0x80, 0x12, 0x00, 0x24, 0x00, 0x48, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x80, 0x09, 0x00, 0x12, 0x00, 0x62, 0x01, 0x86, 0x0E, 0x03, 0xF0,
  0x00, 0x04, 0x02, 0x01, 0x01, 0x80, 0x80, 0x41, 0xFE, 0x10, 0x08, 0x0C,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x40, 0x20, 0x10, 0x08, 0x04, 0x06,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x18, 0x07, 0x80, 0x10, 0x01, 0x10,
  0x01, 0x30, 0x01, 0x20, 0x01, 0x20, 0x02, 0x20, 0x02, 0x20, 0x02, 0x20,
  0x02, 0x40, 0x02, 0x40, 0x06, 0x40, 0x04, 0x40, 0x04, 0x40, 0x04, 0xC0,
  0x04, 0x80, 0x0C, 0x80, 0x0C, 0x80, 0x08, 0x80, 0x18, 0xC0, 0x38, 0x40,
  0x68, 0x60, 0xC8, 0x1F, 0x10, 0x80, 0x07, 0x00, 0x0A, 0x00, 0x34, 0x00,
  0x48, 0x01, 0x88, 0x02, 0x10, 0x04, 0x20, 0x10, 0x40, 0x20, 0x80, 0x81,
  0x01, 0x01, 0x04, 0x02, 0x08, 0x04, 0x20, 0x08, 0x40, 0x11, 0x00, 0x22,
  0x00, 0x28, 0x00, 0x50, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x00, 0xC0,
  0x18, 0x03, 0x40, 0x18, 0x02, 0x40, 0x38, 0x06, 0x40, 0x28, 0x04, 0x40,
  0x28, 0x04, 0x40, 0x48, 0x08, 0x40, 0x48, 0x08, 0x40, 0x88, 0x18, 0x40,
  0x88, 0x10, 0x41, 0x88, 0x30, 0x41, 0x0C, 0x20, 0x43, 0x04, 0x20, 0x42,
  0x04, 0x60, 0x62, 0x04, 0x40, 0x64, 0x04, 0xC0, 0x64, 0x04, 0x80, 0x28,
  0x04, 0x80, 0x28, 0x05, 0x00, 0x38, 0x05, 0x00, 0x30, 0x05, 0x00, 0x30,
  0x06, 0x00, 0x20, 0x06, 0x00, 0x0C, 0x00, 0x41, 0x00, 0x20, 0x60, 0x10,
  0x08, 0x0C, 0x02, 0x02, 0x00, 0x41, 0x00, 0x10, 0x80, 0x06, 0x60, 0x00,
  0x90, 0x00, 0x38, 0x00, 0x04, 0x00, 0x03, 0x00, 0x01, 0xA0, 0x00, 0x48,
  0x00, 0x21, 0x00, 0x18, 0x40, 0x0C, 0x18, 0x02, 0x02, 0x01, 0x00, 0xC0,
  0xC0, 0x10, 0x60, 0x04, 0x10, 0x00, 0x80, 0x04, 0x00, 0x10, 0x40, 0x02,
  0x04, 0x00, 0x20, 0x40, 0x04, 0x06, 0x00, 0x40, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x10, 0x02, 0x01, 0x00, 0x20, 0x20, 0x03, 0x02, 0x00, 0x10,
  0x40, 0x01, 0x04, 0x00, 0x10, 0x80, 0x01, 0x08, 0x00, 0x11, 0x80, 0x01,
  0x10, 0x00, 0x0B, 0x00, 0x00, 0xA0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x18,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x30,
  0x03, 0x00, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x04, 0x08, 0x10, 0x20, 0x41, 0x83, 0x04, 0x08, 0x10, 0x20,
  0x41, 0x82, 0x04, 0x08, 0x10, 0x20, 0xC1, 0x82, 0x04, 0x08, 0x10, 0x20,
  0xC1, 0x02, 0x04, 0x08, 0x10, 0x60, 0xC1, 0x02, 0x04, 0x00, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x60, 0x02, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00,
  0x20, 0x02, 0x00, 0x60, 0x06, 0x00, 0x00, 0x1E, 0x00, 0x24, 0x20, 0x09,
  0x02, 0x01, 0x20, 0x20, 0x28, 0x06, 0x09, 0x00, 0x63, 0x20, 0x07, 0x80,
};

const GFXglyph RobotoCondensed_ThinItalic42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 6, 30, 8, 1, -30 },
  { 24, 6, 8, 11, 5, -32 },
  { 30, 21, 30, 20, 1, -30 },
  { 109, 17, 38, 20, 2, -34 },
  { 190, 20, 30, 27, 4, -30 },
  { 265, 19, 30, 22, 1, -30 },
  { 337, 3, 8, 7, 4, -32 },
  { 340, 11, 43, 11, 2, -33 },
  { 400, 11, 43, 11, -2, -33 },
  { 460, 17, 16, 17, 2, -30 },
  { 494, 17, 21, 20, 2, -24 },
  { 539, 4, 8, 8, -1, -3 },
  { 543, 8, 1, 11, 2, -14 },
  { 544, 2, 2, 9, 1, -2 },
  { 545, 17, 33, 14, -2, -30 },
  { 616, 17, 30, 20, 2, -30 },
  { 680, 9, 30, 20, 6, -30 },
  { 714, 17, 30, 20, 1, -30 },
  { 778, 18, 30, 20, 1, -30 },
  { 846, 17, 30, 20, 1, -30 },
  { 910, 17, 30, 20, 3, -30 },
  { 974, 15, 30, 20, 2, -30 },
  { 1031, 16, 30, 20, 4, -30 },
  { 1091, 18, 30, 20, 1, -30 },
  { 1159, 15, 30, 20, 3, -30 },
  { 1216, 6, 22, 7, 0, -22 },
  { 1233, 7, 27, 7, -1, -22 },
  { 1257, 16, 17, 19, 2, -22 },
  { 1291, 16, 9, 20, 2, -18 },
  { 1309, 16, 17, 19, 1, -22 },
  { 1343, 12, 30, 16, 4, -30 },
  { 1388, 30, 38, 33, 1, -29 },
  { 1531, 20, 30, 22, -1, -30 },
  { 1606, 18, 30, 22, 2, -30 },
  { 1674, 20, 30, 23, 2, -30 },
  { 1749, 20, 30, 23, 2, -30 },
  { 1824, 20, 30, 20, 2, -30 },
  { 1899, 20, 30, 21, 2, -30 },
  { 1974, 20, 30, 25, 3, -30 },
  { 2049, 22, 30, 25, 2, -30 },
  { 2132, 6, 30, 10, 2, -30 },
  { 2155, 18, 30, 20, 1, -30 },
  { 2223, 21, 30, 23, 2, -30 },
  { 2302, 13, 30, 19, 2, -30 },
  { 2351, 28, 30, 30, 2, -30 },
  { 2456, 23, 30, 25, 2, -30 },
  { 2543, 21, 30, 24, 2, -30 },
  { 2622, 19, 30, 22, 2, -30 },
  { 2694, 21, 35, 24, 2, -30 },
  { 2786, 20, 30, 23, 2, -30 },
  { 2861, 20, 30, 21, 1, -30 },
  { 2936, 19, 30, 21, 4, -30 },
  { 3008, 21, 30, 24, 2, -30 },
  { 3087, 19, 30, 22, 4, -30 },
  { 3159, 29, 30, 32, 4, -30 },
  { 3268, 24, 30, 21, -1, -30 },
  { 3358, 19, 30, 21, 4, -30 },
  { 3430, 22, 30, 21, 0, -30 },
  { 3513, 12, 40, 8, 0, -34 },
  { 3573, 6, 33, 14, 4, -30 },
  { 3598, 12, 40, 8, -3, -34 },
  { 3658, 11, 15, 15, 2, -30 },
  { 3679, 15, 1, 15, -2, 0 },
  { 3681, 4, 5, 11, 6, -31 },
  { 3684, 17, 22, 19, 0, -22 },
  { 3731, 17, 32, 20, 1, -32 },
  { 3799, 16, 22, 18, 1, -22 },
  { 3843, 18, 32, 20, 2, -32 },
  { 3915, 16, 22, 18, 1, -22 },
  { 3959, 12, 32, 12, 3, -32 },
  { 4007, 18, 31, 20, 0, -22 },
  { 4077, 16, 32, 20, 1, -32 },
  { 4141, 7, 30, 8, 1, -30 },
  { 4168, 14, 39, 8, -6, -30 },
  { 4237, 17, 32, 17, 1, -32 },
  { 4305, 7, 32, 8, 1, -32 },
  { 4333, 28, 22, 32, 1, -22 },
  { 4410, 16, 22, 20, 1, -22 },
  { 4454, 16, 22, 20, 2, -22 },
  { 4498, 18, 31, 20, 0, -22 },
  { 4568, 16, 31, 20, 2, -22 },
  { 4630, 12, 22, 12, 1, -22 },
  { 4663, 15, 22, 18, 1, -22 },
  { 4705, 9, 28, 12, 2, -28 },
  { 4737, 16, 22, 20, 2, -22 },
  { 4781, 15, 22, 17, 3, -22 },
  { 4823, 24, 22, 27, 3, -22 },
  { 4889, 18, 22, 17, -1, -22 },
  { 4939, 20, 31, 17, -2, -22 },
  { 5017, 17, 22, 17, 0, -22 },
  { 5064, 14, 42, 12, 1, -33 },
  { 5138, 7, 36, 8, 1, -30 },
  { 5170, 13, 42, 12, -3, -33 },
  { 5239, 19, 7, 25, 3, -16 },
};

const GFXfont RobotoCondensed_ThinItalic42pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ThinItalic42pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ThinItalic42pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _ROBOTOCONDENSED_THINITALIC42PT7B_H_
