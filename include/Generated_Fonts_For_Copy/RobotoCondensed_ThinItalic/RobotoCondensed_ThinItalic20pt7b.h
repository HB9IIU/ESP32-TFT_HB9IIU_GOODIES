#ifndef _ROBOTOCONDENSED_THINITALIC20PT7B_H_
#define _ROBOTOCONDENSED_THINITALIC20PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ThinItalic.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ThinItalic20pt7bBitmaps[] PROGMEM = {
  0x00, 0x24, 0x92, 0x4A, 0x48, 0x01, 0x00, 0x76, 0xD0, 0x04, 0x41, 0x20,
  0x48, 0x7B, 0x09, 0x02, 0x41, 0x10, 0x48, 0x12, 0x08, 0x87, 0xD8, 0x90,
  0x44, 0x12, 0x00, 0x04, 0x04, 0x1A, 0x21, 0x41, 0x41, 0x40, 0x40, 0x30,
  0x0C, 0x02, 0x02, 0x82, 0x82, 0x84, 0x78, 0x20, 0x20, 0x70, 0x44, 0x22,
  0x51, 0x29, 0x24, 0xA3, 0xA0, 0x17, 0x14, 0x92, 0x52, 0x29, 0x10, 0x88,
  0x38, 0x1C, 0x22, 0x22, 0x22, 0x24, 0x28, 0x30, 0x50, 0x89, 0x85, 0x85,
  0x82, 0x86, 0x79, 0xF0, 0x08, 0x44, 0x42, 0x21, 0x08, 0x84, 0x21, 0x08,
  0x42, 0x10, 0x84, 0x20, 0x84, 0x00, 0x10, 0x82, 0x10, 0x84, 0x21, 0x08,
  0x42, 0x10, 0x84, 0x42, 0x21, 0x10, 0x88, 0x00, 0x08, 0x08, 0x08, 0x76,
  0x18, 0x28, 0x44, 0x44, 0x08, 0x08, 0x08, 0x08, 0x7E, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x29, 0x40, 0xF0, 0xC0, 0x01, 0x01, 0x02, 0x02, 0x04, 0x04,
  0x08, 0x08, 0x10, 0x10, 0x20, 0x20, 0x40, 0x40, 0x80, 0x1E, 0x21, 0x41,
  0x41, 0x41, 0x81, 0x81, 0x81, 0x82, 0x82, 0x82, 0x84, 0x84, 0x78, 0x3D,
  0x11, 0x22, 0x22, 0x22, 0x44, 0x44, 0x0F, 0x08, 0x48, 0x24, 0x10, 0x08,
  0x08, 0x08, 0x04, 0x04, 0x04, 0x04, 0x04, 0x04, 0x03, 0xF8, 0x1E, 0x21,
  0x41, 0x41, 0x01, 0x02, 0x1C, 0x04, 0x02, 0x02, 0x82, 0x82, 0x84, 0x78,
  0x01, 0x01, 0x80, 0xC0, 0xA0, 0x90, 0x88, 0x44, 0x44, 0x42, 0x3F, 0x80,
  0x80, 0x40, 0x40, 0x20, 0x3F, 0x10, 0x08, 0x04, 0x04, 0x03, 0xE1, 0x08,
  0x04, 0x01, 0x01, 0x20, 0x90, 0x44, 0x41, 0xC0, 0x0E, 0x20, 0x82, 0x04,
  0x0F, 0x90, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x4F, 0x00, 0xFE, 0x02, 0x02,
  0x04, 0x04, 0x08, 0x08, 0x10, 0x20, 0x20, 0x40, 0x40, 0x80, 0x80, 0x0F,
  0x08, 0x48, 0x24, 0x12, 0x09, 0x08, 0x78, 0x44, 0x41, 0x20, 0xA0, 0x50,
  0x24, 0x21, 0xE0, 0x1E, 0x21, 0x41, 0x41, 0x81, 0x81, 0x82, 0x45, 0x3A,
  0x02, 0x02, 0x04, 0x08, 0x70, 0x20, 0x00, 0x00, 0x10, 0x10, 0x00, 0x00,
  0x00, 0x24, 0x48, 0x02, 0x39, 0x84, 0x06, 0x03, 0x01, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFE, 0x40, 0x60, 0x30, 0x11, 0xCC, 0x20, 0x00, 0x7A, 0x18,
  0x41, 0x08, 0x21, 0x08, 0x41, 0x00, 0x00, 0x02, 0x00, 0x07, 0xE0, 0x20,
  0x41, 0x00, 0x88, 0x02, 0x43, 0x85, 0x11, 0x14, 0x84, 0x62, 0x21, 0x88,
  0x86, 0x42, 0x29, 0x08, 0xA4, 0x42, 0x91, 0x12, 0x3B, 0x88, 0x00, 0x20,
  0x00, 0x40, 0x00, 0xF8, 0x00, 0x01, 0x00, 0xC0, 0x30, 0x12, 0x04, 0x82,
  0x20, 0x88, 0x42, 0x10, 0x8B, 0xE2, 0x05, 0x01, 0x40, 0x60, 0x10, 0x3E,
  0x10, 0x88, 0x28, 0x14, 0x0A, 0x09, 0xF8, 0x84, 0x81, 0x40, 0xA0, 0x50,
  0x28, 0x27, 0xE0, 0x0F, 0x0C, 0x22, 0x09, 0x01, 0x40, 0x50, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x28, 0x12, 0x04, 0x42, 0x0F, 0x00, 0x3F, 0x10, 0x48,
  0x28, 0x14, 0x0A, 0x05, 0x02, 0x81, 0x80, 0xC0, 0x60, 0x50, 0x28, 0x27,
  0xE0, 0x3F, 0x10, 0x08, 0x08, 0x04, 0x02, 0x01, 0xF0, 0x80, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x07, 0xF0, 0x3F, 0x10, 0x08, 0x08, 0x04, 0x02, 0x01,
  0xF8, 0x80, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x00, 0x0F, 0x04, 0x22,
  0x05, 0x01, 0x40, 0x10, 0x04, 0x02, 0x1E, 0x80, 0xA0, 0x28, 0x0A, 0x02,
  0x41, 0x0F, 0x80, 0x20, 0x24, 0x04, 0x81, 0x20, 0x24, 0x04, 0x80, 0x9F,
  0xD2, 0x02, 0x80, 0x90, 0x12, 0x02, 0x40, 0x48, 0x09, 0x02, 0x00, 0x24,
  0x94, 0x92, 0x4A, 0x49, 0x00, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x08,
  0x04, 0x02, 0x01, 0x00, 0xA0, 0x90, 0x44, 0x41, 0xC0, 0x20, 0x48, 0x22,
  0x11, 0x08, 0x44, 0x12, 0x05, 0x01, 0xA0, 0x88, 0x21, 0x08, 0x42, 0x08,
  0x82, 0x20, 0x40, 0x20, 0x82, 0x10, 0x41, 0x04, 0x10, 0x82, 0x08, 0x20,
  0x83, 0xF0, 0x20, 0x09, 0x00, 0x48, 0x06, 0xA0, 0x55, 0x02, 0xA8, 0x29,
  0x41, 0x49, 0x12, 0x88, 0x94, 0x48, 0xA2, 0x45, 0x14, 0x48, 0xC2, 0x42,
  0x10, 0x20, 0x24, 0x04, 0xC1, 0x28, 0x24, 0x84, 0x90, 0x91, 0x12, 0x22,
  0x84, 0x90, 0x52, 0x0A, 0x40, 0xC8, 0x19, 0x02, 0x00, 0x0F, 0x0C, 0x22,
  0x05, 0x01, 0x40, 0x50, 0x18, 0x06, 0x02, 0x80, 0xA0, 0x28, 0x0A, 0x04,
  0x42, 0x0F, 0x00, 0x3F, 0x10, 0x48, 0x28, 0x14, 0x0A, 0x05, 0x04, 0xFC,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x00, 0x0F, 0x0C, 0x22, 0x05, 0x01,
  0x40, 0x50, 0x18, 0x06, 0x02, 0x80, 0xA0, 0x28, 0x0A, 0x04, 0x42, 0x0F,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x3F, 0x10, 0x50, 0x28, 0x14, 0x0A, 0x05,
  0x05, 0x7C, 0x84, 0x41, 0x20, 0x90, 0x48, 0x10, 0x08, 0x0F, 0x84, 0x12,
  0x04, 0x81, 0x20, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x28, 0x0A, 0x02,
  0x41, 0x0F, 0x80, 0x7F, 0x04, 0x02, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x20, 0x48, 0x14, 0x05, 0x01,
  0x40, 0x50, 0x24, 0x09, 0x02, 0x80, 0xA0, 0x28, 0x12, 0x04, 0x42, 0x0F,
  0x00, 0x80, 0xC0, 0x60, 0x50, 0x28, 0x24, 0x11, 0x10, 0x88, 0x48, 0x24,
  0x14, 0x0A, 0x06, 0x01, 0x00, 0x82, 0x06, 0x08, 0x18, 0x50, 0xA1, 0x42,
  0x85, 0x12, 0x24, 0x48, 0x91, 0x24, 0x48, 0x91, 0x22, 0x85, 0x0A, 0x14,
  0x28, 0x30, 0x40, 0x81, 0x02, 0x00, 0x20, 0x04, 0x08, 0x42, 0x08, 0x80,
  0x90, 0x14, 0x01, 0x00, 0x20, 0x0A, 0x02, 0x40, 0x88, 0x20, 0x84, 0x11,
  0x01, 0x00, 0x80, 0xC0, 0xA0, 0x48, 0x44, 0x42, 0x20, 0xA0, 0x60, 0x10,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x0F, 0xC0, 0x10, 0x08, 0x04, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x08, 0x04, 0x02, 0x01, 0x00, 0x40, 0x3F, 0xC0,
  0x1C, 0x41, 0x08, 0x20, 0x82, 0x08, 0x21, 0x04, 0x10, 0x41, 0x04, 0x10,
  0x82, 0x0E, 0x00, 0x92, 0x48, 0x92, 0x49, 0x12, 0x48, 0x18, 0x42, 0x10,
  0x88, 0x42, 0x10, 0x84, 0x42, 0x10, 0x84, 0x21, 0x30, 0x10, 0x8A, 0x54,
  0xA6, 0x20, 0xFE, 0xA4, 0x1E, 0x21, 0x41, 0x01, 0x01, 0x3E, 0x42, 0x82,
  0x82, 0x86, 0x7A, 0x20, 0x41, 0x02, 0x05, 0xCC, 0x50, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0xBE, 0x00, 0x3C, 0x86, 0x0C, 0x18, 0x10, 0x20, 0x40,
  0x85, 0x09, 0xE0, 0x01, 0x01, 0x01, 0x01, 0x3D, 0x42, 0x42, 0x82, 0x82,
  0x82, 0x82, 0x82, 0x84, 0x84, 0x7C, 0x3C, 0x86, 0x0C, 0x1F, 0xF0, 0x20,
  0x40, 0x81, 0x09, 0xE0, 0x0C, 0x42, 0x08, 0xF8, 0x84, 0x10, 0x41, 0x04,
  0x10, 0x82, 0x08, 0x00, 0x1E, 0x90, 0x88, 0x48, 0x24, 0x12, 0x09, 0x04,
  0x82, 0x42, 0x21, 0x0F, 0x80, 0x40, 0x24, 0x21, 0xE0, 0x20, 0x41, 0x02,
  0x05, 0xCC, 0x50, 0xA1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0xA1, 0x00, 0x20,
  0x04, 0x92, 0x92, 0x49, 0x20, 0x02, 0x00, 0x00, 0x00, 0x40, 0x81, 0x02,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x04, 0x08, 0x10, 0x23, 0x80, 0x20, 0x41,
  0x02, 0x04, 0x28, 0x92, 0x28, 0xA1, 0xC2, 0x44, 0x88, 0x91, 0x21, 0x00,
  0x24, 0xA4, 0x92, 0x52, 0x49, 0x20, 0x2E, 0x38, 0xC5, 0x12, 0x08, 0x50,
  0x41, 0x41, 0x05, 0x04, 0x14, 0x10, 0x50, 0x41, 0x42, 0x0A, 0x08, 0x28,
  0x20, 0x80, 0x5C, 0xC5, 0x0A, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x0A, 0x10,
  0x3C, 0x85, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x09, 0xE0, 0x2E, 0x31,
  0x21, 0x41, 0x41, 0x41, 0x41, 0x41, 0x41, 0x42, 0xBC, 0x80, 0x80, 0x80,
  0x80, 0x3D, 0x42, 0x42, 0x82, 0x82, 0x82, 0x82, 0x82, 0x84, 0x84, 0x7C,
  0x04, 0x04, 0x04, 0x08, 0x53, 0x10, 0x88, 0x42, 0x10, 0x84, 0x20, 0x1E,
  0x21, 0x41, 0x40, 0x30, 0x0C, 0x02, 0x02, 0x82, 0x84, 0x78, 0x22, 0xF4,
  0x44, 0x44, 0x48, 0x88, 0x60, 0x41, 0x41, 0x42, 0x82, 0x82, 0x82, 0x82,
  0x82, 0x84, 0x84, 0x7C, 0x81, 0x06, 0x0A, 0x24, 0x49, 0x12, 0x28, 0x50,
  0xC0, 0x80, 0x80, 0x31, 0x8A, 0x31, 0x4A, 0x29, 0x49, 0x49, 0x29, 0x45,
  0x28, 0xC5, 0x10, 0x42, 0x08, 0x00, 0x21, 0x22, 0x22, 0x14, 0x18, 0x08,
  0x18, 0x28, 0x44, 0x44, 0x82, 0x20, 0x08, 0x22, 0x08, 0x44, 0x11, 0x04,
  0x81, 0x20, 0x50, 0x14, 0x02, 0x00, 0x80, 0x40, 0x10, 0x08, 0x0C, 0x00,
  0x3F, 0x02, 0x02, 0x04, 0x08, 0x10, 0x10, 0x20, 0x40, 0x80, 0xFE, 0x04,
  0x21, 0x04, 0x20, 0x82, 0x08, 0x42, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x08, 0x11, 0x22, 0x22, 0x22, 0x44, 0x44, 0x44, 0x48, 0x80, 0x10,
  0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x10, 0x84, 0x10, 0x42, 0x08, 0x20,
  0x84, 0x20, 0x70, 0x44, 0x61, 0xC0,
};

const GFXglyph RobotoCondensed_ThinItalic20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 3, 14, 4, 0, -14 },
  { 7, 3, 4, 5, 2, -15 },
  { 9, 10, 14, 9, 0, -14 },
  { 27, 8, 18, 9, 1, -16 },
  { 45, 9, 14, 13, 2, -14 },
  { 61, 8, 14, 10, 1, -14 },
  { 75, 1, 4, 3, 2, -15 },
  { 76, 5, 21, 5, 1, -16 },
  { 90, 5, 21, 5, -1, -16 },
  { 104, 8, 8, 8, 1, -14 },
  { 112, 8, 10, 10, 1, -11 },
  { 122, 3, 4, 4, -1, -2 },
  { 124, 4, 1, 5, 1, -7 },
  { 125, 2, 1, 4, 0, -1 },
  { 126, 8, 15, 7, -1, -14 },
  { 141, 8, 14, 9, 1, -14 },
  { 155, 4, 14, 9, 3, -14 },
  { 162, 9, 14, 9, 0, -14 },
  { 178, 8, 14, 9, 1, -14 },
  { 192, 9, 14, 9, 0, -14 },
  { 208, 9, 14, 9, 1, -14 },
  { 224, 7, 14, 9, 1, -14 },
  { 237, 8, 14, 9, 2, -14 },
  { 251, 9, 14, 9, 0, -14 },
  { 267, 8, 14, 9, 1, -14 },
  { 281, 3, 10, 3, 0, -10 },
  { 285, 4, 12, 3, -1, -10 },
  { 291, 7, 7, 9, 1, -10 },
  { 298, 8, 5, 10, 1, -9 },
  { 303, 7, 7, 9, 1, -10 },
  { 310, 6, 14, 8, 2, -14 },
  { 321, 14, 18, 16, 1, -14 },
  { 353, 10, 14, 10, -1, -14 },
  { 371, 9, 14, 10, 1, -14 },
  { 387, 10, 14, 11, 1, -14 },
  { 405, 9, 14, 11, 1, -14 },
  { 421, 9, 14, 10, 1, -14 },
  { 437, 9, 14, 10, 1, -14 },
  { 453, 10, 14, 12, 1, -14 },
  { 471, 11, 14, 12, 1, -14 },
  { 491, 3, 14, 5, 1, -14 },
  { 497, 9, 14, 9, 0, -14 },
  { 513, 10, 14, 11, 1, -14 },
  { 531, 6, 14, 9, 1, -14 },
  { 542, 13, 14, 15, 1, -14 },
  { 565, 11, 14, 12, 1, -14 },
  { 585, 10, 14, 11, 1, -14 },
  { 603, 9, 14, 10, 1, -14 },
  { 619, 10, 17, 11, 1, -14 },
  { 641, 9, 14, 11, 1, -14 },
  { 657, 10, 14, 10, 0, -14 },
  { 675, 9, 14, 10, 2, -14 },
  { 691, 10, 14, 11, 1, -14 },
  { 709, 9, 14, 10, 2, -14 },
  { 725, 14, 14, 15, 2, -14 },
  { 750, 11, 14, 10, 0, -14 },
  { 770, 9, 14, 10, 2, -14 },
  { 786, 10, 14, 10, 0, -14 },
  { 804, 6, 19, 4, 0, -16 },
  { 819, 3, 15, 7, 2, -14 },
  { 825, 5, 19, 4, -1, -16 },
  { 837, 5, 7, 7, 1, -14 },
  { 842, 7, 1, 7, -1, 0 },
  { 843, 2, 3, 5, 3, -15 },
  { 844, 8, 11, 9, 0, -11 },
  { 855, 7, 15, 9, 1, -15 },
  { 869, 7, 11, 9, 1, -11 },
  { 879, 8, 15, 9, 1, -15 },
  { 894, 7, 11, 9, 1, -11 },
  { 904, 6, 15, 6, 1, -15 },
  { 916, 9, 15, 9, 0, -11 },
  { 933, 7, 15, 9, 1, -15 },
  { 947, 3, 15, 4, 1, -15 },
  { 953, 7, 19, 4, -3, -15 },
  { 970, 7, 15, 8, 1, -15 },
  { 984, 3, 15, 4, 1, -15 },
  { 990, 14, 11, 15, 0, -11 },
  { 1010, 7, 11, 9, 1, -11 },
  { 1020, 7, 11, 9, 1, -11 },
  { 1030, 8, 15, 9, 0, -11 },
  { 1045, 8, 15, 9, 1, -11 },
  { 1060, 5, 11, 6, 1, -11 },
  { 1067, 8, 11, 9, 0, -11 },
  { 1078, 4, 13, 6, 1, -13 },
  { 1085, 8, 11, 9, 1, -11 },
  { 1096, 7, 11, 8, 1, -11 },
  { 1106, 11, 11, 13, 2, -11 },
  { 1122, 8, 11, 8, 0, -11 },
  { 1133, 10, 15, 8, -1, -11 },
  { 1152, 8, 11, 8, 0, -11 },
  { 1163, 6, 20, 6, 1, -16 },
  { 1178, 4, 17, 4, 0, -14 },
  { 1187, 6, 20, 6, -1, -16 },
  { 1202, 9, 3, 12, 1, -7 },
};

const GFXfont RobotoCondensed_ThinItalic20pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ThinItalic20pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ThinItalic20pt7bGlyphs,
  0x20, 0x7E, 23
};

#endif // _ROBOTOCONDENSED_THINITALIC20PT7B_H_
