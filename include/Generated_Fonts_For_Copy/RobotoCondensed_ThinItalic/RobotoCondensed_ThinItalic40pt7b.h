#ifndef _ROBOTOCONDENSED_THINITALIC40PT7B_H_
#define _ROBOTOCONDENSED_THINITALIC40PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ThinItalic.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ThinItalic40pt7bBitmaps[] PROGMEM = {
  0x00, 0x04, 0x10, 0xC2, 0x08, 0x20, 0x82, 0x10, 0x41, 0x04, 0x10, 0x42,
  0x08, 0x20, 0x82, 0x10, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x30, 0x22, 0x4D,
  0x92, 0x24, 0x48, 0x91, 0x64, 0x00, 0x20, 0x40, 0x02, 0x04, 0x00, 0x20,
  0x80, 0x04, 0x08, 0x00, 0x40, 0x80, 0x04, 0x10, 0x00, 0x81, 0x00, 0x08,
  0x10, 0x1F, 0xFF, 0xF0, 0x10, 0x20, 0x01, 0x02, 0x00, 0x10, 0x60, 0x02,
  0x04, 0x00, 0x20, 0x40, 0x02, 0x04, 0x00, 0x40, 0x80, 0x04, 0x08, 0x00,
  0x40, 0x80, 0x08, 0x10, 0x0F, 0xFF, 0xF0, 0x08, 0x10, 0x01, 0x82, 0x00,
  0x10, 0x20, 0x01, 0x02, 0x00, 0x10, 0x40, 0x02, 0x04, 0x00, 0x20, 0x40,
  0x02, 0x08, 0x00, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x0F, 0xC0, 0x0C, 0x30, 0x08, 0x04, 0x08, 0x02, 0x08, 0x00, 0x84, 0x00,
  0x42, 0x00, 0x21, 0x00, 0x11, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x04, 0x40, 0x02, 0x20, 0x01, 0x10, 0x01,
  0x08, 0x00, 0x84, 0x00, 0xC1, 0x00, 0xC0, 0x40, 0xC0, 0x1F, 0x80, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x1E, 0x00, 0x0C, 0x40,
  0x06, 0x08, 0x01, 0x02, 0x00, 0x80, 0x81, 0xA0, 0x20, 0x48, 0x08, 0x22,
  0x02, 0x10, 0x81, 0x0C, 0x20, 0x42, 0x08, 0x21, 0x01, 0x18, 0x80, 0x7C,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x06, 0x1E, 0x01, 0x18, 0xC0, 0x84,
  0x10, 0x42, 0x04, 0x30, 0x81, 0x08, 0x60, 0x44, 0x10, 0x12, 0x04, 0x04,
  0x81, 0x01, 0x40, 0x40, 0x80, 0x10, 0x20, 0x02, 0x30, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x61, 0x00, 0x30, 0x60, 0x08, 0x08, 0x06, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x40, 0x10, 0x10, 0x04, 0x08, 0x01, 0x04, 0x00, 0x26, 0x00,
  0x0B, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x48, 0x00, 0x23, 0x01, 0x10,
  0x40, 0xC8, 0x08, 0x24, 0x02, 0x09, 0x00, 0x46, 0x40, 0x19, 0x20, 0x02,
  0xC8, 0x00, 0xE3, 0x00, 0x10, 0x40, 0x0A, 0x18, 0x04, 0x83, 0x06, 0x10,
  0x3E, 0x06, 0x69, 0x24, 0xB4, 0x00, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x04, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x80, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0x20, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x08, 0x02, 0x00, 0x80, 0x20, 0x18,
  0x04, 0x01, 0x00, 0xC0, 0x20, 0x08, 0x04, 0x01, 0x00, 0x80, 0x20, 0x10,
  0x08, 0x06, 0x03, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x40, 0x87, 0x39, 0x98, 0x07, 0xE0, 0x01, 0x00,
  0x02, 0x80, 0x04, 0xC0, 0x08, 0x40, 0x10, 0x20, 0x30, 0x20, 0x60, 0x10,
  0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0xFF, 0xFF, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x11, 0x32, 0x26, 0x48, 0x7F, 0xF0,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x80, 0x00, 0x80, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x00, 0xF8, 0x03, 0x0C, 0x04, 0x06, 0x08, 0x02, 0x08, 0x02, 0x10, 0x03,
  0x10, 0x01, 0x20, 0x01, 0x20, 0x01, 0x20, 0x01, 0x40, 0x02, 0x40, 0x02,
  0x40, 0x02, 0x40, 0x02, 0x40, 0x02, 0x40, 0x02, 0x80, 0x04, 0x80, 0x04,
  0x80, 0x04, 0x80, 0x04, 0x80, 0x08, 0x80, 0x08, 0x80, 0x18, 0x80, 0x10,
  0x40, 0x20, 0x40, 0x60, 0x20, 0xC0, 0x1F, 0x00, 0x03, 0x0D, 0x72, 0x82,
  0x02, 0x02, 0x02, 0x02, 0x04, 0x04, 0x04, 0x04, 0x04, 0x04, 0x08, 0x08,
  0x08, 0x08, 0x08, 0x18, 0x10, 0x10, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20,
  0x00, 0xF8, 0x03, 0x06, 0x06, 0x02, 0x0C, 0x01, 0x08, 0x01, 0x10, 0x01,
  0x10, 0x01, 0x10, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x30, 0x00, 0x60, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x40, 0x00, 0xFF, 0xFC, 0x00, 0xFC, 0x00, 0xC3,
  0x01, 0x80, 0xC0, 0x80, 0x20, 0x80, 0x18, 0x40, 0x04, 0x40, 0x02, 0x20,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80,
  0x1F, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x48, 0x00, 0x24, 0x00, 0x12, 0x00, 0x10, 0x80, 0x08, 0x40,
  0x08, 0x10, 0x08, 0x0C, 0x18, 0x01, 0xF8, 0x00, 0x00, 0x03, 0x00, 0x07,
  0x00, 0x06, 0x00, 0x0A, 0x00, 0x12, 0x00, 0x32, 0x00, 0x22, 0x00, 0x46,
  0x00, 0x84, 0x01, 0x84, 0x01, 0x04, 0x02, 0x04, 0x04, 0x04, 0x0C, 0x08,
  0x08, 0x08, 0x10, 0x08, 0x30, 0x08, 0x60, 0x08, 0x40, 0x08, 0xFF, 0xFF,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x20, 0x03, 0xFF, 0x82, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x04, 0xF8, 0x03, 0x83, 0x01, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x84, 0x00,
  0x42, 0x00, 0x21, 0x00, 0x20, 0x80, 0x10, 0x40, 0x10, 0x10, 0x18, 0x0C,
  0x18, 0x01, 0xF0, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x00, 0x8F,
  0x82, 0x20, 0xC5, 0x80, 0x8C, 0x00, 0x98, 0x01, 0x20, 0x02, 0xC0, 0x05,
  0x00, 0x0A, 0x00, 0x14, 0x00, 0x28, 0x00, 0x50, 0x00, 0xA0, 0x02, 0x60,
  0x04, 0x40, 0x10, 0xC0, 0x40, 0xC1, 0x00, 0x7C, 0x00, 0xFF, 0xFE, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x40, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80,
  0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x04,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0xC3, 0x01, 0x80, 0x40, 0x80, 0x30, 0x80,
  0x08, 0x40, 0x04, 0x40, 0x02, 0x20, 0x01, 0x10, 0x01, 0x88, 0x00, 0x82,
  0x00, 0xC1, 0x00, 0xC0, 0x61, 0xC0, 0x1F, 0x80, 0x30, 0x60, 0x20, 0x08,
  0x20, 0x06, 0x20, 0x01, 0x10, 0x00, 0x98, 0x00, 0x48, 0x00, 0x24, 0x00,
  0x12, 0x00, 0x19, 0x00, 0x08, 0x40, 0x08, 0x30, 0x0C, 0x0C, 0x18, 0x01,
  0xF8, 0x00, 0x03, 0xE0, 0x18, 0x30, 0x60, 0x20, 0x80, 0x22, 0x00, 0x4C,
  0x00, 0x90, 0x01, 0xA0, 0x03, 0x80, 0x07, 0x00, 0x0A, 0x00, 0x14, 0x00,
  0x28, 0x00, 0x50, 0x01, 0xA0, 0x05, 0x20, 0x0C, 0x40, 0x28, 0x61, 0x90,
  0x7C, 0x20, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x06, 0x00, 0x38, 0x07, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0xC0, 0x06,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x41, 0x82, 0x04, 0x08, 0x20, 0xC1, 0x00, 0x00, 0x02,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x08, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x10, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x40,
  0x00, 0x0F, 0x82, 0x08, 0x80, 0xA0, 0x1C, 0x03, 0x00, 0x60, 0x08, 0x01,
  0x00, 0x20, 0x08, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x02, 0x00, 0x80, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x60, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xE0, 0x70, 0x00,
  0x30, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x80, 0x00, 0x40, 0x10, 0x00,
  0x02, 0x03, 0x00, 0x00, 0x20, 0x60, 0x00, 0x01, 0x04, 0x01, 0xE0, 0x10,
  0x80, 0x61, 0x01, 0x08, 0x08, 0x08, 0x11, 0x01, 0x01, 0x01, 0x10, 0x10,
  0x10, 0x13, 0x02, 0x01, 0x01, 0x20, 0x20, 0x10, 0x12, 0x04, 0x02, 0x01,
  0x60, 0x40, 0x20, 0x14, 0x0C, 0x02, 0x03, 0x40, 0x80, 0x20, 0x24, 0x08,
  0x04, 0x02, 0x40, 0x80, 0x40, 0x24, 0x08, 0x04, 0x04, 0x81, 0x00, 0xC0,
  0x48, 0x10, 0x0C, 0x0C, 0x80, 0x81, 0x40, 0x88, 0x08, 0x24, 0x10, 0xC0,
  0x84, 0x42, 0x04, 0x07, 0x83, 0xC0, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x30, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x28, 0x00, 0x05, 0x00,
  0x01, 0x20, 0x00, 0x24, 0x00, 0x08, 0x40, 0x01, 0x08, 0x00, 0x41, 0x00,
  0x08, 0x20, 0x02, 0x04, 0x00, 0x40, 0x80, 0x10, 0x10, 0x02, 0x01, 0x00,
  0xC0, 0x20, 0x10, 0x04, 0x06, 0x00, 0x80, 0x80, 0x10, 0x30, 0x02, 0x07,
  0xFF, 0xC0, 0x80, 0x0C, 0x20, 0x00, 0x84, 0x00, 0x11, 0x00, 0x02, 0x20,
  0x00, 0x48, 0x00, 0x09, 0x00, 0x01, 0x40, 0x00, 0x30, 0x0F, 0xFC, 0x04,
  0x03, 0x02, 0x00, 0x41, 0x00, 0x10, 0x80, 0x08, 0x80, 0x04, 0x40, 0x02,
  0x20, 0x01, 0x10, 0x00, 0x88, 0x00, 0x84, 0x00, 0xC4, 0x00, 0xC2, 0x00,
  0xC1, 0xFF, 0x80, 0x80, 0x30, 0x40, 0x0C, 0x20, 0x02, 0x20, 0x00, 0x90,
  0x00, 0x48, 0x00, 0x24, 0x00, 0x12, 0x00, 0x19, 0x00, 0x09, 0x00, 0x04,
  0x80, 0x04, 0x40, 0x04, 0x20, 0x0C, 0x1F, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x30, 0x30, 0x08, 0x03, 0x02, 0x00, 0x20, 0x80, 0x06, 0x30, 0x00, 0x44,
  0x00, 0x08, 0x80, 0x01, 0x20, 0x00, 0x24, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x48, 0x00, 0x09, 0x80,
  0x02, 0x10, 0x00, 0x42, 0x00, 0x10, 0x60, 0x06, 0x04, 0x01, 0x80, 0x60,
  0xE0, 0x07, 0xE0, 0x00, 0x0F, 0xFC, 0x01, 0x00, 0x60, 0x20, 0x06, 0x04,
  0x00, 0x40, 0x80, 0x04, 0x20, 0x00, 0x84, 0x00, 0x08, 0x80, 0x01, 0x10,
  0x00, 0x22, 0x00, 0x04, 0x40, 0x00, 0x90, 0x00, 0x22, 0x00, 0x04, 0x40,
  0x00, 0x88, 0x00, 0x11, 0x00, 0x02, 0x20, 0x00, 0x48, 0x00, 0x11, 0x00,
  0x02, 0x20, 0x00, 0x44, 0x00, 0x10, 0x80, 0x02, 0x30, 0x00, 0x84, 0x00,
  0x10, 0x80, 0x04, 0x10, 0x03, 0x02, 0x01, 0xC0, 0x7F, 0xC0, 0x00, 0x0F,
  0xFF, 0xE1, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x7F, 0xFC, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xE1, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x7F, 0xFC, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x70, 0x60, 0x18, 0x02, 0x06, 0x00, 0x20, 0x80,
  0x04, 0x20, 0x00, 0xCC, 0x00, 0x09, 0x00, 0x01, 0x20, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00,
  0x04, 0x03, 0xFC, 0x80, 0x00, 0x90, 0x00, 0x12, 0x00, 0x02, 0x40, 0x00,
  0xC8, 0x00, 0x11, 0x00, 0x02, 0x20, 0x00, 0x46, 0x00, 0x08, 0x40, 0x03,
  0x0C, 0x00, 0xC0, 0xC0, 0xE0, 0x07, 0xF0, 0x00, 0x08, 0x00, 0x08, 0x40,
  0x00, 0x42, 0x00, 0x02, 0x10, 0x00, 0x10, 0x80, 0x01, 0x08, 0x00, 0x08,
  0x40, 0x00, 0x42, 0x00, 0x02, 0x10, 0x00, 0x10, 0x80, 0x01, 0x84, 0x00,
  0x08, 0x40, 0x00, 0x42, 0x00, 0x02, 0x1F, 0xFF, 0xF0, 0x80, 0x00, 0x84,
  0x00, 0x08, 0x20, 0x00, 0x42, 0x00, 0x02, 0x10, 0x00, 0x10, 0x80, 0x00,
  0x84, 0x00, 0x04, 0x20, 0x00, 0x43, 0x00, 0x02, 0x10, 0x00, 0x10, 0x80,
  0x00, 0x84, 0x00, 0x04, 0x20, 0x00, 0x21, 0x00, 0x02, 0x00, 0x04, 0x10,
  0x42, 0x08, 0x20, 0x82, 0x08, 0x41, 0x04, 0x10, 0x43, 0x08, 0x20, 0x82,
  0x08, 0x41, 0x04, 0x10, 0x41, 0x08, 0x20, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x88, 0x00, 0xC4, 0x00, 0x42, 0x00, 0x21, 0x00, 0x20, 0x80, 0x10,
  0x20, 0x10, 0x18, 0x30, 0x03, 0xE0, 0x00, 0x08, 0x00, 0x30, 0x80, 0x06,
  0x08, 0x00, 0xC0, 0x80, 0x18, 0x08, 0x03, 0x01, 0x00, 0x60, 0x10, 0x0C,
  0x01, 0x01, 0x80, 0x10, 0x30, 0x01, 0x06, 0x00, 0x10, 0xC0, 0x02, 0x18,
  0x00, 0x23, 0x00, 0x02, 0x70, 0x00, 0x2D, 0x80, 0x03, 0x08, 0x00, 0x20,
  0x40, 0x04, 0x04, 0x00, 0x40, 0x20, 0x04, 0x02, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x80, 0xC0, 0x08, 0x08, 0x00, 0xC0, 0x80, 0x04, 0x08, 0x00, 0x20,
  0x80, 0x02, 0x08, 0x00, 0x10, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x03, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0xFF, 0xF0, 0x0C, 0x00, 0x00, 0x43, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x0C, 0x38, 0x00, 0x05, 0x0A, 0x00, 0x02, 0x44, 0x80, 0x00, 0xA1, 0x20,
  0x00, 0x48, 0x48, 0x00, 0x12, 0x12, 0x00, 0x08, 0x84, 0x40, 0x02, 0x21,
  0x10, 0x01, 0x18, 0x84, 0x00, 0x44, 0x21, 0x00, 0x21, 0x08, 0x40, 0x08,
  0x42, 0x08, 0x04, 0x10, 0x82, 0x03, 0x04, 0x20, 0x80, 0x82, 0x10, 0x20,
  0x60, 0x84, 0x08, 0x10, 0x21, 0x02, 0x08, 0x08, 0x40, 0x42, 0x02, 0x10,
  0x11, 0x00, 0x84, 0x04, 0x40, 0x42, 0x01, 0x20, 0x10, 0x80, 0x48, 0x04,
  0x20, 0x0C, 0x01, 0x08, 0x03, 0x00, 0x42, 0x00, 0x80, 0x30, 0x0C, 0x00,
  0x08, 0x60, 0x00, 0x43, 0x00, 0x02, 0x14, 0x00, 0x10, 0xA0, 0x00, 0x8C,
  0x80, 0x08, 0x44, 0x00, 0x42, 0x20, 0x02, 0x10, 0x80, 0x10, 0x84, 0x00,
  0x84, 0x10, 0x0C, 0x60, 0x80, 0x42, 0x04, 0x02, 0x10, 0x10, 0x10, 0x80,
  0x80, 0x84, 0x02, 0x04, 0x20, 0x10, 0x62, 0x00, 0x82, 0x10, 0x02, 0x10,
  0x80, 0x10, 0x84, 0x00, 0x44, 0x20, 0x02, 0x63, 0x00, 0x12, 0x10, 0x00,
  0x50, 0x80, 0x02, 0x84, 0x00, 0x0C, 0x20, 0x00, 0x61, 0x00, 0x03, 0x00,
  0x00, 0x7E, 0x00, 0x30, 0x30, 0x08, 0x03, 0x02, 0x00, 0x20, 0x80, 0x02,
  0x30, 0x00, 0x44, 0x00, 0x09, 0x80, 0x01, 0x20, 0x00, 0x24, 0x00, 0x04,
  0x80, 0x00, 0xB0, 0x00, 0x14, 0x00, 0x02, 0x80, 0x00, 0x50, 0x00, 0x12,
  0x00, 0x02, 0x40, 0x00, 0x50, 0x00, 0x0A, 0x00, 0x01, 0x40, 0x00, 0x48,
  0x00, 0x09, 0x00, 0x03, 0x30, 0x00, 0x42, 0x00, 0x18, 0x40, 0x06, 0x04,
  0x01, 0x80, 0x60, 0xE0, 0x07, 0xF0, 0x00, 0x0F, 0xFC, 0x02, 0x00, 0xC0,
  0x80, 0x08, 0x20, 0x03, 0x08, 0x00, 0x44, 0x00, 0x11, 0x00, 0x04, 0x40,
  0x01, 0x10, 0x00, 0x44, 0x00, 0x11, 0x00, 0x08, 0x80, 0x02, 0x20, 0x01,
  0x08, 0x00, 0x82, 0x00, 0xC0, 0xFF, 0xC0, 0x20, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x30, 0x30, 0x08, 0x03, 0x02, 0x00, 0x20, 0x80, 0x02, 0x30, 0x00,
  0x44, 0x00, 0x08, 0x80, 0x01, 0x20, 0x00, 0x24, 0x00, 0x04, 0x80, 0x00,
  0xB0, 0x00, 0x14, 0x00, 0x02, 0x80, 0x00, 0x50, 0x00, 0x12, 0x00, 0x02,
  0x40, 0x00, 0x58, 0x00, 0x0A, 0x00, 0x01, 0x40, 0x00, 0x48, 0x00, 0x09,
  0x00, 0x03, 0x30, 0x00, 0x42, 0x00, 0x10, 0x40, 0x06, 0x04, 0x01, 0x80,
  0x60, 0xE0, 0x07, 0xF8, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x07, 0xFF, 0x00, 0x40, 0x18, 0x04, 0x00,
  0x40, 0x40, 0x02, 0x04, 0x00, 0x20, 0x80, 0x02, 0x08, 0x00, 0x20, 0x80,
  0x02, 0x08, 0x00, 0x20, 0x80, 0x02, 0x08, 0x00, 0x41, 0x00, 0x04, 0x10,
  0x00, 0x81, 0x00, 0x10, 0x10, 0x06, 0x01, 0xFF, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x40, 0x20, 0x04, 0x02, 0x00, 0x60,
  0x40, 0x02, 0x04, 0x00, 0x20, 0x40, 0x03, 0x04, 0x00, 0x10, 0x40, 0x01,
  0x04, 0x00, 0x18, 0x00, 0x7E, 0x00, 0x30, 0x30, 0x08, 0x03, 0x02, 0x00,
  0x20, 0x80, 0x06, 0x10, 0x00, 0x44, 0x00, 0x08, 0x80, 0x01, 0x10, 0x00,
  0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x48, 0x00, 0x09, 0x00, 0x03, 0x20, 0x00, 0x46, 0x00, 0x08,
  0x40, 0x02, 0x0C, 0x00, 0x80, 0xE0, 0x60, 0x07, 0xF0, 0x00, 0xFF, 0xFF,
  0xC0, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x10, 0x80, 0x01, 0x08, 0x00, 0x10, 0x80, 0x01, 0x10,
  0x00, 0x21, 0x00, 0x02, 0x10, 0x00, 0x21, 0x00, 0x02, 0x10, 0x00, 0x22,
  0x00, 0x02, 0x20, 0x00, 0x42, 0x00, 0x04, 0x20, 0x00, 0x42, 0x00, 0x04,
  0x20, 0x00, 0x44, 0x00, 0x08, 0x40, 0x00, 0x84, 0x00, 0x08, 0x40, 0x00,
  0x84, 0x00, 0x08, 0x40, 0x00, 0x84, 0x00, 0x10, 0x40, 0x01, 0x04, 0x00,
  0x20, 0x40, 0x06, 0x02, 0x00, 0xC0, 0x18, 0x38, 0x00, 0xFE, 0x00, 0x40,
  0x00, 0x28, 0x00, 0x0D, 0x00, 0x01, 0x20, 0x00, 0x64, 0x00, 0x08, 0x80,
  0x03, 0x08, 0x00, 0x41, 0x00, 0x08, 0x20, 0x02, 0x04, 0x00, 0x40, 0x80,
  0x10, 0x10, 0x02, 0x03, 0x00, 0x80, 0x20, 0x10, 0x04, 0x04, 0x00, 0x80,
  0x80, 0x10, 0x20, 0x02, 0x04, 0x00, 0x41, 0x00, 0x04, 0x20, 0x00, 0x84,
  0x00, 0x11, 0x00, 0x02, 0x20, 0x00, 0x48, 0x00, 0x09, 0x00, 0x01, 0x40,
  0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x80, 0x04, 0x00, 0x38, 0x00, 0x60,
  0x02, 0x80, 0x0A, 0x00, 0x28, 0x00, 0xA0, 0x04, 0x80, 0x12, 0x00, 0x48,
  0x01, 0x20, 0x04, 0x80, 0x12, 0x00, 0x8C, 0x02, 0x20, 0x08, 0xC0, 0x22,
  0x01, 0x84, 0x04, 0x20, 0x10, 0x40, 0x42, 0x01, 0x04, 0x04, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x41, 0x01, 0x04, 0x04, 0x10,
  0x10, 0x40, 0x43, 0x01, 0x0C, 0x04, 0x20, 0x10, 0x80, 0x42, 0x01, 0x08,
  0x04, 0x40, 0x11, 0x00, 0x44, 0x01, 0x10, 0x04, 0xC0, 0x11, 0x00, 0x68,
  0x00, 0xA0, 0x06, 0x80, 0x0A, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x06, 0x00, 0x04, 0x04,
  0x00, 0x10, 0x08, 0x00, 0x60, 0x08, 0x00, 0x80, 0x10, 0x02, 0x00, 0x30,
  0x08, 0x00, 0x20, 0x30, 0x00, 0x40, 0x40, 0x00, 0x41, 0x00, 0x00, 0x84,
  0x00, 0x00, 0x88, 0x00, 0x01, 0x20, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x14, 0x00, 0x00, 0x48, 0x00, 0x01, 0x08, 0x00,
  0x06, 0x10, 0x00, 0x08, 0x10, 0x00, 0x20, 0x20, 0x00, 0x80, 0x60, 0x03,
  0x00, 0x40, 0x04, 0x00, 0x80, 0x10, 0x00, 0x80, 0x40, 0x01, 0x00, 0x80,
  0x01, 0x02, 0x00, 0x02, 0x00, 0x80, 0x00, 0x60, 0x00, 0x24, 0x00, 0x19,
  0x00, 0x04, 0x40, 0x02, 0x08, 0x01, 0x82, 0x00, 0x40, 0x80, 0x20, 0x10,
  0x18, 0x04, 0x04, 0x01, 0x02, 0x00, 0x21, 0x80, 0x08, 0x40, 0x02, 0x20,
  0x00, 0x58, 0x00, 0x14, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x03,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xE0,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x80, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x0C, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x06, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x60, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x3E, 0x00, 0x82, 0x0C, 0x10, 0x41, 0x04, 0x10, 0x40, 0x82,
  0x08, 0x20, 0x82, 0x0C, 0x10, 0x41, 0x04, 0x10, 0x41, 0x82, 0x08, 0x20,
  0x82, 0x08, 0x10, 0x03, 0xE0, 0x04, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x03, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x18,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x80, 0x10, 0x1E, 0x00, 0x01, 0x80, 0x30,
  0x0A, 0x01, 0x40, 0x48, 0x09, 0x02, 0x10, 0x42, 0x10, 0x42, 0x08, 0x81,
  0x10, 0x24, 0x06, 0x80, 0x40, 0xFF, 0xFC, 0x8C, 0x42, 0x30, 0x00, 0xF8,
  0x03, 0x06, 0x04, 0x02, 0x08, 0x03, 0x18, 0x01, 0x10, 0x01, 0x00, 0x03,
  0x00, 0x02, 0x00, 0x02, 0x03, 0xFE, 0x0C, 0x02, 0x10, 0x02, 0x20, 0x04,
  0x40, 0x04, 0x40, 0x04, 0x40, 0x04, 0x40, 0x0C, 0x40, 0x14, 0x40, 0x28,
  0x20, 0xC8, 0x1F, 0x08, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0xF8,
  0x13, 0x04, 0x14, 0x02, 0x18, 0x02, 0x10, 0x01, 0x10, 0x01, 0x10, 0x01,
  0x20, 0x01, 0x20, 0x01, 0x20, 0x02, 0x20, 0x02, 0x20, 0x02, 0x60, 0x02,
  0x40, 0x02, 0x40, 0x04, 0x40, 0x04, 0x40, 0x0C, 0x40, 0x08, 0xA0, 0x10,
  0x98, 0x60, 0x87, 0xC0, 0x01, 0xF0, 0x0C, 0x18, 0x20, 0x10, 0x80, 0x13,
  0x00, 0x24, 0x00, 0x48, 0x00, 0xA0, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x02, 0x40, 0x04, 0xC0, 0x08,
  0x80, 0x21, 0x80, 0xC1, 0x83, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x02, 0x01, 0xF1, 0x03, 0x04, 0x82, 0x01, 0x43, 0x00, 0x61,
  0x00, 0x31, 0x00, 0x10, 0x80, 0x08, 0x40, 0x04, 0x40, 0x02, 0x20, 0x01,
  0x10, 0x01, 0x88, 0x00, 0x84, 0x00, 0x42, 0x00, 0x21, 0x00, 0x10, 0x80,
  0x08, 0x40, 0x0C, 0x20, 0x04, 0x18, 0x0E, 0x06, 0x09, 0x01, 0xF8, 0x80,
  0x01, 0xF0, 0x0C, 0x18, 0x20, 0x10, 0x80, 0x13, 0x00, 0x24, 0x00, 0x48,
  0x00, 0xA0, 0x01, 0x40, 0x02, 0xFF, 0xFF, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x41,
  0x83, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x10, 0x02, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x0C, 0x00, 0x80, 0x08, 0x07, 0xFC, 0x08, 0x00, 0x80, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C,
  0x00, 0x00, 0xF8, 0x81, 0x82, 0x41, 0x00, 0xA1, 0x80, 0x30, 0x80, 0x18,
  0x80, 0x08, 0x40, 0x04, 0x20, 0x02, 0x20, 0x01, 0x10, 0x00, 0x88, 0x00,
  0xC4, 0x00, 0x42, 0x00, 0x21, 0x00, 0x10, 0x80, 0x08, 0x40, 0x04, 0x20,
  0x06, 0x10, 0x02, 0x0C, 0x07, 0x03, 0x06, 0x80, 0xFC, 0x40, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x08, 0x10, 0x0C, 0x04, 0x0C,
  0x01, 0xF8, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x11, 0xF0, 0x44, 0x10,
  0x90, 0x11, 0x40, 0x23, 0x00, 0x46, 0x00, 0x88, 0x01, 0x30, 0x02, 0x40,
  0x04, 0x80, 0x09, 0x00, 0x12, 0x00, 0x44, 0x00, 0x90, 0x01, 0x20, 0x02,
  0x40, 0x04, 0x80, 0x09, 0x00, 0x26, 0x00, 0x48, 0x00, 0x90, 0x01, 0x00,
  0x06, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x10, 0x60, 0x81, 0x02,
  0x04, 0x08, 0x20, 0x40, 0x81, 0x02, 0x04, 0x10, 0x20, 0x40, 0x81, 0x02,
  0x08, 0x00, 0x00, 0x18, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0xC0, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x06, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x06, 0x00, 0x20, 0x03, 0x00, 0x30,
  0x0F, 0x00, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x02, 0x10,
  0x04, 0x10, 0x08, 0x10, 0x10, 0x10, 0x20, 0x10, 0x40, 0x10, 0x80, 0x21,
  0x00, 0x22, 0x00, 0x2E, 0x00, 0x3A, 0x00, 0x21, 0x00, 0x21, 0x00, 0x40,
  0x80, 0x40, 0x80, 0x40, 0x40, 0x40, 0x40, 0x40, 0x20, 0xC0, 0x20, 0x80,
  0x10, 0x80, 0x10, 0x04, 0x10, 0x41, 0x04, 0x30, 0x82, 0x08, 0x20, 0x86,
  0x10, 0x41, 0x04, 0x10, 0x82, 0x08, 0x20, 0x82, 0x10, 0x41, 0x04, 0x10,
  0x42, 0x00, 0x10, 0xF8, 0x0F, 0x82, 0x20, 0x86, 0x18, 0x48, 0x09, 0x01,
  0x0A, 0x01, 0x40, 0x11, 0x80, 0x38, 0x02, 0x20, 0x06, 0x00, 0x4C, 0x00,
  0x80, 0x09, 0x80, 0x10, 0x01, 0x20, 0x02, 0x00, 0x64, 0x00, 0x40, 0x08,
  0x80, 0x10, 0x01, 0x10, 0x02, 0x00, 0x24, 0x00, 0x40, 0x04, 0x80, 0x08,
  0x00, 0x90, 0x01, 0x00, 0x32, 0x00, 0x20, 0x04, 0x40, 0x08, 0x00, 0x98,
  0x01, 0x00, 0x12, 0x00, 0x20, 0x02, 0x40, 0x04, 0x00, 0x48, 0x00, 0x80,
  0x10, 0x08, 0xF8, 0x22, 0x08, 0x48, 0x08, 0xA0, 0x11, 0x80, 0x23, 0x00,
  0x44, 0x00, 0x98, 0x01, 0x20, 0x02, 0x40, 0x04, 0x80, 0x09, 0x00, 0x22,
  0x00, 0x48, 0x00, 0x90, 0x01, 0x20, 0x02, 0x40, 0x04, 0x80, 0x13, 0x00,
  0x24, 0x00, 0x48, 0x00, 0x80, 0x03, 0xF0, 0x18, 0x30, 0x60, 0x31, 0x80,
  0x22, 0x00, 0x68, 0x00, 0x50, 0x00, 0xA0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x14, 0x00, 0x28, 0x00, 0x50, 0x00, 0xA0, 0x02, 0x40, 0x04, 0x80,
  0x19, 0x00, 0x21, 0x00, 0x83, 0x06, 0x01, 0xF0, 0x00, 0x04, 0x7C, 0x04,
  0xC1, 0x02, 0x80, 0x41, 0x80, 0x20, 0x80, 0x08, 0x40, 0x04, 0x60, 0x02,
  0x20, 0x01, 0x10, 0x00, 0x88, 0x00, 0x84, 0x00, 0x42, 0x00, 0x23, 0x00,
  0x11, 0x00, 0x08, 0x80, 0x08, 0x40, 0x04, 0x20, 0x06, 0x10, 0x02, 0x14,
  0x02, 0x09, 0x86, 0x04, 0x7E, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x00, 0x03,
  0xE2, 0x18, 0x24, 0x40, 0x29, 0x80, 0x32, 0x00, 0x68, 0x00, 0x90, 0x01,
  0x20, 0x02, 0x80, 0x05, 0x00, 0x0A, 0x00, 0x24, 0x00, 0x48, 0x00, 0x90,
  0x01, 0x20, 0x02, 0x40, 0x04, 0x80, 0x11, 0x00, 0x23, 0x01, 0xC3, 0x0E,
  0x83, 0xF1, 0x00, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x08, 0xF1, 0x30, 0x14, 0x01, 0x40,
  0x18, 0x01, 0x00, 0x10, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x08, 0x00,
  0x80, 0x00, 0x03, 0xE0, 0x30, 0x61, 0x80, 0xC4, 0x01, 0x20, 0x04, 0x80,
  0x12, 0x00, 0x04, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x10, 0x00, 0x40, 0x00, 0xA0, 0x02, 0x80, 0x12, 0x00, 0x4C, 0x02, 0x18,
  0x30, 0x1F, 0x00, 0x04, 0x06, 0x02, 0x01, 0x00, 0x80, 0x43, 0xFE, 0x30,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x0F, 0x00, 0x10, 0x02,
  0x40, 0x04, 0x80, 0x09, 0x00, 0x12, 0x00, 0x24, 0x00, 0x90, 0x01, 0x20,
  0x02, 0x40, 0x04, 0x80, 0x09, 0x00, 0x32, 0x00, 0x48, 0x00, 0x90, 0x01,
  0x20, 0x02, 0x40, 0x0C, 0x80, 0x11, 0x00, 0x61, 0x01, 0x43, 0x0C, 0x83,
  0xF1, 0x00, 0x40, 0x02, 0x80, 0x09, 0x00, 0x12, 0x00, 0x44, 0x00, 0x88,
  0x02, 0x08, 0x04, 0x10, 0x10, 0x20, 0x20, 0x40, 0x80, 0x81, 0x01, 0x04,
  0x01, 0x08, 0x02, 0x30, 0x04, 0x40, 0x09, 0x80, 0x12, 0x00, 0x24, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x80, 0x00, 0x80, 0x10, 0x06, 0x00, 0xC0, 0x1C,
  0x03, 0x00, 0xB0, 0x14, 0x02, 0x40, 0x50, 0x19, 0x03, 0x40, 0x44, 0x09,
  0x01, 0x10, 0x26, 0x08, 0x41, 0x08, 0x21, 0x04, 0x21, 0x84, 0x20, 0x84,
  0x10, 0x82, 0x30, 0x44, 0x08, 0x81, 0x10, 0x22, 0x04, 0xC0, 0x90, 0x12,
  0x02, 0x40, 0x48, 0x0B, 0x01, 0x40, 0x28, 0x03, 0x00, 0xA0, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x08, 0x00, 0x82, 0x00, 0x81, 0x00, 0xC0, 0x40,
  0x40, 0x20, 0x40, 0x18, 0x40, 0x04, 0x60, 0x02, 0x20, 0x00, 0xA0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x12, 0x00, 0x11, 0x00, 0x10, 0xC0,
  0x18, 0x20, 0x08, 0x10, 0x08, 0x04, 0x0C, 0x02, 0x0C, 0x00, 0x84, 0x00,
  0x40, 0x04, 0x00, 0x20, 0x80, 0x08, 0x10, 0x01, 0x02, 0x00, 0x40, 0x40,
  0x08, 0x04, 0x02, 0x00, 0x80, 0x40, 0x10, 0x10, 0x02, 0x02, 0x00, 0x40,
  0xC0, 0x08, 0x10, 0x01, 0x06, 0x00, 0x10, 0x80, 0x02, 0x30, 0x00, 0x44,
  0x00, 0x09, 0x80, 0x01, 0x20, 0x00, 0x2C, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00,
  0x00, 0xC0, 0x00, 0x10, 0x00, 0x04, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x30,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00,
  0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x08, 0x01, 0x80, 0x10, 0x01, 0x00, 0x08,
  0x00, 0x80, 0x04, 0x00, 0x60, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x40, 0x06, 0x00, 0x60,
  0x0C, 0x00, 0x18, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x40, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x04, 0x10, 0x43,
  0x08, 0x20, 0x82, 0x08, 0x61, 0x84, 0x10, 0x41, 0x04, 0x30, 0x82, 0x08,
  0x20, 0x86, 0x10, 0x41, 0x04, 0x10, 0xC3, 0x08, 0x20, 0x80, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x60, 0x01, 0x80, 0x30, 0x02, 0x00,
  0x10, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x18, 0x00, 0x0F, 0x00, 0x26, 0x30, 0x08, 0x81, 0x01, 0x20, 0x30,
  0x64, 0x03, 0x18, 0x80, 0x1E, 0x00,
};

const GFXglyph RobotoCondensed_ThinItalic40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 6, 28, 7, 1, -28 },
  { 22, 7, 8, 10, 4, -30 },
  { 29, 20, 28, 19, 1, -28 },
  { 99, 17, 36, 19, 1, -32 },
  { 176, 18, 28, 25, 4, -28 },
  { 239, 18, 28, 21, 1, -28 },
  { 302, 3, 8, 6, 4, -30 },
  { 305, 11, 41, 11, 2, -32 },
  { 362, 10, 41, 11, -2, -32 },
  { 414, 16, 15, 16, 2, -28 },
  { 444, 16, 21, 19, 2, -24 },
  { 486, 4, 8, 7, -1, -3 },
  { 490, 8, 1, 10, 1, -14 },
  { 491, 2, 2, 8, 1, -2 },
  { 492, 16, 30, 13, -1, -28 },
  { 552, 16, 28, 19, 2, -28 },
  { 608, 8, 28, 19, 6, -28 },
  { 636, 16, 28, 19, 1, -28 },
  { 692, 17, 28, 19, 1, -28 },
  { 752, 16, 28, 19, 1, -28 },
  { 808, 17, 28, 19, 2, -28 },
  { 868, 15, 28, 19, 2, -28 },
  { 921, 15, 28, 19, 4, -28 },
  { 974, 17, 28, 19, 1, -28 },
  { 1034, 15, 28, 19, 3, -28 },
  { 1087, 6, 21, 7, 0, -21 },
  { 1103, 7, 26, 7, -1, -21 },
  { 1126, 15, 16, 18, 2, -21 },
  { 1156, 15, 8, 19, 2, -17 },
  { 1171, 15, 16, 18, 1, -21 },
  { 1201, 11, 28, 15, 4, -28 },
  { 1240, 28, 37, 31, 1, -28 },
  { 1370, 19, 28, 20, -1, -28 },
  { 1437, 17, 28, 21, 2, -28 },
  { 1497, 19, 28, 22, 2, -28 },
  { 1564, 19, 28, 22, 2, -28 },
  { 1631, 19, 28, 19, 2, -28 },
  { 1698, 19, 28, 20, 2, -28 },
  { 1765, 19, 28, 23, 3, -28 },
  { 1832, 21, 28, 24, 2, -28 },
  { 1906, 6, 28, 9, 2, -28 },
  { 1927, 17, 28, 19, 1, -28 },
  { 1987, 20, 28, 22, 2, -28 },
  { 2057, 13, 28, 18, 2, -28 },
  { 2103, 26, 28, 29, 2, -28 },
  { 2194, 21, 28, 24, 2, -28 },
  { 2268, 19, 28, 23, 2, -28 },
  { 2335, 18, 28, 21, 2, -28 },
  { 2398, 19, 33, 23, 2, -28 },
  { 2477, 20, 28, 22, 1, -28 },
  { 2547, 19, 28, 20, 1, -28 },
  { 2614, 18, 28, 20, 4, -28 },
  { 2677, 20, 28, 23, 2, -28 },
  { 2747, 19, 28, 20, 3, -28 },
  { 2814, 28, 28, 31, 4, -28 },
  { 2912, 23, 28, 20, -1, -28 },
  { 2993, 18, 28, 20, 4, -28 },
  { 3056, 21, 28, 20, 0, -28 },
  { 3130, 11, 39, 8, 0, -33 },
  { 3184, 6, 30, 13, 4, -28 },
  { 3207, 11, 39, 8, -3, -33 },
  { 3261, 11, 14, 14, 2, -28 },
  { 3281, 14, 1, 14, -2, 0 },
  { 3283, 4, 5, 10, 6, -30 },
  { 3286, 16, 21, 18, 0, -21 },
  { 3328, 16, 30, 19, 1, -30 },
  { 3388, 15, 21, 17, 1, -21 },
  { 3428, 17, 30, 19, 2, -30 },
  { 3492, 15, 21, 18, 1, -21 },
  { 3532, 12, 30, 11, 2, -30 },
  { 3577, 17, 29, 19, 0, -21 },
  { 3639, 15, 30, 19, 1, -30 },
  { 3696, 7, 29, 8, 1, -29 },
  { 3722, 13, 37, 8, -5, -29 },
  { 3783, 16, 30, 16, 1, -30 },
  { 3843, 6, 30, 8, 1, -30 },
  { 3866, 27, 21, 30, 1, -21 },
  { 3937, 15, 21, 19, 1, -21 },
  { 3977, 15, 21, 19, 2, -21 },
  { 4017, 17, 29, 19, 0, -21 },
  { 4079, 15, 29, 19, 2, -21 },
  { 4134, 12, 21, 12, 1, -21 },
  { 4166, 14, 21, 17, 1, -21 },
  { 4203, 9, 27, 11, 2, -27 },
  { 4234, 15, 21, 19, 2, -21 },
  { 4274, 15, 21, 16, 2, -21 },
  { 4314, 22, 21, 26, 3, -21 },
  { 4372, 17, 21, 16, -1, -21 },
  { 4417, 19, 29, 16, -2, -21 },
  { 4486, 16, 21, 16, 0, -21 },
  { 4528, 13, 40, 11, 1, -31 },
  { 4593, 6, 33, 8, 1, -28 },
  { 4618, 13, 40, 11, -3, -31 },
  { 4683, 19, 6, 23, 2, -15 },
};

const GFXfont RobotoCondensed_ThinItalic40pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ThinItalic40pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ThinItalic40pt7bGlyphs,
  0x20, 0x7E, 47
};

#endif // _ROBOTOCONDENSED_THINITALIC40PT7B_H_
