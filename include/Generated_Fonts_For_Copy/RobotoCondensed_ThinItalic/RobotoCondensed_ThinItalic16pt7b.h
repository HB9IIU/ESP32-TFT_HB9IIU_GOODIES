#ifndef _ROBOTOCONDENSED_THINITALIC16PT7B_H_
#define _ROBOTOCONDENSED_THINITALIC16PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ThinItalic.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ThinItalic16pt7bBitmaps[] PROGMEM = {
  0x00, 0x24, 0x94, 0x92, 0x00, 0x40, 0xB4, 0x09, 0x09, 0x0A, 0x1F, 0x12,
  0x14, 0x24, 0x24, 0x7A, 0x48, 0x48, 0x40, 0x00, 0xF4, 0x50, 0x81, 0x02,
  0x04, 0x08, 0x10, 0xA2, 0xF0, 0x00, 0x70, 0x50, 0x92, 0x94, 0x64, 0x08,
  0x10, 0x17, 0x29, 0x49, 0x09, 0x0A, 0x1C, 0x22, 0x22, 0x24, 0x28, 0x10,
  0x30, 0x48, 0x8A, 0x86, 0x84, 0x7A, 0xC0, 0x12, 0x24, 0x48, 0x88, 0x88,
  0x88, 0x88, 0x88, 0x40, 0x01, 0x11, 0x11, 0x11, 0x11, 0x11, 0x22, 0x24,
  0x80, 0x10, 0x4D, 0x88, 0x52, 0x20, 0x10, 0x41, 0x1E, 0x20, 0x82, 0x00,
  0x60, 0x40, 0x80, 0x02, 0x08, 0x10, 0x20, 0x81, 0x04, 0x08, 0x20, 0x41,
  0x02, 0x00, 0x00, 0x39, 0x14, 0x61, 0x86, 0x18, 0x61, 0x86, 0x28, 0x9C,
  0x2D, 0x22, 0x22, 0x22, 0x44, 0x44, 0x1C, 0x44, 0x08, 0x10, 0x20, 0x82,
  0x04, 0x10, 0x41, 0x07, 0xC0, 0x1C, 0x44, 0x08, 0x10, 0x23, 0x81, 0x01,
  0x02, 0x0A, 0x13, 0xC0, 0x02, 0x08, 0x28, 0x61, 0x44, 0x89, 0x22, 0xF4,
  0x10, 0x20, 0x40, 0x3C, 0x81, 0x02, 0x07, 0x80, 0x81, 0x02, 0x04, 0x12,
  0x23, 0x80, 0x18, 0x84, 0x10, 0xFA, 0x18, 0x61, 0x86, 0x28, 0x9C, 0x3E,
  0x08, 0x10, 0x40, 0x82, 0x04, 0x10, 0x20, 0x81, 0x00, 0x00, 0x1C, 0x44,
  0x8A, 0x12, 0x27, 0x89, 0x21, 0x83, 0x06, 0x13, 0xC0, 0x39, 0x18, 0x61,
  0x86, 0x18, 0xDD, 0x08, 0x21, 0x38, 0x00, 0x02, 0x00, 0x00, 0x00, 0x50,
  0x0C, 0xCC, 0x30, 0x20, 0x60, 0x78, 0x07, 0x00, 0x20, 0x60, 0x43, 0x31,
  0x00, 0x3A, 0x42, 0x10, 0x88, 0x84, 0x00, 0x00, 0x80, 0x0F, 0x82, 0x08,
  0x80, 0xA3, 0x14, 0x93, 0x22, 0x64, 0x8D, 0x11, 0xA2, 0x54, 0x8A, 0xEE,
  0x40, 0x08, 0x01, 0x00, 0x1F, 0x00, 0x04, 0x18, 0x30, 0xA1, 0x44, 0x88,
  0xAD, 0x43, 0x06, 0x08, 0x00, 0x7C, 0x85, 0x0A, 0x14, 0x57, 0x21, 0x42,
  0x85, 0x0A, 0x13, 0xC0, 0x3C, 0x85, 0x0C, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x0A, 0x13, 0xC0, 0x5C, 0x85, 0x0A, 0x14, 0x30, 0x60, 0xC1, 0x83, 0x0A,
  0x13, 0xC0, 0x5C, 0x81, 0x02, 0x04, 0x17, 0x20, 0x40, 0x81, 0x02, 0x03,
  0x80, 0x5C, 0x81, 0x02, 0x04, 0x17, 0x20, 0x40, 0x81, 0x02, 0x00, 0x00,
  0x1E, 0x21, 0x41, 0x40, 0x80, 0x80, 0x86, 0x80, 0x82, 0x82, 0x82, 0x7C,
  0x40, 0x41, 0x41, 0x41, 0x41, 0xBD, 0x81, 0x82, 0x82, 0x82, 0x82, 0x00,
  0x15, 0x5A, 0xA8, 0x00, 0x04, 0x08, 0x10, 0x20, 0x40, 0x82, 0x05, 0x0A,
  0x23, 0x80, 0x41, 0x42, 0x44, 0x48, 0x50, 0xA0, 0x50, 0x90, 0x88, 0x88,
  0x84, 0x04, 0x42, 0x10, 0x84, 0x42, 0x10, 0x84, 0x20, 0xE0, 0x40, 0x50,
  0x16, 0x0D, 0x83, 0x61, 0x68, 0x59, 0x26, 0x4A, 0x94, 0xA5, 0x28, 0x88,
  0x20, 0x40, 0x61, 0x61, 0x51, 0x51, 0x91, 0x89, 0x8A, 0x8A, 0x86, 0x86,
  0x02, 0x3C, 0x42, 0x41, 0x81, 0x81, 0x81, 0x82, 0x82, 0x82, 0x82, 0x84,
  0x78, 0x7C, 0x85, 0x0A, 0x14, 0x30, 0xAE, 0x40, 0x81, 0x02, 0x00, 0x00,
  0x3C, 0x42, 0x41, 0x81, 0x81, 0x81, 0x82, 0x82, 0x82, 0x82, 0x84, 0x78,
  0x08, 0x04, 0x7C, 0x85, 0x0A, 0x14, 0x30, 0x6F, 0x44, 0x89, 0x0A, 0x10,
  0x20, 0x1E, 0x21, 0x40, 0x40, 0x20, 0x18, 0x04, 0x02, 0x02, 0x82, 0x82,
  0x7C, 0x7C, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x40, 0x81, 0x02, 0x00,
  0x41, 0x41, 0x41, 0x41, 0x82, 0x82, 0x82, 0x82, 0x82, 0x84, 0x84, 0x78,
  0x81, 0x82, 0x82, 0x42, 0x44, 0x44, 0x48, 0x48, 0x50, 0x50, 0x20, 0x20,
  0x04, 0x31, 0x8A, 0x31, 0x4A, 0x29, 0x49, 0x29, 0x29, 0x25, 0x28, 0xC5,
  0x18, 0xA2, 0x08, 0x41, 0x00, 0x20, 0x10, 0x88, 0x82, 0x81, 0x40, 0x40,
  0x20, 0x30, 0x24, 0x22, 0x10, 0x90, 0x40, 0x81, 0x42, 0x42, 0x44, 0x28,
  0x28, 0x10, 0x20, 0x20, 0x20, 0x20, 0x20, 0x1F, 0x01, 0x02, 0x04, 0x04,
  0x08, 0x10, 0x10, 0x20, 0x40, 0x40, 0xFC, 0x02, 0x22, 0x24, 0x44, 0x44,
  0x48, 0x88, 0x80, 0x2A, 0xAA, 0x55, 0x40, 0x11, 0x11, 0x11, 0x22, 0x22,
  0x22, 0x24, 0x40, 0x22, 0x55, 0x98, 0x78, 0x90, 0x3C, 0x10, 0x41, 0x7E,
  0x18, 0x62, 0x70, 0x20, 0x40, 0x81, 0xE4, 0x28, 0x50, 0xA1, 0x43, 0x0A,
  0x13, 0xC0, 0x3D, 0x14, 0x10, 0x82, 0x08, 0x61, 0x78, 0x00, 0x04, 0x13,
  0xE8, 0x50, 0xA1, 0x42, 0x89, 0x12, 0x27, 0xC0, 0x3D, 0x14, 0x6F, 0x82,
  0x08, 0x20, 0x78, 0x31, 0x10, 0xC4, 0x21, 0x10, 0x84, 0x20, 0x00, 0x3E,
  0x85, 0x0A, 0x14, 0x50, 0xA1, 0x22, 0x7C, 0x08, 0x23, 0x80, 0x20, 0x40,
  0x81, 0xE2, 0x28, 0x50, 0xA1, 0x44, 0x8A, 0x10, 0x20, 0x40, 0xAA, 0xA8,
  0x08, 0x00, 0x01, 0x08, 0x42, 0x10, 0x88, 0x42, 0x11, 0x00, 0x20, 0x40,
  0x81, 0x24, 0x89, 0x14, 0x30, 0x50, 0x92, 0x20, 0x20, 0x55, 0x6A, 0xA8,
  0x1D, 0xE4, 0x45, 0x08, 0xA1, 0x14, 0x42, 0x88, 0x61, 0x0C, 0x21, 0x84,
  0x00, 0x1C, 0x45, 0x0A, 0x14, 0x28, 0x91, 0x42, 0x04, 0x39, 0x18, 0x61,
  0x86, 0x18, 0xA2, 0xF0, 0x1C, 0xC5, 0x0A, 0x14, 0x28, 0x61, 0x42, 0xF9,
  0x02, 0x00, 0x00, 0x7E, 0x18, 0x61, 0x8A, 0x28, 0xA2, 0xF8, 0x21, 0x00,
  0x11, 0x10, 0x84, 0x21, 0x10, 0x00, 0x3D, 0x04, 0x18, 0x18, 0x10, 0x62,
  0x70, 0x09, 0x25, 0x24, 0x92, 0x00, 0x06, 0x18, 0x61, 0x8A, 0x28, 0xA2,
  0xF8, 0x86, 0x28, 0xA2, 0x91, 0x46, 0x10, 0x40, 0x88, 0x44, 0x66, 0x52,
  0xAA, 0x55, 0x32, 0x98, 0x88, 0x04, 0x00, 0x40, 0x48, 0xA1, 0x81, 0x06,
  0x12, 0x24, 0x88, 0x21, 0x22, 0x22, 0x24, 0x24, 0x14, 0x18, 0x10, 0x10,
  0x10, 0x20, 0x40, 0x3C, 0x10, 0x84, 0x10, 0x84, 0x20, 0xF0, 0x11, 0x08,
  0x44, 0x21, 0x10, 0x02, 0x21, 0x08, 0x41, 0x00, 0x24, 0x94, 0x92, 0x49,
  0x49, 0x00, 0x00, 0x84, 0x21, 0x08, 0x41, 0x11, 0x08, 0x42, 0x22, 0x00,
  0x61, 0x24, 0x38,
};

const GFXglyph RobotoCondensed_ThinItalic16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 3, 12, 3, 0, -12 },
  { 6, 2, 3, 4, 2, -12 },
  { 7, 8, 12, 8, 0, -12 },
  { 19, 6, 14, 8, 1, -13 },
  { 30, 8, 12, 10, 1, -12 },
  { 42, 8, 12, 8, 0, -12 },
  { 54, 1, 3, 3, 2, -12 },
  { 55, 4, 17, 4, 1, -13 },
  { 64, 4, 17, 4, -1, -13 },
  { 73, 6, 6, 7, 1, -12 },
  { 78, 6, 8, 8, 1, -9 },
  { 84, 1, 3, 3, 0, -1 },
  { 85, 3, 1, 4, 1, -6 },
  { 86, 1, 1, 3, 0, -1 },
  { 87, 7, 13, 5, -1, -12 },
  { 99, 6, 12, 8, 1, -12 },
  { 108, 4, 12, 8, 2, -12 },
  { 114, 7, 12, 8, 0, -12 },
  { 125, 7, 12, 8, 0, -12 },
  { 136, 7, 12, 8, 0, -12 },
  { 147, 7, 12, 8, 1, -12 },
  { 158, 6, 12, 8, 1, -12 },
  { 167, 7, 12, 8, 1, -12 },
  { 178, 7, 12, 8, 0, -12 },
  { 189, 6, 12, 8, 1, -12 },
  { 198, 2, 8, 3, 0, -8 },
  { 200, 3, 10, 3, -1, -8 },
  { 204, 6, 6, 7, 1, -8 },
  { 209, 6, 3, 8, 1, -7 },
  { 212, 6, 6, 7, 0, -8 },
  { 217, 5, 12, 6, 1, -12 },
  { 225, 11, 15, 13, 1, -11 },
  { 246, 7, 12, 8, 0, -12 },
  { 257, 7, 12, 8, 1, -12 },
  { 268, 7, 12, 9, 1, -12 },
  { 279, 7, 12, 9, 1, -12 },
  { 290, 7, 12, 8, 1, -12 },
  { 301, 7, 12, 8, 1, -12 },
  { 312, 8, 12, 9, 1, -12 },
  { 324, 8, 12, 10, 1, -12 },
  { 336, 2, 12, 4, 1, -12 },
  { 339, 7, 12, 8, 0, -12 },
  { 350, 8, 12, 9, 1, -12 },
  { 362, 5, 12, 7, 1, -12 },
  { 370, 10, 12, 12, 1, -12 },
  { 385, 8, 12, 10, 1, -12 },
  { 397, 8, 12, 9, 1, -12 },
  { 409, 7, 12, 8, 1, -12 },
  { 420, 8, 14, 9, 1, -12 },
  { 434, 7, 12, 9, 1, -12 },
  { 445, 8, 12, 8, 0, -12 },
  { 457, 7, 12, 8, 2, -12 },
  { 468, 8, 12, 9, 1, -12 },
  { 480, 8, 12, 8, 1, -12 },
  { 492, 11, 12, 12, 2, -12 },
  { 509, 9, 12, 8, 0, -12 },
  { 523, 8, 12, 8, 1, -12 },
  { 535, 8, 12, 8, 0, -12 },
  { 547, 4, 15, 3, 0, -13 },
  { 555, 2, 13, 5, 2, -12 },
  { 559, 4, 15, 3, -1, -13 },
  { 567, 4, 6, 6, 1, -12 },
  { 570, 6, 1, 6, -1, 0 },
  { 571, 2, 2, 4, 2, -12 },
  { 572, 6, 9, 7, 0, -9 },
  { 579, 7, 12, 8, 0, -12 },
  { 590, 6, 9, 7, 0, -9 },
  { 597, 7, 12, 8, 1, -12 },
  { 608, 6, 9, 7, 0, -9 },
  { 615, 5, 12, 4, 1, -12 },
  { 623, 7, 12, 8, 0, -9 },
  { 634, 7, 12, 8, 0, -12 },
  { 645, 2, 12, 3, 1, -12 },
  { 648, 5, 15, 3, -2, -12 },
  { 658, 7, 12, 7, 0, -12 },
  { 669, 2, 12, 3, 1, -12 },
  { 672, 11, 9, 12, 0, -9 },
  { 685, 7, 9, 8, 0, -9 },
  { 693, 6, 9, 8, 1, -9 },
  { 700, 7, 12, 8, 0, -9 },
  { 711, 6, 12, 8, 1, -9 },
  { 720, 5, 9, 5, 0, -9 },
  { 726, 6, 9, 7, 0, -9 },
  { 733, 3, 11, 4, 1, -11 },
  { 738, 6, 9, 8, 1, -9 },
  { 745, 6, 9, 7, 1, -9 },
  { 752, 9, 9, 10, 1, -9 },
  { 763, 7, 9, 7, 0, -9 },
  { 771, 8, 12, 7, -1, -9 },
  { 783, 6, 9, 7, 0, -9 },
  { 790, 5, 15, 5, 1, -12 },
  { 800, 3, 14, 3, 0, -12 },
  { 806, 5, 15, 5, -1, -12 },
  { 816, 7, 3, 9, 1, -6 },
};

const GFXfont RobotoCondensed_ThinItalic16pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ThinItalic16pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ThinItalic16pt7bGlyphs,
  0x20, 0x7E, 19
};

#endif // _ROBOTOCONDENSED_THINITALIC16PT7B_H_
