#ifndef _ROBOTOCONDENSED_THINITALIC22PT7B_H_
#define _ROBOTOCONDENSED_THINITALIC22PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ThinItalic.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ThinItalic22pt7bBitmaps[] PROGMEM = {
  0x00, 0x11, 0x12, 0x22, 0x22, 0x24, 0x44, 0x00, 0x0C, 0x55, 0x5A, 0x02,
  0x20, 0x48, 0x11, 0x02, 0x23, 0xFE, 0x11, 0x02, 0x20, 0x48, 0x11, 0x02,
  0x20, 0x44, 0x7F, 0xE2, 0x20, 0x44, 0x09, 0x02, 0x20, 0x02, 0x02, 0x03,
  0x86, 0x22, 0x0A, 0x05, 0x02, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x40, 0x14,
  0x0A, 0x05, 0x04, 0x82, 0x3E, 0x04, 0x02, 0x00, 0x38, 0x12, 0x08, 0x8A,
  0x22, 0x89, 0x22, 0x87, 0x20, 0x10, 0x08, 0x02, 0x71, 0x24, 0x91, 0x24,
  0x51, 0x10, 0x44, 0x0E, 0x0E, 0x08, 0x88, 0x44, 0x22, 0x21, 0x20, 0x60,
  0x20, 0x28, 0x24, 0x61, 0x30, 0x98, 0x34, 0x0A, 0x1C, 0xF1, 0x5A, 0x04,
  0x21, 0x04, 0x20, 0x84, 0x10, 0x41, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x10, 0x40, 0x80, 0x10, 0x20, 0x82, 0x04, 0x10, 0x41, 0x04, 0x10,
  0x42, 0x08, 0x20, 0x84, 0x10, 0x42, 0x10, 0x42, 0x00, 0x04, 0x04, 0x02,
  0x2D, 0xE1, 0x80, 0xA0, 0x90, 0x84, 0x04, 0x02, 0x02, 0x01, 0x00, 0x87,
  0xFC, 0x20, 0x20, 0x10, 0x08, 0x04, 0x00, 0x25, 0x40, 0xF0, 0x40, 0x00,
  0x80, 0x40, 0x40, 0x20, 0x20, 0x10, 0x10, 0x08, 0x08, 0x04, 0x04, 0x02,
  0x02, 0x01, 0x01, 0x00, 0x80, 0x80, 0x00, 0x0E, 0x08, 0x88, 0x28, 0x14,
  0x0A, 0x05, 0x03, 0x01, 0x81, 0x40, 0xA0, 0x50, 0x28, 0x24, 0x12, 0x10,
  0xF0, 0x1B, 0x44, 0x21, 0x08, 0x42, 0x21, 0x08, 0x42, 0x11, 0x08, 0x1E,
  0x10, 0x88, 0x28, 0x14, 0x08, 0x08, 0x04, 0x04, 0x04, 0x02, 0x02, 0x02,
  0x02, 0x02, 0x02, 0x01, 0xFC, 0x1E, 0x10, 0x90, 0x28, 0x10, 0x08, 0x08,
  0x0C, 0x38, 0x02, 0x00, 0x80, 0x50, 0x28, 0x14, 0x12, 0x08, 0xF8, 0x01,
  0x00, 0x80, 0xC0, 0xA0, 0x90, 0x48, 0x48, 0x44, 0x22, 0x21, 0x20, 0x9F,
  0xF0, 0x40, 0x20, 0x10, 0x08, 0x1F, 0xC4, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x03, 0xE0, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x81, 0x20, 0x84, 0x20,
  0xF0, 0x07, 0x08, 0x10, 0x20, 0x40, 0x40, 0x5E, 0xA1, 0xC1, 0x81, 0x81,
  0x81, 0x81, 0x82, 0x42, 0x3C, 0xFF, 0x00, 0x80, 0x40, 0x40, 0x20, 0x20,
  0x10, 0x10, 0x08, 0x08, 0x04, 0x04, 0x02, 0x02, 0x02, 0x01, 0x00, 0x0F,
  0x84, 0x11, 0x04, 0x81, 0x20, 0x48, 0x11, 0x08, 0x3C, 0x31, 0x10, 0x24,
  0x0A, 0x02, 0x80, 0xA0, 0x44, 0x10, 0xF8, 0x3C, 0x42, 0x41, 0x81, 0x81,
  0x81, 0x81, 0x82, 0x82, 0x86, 0x7A, 0x04, 0x04, 0x08, 0x10, 0xE0, 0x20,
  0x00, 0x00, 0x02, 0x00, 0x10, 0x00, 0x00, 0x00, 0x02, 0x44, 0x80, 0x01,
  0x0E, 0x30, 0x40, 0xC0, 0x30, 0x08, 0x06, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x40, 0x30, 0x08, 0x06, 0x01, 0x06, 0x18, 0x60, 0x80, 0x39, 0x18,
  0x61, 0x04, 0x10, 0x42, 0x10, 0x82, 0x10, 0x00, 0x00, 0x20, 0x03, 0xF0,
  0x08, 0x18, 0x20, 0x10, 0x80, 0x12, 0x00, 0x24, 0x38, 0x50, 0x88, 0xA2,
  0x11, 0x88, 0x23, 0x10, 0x86, 0x21, 0x0C, 0x42, 0x29, 0x08, 0x52, 0x29,
  0x23, 0x9C, 0x40, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x00, 0xF8, 0x00,
  0x00, 0x80, 0x30, 0x0A, 0x01, 0x40, 0x28, 0x09, 0x01, 0x10, 0x42, 0x08,
  0x42, 0x08, 0x7F, 0x10, 0x22, 0x04, 0x80, 0x50, 0x0C, 0x01, 0x3F, 0x08,
  0x22, 0x04, 0x81, 0x20, 0x50, 0x24, 0x19, 0xF8, 0x41, 0x10, 0x24, 0x0A,
  0x02, 0x80, 0xA0, 0x48, 0x13, 0xF8, 0x0F, 0x82, 0x08, 0x81, 0x10, 0x14,
  0x02, 0x80, 0x10, 0x02, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x28, 0x09,
  0x01, 0x10, 0x41, 0xF0, 0x3F, 0x04, 0x10, 0x81, 0x10, 0x22, 0x02, 0x80,
  0x50, 0x12, 0x02, 0x40, 0x48, 0x09, 0x01, 0x40, 0x48, 0x09, 0x02, 0x20,
  0x87, 0xE0, 0x3F, 0xC8, 0x02, 0x00, 0x80, 0x20, 0x10, 0x04, 0x01, 0xFC,
  0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x08, 0x03, 0xFC, 0x3F, 0xC4,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x80, 0x10, 0x03, 0xF8, 0x40, 0x08, 0x01,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x0F, 0x82, 0x08, 0x80,
  0x90, 0x14, 0x00, 0x80, 0x10, 0x02, 0x00, 0x43, 0xC8, 0x0A, 0x01, 0x40,
  0x28, 0x04, 0x80, 0x90, 0x61, 0xF0, 0x20, 0x12, 0x01, 0x20, 0x12, 0x02,
  0x20, 0x24, 0x02, 0x40, 0x27, 0xFC, 0x40, 0x24, 0x04, 0x40, 0x48, 0x04,
  0x80, 0x48, 0x04, 0x80, 0x48, 0x08, 0x24, 0x92, 0x4A, 0x49, 0x25, 0x24,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x12, 0x04, 0x81, 0x20, 0x84, 0x20, 0xF0, 0x20, 0x24, 0x08, 0x82,
  0x10, 0x82, 0x20, 0x88, 0x12, 0x02, 0x80, 0x68, 0x08, 0x81, 0x10, 0x41,
  0x08, 0x21, 0x02, 0x20, 0x44, 0x04, 0x20, 0x40, 0x81, 0x02, 0x08, 0x10,
  0x20, 0x40, 0x81, 0x04, 0x08, 0x10, 0x20, 0x7F, 0x20, 0x02, 0x60, 0x08,
  0xC0, 0x31, 0x80, 0x63, 0x01, 0x49, 0x02, 0x92, 0x09, 0x24, 0x12, 0x48,
  0x48, 0x90, 0x91, 0x22, 0x24, 0x24, 0x48, 0x50, 0x90, 0xA1, 0x21, 0x84,
  0x42, 0x08, 0x20, 0x13, 0x01, 0x30, 0x12, 0x82, 0x28, 0x24, 0x82, 0x44,
  0x24, 0x42, 0x42, 0x24, 0x24, 0x42, 0x48, 0x14, 0x81, 0x48, 0x14, 0x80,
  0x88, 0x08, 0x0F, 0x82, 0x08, 0x80, 0x90, 0x14, 0x02, 0x80, 0x50, 0x0A,
  0x01, 0x80, 0x50, 0x0A, 0x01, 0x40, 0x28, 0x09, 0x01, 0x10, 0x41, 0xF0,
  0x3F, 0x88, 0x12, 0x04, 0x81, 0x20, 0x50, 0x14, 0x05, 0x02, 0x7F, 0x10,
  0x04, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x0F, 0x82, 0x08, 0x80,
  0x90, 0x14, 0x02, 0x80, 0x50, 0x0A, 0x01, 0x80, 0x50, 0x0A, 0x01, 0x40,
  0x28, 0x09, 0x01, 0x10, 0x41, 0xF0, 0x02, 0x00, 0x20, 0x04, 0x00, 0x3F,
  0x88, 0x12, 0x04, 0x81, 0x20, 0x50, 0x14, 0x05, 0x02, 0x7F, 0x10, 0x88,
  0x22, 0x08, 0x81, 0x20, 0x48, 0x12, 0x02, 0x0F, 0x8C, 0x12, 0x05, 0x01,
  0x40, 0x10, 0x02, 0x00, 0x60, 0x06, 0x00, 0x40, 0x0A, 0x02, 0x80, 0xA0,
  0x48, 0x31, 0xF0, 0xFF, 0xC2, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x24, 0x04, 0x80, 0x90, 0x14, 0x02, 0x80, 0x50, 0x12, 0x02, 0x40, 0x48,
  0x0A, 0x01, 0x40, 0x48, 0x09, 0x01, 0x10, 0x41, 0xF0, 0x80, 0x60, 0x18,
  0x0A, 0x02, 0x81, 0x10, 0x44, 0x21, 0x08, 0x42, 0x11, 0x04, 0x41, 0x20,
  0x28, 0x0C, 0x03, 0x00, 0x80, 0x81, 0x01, 0x02, 0x06, 0x0A, 0x0C, 0x14,
  0x28, 0x28, 0x50, 0x90, 0xA1, 0x22, 0x44, 0x44, 0x88, 0x88, 0x91, 0x21,
  0x42, 0x42, 0x85, 0x06, 0x0A, 0x0C, 0x0C, 0x10, 0x10, 0x20, 0x20, 0x20,
  0x01, 0x02, 0x10, 0x40, 0x88, 0x08, 0x80, 0x90, 0x06, 0x00, 0x40, 0x04,
  0x00, 0xA0, 0x12, 0x01, 0x10, 0x21, 0x04, 0x08, 0x40, 0x88, 0x04, 0x80,
  0x60, 0x24, 0x09, 0x04, 0x41, 0x08, 0x82, 0x40, 0x90, 0x18, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x08, 0x02, 0x00, 0x80, 0x1F, 0xE0, 0x02, 0x00, 0x40,
  0x08, 0x00, 0x80, 0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x40, 0x0F, 0xF8, 0x1C, 0x41, 0x04, 0x10, 0x82,
  0x08, 0x20, 0x82, 0x08, 0x41, 0x04, 0x10, 0x41, 0x08, 0x20, 0xE0, 0x92,
  0x24, 0x92, 0x48, 0x92, 0x49, 0x20, 0x18, 0x42, 0x10, 0x84, 0x22, 0x10,
  0x84, 0x21, 0x08, 0x84, 0x21, 0x08, 0x4C, 0x00, 0x08, 0x61, 0x89, 0x25,
  0x14, 0x61, 0xFF, 0x94, 0x1F, 0x10, 0x48, 0x20, 0x10, 0x08, 0xF9, 0x84,
  0x82, 0x81, 0x41, 0xA1, 0x4F, 0x20, 0x20, 0x20, 0x20, 0x20, 0x40, 0x5E,
  0x61, 0x41, 0x41, 0x41, 0x81, 0x81, 0x81, 0x81, 0x82, 0x82, 0xFC, 0x1E,
  0x61, 0x41, 0x81, 0x80, 0x80, 0x80, 0x80, 0x82, 0x82, 0x84, 0x78, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x08, 0xF4, 0x84, 0x82, 0x81, 0x40, 0xA0, 0x50,
  0x28, 0x24, 0x12, 0x09, 0x0C, 0x7A, 0x00, 0x1E, 0x21, 0x41, 0x81, 0x81,
  0xFF, 0x80, 0x80, 0x80, 0x80, 0x80, 0x7C, 0x0E, 0x20, 0x41, 0x02, 0x0F,
  0x08, 0x10, 0x20, 0x81, 0x02, 0x04, 0x08, 0x10, 0x40, 0x80, 0x0F, 0x44,
  0x22, 0x09, 0x02, 0x40, 0x90, 0x24, 0x09, 0x04, 0x41, 0x10, 0x44, 0x30,
  0xF4, 0x01, 0x00, 0x88, 0x21, 0xF0, 0x20, 0x20, 0x20, 0x20, 0x40, 0x5E,
  0x61, 0x41, 0x41, 0x41, 0x81, 0x81, 0x81, 0x82, 0x82, 0x82, 0x82, 0x20,
  0x04, 0x92, 0x4A, 0x49, 0x24, 0x02, 0x00, 0x00, 0x00, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x20, 0x40, 0x81, 0x02, 0x08, 0x10, 0x20, 0x47, 0x00, 0x20,
  0x20, 0x20, 0x20, 0x40, 0x41, 0x42, 0x44, 0x48, 0x50, 0xA0, 0xD0, 0x90,
  0x88, 0x88, 0x84, 0x84, 0x24, 0x92, 0x92, 0x49, 0x49, 0x24, 0x80, 0x2F,
  0x1C, 0x61, 0x44, 0x83, 0x09, 0x04, 0x12, 0x08, 0x28, 0x10, 0x50, 0x20,
  0xA0, 0x81, 0x41, 0x02, 0x82, 0x05, 0x04, 0x14, 0x08, 0x20, 0x5E, 0x61,
  0x41, 0x41, 0x41, 0x81, 0x81, 0x81, 0x82, 0x82, 0x82, 0x82, 0x1E, 0x21,
  0x41, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x82, 0x84, 0x78, 0x2F, 0x18,
  0x48, 0x24, 0x14, 0x0A, 0x05, 0x02, 0x81, 0x40, 0xA0, 0x90, 0x57, 0xC8,
  0x04, 0x02, 0x01, 0x00, 0x1E, 0x90, 0x90, 0x50, 0x28, 0x14, 0x0A, 0x05,
  0x04, 0x82, 0x41, 0x21, 0x8F, 0x40, 0x20, 0x20, 0x10, 0x08, 0x5D, 0x84,
  0x10, 0x42, 0x08, 0x20, 0x82, 0x08, 0x20, 0x1E, 0x21, 0x21, 0x40, 0x20,
  0x18, 0x06, 0x01, 0x01, 0x81, 0x42, 0x3C, 0x21, 0x09, 0xF2, 0x11, 0x08,
  0x42, 0x10, 0x88, 0x41, 0x80, 0x40, 0xA0, 0x90, 0x48, 0x24, 0x14, 0x0A,
  0x05, 0x04, 0x82, 0x41, 0x21, 0x8F, 0x40, 0x80, 0x81, 0x42, 0x42, 0x44,
  0x44, 0x44, 0x48, 0x28, 0x30, 0x20, 0x20, 0x84, 0x18, 0x41, 0x8A, 0x28,
  0xA2, 0x8A, 0x49, 0x24, 0x92, 0x4A, 0x28, 0xA2, 0x8C, 0x30, 0xC1, 0x08,
  0x20, 0x20, 0x90, 0x84, 0x82, 0x41, 0x40, 0x40, 0x20, 0x28, 0x24, 0x22,
  0x10, 0x90, 0x40, 0x20, 0x08, 0x11, 0x08, 0x42, 0x11, 0x04, 0x41, 0x20,
  0x48, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x10, 0x04, 0x02, 0x03, 0x00, 0x3F,
  0x80, 0x80, 0x80, 0x40, 0x40, 0x40, 0x40, 0x20, 0x20, 0x20, 0x20, 0x1F,
  0xC0, 0x06, 0x10, 0x40, 0x81, 0x02, 0x08, 0x10, 0x20, 0x82, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x04, 0x00, 0x11, 0x11, 0x22,
  0x22, 0x22, 0x24, 0x44, 0x44, 0x48, 0x80, 0x10, 0x20, 0x82, 0x08, 0x20,
  0x82, 0x08, 0x20, 0x42, 0x10, 0x41, 0x04, 0x10, 0x82, 0x08, 0x42, 0x00,
  0x38, 0x51, 0x18, 0x46, 0x0E,
};

const GFXglyph RobotoCondensed_ThinItalic22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 4, 16, 4, 0, -16 },
  { 9, 4, 4, 6, 2, -17 },
  { 11, 11, 16, 10, 0, -16 },
  { 33, 9, 20, 10, 1, -18 },
  { 56, 10, 16, 14, 2, -16 },
  { 76, 9, 16, 11, 1, -16 },
  { 94, 2, 4, 4, 2, -17 },
  { 95, 6, 22, 6, 1, -17 },
  { 112, 6, 22, 6, -1, -17 },
  { 129, 9, 8, 9, 1, -16 },
  { 138, 9, 11, 11, 1, -13 },
  { 151, 3, 4, 4, -1, -2 },
  { 153, 4, 1, 6, 1, -8 },
  { 154, 2, 1, 5, 0, -1 },
  { 155, 9, 17, 7, -1, -16 },
  { 175, 9, 16, 10, 1, -16 },
  { 193, 5, 16, 10, 3, -16 },
  { 203, 9, 16, 10, 1, -16 },
  { 221, 9, 16, 10, 1, -16 },
  { 239, 9, 16, 10, 1, -16 },
  { 257, 10, 16, 10, 1, -16 },
  { 277, 8, 16, 10, 1, -16 },
  { 293, 9, 16, 10, 2, -16 },
  { 311, 10, 16, 10, 0, -16 },
  { 331, 8, 16, 10, 2, -16 },
  { 347, 3, 11, 4, 0, -11 },
  { 352, 4, 13, 4, -1, -11 },
  { 359, 8, 8, 10, 1, -11 },
  { 367, 8, 6, 10, 1, -10 },
  { 373, 8, 9, 10, 1, -12 },
  { 382, 6, 16, 8, 2, -16 },
  { 394, 15, 20, 17, 1, -15 },
  { 432, 11, 16, 11, -1, -16 },
  { 454, 10, 16, 11, 1, -16 },
  { 474, 11, 16, 12, 1, -16 },
  { 496, 11, 16, 12, 1, -16 },
  { 518, 10, 16, 11, 1, -16 },
  { 538, 11, 16, 11, 1, -16 },
  { 560, 11, 16, 13, 1, -16 },
  { 582, 12, 16, 13, 1, -16 },
  { 606, 3, 16, 5, 1, -16 },
  { 612, 10, 16, 10, 0, -16 },
  { 632, 11, 16, 12, 1, -16 },
  { 654, 7, 16, 10, 1, -16 },
  { 668, 15, 16, 16, 1, -16 },
  { 698, 12, 16, 13, 1, -16 },
  { 722, 11, 16, 12, 1, -16 },
  { 744, 10, 16, 11, 1, -16 },
  { 764, 11, 19, 12, 1, -16 },
  { 791, 10, 16, 12, 1, -16 },
  { 811, 10, 16, 11, 1, -16 },
  { 831, 10, 16, 11, 2, -16 },
  { 851, 11, 16, 12, 1, -16 },
  { 873, 10, 16, 11, 2, -16 },
  { 893, 15, 16, 17, 2, -16 },
  { 923, 12, 16, 11, 0, -16 },
  { 947, 10, 16, 11, 2, -16 },
  { 967, 12, 16, 11, 0, -16 },
  { 991, 6, 21, 4, 0, -18 },
  { 1007, 3, 17, 7, 2, -16 },
  { 1014, 5, 21, 4, -1, -18 },
  { 1028, 6, 8, 8, 1, -16 },
  { 1034, 8, 1, 8, -1, 0 },
  { 1035, 2, 3, 6, 3, -17 },
  { 1036, 9, 12, 10, 0, -12 },
  { 1050, 8, 17, 10, 1, -17 },
  { 1067, 8, 12, 10, 1, -12 },
  { 1079, 9, 17, 10, 1, -17 },
  { 1099, 8, 12, 10, 1, -12 },
  { 1111, 7, 17, 6, 1, -17 },
  { 1126, 10, 16, 10, 0, -12 },
  { 1146, 8, 17, 10, 1, -17 },
  { 1163, 3, 16, 4, 1, -16 },
  { 1169, 7, 20, 4, -3, -16 },
  { 1187, 8, 17, 9, 1, -17 },
  { 1204, 3, 17, 4, 1, -17 },
  { 1211, 15, 12, 17, 0, -12 },
  { 1234, 8, 12, 10, 1, -12 },
  { 1246, 8, 12, 10, 1, -12 },
  { 1258, 9, 16, 10, 0, -12 },
  { 1276, 9, 16, 10, 1, -12 },
  { 1294, 6, 12, 6, 1, -12 },
  { 1303, 8, 12, 9, 0, -12 },
  { 1315, 5, 15, 6, 1, -15 },
  { 1325, 9, 12, 10, 1, -12 },
  { 1339, 8, 12, 9, 1, -12 },
  { 1351, 12, 12, 14, 2, -12 },
  { 1369, 9, 12, 9, 0, -12 },
  { 1383, 10, 16, 9, -1, -12 },
  { 1403, 9, 12, 9, 0, -12 },
  { 1417, 7, 22, 6, 1, -17 },
  { 1437, 4, 19, 4, 0, -16 },
  { 1447, 6, 22, 6, -1, -17 },
  { 1464, 10, 4, 13, 1, -9 },
};

const GFXfont RobotoCondensed_ThinItalic22pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ThinItalic22pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ThinItalic22pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _ROBOTOCONDENSED_THINITALIC22PT7B_H_
