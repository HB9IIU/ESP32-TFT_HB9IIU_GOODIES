#ifndef _ROBOTOCONDENSED_THINITALIC11PT7B_H_
#define _ROBOTOCONDENSED_THINITALIC11PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ThinItalic.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ThinItalic11pt7bBitmaps[] PROGMEM = {
  0x00, 0x15, 0x02, 0xB0, 0x00, 0xA3, 0xCA, 0x51, 0xE5, 0x00, 0x11, 0x50,
  0x86, 0x08, 0x31, 0x70, 0x00, 0xE5, 0x6D, 0xC3, 0xB4, 0xA5, 0x3A, 0x54,
  0x46, 0x4E, 0x4F, 0xC0, 0x0A, 0x49, 0x24, 0x92, 0x40, 0x24, 0x92, 0x49,
  0x25, 0x00, 0x07, 0x4A, 0x01, 0x1C, 0x42, 0x00, 0x80, 0x40, 0x80, 0x01,
  0x22, 0x44, 0x88, 0x00, 0x79, 0x99, 0x99, 0xAE, 0x55, 0xAA, 0x3A, 0x42,
  0x21, 0x11, 0x1C, 0x3A, 0x42, 0x60, 0x06, 0x2E, 0x08, 0x8A, 0x65, 0x38,
  0x40, 0x68, 0x8E, 0x11, 0x1E, 0x68, 0x8E, 0x99, 0x9E, 0x71, 0x22, 0x44,
  0x88, 0x3A, 0x52, 0xE5, 0x46, 0x3E, 0x79, 0x99, 0xF1, 0x2C, 0x40, 0x20,
  0x40, 0x20, 0x1B, 0x20, 0xC1, 0x00, 0x64, 0x43, 0x02, 0xC0, 0xE4, 0x94,
  0x04, 0x1E, 0x21, 0x5D, 0x55, 0xA5, 0xA5, 0xA9, 0xBE, 0x80, 0x78, 0x11,
  0x8C, 0x94, 0xB6, 0x21, 0x7A, 0x52, 0xE4, 0xC6, 0x26, 0x7C, 0x61, 0x08,
  0x42, 0x5C, 0x19, 0x14, 0x51, 0x46, 0x18, 0x8C, 0x19, 0x04, 0x1C, 0x42,
  0x08, 0x08, 0x19, 0x04, 0x1C, 0x42, 0x08, 0x00, 0x7C, 0x21, 0x09, 0x42,
  0x3E, 0x01, 0x14, 0x5F, 0x46, 0x18, 0x40, 0x7E, 0x00, 0x42, 0x10, 0x8A,
  0x5C, 0x05, 0x25, 0x18, 0x62, 0x48, 0x82, 0x04, 0x44, 0x48, 0x82, 0x01,
  0x41, 0x62, 0x65, 0x66, 0xAA, 0x92, 0x12, 0x40, 0x96, 0x55, 0x56, 0x58,
  0x82, 0x7C, 0x63, 0x18, 0xC6, 0x5C, 0x79, 0x14, 0x51, 0x7A, 0x08, 0x00,
  0x7C, 0x63, 0x18, 0xC6, 0x5C, 0x00, 0x79, 0x14, 0x51, 0x7A, 0x08, 0xA2,
  0x39, 0x04, 0x08, 0x18, 0x28, 0x9C, 0x71, 0x08, 0x84, 0x21, 0x00, 0x04,
  0x63, 0x18, 0xC6, 0x5C, 0x04, 0x65, 0x2A, 0x51, 0x08, 0x01, 0x91, 0xAA,
  0xAA, 0xAC, 0xCC, 0x88, 0x08, 0x45, 0x23, 0x08, 0x21, 0x45, 0x22, 0x8C,
  0xA4, 0xC4, 0x21, 0x00, 0x3C, 0x21, 0x04, 0x21, 0x04, 0x1C, 0x09, 0x24,
  0xA4, 0x90, 0x00, 0x2A, 0x95, 0x40, 0x04, 0x92, 0x4A, 0x49, 0x00, 0x5A,
  0x80, 0x60, 0x00, 0x71, 0x17, 0x9F, 0x02, 0x10, 0xF4, 0xC6, 0x32, 0xF0,
  0x78, 0x88, 0x8F, 0x00, 0x42, 0xF4, 0xC6, 0x32, 0xF0, 0x79, 0xB8, 0x86,
  0x4A, 0x49, 0x24, 0x00, 0x7A, 0x63, 0x19, 0x78, 0x5C, 0x04, 0x47, 0x59,
  0x99, 0x80, 0x01, 0x5A, 0x80, 0x00, 0x12, 0x52, 0x48, 0x00, 0x02, 0x10,
  0xA6, 0x62, 0x94, 0x90, 0x15, 0x5A, 0x80, 0x3F, 0x49, 0x89, 0x89, 0x91,
  0x80, 0x35, 0x59, 0x98, 0x72, 0x63, 0x19, 0x38, 0x3A, 0x63, 0x19, 0x7A,
  0x00, 0x7A, 0x63, 0x19, 0x78, 0x40, 0x2A, 0x49, 0x00, 0x78, 0x61, 0x9E,
  0x2A, 0xA0, 0x19, 0x99, 0xAC, 0x0A, 0xAC, 0xC8, 0x06, 0x9D, 0xB6, 0x92,
  0x40, 0x02, 0x88, 0x46, 0x40, 0x02, 0x94, 0xC4, 0x21, 0x00, 0x31, 0x24,
  0x46, 0x02, 0x24, 0x40, 0x04, 0x44, 0x40, 0x15, 0x6A, 0x80, 0x22, 0x22,
  0x20, 0x22, 0x24, 0x00, 0xC9, 0xC0,
};

const GFXglyph RobotoCondensed_ThinItalic11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 8, 2, 0, -8 },
  { 3, 2, 2, 3, 1, -8 },
  { 4, 6, 8, 5, 0, -8 },
  { 10, 5, 10, 5, 0, -9 },
  { 17, 5, 8, 7, 1, -8 },
  { 22, 5, 8, 6, 0, -8 },
  { 27, 1, 2, 2, 1, -8 },
  { 28, 3, 12, 3, 1, -9 },
  { 33, 3, 12, 3, -1, -9 },
  { 38, 4, 4, 4, 1, -8 },
  { 40, 5, 6, 5, 0, -6 },
  { 44, 1, 2, 2, 0, -1 },
  { 45, 3, 1, 3, 0, -4 },
  { 46, 1, 1, 2, 0, -1 },
  { 47, 4, 9, 4, 0, -8 },
  { 52, 4, 8, 5, 1, -8 },
  { 56, 2, 8, 5, 2, -8 },
  { 58, 5, 8, 5, 0, -8 },
  { 63, 5, 8, 5, 0, -8 },
  { 68, 5, 8, 5, 0, -8 },
  { 73, 4, 8, 5, 1, -8 },
  { 77, 4, 8, 5, 1, -8 },
  { 81, 4, 8, 5, 1, -8 },
  { 85, 5, 8, 5, 0, -8 },
  { 90, 4, 8, 5, 1, -8 },
  { 94, 2, 6, 2, 0, -6 },
  { 96, 2, 7, 2, 0, -6 },
  { 98, 5, 5, 5, 0, -6 },
  { 102, 4, 2, 5, 1, -5 },
  { 103, 4, 5, 5, 0, -6 },
  { 106, 3, 8, 4, 1, -8 },
  { 109, 8, 10, 9, 0, -8 },
  { 119, 5, 8, 6, 0, -8 },
  { 124, 5, 8, 6, 0, -8 },
  { 129, 5, 8, 6, 1, -8 },
  { 134, 6, 8, 6, 0, -8 },
  { 140, 6, 8, 5, 0, -8 },
  { 146, 6, 8, 5, 0, -8 },
  { 152, 5, 8, 6, 1, -8 },
  { 157, 6, 8, 7, 0, -8 },
  { 163, 1, 8, 3, 1, -8 },
  { 164, 5, 8, 5, 0, -8 },
  { 169, 6, 8, 6, 0, -8 },
  { 175, 4, 8, 5, 0, -8 },
  { 179, 8, 8, 8, 0, -8 },
  { 187, 6, 8, 7, 0, -8 },
  { 193, 5, 8, 6, 1, -8 },
  { 198, 6, 8, 6, 0, -8 },
  { 204, 5, 9, 6, 1, -8 },
  { 210, 6, 8, 6, 0, -8 },
  { 216, 6, 8, 6, 0, -8 },
  { 222, 5, 8, 6, 1, -8 },
  { 227, 5, 8, 6, 1, -8 },
  { 232, 5, 8, 6, 1, -8 },
  { 237, 8, 8, 8, 1, -8 },
  { 245, 6, 8, 6, 0, -8 },
  { 251, 5, 8, 6, 1, -8 },
  { 256, 6, 8, 6, 0, -8 },
  { 262, 3, 11, 2, 0, -9 },
  { 267, 2, 9, 4, 1, -8 },
  { 270, 3, 11, 2, -1, -9 },
  { 275, 3, 4, 4, 1, -8 },
  { 277, 4, 1, 4, -1, 0 },
  { 278, 1, 2, 3, 2, -9 },
  { 279, 4, 6, 5, 0, -6 },
  { 282, 5, 9, 5, 0, -9 },
  { 288, 4, 6, 5, 0, -6 },
  { 291, 5, 9, 5, 0, -9 },
  { 297, 4, 6, 5, 0, -6 },
  { 300, 3, 9, 3, 1, -9 },
  { 304, 5, 8, 5, 0, -6 },
  { 309, 4, 9, 5, 0, -9 },
  { 314, 2, 9, 2, 0, -9 },
  { 317, 3, 11, 2, -1, -9 },
  { 322, 5, 9, 5, 0, -9 },
  { 328, 2, 9, 2, 0, -9 },
  { 331, 8, 6, 8, 0, -6 },
  { 337, 4, 6, 5, 0, -6 },
  { 340, 5, 6, 5, 0, -6 },
  { 344, 5, 8, 5, 0, -6 },
  { 349, 5, 8, 5, 0, -6 },
  { 354, 3, 6, 3, 0, -6 },
  { 357, 4, 6, 5, 0, -6 },
  { 360, 2, 7, 3, 1, -7 },
  { 362, 4, 6, 5, 1, -6 },
  { 365, 4, 6, 5, 1, -6 },
  { 368, 6, 6, 7, 1, -6 },
  { 373, 5, 6, 5, 0, -6 },
  { 377, 5, 8, 5, 0, -6 },
  { 382, 4, 6, 5, 0, -6 },
  { 385, 4, 11, 3, 0, -9 },
  { 391, 2, 9, 2, 0, -8 },
  { 394, 4, 11, 3, -1, -9 },
  { 400, 5, 2, 6, 1, -4 },
};

const GFXfont RobotoCondensed_ThinItalic11pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ThinItalic11pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ThinItalic11pt7bGlyphs,
  0x20, 0x7E, 13
};

#endif // _ROBOTOCONDENSED_THINITALIC11PT7B_H_
