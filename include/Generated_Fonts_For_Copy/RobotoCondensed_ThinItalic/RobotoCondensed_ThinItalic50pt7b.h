#ifndef _ROBOTOCONDENSED_THINITALIC50PT7B_H_
#define _ROBOTOCONDENSED_THINITALIC50PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ThinItalic.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ThinItalic50pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0x02, 0x02, 0x02, 0x02, 0x06, 0x06, 0x04, 0x04, 0x04, 0x04,
  0x0C, 0x0C, 0x08, 0x08, 0x08, 0x08, 0x18, 0x18, 0x10, 0x10, 0x10, 0x10,
  0x30, 0x20, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0xC0,
  0xC0, 0x31, 0x21, 0x21, 0x23, 0x63, 0x63, 0x62, 0x42, 0x42, 0x46, 0x00,
  0x04, 0x02, 0x00, 0x02, 0x03, 0x00, 0x01, 0x01, 0x00, 0x01, 0x80, 0x80,
  0x00, 0x80, 0xC0, 0x00, 0x40, 0x40, 0x00, 0x60, 0x20, 0x00, 0x20, 0x30,
  0x00, 0x10, 0x10, 0x00, 0x18, 0x08, 0x03, 0xFF, 0xFF, 0xE0, 0x04, 0x04,
  0x00, 0x06, 0x02, 0x00, 0x02, 0x01, 0x00, 0x01, 0x01, 0x80, 0x01, 0x80,
  0x80, 0x00, 0x80, 0x40, 0x00, 0x40, 0x60, 0x00, 0x60, 0x20, 0x00, 0x20,
  0x10, 0x00, 0x10, 0x18, 0x00, 0x08, 0x08, 0x00, 0x0C, 0x04, 0x00, 0x04,
  0x06, 0x00, 0x02, 0x02, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0x01, 0x80, 0x00,
  0x80, 0x80, 0x00, 0xC0, 0x40, 0x00, 0x40, 0x60, 0x00, 0x20, 0x20, 0x00,
  0x30, 0x10, 0x00, 0x10, 0x18, 0x00, 0x08, 0x08, 0x00, 0x0C, 0x04, 0x00,
  0x04, 0x02, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x03, 0xF0, 0x00, 0xE1, 0xC0, 0x18, 0x06,
  0x03, 0x00, 0x20, 0x60, 0x03, 0x04, 0x00, 0x10, 0xC0, 0x01, 0x08, 0x00,
  0x10, 0x80, 0x01, 0x08, 0x00, 0x10, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x48, 0x00, 0x0C,
  0x80, 0x00, 0xC8, 0x00, 0x08, 0x80, 0x00, 0x8C, 0x00, 0x18, 0x40, 0x03,
  0x06, 0x00, 0x20, 0x30, 0x0C, 0x01, 0xC3, 0x80, 0x07, 0xE0, 0x00, 0x18,
  0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x07,
  0x80, 0x00, 0x39, 0x80, 0x00, 0xC1, 0x80, 0x01, 0x01, 0x00, 0x04, 0x02,
  0x00, 0x08, 0x04, 0x03, 0x30, 0x08, 0x04, 0x40, 0x10, 0x10, 0x80, 0x20,
  0x61, 0x00, 0x40, 0x82, 0x01, 0x82, 0x04, 0x02, 0x0C, 0x08, 0x04, 0x30,
  0x10, 0x10, 0x40, 0x30, 0x61, 0x00, 0x33, 0x86, 0x00, 0x3E, 0x08, 0x00,
  0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x07, 0xC0, 0x04, 0x18, 0xC0,
  0x18, 0x40, 0x80, 0x61, 0x81, 0x80, 0x82, 0x01, 0x02, 0x0C, 0x02, 0x0C,
  0x10, 0x04, 0x10, 0x20, 0x08, 0x40, 0x40, 0x31, 0x81, 0x80, 0x62, 0x03,
  0x00, 0x88, 0x06, 0x01, 0x30, 0x04, 0x06, 0x00, 0x08, 0x08, 0x00, 0x18,
  0x20, 0x00, 0x19, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x73,
  0x80, 0x01, 0x81, 0x00, 0x06, 0x03, 0x00, 0x08, 0x06, 0x00, 0x30, 0x04,
  0x00, 0x40, 0x18, 0x00, 0x80, 0x30, 0x01, 0x00, 0x40, 0x02, 0x01, 0x80,
  0x04, 0x06, 0x00, 0x08, 0x18, 0x00, 0x10, 0x60, 0x00, 0x31, 0x80, 0x00,
  0x26, 0x00, 0x00, 0x78, 0x00, 0x00, 0x40, 0x00, 0x03, 0xC0, 0x00, 0x0C,
  0x80, 0x00, 0x31, 0x80, 0x00, 0xC1, 0x00, 0x01, 0x01, 0x00, 0x84, 0x03,
  0x01, 0x18, 0x02, 0x02, 0x20, 0x06, 0x0C, 0xC0, 0x04, 0x11, 0x00, 0x0C,
  0x62, 0x00, 0x08, 0x84, 0x00, 0x0B, 0x08, 0x00, 0x1C, 0x10, 0x00, 0x18,
  0x20, 0x00, 0x70, 0x60, 0x01, 0xA0, 0x60, 0x06, 0x60, 0x60, 0x30, 0x40,
  0x7F, 0xC0, 0x40, 0x08, 0x00, 0x00, 0x24, 0xB6, 0x92, 0xD8, 0x00, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x60, 0x03, 0x00, 0x08, 0x00, 0x60,
  0x01, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0x80,
  0x02, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x06,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x30, 0x00, 0x40, 0x00, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x0C,
  0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x08,
  0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x30,
  0x01, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x1F, 0x82, 0x0E, 0x1C, 0x4F, 0x00, 0xFF, 0x00, 0x03, 0x00,
  0x00, 0xF0, 0x00, 0x32, 0x00, 0x0C, 0x60, 0x03, 0x04, 0x00, 0x40, 0xC0,
  0x10, 0x08, 0x06, 0x01, 0x81, 0x80, 0x10, 0x00, 0x00, 0x08, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00,
  0x10, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0xFF, 0xFF, 0xF0, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0xC4, 0x23, 0x18, 0x8C, 0xC4, 0x00, 0xFF, 0x80, 0x5F, 0x80, 0x00, 0x00,
  0x10, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00,
  0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00,
  0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80,
  0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40,
  0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30,
  0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x06, 0x18, 0x01, 0x80, 0x40, 0x30, 0x06, 0x02, 0x00,
  0x20, 0x60, 0x03, 0x04, 0x00, 0x10, 0xC0, 0x01, 0x08, 0x00, 0x11, 0x80,
  0x01, 0x10, 0x00, 0x11, 0x00, 0x01, 0x10, 0x00, 0x13, 0x00, 0x01, 0x20,
  0x00, 0x32, 0x00, 0x03, 0x20, 0x00, 0x22, 0x00, 0x02, 0x60, 0x00, 0x24,
  0x00, 0x02, 0x40, 0x00, 0x64, 0x00, 0x06, 0x40, 0x00, 0x44, 0x00, 0x04,
  0x40, 0x00, 0xCC, 0x00, 0x0C, 0xC0, 0x00, 0x84, 0x00, 0x18, 0x40, 0x01,
  0x04, 0x00, 0x30, 0x40, 0x02, 0x06, 0x00, 0x60, 0x20, 0x0C, 0x03, 0x01,
  0x80, 0x1C, 0x70, 0x00, 0x7C, 0x00, 0x00, 0x40, 0xF0, 0xE4, 0xE1, 0xC0,
  0xC0, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x18, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x80, 0x60, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x08, 0x06,
  0x01, 0x80, 0x40, 0x00, 0x1F, 0x00, 0x03, 0x8E, 0x00, 0x20, 0x18, 0x02,
  0x00, 0x60, 0x30, 0x01, 0x03, 0x00, 0x08, 0x10, 0x00, 0x61, 0x80, 0x03,
  0x08, 0x00, 0x18, 0x40, 0x00, 0x82, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x1F, 0x80, 0x03, 0x87, 0x00, 0x30, 0x0C, 0x02, 0x00,
  0x20, 0x30, 0x01, 0x83, 0x00, 0x0C, 0x10, 0x00, 0x20, 0x80, 0x01, 0x0C,
  0x00, 0x08, 0x40, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x0F, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x10, 0x00,
  0x08, 0x80, 0x00, 0xC4, 0x00, 0x04, 0x20, 0x00, 0x21, 0x80, 0x02, 0x0C,
  0x00, 0x30, 0x30, 0x03, 0x00, 0xC0, 0x30, 0x03, 0x87, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0x40,
  0x00, 0x1A, 0x00, 0x00, 0x90, 0x00, 0x08, 0x80, 0x00, 0xCC, 0x00, 0x0C,
  0x60, 0x00, 0x42, 0x00, 0x04, 0x10, 0x00, 0x60, 0x80, 0x02, 0x04, 0x00,
  0x20, 0x60, 0x03, 0x03, 0x00, 0x30, 0x10, 0x01, 0x00, 0x80, 0x10, 0x04,
  0x01, 0x80, 0x20, 0x08, 0x03, 0x00, 0x80, 0x18, 0x0C, 0x00, 0x80, 0xC0,
  0x04, 0x04, 0x00, 0x20, 0x60, 0x01, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0xC0,
  0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x01, 0xFF, 0xF8, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20,
  0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x7C,
  0x00, 0x5C, 0x38, 0x03, 0x80, 0x60, 0x10, 0x01, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x20, 0x00, 0x21, 0x00,
  0x03, 0x0C, 0x00, 0x10, 0x60, 0x00, 0x81, 0x00, 0x0C, 0x08, 0x00, 0x40,
  0x60, 0x04, 0x01, 0x80, 0x60, 0x07, 0x0C, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x03, 0xE0, 0x03, 0xE0, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20,
  0x00, 0x0C, 0x00, 0x01, 0x07, 0xC0, 0x23, 0x0E, 0x0D, 0x80, 0x61, 0x60,
  0x04, 0x38, 0x00, 0xC6, 0x00, 0x09, 0x80, 0x01, 0x30, 0x00, 0x34, 0x00,
  0x06, 0x80, 0x00, 0xD0, 0x00, 0x1A, 0x00, 0x02, 0xC0, 0x00, 0x58, 0x00,
  0x0B, 0x00, 0x03, 0x60, 0x00, 0x44, 0x00, 0x08, 0x80, 0x03, 0x18, 0x00,
  0x43, 0x00, 0x18, 0x30, 0x06, 0x03, 0x01, 0x80, 0x30, 0xE0, 0x03, 0xF0,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60,
  0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x10,
  0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C,
  0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x02,
  0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x01, 0xC3,
  0x80, 0x0C, 0x03, 0x00, 0x60, 0x06, 0x03, 0x00, 0x18, 0x08, 0x00, 0x20,
  0x40, 0x00, 0xC1, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x20, 0x80,
  0x00, 0x83, 0x00, 0x06, 0x0C, 0x00, 0x10, 0x10, 0x00, 0xC0, 0x60, 0x06,
  0x00, 0xC0, 0x30, 0x01, 0xC7, 0x00, 0x03, 0xF8, 0x00, 0x30, 0x30, 0x03,
  0x00, 0x20, 0x18, 0x00, 0x40, 0x40, 0x01, 0x82, 0x00, 0x02, 0x18, 0x00,
  0x08, 0x40, 0x00, 0x21, 0x00, 0x00, 0x8C, 0x00, 0x02, 0x30, 0x00, 0x08,
  0xC0, 0x00, 0x63, 0x00, 0x01, 0x04, 0x00, 0x0C, 0x10, 0x00, 0x60, 0x60,
  0x03, 0x00, 0xC0, 0x18, 0x01, 0xC3, 0xC0, 0x01, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0xE3, 0x80, 0x60, 0x30, 0x20, 0x06, 0x10, 0x00, 0x8C, 0x00, 0x22,
  0x00, 0x0D, 0x80, 0x03, 0x40, 0x00, 0x50, 0x00, 0x1C, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x02, 0x80, 0x01,
  0xA0, 0x00, 0x6C, 0x00, 0x2B, 0x00, 0x1E, 0x40, 0x0D, 0x18, 0x06, 0x43,
  0x87, 0x10, 0x3F, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00,
  0x10, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x04, 0x1C, 0x30, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x80, 0x70, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x20,
  0x08, 0x06, 0x01, 0x80, 0x40, 0x30, 0x08, 0x06, 0x01, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x80, 0x3F, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x08,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x0C,
  0x30, 0x20, 0x30, 0x80, 0x23, 0x00, 0x64, 0x00, 0x58, 0x00, 0xA0, 0x01,
  0x40, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00,
  0x04, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40,
  0x00, 0xC0, 0x01, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3E,
  0x3E, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x0C, 0x00, 0x00, 0x04, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00,
  0x08, 0x18, 0x00, 0xF8, 0x01, 0x02, 0x00, 0x71, 0x80, 0x20, 0xC0, 0x18,
  0x18, 0x04, 0x30, 0x04, 0x01, 0x00, 0x86, 0x01, 0x80, 0x60, 0x10, 0x80,
  0x60, 0x08, 0x02, 0x30, 0x08, 0x01, 0x00, 0x44, 0x03, 0x00, 0x20, 0x08,
  0x80, 0x40, 0x0C, 0x01, 0x30, 0x08, 0x01, 0x00, 0x24, 0x03, 0x00, 0x20,
  0x04, 0x80, 0x40, 0x04, 0x01, 0x90, 0x08, 0x01, 0x80, 0x26, 0x03, 0x00,
  0x20, 0x04, 0x80, 0x40, 0x04, 0x00, 0x90, 0x08, 0x00, 0x80, 0x32, 0x01,
  0x00, 0x30, 0x04, 0x40, 0x20, 0x04, 0x01, 0x88, 0x04, 0x01, 0x80, 0x21,
  0x00, 0x80, 0x30, 0x0C, 0x20, 0x10, 0x0A, 0x01, 0x04, 0x02, 0x02, 0x60,
  0x60, 0x80, 0x60, 0x84, 0x18, 0x10, 0x07, 0xE0, 0xFC, 0x03, 0x00, 0x20,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0xC0,
  0x00, 0x01, 0xF0, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x12,
  0x00, 0x00, 0x44, 0x00, 0x00, 0x88, 0x00, 0x02, 0x10, 0x00, 0x04, 0x20,
  0x00, 0x10, 0x40, 0x00, 0x20, 0xC0, 0x00, 0x81, 0x80, 0x01, 0x01, 0x00,
  0x06, 0x02, 0x00, 0x08, 0x04, 0x00, 0x30, 0x08, 0x00, 0x40, 0x10, 0x01,
  0x80, 0x30, 0x02, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x10, 0x00, 0x80, 0x60,
  0x01, 0x00, 0x80, 0x02, 0x03, 0x00, 0x04, 0x07, 0xFF, 0xF8, 0x08, 0x00,
  0x18, 0x20, 0x00, 0x30, 0x40, 0x00, 0x21, 0x00, 0x00, 0x42, 0x00, 0x00,
  0x8C, 0x00, 0x01, 0x10, 0x00, 0x02, 0x60, 0x00, 0x06, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x10, 0x03, 0xFF, 0x80, 0x08, 0x03, 0x80,
  0x20, 0x03, 0x01, 0x80, 0x06, 0x06, 0x00, 0x0C, 0x10, 0x00, 0x10, 0x40,
  0x00, 0x41, 0x00, 0x01, 0x04, 0x00, 0x04, 0x30, 0x00, 0x30, 0xC0, 0x00,
  0xC2, 0x00, 0x02, 0x08, 0x00, 0x18, 0x20, 0x00, 0x40, 0x80, 0x03, 0x06,
  0x00, 0x30, 0x18, 0x03, 0x80, 0x7F, 0xFC, 0x01, 0x00, 0x1C, 0x04, 0x00,
  0x18, 0x10, 0x00, 0x20, 0xC0, 0x00, 0xC2, 0x00, 0x01, 0x08, 0x00, 0x04,
  0x20, 0x00, 0x10, 0x80, 0x00, 0x42, 0x00, 0x01, 0x18, 0x00, 0x04, 0x40,
  0x00, 0x31, 0x00, 0x00, 0x84, 0x00, 0x06, 0x10, 0x00, 0x10, 0xC0, 0x00,
  0x83, 0x00, 0x0C, 0x08, 0x00, 0xE0, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0xE0, 0xE0, 0x07, 0x00, 0x60, 0x18, 0x00, 0x60, 0x60, 0x00, 0x40,
  0x80, 0x00, 0xC3, 0x00, 0x00, 0x84, 0x00, 0x01, 0x18, 0x00, 0x02, 0x20,
  0x00, 0x04, 0xC0, 0x00, 0x09, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x32,
  0x00, 0x00, 0x44, 0x00, 0x00, 0x8C, 0x00, 0x03, 0x18, 0x00, 0x04, 0x10,
  0x00, 0x18, 0x30, 0x00, 0x60, 0x20, 0x01, 0x80, 0x60, 0x06, 0x00, 0x78,
  0x78, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x02, 0x00, 0xE0, 0x02,
  0x00, 0x18, 0x06, 0x00, 0x0C, 0x06, 0x00, 0x04, 0x04, 0x00, 0x06, 0x04,
  0x00, 0x02, 0x04, 0x00, 0x03, 0x04, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x0C,
  0x00, 0x01, 0x08, 0x00, 0x01, 0x08, 0x00, 0x01, 0x08, 0x00, 0x01, 0x08,
  0x00, 0x03, 0x18, 0x00, 0x02, 0x18, 0x00, 0x02, 0x10, 0x00, 0x02, 0x10,
  0x00, 0x02, 0x10, 0x00, 0x02, 0x10, 0x00, 0x06, 0x30, 0x00, 0x04, 0x20,
  0x00, 0x04, 0x20, 0x00, 0x04, 0x20, 0x00, 0x0C, 0x20, 0x00, 0x08, 0x20,
  0x00, 0x08, 0x60, 0x00, 0x18, 0x40, 0x00, 0x10, 0x40, 0x00, 0x30, 0x40,
  0x00, 0x60, 0x40, 0x00, 0xC0, 0xC0, 0x01, 0x80, 0xC0, 0x07, 0x00, 0x80,
  0x3C, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x02, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x10,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x02, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x10,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x78, 0x38, 0x00,
  0xC0, 0x0C, 0x01, 0x80, 0x06, 0x03, 0x00, 0x02, 0x06, 0x00, 0x03, 0x04,
  0x00, 0x03, 0x0C, 0x00, 0x01, 0x08, 0x00, 0x01, 0x18, 0x00, 0x01, 0x10,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x0F, 0xFC, 0x40, 0x00, 0x04, 0x40,
  0x00, 0x04, 0x40, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x08, 0xC0,
  0x00, 0x08, 0x40, 0x00, 0x08, 0x40, 0x00, 0x18, 0x40, 0x00, 0x18, 0x60,
  0x00, 0x18, 0x20, 0x00, 0x10, 0x30, 0x00, 0x70, 0x18, 0x01, 0xC0, 0x0E,
  0x0F, 0x00, 0x03, 0xFC, 0x00, 0x02, 0x00, 0x00, 0x20, 0x40, 0x00, 0x0C,
  0x08, 0x00, 0x01, 0x83, 0x00, 0x00, 0x20, 0x60, 0x00, 0x04, 0x08, 0x00,
  0x00, 0x81, 0x00, 0x00, 0x10, 0x20, 0x00, 0x06, 0x04, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x10, 0x30, 0x00, 0x02, 0x04, 0x00, 0x00, 0x40, 0x80, 0x00,
  0x08, 0x10, 0x00, 0x03, 0x02, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x08, 0x18,
  0x00, 0x01, 0x03, 0xFF, 0xFF, 0xE0, 0x40, 0x00, 0x04, 0x08, 0x00, 0x01,
  0x81, 0x00, 0x00, 0x30, 0x60, 0x00, 0x04, 0x08, 0x00, 0x00, 0x81, 0x00,
  0x00, 0x10, 0x20, 0x00, 0x02, 0x04, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x10,
  0x30, 0x00, 0x02, 0x04, 0x00, 0x00, 0x40, 0x80, 0x00, 0x08, 0x10, 0x00,
  0x03, 0x02, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x08, 0x18, 0x00, 0x01, 0x02,
  0x00, 0x00, 0x20, 0x40, 0x00, 0x04, 0x00, 0x02, 0x0C, 0x18, 0x30, 0x40,
  0x81, 0x06, 0x0C, 0x10, 0x20, 0x40, 0x83, 0x06, 0x08, 0x10, 0x20, 0x41,
  0x83, 0x04, 0x08, 0x10, 0x20, 0xC1, 0x82, 0x04, 0x08, 0x10, 0x60, 0xC1,
  0x02, 0x04, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x02, 0x0C, 0x00, 0x08, 0x20, 0x00, 0x60, 0x80, 0x01, 0x03, 0x00,
  0x04, 0x0C, 0x00, 0x30, 0x10, 0x01, 0x80, 0x60, 0x04, 0x00, 0x80, 0x60,
  0x03, 0x87, 0x00, 0x03, 0xF0, 0x00, 0x02, 0x00, 0x01, 0x80, 0x80, 0x00,
  0x40, 0x20, 0x00, 0x20, 0x18, 0x00, 0x10, 0x06, 0x00, 0x0C, 0x01, 0x00,
  0x06, 0x00, 0x40, 0x03, 0x00, 0x10, 0x01, 0x80, 0x04, 0x00, 0xC0, 0x03,
  0x00, 0x60, 0x00, 0xC0, 0x30, 0x00, 0x20, 0x18, 0x00, 0x08, 0x0C, 0x00,
  0x02, 0x06, 0x00, 0x00, 0x83, 0x00, 0x00, 0x61, 0x80, 0x00, 0x18, 0xC0,
  0x00, 0x04, 0x78, 0x00, 0x01, 0x32, 0x00, 0x00, 0x50, 0xC0, 0x00, 0x18,
  0x10, 0x00, 0x0C, 0x06, 0x00, 0x02, 0x00, 0x80, 0x00, 0x80, 0x30, 0x00,
  0x20, 0x06, 0x00, 0x08, 0x00, 0x80, 0x02, 0x00, 0x30, 0x01, 0x80, 0x04,
  0x00, 0x40, 0x01, 0x80, 0x10, 0x00, 0x20, 0x04, 0x00, 0x0C, 0x01, 0x00,
  0x01, 0x00, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x08, 0x08, 0x00, 0x03, 0x02,
  0x00, 0x00, 0x40, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80,
  0x00, 0xFF, 0xFF, 0x03, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x50, 0x78, 0x00, 0x00, 0x78,
  0x24, 0x00, 0x00, 0x2C, 0x12, 0x00, 0x00, 0x24, 0x09, 0x00, 0x00, 0x12,
  0x04, 0x80, 0x00, 0x11, 0x06, 0x60, 0x00, 0x08, 0x83, 0x30, 0x00, 0x08,
  0xC1, 0x08, 0x00, 0x04, 0x60, 0x84, 0x00, 0x04, 0x20, 0x42, 0x00, 0x06,
  0x10, 0x21, 0x00, 0x02, 0x08, 0x30, 0xC0, 0x03, 0x0C, 0x18, 0x20, 0x01,
  0x06, 0x08, 0x10, 0x01, 0x82, 0x04, 0x08, 0x00, 0x81, 0x02, 0x04, 0x00,
  0xC0, 0x81, 0x02, 0x00, 0x40, 0x41, 0x81, 0x80, 0x60, 0x60, 0x80, 0x40,
  0x20, 0x30, 0x40, 0x20, 0x30, 0x10, 0x20, 0x10, 0x10, 0x08, 0x10, 0x08,
  0x18, 0x04, 0x08, 0x06, 0x08, 0x02, 0x0C, 0x01, 0x0C, 0x03, 0x04, 0x00,
  0x84, 0x01, 0x82, 0x00, 0x46, 0x00, 0x81, 0x00, 0x22, 0x00, 0x40, 0x80,
  0x12, 0x00, 0x20, 0xC0, 0x0D, 0x00, 0x10, 0x60, 0x03, 0x00, 0x18, 0x20,
  0x01, 0x80, 0x0C, 0x10, 0x00, 0x80, 0x04, 0x00, 0x03, 0x00, 0x00, 0x20,
  0x60, 0x00, 0x04, 0x0C, 0x00, 0x01, 0x83, 0xC0, 0x00, 0x30, 0x68, 0x00,
  0x04, 0x0D, 0x00, 0x00, 0x81, 0x10, 0x00, 0x10, 0x22, 0x00, 0x02, 0x04,
  0x60, 0x00, 0xC1, 0x84, 0x00, 0x18, 0x30, 0x80, 0x02, 0x04, 0x18, 0x00,
  0x40, 0x81, 0x00, 0x08, 0x10, 0x30, 0x01, 0x02, 0x02, 0x00, 0x60, 0xC0,
  0x40, 0x0C, 0x18, 0x0C, 0x01, 0x02, 0x00, 0x80, 0x20, 0x40, 0x10, 0x04,
  0x08, 0x01, 0x00, 0x81, 0x00, 0x20, 0x30, 0x60, 0x06, 0x06, 0x0C, 0x00,
  0x40, 0x81, 0x00, 0x08, 0x10, 0x20, 0x01, 0x82, 0x04, 0x00, 0x10, 0xC0,
  0x80, 0x03, 0x18, 0x30, 0x00, 0x23, 0x06, 0x00, 0x04, 0x40, 0x80, 0x00,
  0xC8, 0x10, 0x00, 0x09, 0x02, 0x00, 0x01, 0x60, 0xC0, 0x00, 0x1C, 0x18,
  0x00, 0x03, 0x83, 0x00, 0x00, 0x60, 0x40, 0x00, 0x04, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x70, 0x70, 0x01, 0xC0, 0x18, 0x03, 0x00, 0x0C, 0x06, 0x00,
  0x04, 0x04, 0x00, 0x02, 0x0C, 0x00, 0x02, 0x08, 0x00, 0x02, 0x10, 0x00,
  0x03, 0x10, 0x00, 0x03, 0x30, 0x00, 0x03, 0x20, 0x00, 0x03, 0x20, 0x00,
  0x03, 0x20, 0x00, 0x02, 0x60, 0x00, 0x02, 0x60, 0x00, 0x02, 0x40, 0x00,
  0x02, 0x40, 0x00, 0x06, 0x40, 0x00, 0x06, 0x40, 0x00, 0x04, 0xC0, 0x00,
  0x04, 0xC0, 0x00, 0x04, 0x80, 0x00, 0x04, 0x80, 0x00, 0x0C, 0x80, 0x00,
  0x08, 0x80, 0x00, 0x08, 0x80, 0x00, 0x18, 0x80, 0x00, 0x10, 0x80, 0x00,
  0x30, 0xC0, 0x00, 0x20, 0x40, 0x00, 0x60, 0x40, 0x00, 0xC0, 0x20, 0x01,
  0x80, 0x30, 0x03, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFF,
  0xC0, 0x02, 0x00, 0x70, 0x02, 0x00, 0x18, 0x06, 0x00, 0x0C, 0x06, 0x00,
  0x06, 0x04, 0x00, 0x06, 0x04, 0x00, 0x02, 0x04, 0x00, 0x02, 0x04, 0x00,
  0x02, 0x0C, 0x00, 0x02, 0x0C, 0x00, 0x02, 0x08, 0x00, 0x02, 0x08, 0x00,
  0x06, 0x08, 0x00, 0x04, 0x08, 0x00, 0x0C, 0x18, 0x00, 0x08, 0x18, 0x00,
  0x18, 0x10, 0x00, 0x30, 0x10, 0x00, 0x60, 0x10, 0x03, 0xC0, 0x1F, 0xFE,
  0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x70, 0x70, 0x01, 0xC0, 0x18, 0x03, 0x00, 0x0C, 0x06, 0x00,
  0x04, 0x04, 0x00, 0x02, 0x0C, 0x00, 0x02, 0x08, 0x00, 0x02, 0x10, 0x00,
  0x03, 0x10, 0x00, 0x03, 0x30, 0x00, 0x03, 0x20, 0x00, 0x03, 0x20, 0x00,
  0x03, 0x20, 0x00, 0x02, 0x60, 0x00, 0x02, 0x60, 0x00, 0x02, 0x40, 0x00,
  0x02, 0x40, 0x00, 0x06, 0x40, 0x00, 0x06, 0x40, 0x00, 0x04, 0xC0, 0x00,
  0x04, 0xC0, 0x00, 0x04, 0x80, 0x00, 0x04, 0x80, 0x00, 0x0C, 0x80, 0x00,
  0x08, 0x80, 0x00, 0x08, 0x80, 0x00, 0x18, 0x80, 0x00, 0x10, 0x80, 0x00,
  0x30, 0xC0, 0x00, 0x20, 0x40, 0x00, 0x60, 0x40, 0x00, 0xC0, 0x20, 0x01,
  0x80, 0x30, 0x03, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x40, 0x03, 0xFF, 0xC0, 0x02, 0x00, 0x70, 0x06, 0x00,
  0x18, 0x06, 0x00, 0x0C, 0x04, 0x00, 0x06, 0x04, 0x00, 0x02, 0x04, 0x00,
  0x02, 0x04, 0x00, 0x02, 0x0C, 0x00, 0x02, 0x0C, 0x00, 0x02, 0x08, 0x00,
  0x02, 0x08, 0x00, 0x02, 0x08, 0x00, 0x06, 0x08, 0x00, 0x04, 0x18, 0x00,
  0x04, 0x18, 0x00, 0x08, 0x10, 0x00, 0x18, 0x10, 0x00, 0x30, 0x10, 0x00,
  0x60, 0x10, 0x01, 0x80, 0x3F, 0xFE, 0x00, 0x30, 0x02, 0x00, 0x20, 0x03,
  0x00, 0x20, 0x03, 0x00, 0x20, 0x01, 0x00, 0x20, 0x01, 0x80, 0x60, 0x01,
  0x80, 0x60, 0x00, 0x80, 0x40, 0x00, 0xC0, 0x40, 0x00, 0x40, 0x40, 0x00,
  0x40, 0x40, 0x00, 0x60, 0xC0, 0x00, 0x20, 0x80, 0x00, 0x20, 0x80, 0x00,
  0x30, 0x80, 0x00, 0x10, 0x00, 0x0F, 0xE0, 0x00, 0x78, 0x38, 0x00, 0xC0,
  0x0C, 0x01, 0x80, 0x06, 0x03, 0x00, 0x02, 0x06, 0x00, 0x02, 0x04, 0x00,
  0x03, 0x04, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x08, 0xC0, 0x00,
  0x08, 0xC0, 0x00, 0x08, 0xC0, 0x00, 0x18, 0x40, 0x00, 0x10, 0x40, 0x00,
  0x30, 0x60, 0x00, 0x60, 0x30, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x0E, 0x0F,
  0x00, 0x03, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x04, 0x00, 0x01, 0x86, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x41, 0x00, 0x00,
  0x20, 0x80, 0x00, 0x10, 0x40, 0x00, 0x08, 0x20, 0x00, 0x0C, 0x30, 0x00,
  0x04, 0x18, 0x00, 0x02, 0x08, 0x00, 0x01, 0x04, 0x00, 0x00, 0x82, 0x00,
  0x00, 0x41, 0x00, 0x00, 0x61, 0x80, 0x00, 0x20, 0xC0, 0x00, 0x10, 0x40,
  0x00, 0x08, 0x20, 0x00, 0x04, 0x10, 0x00, 0x02, 0x08, 0x00, 0x03, 0x0C,
  0x00, 0x01, 0x04, 0x00, 0x00, 0x82, 0x00, 0x00, 0x41, 0x00, 0x00, 0x20,
  0x80, 0x00, 0x30, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x08, 0x30, 0x00, 0x04,
  0x18, 0x00, 0x02, 0x0C, 0x00, 0x02, 0x06, 0x00, 0x01, 0x01, 0x00, 0x01,
  0x80, 0xC0, 0x01, 0x80, 0x60, 0x01, 0x80, 0x18, 0x01, 0x80, 0x07, 0x87,
  0x80, 0x00, 0xFE, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x40, 0x00, 0x02, 0x40,
  0x00, 0x06, 0x40, 0x00, 0x04, 0x40, 0x00, 0x0C, 0x60, 0x00, 0x08, 0x60,
  0x00, 0x18, 0x20, 0x00, 0x10, 0x20, 0x00, 0x30, 0x20, 0x00, 0x20, 0x20,
  0x00, 0x20, 0x20, 0x00, 0x60, 0x30, 0x00, 0x40, 0x30, 0x00, 0xC0, 0x10,
  0x00, 0x80, 0x10, 0x01, 0x80, 0x10, 0x01, 0x00, 0x10, 0x03, 0x00, 0x10,
  0x02, 0x00, 0x18, 0x06, 0x00, 0x18, 0x04, 0x00, 0x08, 0x04, 0x00, 0x08,
  0x08, 0x00, 0x08, 0x08, 0x00, 0x08, 0x18, 0x00, 0x0C, 0x10, 0x00, 0x0C,
  0x30, 0x00, 0x04, 0x20, 0x00, 0x04, 0x60, 0x00, 0x04, 0x40, 0x00, 0x04,
  0xC0, 0x00, 0x04, 0x80, 0x00, 0x06, 0x80, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18,
  0x00, 0x0A, 0x00, 0x03, 0x00, 0x03, 0x60, 0x00, 0xA0, 0x00, 0x4C, 0x00,
  0x14, 0x00, 0x09, 0x80, 0x06, 0xC0, 0x03, 0x30, 0x00, 0x98, 0x00, 0x46,
  0x00, 0x11, 0x00, 0x08, 0xC0, 0x06, 0x20, 0x03, 0x08, 0x00, 0x84, 0x00,
  0x41, 0x00, 0x30, 0x80, 0x18, 0x20, 0x04, 0x10, 0x03, 0x04, 0x00, 0x82,
  0x00, 0x40, 0x80, 0x30, 0x40, 0x18, 0x10, 0x04, 0x08, 0x02, 0x02, 0x01,
  0x81, 0x00, 0x40, 0x40, 0x20, 0x30, 0x18, 0x08, 0x04, 0x06, 0x02, 0x01,
  0x01, 0x80, 0xC0, 0x40, 0x30, 0x20, 0x08, 0x18, 0x06, 0x0C, 0x01, 0x02,
  0x00, 0xC1, 0x00, 0x20, 0xC0, 0x18, 0x20, 0x04, 0x10, 0x03, 0x0C, 0x00,
  0x82, 0x00, 0x61, 0x00, 0x10, 0xC0, 0x04, 0x60, 0x02, 0x10, 0x00, 0x88,
  0x00, 0x42, 0x00, 0x11, 0x00, 0x0C, 0xC0, 0x02, 0x60, 0x01, 0x90, 0x00,
  0x48, 0x00, 0x36, 0x00, 0x0B, 0x00, 0x02, 0x80, 0x01, 0x40, 0x00, 0x50,
  0x00, 0x28, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x30, 0x10,
  0x00, 0x06, 0x01, 0x80, 0x00, 0x40, 0x08, 0x00, 0x08, 0x00, 0xC0, 0x01,
  0x80, 0x0C, 0x00, 0x30, 0x00, 0x40, 0x02, 0x00, 0x06, 0x00, 0x60, 0x00,
  0x20, 0x0C, 0x00, 0x03, 0x00, 0x80, 0x00, 0x10, 0x10, 0x00, 0x01, 0x03,
  0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x84, 0x00, 0x00, 0x0C, 0x80, 0x00,
  0x00, 0x58, 0x00, 0x00, 0x05, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x19, 0x00, 0x00, 0x01, 0x18, 0x00,
  0x00, 0x20, 0x80, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x40, 0x40, 0x00, 0x08,
  0x04, 0x00, 0x01, 0x80, 0x60, 0x00, 0x30, 0x02, 0x00, 0x02, 0x00, 0x30,
  0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x10, 0x01, 0x80, 0x01, 0x80, 0x10,
  0x00, 0x08, 0x03, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x04, 0x04, 0x00, 0x00,
  0x60, 0x80, 0x00, 0x07, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x22, 0x00, 0x00,
  0xC6, 0x00, 0x03, 0x0C, 0x00, 0x04, 0x08, 0x00, 0x18, 0x18, 0x00, 0x60,
  0x30, 0x00, 0x80, 0x20, 0x03, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x10, 0x00,
  0x80, 0x60, 0x01, 0x00, 0x80, 0x03, 0x02, 0x00, 0x02, 0x0C, 0x00, 0x04,
  0x10, 0x00, 0x0C, 0x40, 0x00, 0x09, 0x80, 0x00, 0x12, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xF8, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x80,
  0x0C, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x60, 0x03,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0xF8, 0x00, 0xC1, 0x81, 0x02, 0x04, 0x08, 0x10, 0x30, 0x60, 0x40, 0x81,
  0x02, 0x04, 0x0C, 0x18, 0x10, 0x20, 0x40, 0x81, 0x03, 0x06, 0x04, 0x08,
  0x10, 0x20, 0x40, 0xC1, 0x81, 0x02, 0x04, 0x08, 0x10, 0x30, 0x60, 0x40,
  0x80, 0x01, 0xF8, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x03, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x18,
  0x00, 0xC0, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x06, 0x00,
  0x30, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x80, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0xFC, 0x00, 0x00, 0x40, 0x06,
  0x00, 0x30, 0x02, 0xC0, 0x12, 0x01, 0x10, 0x08, 0x80, 0x84, 0x04, 0x20,
  0x41, 0x82, 0x0C, 0x20, 0x21, 0x01, 0x10, 0x08, 0x80, 0x48, 0x03, 0x40,
  0x1C, 0x00, 0x40, 0xFF, 0xFF, 0x80, 0xC2, 0x18, 0x43, 0x08, 0x60, 0x00,
  0x7E, 0x00, 0x38, 0x70, 0x1C, 0x03, 0x02, 0x00, 0x20, 0x80, 0x06, 0x30,
  0x00, 0xC4, 0x00, 0x18, 0x80, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x1F, 0xFC, 0x1F, 0x01, 0x06, 0x00, 0x21, 0x80,
  0x04, 0x60, 0x00, 0x98, 0x00, 0x32, 0x00, 0x06, 0x40, 0x00, 0x88, 0x00,
  0x31, 0x00, 0x0E, 0x20, 0x03, 0x46, 0x00, 0xD8, 0x70, 0xE3, 0x03, 0xF0,
  0x60, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x3F, 0x00, 0xCE, 0x1C,
  0x0D, 0x80, 0x60, 0xA0, 0x02, 0x0C, 0x00, 0x30, 0xC0, 0x03, 0x08, 0x00,
  0x11, 0x80, 0x01, 0x18, 0x00, 0x11, 0x00, 0x01, 0x10, 0x00, 0x31, 0x00,
  0x03, 0x10, 0x00, 0x23, 0x00, 0x02, 0x30, 0x00, 0x22, 0x00, 0x02, 0x20,
  0x00, 0x62, 0x00, 0x04, 0x20, 0x00, 0x46, 0x00, 0x0C, 0x60, 0x00, 0x86,
  0x00, 0x18, 0x70, 0x03, 0x05, 0x80, 0x60, 0x4E, 0x1C, 0x0C, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0xE1, 0xC0, 0x60, 0x18, 0x20, 0x02, 0x10, 0x00, 0xCC,
  0x00, 0x12, 0x00, 0x05, 0x80, 0x01, 0x40, 0x00, 0x50, 0x00, 0x04, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x48, 0x00, 0x12, 0x00, 0x0C, 0x80, 0x02, 0x30,
  0x01, 0x84, 0x00, 0xC1, 0x80, 0x60, 0x38, 0x70, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0xFC, 0x20, 0x0E,
  0x18, 0x80, 0x60, 0x12, 0x03, 0x00, 0x28, 0x18, 0x00, 0x60, 0x40, 0x01,
  0x83, 0x00, 0x04, 0x08, 0x00, 0x10, 0x20, 0x00, 0x41, 0x80, 0x01, 0x04,
  0x00, 0x0C, 0x10, 0x00, 0x30, 0x40, 0x00, 0x81, 0x00, 0x02, 0x0C, 0x00,
  0x08, 0x30, 0x00, 0x20, 0x80, 0x01, 0x82, 0x00, 0x06, 0x08, 0x00, 0x10,
  0x20, 0x00, 0x40, 0xC0, 0x01, 0x03, 0x00, 0x0C, 0x04, 0x00, 0x70, 0x18,
  0x06, 0x80, 0x38, 0x72, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x38,
  0x70, 0x0C, 0x03, 0x03, 0x00, 0x20, 0xC0, 0x06, 0x30, 0x00, 0x44, 0x00,
  0x09, 0x80, 0x01, 0x20, 0x00, 0x24, 0x00, 0x05, 0x80, 0x01, 0xBF, 0xFF,
  0xF4, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00,
  0x08, 0x00, 0x41, 0x80, 0x30, 0x1C, 0x1C, 0x00, 0xFE, 0x00, 0x00, 0x08,
  0x00, 0xFC, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x03,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x0F, 0xFC,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x3F, 0x0C, 0x03, 0x86, 0x20, 0x18, 0x04, 0x80, 0xC0, 0x0A, 0x06,
  0x00, 0x18, 0x10, 0x00, 0x60, 0xC0, 0x01, 0x82, 0x00, 0x04, 0x08, 0x00,
  0x10, 0x60, 0x00, 0x41, 0x00, 0x01, 0x04, 0x00, 0x0C, 0x10, 0x00, 0x20,
  0xC0, 0x00, 0x83, 0x00, 0x02, 0x0C, 0x00, 0x08, 0x20, 0x00, 0x60, 0x80,
  0x01, 0x82, 0x00, 0x04, 0x08, 0x00, 0x10, 0x30, 0x00, 0x40, 0xC0, 0x03,
  0x01, 0x00, 0x1C, 0x06, 0x01, 0xB0, 0x0E, 0x1C, 0x80, 0x0F, 0xC2, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x80, 0x40, 0x06, 0x01, 0x80, 0x30, 0x01, 0x83, 0x80,
  0x03, 0xF8, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x41, 0xF0, 0x18, 0xE1,
  0x83, 0x30, 0x18, 0x4C, 0x01, 0x0B, 0x00, 0x21, 0x40, 0x04, 0x30, 0x00,
  0x8E, 0x00, 0x11, 0x80, 0x02, 0x30, 0x00, 0x44, 0x00, 0x08, 0x80, 0x03,
  0x10, 0x00, 0x66, 0x00, 0x08, 0xC0, 0x01, 0x10, 0x00, 0x22, 0x00, 0x04,
  0x40, 0x01, 0x88, 0x00, 0x33, 0x00, 0x04, 0x60, 0x00, 0x88, 0x00, 0x11,
  0x00, 0x02, 0x20, 0x00, 0xC4, 0x00, 0x11, 0x80, 0x02, 0x00, 0x02, 0x06,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x08, 0x08, 0x08,
  0x18, 0x18, 0x10, 0x10, 0x10, 0x30, 0x30, 0x20, 0x20, 0x20, 0x20, 0x60,
  0x60, 0x40, 0x40, 0x40, 0x40, 0xC0, 0xC0, 0x80, 0x80, 0x80, 0x00, 0x01,
  0x00, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01,
  0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0xC0, 0x07, 0xC0, 0x00,
  0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x30, 0xC0, 0x06, 0x0C,
  0x00, 0x80, 0x80, 0x10, 0x08, 0x02, 0x00, 0x80, 0xC0, 0x08, 0x18, 0x01,
  0x83, 0x00, 0x18, 0x60, 0x01, 0x0C, 0x00, 0x11, 0x80, 0x01, 0x30, 0x00,
  0x16, 0x80, 0x03, 0x8C, 0x00, 0x30, 0x40, 0x02, 0x06, 0x00, 0x20, 0x20,
  0x02, 0x03, 0x00, 0x20, 0x10, 0x06, 0x01, 0x80, 0x60, 0x08, 0x04, 0x00,
  0xC0, 0x40, 0x04, 0x04, 0x00, 0x60, 0x40, 0x02, 0x0C, 0x00, 0x30, 0x02,
  0x04, 0x08, 0x30, 0x60, 0x81, 0x02, 0x04, 0x18, 0x30, 0x40, 0x81, 0x02,
  0x0C, 0x18, 0x20, 0x40, 0x81, 0x06, 0x0C, 0x10, 0x20, 0x40, 0x83, 0x06,
  0x08, 0x10, 0x20, 0x41, 0x83, 0x04, 0x08, 0x10, 0x00, 0x04, 0x1F, 0x00,
  0x7E, 0x03, 0x18, 0x70, 0x70, 0xC0, 0xCC, 0x04, 0x30, 0x08, 0x24, 0x01,
  0x98, 0x02, 0x0A, 0x00, 0x2C, 0x00, 0xC3, 0x80, 0x0A, 0x00, 0x11, 0xC0,
  0x03, 0x00, 0x04, 0x70, 0x00, 0xC0, 0x01, 0x18, 0x00, 0x20, 0x00, 0xC6,
  0x00, 0x08, 0x00, 0x31, 0x00, 0x02, 0x00, 0x08, 0x40, 0x01, 0x80, 0x02,
  0x30, 0x00, 0x40, 0x00, 0x8C, 0x00, 0x10, 0x00, 0x22, 0x00, 0x04, 0x00,
  0x18, 0x80, 0x01, 0x00, 0x06, 0x20, 0x00, 0xC0, 0x01, 0x08, 0x00, 0x30,
  0x00, 0x46, 0x00, 0x08, 0x00, 0x11, 0x80, 0x02, 0x00, 0x04, 0x40, 0x00,
  0x80, 0x03, 0x10, 0x00, 0x20, 0x00, 0xC4, 0x00, 0x18, 0x00, 0x21, 0x00,
  0x04, 0x00, 0x08, 0xC0, 0x01, 0x00, 0x02, 0x30, 0x00, 0x40, 0x00, 0x80,
  0x04, 0x1F, 0x00, 0x8E, 0x38, 0x33, 0x01, 0x86, 0xC0, 0x10, 0xB0, 0x02,
  0x14, 0x00, 0x43, 0x00, 0x08, 0x60, 0x01, 0x18, 0x00, 0x23, 0x00, 0x04,
  0x40, 0x00, 0x88, 0x00, 0x31, 0x00, 0x06, 0x60, 0x00, 0x8C, 0x00, 0x11,
  0x00, 0x02, 0x20, 0x00, 0x44, 0x00, 0x18, 0x80, 0x03, 0x30, 0x00, 0x46,
  0x00, 0x08, 0x80, 0x01, 0x10, 0x00, 0x22, 0x00, 0x0C, 0x40, 0x01, 0x18,
  0x00, 0x20, 0x00, 0xFE, 0x00, 0x70, 0x60, 0x18, 0x06, 0x06, 0x00, 0x61,
  0x80, 0x04, 0x20, 0x00, 0xCC, 0x00, 0x19, 0x00, 0x01, 0x20, 0x00, 0x2C,
  0x00, 0x05, 0x00, 0x00, 0xA0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xA0,
  0x00, 0x14, 0x00, 0x02, 0x80, 0x00, 0xD0, 0x00, 0x12, 0x00, 0x02, 0x40,
  0x00, 0xCC, 0x00, 0x10, 0x80, 0x06, 0x18, 0x01, 0x81, 0x00, 0x60, 0x3C,
  0x38, 0x01, 0xFC, 0x00, 0x02, 0x1F, 0x80, 0x13, 0x87, 0x01, 0xB0, 0x0C,
  0x0E, 0x00, 0x20, 0x60, 0x01, 0x83, 0x00, 0x0C, 0x10, 0x00, 0x21, 0x80,
  0x01, 0x0C, 0x00, 0x08, 0x40, 0x00, 0x42, 0x00, 0x06, 0x10, 0x00, 0x30,
  0x80, 0x01, 0x0C, 0x00, 0x08, 0x60, 0x00, 0x42, 0x00, 0x02, 0x10, 0x00,
  0x30, 0x80, 0x01, 0x04, 0x00, 0x08, 0x60, 0x00, 0xC3, 0x00, 0x04, 0x18,
  0x00, 0x60, 0xE0, 0x06, 0x05, 0x80, 0x60, 0x27, 0x0E, 0x03, 0x0F, 0xC0,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x30, 0x38, 0x62, 0x06, 0x01, 0xA0, 0xC0,
  0x0A, 0x18, 0x00, 0x61, 0x00, 0x06, 0x30, 0x00, 0x42, 0x00, 0x04, 0x20,
  0x00, 0x46, 0x00, 0x04, 0x40, 0x00, 0x44, 0x00, 0x0C, 0x40, 0x00, 0x8C,
  0x00, 0x08, 0xC0, 0x00, 0x8C, 0x00, 0x08, 0x80, 0x01, 0x88, 0x00, 0x18,
  0x80, 0x01, 0x08, 0x00, 0x10, 0xC0, 0x01, 0x0C, 0x00, 0x30, 0x40, 0x07,
  0x06, 0x01, 0xB0, 0x38, 0x72, 0x00, 0xFC, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x04, 0x3E, 0x08,
  0xC0, 0x36, 0x00, 0x68, 0x00, 0xA0, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0xE1, 0xC0, 0x60, 0x18, 0x20, 0x03, 0x18, 0x00, 0x44, 0x00, 0x11,
  0x00, 0x04, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03,
  0x00, 0x00, 0x40, 0x00, 0x12, 0x00, 0x04, 0x80, 0x03, 0x30, 0x00, 0x84,
  0x00, 0x61, 0x80, 0x30, 0x38, 0x78, 0x03, 0xF0, 0x00, 0x06, 0x01, 0x80,
  0x40, 0x10, 0x04, 0x03, 0x00, 0xC0, 0x20, 0xFF, 0xC2, 0x00, 0x80, 0x60,
  0x18, 0x04, 0x01, 0x00, 0x40, 0x10, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x01, 0x80, 0x60, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x60, 0x0F, 0x00, 0x10, 0x00, 0x66, 0x00, 0x08, 0xC0, 0x01, 0x10,
  0x00, 0x22, 0x00, 0x04, 0x40, 0x01, 0x88, 0x00, 0x33, 0x00, 0x04, 0x60,
  0x00, 0x88, 0x00, 0x11, 0x00, 0x02, 0x20, 0x00, 0xC4, 0x00, 0x11, 0x80,
  0x02, 0x20, 0x00, 0x44, 0x00, 0x08, 0x80, 0x03, 0x10, 0x00, 0x62, 0x00,
  0x08, 0x40, 0x03, 0x08, 0x00, 0x61, 0x00, 0x14, 0x30, 0x07, 0x82, 0x01,
  0xB0, 0x70, 0xE4, 0x03, 0xF0, 0x80, 0xC0, 0x00, 0x70, 0x00, 0x24, 0x00,
  0x09, 0x00, 0x06, 0x40, 0x01, 0x10, 0x00, 0xC6, 0x00, 0x21, 0x80, 0x18,
  0x20, 0x04, 0x08, 0x03, 0x02, 0x00, 0x80, 0x80, 0x60, 0x30, 0x10, 0x0C,
  0x0C, 0x01, 0x02, 0x00, 0x41, 0x80, 0x10, 0x40, 0x04, 0x30, 0x01, 0x88,
  0x00, 0x66, 0x00, 0x09, 0x00, 0x02, 0xC0, 0x00, 0xA0, 0x00, 0x28, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x06, 0x00, 0x3C, 0x00, 0x60, 0x02,
  0xC0, 0x0A, 0x00, 0x6C, 0x00, 0xA0, 0x04, 0xC0, 0x1A, 0x00, 0xCC, 0x01,
  0x20, 0x0C, 0x40, 0x32, 0x00, 0x84, 0x02, 0x20, 0x18, 0x40, 0x22, 0x01,
  0x04, 0x04, 0x20, 0x30, 0x40, 0x42, 0x02, 0x04, 0x0C, 0x30, 0x60, 0x40,
  0x83, 0x06, 0x04, 0x18, 0x30, 0x40, 0x41, 0x01, 0x0C, 0x06, 0x30, 0x10,
  0x80, 0x62, 0x01, 0x18, 0x06, 0x60, 0x11, 0x80, 0x64, 0x01, 0x10, 0x06,
  0x40, 0x13, 0x00, 0x2C, 0x01, 0x20, 0x02, 0x80, 0x16, 0x00, 0x38, 0x01,
  0xC0, 0x03, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00,
  0x06, 0x00, 0x08, 0x30, 0x00, 0x80, 0x80, 0x0C, 0x06, 0x00, 0xC0, 0x10,
  0x04, 0x00, 0xC0, 0x40, 0x02, 0x06, 0x00, 0x18, 0x60, 0x00, 0x42, 0x00,
  0x02, 0x20, 0x00, 0x1B, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x01, 0x60, 0x00, 0x19, 0x00, 0x01, 0x8C, 0x00, 0x08, 0x20, 0x00,
  0x81, 0x00, 0x0C, 0x0C, 0x00, 0xC0, 0x20, 0x04, 0x01, 0x80, 0x40, 0x04,
  0x06, 0x00, 0x30, 0x60, 0x00, 0x82, 0x00, 0x06, 0x00, 0x06, 0x00, 0x02,
  0x04, 0x00, 0x0C, 0x08, 0x00, 0x10, 0x10, 0x00, 0x60, 0x20, 0x00, 0x80,
  0x60, 0x03, 0x00, 0xC0, 0x04, 0x00, 0x80, 0x18, 0x01, 0x00, 0x20, 0x02,
  0x00, 0xC0, 0x04, 0x01, 0x00, 0x08, 0x06, 0x00, 0x18, 0x08, 0x00, 0x30,
  0x30, 0x00, 0x20, 0x40, 0x00, 0x41, 0x80, 0x00, 0x82, 0x00, 0x01, 0x0C,
  0x00, 0x03, 0x10, 0x00, 0x06, 0x60, 0x00, 0x04, 0x80, 0x00, 0x0B, 0x00,
  0x00, 0x14, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x02,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00,
  0x40, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00,
  0x40, 0x00, 0x80, 0x02, 0x00, 0x0C, 0x00, 0xE0, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x00, 0x03, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x03, 0x03, 0x02,
  0x02, 0x02, 0x06, 0x06, 0x06, 0x06, 0x04, 0x04, 0x04, 0x0C, 0x0C, 0x0C,
  0x08, 0x08, 0x08, 0x08, 0x18, 0x18, 0x18, 0x10, 0x10, 0x10, 0x30, 0x30,
  0x30, 0x20, 0x20, 0x20, 0x20, 0x60, 0x60, 0x60, 0x40, 0x40, 0x40, 0xC0,
  0xC0, 0xC0, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C,
  0x00, 0x0E, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00,
  0x30, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00,
  0x30, 0x00, 0x40, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x01, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x31, 0x80, 0x04, 0xC1, 0x80, 0x19, 0x01, 0x80,
  0x24, 0x01, 0x80, 0xC8, 0x01, 0x81, 0x30, 0x01, 0x8C, 0x40, 0x01, 0xF0,
};

const GFXglyph RobotoCondensed_ThinItalic50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 8, 36, 9, 1, -36 },
  { 37, 8, 10, 13, 5, -38 },
  { 47, 25, 36, 24, 1, -36 },
  { 160, 20, 46, 23, 2, -41 },
  { 275, 23, 36, 32, 5, -36 },
  { 379, 23, 37, 26, 1, -36 },
  { 486, 3, 10, 8, 5, -38 },
  { 490, 14, 51, 13, 2, -40 },
  { 580, 14, 51, 14, -3, -40 },
  { 670, 19, 19, 20, 3, -36 },
  { 716, 20, 25, 24, 2, -29 },
  { 779, 5, 10, 9, -1, -4 },
  { 786, 9, 1, 13, 2, -17 },
  { 788, 3, 3, 11, 1, -3 },
  { 790, 20, 39, 17, -2, -36 },
  { 888, 20, 36, 23, 2, -36 },
  { 978, 10, 36, 23, 7, -36 },
  { 1023, 21, 36, 23, 1, -36 },
  { 1118, 21, 36, 23, 1, -36 },
  { 1213, 21, 36, 23, 1, -36 },
  { 1308, 21, 36, 23, 3, -36 },
  { 1403, 19, 36, 23, 2, -36 },
  { 1489, 20, 36, 23, 4, -36 },
  { 1579, 22, 36, 23, 1, -36 },
  { 1678, 18, 36, 23, 4, -36 },
  { 1759, 7, 26, 9, 1, -26 },
  { 1782, 10, 32, 9, -2, -26 },
  { 1822, 19, 20, 22, 2, -26 },
  { 1870, 18, 11, 24, 3, -22 },
  { 1895, 19, 19, 22, 1, -26 },
  { 1941, 15, 36, 19, 4, -36 },
  { 2009, 35, 45, 39, 2, -34 },
  { 2206, 23, 36, 26, -1, -36 },
  { 2310, 22, 36, 26, 2, -36 },
  { 2409, 23, 36, 28, 3, -36 },
  { 2513, 24, 36, 28, 2, -36 },
  { 2621, 24, 36, 24, 2, -36 },
  { 2729, 24, 36, 24, 2, -36 },
  { 2837, 24, 36, 29, 3, -36 },
  { 2945, 27, 36, 30, 2, -36 },
  { 3067, 7, 36, 12, 3, -36 },
  { 3099, 22, 36, 24, 1, -36 },
  { 3198, 26, 36, 27, 2, -36 },
  { 3315, 16, 36, 22, 2, -36 },
  { 3387, 33, 36, 36, 2, -36 },
  { 3536, 27, 36, 30, 2, -36 },
  { 3658, 24, 36, 28, 3, -36 },
  { 3766, 24, 36, 26, 2, -36 },
  { 3874, 24, 42, 28, 3, -36 },
  { 4000, 24, 36, 28, 2, -36 },
  { 4108, 24, 36, 25, 1, -36 },
  { 4216, 23, 36, 25, 5, -36 },
  { 4320, 25, 36, 28, 3, -36 },
  { 4433, 24, 36, 26, 4, -36 },
  { 4541, 35, 36, 38, 5, -36 },
  { 4699, 28, 36, 26, -1, -36 },
  { 4825, 23, 36, 25, 5, -36 },
  { 4929, 26, 36, 26, 0, -36 },
  { 5046, 13, 49, 10, 1, -41 },
  { 5126, 7, 39, 17, 5, -36 },
  { 5161, 13, 49, 10, -3, -41 },
  { 5241, 13, 18, 18, 3, -36 },
  { 5271, 17, 1, 18, -2, 0 },
  { 5274, 5, 7, 13, 7, -38 },
  { 5279, 19, 26, 23, 1, -26 },
  { 5341, 20, 38, 23, 1, -38 },
  { 5436, 18, 26, 22, 2, -26 },
  { 5495, 22, 38, 23, 2, -38 },
  { 5600, 19, 26, 22, 1, -26 },
  { 5662, 15, 39, 14, 3, -39 },
  { 5736, 22, 36, 24, 0, -26 },
  { 5835, 19, 38, 23, 1, -38 },
  { 5926, 8, 36, 9, 2, -36 },
  { 5962, 17, 46, 10, -7, -36 },
  { 6060, 20, 38, 20, 1, -38 },
  { 6155, 7, 38, 9, 2, -38 },
  { 6189, 34, 26, 38, 1, -26 },
  { 6300, 19, 26, 23, 1, -26 },
  { 6362, 19, 26, 23, 2, -26 },
  { 6424, 21, 36, 23, 0, -26 },
  { 6519, 20, 36, 23, 2, -26 },
  { 6609, 15, 26, 15, 1, -26 },
  { 6658, 18, 26, 21, 1, -26 },
  { 6717, 10, 34, 14, 3, -34 },
  { 6760, 19, 26, 23, 3, -26 },
  { 6822, 18, 26, 21, 3, -26 },
  { 6881, 28, 26, 32, 4, -26 },
  { 6972, 21, 26, 21, -1, -26 },
  { 7041, 23, 36, 21, -2, -26 },
  { 7145, 20, 26, 21, 0, -26 },
  { 7210, 15, 50, 14, 2, -39 },
  { 7304, 8, 43, 10, 1, -36 },
  { 7347, 15, 50, 14, -3, -39 },
  { 7441, 23, 8, 29, 3, -19 },
};

const GFXfont RobotoCondensed_ThinItalic50pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ThinItalic50pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ThinItalic50pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _ROBOTOCONDENSED_THINITALIC50PT7B_H_
