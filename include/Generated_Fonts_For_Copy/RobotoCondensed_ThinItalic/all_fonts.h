#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated_Fonts_For_Copy/RobotoCondensed_ThinItalic
// Headers: 67

#include "RobotoCondensed_ThinItalic6pt7b.h"
#include "RobotoCondensed_ThinItalic7pt7b.h"
#include "RobotoCondensed_ThinItalic8pt7b.h"
#include "RobotoCondensed_ThinItalic9pt7b.h"
#include "RobotoCondensed_ThinItalic10pt7b.h"
#include "RobotoCondensed_ThinItalic11pt7b.h"
#include "RobotoCondensed_ThinItalic12pt7b.h"
#include "RobotoCondensed_ThinItalic13pt7b.h"
#include "RobotoCondensed_ThinItalic14pt7b.h"
#include "RobotoCondensed_ThinItalic15pt7b.h"
#include "RobotoCondensed_ThinItalic16pt7b.h"
#include "RobotoCondensed_ThinItalic17pt7b.h"
#include "RobotoCondensed_ThinItalic18pt7b.h"
#include "RobotoCondensed_ThinItalic19pt7b.h"
#include "RobotoCondensed_ThinItalic20pt7b.h"
#include "RobotoCondensed_ThinItalic21pt7b.h"
#include "RobotoCondensed_ThinItalic22pt7b.h"
#include "RobotoCondensed_ThinItalic23pt7b.h"
#include "RobotoCondensed_ThinItalic24pt7b.h"
#include "RobotoCondensed_ThinItalic25pt7b.h"
#include "RobotoCondensed_ThinItalic26pt7b.h"
#include "RobotoCondensed_ThinItalic27pt7b.h"
#include "RobotoCondensed_ThinItalic28pt7b.h"
#include "RobotoCondensed_ThinItalic29pt7b.h"
#include "RobotoCondensed_ThinItalic30pt7b.h"
#include "RobotoCondensed_ThinItalic31pt7b.h"
#include "RobotoCondensed_ThinItalic32pt7b.h"
#include "RobotoCondensed_ThinItalic33pt7b.h"
#include "RobotoCondensed_ThinItalic34pt7b.h"
#include "RobotoCondensed_ThinItalic35pt7b.h"
#include "RobotoCondensed_ThinItalic36pt7b.h"
#include "RobotoCondensed_ThinItalic37pt7b.h"
#include "RobotoCondensed_ThinItalic38pt7b.h"
#include "RobotoCondensed_ThinItalic39pt7b.h"
#include "RobotoCondensed_ThinItalic40pt7b.h"
#include "RobotoCondensed_ThinItalic41pt7b.h"
#include "RobotoCondensed_ThinItalic42pt7b.h"
#include "RobotoCondensed_ThinItalic43pt7b.h"
#include "RobotoCondensed_ThinItalic44pt7b.h"
#include "RobotoCondensed_ThinItalic45pt7b.h"
#include "RobotoCondensed_ThinItalic46pt7b.h"
#include "RobotoCondensed_ThinItalic47pt7b.h"
#include "RobotoCondensed_ThinItalic48pt7b.h"
#include "RobotoCondensed_ThinItalic49pt7b.h"
#include "RobotoCondensed_ThinItalic50pt7b.h"
#include "RobotoCondensed_ThinItalic51pt7b.h"
#include "RobotoCondensed_ThinItalic52pt7b.h"
#include "RobotoCondensed_ThinItalic53pt7b.h"
#include "RobotoCondensed_ThinItalic54pt7b.h"
#include "RobotoCondensed_ThinItalic55pt7b.h"
#include "RobotoCondensed_ThinItalic56pt7b.h"
#include "RobotoCondensed_ThinItalic57pt7b.h"
#include "RobotoCondensed_ThinItalic58pt7b.h"
#include "RobotoCondensed_ThinItalic59pt7b.h"
#include "RobotoCondensed_ThinItalic60pt7b.h"
#include "RobotoCondensed_ThinItalic61pt7b.h"
#include "RobotoCondensed_ThinItalic62pt7b.h"
#include "RobotoCondensed_ThinItalic63pt7b.h"
#include "RobotoCondensed_ThinItalic64pt7b.h"
#include "RobotoCondensed_ThinItalic65pt7b.h"
#include "RobotoCondensed_ThinItalic66pt7b.h"
#include "RobotoCondensed_ThinItalic67pt7b.h"
#include "RobotoCondensed_ThinItalic68pt7b.h"
#include "RobotoCondensed_ThinItalic69pt7b.h"
#include "RobotoCondensed_ThinItalic70pt7b.h"
#include "RobotoCondensed_ThinItalic71pt7b.h"
#include "RobotoCondensed_ThinItalic72pt7b.h"
