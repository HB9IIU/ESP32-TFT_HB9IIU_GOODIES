#ifndef _ROBOTOCONDENSED_THINITALIC7PT7B_H_
#define _ROBOTOCONDENSED_THINITALIC7PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ThinItalic.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ThinItalic7pt7bBitmaps[] PROGMEM = {
  0x00, 0x70, 0x00, 0x07, 0x6E, 0x00, 0x0A, 0x23, 0x50, 0x99, 0x36, 0x69,
  0x5E, 0x00, 0x1A, 0xA8, 0x7E, 0x0A, 0x00, 0x09, 0x00, 0x80, 0x00, 0x00,
  0x09, 0x40, 0x76, 0xDE, 0xF8, 0x24, 0xAC, 0x25, 0x1E, 0x2D, 0xF0, 0x48,
  0x96, 0x5A, 0xDE, 0x56, 0x00, 0x75, 0x5E, 0x76, 0xB4, 0x00, 0x00, 0x39,
  0x00, 0x1C, 0x07, 0x00, 0x58, 0x00, 0x3B, 0x67, 0xBD, 0xC1, 0x00, 0x2D,
  0xB0, 0x75, 0xDE, 0x79, 0x88, 0xE0, 0x29, 0x99, 0xE0, 0x28, 0x68, 0xC0,
  0x28, 0x68, 0x80, 0x78, 0x88, 0xF0, 0x09, 0x79, 0x80, 0x78, 0x04, 0x96,
  0x1A, 0xCA, 0x80, 0x12, 0x4C, 0x0A, 0x77, 0xDA, 0x00, 0x4D, 0xBA, 0xA0,
  0x79, 0x99, 0xE0, 0x79, 0xA8, 0x80, 0x79, 0x99, 0xE0, 0x79, 0x8A, 0x80,
  0x48, 0x61, 0xE0, 0x4A, 0x48, 0x09, 0x99, 0xE0, 0x37, 0x48, 0x06, 0xAD,
  0x42, 0x00, 0x06, 0x44, 0x00, 0x3A, 0x48, 0x32, 0x44, 0x40, 0x1A, 0xA0,
  0x78, 0x7C, 0x78, 0x00, 0x80, 0x27, 0xC0, 0x0E, 0xDE, 0x72, 0x60, 0x0E,
  0xDE, 0x7E, 0x40, 0x4A, 0x40, 0x56, 0xF0, 0x80, 0x0E, 0xD0, 0x30, 0x05,
  0x50, 0x11, 0x60, 0x70, 0x7D, 0x6A, 0x10, 0x76, 0x80, 0x76, 0xF0, 0x76,
  0xF0, 0x56, 0xF0, 0x68, 0x51, 0xB0, 0x1A, 0x80, 0x16, 0xE0, 0x97, 0x20,
  0x5E, 0x80, 0x09, 0x00, 0x97, 0x20, 0x00, 0x29, 0x00, 0x50, 0xA0, 0x78,
  0x10, 0xA0, 0x70,
};

const GFXglyph RobotoCondensed_ThinItalic7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 5, 1, 0, -5 },
  { 2, 1, 1, 2, 1, -5 },
  { 3, 4, 5, 3, 0, -5 },
  { 6, 3, 7, 3, 0, -6 },
  { 9, 3, 5, 4, 1, -5 },
  { 11, 3, 5, 4, 0, -5 },
  { 13, 1, 1, 1, 0, -5 },
  { 14, 2, 8, 2, 0, -6 },
  { 16, 1, 8, 2, 0, -6 },
  { 17, 3, 3, 3, 0, -5 },
  { 19, 3, 4, 3, 0, -4 },
  { 21, 1, 2, 1, 0, -1 },
  { 22, 2, 1, 2, 0, -3 },
  { 23, 1, 1, 1, 0, -1 },
  { 24, 3, 5, 2, 0, -5 },
  { 26, 3, 5, 3, 0, -5 },
  { 28, 1, 5, 3, 1, -5 },
  { 29, 3, 5, 3, 0, -5 },
  { 31, 3, 5, 3, 0, -5 },
  { 33, 3, 5, 3, 0, -5 },
  { 35, 3, 5, 3, 0, -5 },
  { 37, 3, 5, 3, 0, -5 },
  { 39, 2, 5, 3, 1, -5 },
  { 41, 3, 5, 3, 0, -5 },
  { 43, 3, 5, 3, 0, -5 },
  { 45, 1, 4, 1, 0, -4 },
  { 46, 1, 5, 1, 0, -4 },
  { 47, 3, 3, 3, 0, -4 },
  { 49, 3, 2, 3, 0, -3 },
  { 50, 3, 3, 3, 0, -4 },
  { 52, 2, 5, 3, 1, -5 },
  { 54, 5, 7, 5, 0, -5 },
  { 59, 3, 5, 4, 0, -5 },
  { 61, 3, 5, 4, 0, -5 },
  { 63, 4, 5, 4, 0, -5 },
  { 66, 4, 5, 4, 0, -5 },
  { 69, 4, 5, 3, 0, -5 },
  { 72, 4, 5, 3, 0, -5 },
  { 75, 4, 5, 4, 0, -5 },
  { 78, 4, 5, 4, 0, -5 },
  { 81, 1, 5, 2, 0, -5 },
  { 82, 3, 5, 3, 0, -5 },
  { 84, 4, 5, 4, 0, -5 },
  { 87, 3, 5, 3, 0, -5 },
  { 89, 5, 5, 5, 0, -5 },
  { 93, 4, 5, 4, 0, -5 },
  { 96, 4, 5, 4, 0, -5 },
  { 99, 4, 5, 4, 0, -5 },
  { 102, 4, 6, 4, 0, -5 },
  { 105, 4, 5, 4, 0, -5 },
  { 108, 4, 5, 4, 0, -5 },
  { 111, 3, 5, 4, 1, -5 },
  { 113, 4, 5, 4, 0, -5 },
  { 116, 3, 5, 4, 1, -5 },
  { 118, 5, 5, 5, 1, -5 },
  { 122, 4, 5, 4, 0, -5 },
  { 125, 3, 5, 4, 1, -5 },
  { 127, 4, 5, 4, 0, -5 },
  { 130, 2, 7, 1, 0, -6 },
  { 132, 1, 5, 2, 1, -5 },
  { 133, 1, 7, 1, 0, -6 },
  { 134, 2, 3, 3, 0, -5 },
  { 135, 2, 1, 3, 0, 0 },
  { 136, 1, 1, 2, 1, -5 },
  { 137, 3, 4, 3, 0, -4 },
  { 139, 3, 5, 3, 0, -5 },
  { 141, 3, 4, 3, 0, -4 },
  { 143, 3, 5, 3, 0, -5 },
  { 145, 3, 4, 3, 0, -4 },
  { 147, 3, 5, 2, 0, -5 },
  { 149, 3, 6, 3, 0, -4 },
  { 152, 3, 5, 3, 0, -5 },
  { 154, 1, 5, 1, 0, -5 },
  { 155, 2, 7, 1, -1, -5 },
  { 157, 3, 5, 3, 0, -5 },
  { 159, 1, 5, 1, 0, -5 },
  { 160, 5, 4, 5, 0, -4 },
  { 163, 3, 4, 3, 0, -4 },
  { 165, 3, 4, 3, 0, -4 },
  { 167, 3, 5, 3, 0, -4 },
  { 169, 3, 5, 3, 0, -4 },
  { 171, 2, 4, 2, 0, -4 },
  { 172, 3, 4, 3, 0, -4 },
  { 174, 2, 5, 2, 0, -5 },
  { 176, 3, 4, 3, 0, -4 },
  { 178, 3, 4, 3, 0, -4 },
  { 180, 3, 4, 4, 1, -4 },
  { 182, 3, 4, 3, 0, -4 },
  { 184, 3, 6, 3, 0, -4 },
  { 187, 3, 4, 3, 0, -4 },
  { 189, 2, 7, 2, 0, -5 },
  { 191, 1, 6, 1, 0, -5 },
  { 192, 2, 7, 2, 0, -5 },
  { 194, 4, 1, 4, 0, -3 },
};

const GFXfont RobotoCondensed_ThinItalic7pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ThinItalic7pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ThinItalic7pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _ROBOTOCONDENSED_THINITALIC7PT7B_H_
