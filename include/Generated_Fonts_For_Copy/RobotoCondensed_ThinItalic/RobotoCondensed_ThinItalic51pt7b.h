#ifndef _ROBOTOCONDENSED_THINITALIC51PT7B_H_
#define _ROBOTOCONDENSED_THINITALIC51PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ThinItalic.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ThinItalic51pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0x03, 0x02, 0x02, 0x02, 0x02, 0x06, 0x06, 0x04, 0x04, 0x04,
  0x04, 0x0C, 0x08, 0x08, 0x08, 0x08, 0x08, 0x18, 0x10, 0x10, 0x10, 0x10,
  0x30, 0x30, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0xE0,
  0xC0, 0x63, 0x63, 0x42, 0x42, 0x42, 0xC6, 0xC6, 0x84, 0x84, 0x84, 0x00,
  0x06, 0x02, 0x00, 0x02, 0x01, 0x00, 0x01, 0x01, 0x80, 0x01, 0x80, 0x80,
  0x00, 0xC0, 0x40, 0x00, 0x40, 0x60, 0x00, 0x20, 0x30, 0x00, 0x30, 0x10,
  0x00, 0x10, 0x18, 0x00, 0x08, 0x0C, 0x03, 0xFF, 0xFF, 0xE0, 0x04, 0x02,
  0x00, 0x02, 0x03, 0x00, 0x03, 0x01, 0x00, 0x01, 0x00, 0x80, 0x00, 0x80,
  0xC0, 0x00, 0xC0, 0x40, 0x00, 0x40, 0x20, 0x00, 0x20, 0x30, 0x00, 0x30,
  0x10, 0x00, 0x10, 0x08, 0x00, 0x08, 0x0C, 0x00, 0x0C, 0x04, 0x00, 0x04,
  0x02, 0x00, 0x02, 0x03, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0x00, 0x80, 0x00,
  0x80, 0xC0, 0x00, 0xC0, 0x40, 0x00, 0x40, 0x20, 0x00, 0x20, 0x30, 0x00,
  0x30, 0x10, 0x00, 0x10, 0x08, 0x00, 0x08, 0x0C, 0x00, 0x0C, 0x04, 0x00,
  0x04, 0x02, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x1F, 0x80, 0x03, 0x87, 0x00, 0x30,
  0x0C, 0x03, 0x00, 0x30, 0x10, 0x00, 0x81, 0x00, 0x04, 0x08, 0x00, 0x30,
  0x80, 0x01, 0x84, 0x00, 0x0C, 0x20, 0x00, 0x61, 0x00, 0x03, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x22, 0x00,
  0x01, 0x10, 0x00, 0x08, 0x80, 0x00, 0x44, 0x00, 0x06, 0x30, 0x00, 0x21,
  0x80, 0x03, 0x04, 0x00, 0x10, 0x30, 0x01, 0x80, 0xC0, 0x18, 0x03, 0x87,
  0x80, 0x07, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x07, 0x80, 0x00, 0x1C, 0xC0, 0x00, 0x30,
  0x60, 0x00, 0x20, 0x20, 0x00, 0x60, 0x20, 0x00, 0x40, 0x30, 0x08, 0xC0,
  0x30, 0x18, 0x80, 0x30, 0x30, 0x80, 0x20, 0x20, 0x80, 0x20, 0x60, 0x80,
  0x20, 0xC0, 0x80, 0x60, 0x80, 0x80, 0x41, 0x00, 0x80, 0xC3, 0x00, 0xC1,
  0x86, 0x00, 0x63, 0x04, 0x00, 0x3E, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x20, 0x78, 0x00, 0x61, 0xCC, 0x00, 0xC3, 0x06, 0x00,
  0x82, 0x02, 0x01, 0x04, 0x02, 0x03, 0x04, 0x02, 0x02, 0x0C, 0x02, 0x04,
  0x08, 0x02, 0x0C, 0x08, 0x02, 0x18, 0x08, 0x02, 0x10, 0x08, 0x02, 0x20,
  0x08, 0x06, 0x60, 0x08, 0x04, 0x00, 0x08, 0x0C, 0x00, 0x0C, 0x18, 0x00,
  0x06, 0x30, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x73, 0x80, 0x01,
  0x81, 0x80, 0x06, 0x03, 0x00, 0x08, 0x02, 0x00, 0x30, 0x04, 0x00, 0x40,
  0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x60, 0x02, 0x01, 0x80, 0x04, 0x02,
  0x00, 0x08, 0x08, 0x00, 0x18, 0x30, 0x00, 0x10, 0x80, 0x00, 0x26, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x60, 0x00, 0x01, 0x40, 0x00, 0x0C, 0xC0, 0x00,
  0x30, 0x80, 0x00, 0xC1, 0x80, 0x21, 0x01, 0x00, 0xC4, 0x03, 0x01, 0x18,
  0x02, 0x02, 0x20, 0x02, 0x0C, 0xC0, 0x06, 0x11, 0x00, 0x04, 0x22, 0x00,
  0x0C, 0xC4, 0x00, 0x0B, 0x08, 0x00, 0x1C, 0x10, 0x00, 0x18, 0x30, 0x00,
  0x70, 0x60, 0x01, 0xB0, 0x60, 0x06, 0x20, 0x60, 0x30, 0x60, 0x7F, 0xC0,
  0x40, 0x08, 0x00, 0x00, 0x22, 0x22, 0x66, 0x44, 0x4C, 0x00, 0x04, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x01, 0x00, 0x08, 0x00, 0x20, 0x01,
  0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x02,
  0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x18, 0x00, 0x20, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20,
  0x00, 0x40, 0x01, 0x00, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x40, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x0C,
  0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0x80, 0x06, 0x00, 0x10,
  0x00, 0xC0, 0x06, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x60, 0x0E, 0x06, 0x0E, 0x38, 0x43, 0x80, 0xF5, 0xE0,
  0x01, 0xF0, 0x00, 0x0C, 0x00, 0x01, 0xA0, 0x00, 0x33, 0x00, 0x06, 0x10,
  0x00, 0xC1, 0x80, 0x18, 0x08, 0x01, 0x00, 0xC0, 0x30, 0x04, 0x06, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x7F,
  0xFF, 0xFC, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00,
  0x18, 0xC4, 0x23, 0x18, 0x8C, 0xC4, 0x00, 0xFF, 0xC0, 0x5F, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06,
  0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00,
  0x08, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00,
  0x10, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00,
  0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00,
  0x20, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x03, 0x8E, 0x00,
  0x30, 0x18, 0x02, 0x00, 0x40, 0x20, 0x03, 0x03, 0x00, 0x08, 0x10, 0x00,
  0x41, 0x80, 0x02, 0x08, 0x00, 0x10, 0xC0, 0x00, 0xC6, 0x00, 0x06, 0x20,
  0x00, 0x21, 0x00, 0x01, 0x18, 0x00, 0x08, 0x80, 0x00, 0x44, 0x00, 0x02,
  0x20, 0x00, 0x31, 0x00, 0x01, 0x98, 0x00, 0x08, 0xC0, 0x00, 0x44, 0x00,
  0x02, 0x20, 0x00, 0x11, 0x00, 0x01, 0x88, 0x00, 0x08, 0x40, 0x00, 0x42,
  0x00, 0x06, 0x10, 0x00, 0x30, 0x80, 0x01, 0x04, 0x00, 0x18, 0x20, 0x00,
  0x81, 0x00, 0x0C, 0x0C, 0x00, 0xC0, 0x20, 0x04, 0x01, 0x80, 0x40, 0x07,
  0x1C, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x60, 0x38, 0x39, 0x1C, 0x2E, 0x04,
  0x00, 0x80, 0x30, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0xC0, 0x18, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x30, 0x06, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x18, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x1F, 0x80, 0x03, 0x8F,
  0x00, 0x30, 0x0C, 0x03, 0x00, 0x60, 0x30, 0x01, 0x83, 0x00, 0x0C, 0x10,
  0x00, 0x20, 0x80, 0x01, 0x0C, 0x00, 0x08, 0x40, 0x00, 0xC2, 0x00, 0x06,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x10, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0x80, 0x01, 0xC3, 0x80,
  0x0C, 0x03, 0x00, 0x60, 0x06, 0x03, 0x00, 0x18, 0x08, 0x00, 0x20, 0x60,
  0x00, 0x81, 0x00, 0x03, 0x0C, 0x00, 0x08, 0x20, 0x00, 0x20, 0x00, 0x00,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x70, 0x00, 0x0F, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x21, 0x00, 0x00, 0x84, 0x00, 0x02, 0x10, 0x00, 0x08, 0x40,
  0x00, 0x61, 0x00, 0x01, 0x06, 0x00, 0x0C, 0x08, 0x00, 0x20, 0x30, 0x01,
  0x00, 0x60, 0x18, 0x00, 0xE1, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x01, 0x80, 0x00, 0x14, 0x00, 0x01, 0xA0, 0x00, 0x0B, 0x00, 0x00,
  0x98, 0x00, 0x0C, 0x80, 0x00, 0xC4, 0x00, 0x04, 0x20, 0x00, 0x43, 0x00,
  0x06, 0x18, 0x00, 0x60, 0x80, 0x02, 0x04, 0x00, 0x30, 0x20, 0x03, 0x01,
  0x00, 0x10, 0x18, 0x01, 0x00, 0xC0, 0x18, 0x04, 0x01, 0x80, 0x20, 0x08,
  0x01, 0x00, 0x80, 0x08, 0x0C, 0x00, 0xC0, 0xC0, 0x06, 0x04, 0x00, 0x20,
  0x60, 0x01, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x01, 0xFF, 0xF8, 0x08,
  0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x7E, 0x00, 0x6E, 0x38, 0x03,
  0x80, 0x60, 0x10, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x06, 0x30, 0x00, 0x21, 0x80, 0x01, 0x0C, 0x00, 0x08,
  0x60, 0x00, 0xC1, 0x00, 0x04, 0x08, 0x00, 0x60, 0x60, 0x06, 0x01, 0x80,
  0x60, 0x07, 0x0E, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x01, 0xE0,
  0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01,
  0x07, 0xE0, 0x23, 0x8E, 0x0C, 0x80, 0x61, 0x20, 0x06, 0x28, 0x00, 0x46,
  0x00, 0x0D, 0x80, 0x01, 0xB0, 0x00, 0x14, 0x00, 0x02, 0x80, 0x00, 0x50,
  0x00, 0x0A, 0x00, 0x01, 0x40, 0x00, 0x78, 0x00, 0x0B, 0x00, 0x01, 0x20,
  0x00, 0x64, 0x00, 0x08, 0x80, 0x01, 0x18, 0x00, 0x63, 0x00, 0x18, 0x30,
  0x06, 0x03, 0x01, 0x80, 0x38, 0xE0, 0x03, 0xF0, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x02,
  0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01,
  0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xE3, 0x80, 0x0C, 0x03, 0x00,
  0x60, 0x06, 0x03, 0x00, 0x0C, 0x08, 0x00, 0x30, 0x60, 0x00, 0x41, 0x00,
  0x01, 0x04, 0x00, 0x04, 0x30, 0x00, 0x30, 0xC0, 0x00, 0xC3, 0x00, 0x02,
  0x0C, 0x00, 0x18, 0x10, 0x00, 0xC0, 0x60, 0x06, 0x00, 0xC0, 0x30, 0x01,
  0xC7, 0x80, 0x03, 0xF8, 0x00, 0x38, 0x38, 0x03, 0x00, 0x30, 0x18, 0x00,
  0x60, 0x40, 0x00, 0x82, 0x00, 0x02, 0x18, 0x00, 0x0C, 0x40, 0x00, 0x31,
  0x00, 0x00, 0xCC, 0x00, 0x03, 0x30, 0x00, 0x08, 0xC0, 0x00, 0x23, 0x00,
  0x01, 0x84, 0x00, 0x04, 0x18, 0x00, 0x20, 0x20, 0x01, 0x80, 0xC0, 0x18,
  0x01, 0xE1, 0xC0, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0xE3, 0xC0, 0x60,
  0x30, 0x30, 0x06, 0x18, 0x00, 0xCC, 0x00, 0x32, 0x00, 0x05, 0x80, 0x01,
  0x40, 0x00, 0x50, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x7C, 0x00,
  0x3B, 0x00, 0x0A, 0x60, 0x0C, 0x88, 0x06, 0x61, 0x87, 0x10, 0x3F, 0x04,
  0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00,
  0x02, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x01, 0xF0,
  0x03, 0xE0, 0x00, 0x04, 0x1C, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x41, 0x83, 0x00, 0x00, 0x80, 0x70, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x08, 0x02, 0x01,
  0x80, 0x60, 0x10, 0x0C, 0x02, 0x01, 0x80, 0x40, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x18,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x80, 0x3F, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x08, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x00,
  0x03, 0xE0, 0x1C, 0x70, 0x60, 0x21, 0x80, 0x66, 0x00, 0x48, 0x00, 0xB0,
  0x01, 0x40, 0x02, 0x80, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x00,
  0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x03, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0x1F, 0x00, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x03, 0x80, 0x00, 0x10, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x30,
  0x00, 0x00, 0x20, 0x04, 0x00, 0x00, 0x02, 0x01, 0x80, 0x00, 0x00, 0x40,
  0x60, 0x00, 0x00, 0x0C, 0x18, 0x00, 0xF8, 0x01, 0x82, 0x00, 0x71, 0x80,
  0x10, 0xC0, 0x18, 0x08, 0x02, 0x10, 0x06, 0x01, 0x00, 0x46, 0x00, 0x80,
  0x20, 0x08, 0x80, 0x20, 0x04, 0x01, 0x30, 0x0C, 0x01, 0x80, 0x26, 0x01,
  0x00, 0x30, 0x04, 0x80, 0x60, 0x04, 0x00, 0xB0, 0x08, 0x00, 0x80, 0x14,
  0x01, 0x00, 0x30, 0x06, 0x80, 0x60, 0x06, 0x00, 0xD0, 0x08, 0x00, 0x80,
  0x16, 0x01, 0x00, 0x10, 0x02, 0xC0, 0x60, 0x02, 0x00, 0xD0, 0x08, 0x00,
  0xC0, 0x12, 0x01, 0x00, 0x10, 0x02, 0x40, 0x20, 0x02, 0x00, 0xC8, 0x04,
  0x00, 0xC0, 0x11, 0x00, 0x80, 0x18, 0x02, 0x20, 0x10, 0x07, 0x00, 0x84,
  0x02, 0x01, 0x20, 0x30, 0x80, 0x40, 0x64, 0x0C, 0x10, 0x04, 0x18, 0xC3,
  0x03, 0x00, 0xFC, 0x0F, 0xC0, 0x60, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0x3E, 0x1E, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x01, 0x40,
  0x00, 0x02, 0x80, 0x00, 0x0D, 0x00, 0x00, 0x12, 0x00, 0x00, 0x64, 0x00,
  0x00, 0x88, 0x00, 0x03, 0x18, 0x00, 0x04, 0x30, 0x00, 0x18, 0x20, 0x00,
  0x20, 0x40, 0x00, 0xC0, 0x80, 0x01, 0x01, 0x00, 0x06, 0x02, 0x00, 0x08,
  0x04, 0x00, 0x30, 0x0C, 0x00, 0x40, 0x18, 0x01, 0x80, 0x10, 0x02, 0x00,
  0x20, 0x04, 0x00, 0x40, 0x10, 0x00, 0x80, 0x20, 0x01, 0x00, 0x80, 0x03,
  0x01, 0x00, 0x06, 0x07, 0xFF, 0xFC, 0x08, 0x00, 0x08, 0x30, 0x00, 0x10,
  0x40, 0x00, 0x21, 0x80, 0x00, 0x42, 0x00, 0x00, 0xCC, 0x00, 0x01, 0x90,
  0x00, 0x03, 0x60, 0x00, 0x02, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x10, 0x03, 0xFF, 0x80, 0x04, 0x01, 0xE0, 0x08, 0x00, 0x60, 0x10,
  0x00, 0x60, 0x60, 0x00, 0x40, 0xC0, 0x00, 0x81, 0x00, 0x01, 0x82, 0x00,
  0x03, 0x04, 0x00, 0x04, 0x08, 0x00, 0x08, 0x30, 0x00, 0x10, 0x60, 0x00,
  0x60, 0x80, 0x00, 0x81, 0x00, 0x03, 0x02, 0x00, 0x0C, 0x04, 0x00, 0x30,
  0x18, 0x03, 0x80, 0x3F, 0xFF, 0x00, 0x40, 0x07, 0x00, 0x80, 0x03, 0x01,
  0x00, 0x03, 0x06, 0x00, 0x02, 0x0C, 0x00, 0x06, 0x10, 0x00, 0x04, 0x20,
  0x00, 0x08, 0x40, 0x00, 0x30, 0x80, 0x00, 0x63, 0x00, 0x00, 0x86, 0x00,
  0x01, 0x08, 0x00, 0x06, 0x10, 0x00, 0x08, 0x20, 0x00, 0x30, 0x40, 0x00,
  0xC1, 0x80, 0x07, 0x03, 0x00, 0x38, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x70, 0x70, 0x00, 0xC0, 0x18, 0x01, 0x00, 0x0C, 0x02, 0x00,
  0x06, 0x04, 0x00, 0x02, 0x0C, 0x00, 0x02, 0x08, 0x00, 0x03, 0x18, 0x00,
  0x03, 0x10, 0x00, 0x03, 0x10, 0x00, 0x03, 0x30, 0x00, 0x03, 0x20, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x80, 0x00, 0x18, 0x80, 0x00, 0x18, 0xC0, 0x00, 0x10, 0xC0, 0x00,
  0x30, 0x40, 0x00, 0x20, 0x40, 0x00, 0x60, 0x60, 0x00, 0xC0, 0x20, 0x01,
  0x80, 0x18, 0x03, 0x00, 0x0E, 0x1E, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFF,
  0xC0, 0x01, 0x00, 0x78, 0x00, 0x80, 0x06, 0x00, 0x40, 0x01, 0x80, 0x60,
  0x00, 0x60, 0x30, 0x00, 0x10, 0x10, 0x00, 0x0C, 0x08, 0x00, 0x02, 0x04,
  0x00, 0x01, 0x02, 0x00, 0x00, 0x83, 0x00, 0x00, 0x41, 0x00, 0x00, 0x20,
  0x80, 0x00, 0x10, 0x40, 0x00, 0x08, 0x20, 0x00, 0x04, 0x10, 0x00, 0x02,
  0x18, 0x00, 0x03, 0x08, 0x00, 0x01, 0x84, 0x00, 0x00, 0x82, 0x00, 0x00,
  0x41, 0x00, 0x00, 0x21, 0x80, 0x00, 0x10, 0xC0, 0x00, 0x18, 0x40, 0x00,
  0x0C, 0x20, 0x00, 0x04, 0x10, 0x00, 0x02, 0x08, 0x00, 0x03, 0x0C, 0x00,
  0x01, 0x06, 0x00, 0x01, 0x82, 0x00, 0x01, 0x81, 0x00, 0x00, 0x80, 0x80,
  0x00, 0x80, 0x40, 0x01, 0x80, 0x60, 0x01, 0x80, 0x30, 0x0F, 0x80, 0x1F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x10, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x81, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x04,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x1C, 0x1C, 0x00, 0x38, 0x03, 0x00, 0x30, 0x00, 0xC0, 0x30, 0x00, 0x30,
  0x30, 0x00, 0x08, 0x10, 0x00, 0x04, 0x18, 0x00, 0x03, 0x08, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00,
  0xFF, 0xE2, 0x00, 0x00, 0x31, 0x00, 0x00, 0x10, 0x80, 0x00, 0x08, 0x40,
  0x00, 0x04, 0x20, 0x00, 0x06, 0x10, 0x00, 0x03, 0x08, 0x00, 0x01, 0x04,
  0x00, 0x00, 0x82, 0x00, 0x00, 0x41, 0x80, 0x00, 0x20, 0x40, 0x00, 0x30,
  0x30, 0x00, 0x70, 0x0C, 0x00, 0x70, 0x03, 0xC3, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x20, 0x00, 0x02, 0x02, 0x00, 0x00, 0x20,
  0x20, 0x00, 0x02, 0x06, 0x00, 0x00, 0x60, 0x60, 0x00, 0x06, 0x04, 0x00,
  0x00, 0x40, 0x40, 0x00, 0x04, 0x04, 0x00, 0x00, 0x40, 0x40, 0x00, 0x04,
  0x0C, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x0C, 0x08, 0x00, 0x00, 0x80, 0x80,
  0x00, 0x08, 0x08, 0x00, 0x00, 0x80, 0x80, 0x00, 0x08, 0x18, 0x00, 0x01,
  0x81, 0xFF, 0xFF, 0xF8, 0x10, 0x00, 0x01, 0x01, 0x00, 0x00, 0x10, 0x10,
  0x00, 0x01, 0x03, 0x00, 0x00, 0x10, 0x30, 0x00, 0x03, 0x02, 0x00, 0x00,
  0x20, 0x20, 0x00, 0x02, 0x02, 0x00, 0x00, 0x20, 0x20, 0x00, 0x02, 0x06,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x06, 0x04, 0x00, 0x00, 0x40, 0x40, 0x00,
  0x04, 0x04, 0x00, 0x00, 0x40, 0x40, 0x00, 0x04, 0x0C, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x0C, 0x08, 0x00, 0x00, 0x80, 0x02, 0x04, 0x18, 0x30, 0x60,
  0x81, 0x02, 0x0C, 0x18, 0x20, 0x40, 0x81, 0x06, 0x0C, 0x10, 0x20, 0x40,
  0x83, 0x06, 0x08, 0x10, 0x20, 0x41, 0x83, 0x04, 0x08, 0x10, 0x60, 0xC1,
  0x02, 0x04, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40,
  0x00, 0x03, 0x0C, 0x00, 0x08, 0x30, 0x00, 0x20, 0xC0, 0x01, 0x83, 0x00,
  0x04, 0x0C, 0x00, 0x30, 0x10, 0x00, 0x80, 0x60, 0x06, 0x00, 0x80, 0x30,
  0x01, 0xC7, 0x80, 0x03, 0xF8, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x80, 0x00,
  0x60, 0x20, 0x00, 0x30, 0x08, 0x00, 0x18, 0x06, 0x00, 0x0C, 0x01, 0x80,
  0x06, 0x00, 0x40, 0x03, 0x00, 0x10, 0x01, 0x80, 0x04, 0x00, 0xC0, 0x01,
  0x00, 0x60, 0x00, 0xC0, 0x30, 0x00, 0x20, 0x18, 0x00, 0x08, 0x0C, 0x00,
  0x02, 0x06, 0x00, 0x00, 0x83, 0x00, 0x00, 0x21, 0x80, 0x00, 0x18, 0xC0,
  0x00, 0x04, 0x78, 0x00, 0x01, 0x33, 0x00, 0x00, 0x58, 0x40, 0x00, 0x1C,
  0x18, 0x00, 0x0C, 0x02, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x80, 0x10, 0x00,
  0x20, 0x06, 0x00, 0x08, 0x00, 0x80, 0x02, 0x00, 0x30, 0x01, 0x80, 0x06,
  0x00, 0x60, 0x01, 0x80, 0x10, 0x00, 0x30, 0x04, 0x00, 0x04, 0x01, 0x00,
  0x01, 0x80, 0x40, 0x00, 0x20, 0x30, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0x02,
  0x00, 0x00, 0x60, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x00, 0x70, 0x30, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00,
  0x0F, 0x06, 0x80, 0x00, 0x02, 0x81, 0xA0, 0x00, 0x01, 0xA0, 0x48, 0x00,
  0x00, 0x48, 0x12, 0x00, 0x00, 0x32, 0x04, 0xC0, 0x00, 0x09, 0x81, 0x30,
  0x00, 0x06, 0x60, 0xC4, 0x00, 0x01, 0x10, 0x21, 0x00, 0x00, 0x84, 0x08,
  0x40, 0x00, 0x21, 0x02, 0x10, 0x00, 0x10, 0xC0, 0x86, 0x00, 0x0C, 0x30,
  0x20, 0x80, 0x02, 0x08, 0x18, 0x20, 0x01, 0x82, 0x04, 0x08, 0x00, 0x40,
  0x81, 0x02, 0x00, 0x30, 0x20, 0x40, 0xC0, 0x08, 0x18, 0x10, 0x10, 0x06,
  0x06, 0x0C, 0x04, 0x01, 0x01, 0x03, 0x01, 0x00, 0xC0, 0x40, 0x80, 0x40,
  0x20, 0x10, 0x20, 0x10, 0x18, 0x04, 0x08, 0x06, 0x04, 0x03, 0x02, 0x00,
  0x83, 0x00, 0xC1, 0x80, 0x20, 0x80, 0x20, 0x60, 0x08, 0x40, 0x08, 0x10,
  0x02, 0x30, 0x02, 0x04, 0x00, 0xC8, 0x00, 0x81, 0x00, 0x16, 0x00, 0x60,
  0x40, 0x05, 0x00, 0x18, 0x30, 0x01, 0xC0, 0x04, 0x0C, 0x00, 0x60, 0x01,
  0x02, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x00, 0x30, 0x30, 0x00, 0x03,
  0x03, 0x80, 0x00, 0x20, 0x28, 0x00, 0x02, 0x06, 0x80, 0x00, 0x20, 0x6C,
  0x00, 0x06, 0x06, 0x40, 0x00, 0x60, 0x44, 0x00, 0x06, 0x04, 0x20, 0x00,
  0x40, 0x42, 0x00, 0x04, 0x0C, 0x30, 0x00, 0x40, 0xC1, 0x00, 0x0C, 0x08,
  0x10, 0x00, 0xC0, 0x80, 0x80, 0x08, 0x08, 0x08, 0x00, 0x81, 0x80, 0xC0,
  0x08, 0x18, 0x04, 0x00, 0x81, 0x80, 0x40, 0x18, 0x10, 0x06, 0x01, 0x81,
  0x00, 0x20, 0x10, 0x10, 0x03, 0x01, 0x03, 0x00, 0x10, 0x10, 0x30, 0x01,
  0x03, 0x03, 0x00, 0x18, 0x30, 0x20, 0x00, 0x83, 0x02, 0x00, 0x0C, 0x20,
  0x20, 0x00, 0x42, 0x06, 0x00, 0x04, 0x20, 0x60, 0x00, 0x66, 0x04, 0x00,
  0x02, 0x60, 0x40, 0x00, 0x26, 0x04, 0x00, 0x01, 0x40, 0x40, 0x00, 0x14,
  0x0C, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x0C, 0x08, 0x00, 0x00, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x78, 0x70, 0x00, 0xC0, 0x0C, 0x03, 0x00, 0x04, 0x02,
  0x00, 0x06, 0x04, 0x00, 0x02, 0x0C, 0x00, 0x03, 0x08, 0x00, 0x01, 0x18,
  0x00, 0x01, 0x10, 0x00, 0x01, 0x30, 0x00, 0x01, 0x20, 0x00, 0x01, 0x20,
  0x00, 0x01, 0x20, 0x00, 0x01, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x40,
  0x00, 0x02, 0x40, 0x00, 0x02, 0x40, 0x00, 0x02, 0x40, 0x00, 0x02, 0xC0,
  0x00, 0x06, 0xC0, 0x00, 0x06, 0x80, 0x00, 0x04, 0x80, 0x00, 0x04, 0x80,
  0x00, 0x0C, 0x80, 0x00, 0x0C, 0x80, 0x00, 0x08, 0x80, 0x00, 0x18, 0x80,
  0x00, 0x10, 0xC0, 0x00, 0x30, 0x40, 0x00, 0x20, 0x60, 0x00, 0x40, 0x20,
  0x00, 0xC0, 0x38, 0x03, 0x00, 0x0E, 0x1E, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xFF, 0xE0, 0x02, 0x00, 0x78, 0x02, 0x00, 0x0C, 0x02, 0x00, 0x04, 0x06,
  0x00, 0x06, 0x06, 0x00, 0x02, 0x04, 0x00, 0x03, 0x04, 0x00, 0x03, 0x04,
  0x00, 0x03, 0x04, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x02, 0x08,
  0x00, 0x02, 0x08, 0x00, 0x06, 0x08, 0x00, 0x04, 0x08, 0x00, 0x0C, 0x18,
  0x00, 0x18, 0x10, 0x00, 0x30, 0x10, 0x00, 0x60, 0x10, 0x03, 0xC0, 0x1F,
  0xFF, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x78, 0x70, 0x00, 0xC0, 0x0C, 0x03, 0x00, 0x04, 0x02,
  0x00, 0x06, 0x04, 0x00, 0x02, 0x0C, 0x00, 0x03, 0x08, 0x00, 0x01, 0x18,
  0x00, 0x01, 0x10, 0x00, 0x01, 0x30, 0x00, 0x01, 0x20, 0x00, 0x01, 0x20,
  0x00, 0x01, 0x20, 0x00, 0x01, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x40,
  0x00, 0x02, 0x40, 0x00, 0x02, 0x40, 0x00, 0x02, 0x40, 0x00, 0x02, 0xC0,
  0x00, 0x06, 0xC0, 0x00, 0x06, 0x80, 0x00, 0x04, 0x80, 0x00, 0x04, 0x80,
  0x00, 0x0C, 0x80, 0x00, 0x0C, 0x80, 0x00, 0x08, 0x80, 0x00, 0x18, 0x80,
  0x00, 0x10, 0xC0, 0x00, 0x30, 0x40, 0x00, 0x20, 0x60, 0x00, 0x40, 0x20,
  0x00, 0x80, 0x30, 0x03, 0x00, 0x0E, 0x1E, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x03, 0xFF, 0xE0, 0x02,
  0x00, 0x78, 0x02, 0x00, 0x0C, 0x06, 0x00, 0x06, 0x06, 0x00, 0x02, 0x04,
  0x00, 0x02, 0x04, 0x00, 0x03, 0x04, 0x00, 0x01, 0x04, 0x00, 0x01, 0x0C,
  0x00, 0x01, 0x0C, 0x00, 0x03, 0x08, 0x00, 0x03, 0x08, 0x00, 0x02, 0x08,
  0x00, 0x02, 0x08, 0x00, 0x04, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x08, 0x10,
  0x00, 0x10, 0x10, 0x00, 0x60, 0x10, 0x01, 0xC0, 0x1F, 0xFF, 0x00, 0x30,
  0x03, 0x00, 0x20, 0x03, 0x00, 0x20, 0x01, 0x00, 0x20, 0x01, 0x80, 0x20,
  0x01, 0x80, 0x20, 0x00, 0x80, 0x60, 0x00, 0xC0, 0x40, 0x00, 0x40, 0x40,
  0x00, 0x40, 0x40, 0x00, 0x60, 0x40, 0x00, 0x20, 0xC0, 0x00, 0x20, 0xC0,
  0x00, 0x30, 0x80, 0x00, 0x10, 0x80, 0x00, 0x18, 0x00, 0x0F, 0xE0, 0x00,
  0x1C, 0x1C, 0x00, 0x38, 0x03, 0x00, 0x30, 0x00, 0xC0, 0x30, 0x00, 0x30,
  0x10, 0x00, 0x08, 0x10, 0x00, 0x04, 0x08, 0x00, 0x02, 0x0C, 0x00, 0x01,
  0x06, 0x00, 0x00, 0x83, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x0C, 0x60, 0x00, 0x06, 0x30, 0x00, 0x03, 0x18, 0x00, 0x01, 0x04,
  0x00, 0x00, 0x82, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x60,
  0x30, 0x00, 0x60, 0x0C, 0x00, 0xE0, 0x03, 0xC3, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x82, 0x00, 0x00, 0x43, 0x00, 0x00, 0x21, 0x80, 0x00, 0x30, 0x80, 0x00,
  0x18, 0x40, 0x00, 0x08, 0x20, 0x00, 0x04, 0x10, 0x00, 0x02, 0x18, 0x00,
  0x01, 0x0C, 0x00, 0x01, 0x84, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x41, 0x00,
  0x00, 0x21, 0x80, 0x00, 0x10, 0xC0, 0x00, 0x08, 0x40, 0x00, 0x0C, 0x20,
  0x00, 0x04, 0x10, 0x00, 0x02, 0x08, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x86,
  0x00, 0x00, 0xC2, 0x00, 0x00, 0x61, 0x00, 0x00, 0x20, 0x80, 0x00, 0x10,
  0x40, 0x00, 0x08, 0x60, 0x00, 0x04, 0x30, 0x00, 0x06, 0x18, 0x00, 0x02,
  0x0C, 0x00, 0x03, 0x06, 0x00, 0x01, 0x01, 0x00, 0x01, 0x80, 0xC0, 0x01,
  0x80, 0x20, 0x01, 0x80, 0x18, 0x01, 0x80, 0x07, 0x87, 0x80, 0x00, 0xFF,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x40, 0x00, 0x03, 0x40, 0x00, 0x02, 0x40,
  0x00, 0x06, 0x60, 0x00, 0x04, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x08, 0x20,
  0x00, 0x18, 0x20, 0x00, 0x10, 0x20, 0x00, 0x30, 0x20, 0x00, 0x20, 0x30,
  0x00, 0x20, 0x30, 0x00, 0x40, 0x10, 0x00, 0x40, 0x10, 0x00, 0xC0, 0x10,
  0x00, 0x80, 0x10, 0x01, 0x80, 0x18, 0x01, 0x00, 0x18, 0x03, 0x00, 0x18,
  0x02, 0x00, 0x08, 0x06, 0x00, 0x08, 0x04, 0x00, 0x08, 0x0C, 0x00, 0x08,
  0x08, 0x00, 0x0C, 0x08, 0x00, 0x0C, 0x10, 0x00, 0x04, 0x10, 0x00, 0x04,
  0x20, 0x00, 0x04, 0x20, 0x00, 0x04, 0x60, 0x00, 0x04, 0x40, 0x00, 0x06,
  0xC0, 0x00, 0x06, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x2C, 0x00, 0x0E, 0x00, 0x02, 0xC0,
  0x00, 0xA0, 0x00, 0x6C, 0x00, 0x0A, 0x00, 0x04, 0xC0, 0x01, 0xA0, 0x00,
  0xCC, 0x00, 0x12, 0x00, 0x08, 0xC0, 0x03, 0x20, 0x00, 0x8C, 0x00, 0x22,
  0x00, 0x18, 0x40, 0x02, 0x20, 0x01, 0x04, 0x00, 0x42, 0x00, 0x10, 0x40,
  0x04, 0x20, 0x03, 0x04, 0x00, 0xC3, 0x00, 0x20, 0x40, 0x08, 0x30, 0x06,
  0x04, 0x00, 0x81, 0x00, 0x40, 0x40, 0x10, 0x10, 0x04, 0x04, 0x01, 0x01,
  0x00, 0xC0, 0x60, 0x30, 0x10, 0x08, 0x06, 0x02, 0x01, 0x00, 0x80, 0x60,
  0x20, 0x10, 0x18, 0x06, 0x04, 0x01, 0x01, 0x00, 0x60, 0x40, 0x10, 0x30,
  0x06, 0x0C, 0x01, 0x82, 0x00, 0x60, 0x80, 0x18, 0x20, 0x02, 0x18, 0x01,
  0x86, 0x00, 0x21, 0x00, 0x18, 0x40, 0x02, 0x10, 0x00, 0x84, 0x00, 0x23,
  0x00, 0x08, 0xC0, 0x02, 0x20, 0x00, 0x88, 0x00, 0x26, 0x00, 0x09, 0x80,
  0x02, 0x40, 0x00, 0x90, 0x00, 0x24, 0x00, 0x09, 0x00, 0x02, 0xC0, 0x00,
  0xB0, 0x00, 0x28, 0x00, 0x0A, 0x00, 0x02, 0x80, 0x00, 0xE0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x10, 0x00, 0x02, 0x01, 0x80, 0x00, 0x60, 0x08, 0x00, 0x0C, 0x00, 0xC0,
  0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x60, 0x03, 0x00, 0x06, 0x00, 0x60,
  0x00, 0x20, 0x04, 0x00, 0x03, 0x00, 0x80, 0x00, 0x10, 0x18, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x08, 0x20, 0x00, 0x00, 0x86, 0x00, 0x00, 0x0C, 0xC0,
  0x00, 0x00, 0x48, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x09, 0x80, 0x00, 0x01, 0x08,
  0x00, 0x00, 0x30, 0x80, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x40, 0x40, 0x00,
  0x08, 0x06, 0x00, 0x01, 0x80, 0x20, 0x00, 0x30, 0x03, 0x00, 0x02, 0x00,
  0x10, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x80, 0x00, 0x80,
  0x10, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x40, 0x60, 0x00, 0x06, 0x04, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0D, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x46, 0x00, 0x01, 0x84, 0x00, 0x06, 0x08, 0x00, 0x08, 0x18, 0x00,
  0x20, 0x10, 0x00, 0xC0, 0x20, 0x01, 0x00, 0x60, 0x04, 0x00, 0x40, 0x18,
  0x00, 0x80, 0x20, 0x01, 0x80, 0x80, 0x01, 0x03, 0x00, 0x02, 0x04, 0x00,
  0x06, 0x10, 0x00, 0x04, 0x60, 0x00, 0x08, 0x80, 0x00, 0x12, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x01, 0xF8, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0xC0, 0x06, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x80, 0x0C,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0xFC, 0x00, 0xC1, 0x81, 0x02, 0x04,
  0x08, 0x18, 0x30, 0x60, 0x40, 0x81, 0x02, 0x06, 0x0C, 0x08, 0x10, 0x20,
  0x40, 0x81, 0x83, 0x02, 0x04, 0x08, 0x10, 0x20, 0x60, 0xC0, 0x81, 0x02,
  0x04, 0x0C, 0x18, 0x30, 0x20, 0x40, 0x80, 0x01, 0xF8, 0x00, 0x40, 0x02,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x0C, 0x00, 0x60, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x60, 0x03,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0xC0,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0xFC, 0x00, 0x00, 0x40, 0x07, 0x00, 0x28, 0x03, 0x40, 0x12, 0x01,
  0x90, 0x08, 0x80, 0xC6, 0x04, 0x30, 0x60, 0x82, 0x04, 0x30, 0x21, 0x01,
  0x18, 0x0C, 0x80, 0x6C, 0x01, 0x40, 0x0E, 0x00, 0x40, 0xFF, 0xFF, 0x80,
  0xC3, 0x18, 0x61, 0x0C, 0x20, 0x00, 0x7E, 0x00, 0x38, 0x70, 0x0C, 0x03,
  0x02, 0x00, 0x30, 0xC0, 0x02, 0x10, 0x00, 0x44, 0x00, 0x08, 0x80, 0x01,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x1F, 0xFC,
  0x0F, 0x80, 0x87, 0x00, 0x31, 0x80, 0x06, 0x60, 0x00, 0x88, 0x00, 0x13,
  0x00, 0x02, 0x40, 0x00, 0x48, 0x00, 0x19, 0x00, 0x06, 0x20, 0x01, 0xC6,
  0x00, 0x68, 0x40, 0x19, 0x0E, 0x1C, 0x20, 0x7E, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04,
  0x00, 0x00, 0x41, 0xF8, 0x04, 0x70, 0xC0, 0x58, 0x06, 0x0F, 0x00, 0x30,
  0xE0, 0x01, 0x0C, 0x00, 0x10, 0x80, 0x01, 0x08, 0x00, 0x10, 0x80, 0x01,
  0x18, 0x00, 0x11, 0x00, 0x01, 0x10, 0x00, 0x11, 0x00, 0x01, 0x10, 0x00,
  0x33, 0x00, 0x03, 0x30, 0x00, 0x22, 0x00, 0x02, 0x20, 0x00, 0x22, 0x00,
  0x06, 0x20, 0x00, 0x46, 0x00, 0x04, 0x60, 0x00, 0x86, 0x00, 0x18, 0x50,
  0x01, 0x05, 0x80, 0x60, 0x46, 0x1C, 0x0C, 0x1F, 0x00, 0x00, 0xFC, 0x00,
  0x70, 0xE0, 0x18, 0x06, 0x06, 0x00, 0x61, 0x80, 0x04, 0x20, 0x00, 0x88,
  0x00, 0x11, 0x00, 0x02, 0x60, 0x00, 0x48, 0x00, 0x01, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x06, 0x40, 0x00, 0x88, 0x00, 0x11, 0x00,
  0x04, 0x30, 0x01, 0x82, 0x00, 0x20, 0x60, 0x18, 0x07, 0x8E, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x3F, 0x04, 0x03,
  0x87, 0x10, 0x18, 0x06, 0xC0, 0xC0, 0x0B, 0x02, 0x00, 0x18, 0x10, 0x00,
  0x60, 0xC0, 0x00, 0x82, 0x00, 0x06, 0x08, 0x00, 0x18, 0x60, 0x00, 0x41,
  0x80, 0x01, 0x04, 0x00, 0x04, 0x10, 0x00, 0x10, 0x40, 0x00, 0xC3, 0x00,
  0x03, 0x0C, 0x00, 0x08, 0x30, 0x00, 0x20, 0x80, 0x00, 0x82, 0x00, 0x06,
  0x08, 0x00, 0x18, 0x20, 0x00, 0x60, 0xC0, 0x01, 0x01, 0x00, 0x0C, 0x04,
  0x00, 0x50, 0x18, 0x02, 0xC0, 0x38, 0x73, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x1C, 0x38, 0x03, 0x00, 0xC0, 0x60, 0x06, 0x0C, 0x00, 0x20,
  0x80, 0x02, 0x18, 0x00, 0x21, 0x00, 0x02, 0x30, 0x00, 0x22, 0x00, 0x02,
  0x60, 0x00, 0x26, 0x00, 0x02, 0x7F, 0xFF, 0xE4, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x10, 0x18,
  0x06, 0x00, 0xE1, 0xC0, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x03,
  0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x07, 0xFF, 0x01, 0x80, 0x03, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0x00, 0x00, 0x3F, 0x04,
  0x03, 0x87, 0x30, 0x18, 0x06, 0xC0, 0xC0, 0x0A, 0x06, 0x00, 0x18, 0x10,
  0x00, 0x60, 0xC0, 0x00, 0x82, 0x00, 0x06, 0x08, 0x00, 0x18, 0x60, 0x00,
  0x41, 0x00, 0x01, 0x04, 0x00, 0x04, 0x10, 0x00, 0x10, 0x40, 0x00, 0xC3,
  0x00, 0x03, 0x0C, 0x00, 0x08, 0x30, 0x00, 0x20, 0x80, 0x00, 0x82, 0x00,
  0x02, 0x08, 0x00, 0x18, 0x20, 0x00, 0x60, 0xC0, 0x01, 0x01, 0x00, 0x0C,
  0x04, 0x00, 0x50, 0x18, 0x06, 0x40, 0x38, 0x73, 0x00, 0x3F, 0x0C, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x40, 0x40, 0x03, 0x01, 0x00, 0x18, 0x02, 0x00, 0xC0, 0x06, 0x0E, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x41, 0xF8, 0x04, 0x70, 0xC0,
  0x4C, 0x06, 0x0D, 0x80, 0x20, 0xD0, 0x03, 0x0A, 0x00, 0x30, 0xE0, 0x03,
  0x0C, 0x00, 0x30, 0x80, 0x03, 0x18, 0x00, 0x31, 0x80, 0x02, 0x10, 0x00,
  0x21, 0x00, 0x02, 0x10, 0x00, 0x21, 0x00, 0x06, 0x30, 0x00, 0x63, 0x00,
  0x04, 0x20, 0x00, 0x42, 0x00, 0x04, 0x20, 0x00, 0x46, 0x00, 0x0C, 0x60,
  0x00, 0x84, 0x00, 0x08, 0x40, 0x00, 0x84, 0x00, 0x08, 0x40, 0x01, 0x8C,
  0x00, 0x18, 0x02, 0x07, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0C, 0x08, 0x08, 0x08, 0x18, 0x18, 0x18, 0x10, 0x10, 0x10, 0x30, 0x30,
  0x20, 0x20, 0x20, 0x20, 0x60, 0x60, 0x40, 0x40, 0x40, 0x40, 0xC0, 0xC0,
  0x80, 0x80, 0x80, 0x00, 0x01, 0x00, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60,
  0x00, 0x20, 0x04, 0x60, 0x03, 0xE0, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00,
  0x08, 0x00, 0x60, 0x40, 0x06, 0x02, 0x00, 0x60, 0x30, 0x06, 0x01, 0x80,
  0x60, 0x08, 0x06, 0x00, 0x40, 0x60, 0x02, 0x06, 0x00, 0x10, 0x60, 0x01,
  0x86, 0x00, 0x0C, 0x40, 0x00, 0x44, 0x00, 0x02, 0x50, 0x00, 0x14, 0x80,
  0x00, 0xC2, 0x00, 0x0C, 0x18, 0x00, 0x40, 0x40, 0x02, 0x03, 0x00, 0x10,
  0x08, 0x00, 0x80, 0x60, 0x0C, 0x01, 0x00, 0x60, 0x0C, 0x02, 0x00, 0x20,
  0x10, 0x01, 0x80, 0x80, 0x04, 0x04, 0x00, 0x30, 0x60, 0x00, 0x80, 0x02,
  0x02, 0x02, 0x02, 0x06, 0x06, 0x04, 0x04, 0x04, 0x04, 0x0C, 0x0C, 0x08,
  0x08, 0x08, 0x08, 0x18, 0x18, 0x10, 0x10, 0x10, 0x30, 0x30, 0x20, 0x20,
  0x20, 0x20, 0x60, 0x60, 0x40, 0x40, 0x40, 0x40, 0xC0, 0xC0, 0x80, 0x80,
  0x80, 0x04, 0x1F, 0x80, 0x3F, 0x01, 0x8E, 0x38, 0x1C, 0x30, 0x33, 0x01,
  0x86, 0x03, 0x06, 0xC0, 0x11, 0x00, 0x20, 0xB0, 0x02, 0x40, 0x04, 0x14,
  0x00, 0x78, 0x00, 0xC3, 0x00, 0x0E, 0x00, 0x18, 0xE0, 0x01, 0x80, 0x03,
  0x18, 0x00, 0x30, 0x00, 0x63, 0x00, 0x04, 0x00, 0x08, 0x40, 0x00, 0x80,
  0x01, 0x08, 0x00, 0x10, 0x00, 0x21, 0x00, 0x02, 0x00, 0x0C, 0x60, 0x00,
  0xC0, 0x01, 0x8C, 0x00, 0x18, 0x00, 0x31, 0x00, 0x02, 0x00, 0x04, 0x20,
  0x00, 0x40, 0x00, 0x84, 0x00, 0x08, 0x00, 0x10, 0x80, 0x01, 0x00, 0x06,
  0x30, 0x00, 0x60, 0x00, 0xC6, 0x00, 0x0C, 0x00, 0x10, 0x80, 0x01, 0x00,
  0x02, 0x10, 0x00, 0x20, 0x00, 0x42, 0x00, 0x04, 0x00, 0x08, 0x40, 0x00,
  0x80, 0x03, 0x18, 0x00, 0x30, 0x00, 0x63, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x04, 0x1F, 0x80, 0x47, 0x0C, 0x04, 0xC0, 0x60, 0xD8, 0x02, 0x0D, 0x00,
  0x30, 0xA0, 0x03, 0x0E, 0x00, 0x30, 0xC0, 0x03, 0x08, 0x00, 0x31, 0x80,
  0x03, 0x18, 0x00, 0x21, 0x00, 0x02, 0x10, 0x00, 0x21, 0x00, 0x02, 0x30,
  0x00, 0x63, 0x00, 0x06, 0x20, 0x00, 0x42, 0x00, 0x04, 0x20, 0x00, 0x42,
  0x00, 0x04, 0x60, 0x00, 0xC6, 0x00, 0x08, 0x40, 0x00, 0x84, 0x00, 0x08,
  0x40, 0x00, 0x84, 0x00, 0x18, 0xC0, 0x01, 0x80, 0x00, 0x7E, 0x00, 0x38,
  0x70, 0x18, 0x03, 0x06, 0x00, 0x20, 0x80, 0x06, 0x30, 0x00, 0x4C, 0x00,
  0x09, 0x00, 0x01, 0x20, 0x00, 0x2C, 0x00, 0x05, 0x00, 0x00, 0xA0, 0x00,
  0x14, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x50, 0x00, 0x0A, 0x00, 0x03, 0x40, 0x00, 0x4C, 0x00, 0x19, 0x80, 0x02,
  0x10, 0x00, 0xC3, 0x00, 0x30, 0x30, 0x0C, 0x03, 0x87, 0x00, 0x3F, 0x80,
  0x00, 0x02, 0x0F, 0xC0, 0x11, 0xC7, 0x00, 0xB0, 0x0C, 0x0F, 0x00, 0x30,
  0x70, 0x00, 0x83, 0x00, 0x04, 0x10, 0x00, 0x20, 0x80, 0x01, 0x0C, 0x00,
  0x08, 0x60, 0x00, 0x42, 0x00, 0x02, 0x10, 0x00, 0x10, 0x80, 0x00, 0x84,
  0x00, 0x0C, 0x60, 0x00, 0x63, 0x00, 0x02, 0x10, 0x00, 0x10, 0x80, 0x00,
  0x84, 0x00, 0x0C, 0x20, 0x00, 0x43, 0x00, 0x02, 0x18, 0x00, 0x20, 0xC0,
  0x03, 0x07, 0x00, 0x10, 0x2C, 0x03, 0x01, 0x38, 0x70, 0x18, 0x7E, 0x00,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x10, 0x38, 0x71, 0x06, 0x01, 0xB0, 0xC0,
  0x0E, 0x18, 0x00, 0x61, 0x00, 0x06, 0x30, 0x00, 0x22, 0x00, 0x06, 0x20,
  0x00, 0x66, 0x00, 0x04, 0x60, 0x00, 0x44, 0x00, 0x04, 0x40, 0x00, 0x44,
  0x00, 0x0C, 0xC0, 0x00, 0xCC, 0x00, 0x08, 0xC0, 0x00, 0x88, 0x00, 0x08,
  0x80, 0x00, 0x88, 0x00, 0x18, 0x80, 0x01, 0x8C, 0x00, 0x10, 0x40, 0x03,
  0x04, 0x00, 0x70, 0x60, 0x19, 0x03, 0x87, 0x30, 0x0F, 0xC2, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00,
  0x04, 0x1E, 0x08, 0xC0, 0x12, 0x00, 0x68, 0x00, 0xE0, 0x01, 0x40, 0x03,
  0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x03, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x78, 0xE0, 0x18, 0x02, 0x06, 0x00,
  0x60, 0x80, 0x04, 0x20, 0x00, 0x84, 0x00, 0x10, 0x80, 0x00, 0x10, 0x00,
  0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0x88, 0x00, 0x11, 0x00, 0x02, 0x30, 0x00, 0xC2, 0x00, 0x30,
  0x60, 0x0C, 0x07, 0x8F, 0x00, 0x3F, 0x80, 0x00, 0x06, 0x00, 0xC0, 0x18,
  0x02, 0x00, 0x40, 0x08, 0x03, 0x07, 0xFF, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x01, 0x80, 0x30, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0xC0, 0x18, 0x02,
  0x00, 0x40, 0x08, 0x03, 0x00, 0x60, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x62, 0x07, 0xC0, 0x10, 0x00, 0x22, 0x00, 0x04,
  0xC0, 0x01, 0x98, 0x00, 0x22, 0x00, 0x04, 0x40, 0x00, 0x88, 0x00, 0x11,
  0x00, 0x06, 0x60, 0x00, 0xCC, 0x00, 0x11, 0x00, 0x02, 0x20, 0x00, 0x44,
  0x00, 0x08, 0x80, 0x03, 0x30, 0x00, 0x66, 0x00, 0x08, 0x80, 0x01, 0x10,
  0x00, 0x22, 0x00, 0x0C, 0x40, 0x01, 0x88, 0x00, 0x21, 0x00, 0x0C, 0x20,
  0x03, 0x86, 0x00, 0xD0, 0x40, 0x36, 0x0E, 0x1C, 0xC0, 0x7E, 0x00, 0x00,
  0xC0, 0x00, 0x58, 0x00, 0x09, 0x00, 0x02, 0x20, 0x00, 0x44, 0x00, 0x10,
  0x80, 0x02, 0x18, 0x00, 0xC3, 0x00, 0x10, 0x20, 0x06, 0x04, 0x00, 0x80,
  0x80, 0x30, 0x10, 0x04, 0x03, 0x01, 0x80, 0x60, 0x20, 0x04, 0x0C, 0x00,
  0x81, 0x00, 0x10, 0x60, 0x02, 0x08, 0x00, 0x63, 0x00, 0x0C, 0x40, 0x00,
  0x88, 0x00, 0x12, 0x00, 0x02, 0x40, 0x00, 0x50, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x1C, 0x00, 0x60, 0x03,
  0xC0, 0x06, 0x00, 0x2C, 0x00, 0xA0, 0x02, 0xC0, 0x0A, 0x00, 0x64, 0x01,
  0xA0, 0x04, 0x40, 0x13, 0x00, 0xC4, 0x03, 0x30, 0x08, 0x40, 0x23, 0x01,
  0x84, 0x02, 0x30, 0x18, 0x40, 0x63, 0x01, 0x04, 0x04, 0x10, 0x30, 0x40,
  0xC1, 0x02, 0x04, 0x08, 0x10, 0x60, 0x61, 0x81, 0x06, 0x06, 0x10, 0x10,
  0x40, 0x63, 0x01, 0x0C, 0x06, 0x20, 0x10, 0x80, 0x62, 0x01, 0x98, 0x06,
  0x60, 0x19, 0x00, 0x24, 0x01, 0x90, 0x02, 0xC0, 0x0B, 0x00, 0x28, 0x00,
  0xA0, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x20, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x0C, 0x18, 0x00, 0x60, 0x20, 0x03,
  0x00, 0xC0, 0x08, 0x01, 0x00, 0x60, 0x06, 0x03, 0x00, 0x08, 0x08, 0x00,
  0x30, 0x40, 0x00, 0x43, 0x00, 0x01, 0x18, 0x00, 0x06, 0x40, 0x00, 0x0A,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x12, 0x00,
  0x00, 0xCC, 0x00, 0x06, 0x10, 0x00, 0x10, 0x40, 0x00, 0x81, 0x80, 0x06,
  0x02, 0x00, 0x30, 0x0C, 0x00, 0x80, 0x10, 0x04, 0x00, 0x60, 0x30, 0x01,
  0x81, 0x80, 0x03, 0x04, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x02, 0x00,
  0x02, 0x02, 0x00, 0x06, 0x02, 0x00, 0x04, 0x02, 0x00, 0x0C, 0x03, 0x00,
  0x08, 0x03, 0x00, 0x18, 0x01, 0x00, 0x10, 0x01, 0x00, 0x30, 0x01, 0x00,
  0x20, 0x01, 0x00, 0x60, 0x01, 0x80, 0x40, 0x01, 0x80, 0xC0, 0x00, 0x80,
  0x80, 0x00, 0x81, 0x80, 0x00, 0x81, 0x00, 0x00, 0x83, 0x00, 0x00, 0x82,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x48,
  0x00, 0x00, 0x58, 0x00, 0x00, 0x50, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x03, 0x00,
  0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00,
  0xC0, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x18, 0x00, 0xE0, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x01, 0x00, 0x01, 0x03, 0x03, 0x03, 0x02, 0x02, 0x02, 0x06, 0x06,
  0x06, 0x06, 0x04, 0x04, 0x04, 0x0C, 0x0C, 0x0C, 0x08, 0x08, 0x08, 0x18,
  0x18, 0x18, 0x18, 0x10, 0x10, 0x10, 0x30, 0x30, 0x30, 0x20, 0x20, 0x20,
  0x60, 0x60, 0x60, 0x40, 0x40, 0x40, 0xC0, 0xC0, 0xC0, 0xC0, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x10, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0F,
  0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0xE0, 0x00, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x18, 0xE0, 0x02, 0x30, 0x30,
  0x02, 0x60, 0x10, 0x06, 0x40, 0x18, 0x04, 0x40, 0x0C, 0x0C, 0xC0, 0x07,
  0x18, 0x00, 0x01, 0xE0,
};

const GFXglyph RobotoCondensed_ThinItalic51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 8, 36, 9, 1, -36 },
  { 37, 8, 10, 13, 6, -38 },
  { 47, 25, 36, 24, 1, -36 },
  { 160, 21, 46, 24, 2, -41 },
  { 281, 24, 36, 32, 5, -36 },
  { 389, 23, 37, 27, 1, -36 },
  { 496, 4, 10, 8, 5, -38 },
  { 501, 14, 52, 14, 2, -40 },
  { 592, 14, 52, 14, -3, -40 },
  { 683, 20, 20, 21, 3, -36 },
  { 733, 21, 27, 24, 2, -30 },
  { 804, 5, 10, 9, -1, -4 },
  { 811, 10, 1, 13, 2, -17 },
  { 813, 3, 3, 11, 1, -3 },
  { 815, 21, 39, 17, -2, -36 },
  { 918, 21, 36, 24, 2, -36 },
  { 1013, 11, 36, 24, 7, -36 },
  { 1063, 21, 36, 24, 1, -36 },
  { 1158, 22, 36, 24, 1, -36 },
  { 1257, 21, 36, 24, 1, -36 },
  { 1352, 21, 36, 24, 3, -36 },
  { 1447, 19, 36, 24, 2, -36 },
  { 1533, 20, 36, 24, 4, -36 },
  { 1623, 22, 36, 24, 1, -36 },
  { 1722, 18, 36, 24, 4, -36 },
  { 1803, 7, 27, 9, 1, -27 },
  { 1827, 10, 33, 9, -2, -27 },
  { 1869, 19, 20, 22, 2, -27 },
  { 1917, 19, 11, 24, 3, -22 },
  { 1944, 19, 20, 23, 1, -27 },
  { 1992, 15, 36, 19, 5, -36 },
  { 2060, 35, 46, 40, 2, -35 },
  { 2262, 23, 36, 26, -1, -36 },
  { 2366, 23, 36, 26, 2, -36 },
  { 2470, 24, 36, 28, 3, -36 },
  { 2578, 25, 36, 28, 2, -36 },
  { 2691, 24, 36, 25, 2, -36 },
  { 2799, 25, 36, 25, 2, -36 },
  { 2912, 25, 36, 30, 3, -36 },
  { 3025, 28, 36, 30, 2, -36 },
  { 3151, 7, 36, 12, 3, -36 },
  { 3183, 22, 36, 24, 1, -36 },
  { 3282, 26, 36, 28, 2, -36 },
  { 3399, 17, 36, 23, 2, -36 },
  { 3476, 34, 36, 37, 2, -36 },
  { 3629, 28, 36, 31, 2, -36 },
  { 3755, 24, 36, 29, 3, -36 },
  { 3863, 24, 36, 26, 2, -36 },
  { 3971, 24, 43, 29, 3, -36 },
  { 4100, 24, 36, 28, 2, -36 },
  { 4208, 25, 36, 26, 1, -36 },
  { 4321, 23, 36, 26, 5, -36 },
  { 4425, 25, 36, 29, 3, -36 },
  { 4538, 24, 36, 26, 4, -36 },
  { 4646, 36, 36, 39, 5, -36 },
  { 4808, 28, 36, 26, -1, -36 },
  { 4934, 23, 36, 26, 5, -36 },
  { 5038, 27, 36, 26, 0, -36 },
  { 5160, 13, 49, 10, 1, -41 },
  { 5240, 7, 39, 17, 5, -36 },
  { 5275, 13, 49, 10, -3, -41 },
  { 5355, 13, 18, 18, 3, -36 },
  { 5385, 17, 1, 18, -2, 0 },
  { 5388, 5, 7, 13, 7, -39 },
  { 5393, 19, 27, 23, 1, -27 },
  { 5458, 20, 38, 24, 1, -38 },
  { 5553, 19, 27, 22, 2, -27 },
  { 5618, 22, 38, 24, 2, -38 },
  { 5723, 20, 27, 22, 1, -27 },
  { 5791, 15, 39, 14, 3, -39 },
  { 5865, 22, 37, 24, 0, -27 },
  { 5967, 20, 38, 24, 1, -38 },
  { 6062, 8, 37, 10, 2, -37 },
  { 6099, 17, 47, 10, -7, -37 },
  { 6199, 21, 38, 21, 1, -38 },
  { 6299, 8, 38, 10, 2, -38 },
  { 6337, 35, 27, 39, 1, -27 },
  { 6456, 20, 27, 24, 1, -27 },
  { 6524, 19, 27, 24, 2, -27 },
  { 6589, 21, 37, 24, 0, -27 },
  { 6687, 20, 37, 24, 2, -27 },
  { 6780, 15, 27, 15, 1, -27 },
  { 6831, 19, 27, 22, 1, -27 },
  { 6896, 11, 34, 14, 3, -34 },
  { 6943, 19, 27, 24, 3, -27 },
  { 7008, 19, 27, 21, 3, -27 },
  { 7073, 28, 27, 33, 4, -27 },
  { 7168, 22, 27, 21, -1, -27 },
  { 7243, 24, 37, 21, -2, -27 },
  { 7354, 21, 27, 21, 0, -27 },
  { 7425, 16, 51, 14, 2, -40 },
  { 7527, 8, 43, 10, 1, -36 },
  { 7570, 16, 51, 14, -3, -40 },
  { 7672, 24, 8, 30, 3, -19 },
};

const GFXfont RobotoCondensed_ThinItalic51pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ThinItalic51pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ThinItalic51pt7bGlyphs,
  0x20, 0x7E, 60
};

#endif // _ROBOTOCONDENSED_THINITALIC51PT7B_H_
