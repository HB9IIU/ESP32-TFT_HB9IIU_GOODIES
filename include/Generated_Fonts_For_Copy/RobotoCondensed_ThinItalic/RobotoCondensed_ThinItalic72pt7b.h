#ifndef _ROBOTOCONDENSED_THINITALIC72PT7B_H_
#define _ROBOTOCONDENSED_THINITALIC72PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ThinItalic.ttf
// Size: 72pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ThinItalic72pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x04, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x30,
  0x00, 0x30, 0x66, 0x0C, 0xC1, 0x98, 0x33, 0x06, 0xE1, 0xD8, 0x33, 0x06,
  0x60, 0xCC, 0x19, 0x83, 0x60, 0xCC, 0x19, 0x83, 0x00, 0x00, 0x00, 0x18,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00,
  0x01, 0x00, 0x18, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x03, 0x00, 0x30,
  0x00, 0x00, 0x20, 0x03, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x06, 0x00, 0x00, 0x04, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x0C, 0x00, 0x00, 0x18, 0x01, 0x80,
  0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0x00,
  0x10, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x02, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0x60, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x08, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x18, 0x00, 0x00, 0x10, 0x01, 0x80, 0x00, 0x03, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x03, 0x00, 0x00, 0x02, 0x00, 0x30, 0x00, 0x00, 0x60, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0x40, 0x06, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x08, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x18, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x01, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x78, 0x1E, 0x00,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x00, 0xC0, 0x06, 0x00, 0x03, 0x00, 0x60,
  0x00, 0x18, 0x06, 0x00, 0x00, 0x60, 0x30, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x18, 0x18, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x30,
  0x60, 0x00, 0x01, 0x83, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x02, 0x18, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x01, 0x86, 0x00, 0x00, 0x0C,
  0x30, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x06, 0x06, 0x00, 0x00, 0x60, 0x30,
  0x00, 0x07, 0x01, 0xC0, 0x00, 0x30, 0x07, 0x00, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x00, 0x78, 0x0F, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x01, 0x80, 0x30, 0x00, 0x01, 0x80,
  0x18, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x60,
  0x01, 0x00, 0x0C, 0x30, 0x00, 0x80, 0x0C, 0x30, 0x00, 0x40, 0x06, 0x18,
  0x00, 0x60, 0x06, 0x0C, 0x00, 0x30, 0x06, 0x06, 0x00, 0x18, 0x07, 0x03,
  0x00, 0x0C, 0x03, 0x01, 0x80, 0x04, 0x03, 0x00, 0xC0, 0x06, 0x03, 0x00,
  0x60, 0x03, 0x01, 0x80, 0x30, 0x03, 0x01, 0x80, 0x18, 0x01, 0x81, 0x80,
  0x06, 0x01, 0x80, 0xC0, 0x03, 0x81, 0x80, 0xC0, 0x00, 0xFF, 0x80, 0xC0,
  0x00, 0x3F, 0x80, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x30, 0x0F, 0xE0, 0x00, 0x18, 0x0F, 0xF8, 0x00, 0x18,
  0x0C, 0x06, 0x00, 0x18, 0x0C, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0xC0, 0x0C,
  0x06, 0x00, 0x60, 0x0C, 0x06, 0x00, 0x30, 0x06, 0x03, 0x00, 0x18, 0x06,
  0x01, 0x80, 0x0C, 0x06, 0x01, 0x80, 0x06, 0x03, 0x00, 0xC0, 0x03, 0x03,
  0x00, 0x60, 0x01, 0x83, 0x00, 0x30, 0x00, 0xC3, 0x00, 0x10, 0x00, 0x61,
  0x80, 0x08, 0x00, 0x61, 0x80, 0x04, 0x00, 0x31, 0x80, 0x02, 0x00, 0x18,
  0xC0, 0x01, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x60, 0x0C,
  0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x06, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x40, 0x00, 0x30, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x60, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x60, 0x01,
  0x80, 0x00, 0x60, 0x03, 0x00, 0x00, 0x60, 0x07, 0x00, 0x00, 0x60, 0x0E,
  0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x30, 0x38, 0x00, 0x00, 0x30, 0x70,
  0x00, 0x00, 0x30, 0xE0, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x1B, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x67, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x03, 0x01, 0x80, 0x00, 0x06, 0x00, 0xC0, 0x03, 0x0C, 0x00, 0xC0,
  0x03, 0x0C, 0x00, 0x60, 0x06, 0x18, 0x00, 0x70, 0x06, 0x30, 0x00, 0x30,
  0x06, 0x30, 0x00, 0x18, 0x0E, 0x60, 0x00, 0x18, 0x0C, 0x60, 0x00, 0x0C,
  0x0C, 0x60, 0x00, 0x0C, 0x18, 0x60, 0x00, 0x06, 0x18, 0xC0, 0x00, 0x07,
  0x30, 0xC0, 0x00, 0x03, 0x30, 0xC0, 0x00, 0x01, 0xE0, 0xC0, 0x00, 0x01,
  0xE0, 0x60, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x03,
  0x60, 0x30, 0x00, 0x06, 0x70, 0x38, 0x00, 0x1C, 0x30, 0x1C, 0x00, 0x30,
  0x18, 0x0F, 0x01, 0xE0, 0x18, 0x03, 0xFF, 0x80, 0x0C, 0x00, 0xFC, 0x00,
  0x00, 0x18, 0xC6, 0x73, 0x18, 0xC6, 0x33, 0x18, 0xC6, 0x31, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x08,
  0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x04, 0x00, 0x60, 0x02,
  0x70, 0x06, 0x01, 0xF3, 0xE0, 0x60, 0x7C, 0x0F, 0x86, 0x3E, 0x00, 0x1E,
  0x6F, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0x30, 0x00, 0x00, 0x73, 0x00, 0x00, 0x0E, 0x18, 0x00, 0x01,
  0xC1, 0xC0, 0x00, 0x18, 0x0C, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x60, 0x06,
  0x00, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x00, 0x38, 0x00, 0x18, 0x01,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x0C, 0x18,
  0x30, 0x61, 0x83, 0x06, 0x18, 0x30, 0xC3, 0x8E, 0x08, 0x00, 0xFF, 0xFB,
  0xFF, 0xE0, 0x6F, 0xFC, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x38, 0x03, 0x80, 0x03, 0x00,
  0x0E, 0x00, 0x30, 0x00, 0x30, 0x03, 0x80, 0x00, 0xC0, 0x18, 0x00, 0x06,
  0x01, 0x80, 0x00, 0x30, 0x0C, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x06, 0x06,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x01, 0x83, 0x00, 0x00, 0x0C, 0x18, 0x00,
  0x00, 0x61, 0x80, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x31, 0x80, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x06, 0x30, 0x00,
  0x00, 0x31, 0x80, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00,
  0xC2, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x31, 0x80, 0x00, 0x01, 0x8C,
  0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x06, 0x18, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x01, 0x84, 0x00, 0x00, 0x18, 0x20, 0x00, 0x00,
  0xC1, 0x00, 0x00, 0x06, 0x08, 0x00, 0x00, 0x60, 0x40, 0x00, 0x03, 0x03,
  0x00, 0x00, 0x18, 0x18, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x0C, 0x06, 0x00,
  0x00, 0xC0, 0x30, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x60, 0x06, 0x00, 0x06,
  0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x06, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x06, 0x00, 0x3C,
  0x03, 0xF8, 0x1E, 0x21, 0xF0, 0xCF, 0x81, 0xB8, 0x03, 0x40, 0x06, 0x00,
  0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x06, 0x00, 0x30, 0x00, 0x18, 0x03, 0x00, 0x00, 0xC0, 0x30, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x18, 0x18, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0x30, 0x60, 0x00, 0x01, 0x83, 0x00, 0x00, 0x0C, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0xF0, 0x1C, 0x00, 0x07, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70,
  0x01, 0x80, 0x00, 0xC0, 0x0C, 0x00, 0x01, 0x80, 0x70, 0x00, 0x06, 0x01,
  0x80, 0x00, 0x08, 0x0E, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x03, 0x06, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x10, 0xC0,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x0C, 0x18, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x01, 0x81, 0x80, 0x00, 0x0C, 0x03, 0x00, 0x00,
  0x70, 0x0E, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0,
  0x00, 0x78, 0x0F, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0x60, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00,
  0x19, 0x80, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x0E, 0x18, 0x00, 0x00, 0x61, 0x80, 0x00, 0x06, 0x0C, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x03, 0x03, 0x00, 0x00, 0x30, 0x18, 0x00, 0x03,
  0x00, 0x80, 0x00, 0x38, 0x0C, 0x00, 0x01, 0x80, 0x60, 0x00, 0x18, 0x03,
  0x00, 0x01, 0x80, 0x18, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0xC0, 0x04, 0x00,
  0x0C, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x00, 0xC0, 0x06, 0x00, 0x06, 0x00, 0x70, 0x00, 0x20, 0x03, 0x00, 0x03,
  0x00, 0x30, 0x00, 0x18, 0x03, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x06, 0x01,
  0x80, 0x00, 0x30, 0x18, 0x00, 0x03, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xF8, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x30, 0x7F, 0x00, 0x00, 0x67,
  0xFF, 0x80, 0x00, 0xDC, 0x03, 0x80, 0x01, 0xE0, 0x01, 0x80, 0x07, 0x00,
  0x01, 0x80, 0x04, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x10, 0x00, 0x00, 0x60,
  0x20, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x06, 0x01,
  0x80, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x60, 0x06,
  0x00, 0x01, 0x80, 0x0C, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x70, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x1F, 0xC0, 0x06, 0x0F, 0xFE, 0x01, 0x87,
  0x00, 0xE0, 0x31, 0x80, 0x0E, 0x06, 0x60, 0x00, 0xE0, 0x98, 0x00, 0x0C,
  0x36, 0x00, 0x00, 0xC7, 0x80, 0x00, 0x18, 0xE0, 0x00, 0x03, 0x18, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x1B,
  0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x0D, 0x80, 0x00,
  0x01, 0x20, 0x00, 0x00, 0x64, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x01, 0x90,
  0x00, 0x00, 0x32, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x03, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x18, 0x06, 0x00, 0x07, 0x00, 0xE0, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x00, 0xF0, 0x3C, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x06,
  0x00, 0xE0, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x02,
  0x01, 0x80, 0x00, 0x02, 0x01, 0x80, 0x00, 0x02, 0x01, 0x80, 0x00, 0x06,
  0x01, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x18,
  0x01, 0x80, 0x00, 0x38, 0x00, 0xC0, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0x70, 0x01, 0xC0, 0x00, 0x38, 0x07, 0x80, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x01, 0xE0, 0x03, 0x80,
  0x03, 0x80, 0x01, 0xC0, 0x07, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x60,
  0x0C, 0x00, 0x00, 0x70, 0x18, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x30,
  0x30, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x30,
  0x60, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x30,
  0x60, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x03, 0x80,
  0x38, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x07, 0x80, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x70,
  0x03, 0x80, 0x18, 0x00, 0x30, 0x06, 0x00, 0x03, 0x01, 0x80, 0x00, 0x60,
  0x70, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x18, 0x60, 0x00,
  0x03, 0x18, 0x00, 0x00, 0x73, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0xD8,
  0x00, 0x00, 0x1B, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x68, 0x00, 0x00,
  0x0B, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x0D, 0x80,
  0x00, 0x01, 0xB0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0x71, 0x80, 0x00, 0x1E, 0x30, 0x00, 0x03, 0xC7, 0x00,
  0x00, 0xD8, 0x60, 0x00, 0x33, 0x0E, 0x00, 0x0C, 0xC0, 0xE0, 0x07, 0x18,
  0x0E, 0x03, 0xC3, 0x00, 0xFF, 0xE0, 0x40, 0x07, 0xF0, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0x80, 0xF0, 0x3C,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x06, 0x03, 0xC0, 0xF0, 0x18, 0x00, 0x00, 0x30, 0x03, 0xC0,
  0x1E, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03,
  0x00, 0x38, 0x01, 0x80, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x40,
  0x1F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x00, 0x04, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x03, 0xFF, 0x00, 0x3C, 0x0E, 0x01, 0xC0, 0x1C, 0x0E,
  0x00, 0x30, 0x30, 0x00, 0x61, 0x80, 0x01, 0x8C, 0x00, 0x06, 0x30, 0x00,
  0x19, 0x80, 0x00, 0x26, 0x00, 0x00, 0x98, 0x00, 0x06, 0x40, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x18, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x07, 0x00, 0x00, 0xFC, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0xC0, 0x30, 0x00, 0x3C, 0x0E, 0x00, 0x18, 0x06, 0x00, 0x0E,
  0x00, 0xE0, 0x01, 0x01, 0x80, 0x03, 0x80, 0x0C, 0x00, 0x20, 0x30, 0x00,
  0x60, 0x01, 0x80, 0x04, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0x81, 0x80,
  0x06, 0x00, 0x0C, 0x00, 0x10, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x0C,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x41, 0x80, 0x06, 0x00, 0x04, 0x00, 0x18,
  0x60, 0x01, 0x80, 0x01, 0x80, 0x03, 0x0C, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x61, 0x80, 0x0C, 0x00, 0x06, 0x00, 0x0C, 0x60, 0x01, 0x80, 0x00, 0x80,
  0x01, 0x8C, 0x00, 0x60, 0x00, 0x30, 0x00, 0x31, 0x80, 0x0C, 0x00, 0x06,
  0x00, 0x0C, 0x30, 0x01, 0x80, 0x00, 0xC0, 0x01, 0x84, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x31, 0x80, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x30, 0x01, 0x80,
  0x00, 0xC0, 0x01, 0x86, 0x00, 0x30, 0x00, 0x18, 0x00, 0x30, 0xC0, 0x06,
  0x00, 0x03, 0x00, 0x06, 0x18, 0x00, 0x80, 0x00, 0xC0, 0x01, 0x82, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x30, 0x40, 0x06, 0x00, 0x07, 0x00, 0x06, 0x08,
  0x00, 0xC0, 0x00, 0xE0, 0x01, 0x83, 0x00, 0x18, 0x00, 0x3C, 0x00, 0x30,
  0x60, 0x03, 0x00, 0x05, 0x00, 0x0C, 0x0C, 0x00, 0x60, 0x01, 0xB0, 0x01,
  0x80, 0x80, 0x0C, 0x00, 0x66, 0x00, 0x60, 0x18, 0x00, 0xC0, 0x18, 0xC0,
  0x18, 0x03, 0x00, 0x18, 0x06, 0x1C, 0x07, 0x00, 0x60, 0x01, 0x83, 0x81,
  0xC3, 0x80, 0x0C, 0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x01, 0x80, 0x00, 0xE0,
  0x00, 0xF0, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0x20,
  0x00, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0x18,
  0xC0, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x00, 0x60, 0x40, 0x00, 0x00, 0x10, 0x10, 0x00, 0x00,
  0x0C, 0x06, 0x00, 0x00, 0x02, 0x01, 0x80, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x00, 0x40, 0x18, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x08, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x20, 0x00, 0x01, 0x80, 0x08, 0x00, 0x00, 0xC0, 0x03,
  0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x10, 0x00, 0x18, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x03,
  0x00, 0x00, 0x60, 0x01, 0x80, 0x00, 0x18, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC,
  0x01, 0x80, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00,
  0x30, 0x18, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x03, 0x01, 0x00, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x06, 0x18, 0x00,
  0x00, 0x01, 0x86, 0x00, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0xC0, 0x00, 0xF0, 0x00, 0xC0, 0x00, 0x38, 0x00, 0xC0, 0x00, 0x1C,
  0x00, 0xC0, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x06, 0x01, 0x80, 0x00, 0x06,
  0x01, 0x80, 0x00, 0x02, 0x01, 0x80, 0x00, 0x03, 0x01, 0x80, 0x00, 0x03,
  0x01, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x06,
  0x02, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x18,
  0x06, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x60, 0x06, 0x00, 0x01, 0xC0,
  0x04, 0x00, 0x07, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x0C, 0x00, 0x07, 0x80, 0x0C, 0x00, 0x01, 0xE0, 0x0C, 0x00, 0x00, 0x60,
  0x18, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x18,
  0x18, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x18, 0x10, 0x00, 0x00, 0x18,
  0x30, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x18,
  0x30, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x18, 0x20, 0x00, 0x00, 0x30,
  0x60, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x01, 0x80, 0x40, 0x00, 0x03, 0x80,
  0xC0, 0x00, 0x0F, 0x00, 0xC0, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x78, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x06, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x30, 0x03, 0x00,
  0x00, 0x06, 0x01, 0x80, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x00, 0x60, 0x30,
  0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x03,
  0x08, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x00, 0x18, 0x18, 0x00,
  0x00, 0x06, 0x06, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x38, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80,
  0x00, 0x78, 0x07, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03,
  0x00, 0x01, 0xE0, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x00, 0xE0,
  0x01, 0x00, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00,
  0x1C, 0x01, 0x80, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x30, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x80, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x0C, 0x06,
  0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x10, 0x18, 0x00, 0x00, 0x02,
  0x03, 0x00, 0x00, 0x00, 0x40, 0x40, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00,
  0x03, 0x03, 0x00, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x0C, 0x0C, 0x00,
  0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0x30, 0x20, 0x00, 0x00, 0x04, 0x0C,
  0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x06,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00,
  0x02, 0x06, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x18, 0x18, 0x00,
  0x00, 0x03, 0x03, 0x00, 0x00, 0x00, 0x60, 0x40, 0x00, 0x00, 0x18, 0x18,
  0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x18,
  0x0C, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x00,
  0x18, 0x0C, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x01, 0x80, 0x30, 0x00,
  0x00, 0x70, 0x06, 0x00, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x10,
  0x00, 0x01, 0xC0, 0x06, 0x00, 0x00, 0xF0, 0x00, 0xC0, 0x00, 0x78, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0C, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x38, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x0E, 0x00, 0x00,
  0x38, 0x03, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x00, 0x30, 0x30, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x03, 0x06, 0x00,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x1F, 0xFF, 0x86, 0x00, 0x07, 0xFF, 0xE1, 0x80, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00,
  0x0C, 0x30, 0x00, 0x00, 0x06, 0x04, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x06, 0x03, 0x00,
  0x00, 0x03, 0x80, 0x60, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x01, 0xE0, 0x03,
  0x80, 0x03, 0xE0, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x01, 0x80,
  0x00, 0x00, 0x08, 0x03, 0x00, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x10, 0x00, 0x00, 0x01, 0x80, 0x60,
  0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x01, 0x80, 0x00, 0x00,
  0x18, 0x03, 0x00, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x00, 0x60, 0x08,
  0x00, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00,
  0x02, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x00, 0x18, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x04, 0x00, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00,
  0x00, 0xC0, 0x30, 0x00, 0x00, 0x01, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x00, 0x18, 0x02, 0x00, 0x00,
  0x00, 0x30, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x80, 0x00,
  0x00, 0x0C, 0x03, 0x00, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x00, 0x20,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x01, 0x80, 0x30, 0x00,
  0x00, 0x03, 0x00, 0x40, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x03, 0x00, 0x00, 0x00, 0x10, 0x06, 0x00, 0x00, 0x00, 0x60, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x01, 0x80, 0x20, 0x00, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x00, 0x08, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x10, 0x00, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0x00, 0x04, 0x01, 0x80, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x40, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x40, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x80, 0x60, 0x00, 0x01, 0x80, 0x60, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x01, 0x80, 0x60, 0x00, 0x03, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x60, 0x00, 0x06, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30,
  0x00, 0x1C, 0x00, 0xE0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x06, 0x00,
  0x00, 0x03, 0x80, 0x30, 0x00, 0x00, 0x38, 0x01, 0x80, 0x00, 0x03, 0x80,
  0x0C, 0x00, 0x00, 0x38, 0x00, 0x40, 0x00, 0x03, 0x80, 0x06, 0x00, 0x00,
  0x38, 0x00, 0x30, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0x38, 0x00, 0x0C,
  0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x02, 0x00, 0x03, 0x80,
  0x00, 0x30, 0x00, 0x38, 0x00, 0x01, 0x80, 0x03, 0x80, 0x00, 0x0C, 0x00,
  0x38, 0x00, 0x00, 0x60, 0x03, 0x80, 0x00, 0x03, 0x00, 0x38, 0x00, 0x00,
  0x10, 0x03, 0x80, 0x00, 0x01, 0x80, 0x38, 0x00, 0x00, 0x0C, 0x03, 0x80,
  0x00, 0x00, 0x60, 0x38, 0x00, 0x00, 0x03, 0x03, 0x80, 0x00, 0x00, 0x18,
  0x38, 0x00, 0x00, 0x00, 0x83, 0xC0, 0x00, 0x00, 0x0C, 0x3E, 0x00, 0x00,
  0x00, 0x63, 0x98, 0x00, 0x00, 0x03, 0x30, 0xC0, 0x00, 0x00, 0x1B, 0x03,
  0x00, 0x00, 0x00, 0xB0, 0x18, 0x00, 0x00, 0x0F, 0x00, 0x60, 0x00, 0x00,
  0x70, 0x03, 0x80, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x70,
  0x00, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x04, 0x00, 0x0E, 0x00, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0xC0, 0x00, 0x03, 0x80, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x00,
  0x70, 0x01, 0x00, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x0E, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x07,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x60, 0x00, 0x00, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x0A, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0xB0,
  0x00, 0x00, 0x00, 0x36, 0x01, 0xB0, 0x00, 0x00, 0x00, 0x36, 0x01, 0x98,
  0x00, 0x00, 0x00, 0x66, 0x01, 0x98, 0x00, 0x00, 0x00, 0x66, 0x01, 0x98,
  0x00, 0x00, 0x00, 0xC4, 0x01, 0x98, 0x00, 0x00, 0x00, 0xCC, 0x01, 0x18,
  0x00, 0x00, 0x01, 0x8C, 0x03, 0x08, 0x00, 0x00, 0x01, 0x8C, 0x03, 0x0C,
  0x00, 0x00, 0x03, 0x0C, 0x03, 0x0C, 0x00, 0x00, 0x03, 0x0C, 0x03, 0x0C,
  0x00, 0x00, 0x06, 0x18, 0x03, 0x0C, 0x00, 0x00, 0x04, 0x18, 0x02, 0x04,
  0x00, 0x00, 0x0C, 0x18, 0x06, 0x04, 0x00, 0x00, 0x18, 0x18, 0x06, 0x06,
  0x00, 0x00, 0x18, 0x18, 0x06, 0x06, 0x00, 0x00, 0x30, 0x18, 0x06, 0x06,
  0x00, 0x00, 0x30, 0x30, 0x06, 0x06, 0x00, 0x00, 0x60, 0x30, 0x04, 0x02,
  0x00, 0x00, 0x60, 0x30, 0x0C, 0x03, 0x00, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x01, 0x80, 0x20, 0x0C, 0x03,
  0x00, 0x01, 0x80, 0x60, 0x08, 0x01, 0x00, 0x03, 0x00, 0x60, 0x18, 0x01,
  0x00, 0x03, 0x00, 0x60, 0x18, 0x01, 0x80, 0x06, 0x00, 0x60, 0x18, 0x01,
  0x80, 0x06, 0x00, 0x60, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x18, 0x00,
  0x80, 0x18, 0x00, 0xC0, 0x10, 0x00, 0x80, 0x18, 0x00, 0xC0, 0x30, 0x00,
  0xC0, 0x30, 0x00, 0xC0, 0x30, 0x00, 0xC0, 0x30, 0x00, 0xC0, 0x30, 0x00,
  0xC0, 0x60, 0x00, 0xC0, 0x30, 0x00, 0xC0, 0x60, 0x01, 0x80, 0x30, 0x00,
  0x40, 0xC0, 0x01, 0x80, 0x20, 0x00, 0x40, 0xC0, 0x01, 0x80, 0x60, 0x00,
  0x61, 0x80, 0x01, 0x80, 0x60, 0x00, 0x61, 0x80, 0x01, 0x80, 0x60, 0x00,
  0x63, 0x00, 0x01, 0x80, 0x60, 0x00, 0x23, 0x00, 0x03, 0x00, 0x60, 0x00,
  0x26, 0x00, 0x03, 0x00, 0x40, 0x00, 0x36, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x00,
  0x18, 0x07, 0x80, 0x00, 0x00, 0x30, 0x0F, 0x00, 0x00, 0x00, 0xC0, 0x1B,
  0x00, 0x00, 0x01, 0x80, 0x76, 0x00, 0x00, 0x03, 0x00, 0xC4, 0x00, 0x00,
  0x06, 0x01, 0x8C, 0x00, 0x00, 0x0C, 0x03, 0x18, 0x00, 0x00, 0x10, 0x06,
  0x18, 0x00, 0x00, 0x60, 0x0C, 0x30, 0x00, 0x00, 0xC0, 0x30, 0x20, 0x00,
  0x01, 0x80, 0x60, 0x60, 0x00, 0x03, 0x00, 0xC0, 0xC0, 0x00, 0x06, 0x01,
  0x80, 0x80, 0x00, 0x18, 0x03, 0x01, 0x80, 0x00, 0x30, 0x06, 0x03, 0x00,
  0x00, 0x60, 0x18, 0x03, 0x00, 0x00, 0xC0, 0x30, 0x06, 0x00, 0x01, 0x80,
  0x60, 0x04, 0x00, 0x03, 0x00, 0xC0, 0x0C, 0x00, 0x0C, 0x01, 0x80, 0x18,
  0x00, 0x18, 0x07, 0x00, 0x18, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x00, 0x60,
  0x18, 0x00, 0x20, 0x00, 0xC0, 0x30, 0x00, 0x60, 0x01, 0x80, 0x60, 0x00,
  0xC0, 0x06, 0x00, 0xC0, 0x00, 0xC0, 0x0C, 0x03, 0x00, 0x01, 0x80, 0x18,
  0x06, 0x00, 0x01, 0x00, 0x30, 0x0C, 0x00, 0x03, 0x00, 0x60, 0x18, 0x00,
  0x06, 0x01, 0xC0, 0x30, 0x00, 0x06, 0x03, 0x00, 0x60, 0x00, 0x0C, 0x06,
  0x01, 0x80, 0x00, 0x18, 0x0C, 0x03, 0x00, 0x00, 0x18, 0x18, 0x06, 0x00,
  0x00, 0x30, 0x30, 0x0C, 0x00, 0x00, 0x20, 0xC0, 0x18, 0x00, 0x00, 0x61,
  0x80, 0x30, 0x00, 0x00, 0xC3, 0x00, 0xC0, 0x00, 0x00, 0xC6, 0x01, 0x80,
  0x00, 0x01, 0x8C, 0x03, 0x00, 0x00, 0x01, 0x18, 0x06, 0x00, 0x00, 0x03,
  0x60, 0x0C, 0x00, 0x00, 0x06, 0xC0, 0x10, 0x00, 0x00, 0x07, 0x80, 0x60,
  0x00, 0x00, 0x0F, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x00,
  0x1C, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x06, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x01, 0x80, 0x60,
  0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x00, 0x83, 0x00, 0x00, 0x00,
  0x10, 0x60, 0x00, 0x00, 0x02, 0x18, 0x00, 0x00, 0x00, 0x43, 0x00, 0x00,
  0x00, 0x18, 0x60, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x00, 0x31,
  0x80, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x00,
  0x31, 0x80, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x00, 0x02, 0x18, 0x00, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x03, 0x01, 0x00,
  0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x06, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x0C, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x03, 0xC0, 0x00, 0x1F, 0x01,
  0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0C, 0x00, 0x03, 0x80,
  0x03, 0x00, 0x00, 0x38, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x18, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x18, 0x04, 0x00,
  0x00, 0x06, 0x03, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x60, 0x30,
  0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x80, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x1C,
  0x06, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x03, 0x80, 0x60, 0x00, 0x01,
  0xC0, 0x10, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x00, 0x70, 0x03, 0x00, 0x00,
  0x38, 0x00, 0xC0, 0x00, 0x7C, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0xE0,
  0x00, 0x06, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x00, 0x0C, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x03,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x00, 0x10, 0x60, 0x00, 0x00, 0x02, 0x18, 0x00,
  0x00, 0x00, 0x43, 0x00, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00,
  0x01, 0x86, 0x00, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x06, 0x30, 0x00,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x02, 0x18,
  0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x03,
  0x18, 0x00, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0x08, 0x60, 0x00, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0x0C, 0x30, 0x00,
  0x00, 0x03, 0x06, 0x00, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x08, 0x18,
  0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x00, 0x18,
  0x06, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x0C, 0x00, 0x00,
  0x70, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x03, 0xC0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x01, 0xF1, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x0C, 0x00, 0x03, 0xC0, 0x03, 0x00, 0x00, 0x38, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x38, 0x06, 0x00, 0x00,
  0x06, 0x01, 0x80, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x20, 0x10, 0x00,
  0x00, 0x0C, 0x0C, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x00, 0x20, 0x30, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x06, 0x02,
  0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x30,
  0x18, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x40, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00,
  0x30, 0x03, 0x00, 0x00, 0x38, 0x00, 0xC0, 0x00, 0x3C, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x04,
  0x00, 0x01, 0x80, 0x03, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x80, 0x00, 0x06, 0x00, 0x60, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00,
  0x30, 0x06, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x03, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x10, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x06, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x0E, 0x08,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x0E, 0x00, 0x00, 0x18, 0x03, 0x00,
  0x00, 0x06, 0x01, 0x80, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x30, 0x30,
  0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x80, 0x00, 0x00, 0x20, 0x60, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x0C, 0x30, 0x00,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0x01, 0x83, 0x00, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0xC0, 0x00, 0x07, 0x00, 0x18, 0x00, 0x03, 0x80, 0x03, 0x80, 0x03, 0xC0,
  0x00, 0x7C, 0x07, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x18, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x00, 0x30, 0x10,
  0x00, 0x00, 0x02, 0x03, 0x00, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x00, 0x04, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x0C,
  0x04, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x08, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x00, 0x18, 0x08, 0x00, 0x00, 0x01, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x18, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x00, 0x30, 0x10, 0x00, 0x00, 0x02, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x30, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00,
  0x04, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x0C, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x00, 0x80,
  0x60, 0x00, 0x00, 0x18, 0x04, 0x00, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00,
  0x18, 0x06, 0x00, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0x30, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x03, 0x00, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x1E,
  0x00, 0x00, 0x7C, 0x07, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x03,
  0x18, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00,
  0x30, 0x30, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x30, 0x0C, 0x00,
  0x00, 0x0C, 0x01, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x01, 0x80, 0x18,
  0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x18, 0x00, 0x03, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x10, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x18, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x60,
  0x03, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x06, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x30, 0x00, 0x00, 0x20, 0x0C, 0x00, 0x00, 0x0C, 0x02, 0x00, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x30, 0x30, 0x00,
  0x00, 0x0C, 0x0C, 0x00, 0x00, 0x01, 0x06, 0x00, 0x00, 0x00, 0x41, 0x80,
  0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x01, 0x98,
  0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x02,
  0xC0, 0x00, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1B, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x03, 0x60, 0x00, 0x01, 0xB0,
  0x00, 0x00, 0xD8, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x26, 0x00, 0x00, 0x31,
  0x80, 0x00, 0x19, 0x80, 0x00, 0x18, 0x60, 0x00, 0x04, 0x60, 0x00, 0x06,
  0x18, 0x00, 0x03, 0x18, 0x00, 0x01, 0x86, 0x00, 0x00, 0xC2, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x20, 0x80, 0x00, 0x30, 0x60, 0x00, 0x18, 0x20, 0x00,
  0x0C, 0x18, 0x00, 0x04, 0x08, 0x00, 0x06, 0x06, 0x00, 0x03, 0x03, 0x00,
  0x01, 0x81, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0x60, 0x30,
  0x00, 0x30, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x0C, 0x06, 0x00, 0x04, 0x03,
  0x00, 0x06, 0x01, 0x80, 0x03, 0x00, 0xC0, 0x01, 0x80, 0x60, 0x00, 0xC0,
  0x30, 0x00, 0x60, 0x18, 0x00, 0x60, 0x0C, 0x00, 0x30, 0x03, 0x00, 0x18,
  0x01, 0x00, 0x0C, 0x00, 0xC0, 0x04, 0x00, 0x40, 0x06, 0x00, 0x30, 0x03,
  0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00,
  0x60, 0x01, 0x80, 0x30, 0x00, 0xC0, 0x18, 0x00, 0x60, 0x0C, 0x00, 0x30,
  0x04, 0x00, 0x18, 0x02, 0x00, 0x0C, 0x03, 0x00, 0x06, 0x01, 0x80, 0x03,
  0x00, 0xC0, 0x01, 0x80, 0x60, 0x00, 0xC0, 0x60, 0x00, 0x60, 0x30, 0x00,
  0x30, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x06, 0x03, 0x00,
  0x03, 0x03, 0x00, 0x00, 0x81, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x20, 0x60,
  0x00, 0x30, 0x60, 0x00, 0x0C, 0x10, 0x00, 0x06, 0x18, 0x00, 0x03, 0x0C,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x63, 0x00, 0x00, 0x31,
  0x80, 0x00, 0x18, 0xC0, 0x00, 0x0C, 0x60, 0x00, 0x06, 0x60, 0x00, 0x03,
  0x18, 0x00, 0x01, 0x98, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x64, 0x00, 0x00,
  0x33, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x06, 0xC0, 0x00,
  0x03, 0x60, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x58, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x70, 0x00,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x38, 0x00, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x18, 0x00, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x01, 0x80, 0x70, 0x00,
  0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0x00, 0x23, 0x00,
  0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0x00, 0x01, 0x83, 0x00, 0x00, 0x00, 0x03,
  0x03, 0x00, 0x00, 0x00, 0x07, 0x03, 0x00, 0x00, 0x00, 0x06, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x07, 0x00,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0x98, 0x00,
  0x00, 0x01, 0xCC, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x00, 0xE0, 0xC0, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x60, 0x18,
  0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x30, 0x01,
  0x80, 0x00, 0x38, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x60, 0x06, 0x00,
  0x00, 0x30, 0x07, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x06, 0x03, 0x00,
  0x00, 0x03, 0x03, 0x00, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x00, 0x61, 0x80,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x06, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x00, 0xC0,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x00, 0x80, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x01, 0x00, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x02, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0x40, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x00,
  0x80, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x00, 0x1F, 0xF0, 0x01,
  0xFE, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x7F, 0x80,
  0x0F, 0xF8, 0x00, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x28, 0x00, 0x0D,
  0x00, 0x01, 0x30, 0x00, 0x66, 0x00, 0x08, 0xC0, 0x03, 0x18, 0x00, 0x43,
  0x00, 0x18, 0x20, 0x02, 0x06, 0x00, 0xC0, 0xC0, 0x10, 0x18, 0x06, 0x03,
  0x01, 0x80, 0x60, 0x30, 0x04, 0x0C, 0x00, 0xC1, 0x80, 0x18, 0x60, 0x03,
  0x0C, 0x00, 0x63, 0x00, 0x0C, 0x60, 0x01, 0x98, 0x00, 0x1B, 0x00, 0x03,
  0xC0, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x60,
  0x70, 0x30, 0x18, 0x1C, 0x0C, 0x06, 0x06, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x3C, 0x07, 0x80, 0x07, 0x00, 0x1C, 0x00, 0xC0, 0x00,
  0xC0, 0x18, 0x00, 0x06, 0x03, 0x00, 0x00, 0x60, 0x30, 0x00, 0x06, 0x06,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x06, 0x04, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x0F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x03, 0xE0, 0x00, 0x80, 0x70, 0x00, 0x08,
  0x0E, 0x00, 0x01, 0x81, 0x80, 0x00, 0x18, 0x38, 0x00, 0x01, 0x83, 0x00,
  0x00, 0x18, 0x60, 0x00, 0x01, 0x06, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x70, 0xC0,
  0x00, 0x0E, 0x0C, 0x00, 0x01, 0xE0, 0x60, 0x00, 0x36, 0x06, 0x00, 0x0E,
  0x60, 0x30, 0x01, 0xC6, 0x03, 0xC0, 0xF0, 0x60, 0x0F, 0xFE, 0x06, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x0F, 0x80, 0x03,
  0x07, 0xFF, 0x00, 0x30, 0xE0, 0x38, 0x03, 0x38, 0x01, 0xC0, 0x36, 0x00,
  0x0E, 0x02, 0xC0, 0x00, 0x60, 0x78, 0x00, 0x06, 0x07, 0x00, 0x00, 0x30,
  0x70, 0x00, 0x03, 0x06, 0x00, 0x00, 0x30, 0x60, 0x00, 0x03, 0x04, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x08, 0x00, 0x00, 0x31, 0x80,
  0x00, 0x03, 0x18, 0x00, 0x00, 0x21, 0x80, 0x00, 0x06, 0x18, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x06, 0x10, 0x00, 0x00, 0x63, 0x00, 0x00, 0x04, 0x30,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0xC2, 0x00, 0x00,
  0x18, 0x60, 0x00, 0x01, 0x86, 0x00, 0x00, 0x18, 0x60, 0x00, 0x03, 0x07,
  0x00, 0x00, 0x30, 0x70, 0x00, 0x06, 0x05, 0x80, 0x00, 0xC0, 0xCC, 0x00,
  0x1C, 0x0C, 0x60, 0x03, 0x80, 0xC3, 0x80, 0xF0, 0x0C, 0x1F, 0xFC, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x01,
  0xF0, 0x3C, 0x00, 0x70, 0x01, 0xC0, 0x1C, 0x00, 0x18, 0x07, 0x00, 0x01,
  0x81, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x61, 0x80,
  0x00, 0x0C, 0x60, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x31, 0x80, 0x00, 0x06,
  0x60, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0x31, 0x80, 0x00, 0x06, 0x10, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x30, 0x60, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x60, 0x1C, 0x00, 0x18, 0x01, 0xC0, 0x06, 0x00, 0x1E, 0x07, 0x80,
  0x01, 0xFF, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x03, 0xE0, 0x18, 0x00, 0x3F, 0xF8,
  0x30, 0x00, 0xE0, 0x38, 0x60, 0x07, 0x00, 0x18, 0xC0, 0x1C, 0x00, 0x19,
  0x80, 0x30, 0x00, 0x1A, 0x00, 0xC0, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x38,
  0x06, 0x00, 0x00, 0x70, 0x18, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0xC0,
  0x60, 0x00, 0x01, 0x01, 0x80, 0x00, 0x06, 0x03, 0x00, 0x00, 0x0C, 0x06,
  0x00, 0x00, 0x18, 0x08, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x00, 0x80, 0xC0, 0x00, 0x03, 0x01, 0x80, 0x00, 0x06, 0x03, 0x00,
  0x00, 0x0C, 0x0C, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x30, 0x30, 0x00,
  0x00, 0x40, 0x60, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x03, 0x01, 0x80, 0x00,
  0x06, 0x03, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00,
  0x60, 0x18, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x01, 0x80, 0x20, 0x00, 0x07,
  0x00, 0x60, 0x00, 0x1E, 0x00, 0xC0, 0x00, 0x68, 0x00, 0xC0, 0x01, 0xB0,
  0x01, 0xC0, 0x0E, 0x60, 0x01, 0xC0, 0x78, 0xC0, 0x01, 0xFF, 0xC1, 0x80,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0xF0, 0x3C, 0x00, 0x70, 0x01, 0xC0, 0x1C, 0x00, 0x18, 0x07, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x0C, 0x60, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x33, 0x00, 0x00,
  0x06, 0x60, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x19, 0x00, 0x00, 0x03, 0x60,
  0x00, 0x00, 0x6F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x10, 0x0C, 0x00, 0x0E, 0x01, 0xC0, 0x03, 0x80, 0x1E, 0x03,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xF8,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x30,
  0x03, 0xC0, 0x70, 0xC0, 0x1C, 0x00, 0x63, 0x00, 0xE0, 0x00, 0xCC, 0x03,
  0x00, 0x01, 0xA0, 0x18, 0x00, 0x07, 0x80, 0xC0, 0x00, 0x0E, 0x03, 0x00,
  0x00, 0x38, 0x18, 0x00, 0x00, 0x60, 0x60, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x04, 0x0C, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x81,
  0x80, 0x00, 0x06, 0x06, 0x00, 0x00, 0x18, 0x10, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x30, 0x30, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x03, 0x03, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00,
  0x30, 0x30, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x06, 0x03, 0x00, 0x00, 0x18,
  0x0C, 0x00, 0x00, 0x60, 0x30, 0x00, 0x03, 0x80, 0x60, 0x00, 0x1E, 0x01,
  0x80, 0x00, 0xD8, 0x07, 0x00, 0x06, 0xC0, 0x0E, 0x00, 0x73, 0x00, 0x1E,
  0x07, 0x8C, 0x00, 0x3F, 0xF8, 0x30, 0x00, 0x1F, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x20, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x30, 0x03, 0x80, 0x01, 0xC0, 0x07,
  0x00, 0x0E, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x03, 0xC0, 0x03, 0x03, 0xFF,
  0x00, 0x60, 0xE0, 0x70, 0x0C, 0x70, 0x03, 0x01, 0x9C, 0x00, 0x60, 0x33,
  0x00, 0x06, 0x04, 0xC0, 0x00, 0xC1, 0xB0, 0x00, 0x18, 0x34, 0x00, 0x03,
  0x07, 0x80, 0x00, 0x60, 0xE0, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x87, 0x00,
  0x00, 0x30, 0xE0, 0x00, 0x06, 0x18, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x18,
  0x60, 0x00, 0x03, 0x08, 0x00, 0x00, 0x43, 0x00, 0x00, 0x18, 0x60, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x61, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x01, 0x84,
  0x00, 0x00, 0x21, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x01, 0x86, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x06, 0x18, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x06, 0x18, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x18, 0x60, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x61, 0x00, 0x00, 0x18, 0x60, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x61, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x0F, 0x00, 0xE0, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x10, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x0C, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x70, 0x18,
  0x00, 0x07, 0x00, 0xC0, 0x00, 0x70, 0x06, 0x00, 0x07, 0x00, 0x30, 0x00,
  0x70, 0x01, 0x00, 0x07, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x07, 0x00,
  0x06, 0x00, 0x60, 0x00, 0x30, 0x06, 0x00, 0x01, 0x00, 0x60, 0x00, 0x18,
  0x06, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x01, 0x86, 0x00, 0x00, 0x08, 0x60, 0x00, 0x00, 0xCF, 0x80, 0x00,
  0x06, 0xEE, 0x00, 0x00, 0x3E, 0x30, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0C,
  0x06, 0x00, 0x00, 0x40, 0x18, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x30, 0x03,
  0x00, 0x01, 0x80, 0x18, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x60, 0x03, 0x00,
  0x02, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x01, 0x80, 0x0C,
  0x00, 0x0C, 0x00, 0x60, 0x00, 0x30, 0x03, 0x00, 0x01, 0x80, 0x10, 0x00,
  0x06, 0x01, 0x80, 0x00, 0x30, 0x0C, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x07,
  0x00, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x04, 0x01, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x03, 0x03,
  0xFF, 0x00, 0x1F, 0xF8, 0x03, 0x0F, 0x03, 0x80, 0x78, 0x1C, 0x03, 0x1C,
  0x01, 0xC0, 0xE0, 0x0E, 0x06, 0x30, 0x00, 0xC1, 0x80, 0x06, 0x06, 0x60,
  0x00, 0x63, 0x00, 0x03, 0x06, 0xC0, 0x00, 0x66, 0x00, 0x03, 0x06, 0xC0,
  0x00, 0x6C, 0x00, 0x03, 0x07, 0x80, 0x00, 0x68, 0x00, 0x03, 0x07, 0x00,
  0x00, 0x78, 0x00, 0x03, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x30, 0x00, 0x00, 0x80, 0x00, 0x04, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x30, 0x00,
  0x01, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x03, 0x00, 0x00, 0x08, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0xC0, 0x00,
  0x02, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x10, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x7C, 0x00, 0x60, 0x7F, 0xE0, 0x0C, 0x1C, 0x0E, 0x01, 0x8E, 0x00, 0x60,
  0x33, 0x80, 0x0C, 0x06, 0x60, 0x00, 0xC1, 0x98, 0x00, 0x18, 0x36, 0x00,
  0x03, 0x06, 0x80, 0x00, 0x60, 0xF0, 0x00, 0x0C, 0x1C, 0x00, 0x01, 0x83,
  0x00, 0x00, 0x30, 0xE0, 0x00, 0x06, 0x1C, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x18, 0x60, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x61, 0x80, 0x00, 0x08, 0x60,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x61, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x01,
  0x86, 0x00, 0x00, 0x30, 0x80, 0x00, 0x04, 0x30, 0x00, 0x01, 0x86, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x06, 0x18, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x18,
  0x40, 0x00, 0x06, 0x18, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x18, 0x60, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x61, 0x80, 0x00, 0x0C, 0x20, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x61, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x01, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xE0, 0x3C, 0x00, 0x70, 0x01, 0xC0,
  0x18, 0x00, 0x18, 0x06, 0x00, 0x03, 0x81, 0x80, 0x00, 0x30, 0x30, 0x00,
  0x07, 0x0C, 0x00, 0x00, 0x63, 0x80, 0x00, 0x0C, 0x60, 0x00, 0x01, 0x8C,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0xCC, 0x00, 0x00,
  0x1B, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x0D, 0x80,
  0x00, 0x01, 0xA0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x05, 0x80, 0x00, 0x01,
  0xB0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0x33, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x31,
  0x80, 0x00, 0x06, 0x30, 0x00, 0x01, 0x86, 0x00, 0x00, 0x30, 0x60, 0x00,
  0x0C, 0x0C, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x60, 0x18, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xC1, 0xFF, 0xC0, 0x01, 0x87, 0x01,
  0xC0, 0x03, 0x38, 0x01, 0xC0, 0x06, 0xC0, 0x01, 0xC0, 0x0B, 0x00, 0x01,
  0x80, 0x3C, 0x00, 0x01, 0x00, 0x70, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x06,
  0x01, 0x80, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x30,
  0x18, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x03, 0x01, 0x80, 0x00, 0x06, 0x02, 0x00, 0x00, 0x0C, 0x0C,
  0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x20, 0x30, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x03, 0x01, 0x00, 0x00, 0x06, 0x06, 0x00,
  0x00, 0x0C, 0x0C, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x60, 0x30, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x03, 0x00, 0x80, 0x00, 0x06, 0x03, 0x00, 0x00,
  0x0C, 0x06, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x01,
  0x80, 0x3C, 0x00, 0x06, 0x00, 0xCC, 0x00, 0x1C, 0x01, 0x9C, 0x00, 0x70,
  0x03, 0x0E, 0x03, 0x80, 0x06, 0x0F, 0xFE, 0x00, 0x0C, 0x03, 0xE0, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xFF, 0x83, 0x00, 0x70, 0x1C, 0x30, 0x1C, 0x00, 0x63, 0x03, 0x80, 0x03,
  0x30, 0x30, 0x00, 0x1A, 0x06, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x0E, 0x0C,
  0x00, 0x00, 0xE1, 0x80, 0x00, 0x06, 0x18, 0x00, 0x00, 0x61, 0x80, 0x00,
  0x04, 0x30, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0xC2,
  0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x86, 0x00, 0x00, 0x08, 0x60, 0x00,
  0x01, 0x86, 0x00, 0x00, 0x18, 0x60, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x18,
  0xC0, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x0E, 0x06, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x34, 0x03, 0x00, 0x06,
  0xC0, 0x38, 0x01, 0xCC, 0x01, 0xE0, 0x78, 0xC0, 0x0F, 0xFE, 0x0C, 0x00,
  0x1F, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xF0, 0x18, 0x3F, 0x80, 0xC3, 0x80,
  0x06, 0x30, 0x00, 0x33, 0x00, 0x01, 0xB0, 0x00, 0x1B, 0x00, 0x00, 0xD0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xE0, 0x3C, 0x00, 0x70, 0x01,
  0xC0, 0x18, 0x00, 0x18, 0x06, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x30, 0x30,
  0x00, 0x06, 0x06, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x18, 0x30, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x30, 0x00, 0x01, 0x86, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x06, 0x0C, 0x00, 0x01, 0x81, 0x80, 0x00, 0x70, 0x18, 0x00, 0x1C,
  0x01, 0x80, 0x07, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x01, 0xFF, 0xFF, 0xFF,
  0xF0, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0F, 0xE0, 0x07, 0x80, 0x0C, 0x00,
  0x00, 0x61, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x01, 0x86, 0x00, 0x00, 0x30,
  0x80, 0x00, 0x04, 0x30, 0x00, 0x01, 0x86, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x06, 0x18, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x18, 0x40, 0x00, 0x02, 0x18,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x18, 0x60, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x0C, 0x60, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x61, 0x80,
  0x00, 0x0C, 0x30, 0x00, 0x01, 0x86, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x04,
  0x30, 0x00, 0x01, 0x86, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x06, 0x18, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x18, 0x60, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x38, 0x30, 0x00, 0x07, 0x06, 0x00, 0x01, 0xE0, 0xC0, 0x00,
  0x6C, 0x1C, 0x00, 0x0D, 0x01, 0x80, 0x07, 0x60, 0x38, 0x01, 0xCC, 0x03,
  0xC0, 0xF1, 0x80, 0x3F, 0xF8, 0x30, 0x00, 0xF8, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xD8, 0x00, 0x00, 0x36, 0x00, 0x00, 0x19, 0x80, 0x00, 0x06, 0x60,
  0x00, 0x03, 0x18, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x18,
  0x30, 0x00, 0x04, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x60, 0x10, 0x00, 0x18, 0x06, 0x00, 0x0C, 0x01, 0x80, 0x03, 0x00, 0x60,
  0x01, 0x80, 0x18, 0x00, 0x60, 0x06, 0x00, 0x30, 0x00, 0x80, 0x0C, 0x00,
  0x30, 0x06, 0x00, 0x0C, 0x01, 0x80, 0x03, 0x00, 0xC0, 0x00, 0xC0, 0x30,
  0x00, 0x30, 0x18, 0x00, 0x04, 0x06, 0x00, 0x01, 0x83, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x18, 0x20, 0x00, 0x06, 0x18, 0x00, 0x01, 0x86, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x03, 0x60, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x06,
  0xC0, 0x00, 0x38, 0x00, 0x06, 0xC0, 0x00, 0x78, 0x00, 0x0C, 0xC0, 0x00,
  0x78, 0x00, 0x0C, 0xC0, 0x00, 0x58, 0x00, 0x1C, 0xC0, 0x00, 0xD8, 0x00,
  0x18, 0xC0, 0x00, 0xD8, 0x00, 0x18, 0xC0, 0x01, 0x88, 0x00, 0x30, 0xC0,
  0x01, 0x8C, 0x00, 0x30, 0x60, 0x03, 0x0C, 0x00, 0x70, 0x60, 0x03, 0x0C,
  0x00, 0x60, 0x60, 0x06, 0x0C, 0x00, 0x60, 0x60, 0x06, 0x0C, 0x00, 0xC0,
  0x60, 0x06, 0x0C, 0x00, 0xC0, 0x60, 0x0C, 0x0C, 0x01, 0x80, 0x60, 0x0C,
  0x0C, 0x01, 0x80, 0x60, 0x18, 0x0C, 0x03, 0x80, 0x60, 0x18, 0x0C, 0x03,
  0x00, 0x60, 0x30, 0x04, 0x03, 0x00, 0x60, 0x30, 0x06, 0x06, 0x00, 0x60,
  0x60, 0x06, 0x06, 0x00, 0x60, 0x60, 0x06, 0x0E, 0x00, 0x60, 0x60, 0x06,
  0x0C, 0x00, 0x30, 0xC0, 0x06, 0x0C, 0x00, 0x30, 0xC0, 0x06, 0x18, 0x00,
  0x31, 0x80, 0x06, 0x18, 0x00, 0x31, 0x80, 0x06, 0x30, 0x00, 0x33, 0x00,
  0x06, 0x30, 0x00, 0x33, 0x00, 0x02, 0x30, 0x00, 0x33, 0x00, 0x02, 0x60,
  0x00, 0x36, 0x00, 0x02, 0x60, 0x00, 0x36, 0x00, 0x03, 0x40, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x03, 0x80,
  0x30, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x1C, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x30, 0x03, 0x00, 0x00, 0x60,
  0x18, 0x00, 0x01, 0x80, 0x60, 0x00, 0x07, 0x03, 0x00, 0x00, 0x0C, 0x18,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x63, 0x00, 0x00, 0x01, 0x98, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0x33, 0x00, 0x00, 0x01,
  0xCC, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x30, 0x60, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x01, 0x80, 0x18,
  0x00, 0x0C, 0x00, 0x60, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x70, 0x00, 0x18, 0x03, 0x80, 0x00, 0x70, 0x0C,
  0x00, 0x00, 0xC0, 0x60, 0x00, 0x03, 0x83, 0x80, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x18,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x06, 0x00, 0x00, 0x60, 0x01, 0x80, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x06, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x80,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00,
  0x04, 0x00, 0x60, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x60, 0x0C, 0x00,
  0x00, 0x18, 0x03, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x01, 0x80, 0x60,
  0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x08, 0x0C, 0x00, 0x00, 0x03, 0x07,
  0x00, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x00, 0x0C,
  0x30, 0x00, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x00, 0x46, 0x00, 0x00, 0x00,
  0x19, 0x80, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x03, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x1C, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x38, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x01, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x03, 0x80, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x70, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x20, 0xE0, 0x60, 0x00, 0x18, 0x70,
  0x0C, 0x00, 0x06, 0x18, 0x01, 0x80, 0x01, 0x8C, 0x00, 0x30, 0x00, 0xC3,
  0x00, 0x0E, 0x00, 0x31, 0x80, 0x01, 0x80, 0x18, 0x60, 0x00, 0x30, 0x0E,
  0x18, 0x00, 0x07, 0x07, 0x04, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0x80,
};

const GFXglyph RobotoCondensed_ThinItalic72pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 11, 52, 13, 1, -51 },
  { 73, 11, 14, 18, 8, -54 },
  { 93, 36, 51, 34, 1, -51 },
  { 323, 29, 67, 34, 3, -59 },
  { 566, 33, 53, 45, 7, -52 },
  { 785, 32, 53, 37, 2, -52 },
  { 997, 5, 15, 12, 7, -54 },
  { 1007, 19, 73, 19, 4, -57 },
  { 1181, 19, 74, 19, -4, -57 },
  { 1357, 28, 28, 29, 4, -51 },
  { 1455, 29, 38, 35, 3, -43 },
  { 1593, 7, 14, 13, -2, -6 },
  { 1606, 14, 2, 19, 3, -25 },
  { 1610, 4, 4, 15, 2, -3 },
  { 1612, 30, 55, 24, -3, -51 },
  { 1819, 29, 53, 34, 3, -52 },
  { 2012, 15, 51, 34, 10, -51 },
  { 2108, 29, 52, 34, 2, -52 },
  { 2297, 30, 53, 34, 2, -52 },
  { 2496, 29, 51, 34, 2, -51 },
  { 2681, 31, 52, 34, 4, -51 },
  { 2883, 27, 52, 34, 3, -51 },
  { 3059, 29, 51, 34, 6, -51 },
  { 3244, 32, 53, 34, 1, -52 },
  { 3456, 27, 52, 34, 5, -52 },
  { 3632, 10, 38, 12, 1, -37 },
  { 3680, 13, 45, 12, -2, -37 },
  { 3754, 27, 29, 32, 3, -38 },
  { 3852, 27, 17, 34, 4, -32 },
  { 3910, 27, 29, 32, 2, -38 },
  { 4008, 22, 53, 27, 6, -52 },
  { 4154, 51, 66, 56, 2, -50 },
  { 4575, 34, 51, 37, -2, -51 },
  { 4792, 32, 51, 37, 3, -51 },
  { 4996, 34, 53, 40, 4, -52 },
  { 5222, 35, 51, 40, 3, -51 },
  { 5446, 34, 51, 35, 3, -51 },
  { 5663, 35, 51, 35, 3, -51 },
  { 5887, 34, 53, 42, 5, -52 },
  { 6113, 39, 51, 43, 3, -51 },
  { 6362, 11, 51, 17, 4, -51 },
  { 6433, 32, 52, 34, 1, -51 },
  { 6641, 37, 51, 39, 3, -51 },
  { 6877, 23, 51, 32, 3, -51 },
  { 7024, 48, 51, 52, 3, -51 },
  { 7330, 39, 51, 43, 3, -51 },
  { 7579, 35, 53, 41, 4, -52 },
  { 7811, 34, 51, 37, 3, -51 },
  { 8028, 35, 61, 41, 4, -52 },
  { 8295, 34, 51, 40, 3, -51 },
  { 8512, 34, 53, 36, 2, -52 },
  { 8738, 33, 51, 37, 7, -51 },
  { 8949, 36, 52, 41, 4, -51 },
  { 9183, 34, 51, 37, 6, -51 },
  { 9400, 50, 51, 55, 7, -51 },
  { 9719, 40, 51, 37, -1, -51 },
  { 9974, 33, 51, 37, 7, -51 },
  { 10185, 38, 51, 37, 0, -51 },
  { 10428, 19, 70, 14, 1, -59 },
  { 10595, 10, 55, 24, 7, -51 },
  { 10664, 20, 70, 14, -5, -59 },
  { 10839, 19, 25, 26, 4, -51 },
  { 10899, 25, 2, 26, -3, 0 },
  { 10906, 8, 9, 19, 10, -54 },
  { 10915, 28, 40, 33, 1, -39 },
  { 11055, 28, 55, 34, 2, -54 },
  { 11248, 27, 40, 31, 2, -39 },
  { 11383, 31, 55, 34, 3, -54 },
  { 11597, 27, 40, 32, 2, -39 },
  { 11732, 22, 55, 20, 4, -55 },
  { 11884, 30, 54, 34, 1, -39 },
  { 12087, 27, 54, 34, 2, -54 },
  { 12270, 12, 52, 14, 2, -52 },
  { 12348, 24, 67, 14, -10, -52 },
  { 12549, 29, 54, 29, 2, -54 },
  { 12745, 11, 54, 14, 2, -54 },
  { 12820, 48, 39, 54, 2, -39 },
  { 13054, 27, 39, 34, 2, -39 },
  { 13186, 27, 40, 34, 3, -39 },
  { 13321, 31, 54, 34, -1, -39 },
  { 13531, 28, 54, 34, 3, -39 },
  { 13720, 21, 39, 21, 2, -39 },
  { 13823, 27, 40, 31, 1, -39 },
  { 13958, 15, 49, 20, 4, -48 },
  { 14050, 27, 39, 34, 4, -38 },
  { 14182, 26, 38, 30, 4, -38 },
  { 14306, 40, 38, 46, 6, -38 },
  { 14496, 30, 38, 30, -1, -38 },
  { 14639, 34, 53, 30, -3, -38 },
  { 14865, 30, 38, 30, -1, -38 },
  { 15008, 23, 72, 20, 2, -56 },
  { 15215, 12, 61, 14, 1, -51 },
  { 15307, 23, 72, 20, -5, -56 },
  { 15514, 34, 12, 42, 4, -28 },
};

const GFXfont RobotoCondensed_ThinItalic72pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ThinItalic72pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ThinItalic72pt7bGlyphs,
  0x20, 0x7E, 84
};

#endif // _ROBOTOCONDENSED_THINITALIC72PT7B_H_
