#ifndef _ROBOTOCONDENSED_THINITALIC52PT7B_H_
#define _ROBOTOCONDENSED_THINITALIC52PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ThinItalic.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ThinItalic52pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0x03, 0x03, 0x02, 0x02, 0x02, 0x02, 0x06, 0x06, 0x04, 0x04,
  0x04, 0x0C, 0x0C, 0x08, 0x08, 0x08, 0x08, 0x18, 0x18, 0x10, 0x10, 0x10,
  0x10, 0x30, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0xC0, 0x00, 0x63, 0x63, 0x63, 0x42, 0x42, 0x42, 0xC6, 0xC6, 0x84,
  0x84, 0x00, 0x02, 0x01, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x40, 0x20, 0x00,
  0x10, 0x08, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x01, 0x00, 0x00, 0x80, 0x40,
  0x00, 0x20, 0x30, 0x00, 0x18, 0x08, 0x00, 0x04, 0x02, 0x00, 0x01, 0x01,
  0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x20, 0x10, 0x00, 0x08, 0x0C, 0x00, 0x06,
  0x02, 0x00, 0x01, 0x00, 0x80, 0x00, 0x40, 0x60, 0x00, 0x30, 0x10, 0x00,
  0x08, 0x04, 0x00, 0x02, 0x03, 0x00, 0x01, 0x80, 0x80, 0x00, 0x40, 0x20,
  0x00, 0x10, 0x18, 0x00, 0x0C, 0x06, 0x00, 0x02, 0x01, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x60, 0x30, 0x00, 0x10, 0x08, 0x00, 0x04, 0x02, 0x00, 0x03,
  0x01, 0x80, 0x00, 0x80, 0x40, 0x00, 0x20, 0x10, 0x00, 0x08, 0x0C, 0x00,
  0x06, 0x02, 0x00, 0x01, 0x00, 0x80, 0x00, 0x40, 0x60, 0x00, 0x30, 0x10,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0xFF, 0x00, 0x18, 0x0C, 0x01,
  0x80, 0x30, 0x18, 0x00, 0x81, 0x80, 0x06, 0x08, 0x00, 0x10, 0x40, 0x00,
  0x86, 0x00, 0x04, 0x20, 0x00, 0x21, 0x00, 0x01, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x64, 0x00, 0x03, 0x20, 0x00, 0x11, 0x00, 0x00,
  0x8C, 0x00, 0x0C, 0x60, 0x00, 0x61, 0x00, 0x06, 0x0C, 0x00, 0x60, 0x30,
  0x07, 0x00, 0xC0, 0x60, 0x03, 0xFE, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x30, 0x20, 0x00, 0x20,
  0x30, 0x00, 0x60, 0x10, 0x04, 0x40, 0x10, 0x0C, 0xC0, 0x10, 0x18, 0xC0,
  0x30, 0x10, 0x80, 0x30, 0x30, 0x80, 0x20, 0x60, 0x80, 0x20, 0x40, 0x80,
  0x60, 0xC0, 0x80, 0x41, 0x80, 0xC0, 0xC1, 0x00, 0x61, 0x82, 0x00, 0x3F,
  0x06, 0x00, 0x08, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x20, 0x10, 0x00, 0x60, 0xFC, 0x00, 0xC1, 0x86, 0x00,
  0x83, 0x03, 0x01, 0x82, 0x01, 0x03, 0x06, 0x01, 0x02, 0x04, 0x01, 0x04,
  0x04, 0x01, 0x0C, 0x0C, 0x01, 0x08, 0x0C, 0x03, 0x10, 0x08, 0x03, 0x30,
  0x08, 0x02, 0x20, 0x08, 0x06, 0x00, 0x0C, 0x04, 0x00, 0x04, 0x0C, 0x00,
  0x06, 0x18, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0xC1, 0x80, 0x03, 0x01, 0x00, 0x0C, 0x02, 0x00, 0x10,
  0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00,
  0xC0, 0x04, 0x01, 0x00, 0x08, 0x06, 0x00, 0x10, 0x18, 0x00, 0x30, 0x60,
  0x00, 0x21, 0x80, 0x00, 0x64, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x0D, 0x80, 0x00, 0x31, 0x00, 0x00, 0xC3, 0x00, 0x03,
  0x02, 0x00, 0x8C, 0x06, 0x01, 0x10, 0x06, 0x02, 0x60, 0x04, 0x0C, 0x80,
  0x0C, 0x13, 0x00, 0x08, 0x64, 0x00, 0x18, 0x88, 0x00, 0x13, 0x10, 0x00,
  0x34, 0x20, 0x00, 0x38, 0x40, 0x00, 0x60, 0xC0, 0x00, 0xE0, 0x80, 0x02,
  0x41, 0x80, 0x18, 0xC1, 0xC0, 0xE0, 0x81, 0xFF, 0x01, 0x80, 0x20, 0x00,
  0x00, 0x32, 0x22, 0x66, 0x64, 0x4C, 0x00, 0x04, 0x00, 0x60, 0x03, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00,
  0x60, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00,
  0xC0, 0x03, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x02,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30,
  0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00,
  0x30, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x18, 0x00,
  0x40, 0x03, 0x00, 0x18, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x00,
  0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x1E, 0x06, 0x07, 0x38, 0x63, 0xC0, 0xF7,
  0xE0, 0x01, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xA0, 0x00, 0x33, 0x00, 0x06,
  0x10, 0x00, 0xC1, 0x80, 0x08, 0x0C, 0x01, 0x80, 0x40, 0x30, 0x06, 0x02,
  0x00, 0x20, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20,
  0x00, 0x18, 0xC6, 0x23, 0x18, 0x8C, 0xC4, 0x00, 0xFF, 0xC0, 0xFC, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00,
  0x04, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06,
  0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00,
  0x08, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x38, 0x18, 0x03, 0x00, 0x40, 0x10, 0x03, 0x01, 0x00,
  0x08, 0x18, 0x00, 0x60, 0x80, 0x03, 0x0C, 0x00, 0x18, 0x40, 0x00, 0x42,
  0x00, 0x02, 0x30, 0x00, 0x11, 0x00, 0x00, 0x88, 0x00, 0x0C, 0xC0, 0x00,
  0x66, 0x00, 0x03, 0x20, 0x00, 0x11, 0x00, 0x00, 0x88, 0x00, 0x04, 0x40,
  0x00, 0x26, 0x00, 0x03, 0x30, 0x00, 0x19, 0x00, 0x00, 0x88, 0x00, 0x04,
  0x40, 0x00, 0x22, 0x00, 0x03, 0x10, 0x00, 0x18, 0x80, 0x00, 0x84, 0x00,
  0x0C, 0x20, 0x00, 0x61, 0x00, 0x02, 0x08, 0x00, 0x30, 0x40, 0x01, 0x03,
  0x00, 0x18, 0x08, 0x01, 0x80, 0x60, 0x18, 0x01, 0x81, 0x80, 0x07, 0xF8,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x3C, 0x1D, 0x9C, 0x3E, 0x05, 0x00,
  0x80, 0x10, 0x06, 0x00, 0xC0, 0x10, 0x02, 0x00, 0x40, 0x08, 0x03, 0x00,
  0x60, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x80, 0x30, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x60,
  0x0C, 0x01, 0x00, 0x20, 0x04, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x0E, 0x06, 0x00, 0x60, 0x0C, 0x03, 0x00, 0x18, 0x08, 0x00, 0x20,
  0x60, 0x00, 0x81, 0x00, 0x02, 0x0C, 0x00, 0x08, 0x20, 0x00, 0x20, 0x80,
  0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x06, 0x07,
  0x00, 0x30, 0x06, 0x01, 0x80, 0x18, 0x0C, 0x00, 0x20, 0x20, 0x00, 0xC1,
  0x80, 0x01, 0x04, 0x00, 0x04, 0x30, 0x00, 0x10, 0xC0, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x31,
  0x00, 0x00, 0x84, 0x00, 0x02, 0x10, 0x00, 0x18, 0x60, 0x00, 0x41, 0x80,
  0x03, 0x03, 0x00, 0x18, 0x0C, 0x00, 0xC0, 0x1C, 0x06, 0x00, 0x1F, 0xF0,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x00, 0x00, 0x14, 0x00, 0x00, 0x90, 0x00, 0x06, 0x40, 0x00, 0x13, 0x00,
  0x00, 0x8C, 0x00, 0x06, 0x20, 0x00, 0x30, 0x80, 0x00, 0x82, 0x00, 0x06,
  0x08, 0x00, 0x30, 0x60, 0x00, 0x81, 0x80, 0x04, 0x04, 0x00, 0x30, 0x10,
  0x01, 0x80, 0x40, 0x04, 0x01, 0x00, 0x30, 0x0C, 0x01, 0x80, 0x30, 0x04,
  0x00, 0x80, 0x20, 0x02, 0x01, 0x80, 0x08, 0x0C, 0x00, 0x60, 0x20, 0x01,
  0x81, 0x80, 0x06, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x40, 0x00, 0x01, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x01, 0xFF,
  0xFC, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x8F, 0xC0, 0x06, 0xE1, 0xC0, 0x1C, 0x01, 0x80, 0x60, 0x02, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x04,
  0x30, 0x00, 0x10, 0xC0, 0x00, 0xC3, 0x00, 0x02, 0x04, 0x00, 0x08, 0x10,
  0x00, 0x60, 0x40, 0x01, 0x01, 0x80, 0x08, 0x03, 0x00, 0x60, 0x06, 0x07,
  0x00, 0x0F, 0xF0, 0x00, 0x04, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0xF8,
  0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x07, 0xE0, 0x11, 0xC7, 0x83, 0x30, 0x0C, 0x34,
  0x00, 0xC2, 0x80, 0x06, 0x30, 0x00, 0x63, 0x00, 0x02, 0x60, 0x00, 0x26,
  0x00, 0x02, 0x40, 0x00, 0x24, 0x00, 0x02, 0x40, 0x00, 0x24, 0x00, 0x02,
  0x40, 0x00, 0x24, 0x00, 0x06, 0x40, 0x00, 0x44, 0x00, 0x04, 0x40, 0x00,
  0xC6, 0x00, 0x08, 0x60, 0x01, 0x83, 0x00, 0x30, 0x30, 0x06, 0x01, 0xC0,
  0xC0, 0x07, 0xF8, 0x00, 0x08, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40,
  0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30,
  0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08,
  0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x03,
  0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xC0, 0xC0,
  0x06, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x60, 0x01, 0x80, 0x80, 0x01, 0x03,
  0x00, 0x02, 0x04, 0x00, 0x04, 0x08, 0x00, 0x08, 0x10, 0x00, 0x10, 0x60,
  0x00, 0x20, 0xC0, 0x00, 0xC1, 0x80, 0x01, 0x01, 0x00, 0x06, 0x03, 0x00,
  0x18, 0x02, 0x00, 0x20, 0x06, 0x01, 0x80, 0x07, 0x9E, 0x00, 0x07, 0xF0,
  0x00, 0x38, 0x38, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x18, 0x08, 0x00, 0x10,
  0x30, 0x00, 0x30, 0x40, 0x00, 0x21, 0x80, 0x00, 0x42, 0x00, 0x00, 0x84,
  0x00, 0x01, 0x18, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x10, 0x40,
  0x00, 0x60, 0x80, 0x01, 0x81, 0x80, 0x06, 0x01, 0x80, 0x18, 0x01, 0x80,
  0xE0, 0x01, 0xFF, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x0C, 0x0C, 0x03, 0x00, 0xC0, 0x80, 0x0C, 0x30, 0x01, 0x8C, 0x00,
  0x11, 0x00, 0x03, 0x60, 0x00, 0x68, 0x00, 0x0D, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x02, 0x80, 0x00,
  0x50, 0x00, 0x1A, 0x00, 0x03, 0x60, 0x00, 0xEC, 0x00, 0x1C, 0x80, 0x05,
  0x18, 0x01, 0x21, 0x80, 0xCC, 0x1C, 0x71, 0x81, 0xF8, 0x20, 0x00, 0x04,
  0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x40,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x01, 0xF0, 0x01,
  0xF0, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x01,
  0x80, 0x60, 0x30, 0x0C, 0x06, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x10, 0x3F, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x08, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x30, 0x60, 0x80, 0x63, 0x00, 0x4C,
  0x00, 0xD0, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x40, 0x01, 0x00, 0x06, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0x8F,
  0x80, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x00, 0x40,
  0x0C, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x00, 0x20, 0x10, 0x00, 0x00,
  0x02, 0x03, 0x00, 0x00, 0x00, 0x20, 0x60, 0x01, 0xE0, 0x03, 0x04, 0x00,
  0x73, 0x80, 0x30, 0xC0, 0x08, 0x0C, 0x03, 0x08, 0x01, 0x00, 0x40, 0x11,
  0x80, 0x20, 0x0C, 0x01, 0x10, 0x06, 0x00, 0xC0, 0x13, 0x00, 0x40, 0x08,
  0x03, 0x30, 0x0C, 0x00, 0x80, 0x32, 0x00, 0x80, 0x18, 0x03, 0x60, 0x18,
  0x01, 0x80, 0x26, 0x01, 0x00, 0x10, 0x02, 0x40, 0x30, 0x01, 0x00, 0x24,
  0x03, 0x00, 0x30, 0x02, 0xC0, 0x20, 0x03, 0x00, 0x6C, 0x02, 0x00, 0x20,
  0x04, 0x80, 0x60, 0x02, 0x00, 0x48, 0x06, 0x00, 0x60, 0x0C, 0x80, 0x40,
  0x06, 0x00, 0x88, 0x04, 0x00, 0xC0, 0x08, 0x80, 0x40, 0x0C, 0x01, 0x88,
  0x04, 0x01, 0x40, 0x10, 0x80, 0x40, 0x14, 0x02, 0x08, 0x06, 0x02, 0x60,
  0x60, 0x80, 0x20, 0xC2, 0x0C, 0x0C, 0x03, 0xF8, 0x3F, 0x00, 0xC0, 0x04,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x03, 0xF1, 0xE0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xA0, 0x00, 0x00, 0xA0, 0x00, 0x01, 0x20, 0x00, 0x01, 0x30, 0x00, 0x02,
  0x30, 0x00, 0x02, 0x10, 0x00, 0x06, 0x10, 0x00, 0x04, 0x10, 0x00, 0x0C,
  0x10, 0x00, 0x08, 0x10, 0x00, 0x18, 0x18, 0x00, 0x10, 0x18, 0x00, 0x30,
  0x08, 0x00, 0x20, 0x08, 0x00, 0x60, 0x08, 0x00, 0x40, 0x08, 0x00, 0xC0,
  0x08, 0x00, 0x80, 0x08, 0x01, 0x80, 0x0C, 0x01, 0x00, 0x0C, 0x03, 0x00,
  0x04, 0x02, 0x00, 0x04, 0x02, 0x00, 0x04, 0x07, 0xFF, 0xFC, 0x04, 0x00,
  0x04, 0x08, 0x00, 0x06, 0x08, 0x00, 0x06, 0x18, 0x00, 0x06, 0x10, 0x00,
  0x02, 0x30, 0x00, 0x02, 0x20, 0x00, 0x02, 0x60, 0x00, 0x02, 0x40, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x03, 0xFF, 0xC0, 0x04, 0x01,
  0xE0, 0x08, 0x00, 0x60, 0x10, 0x00, 0x60, 0x20, 0x00, 0x40, 0xC0, 0x00,
  0xC1, 0x80, 0x00, 0x82, 0x00, 0x01, 0x04, 0x00, 0x02, 0x08, 0x00, 0x04,
  0x10, 0x00, 0x18, 0x60, 0x00, 0x20, 0xC0, 0x00, 0x41, 0x00, 0x01, 0x82,
  0x00, 0x06, 0x04, 0x00, 0x18, 0x08, 0x00, 0x60, 0x30, 0x07, 0x80, 0x7F,
  0xFE, 0x00, 0x80, 0x07, 0x01, 0x00, 0x03, 0x02, 0x00, 0x02, 0x0C, 0x00,
  0x06, 0x18, 0x00, 0x04, 0x20, 0x00, 0x08, 0x40, 0x00, 0x10, 0x80, 0x00,
  0x21, 0x00, 0x00, 0x46, 0x00, 0x01, 0x8C, 0x00, 0x03, 0x10, 0x00, 0x04,
  0x20, 0x00, 0x18, 0x40, 0x00, 0x60, 0x80, 0x01, 0x83, 0x00, 0x06, 0x06,
  0x00, 0x78, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x60, 0x18, 0x01, 0xC0, 0x0C, 0x03, 0x00, 0x06, 0x02, 0x00, 0x02,
  0x06, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x08, 0x00, 0x01, 0x18, 0x00, 0x01,
  0x10, 0x00, 0x01, 0x10, 0x00, 0x01, 0x30, 0x00, 0x01, 0x30, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x08, 0xC0, 0x00, 0x08, 0xC0, 0x00, 0x18,
  0xC0, 0x00, 0x10, 0x40, 0x00, 0x30, 0x40, 0x00, 0x20, 0x60, 0x00, 0x60,
  0x20, 0x00, 0xC0, 0x30, 0x01, 0x80, 0x1C, 0x07, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0x00, 0x38, 0x00, 0x80, 0x07,
  0x00, 0x40, 0x00, 0xC0, 0x20, 0x00, 0x20, 0x30, 0x00, 0x18, 0x18, 0x00,
  0x04, 0x08, 0x00, 0x03, 0x04, 0x00, 0x01, 0x82, 0x00, 0x00, 0x41, 0x00,
  0x00, 0x21, 0x80, 0x00, 0x10, 0xC0, 0x00, 0x08, 0x40, 0x00, 0x04, 0x20,
  0x00, 0x06, 0x10, 0x00, 0x03, 0x08, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x84,
  0x00, 0x00, 0x42, 0x00, 0x00, 0x21, 0x00, 0x00, 0x30, 0x80, 0x00, 0x18,
  0xC0, 0x00, 0x08, 0x60, 0x00, 0x04, 0x20, 0x00, 0x02, 0x10, 0x00, 0x03,
  0x08, 0x00, 0x01, 0x04, 0x00, 0x01, 0x86, 0x00, 0x00, 0x83, 0x00, 0x00,
  0xC1, 0x00, 0x00, 0x40, 0x80, 0x00, 0x60, 0x40, 0x00, 0x60, 0x20, 0x00,
  0xE0, 0x30, 0x00, 0xC0, 0x18, 0x07, 0xC0, 0x0F, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0x81, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x02, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x81, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x1C, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x18, 0x00, 0x30, 0x18, 0x00, 0x08, 0x08, 0x00,
  0x06, 0x08, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x84, 0x00, 0x00, 0x42, 0x00,
  0x00, 0x23, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x1F, 0xF8, 0x80, 0x00, 0x04, 0x40, 0x00, 0x02, 0x20, 0x00, 0x03,
  0x10, 0x00, 0x01, 0x88, 0x00, 0x00, 0x84, 0x00, 0x00, 0x42, 0x00, 0x00,
  0x21, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x10, 0x00,
  0x04, 0x0C, 0x00, 0x0E, 0x03, 0x00, 0x0E, 0x00, 0xE0, 0x3C, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x10, 0x20, 0x00, 0x01,
  0x02, 0x00, 0x00, 0x30, 0x20, 0x00, 0x03, 0x02, 0x00, 0x00, 0x20, 0x60,
  0x00, 0x02, 0x06, 0x00, 0x00, 0x20, 0x40, 0x00, 0x02, 0x04, 0x00, 0x00,
  0x60, 0x40, 0x00, 0x06, 0x04, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x04, 0x0C,
  0x00, 0x00, 0x40, 0x80, 0x00, 0x0C, 0x08, 0x00, 0x00, 0xC0, 0x80, 0x00,
  0x08, 0x08, 0x00, 0x00, 0x81, 0x80, 0x00, 0x08, 0x1F, 0xFF, 0xFF, 0x81,
  0x00, 0x00, 0x18, 0x10, 0x00, 0x01, 0x81, 0x00, 0x00, 0x10, 0x30, 0x00,
  0x01, 0x03, 0x00, 0x00, 0x10, 0x20, 0x00, 0x01, 0x02, 0x00, 0x00, 0x30,
  0x20, 0x00, 0x03, 0x02, 0x00, 0x00, 0x20, 0x60, 0x00, 0x02, 0x06, 0x00,
  0x00, 0x20, 0x40, 0x00, 0x02, 0x04, 0x00, 0x00, 0x60, 0x40, 0x00, 0x06,
  0x04, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x40, 0x80,
  0x00, 0x04, 0x00, 0x02, 0x04, 0x08, 0x10, 0x60, 0xC1, 0x02, 0x04, 0x18,
  0x30, 0x60, 0x81, 0x02, 0x0C, 0x18, 0x20, 0x40, 0x81, 0x06, 0x0C, 0x10,
  0x20, 0x40, 0x83, 0x06, 0x08, 0x10, 0x20, 0x41, 0x83, 0x04, 0x08, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x18,
  0x00, 0x10, 0x30, 0x00, 0x60, 0x60, 0x00, 0x80, 0x40, 0x03, 0x00, 0x80,
  0x0C, 0x01, 0x80, 0x30, 0x01, 0x80, 0xC0, 0x01, 0xFF, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x60, 0x40, 0x00, 0x18, 0x08, 0x00, 0x06,
  0x01, 0x00, 0x01, 0x80, 0x20, 0x00, 0x60, 0x0C, 0x00, 0x18, 0x01, 0x80,
  0x06, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x60, 0x00, 0x80, 0x18, 0x00,
  0x10, 0x06, 0x00, 0x06, 0x01, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x10, 0x18,
  0x00, 0x02, 0x06, 0x00, 0x00, 0x41, 0x80, 0x00, 0x08, 0x60, 0x00, 0x03,
  0x1C, 0x00, 0x00, 0x46, 0xC0, 0x00, 0x09, 0x08, 0x00, 0x01, 0x41, 0x80,
  0x00, 0x30, 0x10, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0x20, 0x00, 0x20,
  0x06, 0x00, 0x04, 0x00, 0x40, 0x00, 0x80, 0x0C, 0x00, 0x10, 0x00, 0x80,
  0x06, 0x00, 0x18, 0x00, 0xC0, 0x01, 0x80, 0x10, 0x00, 0x30, 0x02, 0x00,
  0x03, 0x00, 0x40, 0x00, 0x20, 0x08, 0x00, 0x06, 0x03, 0x00, 0x00, 0x40,
  0x60, 0x00, 0x0C, 0x08, 0x00, 0x00, 0x80, 0x03, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0F,
  0xFF, 0xF8, 0x03, 0x00, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x1C, 0x0E,
  0x00, 0x00, 0x03, 0x01, 0x40, 0x00, 0x00, 0xA0, 0x28, 0x00, 0x00, 0x14,
  0x0D, 0x00, 0x00, 0x04, 0x81, 0xA0, 0x00, 0x01, 0xB0, 0x26, 0x00, 0x00,
  0x26, 0x04, 0xC0, 0x00, 0x0C, 0x80, 0x88, 0x00, 0x01, 0x10, 0x11, 0x00,
  0x00, 0x62, 0x06, 0x20, 0x00, 0x08, 0x40, 0xC4, 0x00, 0x03, 0x18, 0x10,
  0xC0, 0x00, 0x43, 0x02, 0x08, 0x00, 0x18, 0x40, 0x41, 0x00, 0x02, 0x08,
  0x08, 0x20, 0x00, 0xC1, 0x03, 0x04, 0x00, 0x10, 0x60, 0x60, 0xC0, 0x06,
  0x0C, 0x08, 0x18, 0x00, 0x81, 0x81, 0x01, 0x00, 0x20, 0x20, 0x20, 0x20,
  0x04, 0x04, 0x0C, 0x04, 0x01, 0x00, 0x81, 0x80, 0x80, 0x60, 0x30, 0x20,
  0x18, 0x08, 0x06, 0x04, 0x01, 0x03, 0x00, 0x80, 0x80, 0x20, 0x40, 0x10,
  0x10, 0x04, 0x18, 0x02, 0x06, 0x00, 0x82, 0x00, 0x40, 0xC0, 0x18, 0xC0,
  0x18, 0x10, 0x01, 0x10, 0x03, 0x02, 0x00, 0x26, 0x00, 0x40, 0x40, 0x04,
  0x80, 0x08, 0x08, 0x00, 0xB0, 0x01, 0x03, 0x00, 0x14, 0x00, 0x20, 0x60,
  0x03, 0x80, 0x0C, 0x08, 0x00, 0x20, 0x01, 0x80, 0x03, 0x00, 0x00, 0x10,
  0x30, 0x00, 0x01, 0x03, 0x80, 0x00, 0x10, 0x28, 0x00, 0x03, 0x02, 0x80,
  0x00, 0x30, 0x64, 0x00, 0x02, 0x06, 0x40, 0x00, 0x20, 0x66, 0x00, 0x02,
  0x04, 0x20, 0x00, 0x20, 0x42, 0x00, 0x06, 0x04, 0x30, 0x00, 0x60, 0xC1,
  0x00, 0x04, 0x0C, 0x18, 0x00, 0x40, 0xC0, 0x80, 0x04, 0x08, 0x08, 0x00,
  0xC0, 0x80, 0xC0, 0x0C, 0x18, 0x04, 0x00, 0xC1, 0x80, 0x40, 0x08, 0x18,
  0x02, 0x00, 0x81, 0x00, 0x20, 0x08, 0x10, 0x03, 0x01, 0x81, 0x00, 0x10,
  0x18, 0x30, 0x01, 0x01, 0x83, 0x00, 0x08, 0x10, 0x30, 0x00, 0x81, 0x02,
  0x00, 0x0C, 0x10, 0x20, 0x00, 0x43, 0x02, 0x00, 0x04, 0x30, 0x60, 0x00,
  0x63, 0x06, 0x00, 0x02, 0x20, 0x60, 0x00, 0x32, 0x04, 0x00, 0x01, 0x20,
  0x40, 0x00, 0x16, 0x04, 0x00, 0x01, 0xE0, 0xC0, 0x00, 0x0E, 0x0C, 0x00,
  0x00, 0xC0, 0x80, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x18, 0x06, 0x00, 0x38, 0x00, 0x80, 0x30, 0x00, 0x60, 0x10, 0x00,
  0x18, 0x18, 0x00, 0x04, 0x18, 0x00, 0x02, 0x08, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0xC4, 0x00, 0x00, 0x62, 0x00, 0x00, 0x33, 0x00, 0x00, 0x19, 0x00,
  0x00, 0x0C, 0x80, 0x00, 0x06, 0x40, 0x00, 0x02, 0x60, 0x00, 0x01, 0x30,
  0x00, 0x00, 0x90, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x64, 0x00, 0x00, 0x32,
  0x00, 0x00, 0x13, 0x00, 0x00, 0x09, 0x80, 0x00, 0x04, 0x80, 0x00, 0x06,
  0x40, 0x00, 0x03, 0x20, 0x00, 0x01, 0x10, 0x00, 0x00, 0x88, 0x00, 0x00,
  0xC4, 0x00, 0x00, 0x42, 0x00, 0x00, 0x61, 0x80, 0x00, 0x20, 0x40, 0x00,
  0x30, 0x30, 0x00, 0x30, 0x08, 0x00, 0x30, 0x06, 0x00, 0x30, 0x01, 0xC0,
  0x70, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x01,
  0x00, 0x3C, 0x00, 0x80, 0x03, 0x00, 0x40, 0x00, 0xC0, 0x20, 0x00, 0x20,
  0x30, 0x00, 0x18, 0x18, 0x00, 0x04, 0x08, 0x00, 0x02, 0x04, 0x00, 0x01,
  0x02, 0x00, 0x00, 0x81, 0x00, 0x00, 0x41, 0x80, 0x00, 0x60, 0xC0, 0x00,
  0x30, 0x40, 0x00, 0x10, 0x20, 0x00, 0x18, 0x10, 0x00, 0x08, 0x08, 0x00,
  0x0C, 0x0C, 0x00, 0x0C, 0x06, 0x00, 0x1C, 0x02, 0x00, 0x78, 0x01, 0xFF,
  0xF0, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x18,
  0x06, 0x00, 0x38, 0x00, 0x80, 0x30, 0x00, 0x60, 0x10, 0x00, 0x18, 0x10,
  0x00, 0x04, 0x18, 0x00, 0x02, 0x08, 0x00, 0x01, 0x0C, 0x00, 0x00, 0xC4,
  0x00, 0x00, 0x62, 0x00, 0x00, 0x33, 0x00, 0x00, 0x19, 0x00, 0x00, 0x0C,
  0x80, 0x00, 0x06, 0x40, 0x00, 0x02, 0x60, 0x00, 0x01, 0x30, 0x00, 0x00,
  0x98, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x64, 0x00, 0x00, 0x32, 0x00, 0x00,
  0x13, 0x00, 0x00, 0x09, 0x80, 0x00, 0x04, 0x80, 0x00, 0x06, 0x40, 0x00,
  0x03, 0x20, 0x00, 0x01, 0x10, 0x00, 0x00, 0x88, 0x00, 0x00, 0xC4, 0x00,
  0x00, 0x42, 0x00, 0x00, 0x61, 0x80, 0x00, 0x20, 0x40, 0x00, 0x30, 0x30,
  0x00, 0x30, 0x08, 0x00, 0x30, 0x06, 0x00, 0x30, 0x01, 0xC0, 0x70, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04,
  0x00, 0x03, 0xFF, 0xE0, 0x01, 0x00, 0x3C, 0x00, 0x80, 0x03, 0x00, 0x40,
  0x00, 0xC0, 0x60, 0x00, 0x30, 0x30, 0x00, 0x08, 0x10, 0x00, 0x04, 0x08,
  0x00, 0x02, 0x04, 0x00, 0x01, 0x02, 0x00, 0x00, 0x83, 0x00, 0x00, 0x41,
  0x80, 0x00, 0x20, 0x80, 0x00, 0x30, 0x40, 0x00, 0x10, 0x20, 0x00, 0x18,
  0x10, 0x00, 0x08, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x04, 0x00, 0x0C,
  0x02, 0x00, 0x38, 0x01, 0xFF, 0xF0, 0x00, 0x80, 0x18, 0x00, 0xC0, 0x04,
  0x00, 0x60, 0x03, 0x00, 0x20, 0x01, 0x80, 0x10, 0x00, 0x40, 0x08, 0x00,
  0x30, 0x04, 0x00, 0x18, 0x06, 0x00, 0x04, 0x02, 0x00, 0x03, 0x01, 0x00,
  0x01, 0x80, 0x80, 0x00, 0x40, 0x40, 0x00, 0x30, 0x60, 0x00, 0x18, 0x30,
  0x00, 0x04, 0x10, 0x00, 0x03, 0x08, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x1C, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x18, 0x00,
  0x30, 0x18, 0x00, 0x08, 0x08, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x04, 0x00,
  0x01, 0x82, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x84, 0x00, 0x00, 0x46, 0x00, 0x00, 0x63, 0x00, 0x00, 0x30, 0x80, 0x00,
  0x10, 0x40, 0x00, 0x18, 0x30, 0x00, 0x18, 0x08, 0x00, 0x18, 0x06, 0x00,
  0x18, 0x01, 0xC0, 0x38, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0x80, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x04, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x30, 0x40, 0x00, 0x08,
  0x30, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x82, 0x00, 0x00, 0x20, 0x80, 0x00,
  0x18, 0x20, 0x00, 0x06, 0x08, 0x00, 0x01, 0x06, 0x00, 0x00, 0x41, 0x80,
  0x00, 0x10, 0x40, 0x00, 0x04, 0x10, 0x00, 0x03, 0x04, 0x00, 0x00, 0xC1,
  0x00, 0x00, 0x20, 0xC0, 0x00, 0x08, 0x30, 0x00, 0x02, 0x08, 0x00, 0x00,
  0x82, 0x00, 0x00, 0x60, 0x80, 0x00, 0x18, 0x60, 0x00, 0x04, 0x18, 0x00,
  0x01, 0x06, 0x00, 0x00, 0x41, 0x00, 0x00, 0x10, 0x40, 0x00, 0x0C, 0x10,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x83, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x18,
  0x30, 0x00, 0x04, 0x04, 0x00, 0x01, 0x01, 0x00, 0x00, 0xC0, 0x60, 0x00,
  0x60, 0x18, 0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0x70, 0x1C, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x03, 0x80, 0x00, 0x02,
  0x80, 0x00, 0x06, 0xC0, 0x00, 0x04, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x08,
  0x40, 0x00, 0x18, 0x40, 0x00, 0x10, 0x40, 0x00, 0x30, 0x40, 0x00, 0x20,
  0x60, 0x00, 0x20, 0x60, 0x00, 0x60, 0x60, 0x00, 0x40, 0x20, 0x00, 0xC0,
  0x20, 0x00, 0x80, 0x20, 0x01, 0x80, 0x20, 0x01, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x02, 0x00, 0x10, 0x06, 0x00, 0x10, 0x04, 0x00, 0x10, 0x0C, 0x00,
  0x10, 0x08, 0x00, 0x10, 0x08, 0x00, 0x18, 0x18, 0x00, 0x18, 0x10, 0x00,
  0x08, 0x30, 0x00, 0x08, 0x20, 0x00, 0x08, 0x60, 0x00, 0x08, 0x40, 0x00,
  0x0C, 0xC0, 0x00, 0x0C, 0x80, 0x00, 0x05, 0x80, 0x00, 0x05, 0x00, 0x00,
  0x05, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0xC0, 0x00, 0x60, 0x00, 0x2C, 0x00,
  0x0A, 0x00, 0x02, 0xC0, 0x00, 0xA0, 0x00, 0x6C, 0x00, 0x1A, 0x00, 0x04,
  0x40, 0x01, 0x30, 0x00, 0xC4, 0x00, 0x33, 0x00, 0x0C, 0x40, 0x02, 0x10,
  0x00, 0x84, 0x00, 0x21, 0x00, 0x18, 0x40, 0x06, 0x10, 0x01, 0x04, 0x00,
  0x41, 0x00, 0x10, 0x40, 0x0C, 0x10, 0x03, 0x04, 0x00, 0x81, 0x00, 0x20,
  0x40, 0x08, 0x10, 0x06, 0x06, 0x01, 0x81, 0x00, 0x60, 0x60, 0x10, 0x10,
  0x04, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x20, 0x18, 0x08, 0x06, 0x02,
  0x01, 0x80, 0x80, 0x60, 0x60, 0x08, 0x18, 0x02, 0x04, 0x00, 0x81, 0x00,
  0x20, 0xC0, 0x08, 0x30, 0x02, 0x08, 0x00, 0x83, 0x00, 0x20, 0x80, 0x08,
  0x20, 0x02, 0x18, 0x00, 0x86, 0x00, 0x21, 0x00, 0x08, 0x40, 0x02, 0x30,
  0x00, 0xC4, 0x00, 0x22, 0x00, 0x0C, 0xC0, 0x02, 0x20, 0x00, 0xC8, 0x00,
  0x36, 0x00, 0x0D, 0x80, 0x03, 0x40, 0x00, 0xD8, 0x00, 0x3C, 0x00, 0x05,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x38, 0x00, 0x06, 0x00, 0x03, 0x80,
  0x00, 0x60, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x18,
  0x0C, 0x00, 0x01, 0x80, 0x60, 0x00, 0x08, 0x01, 0x00, 0x00, 0x80, 0x0C,
  0x00, 0x0C, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x04, 0x00, 0x04, 0x00,
  0x60, 0x00, 0x20, 0x06, 0x00, 0x01, 0x80, 0x60, 0x00, 0x04, 0x02, 0x00,
  0x00, 0x30, 0x30, 0x00, 0x00, 0x83, 0x00, 0x00, 0x06, 0x10, 0x00, 0x00,
  0x11, 0x00, 0x00, 0x00, 0x98, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0x0C, 0x40, 0x00, 0x00, 0x42, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00,
  0x60, 0x40, 0x00, 0x02, 0x03, 0x00, 0x00, 0x20, 0x08, 0x00, 0x03, 0x00,
  0x60, 0x00, 0x30, 0x01, 0x00, 0x01, 0x00, 0x08, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x01, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x80, 0x00, 0x20, 0x0C,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x20, 0x00, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x06, 0x40, 0x00, 0x04, 0x60, 0x00, 0x0C, 0x60,
  0x00, 0x18, 0x20, 0x00, 0x10, 0x30, 0x00, 0x30, 0x30, 0x00, 0x60, 0x10,
  0x00, 0x40, 0x10, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x08, 0x01, 0x00, 0x08,
  0x03, 0x00, 0x0C, 0x06, 0x00, 0x04, 0x04, 0x00, 0x04, 0x0C, 0x00, 0x06,
  0x18, 0x00, 0x02, 0x10, 0x00, 0x02, 0x30, 0x00, 0x03, 0x60, 0x00, 0x01,
  0x40, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x01, 0xF8, 0x0C, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0xC0, 0x06, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10,
  0x00, 0x80, 0x07, 0xE0, 0x00, 0xC0, 0x40, 0x40, 0x40, 0x40, 0x60, 0x60,
  0x60, 0x20, 0x20, 0x20, 0x20, 0x30, 0x30, 0x30, 0x10, 0x10, 0x10, 0x10,
  0x18, 0x18, 0x18, 0x08, 0x08, 0x08, 0x08, 0x0C, 0x0C, 0x04, 0x04, 0x04,
  0x04, 0x04, 0x06, 0x06, 0x02, 0x02, 0x02, 0x02, 0x02, 0x01, 0xF8, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x03, 0xF0,
  0x00, 0x00, 0x60, 0x01, 0x80, 0x0A, 0x00, 0x68, 0x01, 0x20, 0x0C, 0x80,
  0x23, 0x01, 0x84, 0x04, 0x10, 0x30, 0x40, 0x81, 0x06, 0x06, 0x10, 0x18,
  0xC0, 0x62, 0x00, 0x98, 0x02, 0x40, 0x0B, 0x00, 0x30, 0xFF, 0xFF, 0xC0,
  0x41, 0x82, 0x0C, 0x10, 0x60, 0x80, 0x00, 0x08, 0x00, 0x0F, 0xF8, 0x03,
  0x80, 0xC0, 0x60, 0x06, 0x04, 0x00, 0x20, 0x80, 0x02, 0x18, 0x00, 0x21,
  0x00, 0x02, 0x10, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x0F, 0xFC, 0x07, 0xC0, 0x41, 0xC0, 0x04, 0x30, 0x00,
  0x46, 0x00, 0x0C, 0x40, 0x00, 0xCC, 0x00, 0x08, 0x80, 0x00, 0x88, 0x00,
  0x18, 0x80, 0x01, 0x88, 0x00, 0x38, 0x80, 0x05, 0x8C, 0x01, 0x98, 0x60,
  0x31, 0x03, 0xFE, 0x10, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x43, 0xFC, 0x02, 0x70, 0x30, 0x16, 0x00, 0xC1, 0xE0,
  0x02, 0x0E, 0x00, 0x10, 0x60, 0x00, 0xC2, 0x00, 0x06, 0x10, 0x00, 0x30,
  0x80, 0x01, 0x8C, 0x00, 0x0C, 0x60, 0x00, 0x62, 0x00, 0x02, 0x10, 0x00,
  0x10, 0x80, 0x00, 0x8C, 0x00, 0x04, 0x60, 0x00, 0x22, 0x00, 0x03, 0x10,
  0x00, 0x10, 0x80, 0x00, 0x84, 0x00, 0x0C, 0x60, 0x00, 0x43, 0x00, 0x06,
  0x18, 0x00, 0x20, 0xE0, 0x03, 0x05, 0x80, 0x30, 0x26, 0x03, 0x03, 0x0F,
  0xF0, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x0C, 0x06, 0x02,
  0x00, 0x60, 0x80, 0x04, 0x30, 0x00, 0xCC, 0x00, 0x19, 0x00, 0x03, 0x20,
  0x00, 0x6C, 0x00, 0x0D, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x09, 0x00, 0x03, 0x20, 0x00, 0x46, 0x00,
  0x18, 0x40, 0x02, 0x0C, 0x00, 0x80, 0xC0, 0x60, 0x0F, 0xF8, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x1F, 0xE1, 0x00, 0x60, 0x32, 0x01, 0x80, 0x24, 0x06, 0x00, 0x28, 0x18,
  0x00, 0x70, 0x20, 0x00, 0x60, 0xC0, 0x00, 0x81, 0x00, 0x01, 0x02, 0x00,
  0x02, 0x0C, 0x00, 0x04, 0x18, 0x00, 0x18, 0x20, 0x00, 0x30, 0x40, 0x00,
  0x40, 0x80, 0x00, 0x81, 0x00, 0x01, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x0C,
  0x18, 0x00, 0x10, 0x20, 0x00, 0x20, 0x40, 0x00, 0x40, 0xC0, 0x00, 0x81,
  0x80, 0x03, 0x01, 0x00, 0x06, 0x02, 0x00, 0x18, 0x06, 0x00, 0xD0, 0x06,
  0x03, 0x20, 0x07, 0xF8, 0x40, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x01, 0x80, 0xC0, 0x30, 0x06, 0x06, 0x00, 0x20, 0xC0, 0x03, 0x08,
  0x00, 0x31, 0x00, 0x03, 0x10, 0x00, 0x33, 0x00, 0x03, 0x20, 0x00, 0x36,
  0x00, 0x03, 0x7F, 0xFF, 0xE4, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00,
  0x30, 0x1C, 0x0E, 0x00, 0xFF, 0x80, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x7F,
  0xF0, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x10, 0x0C,
  0x06, 0x40, 0x60, 0x09, 0x03, 0x00, 0x14, 0x18, 0x00, 0x70, 0x40, 0x00,
  0xC3, 0x00, 0x02, 0x08, 0x00, 0x08, 0x20, 0x00, 0x21, 0x80, 0x00, 0x86,
  0x00, 0x06, 0x10, 0x00, 0x18, 0x40, 0x00, 0x41, 0x00, 0x01, 0x04, 0x00,
  0x04, 0x30, 0x00, 0x10, 0xC0, 0x00, 0xC3, 0x00, 0x03, 0x08, 0x00, 0x08,
  0x20, 0x00, 0x20, 0xC0, 0x00, 0x83, 0x00, 0x06, 0x0C, 0x00, 0x18, 0x10,
  0x00, 0xE0, 0x60, 0x0D, 0x00, 0xC0, 0x64, 0x01, 0xFE, 0x10, 0x00, 0x80,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80,
  0x00, 0x04, 0x04, 0x00, 0x30, 0x10, 0x01, 0x80, 0x30, 0x0C, 0x00, 0x70,
  0xE0, 0x00, 0x7E, 0x00, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x20, 0x04,
  0x3F, 0xC0, 0x46, 0x06, 0x04, 0xC0, 0x20, 0xD8, 0x03, 0x0D, 0x00, 0x10,
  0xA0, 0x01, 0x0C, 0x00, 0x10, 0xC0, 0x01, 0x08, 0x00, 0x11, 0x80, 0x01,
  0x18, 0x00, 0x31, 0x00, 0x03, 0x10, 0x00, 0x21, 0x00, 0x02, 0x10, 0x00,
  0x23, 0x00, 0x02, 0x30, 0x00, 0x62, 0x00, 0x06, 0x20, 0x00, 0x42, 0x00,
  0x04, 0x60, 0x00, 0x46, 0x00, 0x0C, 0x60, 0x00, 0xC4, 0x00, 0x08, 0x40,
  0x00, 0x84, 0x00, 0x08, 0xC0, 0x00, 0x80, 0x02, 0x07, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x08, 0x08, 0x08, 0x08, 0x18, 0x18,
  0x10, 0x10, 0x10, 0x10, 0x30, 0x30, 0x20, 0x20, 0x20, 0x60, 0x60, 0x60,
  0x40, 0x40, 0x40, 0xC0, 0xC0, 0x80, 0x80, 0x80, 0x00, 0x01, 0x80, 0x01,
  0xC0, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x30, 0x02, 0x30, 0x01,
  0xF0, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x01,
  0x82, 0x00, 0x30, 0x10, 0x03, 0x01, 0x80, 0x30, 0x0C, 0x03, 0x00, 0x40,
  0x30, 0x02, 0x03, 0x00, 0x10, 0x30, 0x00, 0x83, 0x00, 0x0C, 0x30, 0x00,
  0x63, 0x00, 0x02, 0x30, 0x00, 0x13, 0x80, 0x00, 0xA6, 0x00, 0x06, 0x10,
  0x00, 0x60, 0xC0, 0x03, 0x02, 0x00, 0x10, 0x18, 0x00, 0x80, 0x40, 0x04,
  0x03, 0x00, 0x60, 0x08, 0x03, 0x00, 0x60, 0x10, 0x01, 0x00, 0x80, 0x0C,
  0x04, 0x00, 0x30, 0x20, 0x01, 0x83, 0x00, 0x06, 0x00, 0x03, 0x02, 0x02,
  0x02, 0x02, 0x06, 0x06, 0x04, 0x04, 0x04, 0x04, 0x0C, 0x0C, 0x08, 0x08,
  0x08, 0x08, 0x18, 0x18, 0x10, 0x10, 0x10, 0x30, 0x30, 0x30, 0x20, 0x20,
  0x20, 0x60, 0x60, 0x40, 0x40, 0x40, 0x40, 0xC0, 0xC0, 0x80, 0x80, 0x80,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x87, 0xF8, 0x0F, 0xF0, 0x11, 0x81, 0x83,
  0x03, 0x06, 0x40, 0x10, 0x80, 0x30, 0xD0, 0x03, 0x20, 0x02, 0x1E, 0x00,
  0x28, 0x00, 0x42, 0x80, 0x07, 0x00, 0x08, 0x60, 0x00, 0xC0, 0x01, 0x0C,
  0x00, 0x10, 0x00, 0x23, 0x00, 0x02, 0x00, 0x04, 0x60, 0x00, 0xC0, 0x00,
  0x88, 0x00, 0x18, 0x00, 0x31, 0x00, 0x02, 0x00, 0x06, 0x20, 0x00, 0x40,
  0x00, 0xCC, 0x00, 0x08, 0x00, 0x11, 0x80, 0x01, 0x00, 0x02, 0x30, 0x00,
  0x60, 0x00, 0x44, 0x00, 0x0C, 0x00, 0x18, 0x80, 0x01, 0x00, 0x03, 0x10,
  0x00, 0x20, 0x00, 0x46, 0x00, 0x04, 0x00, 0x08, 0xC0, 0x00, 0x80, 0x01,
  0x18, 0x00, 0x30, 0x00, 0x22, 0x00, 0x06, 0x00, 0x0C, 0x40, 0x00, 0x80,
  0x01, 0x88, 0x00, 0x10, 0x00, 0x23, 0x00, 0x02, 0x00, 0x04, 0x60, 0x00,
  0xC0, 0x00, 0x80, 0x00, 0x02, 0x00, 0x41, 0xFC, 0x04, 0x60, 0x60, 0x4C,
  0x02, 0x0D, 0x80, 0x30, 0xD0, 0x01, 0x0E, 0x00, 0x10, 0xC0, 0x01, 0x0C,
  0x00, 0x10, 0x80, 0x01, 0x18, 0x00, 0x11, 0x80, 0x03, 0x10, 0x00, 0x31,
  0x00, 0x02, 0x10, 0x00, 0x21, 0x00, 0x02, 0x30, 0x00, 0x23, 0x00, 0x06,
  0x20, 0x00, 0x62, 0x00, 0x04, 0x20, 0x00, 0x42, 0x00, 0x04, 0x60, 0x00,
  0xC6, 0x00, 0x0C, 0x40, 0x00, 0x84, 0x00, 0x08, 0x40, 0x00, 0x8C, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x0F, 0xF0, 0x03, 0x81, 0xC0, 0x60, 0x04, 0x0C,
  0x00, 0x60, 0x80, 0x02, 0x18, 0x00, 0x33, 0x00, 0x03, 0x30, 0x00, 0x32,
  0x00, 0x03, 0x60, 0x00, 0x34, 0x00, 0x03, 0x40, 0x00, 0x34, 0x00, 0x02,
  0x40, 0x00, 0x2C, 0x00, 0x02, 0xC0, 0x00, 0x28, 0x00, 0x06, 0x80, 0x00,
  0x48, 0x00, 0x04, 0x80, 0x00, 0xCC, 0x00, 0x08, 0xC0, 0x01, 0x84, 0x00,
  0x10, 0x60, 0x03, 0x02, 0x00, 0x60, 0x38, 0x1C, 0x01, 0xFF, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x7F, 0x80, 0x27, 0x03, 0x00, 0xB0,
  0x06, 0x07, 0x80, 0x08, 0x1C, 0x00, 0x20, 0x60, 0x00, 0xC1, 0x00, 0x03,
  0x04, 0x00, 0x0C, 0x10, 0x00, 0x30, 0xC0, 0x00, 0xC3, 0x00, 0x03, 0x08,
  0x00, 0x0C, 0x20, 0x00, 0x20, 0x80, 0x00, 0x82, 0x00, 0x02, 0x18, 0x00,
  0x08, 0x60, 0x00, 0x61, 0x00, 0x01, 0x04, 0x00, 0x04, 0x10, 0x00, 0x30,
  0x40, 0x00, 0x83, 0x00, 0x02, 0x0C, 0x00, 0x10, 0x38, 0x00, 0xC0, 0xB0,
  0x06, 0x02, 0x60, 0x30, 0x18, 0xFF, 0x80, 0x60, 0x20, 0x01, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE1, 0x03, 0x01, 0x90, 0x60, 0x09,
  0x0C, 0x00, 0x51, 0x80, 0x07, 0x10, 0x00, 0x33, 0x00, 0x02, 0x20, 0x00,
  0x22, 0x00, 0x02, 0x60, 0x00, 0x26, 0x00, 0x06, 0x40, 0x00, 0x64, 0x00,
  0x04, 0x40, 0x00, 0x44, 0x00, 0x04, 0xC0, 0x00, 0x4C, 0x00, 0x0C, 0xC0,
  0x00, 0xC8, 0x00, 0x08, 0x80, 0x00, 0x8C, 0x00, 0x08, 0xC0, 0x01, 0x84,
  0x00, 0x18, 0x40, 0x03, 0x06, 0x00, 0xD0, 0x30, 0x39, 0x01, 0xFE, 0x10,
  0x02, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0x00, 0x08, 0x7C, 0x13, 0x00, 0x2C, 0x00,
  0xD0, 0x01, 0xC0, 0x02, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00,
  0x60, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x0C, 0x06, 0x03, 0x00, 0x60, 0x80, 0x04, 0x30, 0x00, 0xC4,
  0x00, 0x18, 0x80, 0x03, 0x10, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x19, 0x00,
  0x03, 0x20, 0x00, 0x46, 0x00, 0x08, 0xC0, 0x02, 0x0C, 0x00, 0xC0, 0xC0,
  0x70, 0x0F, 0xF8, 0x00, 0x10, 0x00, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x60, 0xFF, 0xE1, 0x80, 0x20, 0x04, 0x00, 0x80,
  0x30, 0x06, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x18, 0x03, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x0C, 0x00, 0xF8, 0x04, 0x00, 0x10, 0x00, 0x21, 0x00,
  0x02, 0x10, 0x00, 0x23, 0x00, 0x02, 0x30, 0x00, 0x62, 0x00, 0x06, 0x20,
  0x00, 0x42, 0x00, 0x04, 0x20, 0x00, 0x46, 0x00, 0x04, 0x60, 0x00, 0xC4,
  0x00, 0x0C, 0x40, 0x00, 0x84, 0x00, 0x08, 0xC0, 0x00, 0x8C, 0x00, 0x18,
  0x80, 0x01, 0x88, 0x00, 0x10, 0x80, 0x01, 0x08, 0x00, 0x30, 0x80, 0x03,
  0x08, 0x00, 0x30, 0x80, 0x07, 0x0C, 0x00, 0xA0, 0x40, 0x1A, 0x06, 0x07,
  0x20, 0x3F, 0xC2, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x78, 0x00, 0x09, 0x00,
  0x03, 0x20, 0x00, 0x44, 0x00, 0x18, 0xC0, 0x02, 0x18, 0x00, 0xC3, 0x00,
  0x10, 0x20, 0x02, 0x04, 0x00, 0x80, 0x80, 0x10, 0x18, 0x04, 0x03, 0x00,
  0x80, 0x60, 0x30, 0x04, 0x04, 0x00, 0x81, 0x80, 0x10, 0x20, 0x03, 0x0C,
  0x00, 0x61, 0x00, 0x0C, 0x60, 0x00, 0x88, 0x00, 0x13, 0x00, 0x02, 0x40,
  0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x10, 0x00, 0x00, 0xC0,
  0x02, 0x00, 0x1E, 0x00, 0x30, 0x00, 0xF0, 0x01, 0xC0, 0x05, 0x80, 0x1E,
  0x00, 0x64, 0x00, 0xB0, 0x02, 0x20, 0x05, 0x80, 0x31, 0x00, 0x6C, 0x01,
  0x08, 0x02, 0x20, 0x18, 0x40, 0x31, 0x00, 0xC2, 0x01, 0x08, 0x04, 0x10,
  0x18, 0x40, 0x60, 0x80, 0x82, 0x02, 0x06, 0x0C, 0x10, 0x30, 0x30, 0x40,
  0xC1, 0x01, 0x82, 0x06, 0x18, 0x0C, 0x30, 0x30, 0xC0, 0x61, 0x01, 0x84,
  0x03, 0x18, 0x04, 0x60, 0x08, 0x80, 0x22, 0x00, 0x4C, 0x01, 0x30, 0x02,
  0x40, 0x09, 0x80, 0x16, 0x00, 0x48, 0x00, 0xA0, 0x02, 0xC0, 0x05, 0x00,
  0x14, 0x00, 0x30, 0x00, 0xA0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x0C, 0x08, 0x00, 0x20, 0x30, 0x01, 0x00, 0xC0, 0x0C,
  0x01, 0x00, 0x60, 0x06, 0x01, 0x00, 0x08, 0x08, 0x00, 0x30, 0x60, 0x00,
  0x43, 0x00, 0x01, 0x88, 0x00, 0x02, 0x40, 0x00, 0x0B, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x12, 0x00, 0x00, 0xCC, 0x00,
  0x06, 0x10, 0x00, 0x10, 0x60, 0x00, 0x80, 0x80, 0x06, 0x03, 0x00, 0x30,
  0x0C, 0x00, 0x80, 0x10, 0x04, 0x00, 0x60, 0x30, 0x00, 0x81, 0x80, 0x03,
  0x04, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x02, 0x00, 0x03, 0x02, 0x00,
  0x02, 0x02, 0x00, 0x06, 0x03, 0x00, 0x04, 0x03, 0x00, 0x0C, 0x03, 0x00,
  0x08, 0x01, 0x00, 0x18, 0x01, 0x00, 0x10, 0x01, 0x00, 0x30, 0x01, 0x00,
  0x20, 0x01, 0x80, 0x60, 0x01, 0x80, 0x40, 0x00, 0x80, 0xC0, 0x00, 0x80,
  0x80, 0x00, 0x81, 0x80, 0x00, 0x81, 0x00, 0x00, 0xC3, 0x00, 0x00, 0xC2,
  0x00, 0x00, 0x46, 0x00, 0x00, 0x44, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x48,
  0x00, 0x00, 0x58, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x01, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x30, 0x00, 0x60, 0x00, 0x40, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x18, 0x00, 0xE0,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x18, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C,
  0x00, 0x07, 0x00, 0x01, 0x00, 0x01, 0x01, 0x03, 0x03, 0x03, 0x02, 0x02,
  0x02, 0x06, 0x06, 0x06, 0x06, 0x04, 0x04, 0x04, 0x0C, 0x0C, 0x0C, 0x08,
  0x08, 0x08, 0x18, 0x18, 0x18, 0x18, 0x10, 0x10, 0x10, 0x30, 0x30, 0x30,
  0x20, 0x20, 0x20, 0x60, 0x60, 0x60, 0x60, 0x40, 0x40, 0x40, 0xC0, 0xC0,
  0xC0, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x18, 0x00, 0x07, 0x00, 0x07, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x00, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x1C, 0xE0, 0x01, 0x30, 0x30, 0x03, 0x60, 0x18, 0x02, 0x40, 0x0C, 0x06,
  0x40, 0x04, 0x04, 0xC0, 0x03, 0x18, 0x00, 0x01, 0xF0,
};

const GFXglyph RobotoCondensed_ThinItalic52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 8, 38, 9, 1, -37 },
  { 39, 8, 10, 13, 6, -39 },
  { 49, 26, 37, 25, 1, -37 },
  { 170, 21, 49, 24, 2, -43 },
  { 299, 24, 39, 33, 5, -38 },
  { 416, 23, 39, 27, 1, -38 },
  { 529, 4, 10, 8, 5, -39 },
  { 534, 14, 53, 14, 3, -41 },
  { 627, 14, 53, 14, -3, -41 },
  { 720, 20, 20, 21, 3, -37 },
  { 770, 21, 27, 25, 2, -31 },
  { 841, 5, 10, 9, -1, -4 },
  { 848, 10, 1, 14, 2, -17 },
  { 850, 3, 3, 11, 1, -2 },
  { 852, 21, 40, 17, -2, -37 },
  { 957, 21, 39, 24, 2, -38 },
  { 1060, 11, 37, 24, 7, -37 },
  { 1111, 22, 38, 24, 1, -38 },
  { 1216, 22, 39, 24, 1, -38 },
  { 1324, 22, 37, 24, 1, -37 },
  { 1426, 22, 38, 24, 3, -37 },
  { 1531, 20, 38, 24, 2, -37 },
  { 1626, 20, 37, 24, 5, -37 },
  { 1719, 23, 39, 24, 1, -38 },
  { 1832, 19, 38, 24, 4, -38 },
  { 1923, 7, 27, 9, 1, -26 },
  { 1947, 10, 32, 9, -2, -26 },
  { 1987, 20, 20, 23, 2, -27 },
  { 2037, 19, 11, 25, 3, -22 },
  { 2064, 20, 20, 23, 1, -27 },
  { 2114, 15, 39, 20, 5, -38 },
  { 2188, 36, 48, 41, 2, -36 },
  { 2404, 24, 37, 27, -1, -37 },
  { 2515, 23, 37, 27, 2, -37 },
  { 2622, 24, 39, 29, 3, -38 },
  { 2739, 25, 37, 29, 2, -37 },
  { 2855, 25, 37, 25, 2, -37 },
  { 2971, 25, 37, 25, 2, -37 },
  { 3087, 25, 39, 30, 3, -38 },
  { 3209, 28, 37, 31, 2, -37 },
  { 3339, 7, 37, 12, 3, -37 },
  { 3372, 23, 38, 24, 1, -37 },
  { 3482, 27, 37, 28, 2, -37 },
  { 3607, 17, 37, 23, 2, -37 },
  { 3686, 35, 37, 38, 2, -37 },
  { 3848, 28, 37, 31, 2, -37 },
  { 3978, 25, 39, 29, 3, -38 },
  { 4100, 25, 37, 27, 2, -37 },
  { 4216, 25, 45, 29, 3, -38 },
  { 4357, 25, 37, 29, 2, -37 },
  { 4473, 25, 39, 26, 1, -38 },
  { 4595, 24, 37, 27, 5, -37 },
  { 4706, 26, 38, 29, 3, -37 },
  { 4830, 24, 37, 27, 5, -37 },
  { 4941, 36, 37, 40, 5, -37 },
  { 5108, 29, 37, 27, -1, -37 },
  { 5243, 24, 37, 26, 5, -37 },
  { 5354, 27, 37, 27, 0, -37 },
  { 5479, 13, 50, 10, 1, -42 },
  { 5561, 8, 40, 17, 5, -37 },
  { 5601, 14, 50, 10, -3, -42 },
  { 5689, 14, 18, 19, 3, -37 },
  { 5721, 18, 1, 19, -2, 0 },
  { 5724, 6, 7, 13, 7, -39 },
  { 5730, 20, 29, 24, 1, -28 },
  { 5803, 21, 40, 24, 1, -39 },
  { 5908, 19, 29, 23, 2, -28 },
  { 5977, 23, 40, 24, 2, -39 },
  { 6092, 20, 29, 23, 1, -28 },
  { 6165, 16, 40, 15, 3, -40 },
  { 6245, 22, 39, 24, 0, -28 },
  { 6353, 20, 39, 24, 1, -39 },
  { 6451, 8, 37, 10, 2, -37 },
  { 6488, 17, 48, 10, -7, -37 },
  { 6590, 21, 39, 21, 1, -39 },
  { 6693, 8, 39, 10, 2, -39 },
  { 6732, 35, 28, 39, 1, -28 },
  { 6855, 20, 28, 24, 1, -28 },
  { 6925, 20, 29, 24, 2, -28 },
  { 6998, 22, 39, 24, 0, -28 },
  { 7106, 20, 39, 24, 2, -28 },
  { 7204, 15, 28, 15, 1, -28 },
  { 7257, 19, 29, 22, 1, -28 },
  { 7326, 11, 36, 15, 3, -35 },
  { 7376, 20, 28, 24, 3, -27 },
  { 7446, 19, 27, 21, 3, -27 },
  { 7511, 29, 27, 33, 4, -27 },
  { 7609, 22, 27, 21, -1, -27 },
  { 7684, 24, 38, 21, -2, -27 },
  { 7798, 21, 27, 21, 0, -27 },
  { 7869, 16, 52, 15, 2, -41 },
  { 7973, 8, 44, 10, 1, -37 },
  { 8017, 16, 52, 15, -3, -41 },
  { 8121, 24, 8, 30, 3, -19 },
};

const GFXfont RobotoCondensed_ThinItalic52pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ThinItalic52pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ThinItalic52pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _ROBOTOCONDENSED_THINITALIC52PT7B_H_
