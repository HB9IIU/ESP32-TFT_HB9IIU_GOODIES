#ifndef _ROBOTOCONDENSED_THINITALIC32PT7B_H_
#define _ROBOTOCONDENSED_THINITALIC32PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ThinItalic.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ThinItalic32pt7bBitmaps[] PROGMEM = {
  0x00, 0x08, 0x84, 0x21, 0x08, 0x84, 0x21, 0x08, 0x44, 0x21, 0x08, 0x00,
  0x00, 0x00, 0x42, 0x00, 0x8C, 0xA5, 0x29, 0x48, 0x00, 0x42, 0x00, 0x21,
  0x00, 0x20, 0x80, 0x10, 0x80, 0x08, 0x40, 0x08, 0x20, 0x7F, 0xFC, 0x02,
  0x10, 0x02, 0x08, 0x01, 0x08, 0x00, 0x84, 0x00, 0x82, 0x00, 0x41, 0x00,
  0x21, 0x00, 0x20, 0x80, 0x10, 0x40, 0x7F, 0xFC, 0x04, 0x20, 0x04, 0x10,
  0x02, 0x10, 0x01, 0x08, 0x01, 0x04, 0x00, 0x84, 0x00, 0x00, 0x40, 0x02,
  0x00, 0x20, 0x07, 0xC0, 0x41, 0x04, 0x04, 0x40, 0x22, 0x01, 0x10, 0x09,
  0x00, 0x44, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x20, 0x01, 0x00, 0x05, 0x00, 0x28, 0x01, 0x40, 0x12, 0x00, 0x88, 0x08,
  0x20, 0x80, 0xF8, 0x01, 0x00, 0x08, 0x00, 0x40, 0x00, 0x1C, 0x00, 0x44,
  0x01, 0x08, 0x02, 0x10, 0x28, 0x20, 0x90, 0x42, 0x20, 0x88, 0x41, 0x10,
  0x84, 0x41, 0x09, 0x01, 0xE2, 0x00, 0x08, 0x00, 0x23, 0xC0, 0x48, 0x81,
  0x20, 0x84, 0x41, 0x10, 0x82, 0x21, 0x04, 0x84, 0x0A, 0x08, 0x24, 0x08,
  0x40, 0x11, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x18, 0x80, 0x41, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x80, 0x82, 0x02, 0x10, 0x09, 0x80, 0x18, 0x00, 0x40,
  0x02, 0x80, 0x12, 0x00, 0x84, 0x14, 0x08, 0x50, 0x22, 0x80, 0x4A, 0x01,
  0x28, 0x03, 0x20, 0x08, 0xC0, 0x51, 0x82, 0x43, 0xF0, 0x80, 0x55, 0x60,
  0x01, 0x02, 0x04, 0x04, 0x08, 0x10, 0x10, 0x20, 0x20, 0x20, 0x40, 0x40,
  0x40, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x40, 0x40, 0x20, 0x20, 0x04, 0x01, 0x00, 0x80,
  0x20, 0x10, 0x08, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x20, 0x10, 0x08, 0x08, 0x04,
  0x04, 0x02, 0x02, 0x01, 0x01, 0x01, 0x01, 0x00, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x20, 0xC2, 0x33, 0x5C, 0x0E, 0x00, 0xA0, 0x12, 0x03, 0x10, 0x20,
  0x84, 0x08, 0x00, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x40, 0xFF, 0xF8, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x24, 0x95, 0x00, 0xFC, 0xA0, 0x00,
  0x08, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x10,
  0x00, 0x80, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x01,
  0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x80, 0x00, 0x07, 0xC0, 0x82, 0x10, 0x11, 0x01, 0x20, 0x12,
  0x01, 0x40, 0x14, 0x01, 0x40, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x28,
  0x02, 0x80, 0x28, 0x02, 0x80, 0x48, 0x04, 0x80, 0x48, 0x08, 0x81, 0x84,
  0x30, 0x3C, 0x00, 0x06, 0x35, 0x8C, 0x10, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x20, 0x40, 0x81, 0x02, 0x04, 0x10, 0x20, 0x40, 0x81, 0x02, 0x08, 0x00,
  0x03, 0xE0, 0x20, 0x82, 0x04, 0x20, 0x11, 0x00, 0x90, 0x04, 0x80, 0x20,
  0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x60, 0x03,
  0xFF, 0x80, 0x03, 0xE0, 0x20, 0x82, 0x02, 0x20, 0x12, 0x00, 0x90, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x10, 0x01, 0x80, 0x18, 0x0F, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x02, 0x80, 0x14, 0x00, 0xA0, 0x09, 0x00, 0x44, 0x04,
  0x10, 0x40, 0x7C, 0x00, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0xA0, 0x09,
  0x00, 0x48, 0x04, 0x80, 0x44, 0x04, 0x20, 0x21, 0x02, 0x08, 0x20, 0x41,
  0x04, 0x10, 0x21, 0x01, 0x08, 0x08, 0xFF, 0xF8, 0x02, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x0F, 0xF8, 0x40, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x2F, 0x81, 0x82, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x24, 0x01, 0x20,
  0x11, 0x00, 0x84, 0x08, 0x20, 0xC0, 0xF8, 0x00, 0x00, 0x70, 0x18, 0x06,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x10, 0x02, 0x00, 0x27, 0xC2, 0x82, 0x50,
  0x16, 0x01, 0x40, 0x14, 0x01, 0x40, 0x14, 0x01, 0x80, 0x18, 0x01, 0x40,
  0x24, 0x02, 0x40, 0x42, 0x08, 0x1F, 0x00, 0xFF, 0xF0, 0x01, 0x00, 0x20,
  0x02, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x02, 0x00,
  0x20, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x20, 0x02,
  0x00, 0x40, 0x04, 0x00, 0x80, 0x00, 0x03, 0xE0, 0x10, 0x40, 0x80, 0x84,
  0x02, 0x10, 0x04, 0x80, 0x12, 0x00, 0x88, 0x02, 0x20, 0x08, 0x40, 0x40,
  0x86, 0x01, 0xE0, 0x18, 0x40, 0x80, 0x84, 0x01, 0x20, 0x04, 0x80, 0x12,
  0x00, 0x48, 0x01, 0x20, 0x08, 0x80, 0x41, 0x02, 0x03, 0xF0, 0x00, 0x07,
  0xC0, 0x86, 0x10, 0x22, 0x01, 0x40, 0x14, 0x01, 0x40, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x34, 0x06, 0x40, 0x62, 0x1A, 0x1E, 0x20, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x78, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x20, 0x84, 0x10,
  0x80, 0x00, 0x10, 0x06, 0x01, 0x80, 0x60, 0x08, 0x03, 0x00, 0xC0, 0x06,
  0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x40, 0x7F, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x20, 0x01, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x10, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x00, 0x80, 0x00, 0x1E, 0x10, 0x90, 0x28, 0x18, 0x0C, 0x04, 0x02,
  0x01, 0x01, 0x00, 0x80, 0x80, 0x80, 0x80, 0x80, 0x40, 0x40, 0x20, 0x00,
  0x00, 0x00, 0x00, 0x02, 0x01, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0x80, 0x80,
  0x18, 0x01, 0x00, 0x80, 0x02, 0x04, 0x00, 0x04, 0x30, 0x00, 0x10, 0x80,
  0x00, 0x44, 0x07, 0x81, 0x10, 0x21, 0x04, 0x81, 0x04, 0x12, 0x08, 0x10,
  0x50, 0x20, 0x41, 0x41, 0x02, 0x05, 0x04, 0x08, 0x14, 0x20, 0x20, 0x60,
  0x80, 0x82, 0x82, 0x04, 0x0A, 0x08, 0x10, 0x28, 0x20, 0xC1, 0x20, 0x83,
  0x04, 0x82, 0x14, 0x22, 0x07, 0x8F, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x06, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x02, 0x40, 0x04, 0x80,
  0x11, 0x00, 0x22, 0x00, 0x84, 0x01, 0x08, 0x04, 0x10, 0x08, 0x20, 0x20,
  0x20, 0x40, 0x40, 0x80, 0x82, 0x01, 0x07, 0xFE, 0x10, 0x04, 0x20, 0x08,
  0x80, 0x09, 0x00, 0x14, 0x00, 0x28, 0x00, 0x60, 0x00, 0x80, 0x0F, 0xF0,
  0x10, 0x10, 0x20, 0x10, 0x80, 0x21, 0x00, 0x42, 0x00, 0x84, 0x01, 0x08,
  0x02, 0x10, 0x04, 0x40, 0x10, 0x80, 0xC1, 0xFE, 0x02, 0x03, 0x04, 0x01,
  0x08, 0x02, 0x20, 0x04, 0x40, 0x08, 0x80, 0x11, 0x00, 0x22, 0x00, 0x84,
  0x01, 0x10, 0x0C, 0x3F, 0xE0, 0x00, 0x03, 0xF0, 0x08, 0x10, 0x20, 0x10,
  0x80, 0x22, 0x00, 0x24, 0x00, 0x50, 0x00, 0xA0, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x09, 0x00, 0x12, 0x00, 0x44, 0x00, 0x84, 0x02, 0x04, 0x08, 0x07,
  0xE0, 0x00, 0x0F, 0xF0, 0x08, 0x08, 0x08, 0x04, 0x10, 0x02, 0x10, 0x02,
  0x10, 0x01, 0x10, 0x01, 0x10, 0x01, 0x10, 0x01, 0x20, 0x02, 0x20, 0x02,
  0x20, 0x02, 0x20, 0x02, 0x20, 0x02, 0x20, 0x02, 0x40, 0x04, 0x40, 0x04,
  0x40, 0x04, 0x40, 0x08, 0x40, 0x10, 0x40, 0x20, 0x80, 0x40, 0xFF, 0x80,
  0x0F, 0xFF, 0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x3F, 0xF0,
  0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x00, 0xFF, 0xF0, 0x0F, 0xFF,
  0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x3F, 0xF8, 0x20, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80, 0x00, 0x01, 0xF0, 0x0C, 0x18,
  0x20, 0x08, 0x80, 0x11, 0x00, 0x24, 0x00, 0x48, 0x00, 0x10, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x0F, 0xD0, 0x00, 0xA0, 0x01,
  0x40, 0x02, 0x80, 0x05, 0x00, 0x12, 0x00, 0x22, 0x00, 0x44, 0x01, 0x84,
  0x0C, 0x07, 0xE0, 0x00, 0x08, 0x00, 0x42, 0x00, 0x20, 0x80, 0x08, 0x40,
  0x02, 0x10, 0x00, 0x84, 0x00, 0x21, 0x00, 0x08, 0x40, 0x04, 0x10, 0x01,
  0x08, 0x00, 0x42, 0x00, 0x10, 0xFF, 0xFC, 0x20, 0x01, 0x08, 0x00, 0x82,
  0x00, 0x21, 0x00, 0x08, 0x40, 0x02, 0x10, 0x00, 0x84, 0x00, 0x41, 0x00,
  0x10, 0x40, 0x04, 0x20, 0x01, 0x08, 0x00, 0x40, 0x11, 0x11, 0x11, 0x22,
  0x22, 0x22, 0x44, 0x44, 0x44, 0x88, 0x88, 0x80, 0x00, 0x04, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x80, 0x22, 0x01, 0x08, 0x04, 0x20, 0x10, 0x80, 0x81, 0x04, 0x03, 0xE0,
  0x00, 0x08, 0x01, 0x04, 0x01, 0x02, 0x01, 0x02, 0x01, 0x01, 0x01, 0x00,
  0x81, 0x00, 0x41, 0x00, 0x21, 0x80, 0x11, 0x80, 0x11, 0x80, 0x09, 0x80,
  0x05, 0x40, 0x03, 0x10, 0x01, 0x08, 0x00, 0x82, 0x00, 0x80, 0x80, 0x40,
  0x40, 0x20, 0x10, 0x10, 0x08, 0x08, 0x02, 0x04, 0x01, 0x04, 0x00, 0x42,
  0x00, 0x20, 0x08, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x3F, 0xF8, 0x08, 0x00,
  0x0C, 0x30, 0x00, 0x20, 0xC0, 0x01, 0x85, 0x00, 0x06, 0x14, 0x00, 0x28,
  0x50, 0x00, 0xA1, 0x20, 0x04, 0x84, 0x80, 0x24, 0x12, 0x00, 0x90, 0x88,
  0x04, 0x42, 0x20, 0x11, 0x08, 0x80, 0x84, 0x21, 0x02, 0x10, 0x84, 0x10,
  0x82, 0x10, 0x42, 0x10, 0x42, 0x08, 0x41, 0x08, 0x21, 0x02, 0x40, 0x84,
  0x09, 0x02, 0x10, 0x28, 0x10, 0x40, 0xA0, 0x42, 0x03, 0x01, 0x08, 0x04,
  0x04, 0x00, 0x08, 0x00, 0x43, 0x00, 0x10, 0xC0, 0x08, 0x50, 0x02, 0x12,
  0x00, 0x84, 0x80, 0x21, 0x10, 0x08, 0x44, 0x04, 0x11, 0x01, 0x08, 0x20,
  0x42, 0x08, 0x10, 0x82, 0x04, 0x20, 0x41, 0x08, 0x10, 0x82, 0x02, 0x21,
  0x00, 0x88, 0x40, 0x22, 0x10, 0x04, 0x84, 0x01, 0x21, 0x00, 0x30, 0x40,
  0x0C, 0x20, 0x03, 0x08, 0x00, 0x40, 0x03, 0xF0, 0x08, 0x10, 0x20, 0x10,
  0x80, 0x12, 0x00, 0x24, 0x00, 0x50, 0x00, 0xA0, 0x01, 0x40, 0x02, 0x80,
  0x05, 0x00, 0x0C, 0x00, 0x28, 0x00, 0x50, 0x00, 0xA0, 0x01, 0x40, 0x02,
  0x80, 0x09, 0x00, 0x12, 0x00, 0x24, 0x00, 0x84, 0x02, 0x04, 0x18, 0x07,
  0xC0, 0x00, 0x0F, 0xF0, 0x10, 0x18, 0x20, 0x18, 0x80, 0x11, 0x00, 0x22,
  0x00, 0x44, 0x00, 0x88, 0x01, 0x10, 0x02, 0x40, 0x08, 0x80, 0x21, 0x00,
  0x83, 0xFE, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x00, 0x03, 0xF0,
  0x08, 0x10, 0x20, 0x10, 0x80, 0x12, 0x00, 0x24, 0x00, 0x50, 0x00, 0xA0,
  0x01, 0x40, 0x02, 0x80, 0x05, 0x00, 0x0C, 0x00, 0x28, 0x00, 0x50, 0x00,
  0xA0, 0x01, 0x40, 0x02, 0x80, 0x09, 0x00, 0x12, 0x00, 0x44, 0x00, 0x84,
  0x02, 0x04, 0x08, 0x07, 0xE0, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x80, 0x0F, 0xF0, 0x10, 0x18, 0x20, 0x08, 0x80, 0x11, 0x00, 0x22, 0x00,
  0x44, 0x00, 0x88, 0x01, 0x10, 0x02, 0x40, 0x08, 0x80, 0x21, 0x00, 0x83,
  0xFE, 0x04, 0x08, 0x08, 0x10, 0x20, 0x10, 0x40, 0x20, 0x80, 0x41, 0x00,
  0x42, 0x00, 0x88, 0x01, 0x10, 0x01, 0x20, 0x02, 0x00, 0x01, 0xF0, 0x0C,
  0x18, 0x20, 0x10, 0x80, 0x11, 0x00, 0x24, 0x00, 0x48, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x04, 0x80, 0x09, 0x00, 0x12, 0x00, 0x24, 0x00, 0x84, 0x03,
  0x04, 0x0C, 0x07, 0xE0, 0x00, 0xFF, 0xFE, 0x02, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x00, 0x10, 0x01, 0x10, 0x01, 0x20, 0x02, 0x20, 0x02, 0x20, 0x02, 0x20,
  0x02, 0x20, 0x02, 0x20, 0x02, 0x40, 0x04, 0x40, 0x04, 0x40, 0x04, 0x40,
  0x04, 0x40, 0x04, 0x40, 0x04, 0x80, 0x08, 0x80, 0x08, 0x80, 0x08, 0x80,
  0x08, 0x80, 0x10, 0x80, 0x10, 0x40, 0x20, 0x60, 0xC0, 0x1F, 0x00, 0x80,
  0x03, 0x00, 0x0A, 0x00, 0x14, 0x00, 0x48, 0x00, 0x88, 0x02, 0x10, 0x04,
  0x20, 0x10, 0x40, 0x20, 0x80, 0x81, 0x01, 0x02, 0x02, 0x02, 0x08, 0x04,
  0x10, 0x08, 0x40, 0x10, 0x80, 0x22, 0x00, 0x44, 0x00, 0x90, 0x00, 0xA0,
  0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x00, 0x80, 0x10, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x14, 0x02, 0x80, 0x50, 0x0A, 0x01, 0x40, 0x48,
  0x09, 0x01, 0x10, 0x22, 0x04, 0x41, 0x08, 0x21, 0x04, 0x20, 0x84, 0x10,
  0x82, 0x10, 0x82, 0x10, 0x42, 0x08, 0x41, 0x10, 0x22, 0x04, 0x40, 0x88,
  0x11, 0x02, 0x20, 0x48, 0x09, 0x01, 0x20, 0x24, 0x05, 0x00, 0x50, 0x14,
  0x01, 0x80, 0x50, 0x06, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x00, 0x18,
  0x00, 0x84, 0x00, 0x82, 0x00, 0x80, 0x80, 0x40, 0x40, 0x40, 0x10, 0x40,
  0x08, 0x20, 0x04, 0x20, 0x01, 0x20, 0x00, 0xA0, 0x00, 0x30, 0x00, 0x10,
  0x00, 0x14, 0x00, 0x12, 0x00, 0x09, 0x00, 0x08, 0x40, 0x08, 0x20, 0x08,
  0x08, 0x04, 0x04, 0x04, 0x02, 0x04, 0x00, 0x82, 0x00, 0x42, 0x00, 0x10,
  0x80, 0x03, 0x00, 0x09, 0x00, 0x22, 0x00, 0x44, 0x01, 0x04, 0x04, 0x08,
  0x08, 0x10, 0x20, 0x10, 0x80, 0x21, 0x00, 0x44, 0x00, 0x50, 0x00, 0xA0,
  0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0xFF, 0xE0, 0x07, 0x82, 0x01,
  0x00, 0x80, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x04, 0x03, 0xC0, 0x84, 0x10, 0x84, 0x21,
  0x08, 0x41, 0x08, 0x42, 0x10, 0x84, 0x10, 0x84, 0x21, 0x08, 0x41, 0x08,
  0x07, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x04, 0x02, 0x01, 0x00, 0x83, 0xC0, 0x04,
  0x06, 0x0A, 0x0A, 0x12, 0x12, 0x21, 0x21, 0x41, 0x41, 0x81, 0x7F, 0xF0,
  0x44, 0x21, 0x03, 0xE0, 0x60, 0x84, 0x04, 0x20, 0x12, 0x00, 0x80, 0x08,
  0x00, 0x40, 0x02, 0x0F, 0xF0, 0x80, 0x88, 0x04, 0x80, 0x44, 0x02, 0x40,
  0x11, 0x01, 0x88, 0x34, 0x3E, 0x20, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x3C, 0x2C, 0x33, 0x01, 0x20, 0x12, 0x01,
  0x20, 0x14, 0x01, 0x40, 0x14, 0x01, 0x40, 0x14, 0x01, 0x40, 0x28, 0x02,
  0x80, 0x2C, 0x04, 0xA0, 0x89, 0xF0, 0x07, 0xC1, 0x82, 0x20, 0x22, 0x01,
  0x40, 0x14, 0x01, 0x40, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x28, 0x04, 0x40, 0x44, 0x18, 0x3E, 0x00, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x00, 0x81, 0xF2, 0x08, 0x28,
  0x40, 0x42, 0x01, 0x08, 0x04, 0x40, 0x11, 0x00, 0x44, 0x01, 0x10, 0x08,
  0x80, 0x22, 0x00, 0x88, 0x02, 0x20, 0x08, 0x80, 0x21, 0x01, 0x04, 0x1C,
  0x0F, 0x90, 0x07, 0xC1, 0x82, 0x10, 0x22, 0x01, 0x40, 0x14, 0x01, 0x40,
  0x1F, 0xFF, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x40,
  0x06, 0x08, 0x1F, 0x00, 0x03, 0x81, 0x00, 0x80, 0x20, 0x10, 0x04, 0x01,
  0x03, 0xF8, 0x10, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x03, 0xE4,
  0x30, 0x50, 0x81, 0x44, 0x02, 0x10, 0x08, 0x80, 0x22, 0x00, 0x88, 0x02,
  0x20, 0x11, 0x00, 0x44, 0x01, 0x10, 0x04, 0x40, 0x11, 0x00, 0x42, 0x02,
  0x08, 0x38, 0x1F, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x42, 0x01,
  0x04, 0x18, 0x0F, 0x80, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x3C, 0x24, 0x22, 0x81, 0x30, 0x12, 0x01, 0x20, 0x12,
  0x01, 0x40, 0x14, 0x01, 0x40, 0x24, 0x02, 0x40, 0x24, 0x02, 0x80, 0x28,
  0x02, 0x80, 0x48, 0x04, 0x08, 0xC0, 0x00, 0x00, 0x42, 0x21, 0x08, 0x42,
  0x11, 0x08, 0x42, 0x10, 0x88, 0x42, 0x00, 0x00, 0x40, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x08, 0x02, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x10, 0x38, 0x00, 0x08, 0x00, 0x40,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x02, 0x20, 0x21,
  0x02, 0x08, 0x20, 0x42, 0x02, 0x20, 0x12, 0x01, 0x20, 0x0E, 0x80, 0x44,
  0x02, 0x10, 0x10, 0x80, 0x82, 0x08, 0x10, 0x40, 0x42, 0x02, 0x10, 0x08,
  0x08, 0x42, 0x21, 0x08, 0x42, 0x11, 0x08, 0x42, 0x10, 0x88, 0x42, 0x10,
  0x84, 0x42, 0x10, 0x23, 0xC1, 0xF1, 0x21, 0x10, 0x4A, 0x05, 0x02, 0x60,
  0x30, 0x12, 0x01, 0x00, 0x90, 0x08, 0x05, 0x00, 0x40, 0x28, 0x02, 0x01,
  0x40, 0x20, 0x0A, 0x01, 0x00, 0x50, 0x08, 0x04, 0x80, 0x40, 0x28, 0x02,
  0x01, 0x40, 0x10, 0x0A, 0x01, 0x00, 0x50, 0x08, 0x02, 0x80, 0x40, 0x20,
  0x13, 0xC2, 0x42, 0x28, 0x13, 0x01, 0x20, 0x12, 0x01, 0x20, 0x14, 0x01,
  0x40, 0x14, 0x02, 0x40, 0x24, 0x02, 0x40, 0x28, 0x02, 0x80, 0x28, 0x04,
  0x80, 0x40, 0x07, 0xC0, 0x82, 0x10, 0x12, 0x01, 0x20, 0x14, 0x01, 0x40,
  0x14, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x02, 0x80, 0x28, 0x02, 0x40,
  0x46, 0x08, 0x1F, 0x00, 0x09, 0xE0, 0xB0, 0x86, 0x02, 0x20, 0x11, 0x00,
  0x88, 0x04, 0x80, 0x24, 0x01, 0x20, 0x09, 0x00, 0x48, 0x02, 0x40, 0x24,
  0x01, 0x20, 0x09, 0x80, 0x8A, 0x08, 0x4F, 0x82, 0x00, 0x10, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x07, 0xC8, 0xC1, 0x44, 0x04,
  0x40, 0x22, 0x01, 0x20, 0x09, 0x00, 0x48, 0x02, 0x40, 0x24, 0x01, 0x20,
  0x09, 0x00, 0x48, 0x02, 0x40, 0x11, 0x01, 0x08, 0x38, 0x3E, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x13, 0x92,
  0x0A, 0x06, 0x02, 0x01, 0x00, 0x80, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x00, 0x0F, 0x82, 0x08, 0x80, 0x90, 0x14,
  0x00, 0x40, 0x08, 0x00, 0xC0, 0x07, 0x00, 0x10, 0x01, 0x00, 0x20, 0x05,
  0x00, 0xA0, 0x22, 0x08, 0x3E, 0x00, 0x10, 0x20, 0x40, 0x8F, 0xC4, 0x08,
  0x10, 0x20, 0x41, 0x02, 0x04, 0x08, 0x10, 0x20, 0x81, 0x02, 0x04, 0x07,
  0x00, 0x20, 0x14, 0x01, 0x40, 0x14, 0x02, 0x40, 0x24, 0x02, 0x80, 0x28,
  0x02, 0x80, 0x48, 0x04, 0x80, 0x48, 0x04, 0x80, 0x48, 0x0C, 0x81, 0x8C,
  0x28, 0x7C, 0x80, 0x80, 0x28, 0x02, 0x80, 0x48, 0x04, 0x40, 0x44, 0x08,
  0x40, 0x84, 0x10, 0x41, 0x04, 0x20, 0x22, 0x02, 0x40, 0x24, 0x02, 0x80,
  0x28, 0x01, 0x00, 0x10, 0x00, 0x80, 0x80, 0xC0, 0xC0, 0x60, 0x60, 0x50,
  0x30, 0x28, 0x28, 0x14, 0x14, 0x12, 0x11, 0x09, 0x08, 0x88, 0x88, 0x44,
  0x44, 0x24, 0x24, 0x12, 0x12, 0x09, 0x09, 0x05, 0x05, 0x02, 0x82, 0x81,
  0x80, 0x80, 0xC0, 0x40, 0x20, 0x00, 0x08, 0x04, 0x20, 0x20, 0x81, 0x01,
  0x04, 0x04, 0x20, 0x09, 0x00, 0x28, 0x00, 0x60, 0x01, 0x00, 0x0A, 0x00,
  0x48, 0x01, 0x20, 0x08, 0x40, 0x41, 0x02, 0x02, 0x08, 0x08, 0x40, 0x10,
  0x10, 0x02, 0x20, 0x08, 0x40, 0x10, 0x40, 0x40, 0x80, 0x81, 0x02, 0x02,
  0x04, 0x04, 0x10, 0x08, 0x20, 0x10, 0x80, 0x11, 0x00, 0x24, 0x00, 0x48,
  0x00, 0xA0, 0x01, 0x40, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x40, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x70, 0x00, 0x1F, 0xF8, 0x00,
  0x80, 0x08, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x00, 0xFF,
  0xE0, 0x00, 0x40, 0x60, 0x10, 0x08, 0x04, 0x01, 0x00, 0x40, 0x10, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x04, 0x01, 0x00, 0x80, 0xC0, 0x18, 0x02,
  0x00, 0x40, 0x10, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x01, 0x00, 0x20, 0x08, 0x44, 0x21, 0x08, 0x42, 0x21, 0x08,
  0x42, 0x10, 0x88, 0x42, 0x10, 0x84, 0x42, 0x10, 0x84, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x08, 0x02, 0x00, 0x80, 0x10, 0x04, 0x00, 0xC0, 0x40, 0x20, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x08, 0x02, 0x00, 0x80, 0x20, 0x10, 0x08, 0x06,
  0x02, 0x00, 0x3C, 0x02, 0x84, 0x09, 0x04, 0x14, 0x04, 0x48, 0x07, 0x00,
};

const GFXglyph RobotoCondensed_ThinItalic32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 5, 23, 6, 1, -23 },
  { 16, 5, 6, 8, 4, -24 },
  { 20, 17, 23, 15, 0, -23 },
  { 69, 13, 29, 15, 1, -26 },
  { 117, 15, 23, 20, 3, -23 },
  { 161, 14, 23, 17, 1, -23 },
  { 202, 2, 6, 5, 3, -24 },
  { 204, 8, 32, 8, 2, -25 },
  { 236, 9, 32, 9, -2, -25 },
  { 272, 12, 12, 13, 2, -23 },
  { 290, 13, 17, 15, 1, -19 },
  { 318, 3, 6, 6, -1, -2 },
  { 321, 6, 1, 8, 1, -11 },
  { 322, 2, 2, 7, 1, -2 },
  { 323, 13, 25, 11, -1, -23 },
  { 364, 12, 23, 15, 2, -23 },
  { 399, 7, 23, 15, 4, -23 },
  { 420, 13, 23, 15, 1, -23 },
  { 458, 13, 23, 15, 1, -23 },
  { 496, 13, 23, 15, 1, -23 },
  { 534, 13, 23, 15, 2, -23 },
  { 572, 12, 23, 15, 1, -23 },
  { 607, 12, 23, 15, 3, -23 },
  { 642, 14, 23, 15, 1, -23 },
  { 683, 12, 23, 15, 2, -23 },
  { 718, 5, 17, 6, 0, -17 },
  { 729, 6, 21, 5, -1, -17 },
  { 745, 12, 13, 14, 1, -17 },
  { 765, 12, 7, 15, 2, -14 },
  { 776, 12, 13, 14, 1, -17 },
  { 796, 9, 23, 12, 3, -23 },
  { 822, 22, 29, 25, 1, -22 },
  { 902, 15, 23, 16, -1, -23 },
  { 946, 15, 23, 17, 1, -23 },
  { 990, 15, 23, 18, 2, -23 },
  { 1034, 16, 23, 18, 1, -23 },
  { 1080, 16, 23, 16, 1, -23 },
  { 1126, 16, 23, 16, 1, -23 },
  { 1172, 15, 23, 19, 2, -23 },
  { 1216, 18, 23, 19, 1, -23 },
  { 1268, 4, 23, 7, 2, -23 },
  { 1280, 14, 23, 15, 1, -23 },
  { 1321, 17, 23, 17, 1, -23 },
  { 1370, 11, 23, 14, 1, -23 },
  { 1402, 22, 23, 23, 1, -23 },
  { 1466, 18, 23, 19, 1, -23 },
  { 1518, 15, 23, 18, 2, -23 },
  { 1562, 15, 23, 16, 1, -23 },
  { 1606, 15, 27, 18, 2, -23 },
  { 1657, 15, 23, 18, 1, -23 },
  { 1701, 15, 23, 16, 1, -23 },
  { 1745, 15, 23, 16, 3, -23 },
  { 1789, 16, 23, 18, 2, -23 },
  { 1835, 15, 23, 16, 3, -23 },
  { 1879, 22, 23, 24, 3, -23 },
  { 1943, 17, 23, 16, 0, -23 },
  { 1992, 15, 23, 16, 3, -23 },
  { 2036, 17, 23, 16, 0, -23 },
  { 2085, 9, 31, 6, 0, -26 },
  { 2120, 5, 25, 11, 3, -23 },
  { 2136, 9, 31, 6, -2, -26 },
  { 2171, 8, 11, 12, 2, -23 },
  { 2182, 12, 1, 12, -2, 0 },
  { 2184, 4, 4, 8, 4, -24 },
  { 2186, 13, 17, 15, 0, -17 },
  { 2214, 12, 24, 15, 1, -24 },
  { 2250, 12, 17, 14, 1, -17 },
  { 2276, 14, 24, 15, 1, -24 },
  { 2318, 12, 17, 14, 1, -17 },
  { 2344, 10, 24, 9, 2, -24 },
  { 2374, 14, 24, 15, 0, -17 },
  { 2416, 12, 24, 15, 1, -24 },
  { 2452, 5, 23, 6, 1, -23 },
  { 2467, 10, 30, 6, -4, -23 },
  { 2505, 13, 24, 13, 1, -24 },
  { 2544, 5, 24, 6, 1, -24 },
  { 2559, 21, 17, 24, 1, -17 },
  { 2604, 12, 17, 15, 1, -17 },
  { 2630, 12, 17, 15, 1, -17 },
  { 2656, 13, 24, 15, 0, -17 },
  { 2695, 13, 24, 15, 1, -17 },
  { 2734, 9, 17, 9, 1, -17 },
  { 2754, 11, 17, 14, 1, -17 },
  { 2778, 7, 21, 9, 2, -21 },
  { 2797, 12, 17, 15, 2, -17 },
  { 2823, 12, 17, 13, 2, -17 },
  { 2849, 17, 17, 21, 3, -17 },
  { 2886, 14, 17, 13, -1, -17 },
  { 2916, 15, 24, 13, -1, -17 },
  { 2961, 13, 17, 13, 0, -17 },
  { 2989, 10, 32, 9, 1, -25 },
  { 3029, 5, 27, 6, 1, -23 },
  { 3046, 10, 32, 9, -2, -25 },
  { 3086, 15, 5, 19, 2, -12 },
};

const GFXfont RobotoCondensed_ThinItalic32pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ThinItalic32pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ThinItalic32pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _ROBOTOCONDENSED_THINITALIC32PT7B_H_
