#ifndef _ROBOTOCONDENSED_THINITALIC36PT7B_H_
#define _ROBOTOCONDENSED_THINITALIC36PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ThinItalic.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ThinItalic36pt7bBitmaps[] PROGMEM = {
  0x00, 0x08, 0x42, 0x10, 0x88, 0x42, 0x10, 0x84, 0x42, 0x10, 0x84, 0x22,
  0x10, 0x00, 0x00, 0x00, 0x84, 0x00, 0x45, 0x24, 0x92, 0x8A, 0x28, 0x80,
  0x00, 0x41, 0x00, 0x10, 0x40, 0x04, 0x10, 0x02, 0x08, 0x00, 0x82, 0x00,
  0x20, 0x80, 0x10, 0x40, 0xFF, 0xFF, 0x01, 0x04, 0x00, 0x82, 0x00, 0x20,
  0x80, 0x08, 0x20, 0x04, 0x10, 0x01, 0x04, 0x00, 0x41, 0x00, 0x20, 0x80,
  0x08, 0x20, 0x02, 0x08, 0x0F, 0xFF, 0xE0, 0x41, 0x00, 0x10, 0x40, 0x04,
  0x10, 0x02, 0x08, 0x00, 0x82, 0x00, 0x20, 0x80, 0x10, 0x40, 0x00, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x0F, 0x80, 0x20, 0xC0, 0x80, 0x82, 0x00,
  0x84, 0x01, 0x10, 0x02, 0x20, 0x04, 0x40, 0x08, 0x80, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x90, 0x01, 0x20, 0x02, 0x40, 0x04, 0x40, 0x08, 0x80, 0x21,
  0x80, 0xC1, 0x83, 0x00, 0xF8, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x0E,
  0x00, 0x18, 0x80, 0x08, 0x20, 0x08, 0x10, 0x24, 0x08, 0x22, 0x04, 0x32,
  0x04, 0x11, 0x02, 0x10, 0x81, 0x10, 0x21, 0x08, 0x11, 0x88, 0x07, 0x88,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x3C, 0x06, 0x22, 0x02, 0x20, 0x82,
  0x10, 0x42, 0x10, 0x21, 0x08, 0x11, 0x04, 0x09, 0x02, 0x04, 0x81, 0x04,
  0x00, 0x82, 0x00, 0x62, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x03, 0x18, 0x02,
  0x08, 0x04, 0x08, 0x04, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x10, 0x04,
  0x20, 0x04, 0x40, 0x05, 0x80, 0x03, 0x00, 0x06, 0x00, 0x09, 0x00, 0x10,
  0x80, 0x20, 0x81, 0x60, 0x41, 0x40, 0x42, 0x40, 0x22, 0x80, 0x24, 0x80,
  0x14, 0x80, 0x18, 0xC0, 0x18, 0x40, 0x24, 0x20, 0x44, 0x1F, 0x82, 0x56,
  0xA8, 0x00, 0x40, 0x20, 0x10, 0x08, 0x04, 0x01, 0x00, 0x80, 0x20, 0x10,
  0x04, 0x02, 0x00, 0x80, 0x20, 0x10, 0x04, 0x01, 0x00, 0x40, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x01, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0x10, 0x00,
  0x04, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x10, 0x04,
  0x02, 0x00, 0x80, 0x40, 0x10, 0x08, 0x04, 0x02, 0x00, 0x01, 0x80, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x03, 0x84, 0x71, 0xAE, 0x01, 0xC0, 0x05,
  0x00, 0x34, 0x01, 0x88, 0x04, 0x30, 0x20, 0x41, 0x01, 0x80, 0x00, 0x80,
  0x02, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x02, 0x03, 0xFF, 0xF0, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x00, 0x12, 0x22, 0x64, 0x80,
  0xFE, 0xF0, 0x00, 0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00,
  0x40, 0x02, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x01,
  0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x80, 0x02,
  0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x01, 0xE0, 0x18, 0x40, 0x80, 0x84, 0x02, 0x10, 0x04,
  0x80, 0x12, 0x00, 0x48, 0x01, 0x40, 0x05, 0x00, 0x14, 0x00, 0x50, 0x02,
  0x40, 0x0A, 0x00, 0x28, 0x00, 0xA0, 0x02, 0x80, 0x0A, 0x00, 0x48, 0x01,
  0x20, 0x04, 0x80, 0x22, 0x00, 0x88, 0x04, 0x10, 0x30, 0x61, 0x80, 0xF8,
  0x00, 0x02, 0x0E, 0x72, 0x82, 0x02, 0x02, 0x04, 0x04, 0x04, 0x04, 0x04,
  0x04, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x20, 0x20, 0x01, 0xF0, 0x0C, 0x10, 0x10, 0x10, 0x40, 0x21, 0x00,
  0x42, 0x00, 0x44, 0x01, 0x10, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20,
  0x00, 0xC0, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x80, 0x06,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x30, 0x00,
  0xC0, 0x01, 0xFF, 0xF0, 0x01, 0xF0, 0x04, 0x18, 0x10, 0x10, 0x40, 0x11,
  0x00, 0x22, 0x00, 0x44, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x20, 0x01, 0x80, 0x3C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x12, 0x00, 0x24, 0x00, 0x48, 0x00, 0x90, 0x01, 0x10, 0x04, 0x30,
  0x10, 0x30, 0x40, 0x3F, 0x00, 0x00, 0x04, 0x00, 0x18, 0x00, 0x50, 0x00,
  0xA0, 0x02, 0x80, 0x09, 0x00, 0x22, 0x00, 0x44, 0x01, 0x08, 0x04, 0x10,
  0x08, 0x40, 0x20, 0x80, 0x81, 0x03, 0x02, 0x04, 0x04, 0x10, 0x08, 0x60,
  0x20, 0x80, 0x43, 0xFF, 0xF8, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x07, 0xFE, 0x08, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x9F, 0x01, 0xC1, 0x02, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x24, 0x00, 0x88, 0x01, 0x10, 0x02, 0x10,
  0x08, 0x20, 0x30, 0x20, 0xC0, 0x3E, 0x00, 0x00, 0x78, 0x0C, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x02, 0x3E, 0x12,
  0x08, 0xA0, 0x26, 0x01, 0x60, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x05, 0x00, 0x28, 0x01, 0x40, 0x12, 0x00, 0x88, 0x08, 0x20, 0x80,
  0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00,
  0x40, 0x02, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x01,
  0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x00,
  0x01, 0xF0, 0x04, 0x18, 0x10, 0x18, 0x40, 0x11, 0x80, 0x22, 0x00, 0x44,
  0x00, 0x88, 0x01, 0x10, 0x02, 0x20, 0x08, 0x60, 0x20, 0x61, 0x80, 0x3C,
  0x01, 0x86, 0x0C, 0x06, 0x10, 0x04, 0x40, 0x0D, 0x00, 0x0A, 0x00, 0x14,
  0x00, 0x48, 0x00, 0x90, 0x01, 0x20, 0x04, 0x20, 0x10, 0x20, 0xC0, 0x3F,
  0x00, 0x07, 0xC0, 0xC1, 0x0C, 0x04, 0x40, 0x24, 0x00, 0xA0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x28, 0x03, 0x40, 0x1B,
  0x01, 0x4C, 0x32, 0x3E, 0x20, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x0C, 0x07, 0x80, 0x00, 0x08, 0x60, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x0C, 0x00, 0x04,
  0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x82, 0x08, 0x41, 0x08, 0x00, 0x00, 0x08, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x06,
  0x00, 0x0C, 0x00, 0x10, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFE, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0x40, 0x00, 0x0F, 0x82, 0x18, 0x81, 0x20, 0x14, 0x03, 0x00,
  0x40, 0x08, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x0C, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x1C, 0x0E, 0x00, 0x10,
  0x01, 0x80, 0x30, 0x00, 0x40, 0x30, 0x00, 0x10, 0x10, 0x00, 0x08, 0x10,
  0x00, 0x02, 0x10, 0x0F, 0x01, 0x08, 0x18, 0x40, 0x88, 0x18, 0x30, 0x44,
  0x08, 0x10, 0x24, 0x08, 0x08, 0x12, 0x04, 0x04, 0x09, 0x04, 0x04, 0x05,
  0x02, 0x02, 0x02, 0x81, 0x01, 0x01, 0x41, 0x00, 0x81, 0x20, 0x80, 0x80,
  0xA0, 0x40, 0x40, 0x50, 0x20, 0x20, 0x28, 0x10, 0x30, 0x24, 0x08, 0x18,
  0x12, 0x04, 0x14, 0x11, 0x02, 0x12, 0x10, 0x80, 0xF0, 0xF0, 0x20, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x0A, 0x00, 0x05, 0x00, 0x02, 0x80, 0x02, 0x40, 0x01,
  0x20, 0x01, 0x10, 0x00, 0x88, 0x00, 0x82, 0x00, 0x41, 0x00, 0x40, 0x80,
  0x20, 0x40, 0x20, 0x20, 0x10, 0x10, 0x10, 0x08, 0x08, 0x04, 0x08, 0x01,
  0x07, 0xFF, 0x84, 0x00, 0x42, 0x00, 0x21, 0x00, 0x11, 0x00, 0x08, 0x80,
  0x04, 0x80, 0x01, 0x40, 0x00, 0xC0, 0x00, 0x40, 0x07, 0xF8, 0x08, 0x06,
  0x08, 0x03, 0x08, 0x01, 0x08, 0x01, 0x08, 0x01, 0x08, 0x01, 0x10, 0x01,
  0x10, 0x01, 0x10, 0x02, 0x10, 0x04, 0x10, 0x08, 0x1F, 0xF0, 0x20, 0x08,
  0x20, 0x04, 0x20, 0x02, 0x20, 0x02, 0x20, 0x02, 0x20, 0x02, 0x40, 0x02,
  0x40, 0x02, 0x40, 0x04, 0x40, 0x04, 0x40, 0x08, 0x40, 0x30, 0xFF, 0xC0,
  0x00, 0xFC, 0x01, 0x83, 0x01, 0x00, 0x41, 0x00, 0x21, 0x00, 0x08, 0x80,
  0x04, 0x80, 0x02, 0x40, 0x01, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x90, 0x00, 0x48, 0x00, 0x42, 0x00, 0x21, 0x00,
  0x20, 0xC0, 0x20, 0x30, 0x20, 0x07, 0xE0, 0x00, 0x07, 0xF8, 0x02, 0x01,
  0x80, 0x80, 0x10, 0x20, 0x02, 0x08, 0x00, 0x82, 0x00, 0x20, 0x80, 0x04,
  0x40, 0x01, 0x10, 0x00, 0x44, 0x00, 0x11, 0x00, 0x08, 0x40, 0x02, 0x10,
  0x00, 0x88, 0x00, 0x22, 0x00, 0x08, 0x80, 0x02, 0x20, 0x01, 0x08, 0x00,
  0x42, 0x00, 0x11, 0x00, 0x08, 0x40, 0x02, 0x10, 0x01, 0x04, 0x00, 0xC1,
  0x00, 0x60, 0x40, 0x60, 0x3F, 0xE0, 0x00, 0x07, 0xFF, 0xC2, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x1F, 0xFC,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC2, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x1F, 0xFC, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x00, 0x00, 0xFC, 0x00, 0xC0, 0xC0, 0x60, 0x10,
  0x20, 0x02, 0x08, 0x00, 0x84, 0x00, 0x21, 0x00, 0x04, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x04, 0x07, 0xF1, 0x00, 0x04, 0x40, 0x01, 0x20, 0x00, 0x48, 0x00, 0x11,
  0x00, 0x08, 0x40, 0x02, 0x10, 0x00, 0x84, 0x00, 0x20, 0x80, 0x30, 0x10,
  0x38, 0x03, 0xF0, 0x00, 0x04, 0x00, 0x10, 0x80, 0x01, 0x08, 0x00, 0x20,
  0x80, 0x02, 0x08, 0x00, 0x20, 0x80, 0x02, 0x08, 0x00, 0x21, 0x00, 0x02,
  0x10, 0x00, 0x41, 0x00, 0x04, 0x10, 0x00, 0x41, 0x00, 0x04, 0x1F, 0xFF,
  0xC2, 0x00, 0x04, 0x20, 0x00, 0x82, 0x00, 0x08, 0x20, 0x00, 0x82, 0x00,
  0x08, 0x20, 0x00, 0x84, 0x00, 0x08, 0x40, 0x01, 0x04, 0x00, 0x10, 0x40,
  0x01, 0x04, 0x00, 0x10, 0x40, 0x01, 0x08, 0x00, 0x10, 0x08, 0x42, 0x10,
  0x88, 0x42, 0x10, 0x84, 0x42, 0x10, 0x84, 0x42, 0x10, 0x84, 0x22, 0x10,
  0x84, 0x00, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x44, 0x00, 0x88, 0x01, 0x10, 0x04, 0x20, 0x08, 0x60, 0x20, 0x60,
  0x80, 0x7E, 0x00, 0x04, 0x00, 0x61, 0x00, 0x18, 0x20, 0x06, 0x04, 0x01,
  0x80, 0x80, 0x60, 0x10, 0x18, 0x02, 0x06, 0x00, 0x81, 0x80, 0x10, 0x60,
  0x02, 0x08, 0x00, 0x42, 0x00, 0x08, 0x80, 0x01, 0x30, 0x00, 0x49, 0x00,
  0x0A, 0x20, 0x01, 0x82, 0x00, 0x20, 0x40, 0x04, 0x04, 0x00, 0x80, 0x80,
  0x20, 0x08, 0x04, 0x01, 0x00, 0x80, 0x10, 0x10, 0x03, 0x02, 0x00, 0x20,
  0x40, 0x06, 0x10, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0F, 0xFF, 0x04, 0x00, 0x01, 0x02,
  0x00, 0x01, 0x82, 0x80, 0x00, 0xC1, 0x40, 0x00, 0xA0, 0xA0, 0x00, 0x50,
  0x50, 0x00, 0x48, 0x28, 0x00, 0x28, 0x24, 0x00, 0x24, 0x11, 0x00, 0x12,
  0x08, 0x80, 0x11, 0x04, 0x40, 0x08, 0x82, 0x20, 0x08, 0x41, 0x10, 0x04,
  0x41, 0x04, 0x04, 0x20, 0x82, 0x02, 0x10, 0x41, 0x02, 0x08, 0x20, 0x81,
  0x04, 0x10, 0x41, 0x02, 0x08, 0x21, 0x82, 0x08, 0x08, 0x81, 0x04, 0x04,
  0x80, 0x82, 0x02, 0x40, 0x41, 0x01, 0x40, 0x20, 0x80, 0xA0, 0x10, 0x40,
  0x20, 0x10, 0x40, 0x10, 0x08, 0x00, 0x04, 0x00, 0x10, 0xC0, 0x01, 0x0A,
  0x00, 0x10, 0xA0, 0x02, 0x0A, 0x00, 0x20, 0x90, 0x02, 0x09, 0x00, 0x21,
  0x88, 0x02, 0x10, 0x80, 0x21, 0x08, 0x04, 0x10, 0x40, 0x41, 0x04, 0x04,
  0x10, 0x20, 0x43, 0x02, 0x04, 0x20, 0x20, 0x42, 0x01, 0x08, 0x20, 0x10,
  0x82, 0x01, 0x08, 0x20, 0x08, 0x84, 0x00, 0x88, 0x40, 0x04, 0x84, 0x00,
  0x50, 0x40, 0x05, 0x04, 0x00, 0x30, 0x40, 0x03, 0x08, 0x00, 0x10, 0x00,
  0xFC, 0x01, 0x83, 0x01, 0x00, 0x41, 0x00, 0x21, 0x00, 0x08, 0x80, 0x04,
  0x80, 0x02, 0x40, 0x01, 0x20, 0x00, 0xA0, 0x00, 0x50, 0x00, 0x28, 0x00,
  0x14, 0x00, 0x0A, 0x00, 0x0A, 0x00, 0x05, 0x00, 0x02, 0x80, 0x01, 0x40,
  0x00, 0xA0, 0x00, 0x90, 0x00, 0x48, 0x00, 0x64, 0x00, 0x21, 0x00, 0x20,
  0xC0, 0x20, 0x30, 0x60, 0x07, 0xC0, 0x00, 0x07, 0xFC, 0x04, 0x01, 0x02,
  0x00, 0x41, 0x00, 0x10, 0x80, 0x08, 0x40, 0x04, 0x20, 0x02, 0x20, 0x01,
  0x10, 0x00, 0x88, 0x00, 0x44, 0x00, 0x42, 0x00, 0x61, 0x00, 0x61, 0x00,
  0x60, 0xFF, 0xC0, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x00, 0x00, 0xFC, 0x01, 0x83, 0x01, 0x00, 0x41, 0x00, 0x21,
  0x00, 0x08, 0x80, 0x04, 0x80, 0x02, 0x40, 0x01, 0x20, 0x00, 0xA0, 0x00,
  0x50, 0x00, 0x28, 0x00, 0x14, 0x00, 0x0A, 0x00, 0x0A, 0x00, 0x05, 0x00,
  0x02, 0x80, 0x01, 0x40, 0x00, 0xA0, 0x00, 0x90, 0x00, 0x48, 0x00, 0x44,
  0x00, 0x21, 0x00, 0x20, 0x80, 0x20, 0x30, 0x60, 0x07, 0xE0, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x07, 0xFC, 0x02,
  0x00, 0x80, 0x80, 0x10, 0x20, 0x02, 0x08, 0x00, 0x82, 0x00, 0x20, 0x80,
  0x08, 0x40, 0x02, 0x10, 0x00, 0x84, 0x00, 0x21, 0x00, 0x10, 0x40, 0x04,
  0x10, 0x02, 0x08, 0x03, 0x03, 0xFF, 0x00, 0x80, 0x80, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x01, 0x00, 0x20, 0x40, 0x08, 0x10, 0x02, 0x04, 0x00,
  0x41, 0x00, 0x10, 0x40, 0x04, 0x20, 0x00, 0x80, 0x00, 0xFC, 0x01, 0x81,
  0x01, 0x00, 0x41, 0x00, 0x21, 0x00, 0x08, 0x80, 0x04, 0x40, 0x02, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x20, 0x00,
  0x90, 0x00, 0x48, 0x00, 0x24, 0x00, 0x21, 0x00, 0x10, 0x80, 0x30, 0x30,
  0x30, 0x07, 0xE0, 0x00, 0xFF, 0xFF, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x44, 0x00,
  0x11, 0x00, 0x04, 0x40, 0x02, 0x10, 0x00, 0x84, 0x00, 0x22, 0x00, 0x08,
  0x80, 0x02, 0x20, 0x00, 0x88, 0x00, 0x42, 0x00, 0x10, 0x80, 0x04, 0x40,
  0x01, 0x10, 0x00, 0x44, 0x00, 0x11, 0x00, 0x08, 0x40, 0x02, 0x10, 0x00,
  0x88, 0x00, 0x22, 0x00, 0x08, 0x80, 0x04, 0x20, 0x01, 0x04, 0x00, 0x81,
  0x80, 0x40, 0x30, 0x60, 0x03, 0xF0, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x90,
  0x00, 0x48, 0x00, 0x44, 0x00, 0x22, 0x00, 0x21, 0x00, 0x10, 0x80, 0x08,
  0x40, 0x08, 0x10, 0x04, 0x08, 0x04, 0x04, 0x02, 0x02, 0x02, 0x01, 0x01,
  0x00, 0x81, 0x00, 0x40, 0x80, 0x10, 0x80, 0x08, 0x40, 0x04, 0x20, 0x02,
  0x20, 0x01, 0x10, 0x00, 0x90, 0x00, 0x48, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x18, 0x01, 0x40, 0x0C, 0x00, 0xA0, 0x06, 0x00,
  0x50, 0x05, 0x00, 0x48, 0x02, 0x80, 0x24, 0x02, 0x40, 0x12, 0x01, 0x20,
  0x11, 0x00, 0x90, 0x08, 0x80, 0x88, 0x08, 0x40, 0x42, 0x04, 0x20, 0x41,
  0x02, 0x10, 0x20, 0x82, 0x08, 0x10, 0x41, 0x04, 0x10, 0x20, 0x82, 0x08,
  0x10, 0x80, 0x88, 0x08, 0x40, 0x44, 0x04, 0x20, 0x22, 0x02, 0x20, 0x12,
  0x01, 0x10, 0x09, 0x00, 0x90, 0x05, 0x00, 0x48, 0x02, 0x80, 0x14, 0x01,
  0x40, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x20, 0x01, 0x00,
  0x00, 0x04, 0x00, 0x10, 0x40, 0x02, 0x02, 0x00, 0x60, 0x20, 0x04, 0x01,
  0x00, 0x80, 0x10, 0x10, 0x01, 0x01, 0x00, 0x08, 0x20, 0x00, 0x84, 0x00,
  0x04, 0xC0, 0x00, 0x48, 0x00, 0x05, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00,
  0x00, 0x50, 0x00, 0x09, 0x00, 0x01, 0x08, 0x00, 0x10, 0x80, 0x02, 0x04,
  0x00, 0x40, 0x40, 0x0C, 0x04, 0x00, 0x80, 0x20, 0x10, 0x02, 0x02, 0x00,
  0x10, 0x20, 0x01, 0x04, 0x00, 0x10, 0x40, 0x00, 0xA0, 0x00, 0x90, 0x00,
  0xCC, 0x00, 0x42, 0x00, 0x41, 0x00, 0x60, 0xC0, 0x20, 0x20, 0x20, 0x10,
  0x30, 0x08, 0x10, 0x02, 0x10, 0x01, 0x18, 0x00, 0x88, 0x00, 0x28, 0x00,
  0x14, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0xC0,
  0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xC0, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x3E, 0x00, 0x84,
  0x21, 0x08, 0x41, 0x08, 0x42, 0x10, 0x84, 0x10, 0x84, 0x21, 0x08, 0x41,
  0x08, 0x42, 0x10, 0x82, 0x10, 0x07, 0x80, 0x40, 0x20, 0x10, 0x08, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x40, 0x20, 0x10, 0x78, 0x00, 0x02, 0x00, 0xC0, 0x50,
  0x14, 0x09, 0x02, 0x41, 0x08, 0x42, 0x20, 0x88, 0x24, 0x09, 0x02, 0x80,
  0x80, 0xFF, 0xF8, 0xC4, 0x62, 0x30, 0x01, 0xF0, 0x18, 0x20, 0x80, 0x44,
  0x01, 0x10, 0x04, 0x40, 0x10, 0x00, 0x40, 0x01, 0x07, 0xFC, 0x60, 0x23,
  0x00, 0x98, 0x02, 0x40, 0x09, 0x00, 0x24, 0x01, 0x10, 0x0C, 0x40, 0x51,
  0x82, 0x41, 0xF1, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x11, 0xF0, 0x58, 0x21, 0x80, 0xC4,
  0x01, 0x20, 0x04, 0x80, 0x12, 0x00, 0x48, 0x01, 0x20, 0x05, 0x00, 0x14,
  0x00, 0x50, 0x02, 0x40, 0x09, 0x00, 0x24, 0x01, 0x10, 0x04, 0xC0, 0x22,
  0xC1, 0x08, 0xF8, 0x00, 0x03, 0xE0, 0x30, 0x41, 0x00, 0x8C, 0x02, 0x20,
  0x09, 0x00, 0x24, 0x00, 0x90, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x48, 0x01, 0x20, 0x08, 0x40, 0x60, 0x83, 0x01,
  0xF0, 0x00, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x03, 0xE2, 0x0C, 0x14, 0x18, 0x0C,
  0x10, 0x0C, 0x20, 0x04, 0x20, 0x04, 0x40, 0x04, 0x40, 0x08, 0x40, 0x08,
  0x40, 0x08, 0x40, 0x08, 0x40, 0x08, 0x80, 0x10, 0x80, 0x10, 0x40, 0x10,
  0x40, 0x10, 0x40, 0x30, 0x20, 0xD0, 0x1F, 0x20, 0x03, 0xE0, 0x30, 0x41,
  0x00, 0x8C, 0x02, 0x20, 0x09, 0x00, 0x24, 0x00, 0x90, 0x02, 0xFF, 0xFA,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x40, 0x20, 0x81, 0x01, 0xF8, 0x00, 0x01, 0xE0, 0x40, 0x10, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x7F, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x00, 0x01, 0xF1, 0x06, 0x0A,
  0x08, 0x06, 0x08, 0x06, 0x10, 0x02, 0x10, 0x02, 0x20, 0x04, 0x20, 0x04,
  0x20, 0x04, 0x20, 0x04, 0x20, 0x04, 0x20, 0x04, 0x40, 0x08, 0x40, 0x08,
  0x40, 0x08, 0x20, 0x08, 0x20, 0x18, 0x10, 0x68, 0x0F, 0x90, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x40, 0x60, 0x60, 0xC0, 0x1F, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00,
  0x04, 0x00, 0x11, 0xF0, 0x48, 0x21, 0x40, 0x86, 0x01, 0x30, 0x04, 0xC0,
  0x12, 0x00, 0x48, 0x02, 0x20, 0x08, 0x80, 0x24, 0x00, 0x90, 0x02, 0x40,
  0x09, 0x00, 0x44, 0x01, 0x10, 0x04, 0x80, 0x12, 0x00, 0x48, 0x02, 0x00,
  0x0C, 0x30, 0x00, 0x00, 0x00, 0x04, 0x10, 0x41, 0x04, 0x20, 0x82, 0x08,
  0x20, 0x84, 0x10, 0x41, 0x04, 0x10, 0x82, 0x00, 0x00, 0x30, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0xF0, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x0C, 0x40, 0x61, 0x03, 0x04, 0x18, 0x20, 0x80, 0x84, 0x02, 0x20,
  0x09, 0x00, 0x2C, 0x00, 0xD0, 0x06, 0x20, 0x10, 0x80, 0x41, 0x01, 0x04,
  0x04, 0x08, 0x10, 0x30, 0x80, 0x42, 0x01, 0x88, 0x02, 0x00, 0x04, 0x20,
  0x82, 0x08, 0x20, 0x84, 0x10, 0x41, 0x04, 0x10, 0x82, 0x08, 0x20, 0x82,
  0x10, 0x41, 0x04, 0x10, 0x42, 0x08, 0x00, 0x11, 0xF0, 0x3C, 0x12, 0x08,
  0xC2, 0x14, 0x09, 0x01, 0x28, 0x06, 0x01, 0x30, 0x04, 0x01, 0x30, 0x04,
  0x01, 0x20, 0x08, 0x01, 0x20, 0x08, 0x01, 0x20, 0x08, 0x01, 0x40, 0x08,
  0x01, 0x40, 0x08, 0x02, 0x40, 0x08, 0x02, 0x40, 0x10, 0x02, 0x40, 0x10,
  0x02, 0x40, 0x10, 0x02, 0x80, 0x10, 0x04, 0x80, 0x10, 0x04, 0x80, 0x10,
  0x04, 0x80, 0x20, 0x04, 0x11, 0xF0, 0x48, 0x21, 0x40, 0x86, 0x01, 0x30,
  0x04, 0xC0, 0x12, 0x00, 0x48, 0x02, 0x20, 0x08, 0x80, 0x24, 0x00, 0x90,
  0x02, 0x40, 0x09, 0x00, 0x44, 0x01, 0x10, 0x04, 0x80, 0x12, 0x00, 0x48,
  0x02, 0x00, 0x03, 0xE0, 0x30, 0x61, 0x80, 0x84, 0x01, 0x20, 0x04, 0x80,
  0x14, 0x00, 0x50, 0x01, 0x40, 0x05, 0x00, 0x14, 0x00, 0x60, 0x02, 0x80,
  0x0A, 0x00, 0x24, 0x01, 0x10, 0x04, 0x40, 0x20, 0x83, 0x01, 0xF8, 0x00,
  0x08, 0xF8, 0x16, 0x08, 0x30, 0x18, 0x40, 0x11, 0x00, 0x22, 0x00, 0x44,
  0x00, 0x88, 0x01, 0x10, 0x02, 0x40, 0x04, 0x80, 0x09, 0x00, 0x22, 0x00,
  0x44, 0x00, 0x88, 0x02, 0x30, 0x04, 0x60, 0x10, 0xB0, 0x41, 0x1F, 0x02,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x00, 0x03, 0xE2, 0x18, 0x28, 0x60, 0x30, 0x80, 0x62, 0x00, 0x44, 0x00,
  0x90, 0x02, 0x20, 0x04, 0x40, 0x08, 0x80, 0x11, 0x00, 0x22, 0x00, 0x48,
  0x01, 0x10, 0x02, 0x20, 0x04, 0x20, 0x08, 0x40, 0x30, 0x41, 0xA0, 0x7C,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40,
  0x00, 0x80, 0x11, 0xC5, 0x81, 0x80, 0x60, 0x30, 0x0C, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x80, 0x20,
  0x08, 0x00, 0x07, 0xC0, 0xC1, 0x84, 0x04, 0x40, 0x12, 0x00, 0x90, 0x00,
  0x80, 0x02, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00,
  0x12, 0x00, 0x90, 0x04, 0x80, 0x42, 0x04, 0x0F, 0xC0, 0x08, 0x08, 0x08,
  0x10, 0x10, 0xFF, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20, 0x20, 0x20, 0x40,
  0x40, 0x40, 0x40, 0x40, 0x40, 0x80, 0x40, 0x40, 0x78, 0x20, 0x04, 0x80,
  0x22, 0x00, 0x88, 0x02, 0x40, 0x09, 0x00, 0x24, 0x01, 0x10, 0x04, 0x40,
  0x12, 0x00, 0x48, 0x01, 0x20, 0x04, 0x80, 0x22, 0x00, 0x88, 0x02, 0x20,
  0x18, 0x80, 0xA1, 0x04, 0x83, 0xE4, 0x00, 0x80, 0x0C, 0x00, 0x50, 0x04,
  0x80, 0x24, 0x02, 0x20, 0x11, 0x01, 0x08, 0x08, 0x20, 0x81, 0x04, 0x08,
  0x40, 0x42, 0x02, 0x20, 0x11, 0x00, 0x50, 0x02, 0x80, 0x18, 0x00, 0xC0,
  0x04, 0x00, 0x80, 0x40, 0x18, 0x06, 0x02, 0x80, 0xA0, 0x28, 0x0A, 0x06,
  0x80, 0xA0, 0x48, 0x12, 0x04, 0x81, 0x20, 0x88, 0x22, 0x08, 0x42, 0x21,
  0x04, 0x42, 0x10, 0x44, 0x23, 0x04, 0x82, 0x20, 0x48, 0x22, 0x04, 0x81,
  0x40, 0x50, 0x14, 0x05, 0x01, 0x40, 0x60, 0x18, 0x06, 0x01, 0x80, 0x40,
  0x10, 0x00, 0x08, 0x02, 0x08, 0x02, 0x04, 0x04, 0x04, 0x08, 0x02, 0x10,
  0x02, 0x10, 0x01, 0x20, 0x01, 0x40, 0x01, 0x80, 0x00, 0x80, 0x01, 0x80,
  0x02, 0x40, 0x04, 0x40, 0x04, 0x20, 0x08, 0x20, 0x10, 0x30, 0x20, 0x10,
  0x20, 0x10, 0x40, 0x08, 0x10, 0x01, 0x08, 0x01, 0x08, 0x02, 0x08, 0x02,
  0x08, 0x04, 0x08, 0x04, 0x08, 0x08, 0x04, 0x08, 0x04, 0x10, 0x04, 0x10,
  0x04, 0x20, 0x04, 0x20, 0x04, 0x40, 0x02, 0x40, 0x02, 0x80, 0x02, 0x80,
  0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x30, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x10, 0x04, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x02, 0x00, 0x40, 0x10, 0x04, 0x03, 0x00, 0x10, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x02, 0x00, 0x08, 0x42, 0x10, 0x84,
  0x42, 0x10, 0x84, 0x23, 0x10, 0x84, 0x21, 0x08, 0x84, 0x21, 0x08, 0x42,
  0x21, 0x08, 0x42, 0x00, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x10, 0x01, 0x80, 0xC0, 0x10, 0x04, 0x00, 0x80,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x00, 0x1E, 0x00, 0x90, 0x80, 0x90, 0x20,
  0x48, 0x10, 0x24, 0x04, 0x24, 0x01, 0xE0,
};

const GFXglyph RobotoCondensed_ThinItalic36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 5, 26, 7, 1, -26 },
  { 18, 6, 7, 9, 4, -27 },
  { 24, 18, 26, 17, 1, -26 },
  { 83, 15, 32, 17, 1, -29 },
  { 143, 17, 26, 23, 3, -26 },
  { 199, 16, 26, 19, 1, -26 },
  { 251, 2, 7, 6, 4, -27 },
  { 253, 10, 37, 10, 2, -29 },
  { 300, 10, 36, 10, -2, -28 },
  { 345, 14, 14, 15, 2, -26 },
  { 370, 14, 19, 17, 2, -21 },
  { 404, 4, 7, 7, -1, -3 },
  { 408, 7, 1, 9, 1, -12 },
  { 409, 2, 2, 8, 1, -2 },
  { 410, 14, 28, 12, -1, -26 },
  { 459, 14, 26, 17, 2, -26 },
  { 505, 8, 26, 17, 5, -26 },
  { 531, 15, 26, 17, 1, -26 },
  { 580, 15, 26, 17, 1, -26 },
  { 629, 15, 26, 17, 1, -26 },
  { 678, 15, 26, 17, 2, -26 },
  { 727, 13, 26, 17, 2, -26 },
  { 770, 14, 26, 17, 3, -26 },
  { 816, 15, 26, 17, 1, -26 },
  { 865, 13, 26, 17, 3, -26 },
  { 908, 6, 19, 6, 0, -19 },
  { 923, 6, 23, 6, -1, -19 },
  { 941, 13, 14, 16, 2, -19 },
  { 964, 13, 8, 17, 2, -16 },
  { 977, 13, 14, 16, 1, -19 },
  { 1000, 11, 26, 14, 3, -26 },
  { 1036, 25, 33, 28, 1, -25 },
  { 1140, 17, 26, 18, -1, -26 },
  { 1196, 16, 26, 19, 1, -26 },
  { 1248, 17, 26, 20, 2, -26 },
  { 1304, 18, 26, 20, 1, -26 },
  { 1363, 18, 26, 18, 1, -26 },
  { 1422, 18, 26, 18, 1, -26 },
  { 1481, 18, 26, 21, 2, -26 },
  { 1540, 20, 26, 21, 1, -26 },
  { 1605, 5, 26, 8, 2, -26 },
  { 1622, 15, 26, 17, 1, -26 },
  { 1671, 19, 26, 19, 1, -26 },
  { 1733, 12, 26, 16, 1, -26 },
  { 1772, 25, 26, 26, 1, -26 },
  { 1854, 20, 26, 22, 1, -26 },
  { 1919, 17, 26, 20, 2, -26 },
  { 1975, 17, 26, 19, 1, -26 },
  { 2031, 17, 31, 20, 2, -26 },
  { 2097, 18, 26, 20, 1, -26 },
  { 2156, 17, 26, 18, 1, -26 },
  { 2212, 16, 26, 18, 4, -26 },
  { 2264, 18, 26, 20, 2, -26 },
  { 2323, 17, 26, 18, 3, -26 },
  { 2379, 25, 26, 27, 4, -26 },
  { 2461, 20, 26, 18, -1, -26 },
  { 2526, 17, 26, 18, 3, -26 },
  { 2582, 19, 26, 18, 0, -26 },
  { 2644, 10, 34, 7, 0, -29 },
  { 2687, 5, 28, 12, 4, -26 },
  { 2705, 9, 34, 7, -2, -29 },
  { 2744, 10, 13, 13, 2, -26 },
  { 2761, 13, 1, 13, -2, 0 },
  { 2763, 4, 5, 9, 5, -27 },
  { 2766, 14, 19, 16, 0, -19 },
  { 2800, 14, 27, 17, 1, -27 },
  { 2848, 14, 19, 16, 1, -19 },
  { 2882, 16, 27, 17, 1, -27 },
  { 2936, 14, 19, 16, 1, -19 },
  { 2970, 11, 27, 10, 2, -27 },
  { 3008, 16, 26, 17, 0, -19 },
  { 3060, 14, 27, 17, 1, -27 },
  { 3108, 6, 26, 7, 1, -26 },
  { 3128, 12, 33, 7, -5, -26 },
  { 3178, 14, 27, 15, 1, -27 },
  { 3226, 6, 27, 7, 1, -27 },
  { 3247, 24, 19, 27, 1, -19 },
  { 3304, 14, 19, 17, 1, -19 },
  { 3338, 14, 19, 17, 1, -19 },
  { 3372, 15, 26, 17, 0, -19 },
  { 3421, 15, 26, 17, 1, -19 },
  { 3470, 10, 19, 11, 1, -19 },
  { 3494, 13, 19, 15, 1, -19 },
  { 3525, 8, 24, 10, 2, -24 },
  { 3549, 14, 19, 17, 2, -19 },
  { 3583, 13, 19, 15, 2, -19 },
  { 3614, 20, 19, 23, 3, -19 },
  { 3662, 16, 19, 15, -1, -19 },
  { 3700, 16, 26, 15, -1, -19 },
  { 3752, 14, 19, 15, 0, -19 },
  { 3786, 11, 36, 10, 1, -28 },
  { 3836, 5, 31, 7, 1, -26 },
  { 3856, 11, 36, 10, -2, -28 },
  { 3906, 17, 6, 21, 2, -14 },
};

const GFXfont RobotoCondensed_ThinItalic36pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ThinItalic36pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ThinItalic36pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _ROBOTOCONDENSED_THINITALIC36PT7B_H_
