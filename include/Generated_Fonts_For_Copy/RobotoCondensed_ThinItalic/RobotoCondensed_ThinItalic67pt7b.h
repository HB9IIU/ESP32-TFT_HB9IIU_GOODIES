#ifndef _ROBOTOCONDENSED_THINITALIC67PT7B_H_
#define _ROBOTOCONDENSED_THINITALIC67PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ThinItalic.ttf
// Size: 67pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ThinItalic67pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x60, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x04,
  0x00, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x40, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0x80, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x08, 0x03, 0x00,
  0x60, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x07, 0x80, 0x40, 0x00, 0x10, 0x66, 0x0C,
  0xC1, 0x98, 0x33, 0x0C, 0x61, 0x88, 0x33, 0x06, 0x60, 0xCC, 0x31, 0x86,
  0x20, 0xCC, 0x18, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x08, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x60, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x60, 0x0C,
  0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x60, 0x00, 0x00, 0x80, 0x18, 0x00, 0x00, 0x60, 0x04, 0x00, 0x00, 0x18,
  0x03, 0x00, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x20, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x18, 0x01, 0x00, 0x00,
  0x06, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x08, 0x00,
  0x00, 0x30, 0x06, 0x00, 0x00, 0x08, 0x01, 0x80, 0x00, 0x06, 0x00, 0x40,
  0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x40, 0x0C, 0x00, 0x00, 0x30, 0x02,
  0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x03, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x18, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x04,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x3F,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x06, 0x00, 0xC0, 0x00,
  0x01, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x08, 0x00, 0x00, 0x30, 0x06, 0x00,
  0x00, 0x08, 0x01, 0x80, 0x00, 0x06, 0x00, 0x40, 0x00, 0x01, 0x80, 0x30,
  0x00, 0x00, 0x40, 0x0C, 0x00, 0x00, 0x30, 0x02, 0x00, 0x00, 0x0C, 0x01,
  0x80, 0x00, 0x02, 0x00, 0x60, 0x00, 0x01, 0x80, 0x10, 0x00, 0x00, 0x60,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1E, 0x03, 0x80, 0x03,
  0x80, 0x1C, 0x00, 0x70, 0x00, 0xC0, 0x0E, 0x00, 0x06, 0x00, 0xC0, 0x00,
  0x60, 0x18, 0x00, 0x03, 0x01, 0x80, 0x00, 0x30, 0x30, 0x00, 0x03, 0x03,
  0x00, 0x00, 0x30, 0x30, 0x00, 0x03, 0x02, 0x00, 0x00, 0x30, 0x20, 0x00,
  0x03, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x40, 0x00, 0x01, 0x84, 0x00, 0x00,
  0x10, 0x40, 0x00, 0x03, 0x04, 0x00, 0x00, 0x30, 0x40, 0x00, 0x03, 0x06,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x06, 0x02, 0x00, 0x00, 0xC0, 0x30, 0x00,
  0x1C, 0x01, 0x80, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x00, 0xF0, 0x1E, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x07, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x06, 0x0C, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x18, 0x02, 0x00, 0x00,
  0x30, 0x03, 0x00, 0x00, 0x30, 0x03, 0x00, 0x10, 0x20, 0x03, 0x00, 0x18,
  0x60, 0x03, 0x00, 0x30, 0x60, 0x03, 0x00, 0x60, 0x40, 0x03, 0x00, 0x60,
  0x40, 0x02, 0x00, 0xC0, 0xC0, 0x02, 0x01, 0x80, 0xC0, 0x06, 0x01, 0x80,
  0xC0, 0x06, 0x03, 0x00, 0xC0, 0x04, 0x06, 0x00, 0xC0, 0x0C, 0x06, 0x00,
  0x40, 0x08, 0x0C, 0x00, 0x60, 0x18, 0x18, 0x00, 0x70, 0x30, 0x18, 0x00,
  0x3D, 0xE0, 0x30, 0x00, 0x1F, 0xC0, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x04, 0x03, 0xF0,
  0x00, 0x0C, 0x07, 0xBC, 0x00, 0x18, 0x0C, 0x0C, 0x00, 0x10, 0x18, 0x06,
  0x00, 0x30, 0x30, 0x06, 0x00, 0x60, 0x30, 0x02, 0x00, 0xC0, 0x60, 0x02,
  0x00, 0xC0, 0x60, 0x02, 0x01, 0x80, 0x40, 0x02, 0x03, 0x00, 0x40, 0x02,
  0x03, 0x00, 0xC0, 0x06, 0x06, 0x00, 0xC0, 0x06, 0x0C, 0x00, 0xC0, 0x06,
  0x0C, 0x00, 0xC0, 0x06, 0x18, 0x00, 0xC0, 0x0C, 0x30, 0x00, 0xC0, 0x0C,
  0x10, 0x00, 0xC0, 0x18, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x60, 0x30,
  0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xE0, 0xE0, 0x00,
  0x07, 0x01, 0xC0, 0x00, 0x18, 0x03, 0x00, 0x00, 0xC0, 0x04, 0x00, 0x02,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x60, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00,
  0x04, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x30, 0x00, 0xC0, 0x00, 0xC0, 0x06,
  0x00, 0x03, 0x00, 0x18, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x30, 0x06, 0x00,
  0x00, 0x40, 0x30, 0x00, 0x01, 0x81, 0x80, 0x00, 0x06, 0x0C, 0x00, 0x00,
  0x08, 0x60, 0x00, 0x00, 0x37, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x03, 0x18,
  0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x06, 0x03, 0x00,
  0x08, 0x30, 0x06, 0x00, 0x61, 0x80, 0x18, 0x01, 0x86, 0x00, 0x30, 0x06,
  0x30, 0x00, 0x60, 0x10, 0x80, 0x01, 0x80, 0xC6, 0x00, 0x03, 0x03, 0x18,
  0x00, 0x0C, 0x08, 0x40, 0x00, 0x18, 0x63, 0x00, 0x00, 0x61, 0x8C, 0x00,
  0x00, 0xCC, 0x30, 0x00, 0x01, 0xF0, 0xC0, 0x00, 0x07, 0x83, 0x00, 0x00,
  0x0C, 0x0E, 0x00, 0x00, 0x70, 0x18, 0x00, 0x03, 0x60, 0x60, 0x00, 0x19,
  0x80, 0xC0, 0x00, 0xC3, 0x01, 0x80, 0x06, 0x0C, 0x03, 0x80, 0xF0, 0x18,
  0x07, 0xFF, 0x00, 0x30, 0x03, 0xE0, 0x00, 0x00, 0x33, 0x33, 0x36, 0x66,
  0x66, 0x4C, 0xCC, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18,
  0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x08,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00,
  0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x38, 0x03, 0x00, 0xE7, 0x80, 0xC1, 0xF0, 0x7C, 0x31, 0xE0,
  0x03, 0xCB, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x31, 0x80, 0x00, 0x18, 0x30, 0x00, 0x0E,
  0x0C, 0x00, 0x07, 0x01, 0x80, 0x03, 0x80, 0x60, 0x00, 0xC0, 0x0C, 0x00,
  0x60, 0x03, 0x80, 0x30, 0x00, 0x60, 0x0C, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x0C, 0x18,
  0x70, 0xC1, 0x83, 0x0C, 0x18, 0x61, 0xC3, 0x04, 0x00, 0x7F, 0xFB, 0xFF,
  0xC0, 0x27, 0x76, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x70, 0x38, 0x00, 0x18, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x01, 0x80, 0x03, 0x00, 0x60, 0x00, 0x30, 0x0C,
  0x00, 0x06, 0x03, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x08, 0x18, 0x00, 0x01,
  0x03, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x06, 0x18, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x18, 0x40, 0x00, 0x03, 0x18, 0x00, 0x00, 0x63, 0x00, 0x00, 0x08,
  0x60, 0x00, 0x01, 0x08, 0x00, 0x00, 0x63, 0x00, 0x00, 0x0C, 0x60, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0x31, 0x80, 0x00, 0x06, 0x20, 0x00, 0x00, 0x84,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x06, 0x30, 0x00, 0x00, 0xC6, 0x00, 0x00,
  0x18, 0xC0, 0x00, 0x03, 0x10, 0x00, 0x00, 0x42, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x03, 0x18, 0x00, 0x00, 0x63, 0x00, 0x00, 0x08, 0x60, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x61, 0x80, 0x00, 0x08, 0x30, 0x00, 0x03, 0x06, 0x00,
  0x00, 0x60, 0x40, 0x00, 0x18, 0x0C, 0x00, 0x03, 0x01, 0x80, 0x00, 0xC0,
  0x30, 0x00, 0x38, 0x03, 0x00, 0x06, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x60, 0x00, 0x70, 0x38, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x04, 0x00, 0xF0, 0x0F, 0xC1, 0xE3, 0x1E, 0x0F, 0xE0, 0x2C, 0x00,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x10, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xF0, 0x1C, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x18, 0x01, 0x80, 0x01, 0x80, 0x60, 0x00, 0x30,
  0x18, 0x00, 0x03, 0x03, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x0C, 0x18, 0x00,
  0x01, 0x82, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x06, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1C, 0x07, 0x00, 0x03, 0x00, 0x18,
  0x00, 0x60, 0x00, 0xC0, 0x0C, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x60, 0x38,
  0x00, 0x06, 0x03, 0x00, 0x00, 0x20, 0x20, 0x00, 0x03, 0x06, 0x00, 0x00,
  0x30, 0x60, 0x00, 0x03, 0x04, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x10, 0xC0,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x02, 0x04, 0x00, 0x00,
  0x60, 0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x18, 0x03,
  0x80, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x00, 0xF0, 0x1C, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x68, 0x00, 0x00,
  0x1B, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x31, 0x80,
  0x00, 0x0C, 0x30, 0x00, 0x01, 0x84, 0x00, 0x00, 0x61, 0x80, 0x00, 0x18,
  0x30, 0x00, 0x02, 0x06, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x30, 0x18, 0x00,
  0x0C, 0x02, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x60, 0x18, 0x00, 0x18, 0x03,
  0x00, 0x07, 0x00, 0x60, 0x00, 0xC0, 0x0C, 0x00, 0x30, 0x01, 0x00, 0x0C,
  0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x18, 0x00, 0x30,
  0x07, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x80, 0x30, 0x00, 0x30, 0x0C, 0x00,
  0x06, 0x01, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x18, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x04, 0x1F, 0x80, 0x00, 0xCF, 0xFE, 0x00, 0x0F, 0x80, 0x38,
  0x00, 0xE0, 0x01, 0x80, 0x0C, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x08, 0x06, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x30, 0x06, 0x00, 0x03, 0x00, 0x30, 0x00, 0x60,
  0x01, 0x80, 0x0C, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0xF0,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x07, 0xE0, 0x06,
  0x0F, 0xFC, 0x03, 0x1C, 0x03, 0x81, 0x18, 0x00, 0xC1, 0x98, 0x00, 0x30,
  0xD8, 0x00, 0x18, 0x78, 0x00, 0x06, 0x38, 0x00, 0x03, 0x18, 0x00, 0x00,
  0x9C, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x36, 0x00, 0x00, 0x1B, 0x00, 0x00,
  0x0D, 0x00, 0x00, 0x06, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0x60, 0x00,
  0x01, 0xB0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x26, 0x00,
  0x00, 0x33, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x30,
  0x00, 0x0C, 0x0C, 0x00, 0x06, 0x06, 0x00, 0x06, 0x01, 0x80, 0x06, 0x00,
  0xE0, 0x06, 0x00, 0x3C, 0x0E, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xF0, 0x3C,
  0x00, 0x07, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x00, 0xC0,
  0x06, 0x00, 0x01, 0x80, 0x30, 0x00, 0x06, 0x01, 0x80, 0x00, 0x18, 0x06,
  0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x02, 0x03, 0x00,
  0x00, 0x18, 0x0C, 0x00, 0x00, 0x60, 0x30, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x04, 0x03, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x01, 0x80, 0x30, 0x00, 0x06,
  0x00, 0x60, 0x00, 0x30, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x0C, 0x00,
  0x07, 0x00, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x06, 0x00,
  0x01, 0x80, 0x30, 0x00, 0x06, 0x01, 0x80, 0x00, 0x0C, 0x06, 0x00, 0x00,
  0x30, 0x30, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x03, 0x06, 0x00, 0x00, 0x0C,
  0x18, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x03, 0x04,
  0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x60, 0x60, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x0C, 0x06, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x01, 0x80, 0x30, 0x00,
  0x0C, 0x00, 0x60, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x01, 0xC0, 0x78,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x7F, 0xF0, 0x00, 0xE0, 0x38, 0x01, 0x80, 0x1C, 0x03, 0x00, 0x0C,
  0x06, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x1C, 0x00, 0x03, 0x18, 0x00, 0x03,
  0x30, 0x00, 0x03, 0x30, 0x00, 0x03, 0x20, 0x00, 0x01, 0x60, 0x00, 0x01,
  0x60, 0x00, 0x01, 0x40, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x0E,
  0xC0, 0x00, 0x1E, 0x60, 0x00, 0x16, 0x60, 0x00, 0x36, 0x30, 0x00, 0x64,
  0x38, 0x01, 0xCC, 0x1C, 0x07, 0x8C, 0x0F, 0xFE, 0x0C, 0x03, 0xF8, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0x01, 0xC1, 0xE0, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0xF0, 0x70, 0x10, 0x00, 0x00, 0x60, 0x07, 0x00, 0xF0, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x06, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x03,
  0x80, 0x30, 0x06, 0x00, 0xE0, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x04, 0x00, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0x08, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x1F, 0xF0, 0x07, 0x01,
  0x80, 0xE0, 0x0C, 0x1C, 0x00, 0x61, 0x80, 0x06, 0x30, 0x00, 0x62, 0x00,
  0x02, 0x60, 0x00, 0x26, 0x00, 0x02, 0xC0, 0x00, 0x2C, 0x00, 0x02, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x20, 0x03, 0x80, 0x00, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x00, 0x00, 0x80, 0x70, 0x00, 0x1F,
  0x80, 0x01, 0x00, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0x03, 0x00, 0x07, 0x01,
  0x80, 0x06, 0x06, 0x00, 0x1C, 0x01, 0x80, 0x0C, 0x18, 0x00, 0x70, 0x03,
  0x00, 0x18, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x30, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x61, 0x80, 0x0C, 0x00, 0x10, 0x00, 0xC3, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x8C, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x18, 0x00, 0xC0, 0x01, 0x80,
  0x06, 0x20, 0x03, 0x00, 0x02, 0x00, 0x08, 0xC0, 0x06, 0x00, 0x0C, 0x00,
  0x11, 0x80, 0x08, 0x00, 0x18, 0x00, 0x63, 0x00, 0x30, 0x00, 0x30, 0x00,
  0xC4, 0x00, 0x60, 0x00, 0x40, 0x01, 0x98, 0x00, 0x80, 0x01, 0x80, 0x02,
  0x30, 0x03, 0x00, 0x03, 0x00, 0x0C, 0x60, 0x06, 0x00, 0x06, 0x00, 0x18,
  0x80, 0x0C, 0x00, 0x08, 0x00, 0x31, 0x00, 0x10, 0x00, 0x30, 0x00, 0x42,
  0x00, 0x60, 0x00, 0x60, 0x01, 0x8C, 0x00, 0xC0, 0x00, 0xC0, 0x03, 0x18,
  0x01, 0x80, 0x03, 0x00, 0x0C, 0x30, 0x03, 0x00, 0x06, 0x00, 0x18, 0x60,
  0x06, 0x00, 0x14, 0x00, 0x60, 0xC0, 0x0C, 0x00, 0x68, 0x00, 0xC1, 0x80,
  0x18, 0x00, 0x90, 0x03, 0x03, 0x00, 0x10, 0x02, 0x20, 0x0C, 0x06, 0x00,
  0x30, 0x1C, 0x60, 0x38, 0x04, 0x00, 0x70, 0x70, 0x60, 0xE0, 0x0C, 0x00,
  0x7F, 0x80, 0xFF, 0x00, 0x18, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x02, 0x80, 0x00, 0x00, 0x06,
  0x80, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x0C,
  0xC0, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x18, 0x40, 0x00, 0x00, 0x30,
  0x40, 0x00, 0x00, 0x30, 0x40, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x00, 0x40, 0x60, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x80,
  0x60, 0x00, 0x01, 0x80, 0x20, 0x00, 0x01, 0x00, 0x20, 0x00, 0x03, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x30, 0x00, 0x06, 0x00, 0x30, 0x00, 0x04, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x10, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x60, 0x00, 0x18, 0x00, 0x60, 0x00, 0x18, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0xC0, 0x00, 0x18, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFC, 0x01, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x0C, 0x02, 0x00, 0x00,
  0x0C, 0x06, 0x00, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00,
  0x04, 0x08, 0x00, 0x00, 0x04, 0x18, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00,
  0x06, 0x30, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00,
  0x06, 0x60, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x02, 0x00, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x60, 0x00, 0x38,
  0x01, 0x80, 0x00, 0x30, 0x06, 0x00, 0x00, 0xC0, 0x10, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x06, 0x03, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x20, 0x30,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x06, 0x02, 0x00, 0x00, 0x18, 0x18, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x01, 0x01, 0x80, 0x00, 0x0C, 0x06, 0x00, 0x00,
  0x30, 0x18, 0x00, 0x01, 0x80, 0x40, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x70,
  0x0C, 0x00, 0x03, 0x80, 0x30, 0x00, 0x38, 0x00, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0x00, 0x08, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x0E, 0x01, 0x80,
  0x00, 0x18, 0x06, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0xC0, 0x40, 0x00,
  0x01, 0x81, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x01, 0x83, 0x00, 0x00, 0x06, 0x08, 0x00, 0x00, 0x18,
  0x20, 0x00, 0x00, 0x41, 0x80, 0x00, 0x03, 0x06, 0x00, 0x00, 0x0C, 0x18,
  0x00, 0x00, 0x20, 0x60, 0x00, 0x01, 0x81, 0x00, 0x00, 0x0C, 0x0C, 0x00,
  0x00, 0x70, 0x30, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x1C, 0x03, 0x00, 0x01,
  0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x38, 0x03, 0x80, 0x01, 0xC0, 0x01,
  0x80, 0x07, 0x00, 0x01, 0x80, 0x18, 0x00, 0x03, 0x80, 0x60, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0x06, 0x03, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x0C,
  0x18, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x61,
  0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x02, 0x18, 0x00, 0x00, 0x0C,
  0x30, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x60, 0x40, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x03, 0x01, 0x80, 0x00, 0x06, 0x01, 0x00, 0x00, 0x18, 0x03,
  0x00, 0x00, 0x60, 0x03, 0x00, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x07,
  0x80, 0x78, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0x80, 0x01, 0xE0, 0x01,
  0x80, 0x00, 0x70, 0x01, 0x80, 0x00, 0x38, 0x01, 0x80, 0x00, 0x18, 0x01,
  0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x02, 0x03, 0x00, 0x00, 0x03, 0x02,
  0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x03, 0x06,
  0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x03, 0x04, 0x00, 0x00, 0x03, 0x04,
  0x00, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x06, 0x0C,
  0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x06, 0x08, 0x00, 0x00, 0x06, 0x08,
  0x00, 0x00, 0x04, 0x18, 0x00, 0x00, 0x04, 0x18, 0x00, 0x00, 0x0C, 0x18,
  0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x0C, 0x10,
  0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x18, 0x30,
  0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x30, 0x20, 0x00, 0x00, 0x30, 0x20,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x00, 0xC0, 0x60, 0x00, 0x01, 0x80, 0x40, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x38, 0x00, 0xC0,
  0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x08,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x08,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x06, 0x00,
  0xC0, 0x00, 0x06, 0x01, 0x80, 0x00, 0x03, 0x01, 0x80, 0x00, 0x03, 0x03,
  0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x01, 0x06,
  0x00, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x20,
  0x00, 0xFF, 0xFC, 0x60, 0x00, 0xFF, 0xFC, 0x60, 0x00, 0x00, 0x0C, 0x60,
  0x00, 0x00, 0x08, 0x60, 0x00, 0x00, 0x08, 0x60, 0x00, 0x00, 0x18, 0x40,
  0x00, 0x00, 0x18, 0x40, 0x00, 0x00, 0x18, 0x40, 0x00, 0x00, 0x18, 0x40,
  0x00, 0x00, 0x10, 0x40, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x30, 0x20, 0x00, 0x00, 0x30, 0x30,
  0x00, 0x00, 0x20, 0x30, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0xE0, 0x0C,
  0x00, 0x03, 0xC0, 0x0E, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x7C, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30,
  0x18, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x00, 0x20, 0x18, 0x00, 0x00,
  0x02, 0x01, 0x80, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x06, 0x01, 0x00,
  0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x00, 0x40,
  0x30, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00,
  0x0C, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x0C, 0x06, 0x00,
  0x00, 0x00, 0x80, 0x60, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x40, 0x00, 0x00, 0x18, 0x04, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00,
  0x10, 0x0C, 0x00, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x0F, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x08, 0x00, 0x00, 0x03, 0x01,
  0x80, 0x00, 0x00, 0x20, 0x18, 0x00, 0x00, 0x02, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x18, 0x00, 0x00, 0x06, 0x01, 0x00, 0x00, 0x00, 0x60, 0x10, 0x00,
  0x00, 0x06, 0x03, 0x00, 0x00, 0x00, 0x40, 0x30, 0x00, 0x00, 0x04, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x0C, 0x02, 0x00, 0x00, 0x00,
  0xC0, 0x20, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x00, 0x80, 0x60, 0x00,
  0x00, 0x08, 0x06, 0x00, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x18, 0x04,
  0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x01,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x02, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x40, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x08, 0x06, 0x01, 0x80, 0x60, 0x18, 0x04, 0x01, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x10, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x02, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x10, 0x00, 0x00, 0x80, 0x40, 0x00,
  0x06, 0x03, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x40, 0x10, 0x00, 0x03,
  0x00, 0x40, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x60, 0x06, 0x00, 0x03, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x03, 0x00, 0x01,
  0xE0, 0x38, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x00, 0x70,
  0x06, 0x00, 0x00, 0x38, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x60, 0x00, 0x0E,
  0x00, 0x10, 0x00, 0x07, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0x60,
  0x03, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x01,
  0x00, 0x60, 0x00, 0x00, 0x40, 0x30, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00,
  0x0C, 0x0C, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x00, 0xC3, 0xC0, 0x00,
  0x00, 0x21, 0xB0, 0x00, 0x00, 0x08, 0xC6, 0x00, 0x00, 0x06, 0x61, 0x80,
  0x00, 0x01, 0xB0, 0x30, 0x00, 0x00, 0x78, 0x0C, 0x00, 0x00, 0x1C, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x60, 0x00, 0x01, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x03, 0x80, 0x00, 0x30, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x20, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00,
  0x38, 0x03, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x30, 0x00,
  0x00, 0x30, 0x0C, 0x00, 0x00, 0x0E, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x00, 0x03, 0x80, 0x78,
  0x00, 0x00, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x1E, 0x00,
  0x00, 0x00, 0x0B, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xD8, 0x04, 0x80, 0x00,
  0x00, 0x04, 0x80, 0x66, 0x00, 0x00, 0x00, 0x6C, 0x03, 0x30, 0x00, 0x00,
  0x02, 0x60, 0x19, 0x80, 0x00, 0x00, 0x33, 0x00, 0xCC, 0x00, 0x00, 0x03,
  0x18, 0x06, 0x20, 0x00, 0x00, 0x18, 0xC0, 0x21, 0x00, 0x00, 0x01, 0x84,
  0x03, 0x0C, 0x00, 0x00, 0x0C, 0x60, 0x18, 0x60, 0x00, 0x00, 0xC3, 0x00,
  0xC3, 0x00, 0x00, 0x06, 0x18, 0x06, 0x18, 0x00, 0x00, 0x60, 0xC0, 0x20,
  0x40, 0x00, 0x03, 0x06, 0x01, 0x02, 0x00, 0x00, 0x30, 0x20, 0x18, 0x18,
  0x00, 0x01, 0x83, 0x00, 0xC0, 0xC0, 0x00, 0x18, 0x18, 0x06, 0x06, 0x00,
  0x00, 0x80, 0xC0, 0x30, 0x10, 0x00, 0x0C, 0x06, 0x01, 0x00, 0x80, 0x00,
  0x40, 0x30, 0x08, 0x06, 0x00, 0x06, 0x01, 0x00, 0xC0, 0x30, 0x00, 0x20,
  0x18, 0x06, 0x01, 0x80, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x00, 0x30, 0x06,
  0x01, 0x80, 0x20, 0x01, 0x80, 0x30, 0x08, 0x01, 0x00, 0x18, 0x01, 0x00,
  0x40, 0x0C, 0x00, 0xC0, 0x18, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x30,
  0x03, 0x00, 0x60, 0x06, 0x01, 0x80, 0x08, 0x06, 0x00, 0x30, 0x0C, 0x00,
  0x40, 0x30, 0x01, 0x80, 0x40, 0x03, 0x03, 0x00, 0x08, 0x02, 0x00, 0x18,
  0x18, 0x00, 0xC0, 0x30, 0x00, 0xC1, 0x80, 0x06, 0x01, 0x80, 0x02, 0x0C,
  0x00, 0x30, 0x0C, 0x00, 0x10, 0xC0, 0x01, 0x80, 0x60, 0x00, 0x86, 0x00,
  0x0C, 0x02, 0x00, 0x06, 0x60, 0x00, 0x40, 0x30, 0x00, 0x32, 0x00, 0x06,
  0x01, 0x80, 0x01, 0xB0, 0x00, 0x30, 0x0C, 0x00, 0x05, 0x00, 0x01, 0x80,
  0x60, 0x00, 0x38, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x10,
  0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x1C, 0x00,
  0x00, 0x03, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x1E, 0x00, 0x00, 0x03, 0x01,
  0xA0, 0x00, 0x00, 0x20, 0x1B, 0x00, 0x00, 0x06, 0x01, 0xB0, 0x00, 0x00,
  0x60, 0x31, 0x00, 0x00, 0x06, 0x03, 0x18, 0x00, 0x00, 0x60, 0x31, 0x80,
  0x00, 0x06, 0x03, 0x0C, 0x00, 0x00, 0x40, 0x30, 0xC0, 0x00, 0x0C, 0x03,
  0x04, 0x00, 0x00, 0xC0, 0x60, 0x60, 0x00, 0x0C, 0x06, 0x06, 0x00, 0x00,
  0xC0, 0x60, 0x20, 0x00, 0x0C, 0x06, 0x03, 0x00, 0x00, 0x80, 0x60, 0x10,
  0x00, 0x18, 0x04, 0x01, 0x80, 0x01, 0x80, 0xC0, 0x18, 0x00, 0x18, 0x0C,
  0x00, 0x80, 0x01, 0x80, 0xC0, 0x0C, 0x00, 0x18, 0x0C, 0x00, 0xC0, 0x03,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x08, 0x00, 0x60, 0x03, 0x01, 0x80, 0x02,
  0x00, 0x30, 0x18, 0x00, 0x30, 0x03, 0x01, 0x80, 0x03, 0x00, 0x30, 0x18,
  0x00, 0x18, 0x06, 0x01, 0x80, 0x01, 0x80, 0x60, 0x10, 0x00, 0x08, 0x06,
  0x03, 0x00, 0x00, 0xC0, 0x60, 0x30, 0x00, 0x0C, 0x06, 0x03, 0x00, 0x00,
  0x40, 0x40, 0x30, 0x00, 0x06, 0x0C, 0x03, 0x00, 0x00, 0x20, 0xC0, 0x20,
  0x00, 0x03, 0x0C, 0x06, 0x00, 0x00, 0x30, 0xC0, 0x60, 0x00, 0x01, 0x0C,
  0x06, 0x00, 0x00, 0x18, 0x80, 0x60, 0x00, 0x01, 0x98, 0x04, 0x00, 0x00,
  0x0D, 0x80, 0xC0, 0x00, 0x00, 0xD8, 0x0C, 0x00, 0x00, 0x05, 0x80, 0xC0,
  0x00, 0x00, 0x78, 0x0C, 0x00, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00,
  0x18, 0x00, 0xC0, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x0C, 0x01, 0x80, 0x00,
  0x06, 0x03, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x02, 0x0C, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x03, 0x08, 0x00, 0x00,
  0x03, 0x18, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x03, 0x10, 0x00, 0x00,
  0x03, 0x30, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x02, 0x30, 0x00, 0x00,
  0x02, 0x30, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00,
  0x06, 0x60, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x04, 0x60, 0x00, 0x00,
  0x04, 0x60, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x00,
  0x0C, 0xC0, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x00,
  0x18, 0xC0, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x18, 0x80, 0x00, 0x00,
  0x18, 0x80, 0x00, 0x00, 0x30, 0x80, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00,
  0xC0, 0x40, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x01, 0x80, 0x60, 0x00, 0x03,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x07, 0x00, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x06, 0x00, 0x03,
  0x80, 0x0C, 0x00, 0x01, 0x80, 0x18, 0x00, 0x01, 0x80, 0x30, 0x00, 0x03,
  0x80, 0x40, 0x00, 0x03, 0x01, 0x80, 0x00, 0x06, 0x03, 0x00, 0x00, 0x06,
  0x06, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x30,
  0x20, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x01, 0x03,
  0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x18, 0x10,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x03, 0x01, 0x80,
  0x00, 0x06, 0x03, 0x00, 0x00, 0x18, 0x04, 0x00, 0x00, 0x60, 0x08, 0x00,
  0x03, 0x80, 0x30, 0x00, 0x1E, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x80, 0x01, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x03, 0x80, 0x03, 0x00,
  0x03, 0x80, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x18,
  0x01, 0x80, 0x00, 0x06, 0x01, 0x80, 0x00, 0x03, 0x01, 0x80, 0x00, 0x01,
  0x80, 0xC0, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00,
  0x18, 0x20, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00,
  0x03, 0x08, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00,
  0x00, 0x43, 0x00, 0x00, 0x00, 0x21, 0x80, 0x00, 0x00, 0x30, 0x80, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x06, 0x30, 0x00,
  0x00, 0x02, 0x18, 0x00, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x01, 0x84, 0x00,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0x31, 0x80,
  0x00, 0x00, 0x10, 0xC0, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x0C, 0x30,
  0x00, 0x00, 0x06, 0x10, 0x00, 0x00, 0x02, 0x08, 0x00, 0x00, 0x03, 0x04,
  0x00, 0x00, 0x01, 0x83, 0x00, 0x00, 0x00, 0x81, 0x80, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x60, 0x10, 0x00, 0x00, 0x70,
  0x0C, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x70, 0x00, 0x0F, 0x00, 0xF0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0x98, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0xC0, 0x00, 0x70, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x80, 0x00, 0x06, 0x01, 0x80, 0x00, 0x06, 0x01,
  0x80, 0x00, 0x03, 0x01, 0x80, 0x00, 0x03, 0x01, 0x80, 0x00, 0x03, 0x01,
  0x80, 0x00, 0x03, 0x01, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x03, 0x03,
  0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x02, 0x03,
  0x00, 0x00, 0x06, 0x02, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x0C, 0x06,
  0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x30, 0x06,
  0x00, 0x00, 0x60, 0x04, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x03, 0x80, 0x0F,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x08,
  0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x06, 0x00, 0x18, 0x00, 0x06, 0x00, 0x10,
  0x00, 0x06, 0x00, 0x10, 0x00, 0x03, 0x00, 0x30, 0x00, 0x03, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x30, 0x00, 0x01, 0x80, 0x30, 0x00, 0x01, 0x80, 0x20,
  0x00, 0x01, 0x80, 0x20, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x60, 0x40,
  0x00, 0x00, 0x60, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x04, 0x01,
  0x80, 0x00, 0x06, 0x03, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x06, 0x02,
  0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x06, 0x06,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x01, 0x80, 0x70, 0x00, 0x03, 0x00, 0x38, 0x00, 0x06, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x20, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x30, 0x20, 0x00, 0x00, 0x10,
  0x30, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x06,
  0x06, 0x00, 0x00, 0x03, 0x02, 0x00, 0x00, 0x01, 0x81, 0x00, 0x00, 0x00,
  0x81, 0x80, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00,
  0x30, 0x30, 0x00, 0x00, 0x18, 0x10, 0x00, 0x00, 0x0C, 0x08, 0x00, 0x00,
  0x04, 0x0C, 0x00, 0x00, 0x02, 0x06, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x00, 0x20, 0x60, 0x00, 0x00, 0x10, 0x30, 0x00, 0x00, 0x18, 0x18, 0x00,
  0x00, 0x0C, 0x0C, 0x00, 0x00, 0x06, 0x04, 0x00, 0x00, 0x03, 0x06, 0x00,
  0x00, 0x01, 0x03, 0x00, 0x00, 0x00, 0x81, 0x80, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x30, 0x20, 0x00, 0x00, 0x18, 0x30,
  0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x06, 0x06,
  0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x60, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0xC0,
  0x06, 0x00, 0x00, 0xC0, 0x03, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x01, 0xC0,
  0x00, 0x3C, 0x03, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x00, 0x64, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0x03, 0x18, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x03, 0x01, 0x00, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x08, 0x06, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x60,
  0x18, 0x00, 0x01, 0x80, 0x30, 0x00, 0x03, 0x00, 0x20, 0x00, 0x0C, 0x00,
  0x40, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x60, 0x01, 0x80, 0x00, 0xC0, 0x03,
  0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x30, 0x00, 0x10, 0x00, 0x40, 0x00, 0x30, 0x01, 0x80, 0x00, 0x60,
  0x03, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x01, 0x80, 0x18, 0x00, 0x03, 0x00,
  0x60, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x06, 0x03, 0x00, 0x00, 0x0C, 0x06,
  0x00, 0x00, 0x18, 0x08, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x60, 0x40,
  0x00, 0x00, 0x41, 0x80, 0x00, 0x00, 0x82, 0x00, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0x03, 0x18, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x0C, 0xC0, 0x00,
  0x00, 0x1B, 0x00, 0x00, 0x00, 0x16, 0x00, 0x00, 0x00, 0x28, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xB0, 0x00, 0x01, 0x40, 0x00, 0x06, 0xC0, 0x00, 0x0D, 0x00, 0x00,
  0x1B, 0x00, 0x00, 0x24, 0x00, 0x00, 0xCC, 0x00, 0x01, 0x90, 0x00, 0x03,
  0x30, 0x00, 0x06, 0x60, 0x00, 0x08, 0xC0, 0x00, 0x11, 0x80, 0x00, 0x63,
  0x00, 0x00, 0xC6, 0x00, 0x01, 0x8C, 0x00, 0x02, 0x18, 0x00, 0x0C, 0x30,
  0x00, 0x18, 0x60, 0x00, 0x30, 0xC0, 0x00, 0x61, 0x80, 0x00, 0xC3, 0x00,
  0x01, 0x02, 0x00, 0x06, 0x04, 0x00, 0x0C, 0x08, 0x00, 0x18, 0x10, 0x00,
  0x20, 0x20, 0x00, 0x40, 0x40, 0x01, 0x80, 0x80, 0x03, 0x01, 0x80, 0x06,
  0x02, 0x00, 0x0C, 0x06, 0x00, 0x10, 0x0C, 0x00, 0x20, 0x18, 0x00, 0xC0,
  0x30, 0x01, 0x80, 0x60, 0x02, 0x00, 0xC0, 0x06, 0x01, 0x80, 0x18, 0x03,
  0x00, 0x30, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x00, 0x30,
  0x03, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x01, 0x00,
  0x60, 0x06, 0x01, 0x80, 0x04, 0x01, 0x00, 0x18, 0x06, 0x00, 0x10, 0x0C,
  0x00, 0x60, 0x30, 0x00, 0x60, 0x30, 0x01, 0x80, 0xC0, 0x01, 0x81, 0x80,
  0x02, 0x03, 0x00, 0x06, 0x06, 0x00, 0x08, 0x18, 0x00, 0x18, 0x18, 0x00,
  0x30, 0x60, 0x00, 0x60, 0xC0, 0x00, 0xC3, 0x00, 0x01, 0x83, 0x00, 0x03,
  0x0C, 0x00, 0x06, 0x08, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x60, 0x00, 0x31,
  0x80, 0x00, 0x61, 0x80, 0x00, 0xC6, 0x00, 0x00, 0x8C, 0x00, 0x03, 0x10,
  0x00, 0x02, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x08, 0xC0, 0x00, 0x33, 0x00,
  0x00, 0x36, 0x00, 0x00, 0xD8, 0x00, 0x00, 0xD8, 0x00, 0x03, 0x60, 0x00,
  0x03, 0x40, 0x00, 0x0D, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x07, 0x00, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x18, 0x00, 0xC0,
  0x00, 0x01, 0xC0, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x60, 0x00, 0x03, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x01, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x01,
  0x81, 0x80, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x03,
  0x02, 0x00, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x00, 0x18, 0x03, 0x00, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x40, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x30, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x00, 0x60, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x18, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00,
  0x01, 0x80, 0xE0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x1D, 0x80, 0x00,
  0x00, 0x33, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x03, 0x86, 0x00, 0x00,
  0x06, 0x0C, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x70, 0x18, 0x00, 0x00,
  0xC0, 0x30, 0x00, 0x03, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x18,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x03, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x38, 0x00, 0x06, 0x00, 0x60, 0x00,
  0x0C, 0x01, 0x80, 0x00, 0x08, 0x03, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00,
  0x30, 0x30, 0x00, 0x00, 0x20, 0x60, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xC0, 0x60, 0x30, 0x18, 0x04, 0x02, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x04, 0x02, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x04, 0x02,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x04, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x04, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x04, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x04, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x02, 0x40,
  0x03, 0x20, 0x01, 0x18, 0x01, 0x8C, 0x00, 0x86, 0x00, 0xC3, 0x00, 0x40,
  0x80, 0x60, 0x40, 0x20, 0x30, 0x30, 0x18, 0x10, 0x0C, 0x18, 0x06, 0x08,
  0x03, 0x0C, 0x00, 0x84, 0x00, 0x66, 0x00, 0x32, 0x00, 0x1B, 0x00, 0x0D,
  0x00, 0x07, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x60, 0xC0,
  0xC1, 0x81, 0x83, 0x83, 0x03, 0x06, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xFF,
  0x00, 0x07, 0x80, 0xE0, 0x03, 0x00, 0x0C, 0x01, 0x80, 0x01, 0x00, 0xC0,
  0x00, 0x60, 0x60, 0x00, 0x18, 0x18, 0x00, 0x02, 0x04, 0x00, 0x00, 0x83,
  0x00, 0x00, 0x20, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x1F,
  0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x3C, 0x00, 0x30, 0x38, 0x00, 0x0C, 0x1C,
  0x00, 0x02, 0x0E, 0x00, 0x00, 0x83, 0x00, 0x00, 0x61, 0x80, 0x00, 0x18,
  0x60, 0x00, 0x06, 0x10, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x43, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x1C, 0x30, 0x00, 0x07, 0x0C, 0x00, 0x03, 0xC3, 0x00,
  0x01, 0xB0, 0x60, 0x01, 0xCC, 0x1C, 0x00, 0xE3, 0x03, 0x80, 0xE0, 0xC0,
  0x7F, 0xF0, 0x30, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x1E, 0x00, 0x08, 0x3F, 0xF0, 0x02,
  0x3C, 0x0E, 0x01, 0x98, 0x00, 0xC0, 0x6C, 0x00, 0x18, 0x1E, 0x00, 0x06,
  0x07, 0x00, 0x00, 0x81, 0x80, 0x00, 0x30, 0xE0, 0x00, 0x0C, 0x30, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x20,
  0x00, 0x03, 0x18, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x31, 0x80, 0x00, 0x0C,
  0x60, 0x00, 0x02, 0x10, 0x00, 0x00, 0x84, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x18, 0xC0, 0x00, 0x06, 0x30, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x42, 0x00,
  0x00, 0x30, 0x80, 0x00, 0x0C, 0x60, 0x00, 0x02, 0x18, 0x00, 0x01, 0x86,
  0x00, 0x00, 0x61, 0x80, 0x00, 0x30, 0x60, 0x00, 0x0C, 0x1C, 0x00, 0x06,
  0x0D, 0x80, 0x03, 0x03, 0x30, 0x01, 0x80, 0xC7, 0x01, 0xC0, 0x30, 0xFF,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xFC, 0x00,
  0x3C, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x30, 0x00, 0x70, 0x30, 0x00, 0x18,
  0x18, 0x00, 0x0C, 0x18, 0x00, 0x03, 0x08, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0x66, 0x00, 0x00, 0x33, 0x00, 0x00, 0x19, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x02, 0x30, 0x00, 0x03, 0x18, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x82,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x40, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x60,
  0x1C, 0x00, 0x60, 0x07, 0x80, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x3E, 0x03, 0x00, 0x0F, 0xFC, 0x18, 0x00,
  0xE0, 0x30, 0xC0, 0x1C, 0x00, 0xE6, 0x01, 0xC0, 0x01, 0x20, 0x0C, 0x00,
  0x0D, 0x00, 0xC0, 0x00, 0x38, 0x04, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x06,
  0x02, 0x00, 0x00, 0x30, 0x30, 0x00, 0x01, 0x01, 0x80, 0x00, 0x18, 0x08,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x06, 0x06, 0x00, 0x00, 0x30, 0x30, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x08, 0x08, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x06,
  0x06, 0x00, 0x00, 0x30, 0x30, 0x00, 0x01, 0x81, 0x80, 0x00, 0x08, 0x0C,
  0x00, 0x00, 0x40, 0x60, 0x00, 0x06, 0x03, 0x00, 0x00, 0x30, 0x10, 0x00,
  0x01, 0x80, 0x80, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x40, 0x30, 0x00, 0x02,
  0x01, 0x80, 0x00, 0x30, 0x0C, 0x00, 0x03, 0x80, 0x30, 0x00, 0x3C, 0x01,
  0x80, 0x03, 0x60, 0x06, 0x00, 0x32, 0x00, 0x38, 0x0F, 0x30, 0x00, 0x7F,
  0xE1, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xFC,
  0x00, 0x1C, 0x07, 0x00, 0x38, 0x00, 0xC0, 0x38, 0x00, 0x70, 0x38, 0x00,
  0x18, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0xC4, 0x00, 0x00, 0x66, 0x00, 0x00, 0x33, 0x00, 0x00, 0x19, 0x00,
  0x00, 0x0D, 0x80, 0x00, 0x06, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x20,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00,
  0x38, 0x0C, 0x00, 0x38, 0x03, 0x80, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0xFF, 0x00, 0x1C, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x02,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7F, 0xE0, 0xC0, 0x0F, 0x01, 0x86, 0x00, 0xE0, 0x07,
  0x30, 0x0E, 0x00, 0x19, 0x00, 0x60, 0x00, 0x78, 0x06, 0x00, 0x01, 0xC0,
  0x20, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x30, 0x10, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x08, 0x0C, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x30, 0x30, 0x00, 0x01, 0x81, 0x80, 0x00, 0x0C, 0x08, 0x00, 0x00, 0x40,
  0x40, 0x00, 0x06, 0x06, 0x00, 0x00, 0x30, 0x30, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x0C, 0x0C, 0x00, 0x00, 0x60, 0x60, 0x00, 0x02, 0x03, 0x00, 0x00,
  0x30, 0x10, 0x00, 0x01, 0x80, 0x80, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x60,
  0x20, 0x00, 0x03, 0x01, 0x80, 0x00, 0x10, 0x0C, 0x00, 0x01, 0x80, 0x60,
  0x00, 0x1C, 0x01, 0x00, 0x01, 0xE0, 0x0C, 0x00, 0x1B, 0x00, 0x30, 0x01,
  0x90, 0x01, 0xC0, 0x78, 0x80, 0x03, 0xFF, 0x0C, 0x00, 0x07, 0xC0, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x04, 0x00, 0x03, 0x00, 0x30, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x80,
  0x03, 0x80, 0x78, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x03, 0xC0, 0x04,
  0x0F, 0xF8, 0x02, 0x1C, 0x06, 0x03, 0x1C, 0x01, 0x81, 0x98, 0x00, 0x60,
  0xD8, 0x00, 0x30, 0x68, 0x00, 0x18, 0x2C, 0x00, 0x0C, 0x14, 0x00, 0x02,
  0x1C, 0x00, 0x01, 0x0E, 0x00, 0x00, 0x86, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x31, 0x80, 0x00, 0x18, 0xC0, 0x00, 0x0C, 0x60, 0x00,
  0x04, 0x30, 0x00, 0x06, 0x18, 0x00, 0x03, 0x08, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0xC6, 0x00, 0x00, 0x63, 0x00, 0x00, 0x21, 0x80, 0x00, 0x30, 0xC0,
  0x00, 0x18, 0x40, 0x00, 0x0C, 0x60, 0x00, 0x06, 0x30, 0x00, 0x02, 0x18,
  0x00, 0x01, 0x0C, 0x00, 0x01, 0x84, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x10, 0xC0, 0x00, 0x08, 0x60, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x1C, 0x07, 0x80, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x18, 0x02,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x04, 0x00, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0x80, 0x30, 0x06, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x70, 0x00, 0x03, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0xFF, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08,
  0x00, 0x07, 0x02, 0x00, 0x03, 0x81, 0x80, 0x01, 0xC0, 0x60, 0x00, 0xE0,
  0x18, 0x00, 0x70, 0x06, 0x00, 0x38, 0x01, 0x00, 0x18, 0x00, 0x40, 0x0C,
  0x00, 0x30, 0x06, 0x00, 0x0C, 0x03, 0x00, 0x03, 0x01, 0x80, 0x00, 0xC0,
  0xC0, 0x00, 0x20, 0x60, 0x00, 0x18, 0x30, 0x00, 0x06, 0x18, 0x00, 0x01,
  0x9E, 0x00, 0x00, 0x6F, 0x80, 0x00, 0x1E, 0x30, 0x00, 0x07, 0x0C, 0x00,
  0x03, 0x81, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x0C, 0x00, 0x0C, 0x03,
  0x00, 0x02, 0x00, 0x60, 0x00, 0x80, 0x18, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0x60, 0x06, 0x00, 0x18, 0x01, 0x80, 0x03, 0x00, 0x40, 0x00, 0xC0,
  0x10, 0x00, 0x18, 0x0C, 0x00, 0x06, 0x03, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x30, 0x30, 0x00, 0x06, 0x00, 0x00, 0x40, 0x08, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x20, 0x04, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x04, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x00, 0xC0,
  0x18, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x0C, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x30, 0xE0, 0x70, 0x1E, 0x07, 0x00, 0xC6, 0x00, 0x60, 0xE0,
  0x0E, 0x03, 0x30, 0x01, 0x86, 0x00, 0x18, 0x0D, 0x80, 0x03, 0x30, 0x00,
  0x20, 0x2C, 0x00, 0x0D, 0x80, 0x00, 0xC1, 0xA0, 0x00, 0x36, 0x00, 0x03,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x0C, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x30,
  0x70, 0x00, 0x0E, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x30, 0x00, 0x03, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0xC0,
  0x00, 0x0C, 0x00, 0x01, 0x83, 0x00, 0x00, 0x20, 0x00, 0x06, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x30, 0x00, 0x06, 0x00, 0x00, 0x61, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x86, 0x00, 0x00, 0x60, 0x00, 0x04, 0x18, 0x00, 0x01,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x30,
  0x00, 0x03, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x20, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x83, 0x00, 0x00, 0x20, 0x00,
  0x06, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x30, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x80, 0x00, 0x18, 0x00, 0x01, 0x86, 0x00, 0x00, 0x60, 0x00, 0x04,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x10, 0x00, 0x03, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x10,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x00, 0xF0, 0x01, 0x03, 0xFE, 0x00,
  0x87, 0x01, 0x80, 0xC7, 0x00, 0x60, 0x66, 0x00, 0x18, 0x32, 0x00, 0x0C,
  0x1A, 0x00, 0x06, 0x0B, 0x00, 0x03, 0x05, 0x00, 0x00, 0x87, 0x00, 0x00,
  0x43, 0x80, 0x00, 0x21, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x18, 0x60, 0x00,
  0x0C, 0x20, 0x00, 0x06, 0x30, 0x00, 0x03, 0x18, 0x00, 0x01, 0x0C, 0x00,
  0x01, 0x86, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x63, 0x00, 0x00, 0x31, 0x80,
  0x00, 0x18, 0xC0, 0x00, 0x08, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x06, 0x10,
  0x00, 0x03, 0x18, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x86, 0x00, 0x00, 0x43,
  0x00, 0x00, 0x61, 0x00, 0x00, 0x30, 0x80, 0x00, 0x18, 0xC0, 0x00, 0x0C,
  0x60, 0x00, 0x04, 0x30, 0x00, 0x02, 0x18, 0x00, 0x03, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x3F, 0xFC, 0x00, 0x3C, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x30,
  0x00, 0x70, 0x30, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x03, 0x18,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x66, 0x00, 0x00, 0x32,
  0x00, 0x00, 0x1B, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x03,
  0x40, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x58, 0x00, 0x00,
  0x2C, 0x00, 0x00, 0x36, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x0D, 0x00, 0x00,
  0x04, 0x80, 0x00, 0x06, 0x40, 0x00, 0x03, 0x20, 0x00, 0x01, 0x18, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0xC6, 0x00, 0x00, 0xC3, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0xE0, 0x70, 0x00, 0xE0, 0x1C, 0x00, 0xE0, 0x07, 0x01, 0xE0, 0x01,
  0xFF, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x02, 0x0F,
  0xFC, 0x00, 0x11, 0xE0, 0x70, 0x01, 0x9C, 0x00, 0xC0, 0x0D, 0x80, 0x03,
  0x00, 0x78, 0x00, 0x18, 0x03, 0x80, 0x00, 0x40, 0x18, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x18, 0x0C, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x06, 0x03, 0x00,
  0x00, 0x30, 0x18, 0x00, 0x01, 0x80, 0x80, 0x00, 0x0C, 0x0C, 0x00, 0x00,
  0x60, 0x60, 0x00, 0x03, 0x03, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x80,
  0xC0, 0x00, 0x04, 0x04, 0x00, 0x00, 0x60, 0x60, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x18, 0x18, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x04, 0x04, 0x00, 0x00,
  0x60, 0x20, 0x00, 0x03, 0x03, 0x00, 0x00, 0x10, 0x18, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x0C, 0x06, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x06, 0x01, 0xC0,
  0x00, 0x60, 0x1B, 0x00, 0x06, 0x00, 0xCC, 0x00, 0x60, 0x06, 0x38, 0x0E,
  0x00, 0x30, 0xFF, 0xE0, 0x01, 0x00, 0xF8, 0x00, 0x08, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0xF8, 0x30, 0x1E, 0x03, 0x8C, 0x0E, 0x00, 0x73, 0x07, 0x00, 0x0C,
  0x81, 0x80, 0x01, 0xA0, 0xC0, 0x00, 0x38, 0x30, 0x00, 0x0E, 0x18, 0x00,
  0x01, 0x86, 0x00, 0x00, 0x63, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x04, 0x20,
  0x00, 0x03, 0x18, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x31, 0x80, 0x00, 0x08,
  0x60, 0x00, 0x02, 0x10, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x18, 0xC0, 0x00, 0x06, 0x30, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x43, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x0C, 0x20, 0x00, 0x03, 0x08, 0x00, 0x00, 0xC2,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x08, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x03,
  0x81, 0x00, 0x01, 0xE0, 0x60, 0x00, 0xD8, 0x0C, 0x00, 0x64, 0x03, 0x80,
  0xF1, 0x00, 0x3F, 0xF0, 0xC0, 0x03, 0xE0, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0xE0, 0x41, 0xFC, 0x08, 0x60, 0x03, 0x38,
  0x00, 0x64, 0x00, 0x0D, 0x00, 0x01, 0xE0, 0x00, 0x28, 0x00, 0x06, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xFC, 0x00,
  0x3C, 0x07, 0x00, 0x38, 0x00, 0xC0, 0x30, 0x00, 0x30, 0x30, 0x00, 0x18,
  0x18, 0x00, 0x04, 0x08, 0x00, 0x02, 0x0C, 0x00, 0x01, 0x06, 0x00, 0x00,
  0x83, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x18, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xC6,
  0x00, 0x00, 0xC1, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x70,
  0x1C, 0x00, 0x70, 0x07, 0x80, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x0F, 0xFF, 0xFF, 0xFF, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x04, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x3F, 0x80, 0x3C, 0x00, 0x04, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x02, 0x0C,
  0x00, 0x00, 0x83, 0x00, 0x00, 0x60, 0x80, 0x00, 0x18, 0x60, 0x00, 0x06,
  0x18, 0x00, 0x01, 0x86, 0x00, 0x00, 0x41, 0x80, 0x00, 0x30, 0x40, 0x00,
  0x0C, 0x10, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x08, 0x30, 0x00, 0x06, 0x08, 0x00, 0x01, 0x82, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x18, 0x60, 0x00, 0x04, 0x18, 0x00, 0x01, 0x06, 0x00, 0x00,
  0xC1, 0x00, 0x00, 0x30, 0x40, 0x00, 0x0C, 0x10, 0x00, 0x07, 0x0C, 0x00,
  0x01, 0x81, 0x00, 0x00, 0x60, 0x40, 0x00, 0x38, 0x18, 0x00, 0x1E, 0x06,
  0x00, 0x0D, 0x81, 0x80, 0x07, 0x60, 0x30, 0x03, 0x90, 0x07, 0x03, 0x8C,
  0x00, 0xFF, 0xC3, 0x00, 0x0F, 0x80, 0x00, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0x40, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x0C, 0x60, 0x00,
  0x0C, 0x60, 0x00, 0x18, 0x60, 0x00, 0x18, 0x20, 0x00, 0x30, 0x30, 0x00,
  0x30, 0x30, 0x00, 0x20, 0x30, 0x00, 0x60, 0x30, 0x00, 0x40, 0x30, 0x00,
  0xC0, 0x10, 0x00, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x00, 0x18, 0x03,
  0x00, 0x18, 0x03, 0x00, 0x18, 0x06, 0x00, 0x08, 0x06, 0x00, 0x0C, 0x0C,
  0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x30,
  0x00, 0x04, 0x30, 0x00, 0x04, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0xC0,
  0x00, 0x06, 0xC0, 0x00, 0x06, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x19, 0x00, 0x00, 0xC0,
  0x00, 0x64, 0x00, 0x07, 0x00, 0x01, 0x98, 0x00, 0x14, 0x00, 0x0C, 0x60,
  0x00, 0xD0, 0x00, 0x31, 0x80, 0x03, 0x40, 0x01, 0x86, 0x00, 0x19, 0x00,
  0x06, 0x18, 0x00, 0x66, 0x00, 0x18, 0x60, 0x03, 0x18, 0x00, 0xC1, 0x80,
  0x0C, 0x60, 0x03, 0x06, 0x00, 0x21, 0x80, 0x18, 0x18, 0x01, 0x86, 0x00,
  0x60, 0x60, 0x06, 0x18, 0x03, 0x01, 0x80, 0x30, 0x60, 0x0C, 0x06, 0x00,
  0xC1, 0x80, 0x30, 0x08, 0x06, 0x06, 0x01, 0x80, 0x20, 0x18, 0x08, 0x06,
  0x00, 0xC0, 0xC0, 0x20, 0x30, 0x03, 0x03, 0x00, 0xC0, 0xC0, 0x0C, 0x08,
  0x03, 0x07, 0x00, 0x30, 0x60, 0x0C, 0x18, 0x00, 0xC1, 0x80, 0x30, 0x60,
  0x03, 0x0C, 0x00, 0xC3, 0x00, 0x0C, 0x30, 0x03, 0x0C, 0x00, 0x31, 0x80,
  0x0C, 0x60, 0x00, 0xC6, 0x00, 0x31, 0x80, 0x03, 0x30, 0x00, 0x46, 0x00,
  0x0C, 0xC0, 0x01, 0x30, 0x00, 0x32, 0x00, 0x04, 0xC0, 0x00, 0x58, 0x00,
  0x12, 0x00, 0x01, 0x40, 0x00, 0x78, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x30, 0x18, 0x00, 0x06, 0x01, 0x80,
  0x00, 0x60, 0x0C, 0x00, 0x0C, 0x00, 0xC0, 0x01, 0x80, 0x0C, 0x00, 0x30,
  0x00, 0x60, 0x03, 0x00, 0x06, 0x00, 0x60, 0x00, 0x30, 0x0C, 0x00, 0x03,
  0x01, 0x80, 0x00, 0x18, 0x18, 0x00, 0x01, 0x83, 0x00, 0x00, 0x08, 0x60,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xD8,
  0x00, 0x00, 0x19, 0x80, 0x00, 0x03, 0x08, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x06, 0x0C, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x18, 0x06, 0x00, 0x03, 0x00,
  0x30, 0x00, 0x30, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x01, 0x80,
  0x18, 0x00, 0x1C, 0x01, 0x80, 0x00, 0xC0, 0x30, 0x00, 0x0C, 0x06, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x80,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0xC0, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x40,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x20,
  0x01, 0x80, 0x00, 0x20, 0x01, 0x80, 0x00, 0x30, 0x03, 0x00, 0x00, 0x30,
  0x03, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x10,
  0x0C, 0x00, 0x00, 0x10, 0x0C, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x18,
  0x18, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x18,
  0x60, 0x00, 0x00, 0x08, 0x60, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x00, 0x0C,
  0xC0, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x00, 0x00, 0x20,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00,
  0x07, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x0C, 0x70, 0x30, 0x00, 0x18, 0xC0, 0x30, 0x00, 0x23, 0x00, 0x30,
  0x00, 0xCC, 0x00, 0x30, 0x01, 0x18, 0x00, 0x60, 0x06, 0x30, 0x00, 0x60,
  0x18, 0xC0, 0x00, 0x60, 0x71, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3E,
  0x00,
};

const GFXglyph RobotoCondensed_ThinItalic67pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 11, 49, 12, 1, -48 },
  { 69, 11, 13, 17, 7, -50 },
  { 87, 34, 48, 32, 1, -48 },
  { 291, 28, 62, 31, 2, -55 },
  { 508, 32, 50, 42, 6, -49 },
  { 708, 30, 50, 35, 2, -49 },
  { 896, 4, 14, 11, 7, -50 },
  { 903, 18, 68, 18, 3, -53 },
  { 1056, 18, 68, 18, -4, -53 },
  { 1209, 26, 26, 27, 4, -48 },
  { 1294, 27, 35, 32, 3, -40 },
  { 1413, 7, 13, 12, -2, -5 },
  { 1425, 13, 2, 18, 2, -23 },
  { 1429, 4, 4, 14, 1, -3 },
  { 1431, 27, 52, 22, -2, -48 },
  { 1607, 27, 50, 31, 3, -49 },
  { 1776, 14, 48, 31, 9, -48 },
  { 1860, 27, 49, 31, 2, -49 },
  { 2026, 28, 50, 31, 2, -49 },
  { 2201, 27, 48, 31, 2, -48 },
  { 2363, 28, 49, 31, 4, -48 },
  { 2535, 25, 49, 31, 3, -48 },
  { 2689, 26, 48, 31, 6, -48 },
  { 2845, 30, 50, 31, 1, -49 },
  { 3033, 24, 49, 31, 5, -49 },
  { 3180, 9, 35, 12, 1, -34 },
  { 3220, 12, 42, 11, -2, -34 },
  { 3283, 25, 26, 30, 3, -35 },
  { 3365, 25, 16, 32, 4, -30 },
  { 3415, 25, 26, 30, 2, -35 },
  { 3497, 20, 50, 25, 6, -49 },
  { 3622, 47, 61, 52, 2, -46 },
  { 3981, 32, 48, 34, -2, -48 },
  { 4173, 30, 48, 35, 3, -48 },
  { 4353, 31, 50, 37, 4, -49 },
  { 4547, 32, 48, 37, 3, -48 },
  { 4739, 32, 48, 33, 3, -48 },
  { 4931, 32, 48, 33, 3, -48 },
  { 5123, 32, 50, 39, 4, -49 },
  { 5323, 36, 48, 40, 3, -48 },
  { 5539, 10, 48, 16, 4, -48 },
  { 5599, 30, 49, 32, 1, -48 },
  { 5783, 34, 48, 36, 3, -48 },
  { 5987, 22, 48, 30, 3, -48 },
  { 6119, 45, 48, 49, 3, -48 },
  { 6389, 36, 48, 40, 3, -48 },
  { 6605, 32, 50, 38, 4, -49 },
  { 6805, 31, 48, 34, 3, -48 },
  { 6991, 33, 58, 38, 3, -49 },
  { 7231, 32, 48, 37, 2, -48 },
  { 7423, 32, 50, 34, 2, -49 },
  { 7623, 30, 48, 34, 7, -48 },
  { 7803, 33, 49, 38, 4, -48 },
  { 8006, 31, 48, 34, 6, -48 },
  { 8192, 46, 48, 51, 7, -48 },
  { 8468, 37, 48, 34, -1, -48 },
  { 8690, 31, 48, 34, 6, -48 },
  { 8876, 35, 48, 34, 0, -48 },
  { 9086, 18, 64, 13, 1, -54 },
  { 9230, 9, 52, 22, 7, -48 },
  { 9289, 18, 64, 13, -4, -54 },
  { 9433, 17, 24, 24, 4, -48 },
  { 9484, 23, 2, 24, -3, 0 },
  { 9490, 7, 9, 17, 9, -51 },
  { 9498, 26, 37, 30, 1, -36 },
  { 9619, 26, 51, 31, 2, -50 },
  { 9785, 25, 37, 29, 2, -36 },
  { 9901, 29, 51, 31, 3, -50 },
  { 10086, 25, 37, 29, 2, -36 },
  { 10202, 20, 51, 19, 4, -51 },
  { 10330, 29, 50, 32, 0, -36 },
  { 10512, 25, 50, 31, 2, -50 },
  { 10669, 11, 48, 13, 2, -48 },
  { 10735, 22, 62, 13, -9, -48 },
  { 10906, 26, 50, 27, 2, -50 },
  { 11069, 11, 50, 13, 2, -50 },
  { 11138, 46, 36, 51, 1, -36 },
  { 11345, 25, 36, 31, 2, -36 },
  { 11458, 25, 37, 31, 3, -36 },
  { 11574, 29, 50, 31, -1, -36 },
  { 11756, 26, 50, 31, 3, -36 },
  { 11919, 19, 36, 20, 2, -36 },
  { 12005, 25, 37, 29, 1, -36 },
  { 12121, 14, 46, 19, 4, -45 },
  { 12202, 26, 36, 31, 3, -35 },
  { 12319, 24, 35, 28, 4, -35 },
  { 12424, 38, 35, 43, 5, -35 },
  { 12591, 28, 35, 28, -1, -35 },
  { 12714, 32, 49, 27, -3, -35 },
  { 12910, 27, 35, 28, 0, -35 },
  { 13029, 21, 66, 19, 2, -52 },
  { 13203, 11, 57, 13, 1, -48 },
  { 13282, 21, 67, 19, -4, -52 },
  { 13458, 31, 11, 39, 4, -26 },
};

const GFXfont RobotoCondensed_ThinItalic67pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ThinItalic67pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ThinItalic67pt7bGlyphs,
  0x20, 0x7E, 79
};

#endif // _ROBOTOCONDENSED_THINITALIC67PT7B_H_
