#ifndef _ROBOTOCONDENSED_THINITALIC63PT7B_H_
#define _ROBOTOCONDENSED_THINITALIC63PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ThinItalic.ttf
// Size: 63pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ThinItalic63pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xC0, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x40, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x01, 0x80,
  0x60, 0x18, 0x04, 0x01, 0x00, 0x40, 0x30, 0x0C, 0x03, 0x00, 0x80, 0x20,
  0x08, 0x06, 0x01, 0x80, 0x60, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0xE0, 0x10, 0x00, 0x30,
  0xCC, 0x33, 0x0C, 0x82, 0x61, 0x98, 0x66, 0x19, 0x86, 0x41, 0x90, 0x4C,
  0x33, 0x0C, 0xC3, 0x00, 0x00, 0x00, 0x60, 0x08, 0x00, 0x00, 0x40, 0x18,
  0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0xC0, 0x10, 0x00, 0x00, 0x80, 0x30,
  0x00, 0x01, 0x80, 0x30, 0x00, 0x01, 0x80, 0x20, 0x00, 0x01, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x60, 0x00, 0x03, 0x00, 0x40, 0x00, 0x02, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0x0C, 0x01, 0x80, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x08, 0x03, 0x00,
  0x00, 0x18, 0x03, 0x00, 0x00, 0x18, 0x02, 0x00, 0x00, 0x10, 0x06, 0x00,
  0x00, 0x10, 0x06, 0x00, 0x00, 0x30, 0x04, 0x00, 0x00, 0x30, 0x04, 0x00,
  0x00, 0x20, 0x0C, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x60, 0x08, 0x00,
  0x00, 0x40, 0x18, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0xC0, 0x10, 0x00,
  0x00, 0x80, 0x30, 0x00, 0x01, 0x80, 0x30, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0x00, 0x60, 0x00, 0x03, 0x00, 0x40, 0x00,
  0x02, 0x00, 0xC0, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x80, 0x00,
  0x04, 0x01, 0x80, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x0C, 0x01, 0x00, 0x00,
  0x08, 0x03, 0x00, 0x00, 0x08, 0x03, 0x00, 0x00, 0x18, 0x02, 0x00, 0x00,
  0x18, 0x06, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x1C, 0x0E, 0x00, 0x0C, 0x01,
  0xC0, 0x06, 0x00, 0x38, 0x03, 0x00, 0x06, 0x01, 0x80, 0x00, 0x80, 0x40,
  0x00, 0x30, 0x30, 0x00, 0x0C, 0x08, 0x00, 0x03, 0x02, 0x00, 0x00, 0x41,
  0x80, 0x00, 0x10, 0x60, 0x00, 0x04, 0x18, 0x00, 0x03, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x61, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x06, 0x30, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x61,
  0x00, 0x00, 0x10, 0x40, 0x00, 0x0C, 0x18, 0x00, 0x02, 0x06, 0x00, 0x01,
  0x80, 0xC0, 0x00, 0xC0, 0x30, 0x00, 0x70, 0x07, 0x00, 0x38, 0x00, 0xE0,
  0x38, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0x86, 0x00, 0x00, 0x30, 0x18, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x18, 0x02,
  0x00, 0x01, 0x80, 0x10, 0x01, 0x0C, 0x00, 0x80, 0x0C, 0x40, 0x04, 0x00,
  0xC6, 0x00, 0x20, 0x0C, 0x30, 0x01, 0x00, 0x41, 0x80, 0x08, 0x06, 0x0C,
  0x00, 0xC0, 0x60, 0x40, 0x06, 0x02, 0x02, 0x00, 0x20, 0x30, 0x18, 0x03,
  0x03, 0x00, 0xC0, 0x18, 0x10, 0x06, 0x01, 0x81, 0x80, 0x18, 0x18, 0x18,
  0x00, 0xE1, 0x81, 0x80, 0x03, 0xF8, 0x0C, 0x00, 0x02, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x02, 0x03, 0xF8, 0x00, 0x30, 0x30, 0xE0, 0x03, 0x03,
  0x01, 0x00, 0x10, 0x30, 0x0C, 0x01, 0x81, 0x00, 0x60, 0x18, 0x18, 0x01,
  0x01, 0x80, 0x80, 0x08, 0x0C, 0x0C, 0x00, 0x40, 0xC0, 0x60, 0x02, 0x0C,
  0x03, 0x00, 0x30, 0x40, 0x10, 0x01, 0x86, 0x00, 0x80, 0x0C, 0x60, 0x04,
  0x00, 0x42, 0x00, 0x20, 0x06, 0x30, 0x01, 0x00, 0x30, 0x00, 0x08, 0x03,
  0x00, 0x00, 0x60, 0x18, 0x00, 0x01, 0x01, 0x80, 0x00, 0x0E, 0x38, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0E, 0x18, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x30, 0x06,
  0x00, 0x06, 0x00, 0x60, 0x00, 0x60, 0x06, 0x00, 0x0C, 0x00, 0x60, 0x00,
  0xC0, 0x06, 0x00, 0x08, 0x00, 0x60, 0x00, 0x80, 0x04, 0x00, 0x08, 0x00,
  0xC0, 0x00, 0x80, 0x08, 0x00, 0x08, 0x01, 0x80, 0x00, 0x80, 0x30, 0x00,
  0x0C, 0x06, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x04, 0x18, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x30,
  0x40, 0x00, 0x06, 0x06, 0x00, 0x00, 0xC0, 0x30, 0x03, 0x18, 0x03, 0x00,
  0x21, 0x00, 0x18, 0x06, 0x30, 0x01, 0x80, 0x66, 0x00, 0x0C, 0x06, 0x60,
  0x00, 0x40, 0xC4, 0x00, 0x06, 0x0C, 0xC0, 0x00, 0x30, 0x8C, 0x00, 0x03,
  0x18, 0xC0, 0x00, 0x1B, 0x0C, 0x00, 0x01, 0xB0, 0xC0, 0x00, 0x0E, 0x0C,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x0E, 0x06, 0x00, 0x01, 0xB0, 0x70, 0x00,
  0x63, 0x03, 0x80, 0x0C, 0x18, 0x1C, 0x03, 0x81, 0x80, 0xFF, 0xE0, 0x0C,
  0x00, 0xF0, 0x00, 0x00, 0x10, 0x8C, 0x63, 0x18, 0xC4, 0x63, 0x18, 0x84,
  0x00, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20,
  0x00, 0x18, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x04, 0x00,
  0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x18, 0x07,
  0xF8, 0x18, 0x3E, 0x1E, 0x18, 0xF0, 0x07, 0x97, 0x80, 0x00, 0xFE, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x78, 0x00, 0x00, 0xCC, 0x00, 0x01, 0x8C, 0x00,
  0x03, 0x06, 0x00, 0x06, 0x06, 0x00, 0x0E, 0x03, 0x00, 0x1C, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x30, 0x00, 0xC0, 0x20, 0x00, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x0C, 0x30, 0x60,
  0xC1, 0x83, 0x0C, 0x18, 0x61, 0xC3, 0x04, 0x00, 0x7F, 0xFF, 0xFF, 0x67,
  0xF0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0x07, 0x00, 0x0C, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x0C, 0x00, 0x18, 0x06, 0x00, 0x0C, 0x06, 0x00, 0x02,
  0x06, 0x00, 0x01, 0x03, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x61, 0x80, 0x00,
  0x30, 0xC0, 0x00, 0x18, 0x40, 0x00, 0x0C, 0x60, 0x00, 0x06, 0x30, 0x00,
  0x03, 0x10, 0x00, 0x01, 0x98, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x46, 0x00,
  0x00, 0x22, 0x00, 0x00, 0x31, 0x00, 0x00, 0x18, 0x80, 0x00, 0x0C, 0xC0,
  0x00, 0x06, 0x60, 0x00, 0x02, 0x30, 0x00, 0x01, 0x10, 0x00, 0x01, 0x88,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x66, 0x00, 0x00, 0x33, 0x00, 0x00, 0x11,
  0x80, 0x00, 0x18, 0xC0, 0x00, 0x0C, 0x60, 0x00, 0x04, 0x30, 0x00, 0x06,
  0x18, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x06, 0x00, 0x01, 0x83, 0x00, 0x00,
  0x80, 0x80, 0x00, 0xC0, 0x60, 0x00, 0xC0, 0x30, 0x00, 0x60, 0x0C, 0x00,
  0x60, 0x07, 0x00, 0x60, 0x01, 0xC0, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x18, 0x03, 0xC0, 0xF6, 0x1E, 0x23, 0x81, 0x70, 0x1A,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x00, 0x08, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08,
  0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x10, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x10, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0x81, 0xC0, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x60, 0x00, 0xC0,
  0x30, 0x00, 0x18, 0x0C, 0x00, 0x06, 0x06, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x60, 0x40, 0x00, 0x18, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x82, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xC1, 0xE0, 0x01, 0xC0, 0x1C, 0x00,
  0xC0, 0x03, 0x00, 0x60, 0x00, 0x60, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x02,
  0x02, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x30, 0x60, 0x00, 0x0C, 0x30, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x30, 0x00, 0x00,
  0x8C, 0x00, 0x00, 0x63, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x06, 0x30, 0x00,
  0x01, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x20, 0x60, 0x00, 0x18, 0x0C,
  0x00, 0x0C, 0x03, 0x00, 0x06, 0x00, 0x70, 0x03, 0x00, 0x0E, 0x07, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0D, 0x80,
  0x00, 0x02, 0x60, 0x00, 0x01, 0x90, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x23,
  0x00, 0x00, 0x18, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x01,
  0x82, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x60, 0x60, 0x00, 0x10, 0x18, 0x00,
  0x0C, 0x06, 0x00, 0x06, 0x01, 0x80, 0x03, 0x00, 0x40, 0x00, 0xC0, 0x10,
  0x00, 0x60, 0x0C, 0x00, 0x30, 0x03, 0x00, 0x08, 0x00, 0xC0, 0x06, 0x00,
  0x20, 0x03, 0x00, 0x08, 0x01, 0x80, 0x02, 0x00, 0x60, 0x01, 0x80, 0x30,
  0x00, 0x60, 0x18, 0x00, 0x18, 0x06, 0x00, 0x04, 0x03, 0x00, 0x01, 0x01,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x0F, 0xC0, 0x00, 0x9F, 0xFC, 0x00,
  0x2C, 0x01, 0x80, 0x1C, 0x00, 0x30, 0x06, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x02,
  0x0C, 0x00, 0x01, 0x83, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x10, 0x30, 0x00,
  0x0C, 0x04, 0x00, 0x03, 0x01, 0x80, 0x01, 0x80, 0x60, 0x00, 0x40, 0x0C,
  0x00, 0x30, 0x03, 0x80, 0x38, 0x00, 0x78, 0x3C, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x03, 0xFC, 0x00, 0x1E,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x1F, 0x80, 0x20, 0xFF, 0xC0, 0xC7, 0x00, 0xC1, 0x98,
  0x00, 0xC3, 0x60, 0x00, 0xC5, 0x80, 0x01, 0x9E, 0x00, 0x01, 0x38, 0x00,
  0x03, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x0D, 0x00, 0x00, 0x1A, 0x00, 0x00,
  0x34, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x05, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x36, 0x00, 0x00, 0x4C,
  0x00, 0x01, 0x88, 0x00, 0x03, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x10, 0x30,
  0x00, 0x60, 0x60, 0x01, 0x80, 0x60, 0x06, 0x00, 0x70, 0x38, 0x00, 0x7F,
  0xC0, 0x00, 0x08, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x0E, 0x07, 0x00, 0x03, 0x80, 0x38, 0x00, 0x70,
  0x00, 0xC0, 0x06, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x60, 0x18, 0x00, 0x06,
  0x01, 0x80, 0x00, 0x20, 0x30, 0x00, 0x02, 0x03, 0x00, 0x00, 0x20, 0x30,
  0x00, 0x02, 0x02, 0x00, 0x00, 0x20, 0x20, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x60, 0x20, 0x00, 0x04, 0x02, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x18, 0x03,
  0x00, 0x01, 0x80, 0x18, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x0E, 0x01,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xE0, 0x78, 0x00,
  0x38, 0x01, 0xC0, 0x06, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x60, 0x18, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x30, 0x30, 0x00, 0x01, 0x02, 0x00, 0x00, 0x18,
  0x60, 0x00, 0x01, 0x86, 0x00, 0x00, 0x18, 0x40, 0x00, 0x01, 0x04, 0x00,
  0x00, 0x10, 0x40, 0x00, 0x03, 0x04, 0x00, 0x00, 0x30, 0x40, 0x00, 0x06,
  0x06, 0x00, 0x00, 0x60, 0x60, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0x38,
  0x00, 0x30, 0x01, 0xC0, 0x0E, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0xF0, 0x70, 0x01, 0xC0, 0x18, 0x03, 0x00, 0x0C, 0x06, 0x00, 0x0C, 0x0C,
  0x00, 0x06, 0x0C, 0x00, 0x06, 0x18, 0x00, 0x06, 0x18, 0x00, 0x02, 0x30,
  0x00, 0x03, 0x30, 0x00, 0x03, 0x20, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60,
  0x00, 0x03, 0x60, 0x00, 0x03, 0x40, 0x00, 0x02, 0x40, 0x00, 0x02, 0x40,
  0x00, 0x06, 0x40, 0x00, 0x06, 0x40, 0x00, 0x06, 0x40, 0x00, 0x0E, 0x60,
  0x00, 0x0E, 0x60, 0x00, 0x1C, 0x60, 0x00, 0x34, 0x30, 0x00, 0x2C, 0x30,
  0x00, 0x6C, 0x18, 0x01, 0xCC, 0x1C, 0x03, 0x88, 0x07, 0xFE, 0x18, 0x03,
  0xF8, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0x03, 0xC1, 0xC0, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x03, 0x81, 0xC0, 0x00,
  0x00, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x06, 0x00, 0xE0, 0x04,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x20, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x08, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x70, 0x70, 0x30, 0x06, 0x18, 0x01, 0x8C, 0x00, 0x22,
  0x00, 0x0D, 0x80, 0x03, 0x40, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x01,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x03, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00,
  0x00, 0x06, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x20, 0x18, 0x00, 0x1F, 0x80,
  0x02, 0x03, 0x00, 0x07, 0xFC, 0x00, 0x30, 0x30, 0x00, 0xC0, 0x60, 0x03,
  0x06, 0x00, 0x18, 0x03, 0x00, 0x30, 0x60, 0x03, 0x00, 0x30, 0x03, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x30, 0xC0, 0x0C, 0x00, 0x20, 0x03, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x31, 0x80, 0x18, 0x00, 0x60, 0x03, 0x18, 0x01, 0x80,
  0x06, 0x00, 0x33, 0x00, 0x30, 0x00, 0x40, 0x03, 0x30, 0x03, 0x00, 0x04,
  0x00, 0x23, 0x00, 0x20, 0x00, 0xC0, 0x02, 0x20, 0x06, 0x00, 0x0C, 0x00,
  0x66, 0x00, 0x60, 0x00, 0x80, 0x06, 0x60, 0x04, 0x00, 0x08, 0x00, 0x66,
  0x00, 0xC0, 0x01, 0x80, 0x04, 0x40, 0x0C, 0x00, 0x18, 0x00, 0xC4, 0x00,
  0x80, 0x01, 0x00, 0x0C, 0xC0, 0x08, 0x00, 0x10, 0x00, 0x8C, 0x00, 0x80,
  0x03, 0x00, 0x18, 0xC0, 0x18, 0x00, 0x30, 0x01, 0x8C, 0x01, 0x80, 0x06,
  0x00, 0x10, 0xC0, 0x18, 0x00, 0x60, 0x03, 0x0C, 0x01, 0x80, 0x0A, 0x00,
  0x20, 0xC0, 0x18, 0x01, 0xA0, 0x06, 0x0C, 0x00, 0x80, 0x33, 0x00, 0xC0,
  0xC0, 0x0C, 0x06, 0x30, 0x18, 0x0C, 0x00, 0xC0, 0xC1, 0x83, 0x00, 0x40,
  0x07, 0xF8, 0x1F, 0xE0, 0x06, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x08, 0x00, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x40, 0x00, 0x00, 0x09, 0x00, 0x00, 0x00, 0x64, 0x00, 0x00, 0x01, 0x10,
  0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x21, 0x80, 0x00, 0x01, 0x86, 0x00,
  0x00, 0x04, 0x18, 0x00, 0x00, 0x30, 0x20, 0x00, 0x00, 0x80, 0x80, 0x00,
  0x06, 0x02, 0x00, 0x00, 0x10, 0x0C, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x02,
  0x00, 0xC0, 0x00, 0x18, 0x03, 0x00, 0x00, 0x40, 0x04, 0x00, 0x03, 0x00,
  0x10, 0x00, 0x0C, 0x00, 0x40, 0x00, 0x60, 0x01, 0x80, 0x01, 0x80, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x01, 0x80,
  0x06, 0x00, 0x02, 0x00, 0x10, 0x00, 0x08, 0x00, 0xC0, 0x00, 0x20, 0x02,
  0x00, 0x00, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x03, 0x00,
  0x00, 0x30, 0x08, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x01, 0x01, 0x00, 0x00,
  0x04, 0x0C, 0x00, 0x00, 0x18, 0x20, 0x00, 0x00, 0x61, 0x80, 0x00, 0x01,
  0x86, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x26,
  0x00, 0x00, 0x00, 0x98, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x20, 0x00, 0xE0, 0x01, 0x00,
  0x01, 0x80, 0x18, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x18, 0x06, 0x00, 0x00,
  0xC0, 0x20, 0x00, 0x02, 0x01, 0x00, 0x00, 0x10, 0x08, 0x00, 0x00, 0x80,
  0xC0, 0x00, 0x04, 0x06, 0x00, 0x00, 0x60, 0x30, 0x00, 0x03, 0x01, 0x00,
  0x00, 0x18, 0x08, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x0C, 0x06, 0x00, 0x00,
  0x60, 0x30, 0x00, 0x06, 0x01, 0x80, 0x00, 0x60, 0x08, 0x00, 0x06, 0x00,
  0x40, 0x00, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0x80,
  0x03, 0xC0, 0x0C, 0x00, 0x07, 0x00, 0x40, 0x00, 0x1C, 0x02, 0x00, 0x00,
  0x60, 0x30, 0x00, 0x01, 0x81, 0x80, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x20,
  0x60, 0x00, 0x01, 0x02, 0x00, 0x00, 0x08, 0x10, 0x00, 0x00, 0x41, 0x80,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0x30, 0x60, 0x00, 0x01, 0x02, 0x00, 0x00,
  0x18, 0x10, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0xC0,
  0x60, 0x00, 0x0E, 0x03, 0x00, 0x00, 0xE0, 0x10, 0x00, 0x1C, 0x00, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x07, 0x81, 0xE0, 0x00, 0xE0, 0x01, 0x80, 0x0E, 0x00,
  0x06, 0x00, 0xC0, 0x00, 0x18, 0x0E, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x02,
  0x06, 0x00, 0x00, 0x18, 0x20, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x06, 0x10,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x0C, 0x40, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x06, 0x20, 0x00,
  0x00, 0x21, 0x80, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x18, 0x60, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x0C, 0x08, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x06, 0x01,
  0x80, 0x00, 0x60, 0x0C, 0x00, 0x06, 0x00, 0x30, 0x00, 0xE0, 0x00, 0xE0,
  0x3C, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x02, 0x00, 0x07, 0x00, 0x04, 0x00,
  0x03, 0x00, 0x18, 0x00, 0x03, 0x00, 0x30, 0x00, 0x03, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x80, 0x00, 0x06, 0x01, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00,
  0x18, 0x0C, 0x00, 0x00, 0x10, 0x18, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00,
  0x60, 0x40, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x01, 0x83, 0x00, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0x10,
  0x20, 0x00, 0x00, 0x60, 0x40, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x01, 0x83,
  0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x08, 0x10,
  0x00, 0x00, 0x30, 0x20, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x02, 0x06, 0x00, 0x00, 0x0C, 0x08, 0x00,
  0x00, 0x18, 0x10, 0x00, 0x00, 0x20, 0x60, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x01, 0x01, 0x80, 0x00, 0x06, 0x02, 0x00, 0x00, 0x18, 0x04, 0x00, 0x00,
  0x30, 0x08, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x03, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0xC0, 0x00, 0x70, 0x01, 0x00, 0x03, 0xC0, 0x03, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xF8, 0x02, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x06, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x02, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x60,
  0x00, 0x30, 0x03, 0x00, 0x00, 0x60, 0x18, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x02, 0x03, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x00, 0x31,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x07, 0xFF, 0xC6, 0x00, 0x1F, 0xFF,
  0x18, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x00, 0x21, 0x00, 0x00, 0x00, 0x8C,
  0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0x04, 0x10, 0x00, 0x00, 0x10, 0x40, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x03, 0x06, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00,
  0x30, 0x30, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x0E, 0x01, 0x80, 0x00, 0xF0,
  0x03, 0x00, 0x0F, 0x00, 0x07, 0x81, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x20, 0x00, 0x00,
  0x10, 0x08, 0x00, 0x00, 0x0C, 0x02, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x08, 0x04, 0x00,
  0x00, 0x02, 0x01, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x60, 0x30,
  0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x01, 0x00,
  0x80, 0x00, 0x00, 0x40, 0x20, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x0C,
  0x06, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00,
  0x20, 0x10, 0x00, 0x00, 0x08, 0x04, 0x00, 0x00, 0x06, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x30, 0x00, 0x00, 0x10, 0x0C, 0x00,
  0x00, 0x04, 0x02, 0x00, 0x00, 0x01, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x02, 0x01,
  0x80, 0x00, 0x00, 0x80, 0x40, 0x00, 0x00, 0x20, 0x10, 0x00, 0x00, 0x18,
  0x0C, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00,
  0x40, 0x20, 0x00, 0x00, 0x10, 0x08, 0x00, 0x00, 0x0C, 0x02, 0x00, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x30, 0x18, 0x00,
  0x00, 0x08, 0x04, 0x00, 0x00, 0x02, 0x01, 0x00, 0x00, 0x01, 0x80, 0x40,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x20, 0x08, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x04, 0x01, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x10, 0x04, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x02,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x00, 0x40, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x20, 0x08, 0x06, 0x01, 0x80, 0x60, 0x18, 0x04, 0x01, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x04, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x18, 0x0C, 0x00,
  0x01, 0x00, 0x40, 0x00, 0x30, 0x06, 0x00, 0x06, 0x00, 0x60, 0x00, 0x60,
  0x03, 0x00, 0x0C, 0x00, 0x38, 0x01, 0x80, 0x01, 0xC0, 0x70, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x40,
  0x00, 0x03, 0x80, 0x20, 0x00, 0x03, 0x80, 0x10, 0x00, 0x03, 0x80, 0x18,
  0x00, 0x03, 0x80, 0x0C, 0x00, 0x03, 0x80, 0x06, 0x00, 0x03, 0x80, 0x02,
  0x00, 0x03, 0x80, 0x01, 0x00, 0x03, 0x80, 0x01, 0x80, 0x03, 0x80, 0x00,
  0xC0, 0x03, 0x80, 0x00, 0x60, 0x03, 0x80, 0x00, 0x30, 0x01, 0x80, 0x00,
  0x10, 0x01, 0x80, 0x00, 0x08, 0x01, 0x80, 0x00, 0x0C, 0x01, 0x80, 0x00,
  0x06, 0x01, 0x80, 0x00, 0x03, 0x01, 0x80, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x00, 0x81, 0x80, 0x00, 0x00, 0x41, 0x80, 0x00, 0x00, 0x61, 0xE0, 0x00,
  0x00, 0x31, 0x90, 0x00, 0x00, 0x19, 0x8C, 0x00, 0x00, 0x0D, 0x83, 0x00,
  0x00, 0x05, 0x01, 0x80, 0x00, 0x03, 0x00, 0x60, 0x00, 0x03, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x60, 0x01,
  0x80, 0x00, 0x20, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x80, 0x02, 0x00,
  0x00, 0xC0, 0x01, 0x00, 0x00, 0x30, 0x00, 0x80, 0x00, 0x18, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x60, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x10,
  0x00, 0x00, 0x60, 0x08, 0x00, 0x00, 0x18, 0x04, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00,
  0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00,
  0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x80, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x00, 0x18, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x1A, 0x00, 0x00,
  0x00, 0x3C, 0x03, 0x40, 0x00, 0x00, 0x0D, 0x80, 0x6C, 0x00, 0x00, 0x01,
  0xB0, 0x09, 0x80, 0x00, 0x00, 0x64, 0x01, 0x30, 0x00, 0x00, 0x08, 0x80,
  0x26, 0x00, 0x00, 0x03, 0x30, 0x0C, 0x40, 0x00, 0x00, 0x46, 0x01, 0x88,
  0x00, 0x00, 0x18, 0xC0, 0x31, 0x80, 0x00, 0x02, 0x18, 0x04, 0x30, 0x00,
  0x00, 0xC2, 0x00, 0x86, 0x00, 0x00, 0x10, 0x40, 0x30, 0x40, 0x00, 0x06,
  0x18, 0x06, 0x08, 0x00, 0x00, 0x83, 0x00, 0xC1, 0x80, 0x00, 0x30, 0x60,
  0x18, 0x30, 0x00, 0x04, 0x08, 0x02, 0x06, 0x00, 0x01, 0x81, 0x00, 0x40,
  0x40, 0x00, 0x60, 0x60, 0x18, 0x08, 0x00, 0x0C, 0x0C, 0x03, 0x01, 0x00,
  0x03, 0x01, 0x80, 0x60, 0x30, 0x00, 0x60, 0x30, 0x0C, 0x06, 0x00, 0x18,
  0x04, 0x01, 0x00, 0xC0, 0x03, 0x00, 0x80, 0x20, 0x08, 0x00, 0xC0, 0x30,
  0x0C, 0x01, 0x00, 0x18, 0x06, 0x01, 0x80, 0x20, 0x06, 0x00, 0xC0, 0x30,
  0x06, 0x00, 0x80, 0x18, 0x06, 0x00, 0xC0, 0x30, 0x02, 0x00, 0x80, 0x08,
  0x04, 0x00, 0x40, 0x10, 0x01, 0x01, 0x80, 0x18, 0x06, 0x00, 0x20, 0x20,
  0x03, 0x00, 0xC0, 0x06, 0x0C, 0x00, 0x60, 0x18, 0x00, 0xC1, 0x00, 0x0C,
  0x03, 0x00, 0x18, 0x60, 0x01, 0x00, 0x40, 0x01, 0x18, 0x00, 0x20, 0x08,
  0x00, 0x23, 0x00, 0x0C, 0x03, 0x00, 0x04, 0xC0, 0x01, 0x80, 0x60, 0x00,
  0xD8, 0x00, 0x30, 0x0C, 0x00, 0x1E, 0x00, 0x06, 0x01, 0x00, 0x01, 0xC0,
  0x00, 0x80, 0x20, 0x00, 0x30, 0x00, 0x10, 0x04, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x0C, 0x03, 0x80,
  0x00, 0x01, 0x00, 0xF0, 0x00, 0x00, 0x20, 0x1A, 0x00, 0x00, 0x0C, 0x03,
  0x60, 0x00, 0x01, 0x80, 0x64, 0x00, 0x00, 0x30, 0x0C, 0xC0, 0x00, 0x06,
  0x01, 0x18, 0x00, 0x00, 0x80, 0x61, 0x00, 0x00, 0x30, 0x0C, 0x30, 0x00,
  0x06, 0x01, 0x82, 0x00, 0x00, 0xC0, 0x30, 0x60, 0x00, 0x18, 0x06, 0x0C,
  0x00, 0x03, 0x00, 0x80, 0x80, 0x00, 0x40, 0x30, 0x18, 0x00, 0x18, 0x06,
  0x01, 0x00, 0x03, 0x00, 0xC0, 0x30, 0x00, 0x60, 0x18, 0x06, 0x00, 0x0C,
  0x03, 0x00, 0x40, 0x01, 0x80, 0x40, 0x0C, 0x00, 0x20, 0x18, 0x01, 0x80,
  0x0C, 0x03, 0x00, 0x10, 0x01, 0x80, 0x60, 0x03, 0x00, 0x30, 0x0C, 0x00,
  0x20, 0x06, 0x01, 0x00, 0x06, 0x00, 0xC0, 0x20, 0x00, 0xC0, 0x10, 0x0C,
  0x00, 0x08, 0x06, 0x01, 0x80, 0x01, 0x80, 0xC0, 0x30, 0x00, 0x10, 0x18,
  0x06, 0x00, 0x03, 0x03, 0x00, 0x80, 0x00, 0x60, 0x40, 0x10, 0x00, 0x04,
  0x18, 0x06, 0x00, 0x00, 0xC3, 0x00, 0xC0, 0x00, 0x08, 0x60, 0x18, 0x00,
  0x01, 0x8C, 0x03, 0x00, 0x00, 0x31, 0x80, 0x40, 0x00, 0x02, 0x20, 0x08,
  0x00, 0x00, 0x6C, 0x03, 0x00, 0x00, 0x0D, 0x80, 0x60, 0x00, 0x00, 0xB0,
  0x0C, 0x00, 0x00, 0x1E, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x20, 0x00, 0x00,
  0x30, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xC0, 0x03, 0x00, 0x07, 0x00,
  0x03, 0x00, 0x18, 0x00, 0x03, 0x00, 0x70, 0x00, 0x06, 0x00, 0xC0, 0x00,
  0x06, 0x03, 0x00, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00,
  0x10, 0x20, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00,
  0xC2, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x04,
  0x20, 0x00, 0x00, 0x08, 0x40, 0x00, 0x00, 0x11, 0x80, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x03, 0x10,
  0x00, 0x00, 0x04, 0x20, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x31, 0x80,
  0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x01, 0x08, 0x00,
  0x00, 0x02, 0x10, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x00, 0x18, 0xC0, 0x00,
  0x00, 0x30, 0x80, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x01, 0x82, 0x00, 0x00,
  0x02, 0x04, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00,
  0x60, 0x10, 0x00, 0x01, 0x80, 0x30, 0x00, 0x03, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x60, 0x00, 0x70, 0x00, 0x60, 0x01, 0xC0, 0x00, 0x78, 0x1E, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x08, 0x00, 0x0E, 0x00, 0x20, 0x00, 0x1C,
  0x01, 0x80, 0x00, 0x30, 0x06, 0x00, 0x00, 0x60, 0x18, 0x00, 0x01, 0x80,
  0x40, 0x00, 0x02, 0x01, 0x00, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x30, 0x30,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x03, 0x03, 0x00, 0x00, 0x0C, 0x08, 0x00,
  0x00, 0x20, 0x20, 0x00, 0x00, 0x81, 0x80, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x18, 0x18, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x03, 0x01, 0x00, 0x00, 0x18,
  0x04, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x38, 0x03,
  0x00, 0x03, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3C, 0x07, 0x00, 0x01, 0xC0,
  0x03, 0x00, 0x07, 0x00, 0x03, 0x00, 0x18, 0x00, 0x03, 0x00, 0x70, 0x00,
  0x06, 0x00, 0xC0, 0x00, 0x06, 0x03, 0x00, 0x00, 0x0C, 0x04, 0x00, 0x00,
  0x08, 0x18, 0x00, 0x00, 0x10, 0x20, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x03,
  0x18, 0x00, 0x00, 0x04, 0x20, 0x00, 0x00, 0x08, 0x40, 0x00, 0x00, 0x11,
  0x80, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x01, 0x8C,
  0x00, 0x00, 0x02, 0x10, 0x00, 0x00, 0x04, 0x20, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0x01, 0x08, 0x00, 0x00, 0x02, 0x10, 0x00, 0x00, 0x0C, 0x60, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x00, 0x21, 0x80, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x01, 0x82, 0x00, 0x00, 0x02, 0x04, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00,
  0x10, 0x18, 0x00, 0x00, 0x60, 0x30, 0x00, 0x01, 0x80, 0x30, 0x00, 0x03,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x70, 0x00, 0x60, 0x01, 0xC0,
  0x00, 0x78, 0x1E, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x06, 0x18, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x08, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x30, 0x06,
  0x00, 0x00, 0x60, 0x10, 0x00, 0x00, 0x80, 0x40, 0x00, 0x03, 0x01, 0x00,
  0x00, 0x0C, 0x0C, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x03, 0x02, 0x00, 0x00, 0x0C, 0x08, 0x00, 0x00, 0x30, 0x20, 0x00, 0x00,
  0x81, 0x80, 0x00, 0x02, 0x06, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x40,
  0x40, 0x00, 0x03, 0x01, 0x00, 0x00, 0x08, 0x0C, 0x00, 0x00, 0x60, 0x30,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0x18, 0x03, 0x00, 0x01, 0xC0, 0x0F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x01, 0x00, 0x01, 0x80,
  0x04, 0x00, 0x06, 0x00, 0x30, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x30, 0x03,
  0x00, 0x00, 0x40, 0x08, 0x00, 0x01, 0x80, 0x20, 0x00, 0x06, 0x00, 0x80,
  0x00, 0x08, 0x06, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0xC0, 0x60, 0x00,
  0x01, 0x01, 0x00, 0x00, 0x06, 0x04, 0x00, 0x00, 0x18, 0x10, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x03,
  0x80, 0x1C, 0x00, 0x03, 0x00, 0x30, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x06,
  0x01, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x08, 0x0C, 0x00, 0x00, 0x10,
  0x10, 0x00, 0x00, 0x20, 0x20, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x01, 0x82, 0x00, 0x00, 0x03,
  0x04, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x30,
  0x30, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x01, 0x80, 0x60, 0x00, 0x06, 0x00,
  0x60, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x78, 0x0F, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x0C,
  0x18, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x20, 0x60, 0x00, 0x00, 0x40,
  0x80, 0x00, 0x01, 0x81, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x06, 0x0C,
  0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x10, 0x30, 0x00, 0x00, 0x20, 0x40,
  0x00, 0x00, 0xC0, 0x80, 0x00, 0x01, 0x83, 0x00, 0x00, 0x03, 0x06, 0x00,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0x10, 0x20, 0x00,
  0x00, 0x60, 0x40, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x01, 0x83, 0x00, 0x00,
  0x02, 0x06, 0x00, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x08, 0x10, 0x00, 0x00,
  0x30, 0x20, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x01,
  0x03, 0x00, 0x00, 0x02, 0x04, 0x00, 0x00, 0x04, 0x08, 0x00, 0x00, 0x18,
  0x30, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x81,
  0x80, 0x00, 0x01, 0x03, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x0C, 0x0C,
  0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x60, 0x10, 0x00, 0x01, 0x80, 0x30,
  0x00, 0x07, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x60, 0x00, 0x70, 0x00, 0x60,
  0x01, 0xC0, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x01, 0x98, 0x00, 0x00, 0x04, 0x60, 0x00, 0x00, 0x31, 0x80, 0x00,
  0x00, 0x86, 0x00, 0x00, 0x06, 0x08, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x03, 0x03, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x60,
  0x30, 0x00, 0x03, 0x00, 0x40, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x20, 0x06,
  0x00, 0x01, 0x80, 0x18, 0x00, 0x04, 0x00, 0x60, 0x00, 0x30, 0x01, 0x80,
  0x00, 0x80, 0x06, 0x00, 0x06, 0x00, 0x08, 0x00, 0x18, 0x00, 0x20, 0x00,
  0xC0, 0x00, 0xC0, 0x03, 0x00, 0x03, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x60,
  0x00, 0x30, 0x03, 0x00, 0x00, 0x40, 0x0C, 0x00, 0x01, 0x00, 0x20, 0x00,
  0x04, 0x01, 0x80, 0x00, 0x18, 0x04, 0x00, 0x00, 0x60, 0x30, 0x00, 0x01,
  0x80, 0x80, 0x00, 0x06, 0x06, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0x20,
  0xC0, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x0C, 0x60,
  0x00, 0x00, 0x31, 0x00, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x01, 0x20, 0x00,
  0x00, 0x05, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xA0,
  0x00, 0x06, 0xC0, 0x00, 0x1A, 0x00, 0x00, 0x44, 0x00, 0x01, 0xB0, 0x00,
  0x0C, 0x40, 0x00, 0x13, 0x00, 0x00, 0xC4, 0x00, 0x03, 0x30, 0x00, 0x08,
  0x40, 0x00, 0x23, 0x00, 0x01, 0x86, 0x00, 0x06, 0x30, 0x00, 0x18, 0x60,
  0x00, 0x61, 0x00, 0x03, 0x06, 0x00, 0x04, 0x10, 0x00, 0x30, 0x60, 0x00,
  0xC1, 0x00, 0x02, 0x06, 0x00, 0x08, 0x10, 0x00, 0x60, 0x60, 0x01, 0x81,
  0x00, 0x06, 0x06, 0x00, 0x18, 0x10, 0x00, 0x40, 0x60, 0x01, 0x01, 0x80,
  0x0C, 0x06, 0x00, 0x30, 0x18, 0x00, 0xC0, 0x60, 0x02, 0x01, 0x80, 0x18,
  0x06, 0x00, 0x60, 0x18, 0x01, 0x80, 0x20, 0x06, 0x01, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x18, 0x03, 0x00, 0x20, 0x0C, 0x00, 0x80, 0x30, 0x02, 0x00,
  0x80, 0x08, 0x02, 0x00, 0x30, 0x18, 0x00, 0x80, 0x60, 0x03, 0x01, 0x80,
  0x08, 0x06, 0x00, 0x30, 0x10, 0x00, 0x80, 0xC0, 0x03, 0x03, 0x00, 0x0C,
  0x0C, 0x00, 0x30, 0x20, 0x00, 0xC0, 0x80, 0x03, 0x06, 0x00, 0x0C, 0x18,
  0x00, 0x30, 0x60, 0x00, 0xC1, 0x80, 0x03, 0x04, 0x00, 0x0C, 0x10, 0x00,
  0x30, 0xC0, 0x00, 0xC3, 0x00, 0x03, 0x08, 0x00, 0x0C, 0x30, 0x00, 0x31,
  0x80, 0x00, 0x46, 0x00, 0x01, 0x18, 0x00, 0x04, 0x60, 0x00, 0x11, 0x00,
  0x00, 0x44, 0x00, 0x01, 0x30, 0x00, 0x04, 0xC0, 0x00, 0x12, 0x00, 0x00,
  0x4C, 0x00, 0x01, 0x60, 0x00, 0x06, 0x80, 0x00, 0x16, 0x00, 0x00, 0x78,
  0x00, 0x01, 0x40, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x30, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0x30, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x03, 0x00, 0x06, 0x00, 0x00, 0x30, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x30, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x0C, 0x03,
  0x00, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00,
  0x00, 0x4C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x05, 0x00, 0x00, 0x00, 0x01, 0xB0,
  0x00, 0x00, 0x00, 0x62, 0x00, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00,
  0x04, 0x01, 0x00, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x60, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x60, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x80, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x06, 0x00, 0x18, 0x00, 0x00, 0x40, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x18,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0x98, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x0C, 0x18,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x06, 0x06, 0x00, 0x00, 0x60, 0x18, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x30, 0x06, 0x00, 0x03, 0x00, 0x10, 0x00, 0x18,
  0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x10, 0x00, 0xC0, 0x00,
  0xC0, 0x0C, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x10, 0x06, 0x00, 0x00, 0xC0,
  0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0x10, 0x30, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x06, 0x30, 0x00, 0x00, 0x11, 0x80, 0x00, 0x00, 0x98, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x40, 0x20, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0x40, 0x20, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0x40, 0x20, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x40, 0x20, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0x40, 0x20, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0x40, 0x20, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x40, 0x20, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x1F, 0xE0,
  0x0F, 0xE0, 0x00, 0x00, 0x10, 0x00, 0x38, 0x00, 0x38, 0x00, 0x68, 0x00,
  0x48, 0x00, 0xC8, 0x00, 0x8C, 0x01, 0x8C, 0x01, 0x0C, 0x03, 0x0C, 0x06,
  0x04, 0x06, 0x04, 0x0C, 0x06, 0x0C, 0x06, 0x18, 0x06, 0x18, 0x06, 0x30,
  0x02, 0x30, 0x02, 0x60, 0x03, 0x60, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC1, 0x86, 0x0C, 0x30, 0x60, 0xC3, 0x00,
  0x01, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x70, 0x3C, 0x01, 0xC0, 0x0C, 0x03,
  0x80, 0x06, 0x03, 0x00, 0x02, 0x06, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x0C,
  0x00, 0x03, 0x08, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x3F, 0xFC, 0x01, 0xFF, 0xFC, 0x07, 0x00, 0x04, 0x1C, 0x00, 0x0C, 0x18,
  0x00, 0x0C, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x08, 0x60, 0x00, 0x08, 0xC0,
  0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x38, 0xC0,
  0x00, 0x70, 0xC0, 0x00, 0xD0, 0x40, 0x01, 0xB0, 0x60, 0x07, 0x30, 0x38,
  0x1C, 0x30, 0x1F, 0xF0, 0x30, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x0F, 0xF8, 0x06, 0x38, 0x1C, 0x06, 0xE0, 0x0E, 0x05,
  0x80, 0x06, 0x07, 0x00, 0x03, 0x0E, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x0C,
  0x00, 0x01, 0x08, 0x00, 0x01, 0x08, 0x00, 0x01, 0x08, 0x00, 0x01, 0x18,
  0x00, 0x01, 0x18, 0x00, 0x01, 0x18, 0x00, 0x03, 0x10, 0x00, 0x03, 0x10,
  0x00, 0x03, 0x30, 0x00, 0x03, 0x30, 0x00, 0x03, 0x30, 0x00, 0x02, 0x30,
  0x00, 0x06, 0x20, 0x00, 0x06, 0x20, 0x00, 0x06, 0x60, 0x00, 0x04, 0x60,
  0x00, 0x0C, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x08, 0x60, 0x00, 0x18, 0x60,
  0x00, 0x30, 0xF0, 0x00, 0x30, 0xD0, 0x00, 0x60, 0xCC, 0x00, 0xC0, 0x87,
  0x03, 0x80, 0x83, 0xFE, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0xE0, 0x78, 0x01, 0x80, 0x18, 0x03, 0x00, 0x0C, 0x06,
  0x00, 0x06, 0x0C, 0x00, 0x06, 0x08, 0x00, 0x06, 0x18, 0x00, 0x02, 0x10,
  0x00, 0x02, 0x30, 0x00, 0x02, 0x30, 0x00, 0x02, 0x20, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x18, 0xC0,
  0x00, 0x18, 0xC0, 0x00, 0x10, 0xC0, 0x00, 0x30, 0x40, 0x00, 0x20, 0x60,
  0x00, 0x60, 0x70, 0x00, 0xC0, 0x38, 0x01, 0x80, 0x1E, 0x0F, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x08, 0x02, 0x00, 0x1F, 0xE0, 0x40, 0x0E, 0x07, 0x18, 0x03,
  0x00, 0x33, 0x00, 0xC0, 0x03, 0x60, 0x30, 0x00, 0x2C, 0x04, 0x00, 0x03,
  0x01, 0x80, 0x00, 0x60, 0x20, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0x81, 0x00,
  0x00, 0x30, 0x20, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x81, 0x80, 0x00, 0x10,
  0x20, 0x00, 0x06, 0x04, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x18, 0x30, 0x00,
  0x02, 0x06, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x18, 0x10, 0x00, 0x03, 0x02,
  0x00, 0x00, 0x60, 0x40, 0x00, 0x0C, 0x08, 0x00, 0x01, 0x01, 0x00, 0x00,
  0x20, 0x20, 0x00, 0x0C, 0x04, 0x00, 0x01, 0x80, 0x80, 0x00, 0x30, 0x18,
  0x00, 0x0E, 0x03, 0x00, 0x03, 0x80, 0x30, 0x00, 0xD0, 0x07, 0x00, 0x76,
  0x00, 0x70, 0x38, 0xC0, 0x07, 0xFE, 0x18, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x03, 0xC1, 0xE0, 0x0C, 0x00, 0xC0, 0x30,
  0x00, 0xC0, 0xC0, 0x00, 0xC3, 0x00, 0x01, 0x84, 0x00, 0x03, 0x18, 0x00,
  0x02, 0x20, 0x00, 0x04, 0xC0, 0x00, 0x09, 0x80, 0x00, 0x16, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0xDF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x18, 0x0C, 0x00, 0x60, 0x0E, 0x07, 0x80, 0x0F, 0xFC,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x03, 0x80, 0x03, 0xF8, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04,
  0x00, 0x01, 0x80, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x00, 0xC0, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x01, 0xFE, 0x04, 0x00, 0xE0, 0x71, 0x80, 0x30, 0x03, 0x30,
  0x0C, 0x00, 0x36, 0x03, 0x00, 0x02, 0x80, 0x40, 0x00, 0x70, 0x18, 0x00,
  0x06, 0x02, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x18, 0x18, 0x00, 0x03, 0x02,
  0x00, 0x00, 0x40, 0xC0, 0x00, 0x08, 0x18, 0x00, 0x03, 0x02, 0x00, 0x00,
  0x60, 0x40, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x83, 0x00, 0x00, 0x20, 0x60,
  0x00, 0x04, 0x0C, 0x00, 0x01, 0x81, 0x00, 0x00, 0x30, 0x20, 0x00, 0x06,
  0x04, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x10, 0x10, 0x00, 0x02, 0x02, 0x00,
  0x00, 0xC0, 0x40, 0x00, 0x18, 0x08, 0x00, 0x03, 0x01, 0x80, 0x00, 0xE0,
  0x30, 0x00, 0x38, 0x03, 0x00, 0x0D, 0x00, 0x70, 0x03, 0x60, 0x07, 0x03,
  0x8C, 0x00, 0x7F, 0xE1, 0x80, 0x00, 0x80, 0x30, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x08, 0x00, 0x0C, 0x01, 0x80, 0x03, 0x80, 0x18,
  0x00, 0xE0, 0x03, 0x80, 0x38, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x0F, 0xF8, 0x06, 0x1C,
  0x1C, 0x06, 0x30, 0x04, 0x04, 0x60, 0x06, 0x04, 0x80, 0x02, 0x0D, 0x80,
  0x02, 0x0D, 0x00, 0x03, 0x0E, 0x00, 0x03, 0x0E, 0x00, 0x03, 0x0C, 0x00,
  0x03, 0x0C, 0x00, 0x02, 0x18, 0x00, 0x02, 0x18, 0x00, 0x02, 0x18, 0x00,
  0x06, 0x18, 0x00, 0x06, 0x10, 0x00, 0x06, 0x10, 0x00, 0x06, 0x30, 0x00,
  0x04, 0x30, 0x00, 0x04, 0x30, 0x00, 0x0C, 0x20, 0x00, 0x0C, 0x20, 0x00,
  0x0C, 0x60, 0x00, 0x08, 0x60, 0x00, 0x08, 0x60, 0x00, 0x18, 0x60, 0x00,
  0x18, 0x40, 0x00, 0x18, 0x40, 0x00, 0x18, 0xC0, 0x00, 0x10, 0xC0, 0x00,
  0x10, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x30, 0x80, 0x00, 0x30, 0x01, 0xC0,
  0x70, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x02, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x00, 0x40, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x20, 0x08, 0x06, 0x01, 0x80, 0x60, 0x18, 0x04, 0x01,
  0x00, 0xC0, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x40, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x70, 0x00, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x06, 0x00,
  0x0C, 0x02, 0x00, 0x0C, 0x01, 0x00, 0x0C, 0x01, 0x80, 0x0C, 0x00, 0xC0,
  0x1C, 0x00, 0x60, 0x1C, 0x00, 0x30, 0x1C, 0x00, 0x10, 0x1C, 0x00, 0x08,
  0x18, 0x00, 0x0C, 0x18, 0x00, 0x06, 0x18, 0x00, 0x03, 0x18, 0x00, 0x01,
  0x1C, 0x00, 0x00, 0x9A, 0x00, 0x00, 0x59, 0x80, 0x00, 0x78, 0x40, 0x00,
  0x30, 0x30, 0x00, 0x18, 0x0C, 0x00, 0x08, 0x06, 0x00, 0x04, 0x01, 0x80,
  0x06, 0x00, 0xC0, 0x03, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x40, 0x03, 0x00, 0x20, 0x00, 0xC0, 0x30, 0x00, 0x60, 0x18, 0x00,
  0x18, 0x0C, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x02, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x30, 0x08, 0x02, 0x01, 0x80, 0x60, 0x18, 0x04, 0x01, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x18, 0x06, 0x01, 0x80, 0x60, 0x10,
  0x04, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x40, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x04, 0x01, 0x00, 0xC0, 0x30, 0x0C, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x60, 0xFF, 0x00, 0x3F, 0xE0, 0x0C, 0x70, 0x38,
  0x1E, 0x0E, 0x01, 0x18, 0x03, 0x07, 0x00, 0x60, 0x66, 0x00, 0x31, 0x80,
  0x0C, 0x0D, 0x80, 0x06, 0x60, 0x00, 0xC1, 0xA0, 0x00, 0x48, 0x00, 0x18,
  0x3C, 0x00, 0x0B, 0x00, 0x03, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x38, 0x00, 0x06, 0x00, 0x01, 0x86, 0x00, 0x00,
  0x80, 0x00, 0x30, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x18, 0x00, 0x06, 0x00,
  0x00, 0xC2, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x40, 0x00, 0x18, 0x00, 0x06,
  0x18, 0x00, 0x02, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x40, 0x00, 0x18, 0x60,
  0x00, 0x08, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x41, 0x00, 0x00,
  0x60, 0x00, 0x08, 0x20, 0x00, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x00,
  0x00, 0x61, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x30, 0x00, 0x04, 0x00, 0x01,
  0x86, 0x00, 0x01, 0x80, 0x00, 0x20, 0x80, 0x00, 0x30, 0x00, 0x04, 0x10,
  0x00, 0x06, 0x00, 0x01, 0x86, 0x00, 0x00, 0x80, 0x00, 0x30, 0xC0, 0x00,
  0x10, 0x00, 0x06, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC2, 0x00, 0x00, 0xC0,
  0x00, 0x10, 0x40, 0x00, 0x18, 0x00, 0x02, 0x18, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x06, 0x0F, 0xF8, 0x06, 0x1C, 0x1C, 0x06, 0x30,
  0x0C, 0x04, 0x40, 0x06, 0x04, 0x80, 0x02, 0x0D, 0x80, 0x02, 0x0D, 0x00,
  0x03, 0x0E, 0x00, 0x03, 0x0E, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x0C, 0x00,
  0x02, 0x18, 0x00, 0x02, 0x18, 0x00, 0x02, 0x18, 0x00, 0x06, 0x18, 0x00,
  0x06, 0x10, 0x00, 0x06, 0x10, 0x00, 0x06, 0x30, 0x00, 0x04, 0x30, 0x00,
  0x04, 0x30, 0x00, 0x0C, 0x20, 0x00, 0x0C, 0x20, 0x00, 0x0C, 0x60, 0x00,
  0x08, 0x60, 0x00, 0x08, 0x60, 0x00, 0x18, 0x60, 0x00, 0x18, 0x40, 0x00,
  0x18, 0x40, 0x00, 0x18, 0xC0, 0x00, 0x10, 0xC0, 0x00, 0x10, 0xC0, 0x00,
  0x30, 0xC0, 0x00, 0x30, 0x80, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0xF0, 0x38, 0x01, 0xC0, 0x0C, 0x03, 0x00, 0x06, 0x07, 0x00,
  0x06, 0x06, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x08, 0x00, 0x03, 0x18, 0x00,
  0x01, 0x18, 0x00, 0x01, 0x30, 0x00, 0x01, 0x30, 0x00, 0x01, 0x30, 0x00,
  0x01, 0x20, 0x00, 0x01, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00,
  0x03, 0x60, 0x00, 0x03, 0x40, 0x00, 0x02, 0x40, 0x00, 0x02, 0x40, 0x00,
  0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x04, 0xC0, 0x00, 0x0C, 0x40, 0x00,
  0x0C, 0x40, 0x00, 0x18, 0x60, 0x00, 0x18, 0x60, 0x00, 0x30, 0x20, 0x00,
  0x60, 0x30, 0x00, 0xE0, 0x18, 0x01, 0xC0, 0x0E, 0x07, 0x80, 0x07, 0xFE,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x3F, 0xC0, 0x03,
  0x1C, 0x0E, 0x00, 0x6E, 0x00, 0xE0, 0x0B, 0x00, 0x0C, 0x01, 0xC0, 0x00,
  0xC0, 0x70, 0x00, 0x18, 0x0C, 0x00, 0x01, 0x01, 0x80, 0x00, 0x20, 0x30,
  0x00, 0x04, 0x04, 0x00, 0x00, 0x81, 0x80, 0x00, 0x10, 0x30, 0x00, 0x02,
  0x06, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x08, 0x10, 0x00, 0x03, 0x02, 0x00,
  0x00, 0x60, 0x40, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x83, 0x00, 0x00, 0x20,
  0x60, 0x00, 0x04, 0x08, 0x00, 0x01, 0x81, 0x00, 0x00, 0x30, 0x60, 0x00,
  0x04, 0x0C, 0x00, 0x01, 0x81, 0x80, 0x00, 0x30, 0x30, 0x00, 0x04, 0x06,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x60, 0x3C, 0x00, 0x0C, 0x06, 0x80, 0x03,
  0x00, 0xDC, 0x00, 0xC0, 0x18, 0xE0, 0x70, 0x02, 0x0F, 0xF8, 0x00, 0x40,
  0x10, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x7F,
  0x81, 0x01, 0xC0, 0xE3, 0x03, 0x00, 0x33, 0x06, 0x00, 0x1B, 0x0C, 0x00,
  0x0A, 0x08, 0x00, 0x06, 0x18, 0x00, 0x06, 0x10, 0x00, 0x06, 0x30, 0x00,
  0x06, 0x30, 0x00, 0x06, 0x20, 0x00, 0x04, 0x60, 0x00, 0x04, 0x60, 0x00,
  0x04, 0x40, 0x00, 0x0C, 0x40, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00,
  0x08, 0xC0, 0x00, 0x08, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18, 0x80, 0x00,
  0x18, 0x80, 0x00, 0x18, 0x80, 0x00, 0x10, 0x80, 0x00, 0x10, 0x80, 0x00,
  0x30, 0x80, 0x00, 0x30, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x60, 0xC0, 0x00,
  0xE0, 0x60, 0x01, 0xA0, 0x70, 0x07, 0x60, 0x38, 0x1E, 0x60, 0x1F, 0xF8,
  0x60, 0x01, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x87, 0xF0, 0x63, 0x80, 0x19,
  0x80, 0x04, 0xC0, 0x01, 0x60, 0x00, 0xD0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x7F, 0xC0, 0x03, 0x81, 0xE0, 0x0C, 0x00, 0xE0, 0x30, 0x00, 0xC0,
  0xC0, 0x00, 0xC3, 0x00, 0x01, 0x86, 0x00, 0x03, 0x08, 0x00, 0x06, 0x10,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x23,
  0x00, 0x00, 0x46, 0x00, 0x01, 0x8C, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x18,
  0x00, 0x30, 0x18, 0x00, 0xC0, 0x1C, 0x0F, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0x00, 0x00, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x07, 0xFF, 0xFF, 0xFE, 0x08, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x0C, 0x00, 0x60, 0x01, 0x00, 0x08, 0x00, 0x60, 0x01, 0xF8, 0x02, 0x00,
  0x0C, 0x00, 0x01, 0x0C, 0x00, 0x03, 0x08, 0x00, 0x03, 0x08, 0x00, 0x03,
  0x08, 0x00, 0x03, 0x18, 0x00, 0x02, 0x18, 0x00, 0x02, 0x18, 0x00, 0x06,
  0x10, 0x00, 0x06, 0x10, 0x00, 0x06, 0x30, 0x00, 0x04, 0x30, 0x00, 0x04,
  0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x20, 0x00, 0x0C, 0x20, 0x00, 0x0C,
  0x60, 0x00, 0x08, 0x60, 0x00, 0x08, 0x60, 0x00, 0x18, 0x60, 0x00, 0x18,
  0x40, 0x00, 0x18, 0x40, 0x00, 0x18, 0xC0, 0x00, 0x10, 0xC0, 0x00, 0x30,
  0xC0, 0x00, 0x30, 0xC0, 0x00, 0x70, 0xC0, 0x00, 0x70, 0x40, 0x00, 0xF0,
  0x60, 0x01, 0xA0, 0x60, 0x03, 0x20, 0x30, 0x06, 0x60, 0x38, 0x1C, 0x60,
  0x0F, 0xF0, 0x60, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x05, 0x80, 0x00, 0x1B,
  0x00, 0x00, 0x32, 0x00, 0x00, 0xC4, 0x00, 0x01, 0x8C, 0x00, 0x06, 0x18,
  0x00, 0x0C, 0x30, 0x00, 0x30, 0x60, 0x00, 0x60, 0x40, 0x01, 0x80, 0x80,
  0x03, 0x01, 0x80, 0x0C, 0x03, 0x00, 0x18, 0x06, 0x00, 0x20, 0x0C, 0x00,
  0xC0, 0x18, 0x01, 0x00, 0x10, 0x06, 0x00, 0x20, 0x08, 0x00, 0x60, 0x30,
  0x00, 0xC0, 0x40, 0x01, 0x81, 0x80, 0x03, 0x02, 0x00, 0x02, 0x0C, 0x00,
  0x04, 0x10, 0x00, 0x0C, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x33, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x58, 0x00, 0x00, 0xB0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x78, 0x00, 0x1C,
  0x00, 0x0F, 0x00, 0x03, 0x80, 0x03, 0x60, 0x00, 0xF0, 0x00, 0x6C, 0x00,
  0x16, 0x00, 0x19, 0x80, 0x06, 0xC0, 0x03, 0x10, 0x00, 0xD8, 0x00, 0x42,
  0x00, 0x13, 0x00, 0x18, 0x40, 0x06, 0x60, 0x03, 0x0C, 0x00, 0x84, 0x00,
  0xC1, 0x80, 0x30, 0x80, 0x18, 0x30, 0x06, 0x10, 0x06, 0x06, 0x01, 0x82,
  0x00, 0xC0, 0xC0, 0x30, 0x60, 0x18, 0x18, 0x0C, 0x0C, 0x06, 0x03, 0x01,
  0x81, 0x80, 0xC0, 0x60, 0x20, 0x30, 0x30, 0x0C, 0x0C, 0x06, 0x06, 0x01,
  0x81, 0x00, 0xC1, 0x80, 0x30, 0x60, 0x08, 0x30, 0x02, 0x08, 0x01, 0x06,
  0x00, 0x43, 0x00, 0x21, 0x80, 0x08, 0x60, 0x04, 0x30, 0x01, 0x18, 0x00,
  0x8C, 0x00, 0x33, 0x00, 0x19, 0x80, 0x06, 0x40, 0x03, 0x30, 0x00, 0xD8,
  0x00, 0x6C, 0x00, 0x1A, 0x00, 0x0D, 0x80, 0x03, 0xC0, 0x01, 0xA0, 0x00,
  0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x60, 0x00,
  0x18, 0x06, 0x00, 0x06, 0x00, 0xC0, 0x01, 0x80, 0x0C, 0x00, 0x20, 0x01,
  0x80, 0x0C, 0x00, 0x10, 0x03, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x60, 0x10,
  0x00, 0x06, 0x06, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x0C, 0x60, 0x00, 0x01,
  0x88, 0x00, 0x00, 0x13, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0x40, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x19,
  0x80, 0x00, 0x06, 0x18, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0x20, 0x00,
  0x0C, 0x06, 0x00, 0x03, 0x00, 0x40, 0x00, 0x60, 0x0C, 0x00, 0x18, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x01, 0x80, 0x03, 0x00, 0x30, 0x00, 0x30, 0x0C,
  0x00, 0x06, 0x03, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x06, 0x00, 0x00, 0x20, 0x08, 0x00, 0x01, 0x80, 0x20, 0x00,
  0x04, 0x00, 0xC0, 0x00, 0x30, 0x03, 0x00, 0x00, 0x80, 0x0C, 0x00, 0x06,
  0x00, 0x30, 0x00, 0x10, 0x00, 0x40, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x18, 0x00, 0x18, 0x00, 0x40, 0x00, 0x60, 0x03, 0x00, 0x01,
  0x80, 0x08, 0x00, 0x06, 0x00, 0x60, 0x00, 0x08, 0x01, 0x00, 0x00, 0x20,
  0x0C, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x03, 0x01, 0x80, 0x00, 0x0C, 0x04,
  0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x01, 0x06, 0x00,
  0x00, 0x04, 0x18, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x01, 0x98, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x00,
  0x2C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x5E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0x40, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00,
  0x60, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x40,
  0x00, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x20, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x04, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x20, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x04,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x04, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01,
  0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x00, 0x80, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0xC6, 0x06, 0x00, 0x04, 0x60, 0x18, 0x00,
  0x26, 0x00, 0x60, 0x03, 0x30, 0x01, 0x80, 0x11, 0x00, 0x06, 0x01, 0x98,
  0x00, 0x18, 0x18, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xF0, 0x00,
};

const GFXglyph RobotoCondensed_ThinItalic63pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 10, 46, 11, 1, -45 },
  { 59, 10, 13, 16, 7, -47 },
  { 76, 32, 45, 30, 1, -45 },
  { 256, 26, 59, 30, 2, -52 },
  { 448, 29, 47, 40, 6, -46 },
  { 619, 28, 47, 33, 2, -46 },
  { 784, 5, 13, 10, 6, -47 },
  { 793, 17, 64, 17, 3, -50 },
  { 929, 17, 64, 17, -4, -50 },
  { 1065, 24, 24, 26, 4, -45 },
  { 1137, 25, 34, 30, 3, -38 },
  { 1244, 7, 13, 11, -2, -5 },
  { 1256, 12, 2, 16, 2, -22 },
  { 1259, 4, 4, 13, 1, -3 },
  { 1261, 25, 49, 21, -2, -45 },
  { 1415, 25, 47, 30, 3, -46 },
  { 1562, 13, 45, 30, 9, -45 },
  { 1636, 26, 46, 30, 2, -46 },
  { 1786, 26, 47, 30, 2, -46 },
  { 1939, 26, 45, 30, 1, -45 },
  { 2086, 26, 46, 30, 4, -45 },
  { 2236, 23, 46, 30, 3, -45 },
  { 2369, 24, 45, 30, 6, -45 },
  { 2504, 28, 47, 30, 1, -46 },
  { 2669, 24, 46, 30, 4, -46 },
  { 2807, 9, 33, 11, 1, -32 },
  { 2845, 12, 40, 11, -2, -32 },
  { 2905, 23, 25, 28, 3, -33 },
  { 2977, 24, 15, 30, 3, -28 },
  { 3022, 23, 25, 28, 2, -33 },
  { 3094, 18, 47, 24, 6, -46 },
  { 3200, 44, 57, 49, 2, -43 },
  { 3514, 30, 45, 32, -2, -45 },
  { 3683, 29, 45, 32, 2, -45 },
  { 3847, 29, 47, 35, 4, -46 },
  { 4018, 31, 45, 35, 2, -45 },
  { 4193, 31, 45, 31, 2, -45 },
  { 4368, 31, 45, 31, 2, -45 },
  { 4543, 30, 47, 37, 4, -46 },
  { 4720, 34, 45, 38, 2, -45 },
  { 4912, 10, 45, 15, 3, -45 },
  { 4969, 28, 46, 30, 1, -45 },
  { 5130, 33, 45, 34, 2, -45 },
  { 5316, 21, 45, 28, 2, -45 },
  { 5435, 43, 45, 46, 2, -45 },
  { 5677, 35, 45, 38, 2, -45 },
  { 5874, 31, 47, 36, 3, -46 },
  { 6057, 30, 45, 32, 2, -45 },
  { 6226, 31, 54, 36, 3, -46 },
  { 6436, 30, 45, 35, 2, -45 },
  { 6605, 31, 47, 32, 1, -46 },
  { 6788, 29, 45, 32, 6, -45 },
  { 6952, 31, 46, 36, 4, -45 },
  { 7131, 30, 45, 32, 5, -45 },
  { 7300, 44, 45, 48, 6, -45 },
  { 7548, 35, 45, 32, -1, -45 },
  { 7745, 29, 45, 32, 6, -45 },
  { 7909, 33, 45, 32, 0, -45 },
  { 8095, 16, 61, 12, 1, -51 },
  { 8217, 9, 49, 21, 6, -45 },
  { 8273, 17, 61, 12, -4, -51 },
  { 8403, 16, 22, 23, 4, -45 },
  { 8447, 22, 2, 23, -3, 0 },
  { 8453, 6, 8, 16, 9, -47 },
  { 8459, 24, 35, 29, 1, -34 },
  { 8564, 24, 48, 30, 2, -47 },
  { 8708, 24, 35, 28, 2, -34 },
  { 8813, 27, 48, 30, 3, -47 },
  { 8975, 23, 35, 28, 2, -34 },
  { 9076, 19, 48, 18, 4, -48 },
  { 9190, 27, 47, 30, 0, -34 },
  { 9349, 24, 47, 30, 2, -47 },
  { 9490, 10, 45, 12, 2, -45 },
  { 9547, 20, 58, 12, -8, -45 },
  { 9692, 25, 47, 26, 2, -47 },
  { 9839, 10, 47, 12, 2, -47 },
  { 9898, 43, 34, 48, 1, -34 },
  { 10081, 24, 34, 30, 2, -34 },
  { 10183, 24, 35, 30, 2, -34 },
  { 10288, 27, 47, 30, -1, -34 },
  { 10447, 24, 47, 30, 3, -34 },
  { 10588, 18, 34, 18, 2, -34 },
  { 10665, 23, 35, 27, 1, -34 },
  { 10766, 13, 43, 18, 4, -42 },
  { 10836, 24, 34, 30, 3, -33 },
  { 10938, 23, 33, 26, 4, -33 },
  { 11033, 35, 33, 40, 5, -33 },
  { 11178, 27, 33, 26, -1, -33 },
  { 11290, 30, 46, 26, -3, -33 },
  { 11463, 25, 33, 26, 0, -33 },
  { 11567, 20, 63, 18, 2, -49 },
  { 11725, 10, 53, 12, 1, -45 },
  { 11792, 20, 63, 18, -4, -49 },
  { 11950, 29, 10, 37, 4, -24 },
};

const GFXfont RobotoCondensed_ThinItalic63pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ThinItalic63pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ThinItalic63pt7bGlyphs,
  0x20, 0x7E, 74
};

#endif // _ROBOTOCONDENSED_THINITALIC63PT7B_H_
