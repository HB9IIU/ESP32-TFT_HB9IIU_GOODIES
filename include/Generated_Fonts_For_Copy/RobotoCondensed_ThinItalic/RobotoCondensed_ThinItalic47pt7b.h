#ifndef _ROBOTOCONDENSED_THINITALIC47PT7B_H_
#define _ROBOTOCONDENSED_THINITALIC47PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ThinItalic.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ThinItalic47pt7bBitmaps[] PROGMEM = {
  0x00, 0x02, 0x04, 0x08, 0x30, 0x40, 0x81, 0x02, 0x0C, 0x10, 0x20, 0x40,
  0x81, 0x06, 0x08, 0x10, 0x20, 0x40, 0x83, 0x04, 0x08, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x60, 0xC0, 0x23, 0x62, 0x62, 0x62, 0x42, 0x46,
  0x46, 0xC4, 0xC4, 0x00, 0x0C, 0x0C, 0x00, 0x10, 0x10, 0x00, 0x20, 0x20,
  0x00, 0xC0, 0xC0, 0x01, 0x01, 0x00, 0x02, 0x02, 0x00, 0x0C, 0x0C, 0x00,
  0x10, 0x10, 0x00, 0x20, 0x20, 0x00, 0xC0, 0xC0, 0x3F, 0xFF, 0xF8, 0x02,
  0x02, 0x00, 0x0C, 0x0C, 0x00, 0x10, 0x10, 0x00, 0x20, 0x20, 0x00, 0xC0,
  0xC0, 0x01, 0x01, 0x00, 0x02, 0x02, 0x00, 0x0C, 0x0C, 0x00, 0x10, 0x10,
  0x00, 0x20, 0x20, 0x00, 0x40, 0xC0, 0x01, 0x01, 0x00, 0x7F, 0xFF, 0xF0,
  0x04, 0x0C, 0x00, 0x10, 0x10, 0x00, 0x20, 0x20, 0x00, 0x40, 0xC0, 0x01,
  0x01, 0x00, 0x02, 0x02, 0x00, 0x04, 0x0C, 0x00, 0x10, 0x10, 0x00, 0x20,
  0x20, 0x00, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x07, 0xE0, 0x03, 0x87, 0x00, 0xC0, 0x30, 0x30, 0x02, 0x04, 0x00, 0x41,
  0x00, 0x0C, 0x20, 0x00, 0x84, 0x00, 0x11, 0x80, 0x02, 0x20, 0x00, 0x44,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00,
  0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x40, 0x00, 0xC8, 0x00, 0x19, 0x00,
  0x02, 0x20, 0x00, 0x44, 0x00, 0x18, 0xC0, 0x02, 0x08, 0x00, 0xC0, 0x80,
  0x30, 0x0C, 0x18, 0x00, 0xFC, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18,
  0x00, 0x02, 0x00, 0x00, 0x07, 0x80, 0x00, 0x33, 0x00, 0x01, 0x06, 0x00,
  0x08, 0x08, 0x00, 0x20, 0x20, 0x11, 0x00, 0x80, 0x44, 0x02, 0x02, 0x10,
  0x08, 0x18, 0x40, 0x20, 0xC3, 0x00, 0x82, 0x0C, 0x06, 0x10, 0x30, 0x10,
  0xC0, 0x40, 0xC2, 0x01, 0x02, 0x10, 0x02, 0x30, 0x80, 0x07, 0x86, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x83, 0xC0, 0x06, 0x31, 0x80, 0x10, 0x83, 0x00,
  0x84, 0x04, 0x04, 0x10, 0x10, 0x30, 0x80, 0x40, 0x82, 0x01, 0x04, 0x08,
  0x04, 0x20, 0x20, 0x11, 0x81, 0x80, 0x44, 0x04, 0x02, 0x20, 0x18, 0x08,
  0x00, 0x20, 0x60, 0x00, 0x81, 0x00, 0x01, 0x18, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x03, 0x1C, 0x00, 0x30, 0x20, 0x03, 0x01, 0x80, 0x10, 0x0C,
  0x00, 0x80, 0x60, 0x0C, 0x02, 0x00, 0x40, 0x10, 0x02, 0x01, 0x80, 0x10,
  0x18, 0x00, 0xC1, 0x80, 0x02, 0x18, 0x00, 0x11, 0x80, 0x00, 0xD0, 0x00,
  0x03, 0x00, 0x00, 0x38, 0x00, 0x03, 0x40, 0x00, 0x31, 0x00, 0x03, 0x0C,
  0x02, 0x30, 0x20, 0x13, 0x01, 0x81, 0x90, 0x04, 0x09, 0x80, 0x30, 0x48,
  0x00, 0x86, 0x40, 0x02, 0x22, 0x00, 0x1B, 0x10, 0x00, 0x70, 0x80, 0x03,
  0x04, 0x00, 0x18, 0x30, 0x01, 0x20, 0xC0, 0x11, 0x83, 0x87, 0x04, 0x07,
  0xE0, 0x30, 0x6D, 0x24, 0xB4, 0x80, 0x00, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x0C, 0x00, 0x40, 0x04, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x00,
  0x08, 0x00, 0x80, 0x04, 0x00, 0x60, 0x02, 0x00, 0x10, 0x01, 0x80, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x10, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x00, 0x18,
  0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x03, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x0C, 0x0C, 0x1D, 0xC2, 0x1C,
  0x0E, 0xB8, 0x00, 0xF8, 0x00, 0x18, 0x00, 0x09, 0x00, 0x06, 0x60, 0x03,
  0x08, 0x01, 0x83, 0x00, 0xC0, 0x40, 0x20, 0x18, 0x10, 0x02, 0x00, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x0F, 0xFF, 0xFE, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x10,
  0x84, 0x23, 0x11, 0x98, 0x80, 0xFF, 0x80, 0xF8, 0x00, 0x00, 0x20, 0x00,
  0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00,
  0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06,
  0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20,
  0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00,
  0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x18, 0x60, 0x04, 0x02, 0x01, 0x00, 0x60, 0x40, 0x04, 0x18, 0x00,
  0x82, 0x00, 0x18, 0x40, 0x03, 0x10, 0x00, 0x22, 0x00, 0x04, 0x40, 0x01,
  0x90, 0x00, 0x32, 0x00, 0x06, 0x40, 0x00, 0x88, 0x00, 0x13, 0x00, 0x02,
  0x40, 0x00, 0x48, 0x00, 0x19, 0x00, 0x03, 0x20, 0x00, 0x44, 0x00, 0x09,
  0x80, 0x01, 0x30, 0x00, 0x66, 0x00, 0x08, 0xC0, 0x01, 0x18, 0x00, 0x63,
  0x00, 0x08, 0x20, 0x03, 0x04, 0x00, 0x40, 0xC0, 0x10, 0x08, 0x04, 0x00,
  0xC3, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x40, 0xF0, 0xE5, 0xC1, 0x40, 0xC0,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x18, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x0C, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x80, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x30, 0x08, 0x02, 0x00, 0x80, 0x20, 0x18, 0x00, 0x00,
  0x3F, 0x00, 0x0C, 0x18, 0x01, 0x80, 0xC0, 0x30, 0x06, 0x06, 0x00, 0x20,
  0x40, 0x02, 0x0C, 0x00, 0x20, 0x80, 0x02, 0x18, 0x00, 0x21, 0x80, 0x02,
  0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01,
  0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0x00, 0x0E, 0x1C, 0x01, 0x80, 0x40, 0x30, 0x02, 0x06, 0x00, 0x20, 0x40,
  0x03, 0x0C, 0x00, 0x30, 0x80, 0x03, 0x08, 0x00, 0x30, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x08,
  0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x44, 0x00, 0x04, 0xC0, 0x00,
  0xC4, 0x00, 0x08, 0x40, 0x00, 0x84, 0x00, 0x18, 0x60, 0x01, 0x02, 0x00,
  0x20, 0x30, 0x04, 0x01, 0xC1, 0x80, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x14, 0x00, 0x02, 0x40, 0x00, 0x64,
  0x00, 0x04, 0xC0, 0x00, 0x88, 0x00, 0x10, 0x80, 0x03, 0x08, 0x00, 0x20,
  0x80, 0x04, 0x08, 0x00, 0xC1, 0x80, 0x18, 0x10, 0x01, 0x01, 0x00, 0x20,
  0x10, 0x06, 0x01, 0x00, 0x40, 0x10, 0x08, 0x03, 0x01, 0x80, 0x20, 0x30,
  0x02, 0x02, 0x00, 0x20, 0x40, 0x02, 0x0F, 0xFF, 0xFE, 0x00, 0x06, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x03, 0xFF, 0xF0, 0x20,
  0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x11, 0xF8, 0x01, 0x60, 0xC0, 0x18, 0x06, 0x03, 0x00, 0x30,
  0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x80, 0x01, 0x08, 0x00,
  0x30, 0x80, 0x02, 0x0C, 0x00, 0x60, 0x40, 0x04, 0x04, 0x00, 0xC0, 0x20,
  0x18, 0x03, 0x87, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x0F, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x43, 0xF0, 0x33, 0x06,
  0x09, 0x00, 0xC2, 0x80, 0x10, 0xC0, 0x06, 0x60, 0x00, 0x98, 0x00, 0x24,
  0x00, 0x09, 0x00, 0x02, 0x40, 0x00, 0xB0, 0x00, 0x2C, 0x00, 0x0A, 0x00,
  0x02, 0xC0, 0x01, 0xB0, 0x00, 0x44, 0x00, 0x31, 0x00, 0x08, 0x60, 0x06,
  0x08, 0x01, 0x03, 0x01, 0x80, 0x70, 0xC0, 0x07, 0xC0, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00,
  0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x0E, 0x1C, 0x01, 0x80,
  0x60, 0x30, 0x02, 0x02, 0x00, 0x30, 0x40, 0x01, 0x04, 0x00, 0x10, 0x80,
  0x01, 0x08, 0x00, 0x10, 0x80, 0x01, 0x08, 0x00, 0x30, 0x80, 0x02, 0x0C,
  0x00, 0x60, 0x40, 0x0C, 0x06, 0x01, 0x80, 0x38, 0x70, 0x01, 0xFC, 0x00,
  0x70, 0x60, 0x0C, 0x01, 0x81, 0x00, 0x08, 0x20, 0x00, 0xC6, 0x00, 0x04,
  0x40, 0x00, 0x44, 0x00, 0x04, 0xC0, 0x00, 0x48, 0x00, 0x0C, 0x80, 0x00,
  0x8C, 0x00, 0x08, 0x40, 0x01, 0x06, 0x00, 0x30, 0x30, 0x06, 0x01, 0xC3,
  0x80, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0xE1, 0x80, 0x60, 0x30, 0x30,
  0x06, 0x18, 0x00, 0x84, 0x00, 0x22, 0x00, 0x08, 0x80, 0x03, 0x60, 0x00,
  0xD0, 0x00, 0x34, 0x00, 0x0D, 0x00, 0x03, 0xC0, 0x00, 0xB0, 0x00, 0x2C,
  0x00, 0x19, 0x00, 0x06, 0x40, 0x03, 0x90, 0x01, 0xE6, 0x00, 0xD0, 0xC0,
  0x64, 0x18, 0x71, 0x03, 0xF0, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04,
  0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x7C, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C,
  0x30, 0x03, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x10, 0x10,
  0x30, 0x20, 0x20, 0x60, 0xC0, 0x80, 0x00, 0x00, 0x40, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00,
  0x20, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x10,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x08, 0x00, 0x00, 0x03, 0xE0, 0x30, 0xC1, 0x80, 0x8C,
  0x02, 0x60, 0x0D, 0x00, 0x14, 0x00, 0x70, 0x01, 0x00, 0x0C, 0x00, 0x20,
  0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x80, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x60, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xC1, 0xE0,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0xC0, 0x00, 0x06, 0x01, 0x80, 0x00, 0x02, 0x03, 0x00, 0x00, 0x02,
  0x02, 0x00, 0x00, 0x03, 0x04, 0x00, 0x00, 0x01, 0x0C, 0x00, 0xF8, 0x01,
  0x08, 0x01, 0x8C, 0x01, 0x18, 0x02, 0x02, 0x01, 0x10, 0x04, 0x02, 0x01,
  0x30, 0x08, 0x02, 0x01, 0x20, 0x18, 0x06, 0x01, 0x20, 0x10, 0x04, 0x01,
  0x60, 0x30, 0x04, 0x01, 0x40, 0x20, 0x04, 0x01, 0x40, 0x60, 0x0C, 0x03,
  0xC0, 0x40, 0x08, 0x02, 0x80, 0x40, 0x08, 0x02, 0x80, 0x40, 0x08, 0x02,
  0x80, 0x80, 0x18, 0x06, 0x80, 0x80, 0x10, 0x04, 0x80, 0x80, 0x30, 0x0C,
  0x80, 0x80, 0x30, 0x08, 0x80, 0x80, 0x50, 0x08, 0x80, 0x80, 0xD0, 0x10,
  0x80, 0xC1, 0x90, 0x20, 0x80, 0x63, 0x18, 0xC0, 0x80, 0x3C, 0x0F, 0x80,
  0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x40, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xB0, 0x00, 0x02, 0x40, 0x00, 0x11, 0x00, 0x00, 0x44, 0x00,
  0x02, 0x10, 0x00, 0x08, 0x40, 0x00, 0x41, 0x00, 0x01, 0x06, 0x00, 0x08,
  0x08, 0x00, 0x20, 0x20, 0x01, 0x00, 0x80, 0x04, 0x02, 0x00, 0x20, 0x08,
  0x00, 0x80, 0x20, 0x04, 0x00, 0xC0, 0x10, 0x03, 0x00, 0x80, 0x04, 0x02,
  0x00, 0x10, 0x18, 0x00, 0x40, 0x7F, 0xFF, 0x03, 0x00, 0x04, 0x08, 0x00,
  0x18, 0x60, 0x00, 0x61, 0x00, 0x00, 0x8C, 0x00, 0x02, 0x20, 0x00, 0x09,
  0x80, 0x00, 0x24, 0x00, 0x00, 0xB0, 0x00, 0x02, 0x80, 0x00, 0x0C, 0x07,
  0xFF, 0x00, 0x30, 0x0E, 0x01, 0x00, 0x18, 0x08, 0x00, 0x60, 0x40, 0x01,
  0x02, 0x00, 0x0C, 0x30, 0x00, 0x61, 0x00, 0x03, 0x08, 0x00, 0x10, 0x40,
  0x00, 0x82, 0x00, 0x04, 0x10, 0x00, 0x61, 0x80, 0x02, 0x08, 0x00, 0x20,
  0x40, 0x06, 0x02, 0x00, 0xE0, 0x1F, 0xFE, 0x00, 0x80, 0x1C, 0x0C, 0x00,
  0x30, 0x40, 0x00, 0x82, 0x00, 0x06, 0x10, 0x00, 0x10, 0x80, 0x00, 0x8C,
  0x00, 0x04, 0x40, 0x00, 0x22, 0x00, 0x03, 0x10, 0x00, 0x10, 0x80, 0x01,
  0x84, 0x00, 0x08, 0x60, 0x00, 0xC2, 0x00, 0x0C, 0x10, 0x03, 0x80, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x03, 0x83, 0x80, 0x18, 0x03, 0x01, 0x80,
  0x04, 0x04, 0x00, 0x18, 0x20, 0x00, 0x21, 0x80, 0x00, 0x84, 0x00, 0x03,
  0x30, 0x00, 0x0C, 0x80, 0x00, 0x32, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x08, 0x00, 0x02, 0x20, 0x00, 0x08, 0x80, 0x00, 0x62, 0x00,
  0x01, 0x08, 0x00, 0x0C, 0x30, 0x00, 0x20, 0x40, 0x01, 0x81, 0x80, 0x0C,
  0x03, 0x00, 0x60, 0x07, 0x07, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFF, 0x00,
  0x08, 0x03, 0x80, 0x10, 0x00, 0xC0, 0x20, 0x00, 0x80, 0x40, 0x00, 0x80,
  0x80, 0x01, 0x83, 0x00, 0x01, 0x04, 0x00, 0x02, 0x08, 0x00, 0x04, 0x10,
  0x00, 0x08, 0x20, 0x00, 0x10, 0x40, 0x00, 0x21, 0x80, 0x00, 0x42, 0x00,
  0x00, 0x84, 0x00, 0x01, 0x08, 0x00, 0x02, 0x10, 0x00, 0x0C, 0x60, 0x00,
  0x10, 0xC0, 0x00, 0x21, 0x00, 0x00, 0x42, 0x00, 0x00, 0x84, 0x00, 0x03,
  0x08, 0x00, 0x04, 0x30, 0x00, 0x08, 0x40, 0x00, 0x30, 0x80, 0x00, 0x41,
  0x00, 0x01, 0x82, 0x00, 0x06, 0x04, 0x00, 0x18, 0x18, 0x00, 0x60, 0x20,
  0x01, 0x80, 0x40, 0x1E, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x10,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00,
  0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xE0, 0xE0, 0x06, 0x00, 0x60, 0x18,
  0x00, 0x40, 0x60, 0x00, 0xC0, 0x80, 0x00, 0x82, 0x00, 0x01, 0x0C, 0x00,
  0x02, 0x10, 0x00, 0x04, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x7F, 0xE2, 0x00, 0x00, 0xC4,
  0x00, 0x01, 0x18, 0x00, 0x02, 0x30, 0x00, 0x04, 0x40, 0x00, 0x08, 0xC0,
  0x00, 0x31, 0x80, 0x00, 0x61, 0x00, 0x00, 0x82, 0x00, 0x01, 0x06, 0x00,
  0x02, 0x04, 0x00, 0x18, 0x04, 0x00, 0xE0, 0x06, 0x0F, 0x80, 0x03, 0xF8,
  0x00, 0x06, 0x00, 0x00, 0x82, 0x00, 0x00, 0x41, 0x00, 0x00, 0x20, 0x80,
  0x00, 0x30, 0x40, 0x00, 0x10, 0x20, 0x00, 0x08, 0x30, 0x00, 0x04, 0x10,
  0x00, 0x02, 0x08, 0x00, 0x01, 0x04, 0x00, 0x01, 0x82, 0x00, 0x00, 0x81,
  0x00, 0x00, 0x41, 0x80, 0x00, 0x20, 0x80, 0x00, 0x10, 0x40, 0x00, 0x08,
  0x20, 0x00, 0x0C, 0x1F, 0xFF, 0xFC, 0x18, 0x00, 0x02, 0x0C, 0x00, 0x01,
  0x04, 0x00, 0x00, 0x82, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x40, 0x80, 0x00,
  0x20, 0xC0, 0x00, 0x10, 0x40, 0x00, 0x08, 0x20, 0x00, 0x04, 0x10, 0x00,
  0x06, 0x08, 0x00, 0x02, 0x04, 0x00, 0x01, 0x06, 0x00, 0x00, 0x82, 0x00,
  0x00, 0x41, 0x00, 0x00, 0x20, 0x80, 0x00, 0x30, 0x00, 0x02, 0x04, 0x08,
  0x10, 0x60, 0xC1, 0x02, 0x04, 0x08, 0x30, 0x40, 0x81, 0x02, 0x04, 0x18,
  0x20, 0x40, 0x81, 0x06, 0x0C, 0x10, 0x20, 0x40, 0x83, 0x06, 0x08, 0x10,
  0x20, 0x40, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x08,
  0x00, 0x10, 0x80, 0x01, 0x08, 0x00, 0x30, 0x80, 0x02, 0x0C, 0x00, 0x60,
  0xC0, 0x04, 0x04, 0x00, 0xC0, 0x60, 0x18, 0x03, 0x87, 0x00, 0x0F, 0xC0,
  0x00, 0x06, 0x00, 0x03, 0x04, 0x00, 0x06, 0x04, 0x00, 0x0C, 0x04, 0x00,
  0x18, 0x04, 0x00, 0x30, 0x04, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x08, 0x01,
  0x80, 0x08, 0x03, 0x00, 0x08, 0x06, 0x00, 0x08, 0x0C, 0x00, 0x08, 0x18,
  0x00, 0x18, 0x30, 0x00, 0x10, 0x60, 0x00, 0x10, 0xC0, 0x00, 0x11, 0xC0,
  0x00, 0x12, 0x40, 0x00, 0x34, 0x60, 0x00, 0x38, 0x20, 0x00, 0x30, 0x30,
  0x00, 0x20, 0x10, 0x00, 0x20, 0x08, 0x00, 0x20, 0x0C, 0x00, 0x60, 0x04,
  0x00, 0x40, 0x06, 0x00, 0x40, 0x02, 0x00, 0x40, 0x03, 0x00, 0x40, 0x01,
  0x00, 0x40, 0x01, 0x80, 0xC0, 0x00, 0x80, 0x80, 0x00, 0xC0, 0x80, 0x00,
  0x60, 0x80, 0x00, 0x20, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00,
  0x20, 0x00, 0x40, 0x00, 0xFF, 0xFE, 0x06, 0x00, 0x00, 0x06, 0x0C, 0x00,
  0x00, 0x0C, 0x1C, 0x00, 0x00, 0x28, 0x28, 0x00, 0x00, 0x70, 0x50, 0x00,
  0x01, 0x60, 0xA0, 0x00, 0x02, 0x83, 0x40, 0x00, 0x09, 0x04, 0xC0, 0x00,
  0x12, 0x08, 0x80, 0x00, 0x44, 0x11, 0x00, 0x01, 0x98, 0x22, 0x00, 0x02,
  0x30, 0x44, 0x00, 0x0C, 0x41, 0x8C, 0x00, 0x10, 0x82, 0x08, 0x00, 0x61,
  0x04, 0x10, 0x00, 0x82, 0x08, 0x20, 0x03, 0x0C, 0x10, 0x40, 0x04, 0x10,
  0x20, 0x80, 0x10, 0x20, 0xC1, 0x80, 0x20, 0x41, 0x01, 0x00, 0x80, 0x82,
  0x02, 0x01, 0x03, 0x04, 0x04, 0x04, 0x06, 0x08, 0x08, 0x18, 0x08, 0x30,
  0x18, 0x20, 0x10, 0x60, 0x10, 0xC0, 0x20, 0x80, 0x21, 0x00, 0x41, 0x00,
  0x46, 0x01, 0x82, 0x00, 0x88, 0x03, 0x04, 0x01, 0x30, 0x04, 0x18, 0x01,
  0x40, 0x08, 0x20, 0x03, 0x00, 0x10, 0x40, 0x06, 0x00, 0x20, 0x80, 0x08,
  0x00, 0xC0, 0x06, 0x00, 0x00, 0x83, 0x00, 0x00, 0x41, 0x40, 0x00, 0x20,
  0xA0, 0x00, 0x10, 0x58, 0x00, 0x18, 0x24, 0x00, 0x0C, 0x32, 0x00, 0x04,
  0x18, 0x80, 0x02, 0x08, 0x40, 0x01, 0x04, 0x30, 0x00, 0x82, 0x08, 0x00,
  0xC1, 0x04, 0x00, 0x41, 0x83, 0x00, 0x20, 0xC0, 0x80, 0x10, 0x40, 0x40,
  0x08, 0x20, 0x10, 0x0C, 0x10, 0x08, 0x06, 0x18, 0x06, 0x02, 0x0C, 0x01,
  0x01, 0x04, 0x00, 0x80, 0x82, 0x00, 0x20, 0x41, 0x00, 0x10, 0x60, 0x80,
  0x0C, 0x30, 0xC0, 0x02, 0x10, 0x60, 0x01, 0x08, 0x20, 0x00, 0x44, 0x10,
  0x00, 0x22, 0x08, 0x00, 0x1B, 0x04, 0x00, 0x05, 0x86, 0x00, 0x02, 0x83,
  0x00, 0x00, 0xC1, 0x00, 0x00, 0x60, 0x80, 0x00, 0x30, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0xE0, 0xE0, 0x07, 0x00, 0x60, 0x18, 0x00, 0x60, 0x20, 0x00,
  0x40, 0x80, 0x00, 0xC3, 0x00, 0x00, 0x84, 0x00, 0x01, 0x18, 0x00, 0x02,
  0x20, 0x00, 0x04, 0x40, 0x00, 0x09, 0x80, 0x00, 0x13, 0x00, 0x00, 0x24,
  0x00, 0x00, 0xC8, 0x00, 0x01, 0x90, 0x00, 0x02, 0x20, 0x00, 0x04, 0xC0,
  0x00, 0x09, 0x00, 0x00, 0x12, 0x00, 0x00, 0x64, 0x00, 0x00, 0x88, 0x00,
  0x01, 0x10, 0x00, 0x02, 0x20, 0x00, 0x0C, 0x40, 0x00, 0x10, 0x80, 0x00,
  0x61, 0x00, 0x00, 0x82, 0x00, 0x03, 0x02, 0x00, 0x0C, 0x06, 0x00, 0x30,
  0x06, 0x00, 0xC0, 0x07, 0x07, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xFF, 0x80,
  0x18, 0x03, 0x80, 0x40, 0x03, 0x01, 0x00, 0x06, 0x04, 0x00, 0x08, 0x10,
  0x00, 0x20, 0xC0, 0x00, 0xC2, 0x00, 0x03, 0x08, 0x00, 0x0C, 0x20, 0x00,
  0x30, 0x80, 0x00, 0x82, 0x00, 0x02, 0x18, 0x00, 0x18, 0x40, 0x00, 0x41,
  0x00, 0x03, 0x04, 0x00, 0x18, 0x10, 0x00, 0xC0, 0x40, 0x1E, 0x03, 0xFF,
  0xC0, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xE0, 0xE0, 0x03, 0x00,
  0x60, 0x18, 0x00, 0x60, 0x20, 0x00, 0x40, 0x80, 0x00, 0x83, 0x00, 0x00,
  0x84, 0x00, 0x01, 0x18, 0x00, 0x02, 0x20, 0x00, 0x04, 0x40, 0x00, 0x09,
  0x80, 0x00, 0x13, 0x00, 0x00, 0x24, 0x00, 0x00, 0xC8, 0x00, 0x01, 0x10,
  0x00, 0x02, 0x20, 0x00, 0x04, 0xC0, 0x00, 0x09, 0x00, 0x00, 0x12, 0x00,
  0x00, 0x64, 0x00, 0x00, 0x88, 0x00, 0x01, 0x10, 0x00, 0x02, 0x20, 0x00,
  0x0C, 0x40, 0x00, 0x10, 0x80, 0x00, 0x61, 0x00, 0x00, 0x82, 0x00, 0x03,
  0x02, 0x00, 0x0C, 0x06, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x07, 0x07, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x07, 0xFF, 0x80,
  0x10, 0x03, 0x80, 0x40, 0x03, 0x01, 0x00, 0x06, 0x04, 0x00, 0x08, 0x30,
  0x00, 0x30, 0xC0, 0x00, 0x42, 0x00, 0x01, 0x08, 0x00, 0x04, 0x20, 0x00,
  0x10, 0x80, 0x00, 0x86, 0x00, 0x02, 0x10, 0x00, 0x08, 0x40, 0x00, 0x41,
  0x00, 0x03, 0x04, 0x00, 0x18, 0x10, 0x00, 0xC0, 0xC0, 0x0E, 0x03, 0xFF,
  0xC0, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x18, 0x02, 0x00, 0x20,
  0x18, 0x00, 0xC0, 0x40, 0x01, 0x01, 0x00, 0x04, 0x04, 0x00, 0x18, 0x10,
  0x00, 0x20, 0xC0, 0x00, 0x83, 0x00, 0x03, 0x08, 0x00, 0x04, 0x20, 0x00,
  0x10, 0x80, 0x00, 0x60, 0x00, 0x1F, 0xC0, 0x00, 0xE0, 0xE0, 0x06, 0x00,
  0x60, 0x18, 0x00, 0x40, 0x60, 0x00, 0xC0, 0x80, 0x00, 0x83, 0x00, 0x01,
  0x04, 0x00, 0x02, 0x08, 0x00, 0x04, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x60, 0x00,
  0x08, 0xC0, 0x00, 0x11, 0x80, 0x00, 0x63, 0x00, 0x00, 0x82, 0x00, 0x03,
  0x04, 0x00, 0x04, 0x04, 0x00, 0x10, 0x0C, 0x00, 0xC0, 0x07, 0x07, 0x00,
  0x03, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x02, 0x10, 0x00, 0x04,
  0x20, 0x00, 0x18, 0x40, 0x00, 0x21, 0x80, 0x00, 0x43, 0x00, 0x00, 0x84,
  0x00, 0x01, 0x08, 0x00, 0x02, 0x10, 0x00, 0x0C, 0x20, 0x00, 0x10, 0xC0,
  0x00, 0x21, 0x00, 0x00, 0x42, 0x00, 0x00, 0x84, 0x00, 0x01, 0x08, 0x00,
  0x06, 0x10, 0x00, 0x08, 0x60, 0x00, 0x10, 0x80, 0x00, 0x21, 0x00, 0x00,
  0x42, 0x00, 0x01, 0x84, 0x00, 0x02, 0x18, 0x00, 0x04, 0x20, 0x00, 0x08,
  0x40, 0x00, 0x10, 0x80, 0x00, 0x61, 0x00, 0x00, 0x82, 0x00, 0x01, 0x06,
  0x00, 0x04, 0x04, 0x00, 0x18, 0x0C, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x0E,
  0x0E, 0x00, 0x07, 0xE0, 0x00, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x2C, 0x00,
  0x00, 0x90, 0x00, 0x04, 0x40, 0x00, 0x11, 0x00, 0x00, 0xC4, 0x00, 0x02,
  0x18, 0x00, 0x18, 0x60, 0x00, 0x40, 0x80, 0x03, 0x02, 0x00, 0x08, 0x08,
  0x00, 0x60, 0x20, 0x01, 0x00, 0x80, 0x0C, 0x03, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x04, 0x00, 0x40, 0x10, 0x01, 0x00, 0x80, 0x04, 0x02, 0x00,
  0x18, 0x10, 0x00, 0x60, 0x40, 0x00, 0x83, 0x00, 0x02, 0x08, 0x00, 0x08,
  0x60, 0x00, 0x21, 0x00, 0x00, 0x8C, 0x00, 0x03, 0x20, 0x00, 0x05, 0x80,
  0x00, 0x14, 0x00, 0x00, 0x50, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x02, 0x80, 0x02,
  0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x06, 0x80, 0x04, 0x80, 0x04,
  0x80, 0x04, 0x80, 0x04, 0x80, 0x08, 0x80, 0x0C, 0x80, 0x08, 0x80, 0x08,
  0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x10, 0x40, 0x10, 0xC0, 0x10, 0x40, 0x10,
  0xC0, 0x20, 0x40, 0x30, 0xC0, 0x20, 0x40, 0x20, 0x40, 0x60, 0x40, 0x20,
  0x40, 0x40, 0x40, 0x40, 0x40, 0x40, 0x40, 0x40, 0x40, 0x80, 0x40, 0xC0,
  0x40, 0x80, 0x40, 0x80, 0x41, 0x80, 0x60, 0x80, 0x41, 0x00, 0x61, 0x80,
  0x43, 0x00, 0x61, 0x00, 0x42, 0x00, 0x21, 0x00, 0x42, 0x00, 0x22, 0x00,
  0x66, 0x00, 0x22, 0x00, 0x64, 0x00, 0x26, 0x00, 0x6C, 0x00, 0x24, 0x00,
  0x68, 0x00, 0x24, 0x00, 0x28, 0x00, 0x2C, 0x00, 0x38, 0x00, 0x28, 0x00,
  0x30, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x20, 0x10, 0x00, 0x10, 0x06, 0x00,
  0x0C, 0x00, 0x80, 0x02, 0x00, 0x30, 0x01, 0x00, 0x04, 0x00, 0xC0, 0x01,
  0x00, 0x60, 0x00, 0x60, 0x10, 0x00, 0x08, 0x08, 0x00, 0x03, 0x06, 0x00,
  0x00, 0x43, 0x00, 0x00, 0x10, 0x80, 0x00, 0x02, 0x40, 0x00, 0x00, 0xB0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x80, 0x00, 0x01,
  0x20, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x21, 0x00, 0x00, 0x10, 0x60, 0x00,
  0x08, 0x08, 0x00, 0x06, 0x02, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x80, 0x10,
  0x00, 0x60, 0x06, 0x00, 0x30, 0x00, 0x80, 0x08, 0x00, 0x20, 0x04, 0x00,
  0x04, 0x03, 0x00, 0x01, 0x01, 0x80, 0x00, 0x60, 0x40, 0x00, 0x08, 0x00,
  0x40, 0x00, 0x0D, 0x00, 0x00, 0x26, 0x00, 0x01, 0x88, 0x00, 0x0C, 0x20,
  0x00, 0x20, 0xC0, 0x01, 0x81, 0x00, 0x0C, 0x04, 0x00, 0x20, 0x18, 0x01,
  0x80, 0x20, 0x0C, 0x00, 0x80, 0x20, 0x03, 0x01, 0x80, 0x04, 0x0C, 0x00,
  0x10, 0x20, 0x00, 0x41, 0x00, 0x00, 0x8C, 0x00, 0x02, 0x20, 0x00, 0x09,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x01, 0xF8, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x60, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x03, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00,
  0xC0, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x06, 0x00, 0x30,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x07, 0xC0, 0x00, 0x82, 0x08, 0x30, 0xC1, 0x04, 0x10, 0x41,
  0x06, 0x08, 0x20, 0x82, 0x08, 0x30, 0xC1, 0x04, 0x10, 0x41, 0x06, 0x18,
  0x20, 0x82, 0x08, 0x20, 0xC3, 0x04, 0x10, 0x41, 0x01, 0xF0, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x06, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01,
  0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x60,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x03, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x0F, 0xC0, 0x00, 0x00, 0x80,
  0x18, 0x01, 0x40, 0x34, 0x02, 0x40, 0x64, 0x04, 0x40, 0xC4, 0x08, 0x61,
  0x82, 0x10, 0x23, 0x02, 0x20, 0x26, 0x02, 0x40, 0x3C, 0x01, 0x80, 0x10,
  0xFF, 0xFF, 0x86, 0x18, 0x43, 0x08, 0x00, 0xFC, 0x00, 0xE1, 0xC0, 0x60,
  0x18, 0x30, 0x02, 0x18, 0x00, 0x84, 0x00, 0x21, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x07, 0xFE, 0x0F, 0x01, 0x06,
  0x00, 0x42, 0x00, 0x11, 0x00, 0x04, 0xC0, 0x01, 0x20, 0x00, 0xC8, 0x00,
  0x22, 0x00, 0x18, 0x80, 0x0E, 0x20, 0x06, 0x8C, 0x03, 0x21, 0x83, 0x98,
  0x1F, 0x06, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x30, 0xF8, 0x04, 0x60, 0xC0, 0xB0, 0x0C, 0x1C, 0x00,
  0x83, 0x00, 0x10, 0x40, 0x03, 0x18, 0x00, 0x62, 0x00, 0x0C, 0x40, 0x01,
  0x88, 0x00, 0x31, 0x00, 0x04, 0x20, 0x00, 0x8C, 0x00, 0x11, 0x00, 0x02,
  0x20, 0x00, 0x44, 0x00, 0x18, 0x80, 0x02, 0x10, 0x00, 0x46, 0x00, 0x18,
  0x80, 0x02, 0x18, 0x00, 0xC3, 0x00, 0x10, 0x50, 0x0C, 0x19, 0x83, 0x02,
  0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0xE1, 0xC0, 0x60, 0x18, 0x30, 0x02,
  0x08, 0x00, 0x84, 0x00, 0x31, 0x00, 0x04, 0x80, 0x01, 0x20, 0x00, 0x48,
  0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x44, 0x00, 0x11, 0x00, 0x08,
  0x40, 0x02, 0x18, 0x01, 0x03, 0x00, 0x80, 0x60, 0xC0, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x01, 0xF8, 0x40, 0x70, 0xC4, 0x0C, 0x02, 0x40, 0x80, 0x14, 0x10,
  0x00, 0xC3, 0x00, 0x08, 0x20, 0x00, 0x82, 0x00, 0x08, 0x40, 0x00, 0x84,
  0x00, 0x08, 0x40, 0x01, 0x84, 0x00, 0x10, 0xC0, 0x01, 0x0C, 0x00, 0x10,
  0x80, 0x01, 0x08, 0x00, 0x30, 0x80, 0x02, 0x08, 0x00, 0x20, 0x80, 0x02,
  0x08, 0x00, 0x20, 0xC0, 0x06, 0x04, 0x00, 0xE0, 0x60, 0x14, 0x03, 0x0E,
  0x40, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0xE1, 0xC0, 0x60, 0x18, 0x30,
  0x02, 0x08, 0x00, 0x84, 0x00, 0x33, 0x00, 0x04, 0x80, 0x01, 0x20, 0x00,
  0x58, 0x00, 0x34, 0x00, 0x0D, 0xFF, 0xFF, 0x40, 0x00, 0x10, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x40, 0x70, 0xE0, 0x07, 0xE0,
  0x00, 0x00, 0x7C, 0x07, 0x00, 0x10, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x0F, 0xFE, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x30, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x7E, 0x10, 0x1C, 0x31, 0x03, 0x00, 0x90, 0x60,
  0x05, 0x04, 0x00, 0x70, 0xC0, 0x02, 0x08, 0x00, 0x20, 0x80, 0x02, 0x10,
  0x00, 0x21, 0x00, 0x02, 0x10, 0x00, 0x61, 0x00, 0x04, 0x30, 0x00, 0x43,
  0x00, 0x04, 0x20, 0x00, 0x42, 0x00, 0x04, 0x20, 0x00, 0xC2, 0x00, 0x08,
  0x20, 0x00, 0x82, 0x00, 0x08, 0x30, 0x01, 0x81, 0x00, 0x28, 0x18, 0x05,
  0x80, 0xC1, 0x90, 0x07, 0xE1, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00,
  0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x0C, 0x00, 0xC0, 0x60,
  0x18, 0x03, 0x87, 0x00, 0x0F, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC3, 0xE0, 0x33, 0x86, 0x09, 0x80,
  0x82, 0xC0, 0x10, 0xA0, 0x04, 0x30, 0x01, 0x1C, 0x00, 0x46, 0x00, 0x11,
  0x80, 0x04, 0x40, 0x01, 0x10, 0x00, 0xC4, 0x00, 0x33, 0x00, 0x08, 0x80,
  0x02, 0x20, 0x00, 0x88, 0x00, 0x22, 0x00, 0x18, 0x80, 0x04, 0x60, 0x01,
  0x10, 0x00, 0x44, 0x00, 0x11, 0x00, 0x04, 0x40, 0x03, 0x30, 0x00, 0x8C,
  0x00, 0x20, 0x03, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04,
  0x0C, 0x0C, 0x08, 0x08, 0x08, 0x08, 0x18, 0x18, 0x10, 0x10, 0x10, 0x10,
  0x30, 0x30, 0x20, 0x20, 0x20, 0x20, 0x60, 0x60, 0x40, 0x40, 0x40, 0x40,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0xC0, 0x01,
  0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0xE0, 0x0F, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x30, 0x01, 0x06, 0x00, 0x40, 0x80, 0x10, 0x10, 0x0C, 0x02, 0x03,
  0x00, 0x40, 0xC0, 0x18, 0x30, 0x02, 0x0C, 0x00, 0x43, 0x00, 0x08, 0xC0,
  0x01, 0x30, 0x00, 0x2E, 0x00, 0x0F, 0x60, 0x01, 0x84, 0x00, 0x20, 0xC0,
  0x04, 0x08, 0x00, 0x81, 0x80, 0x10, 0x10, 0x06, 0x03, 0x00, 0x80, 0x20,
  0x10, 0x06, 0x02, 0x00, 0x40, 0x40, 0x0C, 0x18, 0x00, 0x83, 0x00, 0x18,
  0x00, 0x03, 0x03, 0x02, 0x02, 0x02, 0x02, 0x06, 0x06, 0x04, 0x04, 0x04,
  0x04, 0x0C, 0x08, 0x08, 0x08, 0x08, 0x08, 0x18, 0x10, 0x10, 0x10, 0x10,
  0x30, 0x30, 0x20, 0x20, 0x20, 0x20, 0x60, 0x60, 0x40, 0x40, 0x40, 0x40,
  0x08, 0x3E, 0x00, 0xF8, 0x08, 0xC1, 0x83, 0x0C, 0x09, 0x80, 0x8C, 0x02,
  0x0B, 0x00, 0xC8, 0x02, 0x1A, 0x00, 0x50, 0x03, 0x1C, 0x00, 0x60, 0x01,
  0x18, 0x00, 0x60, 0x01, 0x18, 0x00, 0x40, 0x03, 0x10, 0x00, 0x40, 0x03,
  0x10, 0x00, 0xC0, 0x02, 0x30, 0x00, 0xC0, 0x02, 0x30, 0x00, 0x80, 0x02,
  0x20, 0x00, 0x80, 0x02, 0x20, 0x00, 0x80, 0x02, 0x20, 0x00, 0x80, 0x06,
  0x20, 0x01, 0x80, 0x04, 0x60, 0x01, 0x00, 0x04, 0x60, 0x01, 0x00, 0x04,
  0x40, 0x01, 0x00, 0x04, 0x40, 0x01, 0x00, 0x04, 0x40, 0x01, 0x00, 0x0C,
  0x40, 0x03, 0x00, 0x08, 0xC0, 0x02, 0x00, 0x08, 0xC0, 0x02, 0x00, 0x08,
  0x80, 0x02, 0x00, 0x08, 0x0C, 0x3E, 0x02, 0x18, 0x60, 0x98, 0x08, 0x24,
  0x03, 0x0A, 0x00, 0x43, 0x00, 0x11, 0xC0, 0x04, 0x60, 0x01, 0x18, 0x00,
  0x44, 0x00, 0x11, 0x00, 0x0C, 0x40, 0x03, 0x30, 0x00, 0x88, 0x00, 0x22,
  0x00, 0x08, 0x80, 0x02, 0x20, 0x01, 0x98, 0x00, 0x46, 0x00, 0x11, 0x00,
  0x04, 0x40, 0x01, 0x10, 0x00, 0x44, 0x00, 0x33, 0x00, 0x08, 0xC0, 0x02,
  0x00, 0x00, 0xFC, 0x00, 0xC1, 0x80, 0x40, 0x10, 0x20, 0x06, 0x10, 0x00,
  0x8C, 0x00, 0x22, 0x00, 0x0C, 0x80, 0x03, 0x40, 0x00, 0xD0, 0x00, 0x34,
  0x00, 0x0F, 0x00, 0x02, 0xC0, 0x00, 0xA0, 0x00, 0x28, 0x00, 0x0A, 0x00,
  0x06, 0x80, 0x01, 0x20, 0x00, 0x48, 0x00, 0x32, 0x00, 0x08, 0xC0, 0x06,
  0x10, 0x03, 0x06, 0x01, 0x80, 0xE1, 0xC0, 0x0F, 0xC0, 0x00, 0x06, 0x1F,
  0x00, 0x46, 0x0C, 0x05, 0x80, 0x60, 0x70, 0x02, 0x06, 0x00, 0x20, 0x40,
  0x03, 0x0C, 0x00, 0x30, 0x80, 0x03, 0x08, 0x00, 0x30, 0x80, 0x03, 0x08,
  0x00, 0x20, 0x80, 0x02, 0x18, 0x00, 0x21, 0x00, 0x02, 0x10, 0x00, 0x21,
  0x00, 0x06, 0x10, 0x00, 0x41, 0x00, 0x04, 0x30, 0x00, 0xC2, 0x00, 0x08,
  0x30, 0x01, 0x83, 0x00, 0x10, 0x28, 0x06, 0x06, 0x60, 0xC0, 0x61, 0xF0,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x01, 0xF8, 0x41, 0xC3, 0x10, 0xC0, 0x24, 0x60, 0x05, 0x10,
  0x00, 0xCC, 0x00, 0x22, 0x00, 0x08, 0x80, 0x02, 0x60, 0x00, 0x90, 0x00,
  0x24, 0x00, 0x19, 0x00, 0x04, 0xC0, 0x01, 0x30, 0x00, 0x48, 0x00, 0x12,
  0x00, 0x04, 0x80, 0x03, 0x20, 0x00, 0x88, 0x00, 0x22, 0x00, 0x08, 0x80,
  0x06, 0x10, 0x03, 0x86, 0x01, 0x60, 0xC3, 0x90, 0x1F, 0x84, 0x00, 0x01,
  0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x0C, 0x3C, 0x23,
  0x00, 0x90, 0x02, 0x80, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x30, 0x00, 0xC0, 0x00, 0x01, 0xF8, 0x03, 0x83, 0x03, 0x00, 0xC1,
  0x00, 0x31, 0x00, 0x08, 0x80, 0x04, 0x40, 0x02, 0x20, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x90, 0x00, 0x48,
  0x00, 0x46, 0x00, 0x61, 0x80, 0x60, 0x70, 0xE0, 0x0F, 0xC0, 0x00, 0x04,
  0x01, 0x00, 0xC0, 0x30, 0x08, 0x02, 0x00, 0x83, 0xFE, 0x18, 0x06, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x60, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x0C, 0x03, 0x00, 0x80, 0x30,
  0x04, 0x00, 0xF0, 0x18, 0x00, 0x44, 0x00, 0x11, 0x00, 0x04, 0x40, 0x01,
  0x10, 0x00, 0xCC, 0x00, 0x23, 0x00, 0x08, 0x80, 0x02, 0x20, 0x00, 0x88,
  0x00, 0x22, 0x00, 0x19, 0x80, 0x04, 0x40, 0x01, 0x10, 0x00, 0x44, 0x00,
  0x11, 0x00, 0x0C, 0x40, 0x03, 0x30, 0x00, 0x8C, 0x00, 0x63, 0x00, 0x18,
  0x40, 0x0A, 0x10, 0x03, 0x86, 0x03, 0x60, 0xC3, 0x90, 0x1F, 0x84, 0x00,
  0x80, 0x01, 0xC0, 0x00, 0xB0, 0x00, 0xC8, 0x00, 0x44, 0x00, 0x22, 0x00,
  0x21, 0x00, 0x10, 0x80, 0x10, 0x60, 0x08, 0x30, 0x08, 0x08, 0x04, 0x04,
  0x06, 0x02, 0x02, 0x01, 0x03, 0x00, 0xC1, 0x00, 0x61, 0x80, 0x10, 0x80,
  0x08, 0xC0, 0x04, 0x40, 0x02, 0x60, 0x01, 0xA0, 0x00, 0xD0, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x08, 0x00, 0x00, 0x80, 0x0C, 0x00, 0xE0, 0x03, 0x00,
  0x28, 0x01, 0x40, 0x1A, 0x00, 0x50, 0x06, 0x80, 0x34, 0x01, 0x20, 0x09,
  0x00, 0xCC, 0x06, 0x40, 0x23, 0x01, 0x10, 0x18, 0xC0, 0x44, 0x04, 0x30,
  0x21, 0x01, 0x04, 0x08, 0x40, 0xC1, 0x06, 0x10, 0x20, 0x41, 0x06, 0x18,
  0x10, 0xC1, 0x84, 0x04, 0x20, 0x21, 0x01, 0x08, 0x08, 0xC0, 0x44, 0x02,
  0x20, 0x11, 0x00, 0x98, 0x04, 0x80, 0x24, 0x01, 0x20, 0x09, 0x00, 0x58,
  0x02, 0xC0, 0x14, 0x00, 0xA0, 0x05, 0x00, 0x28, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x00, 0x04, 0x00, 0x30, 0x60, 0x02, 0x02, 0x00, 0x40,
  0x20, 0x0C, 0x03, 0x01, 0x80, 0x10, 0x10, 0x01, 0x82, 0x00, 0x08, 0x60,
  0x00, 0xC4, 0x00, 0x04, 0x80, 0x00, 0x58, 0x00, 0x03, 0x00, 0x00, 0x20,
  0x00, 0x07, 0x00, 0x00, 0x90, 0x00, 0x19, 0x80, 0x01, 0x08, 0x00, 0x20,
  0x80, 0x06, 0x04, 0x00, 0xC0, 0x40, 0x08, 0x06, 0x01, 0x00, 0x20, 0x30,
  0x03, 0x06, 0x00, 0x10, 0x40, 0x01, 0x80, 0x04, 0x00, 0x04, 0x18, 0x00,
  0x20, 0x60, 0x00, 0x80, 0x80, 0x06, 0x02, 0x00, 0x10, 0x08, 0x00, 0xC0,
  0x20, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x04, 0x03, 0x00, 0x10,
  0x08, 0x00, 0x40, 0x60, 0x01, 0x01, 0x00, 0x04, 0x0C, 0x00, 0x18, 0x20,
  0x00, 0x21, 0x80, 0x00, 0x84, 0x00, 0x02, 0x30, 0x00, 0x08, 0x80, 0x00,
  0x26, 0x00, 0x00, 0x90, 0x00, 0x03, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x60, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x08, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x04, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x06, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x40, 0x0E, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x30,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x00, 0x06,
  0x00, 0x08, 0x00, 0x30, 0x00, 0x20, 0x00, 0x02, 0x04, 0x08, 0x30, 0x60,
  0xC1, 0x02, 0x04, 0x08, 0x30, 0x60, 0x81, 0x02, 0x04, 0x18, 0x30, 0x60,
  0x81, 0x02, 0x0C, 0x18, 0x30, 0x40, 0x81, 0x02, 0x0C, 0x18, 0x20, 0x40,
  0x81, 0x06, 0x0C, 0x18, 0x20, 0x00, 0x01, 0x00, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x06, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x08,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x00, 0x0F,
  0x00, 0x08, 0xC4, 0x00, 0x48, 0x10, 0x02, 0xC0, 0x40, 0x34, 0x03, 0x01,
  0x60, 0x0C, 0x1A, 0x00, 0x31, 0x90, 0x00, 0xF0,
};

const GFXglyph RobotoCondensed_ThinItalic47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 7, 33, 8, 1, -33 },
  { 30, 8, 9, 12, 5, -35 },
  { 39, 23, 33, 22, 1, -33 },
  { 134, 19, 41, 22, 2, -37 },
  { 232, 22, 33, 30, 4, -33 },
  { 323, 21, 33, 24, 1, -33 },
  { 410, 3, 9, 8, 5, -35 },
  { 414, 13, 48, 12, 2, -37 },
  { 492, 13, 48, 13, -3, -37 },
  { 570, 18, 18, 19, 3, -33 },
  { 611, 19, 25, 23, 2, -28 },
  { 671, 5, 9, 9, -1, -4 },
  { 677, 9, 1, 12, 2, -16 },
  { 679, 3, 2, 10, 1, -2 },
  { 680, 19, 36, 16, -2, -33 },
  { 766, 19, 33, 22, 2, -33 },
  { 845, 10, 33, 22, 6, -33 },
  { 887, 20, 33, 22, 1, -33 },
  { 970, 20, 33, 22, 1, -33 },
  { 1053, 20, 33, 22, 1, -33 },
  { 1136, 20, 33, 22, 3, -33 },
  { 1219, 18, 33, 22, 2, -33 },
  { 1294, 19, 33, 22, 4, -33 },
  { 1373, 20, 33, 22, 1, -33 },
  { 1456, 18, 33, 22, 3, -33 },
  { 1531, 6, 24, 8, 1, -24 },
  { 1549, 8, 29, 8, -1, -24 },
  { 1578, 18, 19, 21, 2, -25 },
  { 1621, 17, 10, 22, 3, -20 },
  { 1643, 18, 19, 21, 1, -25 },
  { 1686, 14, 33, 18, 4, -33 },
  { 1744, 32, 42, 37, 2, -32 },
  { 1912, 22, 33, 24, -1, -33 },
  { 2003, 21, 33, 24, 2, -33 },
  { 2090, 22, 33, 26, 3, -33 },
  { 2181, 23, 33, 26, 2, -33 },
  { 2276, 22, 33, 23, 2, -33 },
  { 2367, 23, 33, 23, 2, -33 },
  { 2462, 23, 33, 27, 3, -33 },
  { 2557, 25, 33, 28, 2, -33 },
  { 2661, 7, 33, 11, 2, -33 },
  { 2690, 20, 33, 22, 1, -33 },
  { 2773, 24, 33, 25, 2, -33 },
  { 2872, 15, 33, 21, 2, -33 },
  { 2934, 31, 33, 34, 2, -33 },
  { 3062, 25, 33, 28, 2, -33 },
  { 3166, 23, 33, 27, 2, -33 },
  { 3261, 22, 33, 24, 2, -33 },
  { 3352, 23, 39, 27, 2, -33 },
  { 3465, 22, 33, 26, 2, -33 },
  { 3556, 23, 33, 24, 1, -33 },
  { 3651, 21, 33, 24, 5, -33 },
  { 3738, 23, 33, 27, 3, -33 },
  { 3833, 22, 33, 24, 4, -33 },
  { 3924, 32, 33, 36, 5, -33 },
  { 4056, 26, 33, 24, -1, -33 },
  { 4164, 22, 33, 24, 4, -33 },
  { 4255, 25, 33, 24, 0, -33 },
  { 4359, 13, 45, 9, 0, -38 },
  { 4433, 6, 36, 16, 5, -33 },
  { 4460, 13, 45, 9, -3, -38 },
  { 4534, 12, 17, 17, 3, -33 },
  { 4560, 16, 1, 17, -2, 0 },
  { 4562, 5, 6, 12, 7, -35 },
  { 4566, 18, 25, 21, 1, -25 },
  { 4623, 19, 35, 22, 1, -35 },
  { 4707, 18, 25, 21, 1, -25 },
  { 4764, 20, 35, 22, 2, -35 },
  { 4852, 18, 25, 21, 1, -25 },
  { 4909, 14, 35, 13, 3, -35 },
  { 4971, 20, 35, 22, 0, -25 },
  { 5059, 18, 35, 22, 1, -35 },
  { 5138, 8, 34, 9, 1, -34 },
  { 5172, 15, 45, 9, -6, -35 },
  { 5257, 19, 35, 19, 1, -35 },
  { 5341, 8, 35, 9, 1, -35 },
  { 5376, 32, 25, 36, 1, -25 },
  { 5476, 18, 25, 22, 1, -25 },
  { 5533, 18, 25, 22, 2, -25 },
  { 5590, 20, 35, 22, 0, -25 },
  { 5678, 18, 35, 22, 2, -25 },
  { 5757, 14, 25, 14, 1, -25 },
  { 5801, 17, 25, 20, 1, -25 },
  { 5855, 10, 32, 13, 3, -32 },
  { 5895, 18, 25, 22, 2, -25 },
  { 5952, 17, 25, 19, 3, -25 },
  { 6006, 26, 25, 30, 4, -25 },
  { 6088, 20, 25, 19, -1, -25 },
  { 6151, 22, 35, 19, -2, -25 },
  { 6248, 19, 25, 19, 0, -25 },
  { 6308, 14, 47, 13, 2, -37 },
  { 6391, 7, 39, 9, 1, -33 },
  { 6426, 15, 47, 13, -3, -37 },
  { 6515, 21, 8, 28, 3, -18 },
};

const GFXfont RobotoCondensed_ThinItalic47pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ThinItalic47pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ThinItalic47pt7bGlyphs,
  0x20, 0x7E, 55
};

#endif // _ROBOTOCONDENSED_THINITALIC47PT7B_H_
