#ifndef _ROBOTOCONDENSED_THINITALIC26PT7B_H_
#define _ROBOTOCONDENSED_THINITALIC26PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ThinItalic.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ThinItalic26pt7bBitmaps[] PROGMEM = {
  0x00, 0x08, 0x84, 0x21, 0x08, 0x44, 0x21, 0x08, 0x42, 0x20, 0x00, 0x00,
  0x10, 0x59, 0x99, 0xA0, 0x01, 0x08, 0x08, 0x80, 0x44, 0x04, 0x20, 0x22,
  0x0F, 0xFC, 0x10, 0x80, 0x88, 0x04, 0x40, 0x42, 0x02, 0x20, 0x11, 0x01,
  0x08, 0x7F, 0xF0, 0x44, 0x04, 0x20, 0x21, 0x01, 0x10, 0x08, 0x80, 0x01,
  0x00, 0x20, 0x1E, 0x0C, 0x21, 0x02, 0x40, 0x48, 0x09, 0x00, 0x20, 0x04,
  0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0x00, 0x20, 0x04, 0x80, 0x90, 0x12,
  0x02, 0x20, 0x83, 0xE0, 0x10, 0x04, 0x00, 0x1C, 0x01, 0x20, 0x10, 0x80,
  0x84, 0x48, 0x44, 0x42, 0x22, 0x12, 0x09, 0x20, 0x71, 0x00, 0x10, 0x01,
  0x1C, 0x09, 0x20, 0x90, 0x88, 0x84, 0x48, 0x24, 0x42, 0x42, 0x10, 0x09,
  0x00, 0x30, 0x07, 0x01, 0x10, 0x42, 0x08, 0x41, 0x08, 0x22, 0x04, 0x80,
  0xA0, 0x08, 0x03, 0x00, 0x90, 0x21, 0x18, 0x23, 0x02, 0x60, 0x54, 0x04,
  0x80, 0x88, 0x68, 0xF1, 0x00, 0xF8, 0x02, 0x08, 0x10, 0x41, 0x02, 0x08,
  0x10, 0x20, 0x81, 0x02, 0x04, 0x08, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x10, 0x20, 0x40, 0x40, 0x80, 0x08, 0x04, 0x02, 0x02, 0x02, 0x02,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x04,
  0x04, 0x04, 0x08, 0x08, 0x10, 0x10, 0x20, 0x40, 0x80, 0x04, 0x02, 0x02,
  0x11, 0x16, 0xF0, 0xC0, 0x60, 0x48, 0x42, 0x41, 0x00, 0x02, 0x00, 0x40,
  0x08, 0x02, 0x00, 0x40, 0x08, 0x3F, 0xF8, 0x20, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x24, 0xA8, 0xF8, 0x80, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x40, 0x08, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0x10, 0x04, 0x00,
  0x80, 0x20, 0x04, 0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x08, 0x00,
  0x07, 0x81, 0x08, 0x41, 0x10, 0x12, 0x02, 0x80, 0x50, 0x0A, 0x02, 0x40,
  0x48, 0x0A, 0x01, 0x40, 0x28, 0x05, 0x01, 0x20, 0x24, 0x08, 0x81, 0x08,
  0x40, 0xF0, 0x00, 0x1B, 0x62, 0x11, 0x08, 0x42, 0x10, 0x88, 0x42, 0x10,
  0x84, 0x42, 0x10, 0x0F, 0x84, 0x12, 0x04, 0x81, 0x40, 0x40, 0x10, 0x04,
  0x02, 0x00, 0x80, 0x40, 0x20, 0x10, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x0F, 0xF8, 0x0F, 0x82, 0x08, 0x81, 0x10, 0x14, 0x02, 0x00, 0x80,
  0x10, 0x02, 0x01, 0x81, 0xC0, 0x04, 0x00, 0x40, 0x04, 0x00, 0xA0, 0x24,
  0x04, 0x80, 0x88, 0x20, 0xF8, 0x00, 0x00, 0x40, 0x30, 0x14, 0x05, 0x02,
  0x81, 0x20, 0x48, 0x22, 0x10, 0x88, 0x22, 0x11, 0x04, 0x81, 0x3F, 0xF0,
  0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x1F, 0xC4, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x04, 0x01, 0x78, 0x61, 0x00, 0x20, 0x08, 0x02, 0x00, 0x80, 0x28,
  0x12, 0x04, 0x81, 0x20, 0x87, 0xC0, 0x03, 0xC1, 0x00, 0x80, 0x40, 0x20,
  0x08, 0x04, 0x01, 0x3C, 0x70, 0x90, 0x14, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x0A, 0x02, 0x41, 0x10, 0x43, 0xE0, 0x7F, 0xC0, 0x10, 0x04, 0x02, 0x01,
  0x00, 0x40, 0x20, 0x08, 0x04, 0x01, 0x00, 0x80, 0x20, 0x10, 0x04, 0x02,
  0x00, 0x80, 0x40, 0x10, 0x08, 0x00, 0x07, 0x83, 0x08, 0x40, 0x90, 0x12,
  0x02, 0x40, 0x48, 0x11, 0x02, 0x20, 0x83, 0xC0, 0xC4, 0x20, 0x48, 0x05,
  0x00, 0xA0, 0x14, 0x04, 0x80, 0x98, 0x60, 0xF0, 0x00, 0x1F, 0x10, 0x50,
  0x28, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x68, 0x53, 0xD0,
  0x08, 0x04, 0x04, 0x04, 0x04, 0x3C, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x42, 0x21, 0x10,
  0x00, 0x40, 0x60, 0x60, 0x60, 0x60, 0x20, 0x06, 0x00, 0x40, 0x0C, 0x00,
  0x80, 0x10, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x40,
  0x18, 0x02, 0x00, 0xC0, 0x10, 0x04, 0x0C, 0x08, 0x18, 0x30, 0x20, 0x00,
  0x1E, 0x21, 0x41, 0x41, 0x81, 0x01, 0x02, 0x02, 0x04, 0x08, 0x10, 0x10,
  0x20, 0x20, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0xFC, 0x00, 0xC0, 0xC0,
  0x40, 0x08, 0x20, 0x02, 0x10, 0x00, 0x44, 0x1C, 0x12, 0x18, 0x84, 0x84,
  0x21, 0x42, 0x08, 0x50, 0x82, 0x18, 0x41, 0x06, 0x10, 0x41, 0x84, 0x10,
  0xA2, 0x04, 0x28, 0x82, 0x0A, 0x20, 0x84, 0x84, 0x62, 0x21, 0xE7, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x03, 0x04, 0x00, 0x3E,
  0x00, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x12, 0x01, 0x20, 0x22, 0x02, 0x20,
  0x42, 0x04, 0x20, 0x42, 0x08, 0x20, 0x81, 0x1F, 0xF1, 0x01, 0x20, 0x12,
  0x01, 0x40, 0x14, 0x01, 0x80, 0x10, 0x1F, 0xC1, 0x02, 0x10, 0x22, 0x01,
  0x20, 0x12, 0x02, 0x20, 0x22, 0x02, 0x20, 0x43, 0xF8, 0x40, 0xC4, 0x04,
  0x40, 0x24, 0x02, 0x40, 0x28, 0x04, 0x80, 0x48, 0x08, 0xFF, 0x00, 0x0F,
  0xC1, 0x02, 0x20, 0x22, 0x01, 0x40, 0x14, 0x01, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x04, 0x80, 0x48, 0x04, 0x80,
  0x84, 0x10, 0x3E, 0x00, 0x1F, 0xC0, 0x81, 0x04, 0x04, 0x40, 0x22, 0x00,
  0x90, 0x04, 0x80, 0x24, 0x01, 0x20, 0x12, 0x00, 0x90, 0x04, 0x80, 0x24,
  0x01, 0x20, 0x11, 0x00, 0x90, 0x08, 0x80, 0x44, 0x0C, 0x3F, 0x80, 0x1F,
  0xF1, 0x00, 0x10, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x03, 0xFC, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80,
  0x08, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0xFE, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x00, 0x07,
  0xC0, 0x82, 0x10, 0x12, 0x01, 0x40, 0x14, 0x00, 0x40, 0x04, 0x00, 0x80,
  0x08, 0x00, 0x83, 0xE8, 0x02, 0x80, 0x28, 0x02, 0x80, 0x28, 0x04, 0x80,
  0x44, 0x08, 0x3F, 0x00, 0x10, 0x04, 0x40, 0x11, 0x00, 0x48, 0x01, 0x20,
  0x08, 0x80, 0x22, 0x00, 0x88, 0x02, 0x20, 0x08, 0xFF, 0xC4, 0x01, 0x10,
  0x04, 0x40, 0x11, 0x00, 0x44, 0x01, 0x20, 0x04, 0x80, 0x22, 0x00, 0x88,
  0x02, 0x00, 0x11, 0x11, 0x12, 0x22, 0x22, 0x24, 0x44, 0x44, 0x48, 0x80,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x80, 0x88, 0x08,
  0x41, 0x04, 0x10, 0x3E, 0x00, 0x10, 0x08, 0x80, 0x84, 0x08, 0x40, 0x82,
  0x08, 0x10, 0x80, 0x88, 0x04, 0x80, 0x28, 0x02, 0xA0, 0x19, 0x00, 0x84,
  0x04, 0x20, 0x20, 0x81, 0x02, 0x10, 0x10, 0x80, 0x44, 0x02, 0x20, 0x08,
  0x10, 0x08, 0x04, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x01, 0x00, 0x80, 0x40, 0x3F, 0xE0, 0x10, 0x00,
  0x88, 0x00, 0x46, 0x00, 0x65, 0x00, 0x52, 0x80, 0x29, 0x40, 0x24, 0xA0,
  0x12, 0x48, 0x12, 0x24, 0x09, 0x22, 0x08, 0x91, 0x04, 0x48, 0x84, 0x24,
  0x42, 0x22, 0x12, 0x11, 0x09, 0x09, 0x05, 0x04, 0x82, 0x82, 0x40, 0x81,
  0x20, 0x41, 0x00, 0x10, 0x04, 0x40, 0x11, 0x80, 0x4A, 0x01, 0x24, 0x04,
  0x90, 0x22, 0x40, 0x88, 0x82, 0x22, 0x09, 0x04, 0x24, 0x10, 0x90, 0x44,
  0x40, 0x91, 0x02, 0x44, 0x05, 0x20, 0x14, 0x80, 0x52, 0x00, 0x88, 0x02,
  0x00, 0x07, 0xE0, 0x40, 0x84, 0x04, 0x20, 0x12, 0x00, 0x90, 0x05, 0x00,
  0x28, 0x01, 0x40, 0x0A, 0x00, 0x50, 0x05, 0x00, 0x28, 0x01, 0x40, 0x0A,
  0x00, 0x88, 0x04, 0x40, 0x41, 0x04, 0x07, 0xC0, 0x1F, 0xC1, 0x02, 0x10,
  0x12, 0x01, 0x20, 0x12, 0x01, 0x20, 0x12, 0x01, 0x20, 0x24, 0x04, 0x7F,
  0x84, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x00, 0x07, 0xE0, 0x40, 0x84, 0x04, 0x20, 0x12, 0x00, 0x90, 0x05, 0x00,
  0x28, 0x01, 0x40, 0x0A, 0x00, 0x90, 0x05, 0x00, 0x28, 0x01, 0x40, 0x0A,
  0x00, 0x88, 0x04, 0x40, 0x41, 0x04, 0x07, 0xC0, 0x01, 0x00, 0x08, 0x00,
  0x20, 0x1F, 0xC1, 0x02, 0x10, 0x12, 0x01, 0x20, 0x12, 0x01, 0x20, 0x12,
  0x01, 0x20, 0x24, 0x04, 0x7F, 0x84, 0x10, 0x41, 0x04, 0x08, 0x40, 0x88,
  0x08, 0x80, 0x48, 0x04, 0x80, 0x40, 0x07, 0xC1, 0x82, 0x20, 0x12, 0x01,
  0x20, 0x12, 0x00, 0x20, 0x03, 0x00, 0x08, 0x00, 0x70, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x02, 0x80, 0x28, 0x04, 0x80, 0x44, 0x18, 0x3E, 0x00, 0xFF,
  0xE0, 0x80, 0x10, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x00, 0x20, 0x12, 0x01, 0x40, 0x14, 0x01, 0x40, 0x14, 0x01, 0x40,
  0x14, 0x02, 0x80, 0x28, 0x02, 0x80, 0x28, 0x02, 0x80, 0x48, 0x04, 0x80,
  0x48, 0x04, 0x80, 0x84, 0x10, 0x3E, 0x00, 0x80, 0x18, 0x01, 0x40, 0x24,
  0x02, 0x40, 0x24, 0x04, 0x40, 0x44, 0x08, 0x40, 0x82, 0x10, 0x21, 0x02,
  0x20, 0x22, 0x02, 0x40, 0x24, 0x02, 0x40, 0x18, 0x01, 0x80, 0x10, 0x00,
  0x80, 0x80, 0x60, 0x60, 0x28, 0x18, 0x0A, 0x06, 0x02, 0x82, 0x41, 0x20,
  0x90, 0x48, 0x24, 0x22, 0x11, 0x08, 0x84, 0x42, 0x22, 0x11, 0x08, 0x84,
  0x42, 0x21, 0x10, 0x90, 0x48, 0x24, 0x12, 0x0A, 0x04, 0x82, 0x80, 0xC0,
  0xA0, 0x30, 0x10, 0x08, 0x04, 0x02, 0x00, 0x10, 0x04, 0x40, 0x20, 0x81,
  0x02, 0x04, 0x08, 0x20, 0x11, 0x00, 0x48, 0x00, 0xA0, 0x03, 0x00, 0x08,
  0x00, 0x30, 0x01, 0x40, 0x08, 0x80, 0x42, 0x01, 0x04, 0x08, 0x10, 0x40,
  0x41, 0x00, 0x88, 0x02, 0x00, 0x40, 0x12, 0x00, 0x90, 0x08, 0x80, 0x82,
  0x04, 0x10, 0x40, 0x84, 0x02, 0x20, 0x12, 0x00, 0xA0, 0x03, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x1F, 0xFC, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x0F, 0xFE, 0x00, 0x0E, 0x10,
  0x20, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x81, 0x02, 0x04, 0x08, 0x10,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x40, 0xE0, 0x92, 0x49, 0x22, 0x49,
  0x24, 0x89, 0x24, 0x92, 0x0E, 0x04, 0x08, 0x10, 0x20, 0x41, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x81, 0x02, 0x04,
  0x08, 0xE0, 0x04, 0x18, 0x30, 0x91, 0x24, 0x48, 0xA1, 0x42, 0xFF, 0x80,
  0x94, 0x0F, 0x84, 0x12, 0x04, 0x81, 0x00, 0x40, 0x11, 0xFC, 0x81, 0x40,
  0x60, 0x28, 0x0A, 0x06, 0x42, 0x8F, 0x20, 0x10, 0x04, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0xF0, 0xC2, 0x20, 0x50, 0x14, 0x05, 0x01, 0x40, 0x60,
  0x18, 0x0A, 0x02, 0x80, 0xA0, 0x4C, 0x32, 0xF0, 0x1F, 0x08, 0x24, 0x09,
  0x01, 0x80, 0x60, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x0A, 0x04, 0x82,
  0x1F, 0x00, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x47, 0xD1,
  0x06, 0x20, 0x48, 0x09, 0x01, 0x40, 0x48, 0x09, 0x01, 0x20, 0x24, 0x04,
  0x80, 0x90, 0x21, 0x0C, 0x1E, 0x80, 0x1F, 0x10, 0x50, 0x28, 0x18, 0x0F,
  0xFE, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x04, 0x31, 0xE0, 0x0E, 0x20,
  0x41, 0x02, 0x04, 0x3E, 0x20, 0x40, 0x81, 0x02, 0x04, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x00, 0x0F, 0xA2, 0x0C, 0x40, 0x90, 0x12, 0x02, 0x80,
  0x90, 0x12, 0x02, 0x40, 0x48, 0x09, 0x01, 0x20, 0x42, 0x18, 0x7D, 0x00,
  0x20, 0x04, 0x01, 0x08, 0x40, 0xF0, 0x00, 0x10, 0x04, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x70, 0xE2, 0x50, 0x58, 0x14, 0x05, 0x01, 0x40, 0x90,
  0x28, 0x0A, 0x02, 0x80, 0xA0, 0x28, 0x12, 0x04, 0x10, 0x00, 0x02, 0x22,
  0x44, 0x44, 0x44, 0x88, 0x88, 0x80, 0x01, 0x00, 0x00, 0x00, 0x00, 0x02,
  0x02, 0x02, 0x04, 0x04, 0x04, 0x04, 0x04, 0x04, 0x08, 0x08, 0x08, 0x08,
  0x08, 0x10, 0x10, 0x10, 0x20, 0xC0, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x0C, 0x84, 0x42, 0x11, 0x04, 0x81, 0x40, 0x70, 0x12, 0x08,
  0x82, 0x10, 0x84, 0x20, 0x88, 0x22, 0x04, 0x11, 0x12, 0x22, 0x22, 0x24,
  0x44, 0x44, 0x48, 0x88, 0x88, 0x2F, 0x0F, 0x18, 0x48, 0x58, 0x18, 0x2C,
  0x08, 0x14, 0x04, 0x0A, 0x04, 0x05, 0x02, 0x02, 0x81, 0x01, 0x80, 0x80,
  0xC0, 0x40, 0xA0, 0x20, 0x50, 0x20, 0x28, 0x10, 0x14, 0x08, 0x08, 0x27,
  0x0E, 0x25, 0x05, 0x81, 0x40, 0x50, 0x14, 0x09, 0x02, 0x80, 0xA0, 0x28,
  0x0A, 0x02, 0x81, 0x20, 0x40, 0x0F, 0x04, 0x22, 0x05, 0x01, 0x40, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x28, 0x0A, 0x04, 0x42, 0x0F, 0x00, 0x17,
  0x83, 0x08, 0x40, 0x90, 0x12, 0x02, 0x40, 0x48, 0x0A, 0x01, 0x40, 0x48,
  0x09, 0x01, 0x20, 0x46, 0x18, 0xBC, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x00, 0x1F, 0x48, 0x32, 0x05, 0x01, 0x40, 0x60, 0x28, 0x0A, 0x02,
  0x80, 0xA0, 0x28, 0x0A, 0x04, 0x43, 0x1F, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x80, 0x20, 0x2E, 0x61, 0x83, 0x04, 0x08, 0x10, 0x20, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x00, 0x0F, 0x84, 0x12, 0x04, 0x81, 0x20, 0x04, 0x00, 0xC0,
  0x0C, 0x00, 0x80, 0x20, 0x0A, 0x02, 0x41, 0x0F, 0x80, 0x21, 0x09, 0xF4,
  0x21, 0x08, 0x42, 0x21, 0x08, 0x42, 0x10, 0xE0, 0x20, 0x48, 0x14, 0x05,
  0x01, 0x40, 0x50, 0x14, 0x09, 0x02, 0x80, 0xA0, 0x28, 0x1A, 0x04, 0x43,
  0x0F, 0x40, 0x80, 0xC0, 0xA0, 0x50, 0x28, 0x24, 0x11, 0x10, 0x88, 0x48,
  0x24, 0x14, 0x0A, 0x06, 0x01, 0x00, 0x81, 0x01, 0x06, 0x0A, 0x0C, 0x14,
  0x28, 0x48, 0x50, 0x90, 0xA2, 0x22, 0x44, 0x44, 0x88, 0x50, 0xA0, 0xA1,
  0x41, 0x83, 0x03, 0x06, 0x04, 0x0C, 0x08, 0x10, 0x00, 0x20, 0x44, 0x08,
  0x42, 0x08, 0x80, 0xA0, 0x14, 0x01, 0x00, 0x60, 0x0A, 0x02, 0x40, 0x88,
  0x20, 0x84, 0x11, 0x01, 0x00, 0x10, 0x11, 0x01, 0x10, 0x21, 0x02, 0x10,
  0x41, 0x04, 0x08, 0x80, 0x88, 0x09, 0x00, 0x90, 0x0A, 0x00, 0xA0, 0x04,
  0x00, 0x40, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0xE0, 0x00, 0x3F, 0xC0,
  0x10, 0x08, 0x04, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x3F, 0xE0, 0x01, 0x06, 0x04, 0x08, 0x08, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x20, 0x20, 0xC0, 0x40, 0x20, 0x20, 0x20, 0x20, 0x40, 0x40,
  0x40, 0x40, 0x40, 0x40, 0x20, 0x10, 0x08, 0x44, 0x21, 0x08, 0x42, 0x21,
  0x08, 0x42, 0x10, 0x88, 0x42, 0x10, 0x84, 0x40, 0x08, 0x04, 0x02, 0x02,
  0x02, 0x02, 0x02, 0x02, 0x02, 0x04, 0x02, 0x02, 0x01, 0x02, 0x04, 0x04,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x20, 0xC0, 0x78, 0x18,
  0x42, 0x82, 0x28, 0x1C,
};

const GFXglyph RobotoCondensed_ThinItalic26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 5, 19, 5, 0, -19 },
  { 13, 4, 5, 7, 3, -20 },
  { 16, 13, 19, 12, 0, -19 },
  { 47, 11, 23, 12, 1, -21 },
  { 79, 13, 19, 16, 2, -19 },
  { 110, 11, 19, 14, 1, -19 },
  { 137, 1, 5, 4, 3, -20 },
  { 138, 7, 27, 7, 1, -21 },
  { 162, 8, 27, 7, -2, -21 },
  { 189, 9, 10, 11, 2, -19 },
  { 201, 11, 13, 12, 1, -15 },
  { 219, 3, 5, 5, -1, -2 },
  { 221, 5, 1, 7, 1, -9 },
  { 222, 1, 1, 5, 1, -1 },
  { 223, 11, 21, 9, -1, -19 },
  { 252, 11, 19, 12, 1, -19 },
  { 279, 5, 19, 12, 4, -19 },
  { 291, 10, 19, 12, 1, -19 },
  { 315, 11, 19, 12, 1, -19 },
  { 342, 10, 19, 12, 1, -19 },
  { 366, 10, 19, 12, 2, -19 },
  { 390, 10, 19, 12, 1, -19 },
  { 414, 10, 19, 12, 2, -19 },
  { 438, 11, 19, 12, 1, -19 },
  { 465, 9, 19, 12, 2, -19 },
  { 487, 4, 13, 5, 0, -13 },
  { 494, 5, 16, 4, -1, -13 },
  { 504, 10, 11, 11, 1, -14 },
  { 518, 10, 7, 12, 1, -12 },
  { 527, 9, 11, 11, 1, -14 },
  { 540, 8, 19, 10, 2, -19 },
  { 559, 18, 24, 20, 1, -18 },
  { 613, 12, 19, 13, -1, -19 },
  { 642, 12, 19, 13, 1, -19 },
  { 671, 12, 19, 14, 2, -19 },
  { 700, 13, 19, 14, 1, -19 },
  { 731, 12, 19, 13, 1, -19 },
  { 760, 13, 19, 13, 1, -19 },
  { 791, 12, 19, 15, 2, -19 },
  { 820, 14, 19, 16, 1, -19 },
  { 854, 4, 19, 6, 1, -19 },
  { 864, 12, 19, 12, 0, -19 },
  { 893, 13, 19, 14, 1, -19 },
  { 924, 9, 19, 12, 1, -19 },
  { 946, 17, 19, 19, 1, -19 },
  { 987, 14, 19, 16, 1, -19 },
  { 1021, 13, 19, 15, 1, -19 },
  { 1052, 12, 19, 13, 1, -19 },
  { 1081, 13, 22, 15, 1, -19 },
  { 1117, 12, 19, 14, 1, -19 },
  { 1146, 12, 19, 13, 1, -19 },
  { 1175, 11, 19, 13, 3, -19 },
  { 1202, 12, 19, 15, 2, -19 },
  { 1231, 12, 19, 13, 2, -19 },
  { 1260, 18, 19, 20, 3, -19 },
  { 1303, 14, 19, 13, 0, -19 },
  { 1337, 13, 19, 13, 2, -19 },
  { 1368, 14, 19, 13, 0, -19 },
  { 1402, 7, 25, 5, 0, -21 },
  { 1424, 3, 21, 9, 3, -19 },
  { 1432, 7, 25, 5, -2, -21 },
  { 1454, 7, 9, 9, 1, -19 },
  { 1462, 9, 1, 9, -1, 0 },
  { 1464, 2, 3, 7, 4, -19 },
  { 1465, 10, 14, 12, 0, -14 },
  { 1483, 10, 20, 12, 1, -20 },
  { 1508, 10, 14, 11, 1, -14 },
  { 1526, 11, 20, 12, 1, -20 },
  { 1554, 9, 14, 11, 1, -14 },
  { 1570, 7, 20, 7, 2, -20 },
  { 1588, 11, 19, 12, 0, -14 },
  { 1615, 10, 20, 12, 1, -20 },
  { 1640, 4, 19, 5, 1, -19 },
  { 1650, 8, 24, 5, -3, -19 },
  { 1674, 10, 20, 11, 1, -20 },
  { 1699, 4, 20, 5, 1, -20 },
  { 1709, 17, 14, 20, 1, -14 },
  { 1739, 10, 14, 12, 1, -14 },
  { 1757, 10, 14, 12, 1, -14 },
  { 1775, 11, 19, 12, 0, -14 },
  { 1802, 10, 19, 12, 1, -14 },
  { 1826, 7, 14, 8, 1, -14 },
  { 1839, 10, 14, 11, 0, -14 },
  { 1857, 5, 17, 7, 2, -17 },
  { 1868, 10, 14, 12, 1, -14 },
  { 1886, 9, 14, 11, 2, -14 },
  { 1902, 15, 14, 17, 2, -14 },
  { 1929, 11, 14, 11, 0, -14 },
  { 1949, 12, 19, 11, -1, -14 },
  { 1978, 10, 14, 11, 0, -14 },
  { 1996, 8, 26, 7, 1, -20 },
  { 2022, 5, 22, 5, 0, -19 },
  { 2036, 8, 26, 7, -2, -20 },
  { 2062, 12, 4, 15, 2, -10 },
};

const GFXfont RobotoCondensed_ThinItalic26pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ThinItalic26pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ThinItalic26pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _ROBOTOCONDENSED_THINITALIC26PT7B_H_
