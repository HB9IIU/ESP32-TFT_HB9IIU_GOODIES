#ifndef _ROBOTOCONDENSED_THINITALIC43PT7B_H_
#define _ROBOTOCONDENSED_THINITALIC43PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ThinItalic.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ThinItalic43pt7bBitmaps[] PROGMEM = {
  0x00, 0x04, 0x10, 0x41, 0x04, 0x30, 0x82, 0x08, 0x20, 0x86, 0x10, 0x41,
  0x04, 0x10, 0xC2, 0x08, 0x20, 0x82, 0x00, 0x00, 0x00, 0x00, 0x03, 0x0C,
  0x00, 0x46, 0x89, 0x12, 0x2C, 0x59, 0xA3, 0x44, 0x88, 0x00, 0x10, 0x30,
  0x00, 0x81, 0x00, 0x04, 0x08, 0x00, 0x40, 0xC0, 0x02, 0x04, 0x00, 0x10,
  0x20, 0x01, 0x01, 0x00, 0x08, 0x10, 0x00, 0x40, 0x80, 0xFF, 0xFF, 0xC0,
  0x20, 0x40, 0x01, 0x02, 0x00, 0x10, 0x10, 0x00, 0x81, 0x00, 0x04, 0x08,
  0x00, 0x60, 0x40, 0x02, 0x06, 0x00, 0x10, 0x20, 0x01, 0x81, 0x00, 0x08,
  0x18, 0x00, 0x40, 0x80, 0x7F, 0xFF, 0xE0, 0x20, 0x60, 0x01, 0x02, 0x00,
  0x08, 0x10, 0x00, 0x81, 0x80, 0x04, 0x08, 0x00, 0x20, 0x40, 0x02, 0x02,
  0x00, 0x10, 0x20, 0x00, 0x81, 0x00, 0x00, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x0F, 0xC0, 0x1C, 0x30, 0x18, 0x04, 0x08, 0x03,
  0x08, 0x00, 0x84, 0x00, 0x44, 0x00, 0x22, 0x00, 0x11, 0x00, 0x08, 0x80,
  0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02,
  0x00, 0x01, 0x20, 0x00, 0x90, 0x00, 0x48, 0x00, 0x24, 0x00, 0x22, 0x00,
  0x11, 0x80, 0x10, 0x60, 0x18, 0x18, 0x30, 0x03, 0xE0, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0F, 0x00, 0x01, 0x88, 0x00, 0x20,
  0xC0, 0x06, 0x04, 0x00, 0x40, 0x40, 0x44, 0x04, 0x0C, 0x80, 0x40, 0x88,
  0x04, 0x10, 0x80, 0x83, 0x08, 0x08, 0x20, 0x80, 0x84, 0x0C, 0x10, 0x80,
  0x42, 0x08, 0x03, 0xC1, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x3C, 0x01, 0x84, 0x20, 0x10, 0x81, 0x02, 0x18, 0x10, 0x41,
  0x01, 0x04, 0x10, 0x10, 0x82, 0x01, 0x10, 0x20, 0x13, 0x02, 0x03, 0x20,
  0x20, 0x20, 0x02, 0x02, 0x00, 0x30, 0x40, 0x01, 0x88, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x18, 0xC0, 0x06, 0x0C, 0x00, 0x80, 0x80, 0x20, 0x10,
  0x04, 0x02, 0x00, 0x80, 0x40, 0x30, 0x10, 0x06, 0x06, 0x00, 0x40, 0x80,
  0x08, 0x20, 0x01, 0x18, 0x00, 0x16, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x14, 0x00, 0x0C, 0x40, 0x01, 0x0C, 0x04, 0x40, 0x80, 0x90, 0x18, 0x36,
  0x01, 0x04, 0x80, 0x10, 0x90, 0x02, 0x32, 0x00, 0x24, 0xC0, 0x07, 0x98,
  0x00, 0x61, 0x00, 0x0C, 0x20, 0x02, 0x82, 0x00, 0x98, 0x70, 0x61, 0x03,
  0xF0, 0x10, 0x24, 0xB6, 0x92, 0x40, 0x00, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x10, 0x02, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x08, 0x00, 0x80,
  0x10, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0x80,
  0x02, 0x00, 0x20, 0x06, 0x00, 0x40, 0x08, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x06, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x03, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x08, 0x03, 0x00, 0x40, 0x08,
  0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0x20, 0x0C, 0x03, 0x00, 0x40,
  0x00, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x01,
  0x80, 0xC1, 0x07, 0x39, 0x38, 0x0F, 0xE0, 0x03, 0x00, 0x07, 0x80, 0x04,
  0x80, 0x08, 0x40, 0x10, 0x40, 0x30, 0x20, 0x60, 0x30, 0x40, 0x10, 0x00,
  0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x1F, 0xFF,
  0xF0, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x11, 0x13, 0x22, 0x6C, 0x80, 0xFF, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x20,
  0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00,
  0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0xC3, 0x00, 0x80, 0xC0, 0x80, 0x20, 0xC0, 0x18, 0x40,
  0x04, 0x40, 0x02, 0x20, 0x01, 0x10, 0x00, 0x90, 0x00, 0x48, 0x00, 0x24,
  0x00, 0x16, 0x00, 0x0A, 0x00, 0x0D, 0x00, 0x04, 0x80, 0x02, 0x40, 0x01,
  0x20, 0x00, 0xB0, 0x00, 0xD0, 0x00, 0x48, 0x00, 0x24, 0x00, 0x12, 0x00,
  0x19, 0x00, 0x08, 0x80, 0x04, 0x60, 0x04, 0x10, 0x02, 0x08, 0x02, 0x06,
  0x02, 0x01, 0x86, 0x00, 0x7E, 0x00, 0x01, 0x83, 0xC6, 0x7C, 0x28, 0x10,
  0x08, 0x04, 0x02, 0x03, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x18, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0xC0, 0x40, 0x20, 0x10, 0x08, 0x04, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x00, 0x7C, 0x00, 0x60, 0xC0, 0x20, 0x18,
  0x18, 0x02, 0x0C, 0x00, 0x82, 0x00, 0x20, 0x80, 0x0C, 0x40, 0x03, 0x10,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x10, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x7E, 0x00, 0x60, 0xC0, 0x30, 0x18, 0x18, 0x02,
  0x0C, 0x00, 0xC2, 0x00, 0x10, 0x80, 0x04, 0x40, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x01, 0x80, 0x01,
  0xC0, 0x07, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x4C, 0x00, 0x13, 0x00, 0x04, 0xC0, 0x01, 0x10,
  0x00, 0x84, 0x00, 0x21, 0x80, 0x10, 0x30, 0x08, 0x06, 0x0C, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x28, 0x00, 0x16, 0x00, 0x0D,
  0x00, 0x02, 0x40, 0x01, 0x10, 0x00, 0xC4, 0x00, 0x21, 0x00, 0x10, 0x80,
  0x08, 0x20, 0x06, 0x08, 0x01, 0x02, 0x00, 0x80, 0x80, 0x60, 0x20, 0x30,
  0x10, 0x08, 0x04, 0x04, 0x01, 0x03, 0x00, 0x40, 0x80, 0x10, 0x40, 0x0C,
  0x3F, 0xFF, 0xF0, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x07,
  0xFF, 0xC1, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0x4F, 0x80, 0x2C, 0x18, 0x0C, 0x02, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01,
  0x80, 0x00, 0x42, 0x00, 0x10, 0x80, 0x04, 0x20, 0x02, 0x08, 0x00, 0x83,
  0x00, 0x40, 0x40, 0x30, 0x0C, 0x38, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x00,
  0x70, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x21, 0xF0, 0x26, 0x0C, 0x68,
  0x06, 0x50, 0x02, 0x60, 0x02, 0x60, 0x03, 0x40, 0x01, 0x40, 0x01, 0x80,
  0x01, 0x80, 0x03, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x06, 0xC0,
  0x04, 0x40, 0x0C, 0x60, 0x08, 0x20, 0x10, 0x18, 0x60, 0x0F, 0xC0, 0xFF,
  0xFF, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20,
  0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x08, 0x00, 0x08, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x38, 0x60, 0x0C, 0x02,
  0x03, 0x00, 0x60, 0x40, 0x04, 0x18, 0x00, 0x82, 0x00, 0x10, 0x40, 0x02,
  0x08, 0x00, 0x43, 0x00, 0x08, 0x60, 0x03, 0x04, 0x00, 0x40, 0x80, 0x10,
  0x08, 0x06, 0x00, 0xC3, 0x00, 0x0F, 0x80, 0x06, 0x0C, 0x03, 0x00, 0x40,
  0xC0, 0x0C, 0x10, 0x00, 0x84, 0x00, 0x10, 0x80, 0x03, 0x20, 0x00, 0x44,
  0x00, 0x08, 0x80, 0x01, 0x10, 0x00, 0x63, 0x00, 0x08, 0x20, 0x02, 0x06,
  0x00, 0x80, 0x70, 0x60, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x06, 0x0C, 0x0C,
  0x06, 0x18, 0x02, 0x10, 0x02, 0x20, 0x03, 0x20, 0x01, 0x40, 0x01, 0x40,
  0x01, 0x40, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x02, 0x80,
  0x02, 0xC0, 0x06, 0x40, 0x0A, 0x40, 0x1E, 0x60, 0x34, 0x30, 0x64, 0x0F,
  0x84, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x0E, 0x00, 0x78, 0x00, 0x0C, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x10, 0x10, 0x30, 0x30, 0x20, 0x60, 0x40, 0xC0, 0x80, 0x00, 0x01, 0x00,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x38, 0x00, 0x08, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFE, 0x10, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x00, 0x80, 0x00, 0x07, 0xC0, 0xC3,
  0x0C, 0x0C, 0x40, 0x24, 0x01, 0x20, 0x0A, 0x00, 0x50, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x01, 0xC0, 0x06, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x10, 0x03, 0x00, 0x00, 0x20, 0x18,
  0x00, 0x00, 0x80, 0xC0, 0x00, 0x01, 0x02, 0x00, 0x00, 0x04, 0x10, 0x03,
  0xC0, 0x10, 0xC0, 0x30, 0x80, 0x42, 0x01, 0x81, 0x01, 0x18, 0x0C, 0x04,
  0x04, 0x40, 0x20, 0x10, 0x11, 0x01, 0x00, 0xC0, 0x4C, 0x0C, 0x02, 0x01,
  0x20, 0x20, 0x08, 0x04, 0x80, 0x80, 0x20, 0x16, 0x04, 0x01, 0x80, 0x50,
  0x10, 0x04, 0x02, 0x40, 0x40, 0x10, 0x09, 0x03, 0x00, 0x40, 0x24, 0x08,
  0x03, 0x01, 0x90, 0x20, 0x08, 0x04, 0x40, 0x80, 0x60, 0x13, 0x02, 0x01,
  0x80, 0x8C, 0x08, 0x0A, 0x02, 0x10, 0x30, 0x48, 0x10, 0x40, 0x42, 0x11,
  0x81, 0x00, 0xF0, 0x3C, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x01, 0x00, 0x00, 0x38,
  0x38, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x05, 0x00, 0x00, 0x50, 0x00, 0x09, 0x00, 0x00, 0x90, 0x00, 0x10, 0x80,
  0x01, 0x08, 0x00, 0x30, 0x80, 0x02, 0x08, 0x00, 0x60, 0x80, 0x04, 0x08,
  0x00, 0x40, 0x80, 0x08, 0x0C, 0x00, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x20, 0x04, 0x02, 0x00, 0x40, 0x40, 0x04, 0x04, 0x00, 0x60, 0xFF,
  0xFE, 0x08, 0x00, 0x21, 0x00, 0x02, 0x10, 0x00, 0x23, 0x00, 0x02, 0x20,
  0x00, 0x26, 0x00, 0x02, 0x40, 0x00, 0x3C, 0x00, 0x01, 0x80, 0x00, 0x10,
  0x07, 0xFE, 0x00, 0x80, 0x60, 0x30, 0x02, 0x04, 0x00, 0x20, 0x80, 0x04,
  0x10, 0x00, 0x42, 0x00, 0x08, 0x40, 0x01, 0x18, 0x00, 0x42, 0x00, 0x08,
  0x40, 0x01, 0x08, 0x00, 0x41, 0x00, 0x18, 0x20, 0x06, 0x0C, 0x03, 0x81,
  0xFF, 0xC0, 0x20, 0x06, 0x04, 0x00, 0x60, 0x80, 0x06, 0x10, 0x00, 0x46,
  0x00, 0x08, 0x80, 0x01, 0x10, 0x00, 0x22, 0x00, 0x04, 0x40, 0x00, 0x88,
  0x00, 0x23, 0x00, 0x0C, 0x40, 0x01, 0x08, 0x00, 0x41, 0x00, 0x30, 0x3F,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x06, 0x06, 0x00, 0x40, 0x18, 0x04, 0x00,
  0x60, 0x40, 0x01, 0x04, 0x00, 0x08, 0x20, 0x00, 0x42, 0x00, 0x03, 0x10,
  0x00, 0x18, 0x80, 0x00, 0xC8, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x21,
  0x00, 0x01, 0x08, 0x00, 0x08, 0x40, 0x00, 0x82, 0x00, 0x04, 0x18, 0x00,
  0x40, 0x40, 0x06, 0x03, 0x00, 0x60, 0x0E, 0x0C, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xFE, 0x00, 0x20, 0x1C, 0x03, 0x00, 0x30, 0x10, 0x00, 0xC0, 0x80,
  0x02, 0x04, 0x00, 0x18, 0x20, 0x00, 0x41, 0x00, 0x02, 0x18, 0x00, 0x10,
  0x80, 0x00, 0x84, 0x00, 0x04, 0x20, 0x00, 0x21, 0x00, 0x01, 0x08, 0x00,
  0x08, 0xC0, 0x00, 0x44, 0x00, 0x06, 0x20, 0x00, 0x21, 0x00, 0x01, 0x08,
  0x00, 0x08, 0x40, 0x00, 0x46, 0x00, 0x06, 0x20, 0x00, 0x21, 0x00, 0x01,
  0x08, 0x00, 0x18, 0x40, 0x00, 0x82, 0x00, 0x08, 0x30, 0x00, 0xC1, 0x00,
  0x0C, 0x08, 0x00, 0xC0, 0x40, 0x18, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xF0, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x10,
  0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03,
  0xFF, 0xF0, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x20, 0x00, 0x03, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x1C, 0x1C, 0x03, 0x00, 0x60, 0x60, 0x02,
  0x0C, 0x00, 0x30, 0x80, 0x01, 0x10, 0x00, 0x11, 0x00, 0x01, 0x20, 0x00,
  0x12, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x03, 0xFE, 0x80,
  0x00, 0x68, 0x00, 0x04, 0x80, 0x00, 0x48, 0x00, 0x04, 0x80, 0x00, 0x48,
  0x00, 0x0C, 0x80, 0x00, 0xCC, 0x00, 0x08, 0x40, 0x00, 0x86, 0x00, 0x18,
  0x30, 0x07, 0x01, 0x81, 0xC0, 0x07, 0xF0, 0x00, 0x04, 0x00, 0x02, 0x08,
  0x00, 0x04, 0x30, 0x00, 0x18, 0x40, 0x00, 0x20, 0x80, 0x00, 0x41, 0x00,
  0x00, 0x82, 0x00, 0x01, 0x04, 0x00, 0x02, 0x18, 0x00, 0x08, 0x20, 0x00,
  0x10, 0x40, 0x00, 0x20, 0x80, 0x00, 0x41, 0x00, 0x00, 0x82, 0x00, 0x01,
  0x0C, 0x00, 0x04, 0x1F, 0xFF, 0xF8, 0x20, 0x00, 0x10, 0x40, 0x00, 0x20,
  0x80, 0x00, 0x41, 0x00, 0x01, 0x86, 0x00, 0x02, 0x08, 0x00, 0x04, 0x10,
  0x00, 0x08, 0x20, 0x00, 0x10, 0x40, 0x00, 0x20, 0x80, 0x00, 0xC3, 0x00,
  0x01, 0x04, 0x00, 0x02, 0x08, 0x00, 0x04, 0x10, 0x00, 0x08, 0x20, 0x00,
  0x10, 0x00, 0x06, 0x08, 0x10, 0x20, 0x40, 0x83, 0x04, 0x08, 0x10, 0x20,
  0x41, 0x82, 0x04, 0x08, 0x10, 0x20, 0xC1, 0x02, 0x04, 0x08, 0x10, 0x60,
  0x81, 0x02, 0x04, 0x18, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x20, 0x00,
  0x84, 0x00, 0x20, 0x80, 0x04, 0x10, 0x01, 0x82, 0x00, 0x20, 0x20, 0x08,
  0x04, 0x03, 0x00, 0x60, 0xC0, 0x07, 0xE0, 0x00, 0x04, 0x00, 0x0C, 0x10,
  0x00, 0x60, 0xC0, 0x03, 0x02, 0x00, 0x18, 0x08, 0x00, 0xC0, 0x20, 0x06,
  0x00, 0x80, 0x30, 0x02, 0x01, 0x80, 0x18, 0x0C, 0x00, 0x40, 0x60, 0x01,
  0x03, 0x00, 0x04, 0x18, 0x00, 0x10, 0xC0, 0x00, 0x46, 0x00, 0x03, 0x38,
  0x00, 0x09, 0xA0, 0x00, 0x2C, 0xC0, 0x00, 0xE1, 0x00, 0x02, 0x02, 0x00,
  0x08, 0x08, 0x00, 0x60, 0x10, 0x01, 0x00, 0x40, 0x04, 0x00, 0x80, 0x10,
  0x03, 0x00, 0x40, 0x04, 0x01, 0x00, 0x18, 0x0C, 0x00, 0x20, 0x20, 0x00,
  0xC0, 0x80, 0x01, 0x02, 0x00, 0x06, 0x08, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x10, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x18, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x0F, 0xFF, 0xC0, 0x06, 0x00, 0x00, 0x10, 0x60, 0x00, 0x03,
  0x0E, 0x00, 0x00, 0x30, 0xA0, 0x00, 0x05, 0x0A, 0x00, 0x00, 0x50, 0xA0,
  0x00, 0x0B, 0x09, 0x00, 0x01, 0xA0, 0x90, 0x00, 0x12, 0x19, 0x00, 0x03,
  0x21, 0x10, 0x00, 0x22, 0x11, 0x00, 0x06, 0x21, 0x10, 0x00, 0x46, 0x10,
  0x80, 0x0C, 0x41, 0x08, 0x00, 0x84, 0x30, 0x80, 0x10, 0x42, 0x08, 0x01,
  0x04, 0x20, 0x80, 0x20, 0x42, 0x04, 0x02, 0x0C, 0x20, 0x40, 0x40, 0x82,
  0x04, 0x04, 0x08, 0x60, 0x40, 0x80, 0x84, 0x04, 0x08, 0x08, 0x40, 0x41,
  0x00, 0x84, 0x02, 0x10, 0x18, 0x40, 0x22, 0x01, 0x04, 0x02, 0x60, 0x10,
  0xC0, 0x24, 0x01, 0x08, 0x02, 0xC0, 0x10, 0x80, 0x18, 0x03, 0x08, 0x01,
  0x80, 0x20, 0x80, 0x10, 0x02, 0x00, 0x04, 0x00, 0x02, 0x0C, 0x00, 0x04,
  0x38, 0x00, 0x08, 0x70, 0x00, 0x30, 0x90, 0x00, 0x41, 0x20, 0x00, 0x82,
  0x60, 0x01, 0x04, 0x40, 0x02, 0x18, 0x80, 0x04, 0x30, 0x80, 0x18, 0x41,
  0x00, 0x20, 0x82, 0x00, 0x41, 0x02, 0x00, 0x82, 0x04, 0x01, 0x0C, 0x0C,
  0x06, 0x10, 0x08, 0x0C, 0x20, 0x10, 0x10, 0x40, 0x10, 0x20, 0x80, 0x20,
  0x41, 0x00, 0x60, 0x86, 0x00, 0x43, 0x08, 0x00, 0x86, 0x10, 0x00, 0x88,
  0x20, 0x01, 0x10, 0x40, 0x02, 0x20, 0x80, 0x02, 0x43, 0x00, 0x05, 0x84,
  0x00, 0x0F, 0x08, 0x00, 0x0C, 0x10, 0x00, 0x18, 0x20, 0x00, 0x10, 0x00,
  0x00, 0x3F, 0x00, 0x06, 0x06, 0x00, 0x40, 0x18, 0x04, 0x00, 0x60, 0x40,
  0x01, 0x04, 0x00, 0x0C, 0x20, 0x00, 0x22, 0x00, 0x01, 0x10, 0x00, 0x09,
  0x80, 0x00, 0x48, 0x00, 0x02, 0x40, 0x00, 0x12, 0x00, 0x01, 0x90, 0x00,
  0x09, 0x80, 0x00, 0x48, 0x00, 0x02, 0x40, 0x00, 0x12, 0x00, 0x00, 0x90,
  0x00, 0x0C, 0x80, 0x00, 0x4C, 0x00, 0x02, 0x60, 0x00, 0x12, 0x00, 0x01,
  0x98, 0x00, 0x08, 0x40, 0x00, 0xC2, 0x00, 0x04, 0x10, 0x00, 0x60, 0x40,
  0x06, 0x03, 0x00, 0x60, 0x0E, 0x0C, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xFF,
  0x00, 0x40, 0x18, 0x0C, 0x00, 0x40, 0x80, 0x02, 0x08, 0x00, 0x20, 0x80,
  0x03, 0x08, 0x00, 0x10, 0x80, 0x01, 0x18, 0x00, 0x31, 0x00, 0x02, 0x10,
  0x00, 0x21, 0x00, 0x02, 0x10, 0x00, 0x41, 0x00, 0x04, 0x30, 0x00, 0x82,
  0x00, 0x10, 0x20, 0x0E, 0x03, 0xFF, 0x80, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x06, 0x06, 0x00, 0x40, 0x08,
  0x04, 0x00, 0x60, 0x40, 0x01, 0x04, 0x00, 0x08, 0x20, 0x00, 0x22, 0x00,
  0x01, 0x10, 0x00, 0x09, 0x80, 0x00, 0x48, 0x00, 0x02, 0x40, 0x00, 0x12,
  0x00, 0x01, 0x90, 0x00, 0x09, 0x80, 0x00, 0x48, 0x00, 0x02, 0x40, 0x00,
  0x12, 0x00, 0x00, 0x90, 0x00, 0x0C, 0x80, 0x00, 0x4C, 0x00, 0x02, 0x60,
  0x00, 0x12, 0x00, 0x01, 0x18, 0x00, 0x08, 0x40, 0x00, 0xC2, 0x00, 0x04,
  0x10, 0x00, 0x40, 0x40, 0x06, 0x03, 0x00, 0x60, 0x0E, 0x0C, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x07, 0xFF, 0x00, 0x40, 0x18, 0x0C,
  0x00, 0x40, 0x80, 0x02, 0x08, 0x00, 0x20, 0x80, 0x01, 0x08, 0x00, 0x10,
  0x80, 0x01, 0x10, 0x00, 0x11, 0x00, 0x03, 0x10, 0x00, 0x21, 0x00, 0x02,
  0x10, 0x00, 0x61, 0x00, 0x04, 0x20, 0x00, 0x82, 0x00, 0x10, 0x20, 0x06,
  0x03, 0xFF, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x40, 0x08, 0x04, 0x00,
  0x40, 0x40, 0x04, 0x04, 0x00, 0x60, 0x40, 0x02, 0x0C, 0x00, 0x20, 0x80,
  0x03, 0x08, 0x00, 0x10, 0x80, 0x01, 0x08, 0x00, 0x18, 0x80, 0x00, 0x80,
  0x00, 0x3F, 0x00, 0x06, 0x06, 0x00, 0xC0, 0x08, 0x0C, 0x00, 0x60, 0x40,
  0x01, 0x04, 0x00, 0x08, 0x20, 0x00, 0x41, 0x00, 0x02, 0x18, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x22, 0x00, 0x01,
  0x10, 0x00, 0x08, 0x80, 0x00, 0x46, 0x00, 0x04, 0x10, 0x00, 0x60, 0xC0,
  0x02, 0x03, 0x00, 0x60, 0x0E, 0x0E, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xFF,
  0xF0, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04,
  0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00,
  0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0,
  0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x08, 0x80, 0x00, 0x44, 0x00, 0x04,
  0x20, 0x00, 0x21, 0x00, 0x01, 0x08, 0x00, 0x08, 0x40, 0x00, 0x44, 0x00,
  0x02, 0x20, 0x00, 0x21, 0x00, 0x01, 0x08, 0x00, 0x08, 0x40, 0x00, 0x46,
  0x00, 0x02, 0x20, 0x00, 0x31, 0x00, 0x01, 0x08, 0x00, 0x08, 0x40, 0x00,
  0x42, 0x00, 0x02, 0x30, 0x00, 0x11, 0x00, 0x01, 0x88, 0x00, 0x08, 0x40,
  0x00, 0x42, 0x00, 0x02, 0x10, 0x00, 0x10, 0x80, 0x01, 0x04, 0x00, 0x08,
  0x20, 0x00, 0x80, 0x80, 0x0C, 0x06, 0x00, 0xC0, 0x1C, 0x18, 0x00, 0x3F,
  0x00, 0x00, 0x80, 0x00, 0x38, 0x00, 0x02, 0x80, 0x00, 0x68, 0x00, 0x04,
  0xC0, 0x00, 0x44, 0x00, 0x08, 0x40, 0x00, 0x84, 0x00, 0x10, 0x40, 0x01,
  0x04, 0x00, 0x30, 0x60, 0x02, 0x06, 0x00, 0x60, 0x20, 0x04, 0x02, 0x00,
  0x40, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x10, 0x03, 0x01, 0x00, 0x10,
  0x20, 0x01, 0x02, 0x00, 0x10, 0x60, 0x01, 0x04, 0x00, 0x10, 0xC0, 0x01,
  0x08, 0x00, 0x18, 0x80, 0x00, 0x90, 0x00, 0x09, 0x00, 0x00, 0xA0, 0x00,
  0x0A, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x3C, 0x00, 0x30, 0x00, 0xB0, 0x01, 0x40, 0x02, 0xC0,
  0x05, 0x00, 0x19, 0x00, 0x24, 0x00, 0x44, 0x00, 0x90, 0x01, 0x10, 0x02,
  0x40, 0x08, 0x40, 0x10, 0x80, 0x21, 0x00, 0x42, 0x01, 0x84, 0x03, 0x08,
  0x04, 0x10, 0x08, 0x20, 0x10, 0x40, 0x20, 0x80, 0xC1, 0x01, 0x02, 0x02,
  0x04, 0x04, 0x08, 0x08, 0x10, 0x30, 0x20, 0x40, 0x40, 0x80, 0x81, 0x01,
  0x82, 0x02, 0x04, 0x06, 0x10, 0x0C, 0x20, 0x18, 0x40, 0x10, 0x80, 0x23,
  0x00, 0x46, 0x00, 0x88, 0x01, 0x10, 0x02, 0x20, 0x04, 0x40, 0x09, 0x00,
  0x12, 0x00, 0x24, 0x00, 0x48, 0x00, 0xB0, 0x01, 0x20, 0x02, 0x80, 0x05,
  0x00, 0x0A, 0x00, 0x14, 0x00, 0x30, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x03, 0x02, 0x00, 0x02, 0x03,
  0x00, 0x04, 0x01, 0x00, 0x0C, 0x01, 0x80, 0x08, 0x00, 0x80, 0x10, 0x00,
  0x80, 0x20, 0x00, 0x40, 0x60, 0x00, 0x40, 0x40, 0x00, 0x60, 0x80, 0x00,
  0x21, 0x80, 0x00, 0x21, 0x00, 0x00, 0x12, 0x00, 0x00, 0x14, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x14, 0x00, 0x00, 0x24, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x42, 0x00, 0x00, 0x82, 0x00, 0x01, 0x01, 0x00, 0x03,
  0x01, 0x00, 0x02, 0x01, 0x80, 0x04, 0x00, 0x80, 0x0C, 0x00, 0x80, 0x08,
  0x00, 0x40, 0x10, 0x00, 0x40, 0x20, 0x00, 0x60, 0x60, 0x00, 0x20, 0x40,
  0x00, 0x20, 0xC0, 0x00, 0x3C, 0x00, 0x02, 0x40, 0x00, 0x44, 0x00, 0x0C,
  0x60, 0x00, 0x82, 0x00, 0x10, 0x20, 0x03, 0x03, 0x00, 0x20, 0x10, 0x04,
  0x01, 0x00, 0xC0, 0x18, 0x08, 0x00, 0x81, 0x00, 0x08, 0x10, 0x00, 0xC2,
  0x00, 0x04, 0x60, 0x00, 0x44, 0x00, 0x04, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xF0,
  0x10, 0x01, 0x00, 0x30, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x18, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x07,
  0xC0, 0x41, 0x04, 0x10, 0x41, 0x04, 0x18, 0x20, 0x82, 0x08, 0x20, 0x83,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x60, 0x82, 0x08, 0x20, 0x82, 0x0C, 0x10,
  0x41, 0x04, 0x10, 0x01, 0xF0, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04,
  0x00, 0xC0, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x01, 0x80, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x30, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x08, 0x0F, 0x80, 0x00, 0x80, 0x18, 0x01, 0x40, 0x24,
  0x02, 0x40, 0x44, 0x04, 0x40, 0x84, 0x08, 0x21, 0x02, 0x10, 0x22, 0x02,
  0x20, 0x24, 0x03, 0x40, 0x30, 0xFF, 0xFE, 0xC2, 0x18, 0x43, 0x08, 0x00,
  0xFC, 0x01, 0xC3, 0x81, 0x80, 0x41, 0x80, 0x30, 0x80, 0x08, 0xC0, 0x04,
  0x40, 0x02, 0x00, 0x01, 0x00, 0x01, 0x00, 0x00, 0x80, 0x7F, 0xC1, 0xC0,
  0x21, 0x80, 0x11, 0x80, 0x19, 0x80, 0x08, 0x80, 0x04, 0x40, 0x02, 0x20,
  0x03, 0x10, 0x01, 0x88, 0x01, 0xC6, 0x03, 0x41, 0x87, 0x20, 0x7E, 0x10,
  0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x3E, 0x02, 0x60, 0x81,
  0x40, 0x21, 0xC0, 0x18, 0xC0, 0x04, 0x40, 0x02, 0x20, 0x01, 0x10, 0x00,
  0x88, 0x00, 0x4C, 0x00, 0x24, 0x00, 0x12, 0x00, 0x19, 0x00, 0x08, 0x80,
  0x04, 0x40, 0x02, 0x60, 0x01, 0x20, 0x01, 0x10, 0x00, 0x88, 0x00, 0x86,
  0x00, 0x43, 0x80, 0x42, 0x60, 0xC1, 0x0F, 0xC0, 0x01, 0xF8, 0x07, 0x0E,
  0x0C, 0x02, 0x08, 0x03, 0x10, 0x01, 0x30, 0x01, 0x20, 0x01, 0x20, 0x01,
  0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0x80, 0x00, 0xC0, 0x06, 0xC0, 0x04, 0x40, 0x04, 0x40, 0x08,
  0x60, 0x10, 0x30, 0x60, 0x0F, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0xFC, 0x20, 0x61, 0x90, 0x20, 0x14, 0x10, 0x03, 0x08,
  0x00, 0xC2, 0x00, 0x31, 0x80, 0x0C, 0x40, 0x02, 0x10, 0x00, 0x84, 0x00,
  0x23, 0x00, 0x08, 0x80, 0x02, 0x20, 0x01, 0x88, 0x00, 0x42, 0x00, 0x10,
  0x80, 0x04, 0x20, 0x01, 0x08, 0x00, 0x42, 0x00, 0x30, 0x80, 0x18, 0x10,
  0x0A, 0x06, 0x0C, 0x80, 0x7C, 0x20, 0x00, 0xF8, 0x03, 0x0C, 0x04, 0x02,
  0x08, 0x03, 0x10, 0x01, 0x30, 0x01, 0x20, 0x01, 0x20, 0x01, 0x40, 0x01,
  0x40, 0x01, 0x7F, 0xFF, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20, 0x08,
  0x18, 0x30, 0x0F, 0xC0, 0x00, 0xF0, 0x30, 0x02, 0x00, 0x40, 0x04, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x0F, 0xF8, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x00, 0xFC, 0x60, 0x30, 0xC8, 0x08, 0x05, 0x02,
  0x00, 0x60, 0x80, 0x0C, 0x10, 0x01, 0x86, 0x00, 0x30, 0x80, 0x04, 0x10,
  0x00, 0x82, 0x00, 0x10, 0x80, 0x02, 0x10, 0x00, 0x42, 0x00, 0x18, 0x40,
  0x02, 0x08, 0x00, 0x41, 0x00, 0x08, 0x20, 0x01, 0x04, 0x00, 0x20, 0x80,
  0x0C, 0x10, 0x03, 0x01, 0x00, 0xA0, 0x30, 0x64, 0x01, 0xF0, 0x80, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x04, 0x0C, 0x00,
  0x80, 0x80, 0x20, 0x0C, 0x18, 0x00, 0x7C, 0x00, 0x02, 0x00, 0x03, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18,
  0x00, 0x08, 0x00, 0x04, 0x3E, 0x02, 0x60, 0x81, 0x60, 0x20, 0xA0, 0x10,
  0xA0, 0x08, 0x60, 0x06, 0x30, 0x02, 0x10, 0x01, 0x08, 0x00, 0x8C, 0x00,
  0x44, 0x00, 0x22, 0x00, 0x11, 0x00, 0x18, 0x80, 0x08, 0x40, 0x04, 0x60,
  0x02, 0x20, 0x01, 0x10, 0x00, 0x88, 0x00, 0xC4, 0x00, 0x42, 0x00, 0x23,
  0x00, 0x11, 0x00, 0x08, 0x06, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08,
  0x10, 0x20, 0x41, 0x82, 0x04, 0x08, 0x10, 0x20, 0xC1, 0x02, 0x04, 0x08,
  0x10, 0x60, 0x81, 0x02, 0x04, 0x08, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x80, 0x02,
  0x00, 0x10, 0x00, 0xC0, 0x3C, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0xC2, 0x00, 0xC1, 0x00, 0xC0, 0x80, 0xC0, 0x80, 0xC0,
  0x40, 0x80, 0x20, 0x80, 0x10, 0x80, 0x08, 0x80, 0x0C, 0x80, 0x04, 0xC0,
  0x02, 0x90, 0x01, 0x88, 0x00, 0x82, 0x00, 0x41, 0x00, 0x60, 0x40, 0x20,
  0x20, 0x10, 0x08, 0x08, 0x04, 0x04, 0x01, 0x02, 0x00, 0xC2, 0x00, 0x21,
  0x00, 0x18, 0x02, 0x04, 0x18, 0x20, 0x40, 0x81, 0x02, 0x0C, 0x10, 0x20,
  0x40, 0x81, 0x06, 0x08, 0x10, 0x20, 0x40, 0x83, 0x04, 0x08, 0x10, 0x20,
  0xC1, 0x02, 0x04, 0x08, 0x10, 0x60, 0x08, 0x7C, 0x07, 0xE0, 0x4C, 0x30,
  0x61, 0x86, 0xC0, 0x4C, 0x04, 0x2C, 0x02, 0x40, 0x11, 0x40, 0x14, 0x00,
  0x8C, 0x00, 0xC0, 0x04, 0x60, 0x06, 0x00, 0x22, 0x00, 0x20, 0x01, 0x30,
  0x01, 0x00, 0x09, 0x00, 0x08, 0x00, 0xC8, 0x00, 0x40, 0x04, 0x40, 0x02,
  0x00, 0x22, 0x00, 0x20, 0x01, 0x10, 0x01, 0x00, 0x09, 0x80, 0x08, 0x00,
  0x48, 0x00, 0x40, 0x06, 0x40, 0x02, 0x00, 0x22, 0x00, 0x30, 0x01, 0x10,
  0x01, 0x00, 0x08, 0x80, 0x08, 0x00, 0x4C, 0x00, 0x40, 0x02, 0x40, 0x02,
  0x00, 0x32, 0x00, 0x10, 0x01, 0x00, 0x08, 0x7C, 0x04, 0x41, 0x02, 0xC0,
  0x43, 0x40, 0x21, 0x40, 0x10, 0xC0, 0x0C, 0x60, 0x04, 0x20, 0x02, 0x10,
  0x01, 0x18, 0x00, 0x88, 0x00, 0x44, 0x00, 0x22, 0x00, 0x31, 0x00, 0x10,
  0x80, 0x08, 0xC0, 0x04, 0x40, 0x02, 0x20, 0x01, 0x10, 0x01, 0x88, 0x00,
  0x84, 0x00, 0x46, 0x00, 0x22, 0x00, 0x10, 0x01, 0xF8, 0x06, 0x0C, 0x08,
  0x06, 0x10, 0x02, 0x30, 0x03, 0x20, 0x01, 0x60, 0x01, 0x40, 0x01, 0x40,
  0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x02, 0x80,
  0x02, 0x80, 0x06, 0x80, 0x04, 0x80, 0x04, 0x80, 0x08, 0xC0, 0x18, 0x40,
  0x30, 0x30, 0x60, 0x1F, 0x80, 0x04, 0x3E, 0x01, 0x30, 0x40, 0x50, 0x08,
  0x38, 0x03, 0x0C, 0x00, 0x42, 0x00, 0x10, 0x80, 0x04, 0x20, 0x01, 0x08,
  0x00, 0x46, 0x00, 0x11, 0x00, 0x04, 0x40, 0x03, 0x10, 0x00, 0x84, 0x00,
  0x21, 0x00, 0x08, 0xC0, 0x02, 0x20, 0x01, 0x08, 0x00, 0x42, 0x00, 0x20,
  0xC0, 0x08, 0x38, 0x04, 0x13, 0x06, 0x04, 0x3E, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x03, 0xF1, 0x83, 0x0C, 0x82, 0x01, 0x42,
  0x00, 0x62, 0x00, 0x31, 0x00, 0x09, 0x80, 0x0C, 0x80, 0x04, 0x40, 0x02,
  0x20, 0x01, 0x30, 0x00, 0x90, 0x00, 0x48, 0x00, 0x44, 0x00, 0x22, 0x00,
  0x11, 0x00, 0x08, 0x80, 0x04, 0x40, 0x02, 0x20, 0x02, 0x10, 0x03, 0x04,
  0x02, 0x83, 0x06, 0x40, 0x7C, 0x20, 0x00, 0x10, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00,
  0x40, 0x08, 0x78, 0x4C, 0x02, 0x80, 0x38, 0x01, 0x40, 0x0C, 0x00, 0x60,
  0x02, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x60,
  0x02, 0x00, 0x00, 0x01, 0xF0, 0x06, 0x0C, 0x08, 0x06, 0x10, 0x02, 0x10,
  0x02, 0x20, 0x02, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x04, 0x80, 0x0C, 0x80, 0x08, 0x80, 0x08, 0x40, 0x30, 0x30, 0xE0, 0x1F,
  0x80, 0x08, 0x08, 0x08, 0x08, 0x18, 0x10, 0xFF, 0x10, 0x10, 0x10, 0x30,
  0x20, 0x20, 0x20, 0x20, 0x20, 0x60, 0x40, 0x40, 0x40, 0x40, 0x40, 0x80,
  0x80, 0x80, 0x80, 0x80, 0xC0, 0x78, 0x10, 0x01, 0x88, 0x00, 0x84, 0x00,
  0x44, 0x00, 0x22, 0x00, 0x11, 0x00, 0x08, 0x80, 0x0C, 0x40, 0x04, 0x60,
  0x02, 0x20, 0x01, 0x10, 0x00, 0x88, 0x00, 0x44, 0x00, 0x62, 0x00, 0x23,
  0x00, 0x11, 0x00, 0x08, 0x80, 0x0C, 0x40, 0x06, 0x30, 0x07, 0x08, 0x03,
  0x04, 0x02, 0x81, 0x06, 0x40, 0x7C, 0x20, 0x80, 0x03, 0x00, 0x0E, 0x00,
  0x14, 0x00, 0x6C, 0x00, 0x88, 0x03, 0x10, 0x04, 0x20, 0x08, 0x40, 0x20,
  0x80, 0x41, 0x81, 0x01, 0x02, 0x02, 0x08, 0x04, 0x10, 0x08, 0x40, 0x10,
  0x80, 0x23, 0x00, 0x24, 0x00, 0x58, 0x00, 0xA0, 0x01, 0xC0, 0x03, 0x00,
  0x06, 0x00, 0x00, 0x40, 0x08, 0x01, 0x40, 0x18, 0x03, 0x40, 0x18, 0x02,
  0x40, 0x38, 0x02, 0x40, 0x28, 0x06, 0x40, 0x28, 0x04, 0x40, 0x4C, 0x0C,
  0x40, 0x4C, 0x08, 0x40, 0x84, 0x08, 0x40, 0x84, 0x18, 0x41, 0x84, 0x10,
  0x41, 0x04, 0x30, 0x63, 0x04, 0x20, 0x62, 0x04, 0x20, 0x62, 0x04, 0x40,
  0x24, 0x04, 0x40, 0x24, 0x04, 0xC0, 0x28, 0x04, 0x80, 0x28, 0x02, 0x80,
  0x28, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00,
  0x0C, 0x00, 0x40, 0x80, 0x18, 0x18, 0x06, 0x01, 0x00, 0x80, 0x20, 0x20,
  0x02, 0x0C, 0x00, 0x41, 0x00, 0x0C, 0x40, 0x00, 0x90, 0x00, 0x1E, 0x00,
  0x01, 0x80, 0x00, 0x20, 0x00, 0x0A, 0x00, 0x03, 0x40, 0x00, 0x44, 0x00,
  0x10, 0x80, 0x04, 0x18, 0x01, 0x81, 0x00, 0x20, 0x30, 0x08, 0x02, 0x03,
  0x00, 0x40, 0xC0, 0x0C, 0x10, 0x00, 0x80, 0x04, 0x00, 0x10, 0x40, 0x01,
  0x04, 0x00, 0x20, 0x60, 0x02, 0x02, 0x00, 0x40, 0x20, 0x04, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x01, 0x00, 0x20, 0x10, 0x03, 0x02, 0x00, 0x10,
  0x20, 0x01, 0x04, 0x00, 0x10, 0x40, 0x01, 0x08, 0x00, 0x10, 0x80, 0x01,
  0x98, 0x00, 0x09, 0x00, 0x00, 0xB0, 0x00, 0x0A, 0x00, 0x00, 0xE0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x30,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x06,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x04, 0x00, 0x60, 0x02, 0x00, 0x10, 0x00,
  0xC0, 0x02, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00,
  0xC0, 0x02, 0x00, 0x30, 0x01, 0x00, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x06, 0x00, 0x08, 0x00, 0x18, 0x00, 0x20, 0x00, 0x06, 0x08, 0x10, 0x20,
  0x40, 0x83, 0x06, 0x08, 0x10, 0x20, 0x40, 0x83, 0x06, 0x08, 0x10, 0x20,
  0x41, 0x83, 0x04, 0x08, 0x10, 0x20, 0x41, 0x83, 0x04, 0x08, 0x10, 0x20,
  0xC1, 0x82, 0x04, 0x08, 0x00, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x18, 0x00, 0x70, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x02, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00,
  0xC0, 0x02, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0x00, 0x1E, 0x00, 0x26,
  0x30, 0x05, 0x02, 0x00, 0xA0, 0x20, 0x28, 0x02, 0x05, 0x00, 0x21, 0x20,
  0x03, 0xC0,
};

const GFXglyph RobotoCondensed_ThinItalic43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 6, 31, 8, 1, -31 },
  { 25, 7, 9, 11, 5, -32 },
  { 33, 21, 31, 20, 1, -31 },
  { 115, 17, 39, 20, 2, -35 },
  { 198, 20, 31, 27, 4, -31 },
  { 276, 19, 31, 22, 1, -31 },
  { 350, 3, 9, 7, 4, -32 },
  { 354, 12, 44, 11, 2, -34 },
  { 420, 11, 44, 12, -2, -34 },
  { 481, 16, 17, 17, 3, -31 },
  { 515, 17, 23, 21, 2, -26 },
  { 564, 4, 9, 8, -1, -3 },
  { 569, 8, 1, 11, 2, -14 },
  { 570, 2, 2, 9, 1, -2 },
  { 571, 18, 34, 14, -2, -31 },
  { 648, 17, 31, 20, 2, -31 },
  { 714, 9, 31, 20, 6, -31 },
  { 749, 18, 31, 20, 1, -31 },
  { 819, 18, 31, 20, 1, -31 },
  { 889, 18, 31, 20, 1, -31 },
  { 959, 18, 31, 20, 3, -31 },
  { 1029, 16, 31, 20, 2, -31 },
  { 1091, 17, 31, 20, 4, -31 },
  { 1157, 19, 31, 20, 1, -31 },
  { 1231, 16, 31, 20, 3, -31 },
  { 1293, 7, 22, 7, 0, -22 },
  { 1313, 8, 28, 7, -1, -22 },
  { 1341, 16, 16, 19, 2, -22 },
  { 1373, 16, 10, 21, 2, -19 },
  { 1393, 16, 16, 19, 1, -22 },
  { 1425, 13, 31, 16, 4, -31 },
  { 1476, 30, 40, 34, 1, -30 },
  { 1626, 20, 31, 22, -1, -31 },
  { 1704, 19, 31, 22, 2, -31 },
  { 1778, 21, 31, 24, 2, -31 },
  { 1860, 21, 31, 24, 2, -31 },
  { 1942, 20, 31, 21, 2, -31 },
  { 2020, 21, 31, 21, 2, -31 },
  { 2102, 20, 31, 25, 3, -31 },
  { 2180, 23, 31, 26, 2, -31 },
  { 2270, 7, 31, 10, 2, -31 },
  { 2298, 19, 31, 20, 1, -31 },
  { 2372, 22, 31, 23, 2, -31 },
  { 2458, 14, 31, 19, 2, -31 },
  { 2513, 28, 31, 31, 2, -31 },
  { 2622, 23, 31, 26, 2, -31 },
  { 2712, 21, 31, 24, 2, -31 },
  { 2794, 20, 31, 22, 2, -31 },
  { 2872, 21, 37, 24, 2, -31 },
  { 2970, 20, 31, 24, 2, -31 },
  { 3048, 21, 31, 22, 1, -31 },
  { 3130, 20, 31, 22, 4, -31 },
  { 3208, 21, 31, 24, 3, -31 },
  { 3290, 20, 31, 22, 4, -31 },
  { 3368, 30, 31, 33, 4, -31 },
  { 3485, 24, 31, 22, -1, -31 },
  { 3578, 20, 31, 22, 4, -31 },
  { 3656, 22, 31, 22, 0, -31 },
  { 3742, 12, 42, 8, 0, -35 },
  { 3805, 6, 34, 14, 4, -31 },
  { 3831, 12, 42, 8, -3, -35 },
  { 3894, 12, 15, 15, 2, -31 },
  { 3917, 15, 1, 15, -2, 0 },
  { 3919, 5, 6, 11, 6, -33 },
  { 3923, 17, 23, 20, 0, -23 },
  { 3972, 17, 32, 20, 1, -32 },
  { 4040, 16, 23, 19, 1, -23 },
  { 4086, 18, 32, 20, 2, -32 },
  { 4158, 16, 23, 19, 1, -23 },
  { 4204, 12, 32, 12, 3, -32 },
  { 4252, 19, 32, 20, 0, -23 },
  { 4328, 17, 32, 20, 1, -32 },
  { 4396, 7, 31, 8, 1, -31 },
  { 4424, 14, 40, 8, -6, -31 },
  { 4494, 17, 32, 18, 1, -32 },
  { 4562, 7, 32, 8, 1, -32 },
  { 4590, 29, 23, 32, 1, -23 },
  { 4674, 17, 23, 20, 1, -23 },
  { 4723, 16, 23, 20, 2, -23 },
  { 4769, 18, 32, 20, 0, -23 },
  { 4841, 17, 32, 20, 2, -23 },
  { 4909, 13, 23, 13, 1, -23 },
  { 4947, 16, 23, 18, 1, -23 },
  { 4993, 8, 29, 12, 3, -29 },
  { 5022, 17, 23, 20, 2, -23 },
  { 5071, 15, 23, 18, 3, -23 },
  { 5115, 24, 23, 28, 3, -23 },
  { 5184, 19, 23, 18, -1, -23 },
  { 5239, 20, 32, 18, -2, -23 },
  { 5319, 17, 23, 18, 0, -23 },
  { 5368, 14, 43, 12, 1, -34 },
  { 5444, 7, 37, 8, 1, -31 },
  { 5477, 14, 43, 12, -3, -34 },
  { 5553, 19, 7, 25, 3, -16 },
};

const GFXfont RobotoCondensed_ThinItalic43pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ThinItalic43pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ThinItalic43pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _ROBOTOCONDENSED_THINITALIC43PT7B_H_
