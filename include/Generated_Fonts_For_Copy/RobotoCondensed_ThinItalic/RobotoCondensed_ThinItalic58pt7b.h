#ifndef _ROBOTOCONDENSED_THINITALIC58PT7B_H_
#define _ROBOTOCONDENSED_THINITALIC58PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ThinItalic.ttf
// Size: 58pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ThinItalic58pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0x80, 0xC0, 0x60, 0x20, 0x10, 0x08, 0x0C, 0x06, 0x03, 0x01,
  0x00, 0x80, 0x40, 0x60, 0x30, 0x10, 0x08, 0x04, 0x06, 0x03, 0x01, 0x80,
  0x80, 0x40, 0x20, 0x30, 0x18, 0x0C, 0x04, 0x02, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0xE0, 0x00,
  0x00, 0x30, 0xCC, 0x23, 0x08, 0xC6, 0x21, 0x98, 0x66, 0x19, 0x84, 0x61,
  0x10, 0xC4, 0x33, 0x0C, 0x00, 0x01, 0x80, 0x60, 0x00, 0x0C, 0x03, 0x00,
  0x00, 0x40, 0x10, 0x00, 0x02, 0x01, 0x80, 0x00, 0x30, 0x0C, 0x00, 0x01,
  0x00, 0x40, 0x00, 0x08, 0x06, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x04, 0x01,
  0x00, 0x00, 0x20, 0x18, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x10, 0x04, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x0C, 0x03, 0x00, 0x00, 0x40, 0x10, 0x00, 0x02,
  0x01, 0x80, 0x00, 0x30, 0x0C, 0x00, 0x01, 0x80, 0x40, 0x00, 0x08, 0x06,
  0x00, 0x00, 0xC0, 0x30, 0x00, 0x06, 0x01, 0x00, 0x00, 0x20, 0x18, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x18, 0x04, 0x00, 0x00, 0x80, 0x20, 0x00, 0x0C,
  0x03, 0x00, 0x00, 0x60, 0x10, 0x00, 0x02, 0x00, 0x80, 0x0F, 0xFF, 0xFF,
  0xF0, 0x01, 0x80, 0x40, 0x00, 0x08, 0x02, 0x00, 0x00, 0xC0, 0x30, 0x00,
  0x06, 0x01, 0x00, 0x00, 0x20, 0x08, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x18,
  0x04, 0x00, 0x00, 0x80, 0x20, 0x00, 0x04, 0x03, 0x00, 0x00, 0x60, 0x10,
  0x00, 0x02, 0x00, 0x80, 0x00, 0x10, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x78, 0x18, 0x00, 0xE0, 0x0C,
  0x01, 0x80, 0x06, 0x01, 0x80, 0x06, 0x03, 0x00, 0x02, 0x02, 0x00, 0x03,
  0x06, 0x00, 0x03, 0x04, 0x00, 0x03, 0x04, 0x00, 0x03, 0x04, 0x00, 0x03,
  0x0C, 0x00, 0x03, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18,
  0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x10, 0x40, 0x00, 0x30,
  0x60, 0x00, 0x20, 0x60, 0x00, 0x60, 0x30, 0x00, 0xC0, 0x18, 0x01, 0x80,
  0x0C, 0x07, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0E, 0x18, 0x00, 0x01, 0x80,
  0x80, 0x00, 0x10, 0x08, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x20, 0x0C, 0x00,
  0x86, 0x00, 0xC0, 0x18, 0x40, 0x0C, 0x03, 0x04, 0x00, 0xC0, 0x60, 0x40,
  0x08, 0x04, 0x0C, 0x00, 0x80, 0xC0, 0xC0, 0x08, 0x18, 0x0C, 0x01, 0x81,
  0x00, 0x40, 0x10, 0x30, 0x04, 0x03, 0x06, 0x00, 0x60, 0x60, 0x40, 0x03,
  0x0C, 0x0C, 0x00, 0x1F, 0x81, 0x80, 0x00, 0x40, 0x10, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x18, 0x1F, 0x80, 0x03, 0x03, 0x0C, 0x00, 0x20, 0x60, 0x60, 0x06,
  0x0C, 0x02, 0x00, 0xC0, 0x80, 0x20, 0x08, 0x18, 0x02, 0x01, 0x01, 0x00,
  0x20, 0x30, 0x10, 0x02, 0x06, 0x03, 0x00, 0x20, 0x40, 0x30, 0x02, 0x0C,
  0x02, 0x00, 0x61, 0x80, 0x20, 0x06, 0x10, 0x02, 0x00, 0x43, 0x00, 0x30,
  0x0C, 0x00, 0x03, 0x00, 0x80, 0x00, 0x10, 0x18, 0x00, 0x01, 0x87, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x0E, 0x1C, 0x00, 0x0C, 0x02, 0x00, 0x06, 0x01, 0x80, 0x06,
  0x00, 0xC0, 0x02, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00,
  0x80, 0x0C, 0x00, 0x40, 0x0C, 0x00, 0x20, 0x06, 0x00, 0x10, 0x06, 0x00,
  0x08, 0x06, 0x00, 0x06, 0x06, 0x00, 0x01, 0x06, 0x00, 0x00, 0x86, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0D, 0x80, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0x10, 0x00, 0x0C, 0x0C,
  0x00, 0x8C, 0x02, 0x00, 0xCC, 0x01, 0x80, 0x64, 0x00, 0x60, 0x26, 0x00,
  0x30, 0x12, 0x00, 0x0C, 0x1B, 0x00, 0x02, 0x09, 0x80, 0x01, 0x8C, 0xC0,
  0x00, 0x46, 0x40, 0x00, 0x36, 0x30, 0x00, 0x0E, 0x18, 0x00, 0x07, 0x0C,
  0x00, 0x03, 0x82, 0x00, 0x03, 0x41, 0x80, 0x03, 0x30, 0x60, 0x03, 0x08,
  0x1C, 0x0E, 0x06, 0x07, 0xFC, 0x01, 0x80, 0x20, 0x00, 0x00, 0x33, 0x22,
  0x66, 0x64, 0x4C, 0xCC, 0x00, 0x02, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80,
  0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00,
  0x01, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80,
  0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x03,
  0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00,
  0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x00, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x02, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x20, 0x0C, 0x02, 0xF0, 0x10, 0x3C, 0x3C, 0x21, 0xE0, 0x1E, 0x5E,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x32, 0x00,
  0x00, 0xC6, 0x00, 0x03, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x30, 0x0C, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x18, 0x06, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x18, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x30, 0xC3, 0x0C, 0x21, 0x86, 0x30, 0xC6, 0x10, 0xFF, 0xE0, 0x07,
  0xE4, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x01, 0xC1, 0xC0, 0x06, 0x00, 0xC0, 0x18,
  0x01, 0x80, 0x60, 0x01, 0x80, 0x80, 0x03, 0x03, 0x00, 0x02, 0x0C, 0x00,
  0x04, 0x18, 0x00, 0x08, 0x20, 0x00, 0x18, 0xC0, 0x00, 0x31, 0x00, 0x00,
  0x62, 0x00, 0x00, 0xCC, 0x00, 0x01, 0x98, 0x00, 0x02, 0x20, 0x00, 0x04,
  0x40, 0x00, 0x08, 0x80, 0x00, 0x33, 0x00, 0x00, 0x66, 0x00, 0x00, 0xCC,
  0x00, 0x01, 0x90, 0x00, 0x02, 0x20, 0x00, 0x04, 0x40, 0x00, 0x19, 0x80,
  0x00, 0x33, 0x00, 0x00, 0x66, 0x00, 0x00, 0x88, 0x00, 0x01, 0x10, 0x00,
  0x06, 0x20, 0x00, 0x0C, 0x40, 0x00, 0x10, 0x80, 0x00, 0x61, 0x00, 0x00,
  0x83, 0x00, 0x03, 0x06, 0x00, 0x06, 0x04, 0x00, 0x18, 0x08, 0x00, 0x60,
  0x18, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x18, 0x1C, 0x00, 0x1F, 0xE0, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x10, 0x0F, 0x03, 0xB1, 0xE3, 0x70, 0x2C, 0x02,
  0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0x80, 0x08, 0x00, 0x80, 0x18, 0x01, 0x80, 0x10,
  0x01, 0x00, 0x10, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0x80, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x38, 0x1C, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x06, 0x01, 0x80, 0x02, 0x03,
  0x00, 0x03, 0x03, 0x00, 0x03, 0x06, 0x00, 0x03, 0x06, 0x00, 0x03, 0x04,
  0x00, 0x03, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x01, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x70, 0x38, 0x00, 0xC0, 0x0C, 0x01,
  0x80, 0x04, 0x03, 0x00, 0x06, 0x02, 0x00, 0x02, 0x06, 0x00, 0x02, 0x04,
  0x00, 0x03, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x08, 0x80, 0x00, 0x08, 0x80, 0x00, 0x08, 0x80,
  0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x10, 0xC0, 0x00, 0x30, 0x40,
  0x00, 0x20, 0x60, 0x00, 0x60, 0x30, 0x00, 0xC0, 0x38, 0x01, 0x80, 0x1C,
  0x07, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x24, 0x00, 0x00, 0x64, 0x00, 0x00, 0xC4, 0x00, 0x01, 0x8C, 0x00,
  0x01, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x08, 0x00, 0x04, 0x08, 0x00,
  0x0C, 0x08, 0x00, 0x18, 0x18, 0x00, 0x30, 0x18, 0x00, 0x20, 0x18, 0x00,
  0x60, 0x10, 0x00, 0xC0, 0x10, 0x00, 0x80, 0x10, 0x01, 0x80, 0x30, 0x03,
  0x00, 0x30, 0x06, 0x00, 0x30, 0x04, 0x00, 0x20, 0x0C, 0x00, 0x20, 0x18,
  0x00, 0x60, 0x30, 0x00, 0x60, 0x30, 0x00, 0x60, 0x60, 0x00, 0x40, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x01,
  0xFF, 0xFF, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x7E, 0x00, 0x1B,
  0xEF, 0x80, 0x16, 0x01, 0xC0, 0x18, 0x00, 0xC0, 0x10, 0x00, 0x60, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x80, 0x00, 0x20, 0x80, 0x00, 0x20, 0x80,
  0x00, 0x60, 0x80, 0x00, 0x40, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0x80, 0x40,
  0x01, 0x80, 0x60, 0x03, 0x00, 0x30, 0x06, 0x00, 0x18, 0x1C, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0x80, 0x07,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0xFC, 0x06, 0x1E, 0xF8, 0x33,
  0x00, 0xE1, 0x30, 0x03, 0x0A, 0x00, 0x0C, 0xF0, 0x00, 0x67, 0x00, 0x01,
  0x30, 0x00, 0x0D, 0x80, 0x00, 0x68, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0A,
  0x00, 0x00, 0xD0, 0x00, 0x06, 0xC0, 0x00, 0x26, 0x00, 0x03, 0x30, 0x00,
  0x10, 0x80, 0x01, 0x86, 0x00, 0x18, 0x18, 0x00, 0xC0, 0xE0, 0x1C, 0x03,
  0x81, 0xC0, 0x07, 0xF8, 0x00, 0x04, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x20, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x03, 0xC1, 0xC0, 0x01, 0xC0, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x20,
  0x00, 0x40, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x06, 0x03, 0x00, 0x00, 0x80,
  0x80, 0x00, 0x20, 0x60, 0x00, 0x08, 0x18, 0x00, 0x02, 0x06, 0x00, 0x01,
  0x81, 0x00, 0x00, 0x40, 0x60, 0x00, 0x30, 0x18, 0x00, 0x0C, 0x02, 0x00,
  0x06, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x01, 0x80, 0x07, 0x00, 0xC0, 0x00,
  0x7B, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1C, 0x0E, 0x00, 0x1C, 0x00, 0xC0,
  0x0C, 0x00, 0x18, 0x06, 0x00, 0x03, 0x01, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x10, 0x20, 0x00, 0x06, 0x18, 0x00, 0x01, 0x84, 0x00, 0x00, 0x61, 0x00,
  0x00, 0x10, 0x40, 0x00, 0x04, 0x10, 0x00, 0x03, 0x04, 0x00, 0x00, 0xC1,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x03, 0x00, 0x06,
  0x00, 0x60, 0x07, 0x00, 0x0E, 0x07, 0x80, 0x01, 0xFF, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x1C, 0x0E, 0x00, 0xC0,
  0x18, 0x06, 0x00, 0x30, 0x30, 0x00, 0x41, 0x80, 0x01, 0x86, 0x00, 0x06,
  0x30, 0x00, 0x08, 0xC0, 0x00, 0x22, 0x00, 0x00, 0x98, 0x00, 0x02, 0x40,
  0x00, 0x09, 0x00, 0x00, 0x2C, 0x00, 0x00, 0xB0, 0x00, 0x02, 0xC0, 0x00,
  0x0B, 0x00, 0x00, 0x6C, 0x00, 0x01, 0xB0, 0x00, 0x0E, 0xC0, 0x00, 0x31,
  0x00, 0x01, 0x46, 0x00, 0x0D, 0x18, 0x00, 0x6C, 0x30, 0x03, 0x30, 0x60,
  0x18, 0x80, 0xF7, 0xC2, 0x01, 0xFC, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x38, 0x00, 0x3F, 0x80, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x40, 0xE0, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x00,
  0xC0, 0x18, 0x02, 0x00, 0xC0, 0x30, 0x06, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x3C, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x02, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x10, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x20, 0x01, 0xFE, 0x01, 0x81,
  0x81, 0x80, 0x61, 0x80, 0x11, 0x80, 0x0C, 0x80, 0x06, 0xC0, 0x01, 0x40,
  0x00, 0xA0, 0x00, 0x70, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08,
  0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01,
  0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x38, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x00, 0xF0, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0xC0, 0x00, 0x00, 0x02, 0x01, 0x80, 0x00, 0x00, 0x02, 0x01, 0x80, 0x00,
  0x00, 0x03, 0x03, 0x00, 0x07, 0xC0, 0x03, 0x02, 0x00, 0x1F, 0xF0, 0x01,
  0x06, 0x00, 0x30, 0x18, 0x01, 0x04, 0x00, 0x60, 0x08, 0x01, 0x0C, 0x00,
  0xC0, 0x08, 0x01, 0x08, 0x01, 0x80, 0x18, 0x01, 0x18, 0x01, 0x00, 0x18,
  0x01, 0x18, 0x03, 0x00, 0x10, 0x01, 0x10, 0x02, 0x00, 0x10, 0x01, 0x30,
  0x06, 0x00, 0x30, 0x01, 0x20, 0x04, 0x00, 0x30, 0x03, 0x20, 0x0C, 0x00,
  0x20, 0x03, 0x60, 0x0C, 0x00, 0x20, 0x03, 0x60, 0x08, 0x00, 0x60, 0x02,
  0x40, 0x18, 0x00, 0x60, 0x02, 0x40, 0x18, 0x00, 0x40, 0x06, 0x40, 0x10,
  0x00, 0x40, 0x06, 0xC0, 0x10, 0x00, 0xC0, 0x04, 0xC0, 0x10, 0x00, 0xC0,
  0x0C, 0xC0, 0x30, 0x00, 0x80, 0x0C, 0xC0, 0x30, 0x01, 0x80, 0x08, 0xC0,
  0x30, 0x01, 0x80, 0x18, 0xC0, 0x30, 0x02, 0x80, 0x10, 0xC0, 0x30, 0x06,
  0x80, 0x30, 0xC0, 0x30, 0x04, 0x80, 0x60, 0xC0, 0x10, 0x18, 0xC0, 0xC0,
  0xC0, 0x18, 0x30, 0xC1, 0x80, 0xC0, 0x0F, 0xE0, 0x7F, 0x00, 0x40, 0x03,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x02, 0x00, 0x00,
  0x03, 0x80, 0x0E, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x14, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x24, 0x00, 0x00, 0x02, 0x60,
  0x00, 0x00, 0x46, 0x00, 0x00, 0x04, 0x20, 0x00, 0x00, 0xC2, 0x00, 0x00,
  0x08, 0x20, 0x00, 0x01, 0x82, 0x00, 0x00, 0x10, 0x20, 0x00, 0x03, 0x03,
  0x00, 0x00, 0x20, 0x30, 0x00, 0x06, 0x03, 0x00, 0x00, 0x40, 0x10, 0x00,
  0x0C, 0x01, 0x00, 0x00, 0x80, 0x10, 0x00, 0x18, 0x01, 0x00, 0x01, 0x00,
  0x18, 0x00, 0x30, 0x01, 0x80, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x04, 0x00, 0x08, 0x00, 0xC0, 0x00, 0x80, 0x08, 0x00, 0x08, 0x01, 0x80,
  0x00, 0xC0, 0x10, 0x00, 0x0C, 0x03, 0xFF, 0xFF, 0xC0, 0x20, 0x00, 0x0C,
  0x06, 0x00, 0x00, 0x40, 0x60, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x40, 0xC0,
  0x00, 0x06, 0x18, 0x00, 0x00, 0x61, 0x80, 0x00, 0x06, 0x10, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0x26, 0x00, 0x00, 0x02, 0x40,
  0x00, 0x00, 0x20, 0x01, 0xFF, 0xF0, 0x00, 0x60, 0x1F, 0x00, 0x10, 0x00,
  0x70, 0x04, 0x00, 0x0C, 0x01, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x20, 0x30,
  0x00, 0x0C, 0x0C, 0x00, 0x03, 0x02, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x30,
  0x20, 0x00, 0x0C, 0x18, 0x00, 0x03, 0x06, 0x00, 0x00, 0x81, 0x00, 0x00,
  0x60, 0x40, 0x00, 0x18, 0x10, 0x00, 0x0C, 0x0C, 0x00, 0x06, 0x03, 0x00,
  0x03, 0x00, 0xC0, 0x03, 0x80, 0x20, 0x0F, 0x80, 0x0F, 0xFF, 0xE0, 0x02,
  0x00, 0x0E, 0x01, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x18, 0x18, 0x00, 0x06,
  0x04, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x30, 0x40, 0x00, 0x04, 0x30, 0x00,
  0x01, 0x0C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0x80, 0x00, 0x08, 0x20,
  0x00, 0x02, 0x08, 0x00, 0x01, 0x86, 0x00, 0x00, 0x41, 0x80, 0x00, 0x30,
  0x40, 0x00, 0x18, 0x10, 0x00, 0x0C, 0x04, 0x00, 0x0E, 0x03, 0x00, 0x3F,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x3C, 0x07, 0x00, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x00, 0xC0, 0x18,
  0x00, 0x0C, 0x03, 0x00, 0x00, 0x60, 0x20, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x20, 0x40, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x20, 0x80, 0x00, 0x02, 0x18,
  0x00, 0x00, 0x21, 0x80, 0x00, 0x02, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x01, 0x04, 0x00, 0x00, 0x30, 0x40, 0x00, 0x03,
  0x04, 0x00, 0x00, 0x20, 0x40, 0x00, 0x06, 0x06, 0x00, 0x00, 0x40, 0x60,
  0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0x30, 0x00, 0x30, 0x01, 0x80, 0x06,
  0x00, 0x0E, 0x03, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x18, 0x07, 0xE0, 0x01, 0x00, 0x07, 0x00, 0x10,
  0x00, 0x18, 0x01, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x04, 0x03, 0x00, 0x00,
  0x60, 0x30, 0x00, 0x02, 0x02, 0x00, 0x00, 0x30, 0x20, 0x00, 0x03, 0x06,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x01, 0x06, 0x00, 0x00, 0x10, 0x40, 0x00,
  0x01, 0x04, 0x00, 0x00, 0x10, 0x40, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x20, 0x80, 0x00, 0x02, 0x08, 0x00,
  0x00, 0x20, 0x80, 0x00, 0x06, 0x18, 0x00, 0x00, 0x61, 0x80, 0x00, 0x06,
  0x18, 0x00, 0x00, 0x41, 0x00, 0x00, 0x04, 0x10, 0x00, 0x00, 0xC1, 0x00,
  0x00, 0x0C, 0x30, 0x00, 0x00, 0x83, 0x00, 0x00, 0x18, 0x30, 0x00, 0x01,
  0x82, 0x00, 0x00, 0x30, 0x20, 0x00, 0x03, 0x02, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x0C, 0x06, 0x00, 0x01, 0xC0, 0x40, 0x00, 0x38, 0x04, 0x00, 0x07,
  0x00, 0x40, 0x01, 0xC0, 0x0C, 0x01, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xF0, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xFF, 0xF0, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFC, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x38, 0x07, 0x00, 0x06,
  0x00, 0x18, 0x00, 0xC0, 0x00, 0xC0, 0x18, 0x00, 0x0C, 0x03, 0x00, 0x00,
  0x60, 0x60, 0x00, 0x06, 0x04, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x02, 0x08,
  0x00, 0x00, 0x21, 0x80, 0x00, 0x02, 0x18, 0x00, 0x00, 0x21, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x40, 0x03, 0xFF, 0x84, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x01,
  0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x30, 0x40,
  0x00, 0x03, 0x04, 0x00, 0x00, 0x20, 0x60, 0x00, 0x02, 0x02, 0x00, 0x00,
  0x60, 0x30, 0x00, 0x1C, 0x01, 0x80, 0x07, 0x80, 0x0E, 0x01, 0xE0, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x80, 0x00, 0x03, 0x01,
  0x80, 0x00, 0x02, 0x01, 0x00, 0x00, 0x02, 0x01, 0x00, 0x00, 0x02, 0x01,
  0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x04, 0x03,
  0x00, 0x00, 0x04, 0x02, 0x00, 0x00, 0x04, 0x02, 0x00, 0x00, 0x0C, 0x06,
  0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x08, 0x04,
  0x00, 0x00, 0x08, 0x04, 0x00, 0x00, 0x08, 0x04, 0x00, 0x00, 0x18, 0x0C,
  0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x10, 0x08,
  0x00, 0x00, 0x10, 0x0F, 0xFF, 0xFF, 0xF0, 0x08, 0x00, 0x00, 0x30, 0x18,
  0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x20, 0x10,
  0x00, 0x00, 0x20, 0x10, 0x00, 0x00, 0x20, 0x10, 0x00, 0x00, 0x60, 0x30,
  0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x40, 0x20,
  0x00, 0x00, 0x40, 0x20, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x80, 0x40, 0x00, 0x00, 0x80, 0x40,
  0x00, 0x00, 0x80, 0x40, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x01, 0x80, 0x01, 0x80, 0x80, 0x40, 0x20, 0x30, 0x18, 0x0C, 0x04,
  0x02, 0x01, 0x01, 0x80, 0xC0, 0x60, 0x20, 0x10, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x00, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x08, 0x04, 0x06, 0x03, 0x01,
  0x80, 0x80, 0x40, 0x20, 0x30, 0x18, 0x0C, 0x04, 0x02, 0x03, 0x01, 0x80,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x83,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x20, 0x60, 0x00, 0x30,
  0x30, 0x00, 0x18, 0x08, 0x00, 0x18, 0x06, 0x00, 0x08, 0x03, 0x00, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0x30, 0x1C, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x60, 0x10, 0x00,
  0x03, 0x00, 0x40, 0x00, 0x18, 0x01, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x06,
  0x00, 0x30, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00,
  0x08, 0x00, 0x60, 0x00, 0x60, 0x03, 0x00, 0x01, 0x80, 0x18, 0x00, 0x06,
  0x00, 0xC0, 0x00, 0x10, 0x06, 0x00, 0x00, 0x40, 0x30, 0x00, 0x01, 0x01,
  0x80, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x02, 0x1E, 0x00, 0x00, 0x08, 0xD8, 0x00, 0x00, 0x26, 0x30, 0x00,
  0x01, 0xB0, 0xC0, 0x00, 0x07, 0x01, 0x80, 0x00, 0x18, 0x02, 0x00, 0x00,
  0x40, 0x0C, 0x00, 0x01, 0x00, 0x10, 0x00, 0x04, 0x00, 0x60, 0x00, 0x30,
  0x00, 0xC0, 0x00, 0xC0, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00,
  0x18, 0x00, 0x20, 0x00, 0x30, 0x00, 0x80, 0x00, 0xC0, 0x06, 0x00, 0x01,
  0x80, 0x18, 0x00, 0x06, 0x00, 0x40, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x10,
  0x04, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x01, 0x80, 0x00, 0x00, 0x06, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x0A, 0x00, 0x00, 0x00, 0xF0, 0x14, 0x00,
  0x00, 0x01, 0x40, 0x68, 0x00, 0x00, 0x06, 0x80, 0xD8, 0x00, 0x00, 0x1B,
  0x01, 0xB0, 0x00, 0x00, 0x26, 0x02, 0x60, 0x00, 0x00, 0xCC, 0x04, 0x40,
  0x00, 0x01, 0x10, 0x08, 0x80, 0x00, 0x06, 0x20, 0x31, 0x00, 0x00, 0x08,
  0x40, 0x63, 0x00, 0x00, 0x31, 0x80, 0x86, 0x00, 0x00, 0x43, 0x01, 0x04,
  0x00, 0x01, 0x86, 0x02, 0x08, 0x00, 0x02, 0x08, 0x0C, 0x10, 0x00, 0x0C,
  0x10, 0x18, 0x30, 0x00, 0x10, 0x20, 0x30, 0x60, 0x00, 0x60, 0xC0, 0x40,
  0x40, 0x00, 0x81, 0x80, 0x80, 0x80, 0x03, 0x03, 0x01, 0x01, 0x00, 0x0C,
  0x04, 0x06, 0x02, 0x00, 0x18, 0x08, 0x0C, 0x06, 0x00, 0x60, 0x10, 0x18,
  0x0C, 0x00, 0x80, 0x60, 0x20, 0x08, 0x03, 0x00, 0xC0, 0x40, 0x10, 0x04,
  0x01, 0x80, 0x80, 0x20, 0x18, 0x02, 0x03, 0x00, 0x60, 0x20, 0x04, 0x06,
  0x00, 0xC0, 0xC0, 0x18, 0x0C, 0x00, 0x81, 0x00, 0x30, 0x10, 0x01, 0x06,
  0x00, 0x60, 0x20, 0x02, 0x08, 0x00, 0x80, 0x40, 0x04, 0x30, 0x01, 0x01,
  0x80, 0x0C, 0x40, 0x02, 0x03, 0x00, 0x09, 0x80, 0x0C, 0x06, 0x00, 0x16,
  0x00, 0x18, 0x08, 0x00, 0x2C, 0x00, 0x30, 0x10, 0x00, 0x70, 0x00, 0x40,
  0x60, 0x00, 0xC0, 0x00, 0x80, 0xC0, 0x01, 0x80, 0x01, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x01, 0x80, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x02, 0x01, 0x40,
  0x00, 0x02, 0x01, 0x60, 0x00, 0x02, 0x03, 0x20, 0x00, 0x06, 0x03, 0x20,
  0x00, 0x06, 0x03, 0x30, 0x00, 0x06, 0x03, 0x10, 0x00, 0x04, 0x02, 0x18,
  0x00, 0x04, 0x06, 0x18, 0x00, 0x04, 0x06, 0x08, 0x00, 0x0C, 0x06, 0x0C,
  0x00, 0x0C, 0x06, 0x04, 0x00, 0x0C, 0x04, 0x04, 0x00, 0x08, 0x04, 0x06,
  0x00, 0x08, 0x0C, 0x02, 0x00, 0x18, 0x0C, 0x03, 0x00, 0x18, 0x0C, 0x01,
  0x00, 0x18, 0x0C, 0x01, 0x00, 0x18, 0x08, 0x01, 0x80, 0x10, 0x08, 0x00,
  0x80, 0x10, 0x18, 0x00, 0xC0, 0x30, 0x18, 0x00, 0x40, 0x30, 0x18, 0x00,
  0x40, 0x30, 0x18, 0x00, 0x60, 0x30, 0x10, 0x00, 0x20, 0x20, 0x10, 0x00,
  0x30, 0x20, 0x30, 0x00, 0x10, 0x60, 0x30, 0x00, 0x10, 0x60, 0x30, 0x00,
  0x18, 0x60, 0x20, 0x00, 0x08, 0x40, 0x20, 0x00, 0x0C, 0x40, 0x20, 0x00,
  0x0C, 0xC0, 0x60, 0x00, 0x04, 0xC0, 0x60, 0x00, 0x06, 0xC0, 0x60, 0x00,
  0x02, 0xC0, 0x40, 0x00, 0x02, 0x80, 0x40, 0x00, 0x03, 0x80, 0xC0, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x3C, 0x07, 0x00, 0x07, 0x00, 0x18, 0x00, 0xC0, 0x00, 0xC0,
  0x18, 0x00, 0x04, 0x03, 0x00, 0x00, 0x60, 0x20, 0x00, 0x02, 0x06, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x30, 0x80, 0x00, 0x03,
  0x18, 0x00, 0x00, 0x31, 0x80, 0x00, 0x03, 0x10, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x03, 0x30, 0x00, 0x00, 0x33, 0x00, 0x00, 0x02, 0x20, 0x00, 0x00,
  0x22, 0x00, 0x00, 0x02, 0x20, 0x00, 0x00, 0x66, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x04, 0x40, 0x00, 0x00, 0x44, 0x00, 0x00,
  0x04, 0x40, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x8C,
  0x00, 0x00, 0x08, 0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x18, 0xC0, 0x00,
  0x01, 0x0C, 0x00, 0x00, 0x30, 0x40, 0x00, 0x06, 0x06, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x0C, 0x02, 0x00, 0x01, 0x80, 0x30, 0x00, 0x30, 0x01, 0x80,
  0x06, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x18, 0x03, 0xE0, 0x01, 0x00, 0x03, 0x80,
  0x10, 0x00, 0x18, 0x01, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x06, 0x03, 0x00,
  0x00, 0x60, 0x30, 0x00, 0x06, 0x02, 0x00, 0x00, 0x20, 0x20, 0x00, 0x02,
  0x02, 0x00, 0x00, 0x20, 0x60, 0x00, 0x02, 0x06, 0x00, 0x00, 0x60, 0x40,
  0x00, 0x06, 0x04, 0x00, 0x00, 0x40, 0x40, 0x00, 0x0C, 0x0C, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x18, 0x0C, 0x00, 0x01, 0x80, 0x80, 0x00, 0x30, 0x08,
  0x00, 0x0E, 0x00, 0x80, 0x01, 0xC0, 0x18, 0x01, 0xF0, 0x01, 0xFF, 0xFC,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3C, 0x07, 0x00,
  0x06, 0x00, 0x18, 0x00, 0xC0, 0x00, 0xC0, 0x18, 0x00, 0x04, 0x03, 0x00,
  0x00, 0x60, 0x20, 0x00, 0x02, 0x06, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x30, 0x80, 0x00, 0x03, 0x18, 0x00, 0x00, 0x31, 0x80,
  0x00, 0x03, 0x10, 0x00, 0x00, 0x33, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00,
  0x33, 0x00, 0x00, 0x02, 0x20, 0x00, 0x00, 0x22, 0x00, 0x00, 0x02, 0x20,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x04, 0x40, 0x00, 0x00, 0x44, 0x00, 0x00, 0x04, 0x40, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x08, 0xC0, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x30,
  0x40, 0x00, 0x06, 0x06, 0x00, 0x00, 0x60, 0x60, 0x00, 0x0C, 0x02, 0x00,
  0x01, 0x80, 0x30, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x0E, 0x03, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x21, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x80, 0x01, 0xFF, 0xF8, 0x00,
  0x10, 0x03, 0xF0, 0x01, 0x00, 0x03, 0x80, 0x10, 0x00, 0x0C, 0x03, 0x00,
  0x00, 0x40, 0x30, 0x00, 0x06, 0x03, 0x00, 0x00, 0x20, 0x20, 0x00, 0x02,
  0x02, 0x00, 0x00, 0x20, 0x20, 0x00, 0x02, 0x06, 0x00, 0x00, 0x20, 0x60,
  0x00, 0x02, 0x06, 0x00, 0x00, 0x20, 0x40, 0x00, 0x06, 0x04, 0x00, 0x00,
  0x40, 0x40, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x18, 0x08,
  0x00, 0x03, 0x00, 0x80, 0x00, 0x60, 0x08, 0x00, 0x0C, 0x01, 0x80, 0x0F,
  0x00, 0x1F, 0xFF, 0xC0, 0x01, 0x80, 0x0C, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x06, 0x00, 0x10, 0x00, 0x60, 0x03, 0x00, 0x02, 0x00, 0x30, 0x00,
  0x30, 0x03, 0x00, 0x03, 0x00, 0x20, 0x00, 0x10, 0x02, 0x00, 0x01, 0x80,
  0x20, 0x00, 0x18, 0x06, 0x00, 0x00, 0x80, 0x60, 0x00, 0x0C, 0x06, 0x00,
  0x00, 0xC0, 0x40, 0x00, 0x04, 0x04, 0x00, 0x00, 0x60, 0x40, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x1C, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0xC0,
  0x00, 0xC0, 0x18, 0x00, 0x06, 0x01, 0x00, 0x00, 0x20, 0x30, 0x00, 0x02,
  0x02, 0x00, 0x00, 0x30, 0x60, 0x00, 0x03, 0x06, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x03, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x40, 0x00, 0x01, 0x84, 0x00, 0x00, 0x18,
  0x40, 0x00, 0x01, 0x84, 0x00, 0x00, 0x10, 0x40, 0x00, 0x03, 0x06, 0x00,
  0x00, 0x30, 0x60, 0x00, 0x06, 0x03, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x18,
  0x01, 0xC0, 0x03, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x10, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x02, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x08, 0x10, 0x00, 0x00,
  0x40, 0x80, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x30, 0x60, 0x00, 0x01, 0x03,
  0x00, 0x00, 0x08, 0x10, 0x00, 0x00, 0x40, 0x80, 0x00, 0x06, 0x0C, 0x00,
  0x00, 0x30, 0x60, 0x00, 0x01, 0x83, 0x00, 0x00, 0x08, 0x10, 0x00, 0x00,
  0x40, 0x80, 0x00, 0x02, 0x04, 0x00, 0x00, 0x30, 0x60, 0x00, 0x01, 0x83,
  0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x40, 0x80, 0x00, 0x02, 0x04, 0x00,
  0x00, 0x10, 0x20, 0x00, 0x01, 0x83, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00,
  0x40, 0xC0, 0x00, 0x02, 0x04, 0x00, 0x00, 0x10, 0x20, 0x00, 0x00, 0x81,
  0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x02, 0x06, 0x00,
  0x00, 0x10, 0x20, 0x00, 0x00, 0x81, 0x00, 0x00, 0x0C, 0x08, 0x00, 0x00,
  0x60, 0x40, 0x00, 0x02, 0x02, 0x00, 0x00, 0x30, 0x18, 0x00, 0x01, 0x00,
  0xC0, 0x00, 0x18, 0x03, 0x00, 0x01, 0x80, 0x18, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x01, 0xC0, 0x78, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0x20, 0x00, 0x00, 0x64, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x03, 0x18, 0x00,
  0x00, 0x43, 0x00, 0x00, 0x18, 0x60, 0x00, 0x02, 0x04, 0x00, 0x00, 0xC0,
  0x80, 0x00, 0x10, 0x10, 0x00, 0x06, 0x03, 0x00, 0x00, 0x80, 0x60, 0x00,
  0x30, 0x0C, 0x00, 0x04, 0x01, 0x80, 0x01, 0x80, 0x10, 0x00, 0x30, 0x02,
  0x00, 0x0C, 0x00, 0x40, 0x01, 0x80, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x0C,
  0x00, 0x30, 0x01, 0x00, 0x02, 0x00, 0x60, 0x00, 0x40, 0x08, 0x00, 0x08,
  0x03, 0x00, 0x01, 0x00, 0x40, 0x00, 0x30, 0x18, 0x00, 0x06, 0x02, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x08, 0x10, 0x00, 0x01, 0x06, 0x00, 0x00, 0x20,
  0xC0, 0x00, 0x06, 0x10, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x18, 0x80, 0x00,
  0x01, 0x30, 0x00, 0x00, 0x24, 0x00, 0x00, 0x05, 0x80, 0x00, 0x00, 0xA0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x18,
  0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x02,
  0xC0, 0x00, 0x28, 0x00, 0x06, 0xC0, 0x00, 0x68, 0x00, 0x04, 0xC0, 0x00,
  0x48, 0x00, 0x0C, 0xC0, 0x00, 0xC8, 0x00, 0x0C, 0xC0, 0x00, 0x88, 0x00,
  0x08, 0xC0, 0x00, 0x8C, 0x00, 0x18, 0xC0, 0x01, 0x8C, 0x00, 0x18, 0xC0,
  0x01, 0x0C, 0x00, 0x10, 0xC0, 0x03, 0x0C, 0x00, 0x30, 0x40, 0x02, 0x04,
  0x00, 0x20, 0x40, 0x02, 0x04, 0x00, 0x60, 0x40, 0x06, 0x04, 0x00, 0x60,
  0x40, 0x04, 0x04, 0x00, 0x40, 0x40, 0x0C, 0x04, 0x00, 0xC0, 0x40, 0x08,
  0x04, 0x00, 0xC0, 0x60, 0x08, 0x04, 0x00, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x10, 0x06, 0x01, 0x00, 0x60, 0x30, 0x06, 0x03, 0x00, 0x60,
  0x20, 0x06, 0x03, 0x00, 0x60, 0x20, 0x06, 0x02, 0x00, 0x60, 0x60, 0x02,
  0x06, 0x00, 0x60, 0x40, 0x02, 0x04, 0x00, 0x60, 0xC0, 0x02, 0x04, 0x00,
  0x20, 0x80, 0x02, 0x0C, 0x00, 0x21, 0x80, 0x02, 0x08, 0x00, 0x21, 0x80,
  0x02, 0x18, 0x00, 0x21, 0x00, 0x03, 0x18, 0x00, 0x23, 0x00, 0x03, 0x10,
  0x00, 0x22, 0x00, 0x03, 0x30, 0x00, 0x26, 0x00, 0x03, 0x20, 0x00, 0x36,
  0x00, 0x03, 0x60, 0x00, 0x34, 0x00, 0x03, 0x60, 0x00, 0x3C, 0x00, 0x01,
  0x40, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x80, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x04, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x60, 0x00, 0x18, 0x00, 0x60, 0x00, 0x30, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x30, 0x00, 0x60, 0x00, 0x10, 0x00, 0xC0, 0x00, 0x18,
  0x01, 0x80, 0x00, 0x18, 0x01, 0x80, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x0C,
  0x06, 0x00, 0x00, 0x04, 0x04, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x02,
  0x18, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x03, 0x20, 0x00, 0x00, 0x01,
  0x60, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x0C,
  0x20, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x10, 0x30, 0x00, 0x00, 0x30,
  0x10, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x40, 0x08, 0x00, 0x00, 0xC0,
  0x0C, 0x00, 0x01, 0x80, 0x04, 0x00, 0x03, 0x00, 0x06, 0x00, 0x02, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x18, 0x00,
  0x01, 0x00, 0x10, 0x00, 0x01, 0x80, 0x30, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x00, 0xC0, 0x40, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x09, 0x80, 0x00, 0x03, 0x10, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x10, 0x60,
  0x00, 0x06, 0x04, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x20, 0x18, 0x00, 0x0C,
  0x01, 0x00, 0x03, 0x00, 0x30, 0x00, 0x40, 0x06, 0x00, 0x18, 0x00, 0x40,
  0x06, 0x00, 0x08, 0x00, 0x80, 0x01, 0x80, 0x30, 0x00, 0x10, 0x0C, 0x00,
  0x02, 0x01, 0x00, 0x00, 0x60, 0x60, 0x00, 0x04, 0x18, 0x00, 0x00, 0x82,
  0x00, 0x00, 0x18, 0xC0, 0x00, 0x01, 0x30, 0x00, 0x00, 0x24, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0xFE, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0x7E, 0x00, 0xC0, 0xC0, 0xC0, 0xC0,
  0x40, 0x40, 0x40, 0x60, 0x60, 0x60, 0x60, 0x20, 0x20, 0x20, 0x30, 0x30,
  0x30, 0x30, 0x10, 0x10, 0x10, 0x18, 0x18, 0x18, 0x08, 0x08, 0x08, 0x08,
  0x0C, 0x0C, 0x0C, 0x04, 0x04, 0x04, 0x06, 0x06, 0x06, 0x06, 0x02, 0x02,
  0x02, 0x03, 0x03, 0x03, 0x03, 0x00, 0x7F, 0x00, 0x03, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0xFE, 0x00, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x78, 0x00, 0x58, 0x00, 0xD8, 0x00, 0x88, 0x01, 0x88, 0x01,
  0x08, 0x03, 0x0C, 0x02, 0x0C, 0x06, 0x0C, 0x04, 0x04, 0x0C, 0x04, 0x0C,
  0x04, 0x18, 0x04, 0x18, 0x06, 0x30, 0x06, 0x30, 0x06, 0x60, 0x02, 0x60,
  0x02, 0xC0, 0x02, 0xFF, 0xFF, 0xF0, 0xC1, 0x86, 0x0C, 0x10, 0x60, 0x83,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x0E, 0x07, 0x00, 0xE0, 0x06, 0x06,
  0x00, 0x08, 0x18, 0x00, 0x30, 0xC0, 0x00, 0xC2, 0x00, 0x03, 0x08, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x1F, 0xFE, 0x03, 0xFF, 0xF0, 0x38,
  0x00, 0x41, 0x80, 0x01, 0x0C, 0x00, 0x0C, 0x60, 0x00, 0x31, 0x80, 0x00,
  0xCC, 0x00, 0x02, 0x30, 0x00, 0x08, 0x80, 0x00, 0x62, 0x00, 0x01, 0x88,
  0x00, 0x0E, 0x30, 0x00, 0x78, 0xC0, 0x03, 0x61, 0x80, 0x39, 0x83, 0x03,
  0x86, 0x07, 0xF8, 0x10, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x43, 0xFE, 0x00,
  0x8C, 0x06, 0x03, 0x60, 0x06, 0x07, 0x80, 0x04, 0x0E, 0x00, 0x0C, 0x18,
  0x00, 0x18, 0x30, 0x00, 0x10, 0xC0, 0x00, 0x21, 0x80, 0x00, 0x43, 0x00,
  0x00, 0x84, 0x00, 0x01, 0x08, 0x00, 0x02, 0x10, 0x00, 0x04, 0x60, 0x00,
  0x18, 0xC0, 0x00, 0x31, 0x80, 0x00, 0x62, 0x00, 0x00, 0x84, 0x00, 0x01,
  0x08, 0x00, 0x02, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x21,
  0x00, 0x00, 0xC2, 0x00, 0x01, 0x84, 0x00, 0x02, 0x18, 0x00, 0x0C, 0x38,
  0x00, 0x30, 0x78, 0x00, 0x60, 0x98, 0x03, 0x81, 0x18, 0x0E, 0x02, 0x0F,
  0xF0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x04, 0x00, 0x01, 0xFF, 0x00, 0x1C,
  0x0E, 0x00, 0xC0, 0x0C, 0x06, 0x00, 0x10, 0x30, 0x00, 0x61, 0x80, 0x01,
  0x86, 0x00, 0x02, 0x30, 0x00, 0x08, 0xC0, 0x00, 0x22, 0x00, 0x00, 0x98,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x08, 0x80,
  0x00, 0x63, 0x00, 0x01, 0x0C, 0x00, 0x0C, 0x10, 0x00, 0x20, 0x60, 0x01,
  0x80, 0xC0, 0x0C, 0x01, 0x80, 0xE0, 0x03, 0xFE, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x40, 0x00, 0x40, 0x20, 0x03, 0xFC, 0x10, 0x07, 0x03, 0x18, 0x06,
  0x00, 0x4C, 0x06, 0x00, 0x16, 0x06, 0x00, 0x0E, 0x03, 0x00, 0x03, 0x03,
  0x00, 0x01, 0x81, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x30,
  0x40, 0x00, 0x10, 0x20, 0x00, 0x08, 0x30, 0x00, 0x04, 0x18, 0x00, 0x06,
  0x0C, 0x00, 0x03, 0x06, 0x00, 0x01, 0x82, 0x00, 0x00, 0x81, 0x00, 0x00,
  0x40, 0x80, 0x00, 0x20, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x18, 0x30, 0x00,
  0x0C, 0x18, 0x00, 0x04, 0x0C, 0x00, 0x02, 0x02, 0x00, 0x03, 0x01, 0x00,
  0x01, 0x80, 0xC0, 0x01, 0xC0, 0x60, 0x01, 0xC0, 0x18, 0x01, 0xA0, 0x06,
  0x07, 0x10, 0x01, 0xFE, 0x18, 0x00, 0x10, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x03, 0xFE, 0x00, 0x70, 0x38, 0x06, 0x00, 0x60, 0x60, 0x01, 0x06, 0x00,
  0x0C, 0x20, 0x00, 0x63, 0x00, 0x01, 0x30, 0x00, 0x09, 0x80, 0x00, 0x48,
  0x00, 0x02, 0xC0, 0x00, 0x16, 0x00, 0x00, 0xA0, 0x00, 0x0F, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x08, 0x18, 0x00, 0xC0, 0x70, 0x3C, 0x01, 0xFF, 0x80, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x07, 0xFF, 0xC1, 0xFF, 0xF0,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x0F, 0xF0,
  0x40, 0x1C, 0x0C, 0x60, 0x18, 0x01, 0x30, 0x18, 0x00, 0x58, 0x18, 0x00,
  0x38, 0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x06, 0x06, 0x00, 0x03, 0x02, 0x00,
  0x01, 0x83, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x40, 0x80, 0x00, 0x20, 0xC0,
  0x00, 0x10, 0x60, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x10, 0x00, 0x06, 0x08,
  0x00, 0x02, 0x04, 0x00, 0x01, 0x02, 0x00, 0x01, 0x83, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x60, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x10, 0x30, 0x00, 0x08,
  0x08, 0x00, 0x0C, 0x04, 0x00, 0x06, 0x03, 0x00, 0x07, 0x01, 0x80, 0x07,
  0x80, 0x60, 0x0E, 0x80, 0x18, 0x1C, 0x40, 0x07, 0xF8, 0x60, 0x00, 0x40,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x02, 0x01, 0x00, 0x03, 0x01, 0x80, 0x03, 0x00, 0x60,
  0x03, 0x80, 0x18, 0x03, 0x80, 0x07, 0x8F, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x10, 0x7F, 0x80, 0x47, 0x03, 0x03, 0x30, 0x06, 0x0D, 0x80, 0x18, 0x34,
  0x00, 0x20, 0xA0, 0x00, 0xC2, 0x80, 0x03, 0x0C, 0x00, 0x0C, 0x70, 0x00,
  0x31, 0x80, 0x00, 0xC6, 0x00, 0x02, 0x10, 0x00, 0x08, 0x40, 0x00, 0x23,
  0x00, 0x01, 0x8C, 0x00, 0x06, 0x30, 0x00, 0x18, 0xC0, 0x00, 0x42, 0x00,
  0x01, 0x08, 0x00, 0x04, 0x60, 0x00, 0x31, 0x80, 0x00, 0xC6, 0x00, 0x03,
  0x18, 0x00, 0x08, 0x40, 0x00, 0x21, 0x00, 0x00, 0x8C, 0x00, 0x06, 0x30,
  0x00, 0x18, 0xC0, 0x00, 0x62, 0x00, 0x01, 0x08, 0x00, 0x04, 0x20, 0x00,
  0x10, 0x01, 0x81, 0xC0, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x40, 0x20, 0x30, 0x18, 0x0C, 0x06, 0x02, 0x01, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x10, 0x08, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x80,
  0x40, 0x60, 0x30, 0x18, 0x0C, 0x04, 0x02, 0x03, 0x01, 0x80, 0xC0, 0x40,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x0C, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x80, 0x01, 0x81, 0x00, 0x06, 0x06, 0x00, 0x18, 0x0C, 0x00, 0x60, 0x18,
  0x01, 0x80, 0x20, 0x06, 0x00, 0x40, 0x18, 0x00, 0x80, 0x60, 0x03, 0x01,
  0x80, 0x06, 0x06, 0x00, 0x0C, 0x18, 0x00, 0x10, 0x60, 0x00, 0x21, 0x00,
  0x00, 0xCE, 0x00, 0x01, 0xB4, 0x00, 0x03, 0xCC, 0x00, 0x07, 0x08, 0x00,
  0x0C, 0x18, 0x00, 0x10, 0x10, 0x00, 0x60, 0x30, 0x00, 0xC0, 0x20, 0x01,
  0x80, 0x60, 0x02, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x08, 0x00, 0xC0, 0x30,
  0x01, 0x80, 0x60, 0x01, 0x80, 0xC0, 0x03, 0x01, 0x00, 0x03, 0x02, 0x00,
  0x06, 0x04, 0x00, 0x06, 0x00, 0x01, 0x80, 0xC0, 0x40, 0x20, 0x10, 0x18,
  0x0C, 0x06, 0x02, 0x01, 0x00, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x08, 0x04,
  0x06, 0x03, 0x01, 0x80, 0x80, 0x40, 0x60, 0x30, 0x18, 0x0C, 0x04, 0x02,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x20, 0x10, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x00, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x06, 0x0F, 0xF0, 0x07, 0xF8, 0x06, 0x38, 0x18, 0x1C, 0x0C, 0x06, 0x60,
  0x0C, 0x30, 0x04, 0x06, 0xC0, 0x0C, 0x60, 0x06, 0x05, 0x80, 0x04, 0xC0,
  0x02, 0x05, 0x00, 0x05, 0x80, 0x02, 0x0E, 0x00, 0x05, 0x00, 0x02, 0x0E,
  0x00, 0x06, 0x00, 0x02, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x0C, 0x00, 0x04,
  0x00, 0x02, 0x08, 0x00, 0x04, 0x00, 0x02, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x10, 0x00, 0x08, 0x00, 0x04, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x10, 0x00, 0x08, 0x00, 0x04, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x20, 0x00, 0x10, 0x00, 0x08, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x60, 0x00, 0x30, 0x00, 0x18, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x40, 0x00, 0x20, 0x00, 0x10, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x40, 0x00, 0x20, 0x00, 0x10, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x10, 0x7F, 0x80, 0x43, 0x03, 0x03, 0x30, 0x06, 0x0C, 0x80,
  0x18, 0x34, 0x00, 0x20, 0xA0, 0x00, 0xC2, 0x80, 0x03, 0x0C, 0x00, 0x0C,
  0x70, 0x00, 0x31, 0x80, 0x00, 0xC6, 0x00, 0x02, 0x10, 0x00, 0x08, 0x40,
  0x00, 0x23, 0x00, 0x01, 0x8C, 0x00, 0x06, 0x30, 0x00, 0x18, 0xC0, 0x00,
  0x42, 0x00, 0x01, 0x08, 0x00, 0x04, 0x60, 0x00, 0x31, 0x80, 0x00, 0xC6,
  0x00, 0x03, 0x10, 0x00, 0x08, 0x40, 0x00, 0x21, 0x00, 0x00, 0x8C, 0x00,
  0x06, 0x30, 0x00, 0x18, 0xC0, 0x00, 0x62, 0x00, 0x01, 0x08, 0x00, 0x04,
  0x20, 0x00, 0x10, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x1C, 0x07, 0x00,
  0xE0, 0x0C, 0x06, 0x00, 0x18, 0x10, 0x00, 0x30, 0xC0, 0x00, 0xC6, 0x00,
  0x03, 0x18, 0x00, 0x04, 0x40, 0x00, 0x13, 0x00, 0x00, 0x48, 0x00, 0x01,
  0x20, 0x00, 0x05, 0x80, 0x00, 0x16, 0x00, 0x00, 0x50, 0x00, 0x03, 0x40,
  0x00, 0x0D, 0x00, 0x00, 0x34, 0x00, 0x00, 0xB0, 0x00, 0x02, 0xC0, 0x00,
  0x1B, 0x00, 0x00, 0x6C, 0x00, 0x01, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x31,
  0x00, 0x01, 0x84, 0x00, 0x06, 0x18, 0x00, 0x30, 0x20, 0x01, 0x80, 0xC0,
  0x0C, 0x01, 0xC0, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x43, 0xFE, 0x00, 0x63, 0x83, 0x80, 0x36, 0x00, 0x60, 0x1E,
  0x00, 0x10, 0x0E, 0x00, 0x0C, 0x06, 0x00, 0x06, 0x02, 0x00, 0x01, 0x03,
  0x00, 0x00, 0x81, 0x80, 0x00, 0x40, 0xC0, 0x00, 0x20, 0x40, 0x00, 0x10,
  0x20, 0x00, 0x08, 0x10, 0x00, 0x04, 0x18, 0x00, 0x06, 0x0C, 0x00, 0x03,
  0x06, 0x00, 0x01, 0x82, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x40, 0x80, 0x00,
  0x20, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x18, 0x30, 0x00, 0x08, 0x10, 0x00,
  0x0C, 0x08, 0x00, 0x06, 0x04, 0x00, 0x02, 0x06, 0x00, 0x03, 0x03, 0x80,
  0x03, 0x01, 0xE0, 0x01, 0x00, 0x98, 0x03, 0x80, 0x47, 0x03, 0x80, 0x21,
  0xFF, 0x00, 0x30, 0x08, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0xFF, 0x04, 0x07, 0x03,
  0x18, 0x18, 0x01, 0x30, 0x60, 0x01, 0x41, 0x80, 0x03, 0x83, 0x00, 0x03,
  0x0C, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x20, 0x00, 0x18, 0xC0, 0x00, 0x21,
  0x80, 0x00, 0x42, 0x00, 0x00, 0x8C, 0x00, 0x01, 0x18, 0x00, 0x06, 0x30,
  0x00, 0x0C, 0x60, 0x00, 0x10, 0x80, 0x00, 0x21, 0x00, 0x00, 0x42, 0x00,
  0x01, 0x8C, 0x00, 0x03, 0x18, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x60, 0x00,
  0x10, 0xC0, 0x00, 0x20, 0x80, 0x00, 0xC1, 0x00, 0x01, 0x83, 0x00, 0x07,
  0x06, 0x00, 0x1C, 0x06, 0x00, 0x68, 0x06, 0x07, 0x10, 0x07, 0xF8, 0x60,
  0x01, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x04, 0x3F, 0x04, 0x60, 0x0C, 0x80, 0x0D, 0x00, 0x0F, 0x00, 0x0A,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x70, 0x38, 0x06,
  0x00, 0x60, 0x60, 0x01, 0x86, 0x00, 0x0C, 0x20, 0x00, 0x61, 0x00, 0x01,
  0x18, 0x00, 0x18, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0xC0, 0x00, 0x66, 0x00, 0x02, 0x30,
  0x00, 0x11, 0x80, 0x01, 0x86, 0x00, 0x18, 0x38, 0x01, 0x80, 0xE0, 0x38,
  0x01, 0xFF, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x20, 0x02, 0x00, 0x60, 0x7F, 0xFF, 0xFF, 0x06, 0x00, 0x40,
  0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x08, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x10, 0x01, 0x00, 0x10, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x03, 0x00, 0x3F, 0x00, 0x40, 0x08, 0x00, 0x04, 0x60, 0x00, 0x31,
  0x80, 0x00, 0xC6, 0x00, 0x03, 0x10, 0x00, 0x08, 0x40, 0x00, 0x21, 0x00,
  0x00, 0x8C, 0x00, 0x06, 0x30, 0x00, 0x18, 0xC0, 0x00, 0x62, 0x00, 0x01,
  0x08, 0x00, 0x04, 0x20, 0x00, 0x31, 0x80, 0x00, 0xC6, 0x00, 0x03, 0x18,
  0x00, 0x0C, 0x40, 0x00, 0x21, 0x00, 0x00, 0x84, 0x00, 0x06, 0x30, 0x00,
  0x18, 0xC0, 0x00, 0x63, 0x00, 0x01, 0x0C, 0x00, 0x04, 0x30, 0x00, 0x30,
  0xC0, 0x00, 0xC3, 0x00, 0x07, 0x0C, 0x00, 0x3C, 0x10, 0x01, 0xA0, 0x60,
  0x0C, 0x80, 0xC0, 0xE2, 0x01, 0xFE, 0x18, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x14, 0x00, 0x01, 0xB0, 0x00, 0x09, 0x80, 0x00, 0xCC, 0x00, 0x04, 0x20,
  0x00, 0x61, 0x00, 0x03, 0x08, 0x00, 0x30, 0x60, 0x01, 0x83, 0x00, 0x08,
  0x18, 0x00, 0xC0, 0xC0, 0x04, 0x02, 0x00, 0x60, 0x10, 0x02, 0x00, 0xC0,
  0x30, 0x06, 0x01, 0x00, 0x30, 0x18, 0x01, 0x80, 0x80, 0x04, 0x0C, 0x00,
  0x20, 0x40, 0x01, 0x06, 0x00, 0x0C, 0x30, 0x00, 0x63, 0x00, 0x03, 0x18,
  0x00, 0x08, 0x80, 0x00, 0x4C, 0x00, 0x02, 0x40, 0x00, 0x1E, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x01, 0x80, 0x03,
  0x80, 0x01, 0x80, 0x02, 0x80, 0x03, 0x80, 0x06, 0xC0, 0x03, 0x80, 0x06,
  0xC0, 0x07, 0x80, 0x0C, 0xC0, 0x05, 0x80, 0x0C, 0xC0, 0x0C, 0x80, 0x08,
  0xC0, 0x08, 0x80, 0x18, 0xC0, 0x18, 0x80, 0x18, 0xC0, 0x18, 0x80, 0x30,
  0xC0, 0x10, 0x80, 0x30, 0xC0, 0x30, 0xC0, 0x60, 0x40, 0x20, 0xC0, 0x60,
  0x40, 0x60, 0xC0, 0x40, 0x40, 0x40, 0xC0, 0xC0, 0x40, 0xC0, 0xC0, 0xC0,
  0x40, 0xC0, 0xC1, 0x80, 0x60, 0x80, 0x41, 0x80, 0x61, 0x80, 0x41, 0x00,
  0x61, 0x00, 0x43, 0x00, 0x63, 0x00, 0x43, 0x00, 0x62, 0x00, 0x46, 0x00,
  0x66, 0x00, 0x46, 0x00, 0x64, 0x00, 0x64, 0x00, 0x64, 0x00, 0x6C, 0x00,
  0x6C, 0x00, 0x6C, 0x00, 0x28, 0x00, 0x68, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x01, 0x01, 0x80, 0x01, 0x80, 0xC0, 0x01, 0x80, 0x30, 0x01,
  0x80, 0x18, 0x00, 0x80, 0x04, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x00, 0x80,
  0xC0, 0x00, 0x60, 0x60, 0x00, 0x30, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x06,
  0x20, 0x00, 0x01, 0x30, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x14, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x19, 0x80, 0x00,
  0x08, 0x40, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x08, 0x00, 0x0C, 0x06, 0x00,
  0x04, 0x01, 0x00, 0x06, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x18,
  0x03, 0x00, 0x0C, 0x03, 0x00, 0x02, 0x03, 0x00, 0x01, 0x83, 0x00, 0x00,
  0xC0, 0x02, 0x00, 0x00, 0x60, 0x60, 0x00, 0x08, 0x0C, 0x00, 0x03, 0x01,
  0x80, 0x00, 0x40, 0x10, 0x00, 0x18, 0x02, 0x00, 0x02, 0x00, 0x40, 0x00,
  0xC0, 0x0C, 0x00, 0x10, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0x80, 0x06,
  0x00, 0x30, 0x00, 0x40, 0x04, 0x00, 0x08, 0x01, 0x80, 0x01, 0x00, 0x20,
  0x00, 0x30, 0x0C, 0x00, 0x06, 0x01, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x08,
  0x08, 0x00, 0x01, 0x03, 0x00, 0x00, 0x20, 0x40, 0x00, 0x06, 0x18, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x01, 0x18, 0x00, 0x00, 0x26,
  0x00, 0x00, 0x04, 0xC0, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x13, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0xF0, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x20, 0x00, 0x00, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x04, 0x02, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x20, 0x10,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x80, 0x40, 0x60, 0x30, 0x18, 0x0C,
  0x04, 0x02, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0x80, 0x40, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x02, 0x03,
  0x01, 0x80, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x30, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xB8, 0x00, 0x13, 0x03, 0x00,
  0x0D, 0x80, 0x60, 0x02, 0x40, 0x0C, 0x00, 0xB0, 0x01, 0x80, 0x48, 0x00,
  0x30, 0x32, 0x00, 0x07, 0x78, 0x00, 0x00, 0xF8, 0x00,
};

const GFXglyph RobotoCondensed_ThinItalic58pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 9, 42, 10, 1, -41 },
  { 49, 10, 12, 15, 6, -44 },
  { 64, 29, 41, 27, 1, -41 },
  { 213, 24, 53, 27, 2, -47 },
  { 372, 28, 43, 37, 5, -42 },
  { 523, 25, 43, 30, 2, -42 },
  { 658, 4, 12, 9, 6, -44 },
  { 664, 16, 59, 15, 3, -46 },
  { 782, 15, 59, 16, -3, -46 },
  { 893, 23, 22, 24, 3, -41 },
  { 957, 24, 29, 28, 2, -33 },
  { 1044, 6, 12, 11, -2, -4 },
  { 1053, 11, 1, 15, 2, -19 },
  { 1055, 4, 4, 12, 1, -3 },
  { 1057, 23, 45, 19, -2, -41 },
  { 1187, 23, 43, 27, 3, -42 },
  { 1311, 12, 41, 27, 8, -41 },
  { 1373, 24, 42, 27, 1, -42 },
  { 1499, 24, 43, 27, 2, -42 },
  { 1628, 24, 41, 27, 1, -41 },
  { 1751, 24, 42, 27, 4, -41 },
  { 1877, 21, 42, 27, 3, -41 },
  { 1988, 23, 41, 27, 5, -41 },
  { 2106, 26, 43, 27, 1, -42 },
  { 2246, 22, 42, 27, 4, -42 },
  { 2362, 8, 31, 10, 1, -30 },
  { 2393, 11, 38, 10, -2, -30 },
  { 2446, 21, 23, 26, 3, -30 },
  { 2507, 22, 12, 28, 3, -25 },
  { 2540, 21, 22, 26, 2, -30 },
  { 2598, 17, 43, 22, 5, -42 },
  { 2690, 40, 53, 45, 2, -40 },
  { 2955, 28, 41, 30, -2, -41 },
  { 3099, 26, 41, 30, 2, -41 },
  { 3233, 28, 43, 32, 3, -42 },
  { 3384, 28, 41, 32, 2, -41 },
  { 3528, 28, 41, 28, 2, -41 },
  { 3672, 28, 41, 28, 2, -41 },
  { 3816, 28, 43, 34, 4, -42 },
  { 3967, 32, 41, 35, 2, -41 },
  { 4131, 9, 41, 14, 3, -41 },
  { 4178, 25, 42, 27, 1, -41 },
  { 4310, 30, 41, 31, 2, -41 },
  { 4464, 19, 41, 26, 2, -41 },
  { 4562, 39, 41, 42, 2, -41 },
  { 4762, 32, 41, 35, 2, -41 },
  { 4926, 28, 43, 33, 3, -42 },
  { 5077, 28, 41, 30, 2, -41 },
  { 5221, 28, 50, 33, 3, -42 },
  { 5396, 28, 41, 32, 2, -41 },
  { 5540, 28, 43, 29, 1, -42 },
  { 5691, 26, 41, 30, 6, -41 },
  { 5825, 29, 42, 33, 3, -41 },
  { 5978, 27, 41, 30, 5, -41 },
  { 6117, 40, 41, 44, 6, -41 },
  { 6322, 32, 41, 30, -1, -41 },
  { 6486, 27, 41, 30, 5, -41 },
  { 6625, 30, 41, 30, 0, -41 },
  { 6779, 15, 56, 11, 1, -47 },
  { 6884, 8, 45, 19, 6, -41 },
  { 6929, 16, 56, 11, -4, -47 },
  { 7041, 16, 21, 21, 3, -41 },
  { 7083, 20, 1, 21, -3, 0 },
  { 7086, 6, 8, 15, 8, -44 },
  { 7092, 22, 33, 26, 1, -32 },
  { 7183, 23, 45, 27, 1, -44 },
  { 7313, 22, 33, 25, 2, -32 },
  { 7404, 25, 45, 27, 2, -44 },
  { 7545, 21, 33, 25, 2, -32 },
  { 7632, 18, 45, 16, 3, -45 },
  { 7734, 25, 44, 27, 0, -32 },
  { 7872, 22, 44, 27, 2, -44 },
  { 7993, 9, 42, 11, 2, -42 },
  { 8041, 19, 54, 11, -8, -42 },
  { 8170, 23, 44, 24, 2, -44 },
  { 8297, 9, 44, 11, 2, -44 },
  { 8347, 40, 32, 44, 1, -32 },
  { 8507, 22, 32, 27, 2, -32 },
  { 8595, 22, 33, 27, 2, -32 },
  { 8686, 25, 44, 27, -1, -32 },
  { 8824, 23, 44, 27, 2, -32 },
  { 8951, 16, 32, 17, 2, -32 },
  { 9015, 21, 33, 25, 1, -32 },
  { 9102, 12, 40, 16, 3, -39 },
  { 9162, 22, 32, 27, 3, -31 },
  { 9250, 21, 31, 24, 4, -31 },
  { 9332, 32, 31, 37, 5, -31 },
  { 9456, 25, 31, 24, -1, -31 },
  { 9553, 27, 43, 24, -2, -31 },
  { 9699, 23, 31, 24, 0, -31 },
  { 9789, 18, 58, 16, 2, -45 },
  { 9920, 9, 49, 11, 1, -41 },
  { 9976, 18, 58, 16, -4, -45 },
  { 10107, 26, 9, 34, 4, -22 },
};

const GFXfont RobotoCondensed_ThinItalic58pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ThinItalic58pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ThinItalic58pt7bGlyphs,
  0x20, 0x7E, 68
};

#endif // _ROBOTOCONDENSED_THINITALIC58PT7B_H_
