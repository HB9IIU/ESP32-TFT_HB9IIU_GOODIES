#ifndef _ROBOTOCONDENSED_THINITALIC37PT7B_H_
#define _ROBOTOCONDENSED_THINITALIC37PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ThinItalic.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ThinItalic37pt7bBitmaps[] PROGMEM = {
  0x00, 0x08, 0x42, 0x10, 0x88, 0x42, 0x10, 0x84, 0x42, 0x10, 0x84, 0x22,
  0x10, 0x00, 0x00, 0x00, 0xC4, 0x00, 0x45, 0x14, 0xD2, 0x4A, 0x28, 0x80,
  0x00, 0x40, 0x80, 0x10, 0x40, 0x04, 0x10, 0x02, 0x04, 0x00, 0x82, 0x00,
  0x20, 0x80, 0x10, 0x20, 0x7F, 0xFF, 0x01, 0x04, 0x00, 0x41, 0x00, 0x20,
  0x80, 0x08, 0x20, 0x02, 0x08, 0x01, 0x04, 0x00, 0x41, 0x00, 0x10, 0x40,
  0x08, 0x20, 0x02, 0x08, 0x0F, 0xFF, 0xE0, 0x41, 0x00, 0x10, 0x40, 0x04,
  0x10, 0x02, 0x04, 0x00, 0x82, 0x00, 0x20, 0x80, 0x10, 0x20, 0x00, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0xF8, 0x03, 0x0C, 0x04, 0x06, 0x08,
  0x02, 0x08, 0x02, 0x10, 0x01, 0x10, 0x01, 0x10, 0x02, 0x10, 0x00, 0x18,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x08, 0x00, 0x04, 0x80, 0x04, 0x80, 0x04, 0x80, 0x08, 0x40,
  0x08, 0x40, 0x18, 0x60, 0x30, 0x30, 0x60, 0x0F, 0x80, 0x02, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x0F, 0x00, 0x04, 0x40, 0x02, 0x08, 0x01, 0x02, 0x04,
  0x40, 0x81, 0x10, 0x20, 0x84, 0x08, 0x42, 0x02, 0x10, 0x81, 0x08, 0x10,
  0x44, 0x04, 0x22, 0x00, 0xF0, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x18,
  0xF0, 0x04, 0x62, 0x02, 0x30, 0x81, 0x08, 0x10, 0x42, 0x04, 0x21, 0x01,
  0x10, 0x40, 0x88, 0x10, 0x22, 0x04, 0x08, 0x01, 0x04, 0x00, 0x23, 0x00,
  0x07, 0x00, 0x00, 0xF0, 0x01, 0x08, 0x02, 0x0C, 0x04, 0x04, 0x04, 0x04,
  0x04, 0x08, 0x04, 0x08, 0x04, 0x10, 0x04, 0x20, 0x04, 0x40, 0x02, 0x80,
  0x03, 0x00, 0x05, 0x00, 0x09, 0x00, 0x10, 0x81, 0x20, 0x81, 0x20, 0x41,
  0x40, 0x63, 0x40, 0x22, 0x80, 0x12, 0x80, 0x14, 0x80, 0x08, 0xC0, 0x18,
  0x40, 0x24, 0x20, 0x42, 0x1F, 0x82, 0x55, 0xA8, 0x00, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x01, 0x00, 0x80, 0x20, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x04, 0x01, 0x00, 0x40, 0x10, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x01, 0x00,
  0x40, 0x10, 0x02, 0x00, 0x80, 0x10, 0x00, 0x02, 0x00, 0x80, 0x10, 0x04,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x20, 0x08, 0x04, 0x01, 0x00, 0x80, 0x20, 0x10,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x00, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x03, 0x84, 0x71, 0x96, 0x01, 0xE0, 0x07, 0x00, 0x16, 0x00,
  0x88, 0x04, 0x10, 0x20, 0x41, 0x00, 0x80, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x01,
  0xFF, 0xFC, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x13, 0x22, 0x64, 0x80, 0xFE,
  0xF0, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x02,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00,
  0x80, 0x02, 0x00, 0x04, 0x00, 0x00, 0x01, 0xF0, 0x18, 0x60, 0xC0, 0x82,
  0x01, 0x10, 0x04, 0x40, 0x12, 0x00, 0x48, 0x01, 0x40, 0x05, 0x00, 0x14,
  0x00, 0x50, 0x01, 0x40, 0x06, 0x00, 0x18, 0x00, 0xA0, 0x02, 0x80, 0x0A,
  0x00, 0x28, 0x01, 0x20, 0x04, 0x80, 0x12, 0x00, 0x88, 0x06, 0x10, 0x10,
  0x61, 0x80, 0x78, 0x00, 0x03, 0x0D, 0x72, 0x82, 0x02, 0x02, 0x02, 0x02,
  0x04, 0x04, 0x04, 0x04, 0x04, 0x04, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x20, 0x01, 0xF0, 0x04, 0x18, 0x10, 0x10,
  0x40, 0x11, 0x80, 0x22, 0x00, 0x44, 0x00, 0x90, 0x01, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x18, 0x00, 0x60,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x40, 0x01, 0xFF, 0xF0, 0x01, 0xF8, 0x02, 0x0C, 0x04,
  0x06, 0x08, 0x02, 0x18, 0x02, 0x10, 0x02, 0x10, 0x02, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x03, 0xC0, 0x00, 0x30, 0x00,
  0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x04, 0x80, 0x04, 0x80, 0x04, 0x80,
  0x08, 0xC0, 0x08, 0x40, 0x10, 0x60, 0x30, 0x30, 0x60, 0x0F, 0x80, 0x00,
  0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0xA0, 0x02, 0x40, 0x0C, 0x80, 0x12,
  0x00, 0x44, 0x01, 0x08, 0x02, 0x10, 0x08, 0x20, 0x20, 0x40, 0x81, 0x01,
  0x02, 0x04, 0x04, 0x10, 0x08, 0x60, 0x10, 0x80, 0x23, 0xFF, 0xF8, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80,
  0x07, 0xFF, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x17, 0xC0, 0x28, 0x30,
  0x30, 0x18, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x08, 0x80, 0x08, 0x80, 0x08, 0x80, 0x10, 0x40, 0x10, 0x40, 0x20,
  0x30, 0xC0, 0x1F, 0x80, 0x00, 0x78, 0x0C, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x01, 0x1E, 0x13, 0x0C, 0xA0, 0x26,
  0x00, 0xA0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x01, 0x40, 0x0B, 0x00, 0x88, 0x0C, 0x20, 0xC0, 0xF8, 0x00, 0x7F,
  0xFE, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40,
  0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x00,
  0x00, 0xF8, 0x03, 0x0C, 0x04, 0x02, 0x08, 0x02, 0x08, 0x01, 0x10, 0x01,
  0x10, 0x01, 0x10, 0x02, 0x10, 0x02, 0x10, 0x04, 0x08, 0x0C, 0x0C, 0x18,
  0x03, 0xE0, 0x08, 0x30, 0x30, 0x08, 0x20, 0x0C, 0x40, 0x04, 0x40, 0x04,
  0x80, 0x04, 0x80, 0x04, 0x80, 0x04, 0x80, 0x08, 0x80, 0x18, 0x40, 0x30,
  0x20, 0x60, 0x1F, 0x80, 0x07, 0xC0, 0x41, 0x84, 0x04, 0x40, 0x14, 0x00,
  0xA0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x38,
  0x01, 0xC0, 0x19, 0x01, 0x4C, 0x32, 0x1F, 0x10, 0x01, 0x00, 0x08, 0x00,
  0xC0, 0x04, 0x00, 0x40, 0x06, 0x00, 0x60, 0x0C, 0x07, 0x80, 0x00, 0x08,
  0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x0C, 0x00, 0x04, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x40, 0x81, 0x06, 0x08, 0x20, 0x00, 0x00,
  0x08, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x18, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x10, 0x7F, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFE,
  0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x02, 0x00,
  0x00, 0x0F, 0x82, 0x08, 0x80, 0xA0, 0x14, 0x03, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x40, 0x08, 0x02, 0x00, 0xC0, 0x30, 0x0C, 0x01, 0x00, 0x40, 0x10,
  0x02, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x0C,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x06, 0x03, 0x00, 0x06, 0x00, 0x20, 0x02,
  0x00, 0x04, 0x01, 0x00, 0x00, 0x80, 0x80, 0x00, 0x20, 0x40, 0x00, 0x08,
  0x30, 0x00, 0x01, 0x08, 0x07, 0x80, 0x44, 0x02, 0x18, 0x11, 0x01, 0x02,
  0x04, 0x80, 0x80, 0x81, 0x20, 0x40, 0x40, 0x48, 0x10, 0x10, 0x14, 0x08,
  0x04, 0x05, 0x02, 0x01, 0x02, 0x40, 0x80, 0x80, 0x90, 0x40, 0x20, 0x28,
  0x10, 0x08, 0x0A, 0x04, 0x06, 0x04, 0x81, 0x01, 0x01, 0x20, 0x40, 0xC0,
  0x88, 0x10, 0x50, 0x62, 0x04, 0x22, 0x30, 0x80, 0xF0, 0xF0, 0x10, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x18, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x05, 0x00, 0x02, 0x80, 0x02, 0x40,
  0x01, 0x20, 0x01, 0x08, 0x00, 0x84, 0x00, 0x82, 0x00, 0x41, 0x00, 0x40,
  0x80, 0x20, 0x40, 0x20, 0x20, 0x10, 0x08, 0x08, 0x04, 0x08, 0x02, 0x04,
  0x01, 0x07, 0xFF, 0x82, 0x00, 0x42, 0x00, 0x21, 0x00, 0x09, 0x00, 0x04,
  0x80, 0x02, 0x80, 0x01, 0x40, 0x00, 0xC0, 0x00, 0x40, 0x07, 0xFC, 0x02,
  0x03, 0x02, 0x00, 0x41, 0x00, 0x30, 0x80, 0x08, 0x40, 0x04, 0x20, 0x02,
  0x10, 0x02, 0x10, 0x01, 0x08, 0x01, 0x84, 0x00, 0x82, 0x01, 0x81, 0xFF,
  0x00, 0x80, 0x60, 0x80, 0x18, 0x40, 0x04, 0x20, 0x02, 0x10, 0x00, 0x88,
  0x00, 0x44, 0x00, 0x44, 0x00, 0x22, 0x00, 0x11, 0x00, 0x10, 0x80, 0x10,
  0x40, 0x30, 0x3F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0xC0, 0xC0, 0x40, 0x10,
  0x20, 0x02, 0x18, 0x00, 0x84, 0x00, 0x22, 0x00, 0x08, 0x80, 0x02, 0x20,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x22,
  0x00, 0x08, 0x80, 0x02, 0x10, 0x01, 0x04, 0x00, 0xC1, 0x80, 0x60, 0x30,
  0x30, 0x03, 0xF0, 0x00, 0x07, 0xFC, 0x01, 0x00, 0x80, 0x80, 0x18, 0x20,
  0x02, 0x08, 0x00, 0x42, 0x00, 0x10, 0x80, 0x04, 0x20, 0x01, 0x10, 0x00,
  0x44, 0x00, 0x11, 0x00, 0x04, 0x40, 0x01, 0x10, 0x00, 0x44, 0x00, 0x22,
  0x00, 0x08, 0x80, 0x02, 0x20, 0x00, 0x88, 0x00, 0x22, 0x00, 0x10, 0x80,
  0x04, 0x40, 0x02, 0x10, 0x00, 0x84, 0x00, 0x41, 0x00, 0x20, 0x40, 0x30,
  0x1F, 0xF0, 0x00, 0x07, 0xFF, 0xC1, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x1F, 0xFC, 0x04, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x1F,
  0xFF, 0x00, 0x07, 0xFF, 0xC1, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x1F, 0xFE, 0x04, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x60, 0xC0, 0x60, 0x08, 0x30, 0x03, 0x08, 0x00,
  0x44, 0x00, 0x11, 0x00, 0x04, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x07, 0xF9, 0x00,
  0x02, 0x40, 0x01, 0x10, 0x00, 0x44, 0x00, 0x11, 0x00, 0x04, 0x40, 0x01,
  0x10, 0x00, 0x84, 0x00, 0x20, 0x80, 0x18, 0x18, 0x18, 0x03, 0xF8, 0x00,
  0x04, 0x00, 0x10, 0x40, 0x01, 0x08, 0x00, 0x10, 0x80, 0x01, 0x08, 0x00,
  0x10, 0x80, 0x01, 0x08, 0x00, 0x20, 0x80, 0x02, 0x10, 0x00, 0x21, 0x00,
  0x02, 0x10, 0x00, 0x21, 0x00, 0x04, 0x1F, 0xFF, 0xC1, 0x00, 0x04, 0x20,
  0x00, 0x42, 0x00, 0x04, 0x20, 0x00, 0x42, 0x00, 0x08, 0x20, 0x00, 0x82,
  0x00, 0x08, 0x40, 0x00, 0x84, 0x00, 0x08, 0x40, 0x00, 0x84, 0x00, 0x10,
  0x40, 0x01, 0x08, 0x00, 0x10, 0x08, 0x42, 0x10, 0x84, 0x42, 0x10, 0x84,
  0x42, 0x10, 0x84, 0x22, 0x10, 0x84, 0x21, 0x10, 0x84, 0x00, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x80, 0x08,
  0x80, 0x10, 0x80, 0x10, 0x80, 0x20, 0x80, 0x20, 0x40, 0x40, 0x60, 0x80,
  0x1F, 0x00, 0x04, 0x00, 0x20, 0x40, 0x04, 0x08, 0x00, 0x80, 0x80, 0x10,
  0x08, 0x02, 0x00, 0x80, 0x40, 0x08, 0x08, 0x00, 0x81, 0x00, 0x10, 0x20,
  0x01, 0x04, 0x00, 0x10, 0x80, 0x01, 0x10, 0x00, 0x13, 0x00, 0x01, 0x48,
  0x00, 0x28, 0x80, 0x03, 0x04, 0x00, 0x20, 0x60, 0x02, 0x02, 0x00, 0x20,
  0x10, 0x02, 0x01, 0x00, 0x40, 0x08, 0x04, 0x00, 0x80, 0x40, 0x04, 0x04,
  0x00, 0x40, 0x40, 0x02, 0x08, 0x00, 0x30, 0x04, 0x00, 0x20, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x03,
  0xFF, 0xC0, 0x04, 0x00, 0x00, 0x83, 0x00, 0x00, 0xC2, 0x80, 0x00, 0xA1,
  0x40, 0x00, 0x50, 0xA0, 0x00, 0x50, 0x50, 0x00, 0x28, 0x28, 0x00, 0x24,
  0x12, 0x00, 0x12, 0x11, 0x00, 0x11, 0x08, 0x80, 0x08, 0x84, 0x40, 0x08,
  0x82, 0x20, 0x04, 0x41, 0x08, 0x04, 0x20, 0x84, 0x02, 0x10, 0x82, 0x02,
  0x08, 0x41, 0x01, 0x04, 0x20, 0x81, 0x04, 0x10, 0x21, 0x02, 0x08, 0x10,
  0x81, 0x04, 0x08, 0x80, 0x84, 0x04, 0x40, 0x42, 0x02, 0x40, 0x41, 0x01,
  0x20, 0x20, 0x80, 0x60, 0x10, 0x40, 0x30, 0x08, 0x40, 0x10, 0x04, 0x00,
  0x04, 0x00, 0x08, 0x30, 0x00, 0x83, 0x80, 0x04, 0x14, 0x00, 0x20, 0x90,
  0x01, 0x04, 0x80, 0x08, 0x24, 0x00, 0xC1, 0x10, 0x04, 0x18, 0x80, 0x20,
  0x82, 0x01, 0x04, 0x10, 0x08, 0x20, 0x80, 0x41, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x80, 0x41, 0x04, 0x02, 0x08, 0x20, 0x10, 0x41, 0x00, 0x42, 0x08,
  0x02, 0x20, 0x40, 0x09, 0x04, 0x00, 0x48, 0x20, 0x02, 0x41, 0x00, 0x0A,
  0x08, 0x00, 0x70, 0x40, 0x01, 0x02, 0x00, 0x08, 0x00, 0x00, 0xFC, 0x00,
  0xC0, 0xC0, 0x40, 0x10, 0x20, 0x02, 0x10, 0x00, 0x84, 0x00, 0x12, 0x00,
  0x04, 0x80, 0x01, 0x20, 0x00, 0x50, 0x00, 0x14, 0x00, 0x09, 0x00, 0x02,
  0x40, 0x00, 0x90, 0x00, 0x24, 0x00, 0x0A, 0x00, 0x02, 0x80, 0x01, 0x20,
  0x00, 0x48, 0x00, 0x12, 0x00, 0x08, 0x80, 0x02, 0x20, 0x01, 0x04, 0x00,
  0x41, 0x80, 0x60, 0x30, 0x30, 0x03, 0xF0, 0x00, 0x07, 0xFC, 0x01, 0x00,
  0xC0, 0x80, 0x18, 0x20, 0x02, 0x08, 0x00, 0x42, 0x00, 0x10, 0x80, 0x04,
  0x20, 0x01, 0x10, 0x00, 0x84, 0x00, 0x21, 0x00, 0x18, 0x40, 0x04, 0x10,
  0x02, 0x04, 0x03, 0x03, 0xFF, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x00, 0x40, 0x00, 0x20, 0x00, 0x00, 0x00, 0xFC, 0x00, 0xC0, 0xC0,
  0x40, 0x10, 0x20, 0x02, 0x10, 0x00, 0x84, 0x00, 0x12, 0x00, 0x04, 0x80,
  0x01, 0x20, 0x00, 0x50, 0x00, 0x14, 0x00, 0x09, 0x00, 0x02, 0x40, 0x00,
  0x90, 0x00, 0x24, 0x00, 0x0A, 0x00, 0x02, 0x80, 0x01, 0x20, 0x00, 0x48,
  0x00, 0x12, 0x00, 0x08, 0x80, 0x02, 0x20, 0x01, 0x04, 0x00, 0xC1, 0x80,
  0x60, 0x30, 0x30, 0x03, 0xF8, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x07, 0xFC, 0x01, 0x00, 0xC0, 0x80, 0x08,
  0x20, 0x02, 0x08, 0x00, 0x42, 0x00, 0x10, 0x80, 0x04, 0x20, 0x01, 0x10,
  0x00, 0x84, 0x00, 0x21, 0x00, 0x08, 0x40, 0x04, 0x10, 0x02, 0x08, 0x03,
  0x03, 0xFF, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x00, 0x81,
  0x00, 0x20, 0x40, 0x0C, 0x10, 0x01, 0x04, 0x00, 0x41, 0x00, 0x18, 0x40,
  0x02, 0x20, 0x00, 0x80, 0x00, 0xFC, 0x00, 0xC0, 0xC0, 0x40, 0x18, 0x20,
  0x02, 0x18, 0x00, 0x84, 0x00, 0x21, 0x00, 0x08, 0x40, 0x00, 0x10, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x88, 0x00, 0x32, 0x00,
  0x08, 0x80, 0x02, 0x20, 0x00, 0x84, 0x00, 0x41, 0x80, 0x20, 0x30, 0x30,
  0x03, 0xF0, 0x00, 0xFF, 0xFF, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x08, 0x00, 0x22, 0x00, 0x08,
  0x40, 0x01, 0x08, 0x00, 0x21, 0x00, 0x04, 0x20, 0x00, 0x84, 0x00, 0x21,
  0x00, 0x04, 0x20, 0x00, 0x84, 0x00, 0x10, 0x80, 0x02, 0x10, 0x00, 0x44,
  0x00, 0x10, 0x80, 0x02, 0x10, 0x00, 0x42, 0x00, 0x08, 0x40, 0x01, 0x08,
  0x00, 0x42, 0x00, 0x08, 0x40, 0x01, 0x08, 0x00, 0x20, 0x80, 0x08, 0x10,
  0x03, 0x03, 0x00, 0xC0, 0x30, 0x30, 0x01, 0xF8, 0x00, 0x80, 0x00, 0xB0,
  0x00, 0x24, 0x00, 0x11, 0x00, 0x04, 0x40, 0x02, 0x10, 0x00, 0x84, 0x00,
  0x61, 0x00, 0x10, 0x20, 0x04, 0x08, 0x02, 0x02, 0x00, 0x80, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x08, 0x02, 0x02, 0x00, 0x41, 0x00, 0x10, 0x40, 0x04,
  0x20, 0x01, 0x08, 0x00, 0x44, 0x00, 0x11, 0x00, 0x02, 0x80, 0x00, 0xA0,
  0x00, 0x28, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x08, 0x00, 0xC0,
  0x0C, 0x00, 0x60, 0x06, 0x00, 0x50, 0x03, 0x00, 0x28, 0x02, 0x40, 0x14,
  0x01, 0x20, 0x12, 0x01, 0x10, 0x09, 0x00, 0x88, 0x04, 0x80, 0x44, 0x04,
  0x40, 0x42, 0x02, 0x20, 0x21, 0x02, 0x10, 0x20, 0x81, 0x08, 0x10, 0x40,
  0x82, 0x10, 0x20, 0x81, 0x08, 0x10, 0x40, 0x84, 0x04, 0x20, 0x44, 0x02,
  0x20, 0x22, 0x01, 0x10, 0x12, 0x00, 0x90, 0x09, 0x00, 0x48, 0x04, 0x80,
  0x24, 0x02, 0x80, 0x14, 0x01, 0x40, 0x0A, 0x00, 0xC0, 0x06, 0x00, 0x60,
  0x03, 0x00, 0x30, 0x01, 0x80, 0x00, 0x04, 0x00, 0x18, 0x30, 0x00, 0x80,
  0x80, 0x08, 0x04, 0x00, 0x80, 0x10, 0x0C, 0x00, 0x80, 0x40, 0x02, 0x04,
  0x00, 0x10, 0x40, 0x00, 0x82, 0x00, 0x02, 0x20, 0x00, 0x12, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x40, 0x00, 0x11, 0x00,
  0x01, 0x88, 0x00, 0x08, 0x40, 0x00, 0x81, 0x00, 0x08, 0x08, 0x00, 0xC0,
  0x20, 0x04, 0x01, 0x00, 0x40, 0x0C, 0x04, 0x00, 0x20, 0x20, 0x01, 0x02,
  0x00, 0x04, 0x00, 0x40, 0x00, 0x90, 0x00, 0x24, 0x00, 0x10, 0x80, 0x08,
  0x20, 0x02, 0x08, 0x01, 0x01, 0x00, 0x80, 0x40, 0x60, 0x10, 0x10, 0x02,
  0x08, 0x00, 0x86, 0x00, 0x21, 0x00, 0x04, 0x80, 0x01, 0x60, 0x00, 0x50,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0xC0,
  0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xC0, 0x80, 0x20, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x03,
  0xE0, 0x84, 0x21, 0x08, 0x21, 0x08, 0x42, 0x10, 0x82, 0x10, 0x84, 0x21,
  0x04, 0x21, 0x08, 0x42, 0x10, 0x42, 0x10, 0x07, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x04, 0x01, 0x03, 0xC0, 0x03, 0x00, 0xC0, 0x50, 0x14, 0x09, 0x02, 0x21,
  0x08, 0x42, 0x20, 0x88, 0x24, 0x09, 0x01, 0x80, 0x40, 0xFF, 0xF8, 0xC4,
  0x22, 0x10, 0x01, 0xF0, 0x0C, 0x18, 0x20, 0x10, 0x40, 0x21, 0x00, 0x22,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x07, 0xF8, 0x70, 0x11, 0x80,
  0x46, 0x00, 0x88, 0x01, 0x10, 0x02, 0x20, 0x0C, 0x40, 0x18, 0x80, 0xE1,
  0x83, 0x40, 0xF8, 0x80, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x11, 0xF0, 0x2C, 0x10, 0x60,
  0x10, 0x80, 0x21, 0x00, 0x44, 0x00, 0x88, 0x01, 0x10, 0x02, 0x20, 0x04,
  0x40, 0x08, 0x80, 0x12, 0x00, 0x24, 0x00, 0x48, 0x01, 0x10, 0x02, 0x20,
  0x04, 0x40, 0x11, 0x40, 0x42, 0x41, 0x04, 0x7C, 0x00, 0x03, 0xE0, 0x30,
  0x61, 0x80, 0x84, 0x03, 0x20, 0x04, 0x80, 0x14, 0x00, 0x50, 0x00, 0x40,
  0x01, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x01, 0x20,
  0x04, 0x40, 0x11, 0x00, 0x82, 0x0C, 0x07, 0xC0, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x02, 0x07,
  0xC4, 0x30, 0x48, 0x40, 0x51, 0x00, 0x64, 0x00, 0x88, 0x01, 0x10, 0x02,
  0x40, 0x04, 0x80, 0x09, 0x00, 0x12, 0x00, 0x44, 0x00, 0x88, 0x01, 0x10,
  0x02, 0x20, 0x04, 0x40, 0x10, 0x80, 0x21, 0x00, 0xC1, 0x06, 0x81, 0xF1,
  0x00, 0x03, 0xE0, 0x30, 0x61, 0x80, 0x84, 0x01, 0x20, 0x04, 0x80, 0x14,
  0x00, 0x50, 0x01, 0x7F, 0xFE, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x83, 0x06, 0x07, 0xE0,
  0x01, 0xE0, 0x40, 0x10, 0x02, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x7F,
  0x82, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x02,
  0x00, 0x40, 0x00, 0x01, 0xF1, 0x06, 0x09, 0x04, 0x05, 0x08, 0x02, 0x10,
  0x02, 0x10, 0x02, 0x10, 0x02, 0x20, 0x02, 0x20, 0x02, 0x20, 0x04, 0x20,
  0x04, 0x20, 0x04, 0x20, 0x04, 0x40, 0x04, 0x40, 0x04, 0x20, 0x08, 0x20,
  0x08, 0x20, 0x18, 0x10, 0x68, 0x0F, 0x88, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x20, 0x40, 0x60, 0x60, 0xC0, 0x1F, 0x00, 0x04,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x04,
  0x00, 0x10, 0xF0, 0x4C, 0x21, 0x40, 0x46, 0x01, 0x18, 0x04, 0xC0, 0x13,
  0x00, 0x48, 0x01, 0x20, 0x04, 0x80, 0x12, 0x00, 0x90, 0x02, 0x40, 0x09,
  0x00, 0x24, 0x00, 0x90, 0x04, 0x40, 0x12, 0x00, 0x48, 0x01, 0x20, 0x04,
  0x0C, 0x30, 0x00, 0x00, 0x00, 0x04, 0x10, 0x41, 0x04, 0x10, 0x82, 0x08,
  0x20, 0x82, 0x10, 0x41, 0x04, 0x10, 0x42, 0x08, 0x00, 0x00, 0x10, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x0C, 0x01, 0x80,
  0xF0, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x08, 0x00, 0x10, 0x04, 0x20, 0x10, 0x40, 0x40, 0x81,
  0x01, 0x04, 0x04, 0x10, 0x08, 0x40, 0x11, 0x00, 0x24, 0x00, 0x58, 0x00,
  0xC8, 0x02, 0x10, 0x04, 0x10, 0x08, 0x20, 0x10, 0x20, 0x20, 0x40, 0x40,
  0x41, 0x00, 0x82, 0x00, 0x84, 0x01, 0x00, 0x04, 0x10, 0x42, 0x08, 0x20,
  0x82, 0x10, 0x41, 0x04, 0x10, 0x42, 0x08, 0x20, 0x82, 0x08, 0x41, 0x04,
  0x10, 0x41, 0x08, 0x20, 0x11, 0xF0, 0x3E, 0x09, 0x04, 0x60, 0x85, 0x01,
  0x60, 0x43, 0x00, 0xA0, 0x13, 0x00, 0x60, 0x09, 0x80, 0x20, 0x04, 0x80,
  0x10, 0x02, 0x40, 0x08, 0x01, 0x20, 0x04, 0x01, 0x10, 0x04, 0x00, 0x90,
  0x02, 0x00, 0x48, 0x01, 0x00, 0x24, 0x00, 0x80, 0x12, 0x00, 0x40, 0x09,
  0x00, 0x20, 0x08, 0x80, 0x20, 0x04, 0x80, 0x10, 0x02, 0x40, 0x08, 0x01,
  0x20, 0x04, 0x00, 0x90, 0x02, 0x00, 0x40, 0x10, 0xF0, 0x4C, 0x21, 0x40,
  0x46, 0x01, 0x18, 0x04, 0xC0, 0x13, 0x00, 0x48, 0x01, 0x20, 0x04, 0x80,
  0x12, 0x00, 0x90, 0x02, 0x40, 0x09, 0x00, 0x24, 0x00, 0x90, 0x04, 0x40,
  0x12, 0x00, 0x48, 0x01, 0x20, 0x04, 0x03, 0xF0, 0x08, 0x30, 0x20, 0x30,
  0x80, 0x22, 0x00, 0x44, 0x00, 0x88, 0x00, 0xA0, 0x02, 0x40, 0x04, 0x80,
  0x09, 0x00, 0x12, 0x00, 0x28, 0x00, 0x50, 0x01, 0x20, 0x02, 0x20, 0x0C,
  0x40, 0x10, 0xC0, 0x40, 0xC3, 0x00, 0xFC, 0x00, 0x08, 0xF8, 0x0B, 0x04,
  0x0C, 0x02, 0x08, 0x02, 0x08, 0x02, 0x10, 0x01, 0x10, 0x01, 0x10, 0x02,
  0x10, 0x02, 0x10, 0x02, 0x10, 0x02, 0x20, 0x02, 0x20, 0x02, 0x20, 0x04,
  0x20, 0x04, 0x20, 0x04, 0x20, 0x08, 0x50, 0x10, 0x58, 0x20, 0x47, 0xC0,
  0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x03, 0xE2, 0x18, 0x24, 0x20, 0x28, 0x80, 0x22,
  0x00, 0x44, 0x00, 0x88, 0x01, 0x20, 0x02, 0x40, 0x04, 0x80, 0x11, 0x00,
  0x22, 0x00, 0x44, 0x00, 0x88, 0x01, 0x20, 0x02, 0x20, 0x08, 0x40, 0x10,
  0x80, 0x60, 0x83, 0x40, 0xF8, 0x80, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x11, 0xE2, 0x40,
  0x50, 0x0C, 0x01, 0x00, 0x60, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x40,
  0x00, 0x07, 0xE0, 0x40, 0x84, 0x02, 0x40, 0x12, 0x00, 0x90, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x38, 0x00, 0x20, 0x00, 0xC0, 0x02, 0x00, 0x08,
  0x00, 0x50, 0x04, 0x80, 0x24, 0x02, 0x18, 0x30, 0x3E, 0x00, 0x08, 0x08,
  0x08, 0x08, 0x10, 0xFF, 0x10, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20, 0x20,
  0x20, 0x20, 0x40, 0x40, 0x40, 0x40, 0x40, 0x40, 0x40, 0x40, 0x38, 0x20,
  0x04, 0x80, 0x12, 0x00, 0x48, 0x02, 0x40, 0x09, 0x00, 0x24, 0x00, 0x90,
  0x02, 0x40, 0x09, 0x00, 0x48, 0x01, 0x20, 0x04, 0x80, 0x12, 0x00, 0x48,
  0x03, 0x20, 0x08, 0x80, 0x62, 0x02, 0x84, 0x1A, 0x0F, 0x88, 0x80, 0x09,
  0x00, 0x24, 0x00, 0x90, 0x04, 0x40, 0x11, 0x00, 0x84, 0x02, 0x08, 0x10,
  0x20, 0x40, 0x82, 0x02, 0x08, 0x08, 0x40, 0x21, 0x00, 0x88, 0x01, 0x20,
  0x05, 0x00, 0x14, 0x00, 0x50, 0x01, 0x80, 0x06, 0x00, 0x80, 0x20, 0x14,
  0x03, 0x00, 0xA0, 0x18, 0x0D, 0x01, 0x40, 0x48, 0x0A, 0x02, 0x40, 0xD0,
  0x22, 0x04, 0x81, 0x08, 0x24, 0x18, 0x42, 0x20, 0x82, 0x10, 0x84, 0x11,
  0x04, 0x40, 0x88, 0x22, 0x04, 0x81, 0x30, 0x24, 0x09, 0x01, 0x20, 0x48,
  0x0A, 0x02, 0x80, 0x50, 0x14, 0x03, 0x00, 0xA0, 0x18, 0x06, 0x00, 0x80,
  0x10, 0x00, 0x08, 0x01, 0x0C, 0x02, 0x04, 0x04, 0x04, 0x0C, 0x02, 0x08,
  0x02, 0x10, 0x01, 0x20, 0x01, 0x20, 0x01, 0x40, 0x00, 0x80, 0x01, 0x80,
  0x01, 0x40, 0x02, 0x40, 0x04, 0x20, 0x0C, 0x20, 0x08, 0x30, 0x10, 0x10,
  0x20, 0x10, 0x60, 0x08, 0x40, 0x08, 0x04, 0x00, 0x41, 0x00, 0x20, 0x40,
  0x08, 0x10, 0x04, 0x04, 0x01, 0x01, 0x00, 0x80, 0x40, 0x20, 0x08, 0x10,
  0x02, 0x04, 0x00, 0x82, 0x00, 0x20, 0x80, 0x08, 0x40, 0x02, 0x10, 0x00,
  0x8C, 0x00, 0x12, 0x00, 0x05, 0x80, 0x01, 0x40, 0x00, 0x50, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x80, 0x01, 0xC0, 0x00, 0x1F, 0xFE, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x10, 0x06, 0x00, 0x80, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x10,
  0x03, 0x00, 0xC0, 0x02, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x01, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x0C, 0x20, 0x82, 0x08, 0x20,
  0x84, 0x10, 0x41, 0x04, 0x10, 0xC2, 0x08, 0x20, 0x82, 0x18, 0x41, 0x04,
  0x10, 0x41, 0x08, 0x20, 0x82, 0x08, 0x00, 0x04, 0x00, 0x60, 0x04, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x00, 0x80, 0x18, 0x01, 0x80, 0x40, 0x10,
  0x04, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x00, 0x1E, 0x00,
  0x90, 0x80, 0x50, 0x20, 0x28, 0x08, 0x24, 0x06, 0x24, 0x00, 0xE0,
};

const GFXglyph RobotoCondensed_ThinItalic37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 5, 26, 7, 1, -26 },
  { 18, 6, 7, 9, 4, -28 },
  { 24, 18, 26, 17, 1, -26 },
  { 83, 16, 32, 17, 1, -29 },
  { 147, 18, 26, 23, 3, -26 },
  { 206, 16, 26, 19, 1, -26 },
  { 258, 2, 7, 6, 4, -28 },
  { 260, 10, 37, 10, 2, -29 },
  { 307, 10, 37, 10, -2, -29 },
  { 354, 14, 14, 15, 2, -26 },
  { 379, 15, 19, 18, 2, -22 },
  { 415, 4, 7, 7, -1, -3 },
  { 419, 7, 1, 10, 1, -13 },
  { 420, 2, 2, 8, 1, -2 },
  { 421, 15, 28, 12, -1, -26 },
  { 474, 14, 26, 17, 2, -26 },
  { 520, 8, 26, 17, 5, -26 },
  { 546, 15, 26, 17, 1, -26 },
  { 595, 16, 26, 17, 1, -26 },
  { 647, 15, 26, 17, 1, -26 },
  { 696, 16, 26, 17, 2, -26 },
  { 748, 13, 26, 17, 2, -26 },
  { 791, 15, 26, 17, 3, -26 },
  { 840, 16, 26, 17, 1, -26 },
  { 892, 13, 26, 17, 3, -26 },
  { 935, 6, 19, 6, 0, -19 },
  { 950, 7, 23, 6, -1, -19 },
  { 971, 13, 14, 16, 2, -19 },
  { 994, 14, 8, 18, 2, -16 },
  { 1008, 14, 14, 16, 1, -19 },
  { 1033, 11, 26, 14, 3, -26 },
  { 1069, 26, 33, 29, 1, -25 },
  { 1177, 17, 26, 19, -1, -26 },
  { 1233, 17, 26, 19, 1, -26 },
  { 1289, 18, 26, 20, 2, -26 },
  { 1348, 18, 26, 21, 1, -26 },
  { 1407, 18, 26, 18, 1, -26 },
  { 1466, 18, 26, 18, 1, -26 },
  { 1525, 18, 26, 22, 2, -26 },
  { 1584, 20, 26, 22, 1, -26 },
  { 1649, 5, 26, 9, 2, -26 },
  { 1666, 16, 26, 17, 1, -26 },
  { 1718, 20, 26, 20, 1, -26 },
  { 1783, 13, 26, 16, 1, -26 },
  { 1826, 25, 26, 27, 1, -26 },
  { 1908, 21, 26, 22, 1, -26 },
  { 1977, 18, 26, 21, 2, -26 },
  { 2036, 18, 26, 19, 1, -26 },
  { 2095, 18, 31, 21, 2, -26 },
  { 2165, 18, 26, 21, 1, -26 },
  { 2224, 18, 26, 19, 1, -26 },
  { 2283, 16, 26, 19, 4, -26 },
  { 2335, 19, 26, 21, 2, -26 },
  { 2397, 18, 26, 19, 3, -26 },
  { 2456, 25, 26, 28, 4, -26 },
  { 2538, 21, 26, 19, -1, -26 },
  { 2607, 18, 26, 19, 3, -26 },
  { 2666, 19, 26, 19, 0, -26 },
  { 2728, 10, 36, 7, 0, -30 },
  { 2773, 5, 28, 12, 4, -26 },
  { 2791, 10, 36, 7, -2, -30 },
  { 2836, 10, 13, 13, 2, -26 },
  { 2853, 13, 1, 13, -2, 0 },
  { 2855, 4, 5, 10, 5, -28 },
  { 2858, 15, 20, 17, 0, -20 },
  { 2896, 15, 28, 17, 1, -28 },
  { 2949, 14, 20, 16, 1, -20 },
  { 2984, 15, 28, 17, 2, -28 },
  { 3037, 14, 20, 16, 1, -20 },
  { 3072, 11, 28, 10, 2, -28 },
  { 3111, 16, 28, 17, 0, -20 },
  { 3167, 14, 28, 17, 1, -28 },
  { 3216, 6, 27, 7, 1, -27 },
  { 3237, 12, 35, 7, -5, -27 },
  { 3290, 15, 28, 15, 1, -28 },
  { 3343, 6, 28, 7, 1, -28 },
  { 3364, 25, 20, 28, 1, -20 },
  { 3427, 14, 20, 17, 1, -20 },
  { 3462, 15, 20, 17, 1, -20 },
  { 3500, 16, 28, 17, 0, -20 },
  { 3556, 15, 28, 17, 1, -20 },
  { 3609, 11, 20, 11, 1, -20 },
  { 3637, 13, 20, 16, 1, -20 },
  { 3670, 8, 25, 10, 2, -25 },
  { 3695, 14, 20, 17, 2, -20 },
  { 3730, 14, 20, 15, 2, -20 },
  { 3765, 21, 20, 24, 3, -20 },
  { 3818, 16, 20, 15, -1, -20 },
  { 3858, 18, 28, 15, -2, -20 },
  { 3921, 15, 20, 15, 0, -20 },
  { 3959, 12, 37, 11, 1, -29 },
  { 4015, 6, 31, 7, 1, -26 },
  { 4039, 11, 37, 11, -2, -29 },
  { 4090, 17, 6, 22, 2, -14 },
};

const GFXfont RobotoCondensed_ThinItalic37pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ThinItalic37pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ThinItalic37pt7bGlyphs,
  0x20, 0x7E, 43
};

#endif // _ROBOTOCONDENSED_THINITALIC37PT7B_H_
