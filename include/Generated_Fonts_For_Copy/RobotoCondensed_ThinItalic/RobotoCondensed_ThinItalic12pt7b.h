#ifndef _ROBOTOCONDENSED_THINITALIC12PT7B_H_
#define _ROBOTOCONDENSED_THINITALIC12PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ThinItalic.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ThinItalic12pt7bBitmaps[] PROGMEM = {
  0x00, 0x15, 0x40, 0x80, 0x20, 0x14, 0x53, 0xCA, 0x29, 0x47, 0x94, 0x00,
  0x01, 0xD2, 0x84, 0x18, 0x31, 0x8B, 0x80, 0x62, 0xAA, 0xBC, 0x20, 0xF5,
  0x45, 0x18, 0x38, 0xA4, 0x8C, 0x21, 0x59, 0x62, 0x70, 0x40, 0x29, 0x49,
  0x24, 0x92, 0x48, 0x21, 0x11, 0x11, 0x12, 0x22, 0x24, 0x00, 0x02, 0x66,
  0x80, 0x22, 0x64, 0x44, 0x80, 0x40, 0x80, 0x01, 0x12, 0x24, 0x48, 0x80,
  0x79, 0x99, 0x99, 0x99, 0xE0, 0x55, 0x5A, 0x80, 0x3A, 0x42, 0x11, 0x08,
  0x88, 0xF0, 0x3A, 0x42, 0x13, 0x06, 0x31, 0x70, 0x08, 0x46, 0x54, 0xA9,
  0xC2, 0x10, 0x72, 0x21, 0xE1, 0x08, 0x42, 0xE0, 0x24, 0x8F, 0x99, 0x99,
  0xE0, 0x78, 0x84, 0x42, 0x21, 0x10, 0x80, 0x3A, 0x52, 0x93, 0xA6, 0x31,
  0x70, 0x79, 0x99, 0x9F, 0x12, 0xC0, 0x40, 0x08, 0x40, 0x08, 0x3C, 0xC2,
  0x66, 0x60, 0xCD, 0x80, 0x79, 0x12, 0x24, 0x00, 0x80, 0x1F, 0x10, 0x53,
  0x2A, 0x15, 0x4D, 0x26, 0x95, 0x7E, 0x80, 0x20, 0x0C, 0x00, 0x10, 0x8A,
  0x54, 0xBE, 0x31, 0x00, 0x79, 0x14, 0x51, 0x79, 0x04, 0x62, 0x38, 0x7C,
  0x61, 0x08, 0x42, 0x32, 0xF0, 0x1D, 0x14, 0x51, 0x45, 0x14, 0x62, 0x30,
  0x19, 0x04, 0x10, 0x71, 0x04, 0x20, 0x30, 0x19, 0x04, 0x10, 0x71, 0x04,
  0x20, 0x00, 0x39, 0x08, 0x20, 0x8A, 0x08, 0xA2, 0xF0, 0x00, 0x85, 0x0A,
  0x17, 0xA8, 0x91, 0x42, 0x04, 0x7F, 0x00, 0x00, 0x42, 0x10, 0x84, 0x32,
  0xF0, 0x00, 0x89, 0x22, 0x86, 0x0A, 0x14, 0x44, 0x00, 0x04, 0x44, 0x44,
  0x48, 0x20, 0x00, 0x10, 0x88, 0xCC, 0x66, 0x52, 0xA9, 0x65, 0x32, 0x10,
  0x00, 0x20, 0x45, 0x4A, 0x95, 0x29, 0x93, 0x42, 0x04, 0x7C, 0x63, 0x18,
  0xC6, 0x31, 0xF0, 0x7D, 0x14, 0x51, 0x79, 0x04, 0x20, 0x00, 0x7C, 0x63,
  0x18, 0xC6, 0x31, 0xF0, 0x04, 0x7D, 0x14, 0x51, 0x79, 0x08, 0xA2, 0x00,
  0x3D, 0x04, 0x10, 0x30, 0x28, 0x62, 0x70, 0x78, 0x82, 0x08, 0x20, 0x84,
  0x10, 0x40, 0x06, 0x18, 0x62, 0x8A, 0x28, 0xA2, 0xF0, 0x02, 0x28, 0xA4,
  0x92, 0x46, 0x10, 0x40, 0x88, 0x44, 0xA6, 0x55, 0x2A, 0xA5, 0x53, 0x28,
  0x88, 0x04, 0x00, 0x40, 0x92, 0x8C, 0x10, 0xC4, 0x92, 0x80, 0x82, 0x25,
  0x14, 0x60, 0x84, 0x10, 0x40, 0x1C, 0x10, 0x84, 0x10, 0x84, 0x10, 0xF0,
  0x09, 0x24, 0x94, 0x92, 0x40, 0xAA, 0x95, 0x40, 0x04, 0x92, 0x49, 0x49,
  0x20, 0x4A, 0x90, 0x70, 0x40, 0x78, 0x42, 0xD8, 0xCB, 0x80, 0x02, 0x1E,
  0x94, 0xC6, 0x31, 0xF0, 0x3A, 0x61, 0x08, 0x41, 0xC0, 0x04, 0x13, 0x92,
  0x8A, 0x28, 0xA2, 0x70, 0x3A, 0x6F, 0x08, 0x41, 0xC0, 0x0A, 0x49, 0x24,
  0x00, 0x3A, 0x63, 0x18, 0xC5, 0xC2, 0xE0, 0x02, 0x1E, 0x94, 0xA6, 0x31,
  0x80, 0x01, 0x56, 0xA0, 0x00, 0x01, 0x11, 0x12, 0x22, 0x24, 0x02, 0x12,
  0xA6, 0x22, 0x92, 0x80, 0x15, 0x5A, 0x80, 0x7F, 0x49, 0x49, 0x89, 0x89,
  0x89, 0x81, 0x7A, 0x52, 0x98, 0xC6, 0x00, 0x3A, 0x63, 0x18, 0xC5, 0xC0,
  0x7A, 0x53, 0x18, 0xC7, 0xD0, 0x00, 0x3A, 0x63, 0x18, 0xC5, 0xC2, 0x10,
  0x64, 0x44, 0x88, 0x80, 0x7A, 0x50, 0x41, 0x4B, 0xC0, 0x2A, 0xA8, 0x89,
  0x99, 0x9A, 0xE0, 0x09, 0xAA, 0xC4, 0x40, 0x01, 0x2A, 0xD6, 0xAD, 0x91,
  0x20, 0x00, 0x0A, 0x88, 0x46, 0x2A, 0x40, 0x00, 0x92, 0x8A, 0x30, 0x42,
  0x08, 0x40, 0x38, 0x84, 0x44, 0x41, 0x80, 0x12, 0x22, 0x40, 0x44, 0x44,
  0x40, 0x15, 0x56, 0xA8, 0x21, 0x12, 0x20, 0x02, 0x22, 0x40, 0xE1, 0xC0,
};

const GFXglyph RobotoCondensed_ThinItalic12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 2, 9, 2, 0, -9 },
  { 4, 2, 2, 3, 1, -9 },
  { 5, 6, 9, 6, 0, -9 },
  { 12, 5, 11, 6, 0, -10 },
  { 19, 6, 9, 8, 1, -9 },
  { 26, 6, 9, 6, 0, -9 },
  { 33, 1, 2, 2, 1, -9 },
  { 34, 3, 13, 3, 1, -10 },
  { 39, 4, 13, 3, -1, -10 },
  { 46, 4, 5, 5, 1, -9 },
  { 49, 4, 6, 6, 1, -7 },
  { 52, 1, 2, 2, 0, -1 },
  { 53, 3, 1, 3, 0, -5 },
  { 54, 1, 1, 3, 0, -1 },
  { 55, 4, 10, 4, 0, -9 },
  { 60, 4, 9, 6, 1, -9 },
  { 65, 2, 9, 6, 2, -9 },
  { 68, 5, 9, 6, 0, -9 },
  { 74, 5, 9, 6, 0, -9 },
  { 80, 5, 9, 6, 0, -9 },
  { 86, 5, 9, 6, 1, -9 },
  { 92, 4, 9, 6, 1, -9 },
  { 97, 5, 9, 6, 1, -9 },
  { 103, 5, 9, 6, 0, -9 },
  { 109, 4, 9, 6, 1, -9 },
  { 114, 2, 7, 2, 0, -7 },
  { 116, 2, 8, 2, 0, -7 },
  { 118, 4, 4, 5, 1, -6 },
  { 120, 4, 2, 6, 1, -5 },
  { 121, 5, 4, 5, 0, -6 },
  { 124, 4, 9, 5, 1, -9 },
  { 129, 9, 11, 9, 0, -8 },
  { 142, 5, 9, 6, 0, -9 },
  { 148, 6, 9, 6, 0, -9 },
  { 155, 5, 9, 7, 1, -9 },
  { 161, 6, 9, 7, 0, -9 },
  { 168, 6, 9, 6, 0, -9 },
  { 175, 6, 9, 6, 0, -9 },
  { 182, 6, 9, 7, 1, -9 },
  { 189, 7, 9, 7, 0, -9 },
  { 197, 1, 9, 3, 1, -9 },
  { 199, 5, 9, 6, 0, -9 },
  { 205, 7, 9, 6, 0, -9 },
  { 213, 4, 9, 5, 0, -9 },
  { 218, 9, 9, 9, 0, -9 },
  { 229, 7, 9, 7, 0, -9 },
  { 237, 5, 9, 7, 1, -9 },
  { 243, 6, 9, 6, 0, -9 },
  { 250, 5, 11, 7, 1, -9 },
  { 257, 6, 9, 7, 0, -9 },
  { 264, 6, 9, 6, 0, -9 },
  { 271, 6, 9, 6, 1, -9 },
  { 278, 6, 9, 7, 1, -9 },
  { 285, 6, 9, 6, 1, -9 },
  { 292, 9, 9, 9, 1, -9 },
  { 303, 6, 9, 6, 0, -9 },
  { 310, 6, 9, 6, 1, -9 },
  { 317, 6, 9, 6, 0, -9 },
  { 324, 3, 12, 2, 0, -10 },
  { 329, 2, 10, 4, 1, -9 },
  { 332, 3, 12, 2, -1, -10 },
  { 337, 3, 4, 4, 1, -9 },
  { 339, 5, 1, 4, -1, 0 },
  { 340, 1, 2, 3, 2, -9 },
  { 341, 5, 7, 5, 0, -7 },
  { 346, 5, 9, 6, 0, -9 },
  { 352, 5, 7, 5, 0, -7 },
  { 357, 6, 9, 6, 0, -9 },
  { 364, 5, 7, 5, 0, -7 },
  { 369, 3, 9, 3, 1, -9 },
  { 373, 5, 9, 6, 0, -7 },
  { 379, 5, 9, 6, 0, -9 },
  { 385, 2, 10, 2, 0, -10 },
  { 388, 4, 12, 2, -2, -10 },
  { 394, 5, 9, 5, 0, -9 },
  { 400, 2, 9, 2, 0, -9 },
  { 403, 8, 7, 9, 0, -7 },
  { 410, 5, 7, 6, 0, -7 },
  { 415, 5, 7, 6, 0, -7 },
  { 420, 5, 9, 6, 0, -7 },
  { 426, 5, 9, 6, 0, -7 },
  { 432, 4, 7, 4, 0, -7 },
  { 436, 5, 7, 5, 0, -7 },
  { 441, 2, 8, 3, 1, -8 },
  { 443, 4, 7, 6, 1, -7 },
  { 447, 4, 7, 5, 1, -7 },
  { 451, 7, 7, 8, 1, -7 },
  { 458, 5, 7, 5, 0, -7 },
  { 463, 6, 9, 5, -1, -7 },
  { 470, 5, 7, 5, 0, -7 },
  { 475, 4, 12, 3, 0, -9 },
  { 481, 2, 11, 2, 0, -9 },
  { 484, 4, 12, 3, -1, -9 },
  { 490, 5, 2, 7, 1, -5 },
};

const GFXfont RobotoCondensed_ThinItalic12pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ThinItalic12pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ThinItalic12pt7bGlyphs,
  0x20, 0x7E, 14
};

#endif // _ROBOTOCONDENSED_THINITALIC12PT7B_H_
