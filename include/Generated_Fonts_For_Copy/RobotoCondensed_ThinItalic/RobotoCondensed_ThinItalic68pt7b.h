#ifndef _ROBOTOCONDENSED_THINITALIC68PT7B_H_
#define _ROBOTOCONDENSED_THINITALIC68PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ThinItalic.ttf
// Size: 68pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ThinItalic68pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x04,
  0x00, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x40, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0x80, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x18, 0x03, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x3C, 0x07, 0x00, 0x60, 0x00, 0x18, 0x63, 0x0C,
  0xC1, 0x98, 0x33, 0x06, 0x60, 0x8C, 0x31, 0x86, 0x60, 0xCC, 0x19, 0x83,
  0x30, 0xC6, 0x18, 0x83, 0x00, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x80, 0x00, 0x02, 0x00, 0x60, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00,
  0x60, 0x04, 0x00, 0x00, 0x10, 0x03, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x60, 0x06, 0x00,
  0x00, 0x18, 0x01, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x30,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x08, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x40, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x40,
  0x0C, 0x00, 0x00, 0x30, 0x02, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x02,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00,
  0x10, 0x03, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x60, 0x00,
  0x00, 0x80, 0x18, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x18, 0x03, 0x00,
  0x00, 0x04, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x18,
  0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x06, 0x00,
  0xC0, 0x00, 0x01, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x30,
  0x02, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x06, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x10, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x80, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0x80, 0x18, 0x00,
  0x00, 0x60, 0x04, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0E,
  0x03, 0x80, 0x01, 0xC0, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xC0, 0x00,
  0xC0, 0x0C, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x18, 0x06, 0x00, 0x00, 0xC0,
  0x20, 0x00, 0x02, 0x03, 0x00, 0x00, 0x10, 0x18, 0x00, 0x00, 0x80, 0xC0,
  0x00, 0x04, 0x04, 0x00, 0x00, 0x20, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0C, 0x18, 0x00, 0x00, 0x60, 0x80, 0x00, 0x03, 0x04, 0x00, 0x00, 0x18,
  0x20, 0x00, 0x00, 0x81, 0x80, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x06, 0x01, 0x80, 0x00, 0x70, 0x0C, 0x00, 0x03, 0x00, 0x30, 0x00,
  0x30, 0x01, 0xC0, 0x07, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0x0E,
  0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x10, 0x03,
  0x00, 0x00, 0x30, 0x03, 0x00, 0x08, 0x20, 0x03, 0x00, 0x18, 0x60, 0x03,
  0x00, 0x18, 0x60, 0x03, 0x00, 0x30, 0x60, 0x03, 0x00, 0x60, 0x40, 0x03,
  0x00, 0x60, 0x40, 0x03, 0x00, 0xC0, 0xC0, 0x02, 0x01, 0x80, 0xC0, 0x06,
  0x01, 0x00, 0xC0, 0x06, 0x03, 0x00, 0x40, 0x0C, 0x06, 0x00, 0x60, 0x0C,
  0x0C, 0x00, 0x60, 0x18, 0x0C, 0x00, 0x30, 0x30, 0x18, 0x00, 0x3F, 0xE0,
  0x30, 0x00, 0x1F, 0xC0, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x06, 0x01, 0xF8, 0x00, 0x0C,
  0x07, 0xBC, 0x00, 0x18, 0x0E, 0x06, 0x00, 0x18, 0x18, 0x02, 0x00, 0x30,
  0x18, 0x03, 0x00, 0x60, 0x30, 0x03, 0x00, 0x60, 0x30, 0x03, 0x00, 0xC0,
  0x60, 0x03, 0x01, 0x80, 0x60, 0x03, 0x01, 0x00, 0x60, 0x03, 0x03, 0x00,
  0x40, 0x03, 0x06, 0x00, 0x40, 0x03, 0x04, 0x00, 0xC0, 0x02, 0x0C, 0x00,
  0xC0, 0x06, 0x18, 0x00, 0xC0, 0x06, 0x30, 0x00, 0xC0, 0x0C, 0x10, 0x00,
  0x40, 0x0C, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x60, 0x38, 0x00, 0x00,
  0x30, 0x70, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x70, 0x60, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x18, 0x03, 0x80, 0x00, 0xC0, 0x06, 0x00, 0x03, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x60, 0x00, 0x60, 0x01, 0x80, 0x01, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x00, 0xC0, 0x03, 0x00, 0x03,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x10, 0x07, 0x00, 0x00, 0x60,
  0x38, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x0C, 0x60,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00,
  0x18, 0x60, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x06, 0x01, 0x80, 0x0C, 0x30,
  0x06, 0x00, 0x31, 0x80, 0x0C, 0x00, 0x86, 0x00, 0x30, 0x06, 0x30, 0x00,
  0x60, 0x18, 0xC0, 0x01, 0x80, 0x66, 0x00, 0x03, 0x03, 0x18, 0x00, 0x06,
  0x0C, 0x40, 0x00, 0x18, 0x63, 0x00, 0x00, 0x31, 0x8C, 0x00, 0x00, 0xCC,
  0x30, 0x00, 0x01, 0xB0, 0xC0, 0x00, 0x07, 0x83, 0x00, 0x00, 0x0E, 0x06,
  0x00, 0x00, 0x38, 0x18, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x0C, 0xC0, 0xC0,
  0x00, 0xE3, 0x01, 0xC0, 0x06, 0x06, 0x03, 0xC0, 0x70, 0x18, 0x07, 0xFF,
  0x00, 0x30, 0x01, 0xE0, 0x00, 0x00, 0x33, 0x33, 0x33, 0x66, 0x66, 0x6C,
  0xCC, 0x00, 0x00, 0x20, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x20, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01,
  0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x78, 0x03, 0x00, 0xF7, 0xC0,
  0xC0, 0xF0, 0x3C, 0x31, 0xF0, 0x03, 0xCD, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x66, 0x00, 0x00, 0x31, 0x80,
  0x00, 0x1C, 0x30, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x01, 0x80, 0x01, 0x80,
  0x30, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x30, 0x00, 0x70, 0x0C,
  0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x0C, 0x18, 0x30, 0xC1, 0x83, 0x06,
  0x18, 0x30, 0xC3, 0x86, 0x08, 0x00, 0x7F, 0xFD, 0xFF, 0xE0, 0x37, 0x76,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x78, 0x1C, 0x00, 0x1C, 0x01, 0xC0, 0x06, 0x00,
  0x18, 0x01, 0x80, 0x01, 0x80, 0x70, 0x00, 0x30, 0x0C, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x83, 0x00, 0x00,
  0x30, 0x40, 0x00, 0x06, 0x18, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x18, 0x40,
  0x00, 0x03, 0x18, 0x00, 0x00, 0x63, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x01,
  0x88, 0x00, 0x00, 0x33, 0x00, 0x00, 0x06, 0x60, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0x31, 0x80, 0x00, 0x06, 0x30, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x19,
  0x80, 0x00, 0x02, 0x30, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x18, 0xC0, 0x00,
  0x03, 0x18, 0x00, 0x00, 0x62, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x03, 0x18,
  0x00, 0x00, 0x63, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x02, 0x00, 0x00, 0x60, 0x40,
  0x00, 0x0C, 0x0C, 0x00, 0x03, 0x01, 0x80, 0x00, 0xE0, 0x30, 0x00, 0x18,
  0x03, 0x00, 0x06, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x60, 0x00, 0x70,
  0x38, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x78, 0x03, 0xD0, 0x1E, 0x61, 0xE0, 0xCF, 0x01, 0xB8, 0x03, 0x00, 0x04,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x02, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1C,
  0x07, 0x00, 0x03, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x0C, 0x00, 0x0C,
  0x01, 0x80, 0x00, 0x60, 0x18, 0x00, 0x06, 0x03, 0x00, 0x00, 0x60, 0x30,
  0x00, 0x06, 0x06, 0x00, 0x00, 0x60, 0x60, 0x00, 0x06, 0x04, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x00,
  0xC0, 0x0E, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x60, 0x18, 0x00, 0x03, 0x03,
  0x00, 0x00, 0x30, 0x30, 0x00, 0x03, 0x02, 0x00, 0x00, 0x30, 0x60, 0x00,
  0x03, 0x06, 0x00, 0x00, 0x30, 0x60, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x18, 0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x01, 0x8C,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x06, 0x00, 0x00, 0x20, 0x60, 0x00,
  0x06, 0x06, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x1C, 0x03, 0x80, 0x03, 0x80,
  0x1C, 0x00, 0x70, 0x00, 0xF0, 0x1E, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x4C, 0x00,
  0x00, 0x0C, 0xC0, 0x00, 0x01, 0x88, 0x00, 0x00, 0x31, 0x80, 0x00, 0x03,
  0x18, 0x00, 0x00, 0x61, 0x80, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x81, 0x00,
  0x00, 0x18, 0x10, 0x00, 0x03, 0x03, 0x00, 0x00, 0x60, 0x30, 0x00, 0x06,
  0x03, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x18, 0x02, 0x00, 0x03, 0x00, 0x60,
  0x00, 0x30, 0x06, 0x00, 0x06, 0x00, 0x60, 0x00, 0xC0, 0x06, 0x00, 0x1C,
  0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x0C,
  0x00, 0x60, 0x00, 0xC0, 0x0C, 0x00, 0x0C, 0x01, 0x80, 0x00, 0xC0, 0x38,
  0x00, 0x08, 0x03, 0x00, 0x01, 0x80, 0x60, 0x00, 0x18, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x10, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x07, 0xF0, 0x00, 0x09,
  0xFF, 0xE0, 0x00, 0xDC, 0x03, 0x80, 0x07, 0x80, 0x0E, 0x00, 0x30, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x04,
  0x0C, 0x00, 0x00, 0x60, 0x60, 0x00, 0x03, 0x03, 0x00, 0x00, 0x18, 0x08,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x0C, 0x03, 0x00, 0x00, 0xC0, 0x18, 0x00,
  0x06, 0x00, 0x60, 0x00, 0x60, 0x03, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x70,
  0x00, 0x38, 0x0E, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x07, 0xF0, 0x06, 0x0F, 0xFE, 0x03,
  0x1C, 0x03, 0x81, 0x18, 0x00, 0xE1, 0x98, 0x00, 0x30, 0xD8, 0x00, 0x0C,
  0x78, 0x00, 0x06, 0x38, 0x00, 0x01, 0x98, 0x00, 0x00, 0xDC, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x36, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x0D, 0x80, 0x00,
  0x06, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x58, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x36, 0x00, 0x00, 0x19, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x06, 0x0C,
  0x00, 0x06, 0x06, 0x00, 0x06, 0x01, 0x80, 0x07, 0x00, 0xE0, 0x07, 0x00,
  0x3C, 0x0F, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0xF0, 0x1C, 0x00, 0x07, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x01,
  0xC0, 0x00, 0xE0, 0x06, 0x00, 0x01, 0x80, 0x30, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0x0C, 0x06, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0xC0, 0x40, 0x00,
  0x03, 0x03, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x20, 0x30, 0x00, 0x01,
  0x80, 0xC0, 0x00, 0x06, 0x03, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0xC0,
  0x18, 0x00, 0x06, 0x00, 0x60, 0x00, 0x38, 0x00, 0xC0, 0x01, 0xC0, 0x03,
  0x80, 0x0E, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xC0, 0x00,
  0xC0, 0x06, 0x00, 0x01, 0x80, 0x30, 0x00, 0x03, 0x01, 0x80, 0x00, 0x0C,
  0x06, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x01, 0x86,
  0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x41, 0x80,
  0x00, 0x03, 0x06, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x30, 0x60, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x06, 0x06, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x01,
  0xC0, 0x30, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80,
  0x01, 0xC0, 0x78, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x3C, 0x0E, 0x00, 0x38, 0x03,
  0x80, 0x30, 0x00, 0xE0, 0x30, 0x00, 0x30, 0x30, 0x00, 0x0C, 0x18, 0x00,
  0x06, 0x18, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x06, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x2C, 0x00, 0x00, 0x36, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x1D,
  0x80, 0x00, 0x0E, 0xC0, 0x00, 0x0F, 0x20, 0x00, 0x05, 0x18, 0x00, 0x07,
  0x8C, 0x00, 0x06, 0xC3, 0x00, 0x06, 0x61, 0xC0, 0x0E, 0x20, 0x70, 0x0E,
  0x30, 0x1F, 0xFC, 0x18, 0x03, 0xF8, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0x81,
  0xC0, 0xE0, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x78,
  0x38, 0x18, 0x00, 0x00, 0x20, 0x07, 0x00, 0xF0, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0x80,
  0x18, 0x03, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x02, 0x00, 0x3F, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFC,
  0x08, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x1F, 0xF0, 0x07, 0x81, 0xC0, 0xE0, 0x0C, 0x1C,
  0x00, 0x61, 0x80, 0x06, 0x30, 0x00, 0x33, 0x00, 0x03, 0x60, 0x00, 0x36,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00,
  0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x04, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x7E, 0x00, 0x06,
  0x01, 0x80, 0x01, 0xFF, 0x80, 0x02, 0x01, 0x80, 0x03, 0x81, 0xC0, 0x02,
  0x03, 0x00, 0x06, 0x00, 0xE0, 0x02, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x02,
  0x06, 0x00, 0x18, 0x00, 0x40, 0x03, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x0C, 0x00, 0x60, 0x00, 0xC0, 0x02,
  0x18, 0x00, 0x60, 0x00, 0x80, 0x02, 0x18, 0x00, 0xC0, 0x01, 0x80, 0x02,
  0x18, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x30, 0x01, 0x80, 0x01, 0x80, 0x06,
  0x30, 0x01, 0x80, 0x01, 0x00, 0x06, 0x30, 0x01, 0x00, 0x03, 0x00, 0x06,
  0x20, 0x03, 0x00, 0x03, 0x00, 0x06, 0x60, 0x03, 0x00, 0x03, 0x00, 0x04,
  0x60, 0x02, 0x00, 0x03, 0x00, 0x0C, 0x60, 0x06, 0x00, 0x02, 0x00, 0x0C,
  0x60, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x40, 0x06, 0x00, 0x06, 0x00, 0x18,
  0x40, 0x04, 0x00, 0x06, 0x00, 0x18, 0x40, 0x04, 0x00, 0x0C, 0x00, 0x18,
  0xC0, 0x04, 0x00, 0x0C, 0x00, 0x30, 0xC0, 0x0C, 0x00, 0x1C, 0x00, 0x30,
  0xC0, 0x0C, 0x00, 0x1C, 0x00, 0x60, 0xC0, 0x0C, 0x00, 0x3C, 0x00, 0x60,
  0xC0, 0x0C, 0x00, 0x2C, 0x00, 0xC0, 0xC0, 0x04, 0x00, 0x6C, 0x00, 0xC0,
  0xC0, 0x06, 0x00, 0xCC, 0x01, 0x80, 0x40, 0x06, 0x01, 0x84, 0x03, 0x00,
  0x60, 0x03, 0x07, 0x07, 0x0E, 0x00, 0x60, 0x03, 0xFC, 0x03, 0xFC, 0x00,
  0x60, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x00,
  0x00, 0xF8, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x00,
  0x08, 0x40, 0x00, 0x00, 0x18, 0x40, 0x00, 0x00, 0x10, 0x60, 0x00, 0x00,
  0x30, 0x60, 0x00, 0x00, 0x20, 0x60, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00,
  0x40, 0x20, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x01,
  0x80, 0x30, 0x00, 0x01, 0x80, 0x30, 0x00, 0x03, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x30, 0x00, 0x06, 0x00, 0x10, 0x00, 0x0C,
  0x00, 0x10, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x18, 0x00, 0x30, 0x00, 0x18, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x60, 0x00, 0x08, 0x00, 0x40, 0x00, 0x0C, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0x00,
  0x00, 0x0C, 0x03, 0x00, 0x00, 0x0C, 0x02, 0x00, 0x00, 0x04, 0x06, 0x00,
  0x00, 0x04, 0x06, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x06, 0x0C, 0x00,
  0x00, 0x06, 0x18, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x06, 0x30, 0x00,
  0x00, 0x06, 0x30, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x03, 0x60, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x08, 0x00, 0x1E, 0x00, 0x60, 0x00, 0x1C, 0x01, 0x80, 0x00,
  0x30, 0x06, 0x00, 0x00, 0x60, 0x18, 0x00, 0x01, 0x80, 0x40, 0x00, 0x03,
  0x03, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x03, 0x03, 0x00, 0x00, 0x08, 0x08, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x01, 0x81, 0x80, 0x00, 0x06, 0x06, 0x00, 0x00, 0x30, 0x18, 0x00,
  0x01, 0xC0, 0x40, 0x00, 0x06, 0x01, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x03,
  0x80, 0x30, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00,
  0x08, 0x00, 0x0F, 0x00, 0x20, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x1C, 0x06,
  0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x60, 0x60, 0x00, 0x01, 0x81, 0x00,
  0x00, 0x02, 0x0C, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x00, 0x83, 0x00, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x18, 0x20, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x01, 0x86, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x30,
  0x60, 0x00, 0x01, 0x81, 0x00, 0x00, 0x06, 0x04, 0x00, 0x00, 0x30, 0x30,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x1C, 0x03, 0x00, 0x01, 0xE0, 0x0F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70,
  0x00, 0x18, 0x00, 0xE0, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x0E, 0x01, 0x80,
  0x00, 0x06, 0x03, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x06, 0x06, 0x00,
  0x00, 0x03, 0x04, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x03, 0x18, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x60, 0x40, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x01, 0x80, 0x30, 0x00,
  0x03, 0x00, 0x30, 0x00, 0x07, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x0C, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x60,
  0x00, 0x78, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x01, 0x80, 0x0C,
  0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x30, 0x02, 0x00, 0x00, 0x0C, 0x03,
  0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0xC0,
  0x60, 0x00, 0x00, 0x60, 0x20, 0x00, 0x00, 0x30, 0x10, 0x00, 0x00, 0x08,
  0x18, 0x00, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x02, 0x06, 0x00, 0x00, 0x01,
  0x03, 0x00, 0x00, 0x01, 0x81, 0x00, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x10, 0x30, 0x00, 0x00,
  0x08, 0x18, 0x00, 0x00, 0x0C, 0x08, 0x00, 0x00, 0x06, 0x04, 0x00, 0x00,
  0x03, 0x06, 0x00, 0x00, 0x01, 0x83, 0x00, 0x00, 0x00, 0x81, 0x80, 0x00,
  0x00, 0x40, 0xC0, 0x00, 0x00, 0x60, 0x40, 0x00, 0x00, 0x30, 0x60, 0x00,
  0x00, 0x18, 0x30, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0x0C, 0x0C, 0x00,
  0x00, 0x06, 0x04, 0x00, 0x00, 0x06, 0x02, 0x00, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x03, 0x01, 0x80, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x01, 0x80, 0x60,
  0x00, 0x01, 0x80, 0x20, 0x00, 0x01, 0xC0, 0x10, 0x00, 0x01, 0xC0, 0x18,
  0x00, 0x01, 0xC0, 0x0C, 0x00, 0x03, 0x80, 0x06, 0x00, 0x07, 0x80, 0x03,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x08, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x08,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F,
  0x00, 0xF0, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x18, 0x00, 0xE0,
  0x00, 0x0C, 0x01, 0xC0, 0x00, 0x06, 0x01, 0x80, 0x00, 0x06, 0x03, 0x00,
  0x00, 0x06, 0x06, 0x00, 0x00, 0x02, 0x06, 0x00, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x03, 0x18, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x40, 0x00, 0xFF, 0xF8, 0x40, 0x00, 0xFF, 0xF8, 0xC0, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x18, 0xC0, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x00, 0x10, 0x80, 0x00, 0x00, 0x30, 0x80, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x00, 0x60, 0x60, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0xE0, 0x30, 0x00,
  0x01, 0xC0, 0x18, 0x00, 0x07, 0x80, 0x0C, 0x00, 0x1F, 0x00, 0x07, 0x00,
  0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x10, 0x08, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x18, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00,
  0x02, 0x01, 0x80, 0x00, 0x00, 0x20, 0x10, 0x00, 0x00, 0x06, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x30, 0x00, 0x00, 0x04, 0x02, 0x00, 0x00, 0x00, 0x40, 0x20, 0x00, 0x00,
  0x0C, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x0C, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x08, 0x04, 0x00, 0x00, 0x01, 0x80,
  0x40, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00,
  0x18, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x08, 0x00,
  0x00, 0x03, 0x00, 0x80, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x03, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x02, 0x01, 0x80, 0x00, 0x00,
  0x20, 0x10, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x00, 0x60, 0x30, 0x00,
  0x00, 0x06, 0x03, 0x00, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x04, 0x02,
  0x00, 0x00, 0x00, 0x40, 0x20, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x60, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x60, 0x00,
  0x00, 0x08, 0x04, 0x00, 0x00, 0x01, 0x80, 0x40, 0x00, 0x00, 0x18, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0xC0, 0x00, 0x00, 0x10, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x20, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x04, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x10, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x08, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x04, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x02, 0x00, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00,
  0xC0, 0x40, 0x00, 0x02, 0x01, 0x00, 0x00, 0x18, 0x04, 0x00, 0x00, 0x60,
  0x10, 0x00, 0x03, 0x00, 0x60, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x60, 0x06,
  0x00, 0x01, 0x80, 0x1C, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60,
  0x03, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x10, 0x00, 0x00, 0x30, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x03, 0x00, 0x00, 0x20, 0x00, 0xC0, 0x00, 0x04,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00,
  0x06, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x10, 0x0C, 0x00,
  0x00, 0x02, 0x03, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x18, 0x30,
  0x00, 0x00, 0x03, 0x0F, 0x00, 0x00, 0x00, 0x63, 0x60, 0x00, 0x00, 0x08,
  0xC6, 0x00, 0x00, 0x01, 0x30, 0x60, 0x00, 0x00, 0x6C, 0x0C, 0x00, 0x00,
  0x0F, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x00, 0x30, 0x01, 0x80,
  0x00, 0x04, 0x00, 0x30, 0x00, 0x01, 0x80, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x10,
  0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x03, 0x00, 0x00, 0x30, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x08, 0x00, 0x00, 0x60, 0x01, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x0C, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x30,
  0x00, 0x00, 0x18, 0x04, 0x00, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x02,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x38, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x00,
  0x1E, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x00, 0x0D,
  0x00, 0xD0, 0x00, 0x00, 0x00, 0x78, 0x06, 0xC0, 0x00, 0x00, 0x06, 0xC0,
  0x26, 0x00, 0x00, 0x00, 0x26, 0x03, 0x30, 0x00, 0x00, 0x03, 0x30, 0x19,
  0x80, 0x00, 0x00, 0x11, 0x80, 0xC4, 0x00, 0x00, 0x01, 0x88, 0x06, 0x20,
  0x00, 0x00, 0x08, 0xC0, 0x21, 0x80, 0x00, 0x00, 0xC6, 0x01, 0x0C, 0x00,
  0x00, 0x0C, 0x30, 0x18, 0x60, 0x00, 0x00, 0x61, 0x80, 0xC3, 0x00, 0x00,
  0x06, 0x0C, 0x06, 0x08, 0x00, 0x00, 0x30, 0x40, 0x30, 0x60, 0x00, 0x03,
  0x06, 0x01, 0x03, 0x00, 0x00, 0x18, 0x30, 0x08, 0x18, 0x00, 0x01, 0x81,
  0x80, 0xC0, 0xC0, 0x00, 0x0C, 0x0C, 0x06, 0x02, 0x00, 0x00, 0xC0, 0x40,
  0x30, 0x10, 0x00, 0x04, 0x02, 0x01, 0x80, 0xC0, 0x00, 0x60, 0x30, 0x08,
  0x06, 0x00, 0x02, 0x01, 0x80, 0x40, 0x30, 0x00, 0x30, 0x0C, 0x06, 0x00,
  0x80, 0x03, 0x00, 0x60, 0x30, 0x04, 0x00, 0x18, 0x02, 0x01, 0x80, 0x30,
  0x01, 0x80, 0x30, 0x0C, 0x01, 0x80, 0x0C, 0x01, 0x80, 0x40, 0x0C, 0x00,
  0xC0, 0x0C, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x30, 0x01, 0x00, 0x60,
  0x03, 0x01, 0x80, 0x08, 0x03, 0x00, 0x10, 0x0C, 0x00, 0x60, 0x30, 0x01,
  0x80, 0x60, 0x03, 0x01, 0x80, 0x0C, 0x02, 0x00, 0x18, 0x18, 0x00, 0x60,
  0x30, 0x00, 0x40, 0xC0, 0x03, 0x01, 0x80, 0x02, 0x0C, 0x00, 0x18, 0x0C,
  0x00, 0x18, 0x40, 0x00, 0x80, 0x60, 0x00, 0xC6, 0x00, 0x0C, 0x03, 0x00,
  0x06, 0x60, 0x00, 0x60, 0x10, 0x00, 0x13, 0x00, 0x03, 0x01, 0x80, 0x00,
  0xB0, 0x00, 0x18, 0x0C, 0x00, 0x05, 0x80, 0x00, 0x80, 0x60, 0x00, 0x38,
  0x00, 0x04, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x10, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x00, 0x80,
  0x78, 0x00, 0x00, 0x0C, 0x03, 0xC0, 0x00, 0x00, 0x60, 0x1A, 0x00, 0x00,
  0x03, 0x00, 0xD8, 0x00, 0x00, 0x18, 0x06, 0x40, 0x00, 0x00, 0xC0, 0x33,
  0x00, 0x00, 0x04, 0x03, 0x18, 0x00, 0x00, 0x60, 0x18, 0x40, 0x00, 0x03,
  0x00, 0xC3, 0x00, 0x00, 0x18, 0x06, 0x18, 0x00, 0x00, 0xC0, 0x30, 0x60,
  0x00, 0x06, 0x01, 0x83, 0x00, 0x00, 0x20, 0x18, 0x08, 0x00, 0x03, 0x00,
  0xC0, 0x60, 0x00, 0x18, 0x06, 0x03, 0x00, 0x00, 0xC0, 0x30, 0x0C, 0x00,
  0x06, 0x01, 0x80, 0x60, 0x00, 0x30, 0x08, 0x01, 0x00, 0x01, 0x00, 0xC0,
  0x0C, 0x00, 0x18, 0x06, 0x00, 0x60, 0x00, 0xC0, 0x30, 0x01, 0x80, 0x06,
  0x01, 0x80, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x20, 0x01, 0x80, 0xC0, 0x01,
  0x80, 0x18, 0x06, 0x00, 0x0C, 0x00, 0xC0, 0x30, 0x00, 0x20, 0x06, 0x01,
  0x80, 0x01, 0x80, 0x30, 0x0C, 0x00, 0x04, 0x01, 0x80, 0x60, 0x00, 0x30,
  0x0C, 0x06, 0x00, 0x01, 0x80, 0xC0, 0x30, 0x00, 0x04, 0x06, 0x01, 0x80,
  0x00, 0x30, 0x30, 0x0C, 0x00, 0x01, 0x81, 0x80, 0x60, 0x00, 0x06, 0x0C,
  0x02, 0x00, 0x00, 0x30, 0x40, 0x30, 0x00, 0x00, 0x86, 0x01, 0x80, 0x00,
  0x06, 0x30, 0x0C, 0x00, 0x00, 0x31, 0x80, 0x60, 0x00, 0x00, 0xCC, 0x03,
  0x00, 0x00, 0x06, 0x60, 0x10, 0x00, 0x00, 0x16, 0x01, 0x80, 0x00, 0x00,
  0xF0, 0x0C, 0x00, 0x00, 0x07, 0x80, 0x60, 0x00, 0x00, 0x1C, 0x03, 0x00,
  0x00, 0x00, 0xE0, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x07, 0x80, 0x07,
  0x00, 0x07, 0x00, 0x01, 0x80, 0x07, 0x00, 0x00, 0x60, 0x07, 0x00, 0x00,
  0x18, 0x03, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x02, 0x03, 0x00, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x00, 0x30, 0x60, 0x00, 0x00, 0x08, 0x60, 0x00, 0x00, 0x04, 0x30, 0x00,
  0x00, 0x02, 0x18, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0x31, 0x80,
  0x00, 0x00, 0x18, 0x80, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x00, 0x0C, 0x60,
  0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x01, 0x8C,
  0x00, 0x00, 0x00, 0x84, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x0C,
  0x60, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x01, 0x83, 0x00, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x60, 0x20, 0x00, 0x00,
  0x60, 0x18, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x70, 0x03, 0x00, 0x00,
  0x70, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x30, 0x00, 0xF0, 0x00, 0x0E, 0x01,
  0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x80, 0x00, 0xF0, 0x01,
  0x80, 0x00, 0x38, 0x01, 0x80, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x0C, 0x01,
  0x80, 0x00, 0x0E, 0x01, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x02, 0x03,
  0x00, 0x00, 0x06, 0x02, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x06, 0x06,
  0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x0C, 0x04,
  0x00, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x18, 0x0C,
  0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0xE0, 0x08,
  0x00, 0x03, 0xC0, 0x08, 0x00, 0x0F, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0x00, 0xE0, 0x00,
  0x3C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x0C, 0x01,
  0xC0, 0x00, 0x06, 0x01, 0x80, 0x00, 0x06, 0x03, 0x00, 0x00, 0x02, 0x06,
  0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x01, 0x18, 0x00, 0x00, 0x01, 0x18,
  0x00, 0x00, 0x01, 0x18, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x03, 0x30,
  0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x03, 0x30,
  0x00, 0x00, 0x02, 0x20, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0x04, 0x40, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x0C, 0xC0,
  0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x0C, 0xC0,
  0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x60, 0x40, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x03, 0x80, 0x30, 0x00, 0x07, 0x00, 0x18,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x3E, 0x70, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x30, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x03, 0x80, 0x0C, 0x00, 0x00, 0xE0,
  0x06, 0x00, 0x00, 0x30, 0x02, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x06,
  0x01, 0x80, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x60, 0x00, 0x00,
  0x60, 0x30, 0x00, 0x00, 0x30, 0x10, 0x00, 0x00, 0x10, 0x18, 0x00, 0x00,
  0x08, 0x0C, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x03, 0x00, 0x80, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0xC0, 0x18, 0x00,
  0x00, 0xC0, 0x08, 0x00, 0x01, 0xC0, 0x04, 0x00, 0x03, 0x80, 0x07, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0x80, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x02, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x30, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x20, 0x00, 0x00, 0xC0, 0x10, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x30,
  0x0C, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x03,
  0x01, 0x00, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0xC0, 0x00,
  0x06, 0x01, 0x80, 0x00, 0x06, 0x03, 0x00, 0x00, 0x02, 0x03, 0x00, 0x00,
  0x03, 0x02, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00,
  0x02, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00,
  0xC0, 0x60, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x03, 0x80, 0x38, 0x00, 0x07,
  0x00, 0x1C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x78, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x00, 0x30, 0x30, 0x00, 0x00, 0x08, 0x0C, 0x00, 0x00, 0x06, 0x02, 0x00,
  0x00, 0x01, 0x80, 0x80, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x18, 0x18,
  0x00, 0x00, 0x04, 0x06, 0x00, 0x00, 0x01, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x40, 0x00, 0x00, 0x30, 0x10, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x03,
  0x03, 0x00, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x00, 0x20, 0x30, 0x00, 0x00,
  0x18, 0x08, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x00, 0x10, 0x18, 0x00, 0x00, 0x04, 0x06, 0x00,
  0x00, 0x03, 0x01, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x30, 0x30,
  0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x02, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x80, 0x00, 0x00, 0x60, 0x20, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x06,
  0x06, 0x00, 0x00, 0x01, 0x01, 0x80, 0x00, 0x00, 0x40, 0x60, 0x00, 0x00,
  0x30, 0x10, 0x00, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x00, 0x20, 0x30, 0x00, 0x00, 0x18, 0x0C, 0x00,
  0x00, 0x06, 0x01, 0x00, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x18,
  0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x0F, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x00, 0x0C, 0x60, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x18, 0x60, 0x00,
  0x00, 0x18, 0x60, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x30, 0x60, 0x00,
  0x00, 0x60, 0x20, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0xC0, 0x30, 0x00,
  0x00, 0xC0, 0x30, 0x00, 0x00, 0x80, 0x30, 0x00, 0x01, 0x80, 0x30, 0x00,
  0x01, 0x80, 0x30, 0x00, 0x03, 0x00, 0x10, 0x00, 0x03, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x18, 0x00, 0x06, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x08, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x0C, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x40, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x04, 0x00,
  0xC0, 0x00, 0x06, 0x01, 0x80, 0x00, 0x06, 0x01, 0x80, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x02, 0x06,
  0x00, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x03, 0x08,
  0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x03, 0x10, 0x00, 0x00, 0x03, 0x30,
  0x00, 0x00, 0x01, 0x20, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x07, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x36, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x58, 0x00, 0x01, 0x98, 0x00, 0x01, 0xB0, 0x00, 0x03, 0x30, 0x00, 0x02,
  0x60, 0x00, 0x06, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18,
  0x80, 0x00, 0x31, 0x80, 0x00, 0x21, 0x00, 0x00, 0x43, 0x00, 0x00, 0xC2,
  0x00, 0x01, 0x86, 0x00, 0x01, 0x04, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x08,
  0x00, 0x0C, 0x08, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x18, 0x00, 0x10, 0x30,
  0x00, 0x30, 0x30, 0x00, 0x60, 0x60, 0x00, 0xC0, 0x60, 0x00, 0x80, 0xC0,
  0x01, 0x80, 0xC0, 0x03, 0x01, 0x80, 0x02, 0x01, 0x80, 0x06, 0x03, 0x00,
  0x0C, 0x03, 0x00, 0x18, 0x02, 0x00, 0x18, 0x06, 0x00, 0x30, 0x04, 0x00,
  0x60, 0x0C, 0x00, 0x40, 0x08, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x10, 0x01,
  0x80, 0x30, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x0C, 0x00, 0x60, 0x0C,
  0x00, 0xC0, 0x18, 0x00, 0xC0, 0x10, 0x01, 0x80, 0x20, 0x01, 0x80, 0x60,
  0x03, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x02, 0x01, 0x80, 0x06, 0x03, 0x00,
  0x04, 0x06, 0x00, 0x0C, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x0C, 0x00,
  0x18, 0x10, 0x00, 0x10, 0x30, 0x00, 0x30, 0x60, 0x00, 0x20, 0x60, 0x00,
  0x60, 0xC0, 0x00, 0x40, 0x80, 0x00, 0xC3, 0x00, 0x00, 0xC3, 0x00, 0x01,
  0x86, 0x00, 0x01, 0x86, 0x00, 0x03, 0x18, 0x00, 0x03, 0x18, 0x00, 0x06,
  0x30, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0x40, 0x00, 0x19,
  0x80, 0x00, 0x19, 0x80, 0x00, 0x33, 0x00, 0x00, 0x33, 0x00, 0x00, 0x64,
  0x00, 0x00, 0x64, 0x00, 0x00, 0xD8, 0x00, 0x00, 0xD8, 0x00, 0x00, 0xB0,
  0x00, 0x00, 0xB0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00,
  0x00, 0xE0, 0x06, 0x00, 0x00, 0x03, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x06, 0x00, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x00, 0x02, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x00,
  0x31, 0x80, 0x00, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x00, 0x01, 0xB0, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x80, 0x00,
  0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x00, 0x0C,
  0x18, 0x00, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x03, 0x00, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x18,
  0x30, 0x00, 0x00, 0x30, 0x38, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x60,
  0x18, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x01, 0x80,
  0x0C, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x30, 0x00, 0x03, 0x00, 0x30, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x46, 0x00, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x00, 0x68, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x02, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0xC0, 0x60, 0x30, 0x08, 0x04,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x08, 0x04, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x08, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x08, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x08, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x10, 0x08, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x10, 0x08, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x10, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00,
  0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x07, 0x00, 0x01, 0x40, 0x00, 0xD0, 0x00, 0x24, 0x00, 0x19, 0x80, 0x04,
  0x60, 0x03, 0x18, 0x00, 0x86, 0x00, 0x60, 0x80, 0x10, 0x20, 0x0C, 0x0C,
  0x02, 0x03, 0x01, 0x80, 0xC0, 0x40, 0x30, 0x30, 0x04, 0x08, 0x01, 0x86,
  0x00, 0x61, 0x00, 0x18, 0xC0, 0x06, 0x20, 0x01, 0x98, 0x00, 0x64, 0x00,
  0x0F, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x60, 0x70, 0x30,
  0x38, 0x18, 0x0C, 0x0C, 0x06, 0x06, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xFF,
  0x00, 0x07, 0x80, 0xE0, 0x03, 0x80, 0x0C, 0x01, 0x80, 0x01, 0x80, 0xC0,
  0x00, 0x60, 0x30, 0x00, 0x08, 0x18, 0x00, 0x03, 0x04, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x0F, 0x00, 0x0C, 0x0E,
  0x00, 0x03, 0x07, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x08,
  0x60, 0x00, 0x06, 0x18, 0x00, 0x01, 0x84, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x18, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x01, 0xC3, 0x00,
  0x00, 0xF0, 0xC0, 0x00, 0x6C, 0x18, 0x00, 0x33, 0x07, 0x00, 0x38, 0xC0,
  0xE0, 0x3C, 0x30, 0x1F, 0xFC, 0x0C, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x78,
  0x00, 0x18, 0x7F, 0xF0, 0x02, 0x1C, 0x07, 0x00, 0x4E, 0x00, 0x70, 0x1B,
  0x00, 0x06, 0x03, 0xC0, 0x00, 0x60, 0x70, 0x00, 0x0C, 0x0C, 0x00, 0x01,
  0x81, 0x80, 0x00, 0x30, 0x20, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x41, 0x80,
  0x00, 0x08, 0x30, 0x00, 0x01, 0x06, 0x00, 0x00, 0x20, 0x80, 0x00, 0x0C,
  0x30, 0x00, 0x01, 0x86, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x06, 0x18, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x18, 0x40, 0x00, 0x02, 0x18, 0x00, 0x00, 0x43,
  0x00, 0x00, 0x18, 0x60, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x61, 0x00, 0x00,
  0x08, 0x20, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x61, 0x80, 0x00, 0x18, 0x30,
  0x00, 0x03, 0x06, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x18, 0x14, 0x00, 0x06,
  0x06, 0xC0, 0x01, 0xC0, 0xCC, 0x00, 0x70, 0x18, 0xE0, 0x3C, 0x03, 0x07,
  0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xFE,
  0x00, 0x0F, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x03, 0x80, 0x03, 0x00, 0xC0,
  0x00, 0xC0, 0x60, 0x00, 0x18, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x86,
  0x00, 0x00, 0x61, 0x80, 0x00, 0x18, 0x40, 0x00, 0x06, 0x30, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x18, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x06, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x60, 0x60, 0x00, 0x30, 0x0C, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00,
  0x78, 0x0E, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x3E, 0x01, 0x80, 0x0F, 0xFC, 0x08, 0x00, 0xE0, 0x38, 0x40,
  0x0C, 0x00, 0x66, 0x00, 0xC0, 0x01, 0xB0, 0x0C, 0x00, 0x05, 0x80, 0xC0,
  0x00, 0x3C, 0x06, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x06, 0x03, 0x00, 0x00,
  0x30, 0x10, 0x00, 0x01, 0x81, 0x80, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x60,
  0x40, 0x00, 0x02, 0x06, 0x00, 0x00, 0x30, 0x30, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x0C, 0x0C, 0x00, 0x00, 0x60, 0x40, 0x00, 0x03, 0x06, 0x00, 0x00,
  0x10, 0x30, 0x00, 0x01, 0x81, 0x80, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x03, 0x03, 0x00, 0x00, 0x10, 0x18, 0x00, 0x00, 0x80, 0xC0,
  0x00, 0x0C, 0x06, 0x00, 0x00, 0x60, 0x30, 0x00, 0x03, 0x01, 0x80, 0x00,
  0x18, 0x0C, 0x00, 0x01, 0x80, 0x60, 0x00, 0x0C, 0x01, 0x80, 0x00, 0xE0,
  0x0C, 0x00, 0x1B, 0x00, 0x30, 0x01, 0x98, 0x00, 0xE0, 0x78, 0xC0, 0x03,
  0xFF, 0x04, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0xFC, 0x00, 0x1C, 0x07, 0x00, 0x18, 0x00, 0xC0, 0x18, 0x00, 0x30, 0x18,
  0x00, 0x18, 0x18, 0x00, 0x06, 0x18, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x8C,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0x66, 0x00, 0x00, 0x33, 0x00, 0x00, 0x19,
  0x80, 0x00, 0x0D, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x03, 0x7F, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xD0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x0C, 0x07, 0x00, 0x1C, 0x01, 0xE0, 0x38, 0x00,
  0x7F, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0xFF, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x7F, 0xFF,
  0x07, 0xFF, 0xF0, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x40,
  0x07, 0x01, 0xC6, 0x00, 0x60, 0x03, 0x30, 0x06, 0x00, 0x0D, 0x80, 0x60,
  0x00, 0x2C, 0x06, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x06, 0x03, 0x00, 0x00,
  0x30, 0x18, 0x00, 0x01, 0x81, 0x80, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x02, 0x02, 0x00, 0x00, 0x10, 0x30, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x0C, 0x0C, 0x00, 0x00, 0x60, 0x40, 0x00, 0x03, 0x02, 0x00, 0x00,
  0x10, 0x30, 0x00, 0x00, 0x81, 0x80, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x03, 0x03, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x80, 0xC0,
  0x00, 0x04, 0x04, 0x00, 0x00, 0x60, 0x30, 0x00, 0x03, 0x01, 0x80, 0x00,
  0x18, 0x0C, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x0C, 0x03, 0x00, 0x00, 0xE0,
  0x0C, 0x00, 0x0F, 0x00, 0x60, 0x00, 0xD8, 0x01, 0x80, 0x0C, 0xC0, 0x07,
  0x03, 0xC6, 0x00, 0x1F, 0xF8, 0x20, 0x00, 0x3E, 0x01, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x20,
  0x00, 0x18, 0x01, 0x80, 0x01, 0xC0, 0x06, 0x00, 0x1C, 0x00, 0x1C, 0x03,
  0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x0F, 0x00, 0x0C, 0x1F,
  0xF8, 0x03, 0x0E, 0x07, 0x00, 0x8E, 0x00, 0xC0, 0x67, 0x00, 0x18, 0x19,
  0x80, 0x06, 0x06, 0xC0, 0x00, 0x81, 0xE0, 0x00, 0x30, 0x50, 0x00, 0x0C,
  0x1C, 0x00, 0x03, 0x0E, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x30, 0xC0, 0x00,
  0x0C, 0x30, 0x00, 0x02, 0x08, 0x00, 0x01, 0x86, 0x00, 0x00, 0x61, 0x80,
  0x00, 0x18, 0x60, 0x00, 0x06, 0x18, 0x00, 0x01, 0x86, 0x00, 0x00, 0x41,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x08, 0x20, 0x00, 0x06, 0x18, 0x00,
  0x01, 0x86, 0x00, 0x00, 0x61, 0x80, 0x00, 0x18, 0x60, 0x00, 0x04, 0x18,
  0x00, 0x01, 0x04, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0C,
  0x30, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x40, 0x1C, 0x07, 0x80,
  0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x08, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x04, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x10,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x08, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x04, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x02,
  0x00, 0xC0, 0x18, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x06, 0x02, 0x00, 0x01, 0x80, 0x40, 0x00,
  0x60, 0x18, 0x00, 0x18, 0x03, 0x00, 0x06, 0x00, 0x60, 0x01, 0x80, 0x0C,
  0x00, 0xE0, 0x01, 0x00, 0x38, 0x00, 0x20, 0x0E, 0x00, 0x0C, 0x03, 0x80,
  0x01, 0x80, 0xE0, 0x00, 0x30, 0x38, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x83,
  0x80, 0x00, 0x30, 0xC0, 0x00, 0x06, 0x38, 0x00, 0x00, 0xCF, 0x00, 0x00,
  0x1B, 0x30, 0x00, 0x03, 0xC6, 0x00, 0x00, 0x70, 0x60, 0x00, 0x1C, 0x0C,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0x60, 0x18, 0x00, 0x0C, 0x01, 0x80, 0x01,
  0x80, 0x30, 0x00, 0x20, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x0C, 0x00, 0x80, 0x01, 0xC0, 0x10,
  0x00, 0x18, 0x06, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x30, 0x18, 0x00, 0x07,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x08, 0x01, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x04, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x02,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x00,
  0x40, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x40,
  0x18, 0x03, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x02, 0x07,
  0xFC, 0x00, 0xFF, 0xC0, 0x0C, 0x38, 0x0E, 0x03, 0x80, 0xC0, 0x18, 0xE0,
  0x0C, 0x1C, 0x00, 0xC0, 0x33, 0x00, 0x0C, 0x70, 0x00, 0xC0, 0x6C, 0x00,
  0x18, 0xC0, 0x01, 0x80, 0xD0, 0x00, 0x13, 0x00, 0x03, 0x01, 0x60, 0x00,
  0x2C, 0x00, 0x02, 0x07, 0x80, 0x00, 0x70, 0x00, 0x04, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x08, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x10, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x20, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x30, 0x00, 0x03, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x00,
  0x00, 0x10, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x18, 0x00, 0x01, 0x83, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x30, 0x00, 0x03, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x18, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x83, 0x00, 0x00, 0x20, 0x00, 0x02, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0xC1, 0xFF,
  0x80, 0x20, 0xE0, 0x70, 0x08, 0x60, 0x0C, 0x06, 0x30, 0x01, 0x81, 0x98,
  0x00, 0x60, 0x6C, 0x00, 0x08, 0x1E, 0x00, 0x03, 0x05, 0x00, 0x00, 0xC3,
  0xC0, 0x00, 0x30, 0xE0, 0x00, 0x0C, 0x38, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x20, 0x80, 0x00, 0x18, 0x60, 0x00, 0x06, 0x18, 0x00,
  0x01, 0x86, 0x00, 0x00, 0x61, 0x80, 0x00, 0x18, 0x60, 0x00, 0x04, 0x10,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0C,
  0x30, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x82, 0x00, 0x00, 0x61, 0x80, 0x00,
  0x18, 0x60, 0x00, 0x06, 0x18, 0x00, 0x01, 0x86, 0x00, 0x00, 0x41, 0x80,
  0x00, 0x10, 0x40, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0xFE, 0x00, 0x0F, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x03, 0x80, 0x07, 0x01,
  0xC0, 0x00, 0xC0, 0x60, 0x00, 0x18, 0x30, 0x00, 0x06, 0x18, 0x00, 0x01,
  0x86, 0x00, 0x00, 0x23, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x03, 0x30, 0x00,
  0x00, 0xD8, 0x00, 0x00, 0x26, 0x00, 0x00, 0x09, 0x80, 0x00, 0x02, 0x40,
  0x00, 0x01, 0x90, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x33, 0x00, 0x00,
  0x0C, 0xC0, 0x00, 0x03, 0x20, 0x00, 0x00, 0x88, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x81,
  0x00, 0x00, 0xE0, 0x60, 0x00, 0x30, 0x1C, 0x00, 0x18, 0x03, 0x80, 0x1C,
  0x00, 0x78, 0x1E, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x01, 0x87, 0xFF, 0x00, 0x04, 0x38, 0x0E, 0x00, 0x33,
  0x80, 0x1C, 0x00, 0xD8, 0x00, 0x30, 0x03, 0xC0, 0x00, 0x60, 0x0E, 0x00,
  0x01, 0x80, 0x30, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x08, 0x06, 0x00, 0x00,
  0x20, 0x18, 0x00, 0x00, 0x80, 0x60, 0x00, 0x02, 0x01, 0x80, 0x00, 0x08,
  0x06, 0x00, 0x00, 0x20, 0x10, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x60, 0x30, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x06, 0x02, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x40, 0x60, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x30, 0x10, 0x00, 0x00,
  0x80, 0x40, 0x00, 0x06, 0x03, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0xC0,
  0x30, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x18, 0x03, 0x80, 0x00, 0x60, 0x0E,
  0x00, 0x03, 0x00, 0x6C, 0x00, 0x18, 0x01, 0x98, 0x00, 0xE0, 0x06, 0x38,
  0x0E, 0x00, 0x18, 0x3F, 0xF0, 0x00, 0x40, 0x3E, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0xF8, 0x10, 0x0E, 0x03, 0x84, 0x06, 0x00, 0x33,
  0x03, 0x00, 0x06, 0xC1, 0x80, 0x00, 0xB0, 0xC0, 0x00, 0x38, 0x30, 0x00,
  0x06, 0x18, 0x00, 0x01, 0x86, 0x00, 0x00, 0x63, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x06, 0x30, 0x00, 0x01, 0x08, 0x00, 0x00, 0x46, 0x00, 0x00, 0x31,
  0x80, 0x00, 0x0C, 0x60, 0x00, 0x03, 0x18, 0x00, 0x00, 0xC4, 0x00, 0x00,
  0x23, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x06, 0x30, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x04, 0x30, 0x00, 0x01, 0x0C,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x03,
  0x0C, 0x00, 0x01, 0x83, 0x00, 0x00, 0x60, 0x60, 0x00, 0x38, 0x18, 0x00,
  0x36, 0x03, 0x00, 0x19, 0x80, 0x70, 0x3C, 0x60, 0x0F, 0xFC, 0x10, 0x00,
  0xF8, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xE0,
  0x30, 0xFE, 0x03, 0x1C, 0x00, 0x23, 0x00, 0x06, 0x60, 0x00, 0x6C, 0x00,
  0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xFC,
  0x00, 0x3C, 0x07, 0x80, 0x38, 0x00, 0xC0, 0x38, 0x00, 0x30, 0x18, 0x00,
  0x08, 0x18, 0x00, 0x06, 0x08, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x86, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0x63, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x30, 0x60, 0x00,
  0x30, 0x38, 0x00, 0x38, 0x0E, 0x00, 0x38, 0x03, 0xC0, 0x78, 0x00, 0x7F,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x0F, 0xFF,
  0xFF, 0xFF, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00,
  0xFE, 0x00, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x84, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x31, 0x80, 0x00, 0x18, 0xC0, 0x00, 0x0C, 0x60,
  0x00, 0x04, 0x20, 0x00, 0x06, 0x30, 0x00, 0x03, 0x18, 0x00, 0x01, 0x8C,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0x63, 0x00, 0x00, 0x21, 0x00, 0x00, 0x31,
  0x80, 0x00, 0x18, 0xC0, 0x00, 0x0C, 0x60, 0x00, 0x06, 0x30, 0x00, 0x02,
  0x10, 0x00, 0x01, 0x08, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xC6, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x31, 0x80, 0x00, 0x10, 0x80, 0x00, 0x18, 0x40, 0x00,
  0x0C, 0x20, 0x00, 0x06, 0x10, 0x00, 0x07, 0x08, 0x00, 0x03, 0x86, 0x00,
  0x03, 0x83, 0x00, 0x01, 0xC1, 0x80, 0x01, 0xE0, 0xE0, 0x01, 0xB0, 0x30,
  0x03, 0x98, 0x0E, 0x07, 0x8C, 0x03, 0xFF, 0x04, 0x00, 0x7C, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0x90, 0x00, 0x00, 0xCC, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0x63, 0x00, 0x00, 0x61, 0x80, 0x00, 0x30, 0xC0, 0x00,
  0x30, 0x20, 0x00, 0x18, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x0C, 0x06, 0x00,
  0x04, 0x03, 0x00, 0x06, 0x01, 0x80, 0x02, 0x00, 0x40, 0x03, 0x00, 0x30,
  0x01, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0xC0, 0x03,
  0x00, 0x60, 0x00, 0x80, 0x60, 0x00, 0x60, 0x30, 0x00, 0x30, 0x30, 0x00,
  0x18, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x0C, 0x00,
  0x00, 0xC6, 0x00, 0x00, 0x62, 0x00, 0x00, 0x33, 0x00, 0x00, 0x19, 0x00,
  0x00, 0x0D, 0x80, 0x00, 0x02, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x1E, 0x00, 0x03,
  0x00, 0x00, 0xF0, 0x00, 0x18, 0x00, 0x0D, 0x80, 0x01, 0xE0, 0x00, 0x6C,
  0x00, 0x0B, 0x00, 0x06, 0x60, 0x00, 0xD8, 0x00, 0x33, 0x00, 0x06, 0xC0,
  0x01, 0x98, 0x00, 0x66, 0x00, 0x18, 0xC0, 0x03, 0x30, 0x00, 0xC6, 0x00,
  0x31, 0x80, 0x0C, 0x30, 0x01, 0x8C, 0x00, 0x61, 0x80, 0x08, 0x60, 0x03,
  0x0C, 0x00, 0xC1, 0x00, 0x30, 0x60, 0x06, 0x08, 0x01, 0x81, 0x00, 0x60,
  0x60, 0x18, 0x08, 0x03, 0x03, 0x00, 0xC0, 0x60, 0x30, 0x18, 0x0E, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x18, 0x18, 0x06, 0x03, 0x00, 0xC0, 0xC0, 0x30,
  0x30, 0x06, 0x04, 0x01, 0x81, 0x80, 0x30, 0x60, 0x0C, 0x18, 0x01, 0x83,
  0x00, 0x60, 0xC0, 0x0C, 0x30, 0x01, 0x06, 0x00, 0x61, 0x80, 0x08, 0x60,
  0x03, 0x18, 0x00, 0x43, 0x00, 0x18, 0xC0, 0x03, 0x30, 0x00, 0xC4, 0x00,
  0x19, 0x80, 0x06, 0x60, 0x00, 0xCC, 0x00, 0x12, 0x00, 0x06, 0xC0, 0x00,
  0xB0, 0x00, 0x36, 0x00, 0x05, 0x80, 0x01, 0xA0, 0x00, 0x28, 0x00, 0x0F,
  0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x01, 0x80,
  0x60, 0x00, 0x18, 0x01, 0x80, 0x01, 0x80, 0x0C, 0x00, 0x1C, 0x00, 0x70,
  0x00, 0xC0, 0x01, 0x80, 0x0C, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x30, 0x0E,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0x30, 0x60, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1B, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x0C, 0x40, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x06, 0x00, 0x60, 0x00, 0x30, 0x01,
  0x80, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x03, 0x00, 0x01, 0x80,
  0x18, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x30, 0x18, 0x00, 0x01, 0x81, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x02, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x40, 0x00, 0x18, 0x00, 0x40, 0x00, 0x18, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x60, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x20, 0x00, 0xC0, 0x00,
  0x30, 0x01, 0x80, 0x00, 0x30, 0x01, 0x80, 0x00, 0x30, 0x03, 0x00, 0x00,
  0x30, 0x03, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x10, 0x06, 0x00, 0x00,
  0x10, 0x0C, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00,
  0x18, 0x18, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00,
  0x08, 0x60, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00,
  0x0C, 0xC0, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x08, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x04, 0x30, 0x30,
  0x00, 0x18, 0xC0, 0x30, 0x00, 0x33, 0x00, 0x30, 0x00, 0x44, 0x00, 0x30,
  0x01, 0x98, 0x00, 0x30, 0x02, 0x30, 0x00, 0x70, 0x0C, 0x40, 0x00, 0x70,
  0x31, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3E, 0x00,
};

const GFXglyph RobotoCondensed_ThinItalic68pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 11, 49, 12, 1, -48 },
  { 69, 11, 14, 17, 7, -51 },
  { 89, 34, 48, 32, 1, -48 },
  { 293, 29, 62, 32, 2, -55 },
  { 518, 32, 50, 43, 6, -49 },
  { 718, 30, 50, 35, 2, -49 },
  { 906, 4, 14, 11, 7, -51 },
  { 913, 19, 70, 18, 3, -54 },
  { 1080, 18, 70, 18, -4, -54 },
  { 1238, 26, 26, 28, 4, -48 },
  { 1323, 27, 36, 33, 3, -41 },
  { 1445, 7, 14, 12, -2, -5 },
  { 1458, 14, 2, 18, 2, -23 },
  { 1462, 4, 4, 14, 1, -3 },
  { 1464, 27, 52, 23, -2, -48 },
  { 1640, 27, 50, 32, 3, -49 },
  { 1809, 15, 48, 32, 9, -48 },
  { 1899, 28, 49, 32, 2, -49 },
  { 2071, 28, 50, 32, 2, -49 },
  { 2246, 28, 48, 32, 2, -48 },
  { 2414, 29, 49, 32, 4, -48 },
  { 2592, 25, 49, 32, 3, -48 },
  { 2746, 27, 48, 32, 6, -48 },
  { 2908, 30, 50, 32, 1, -49 },
  { 3096, 25, 49, 32, 5, -49 },
  { 3250, 9, 36, 12, 1, -35 },
  { 3291, 12, 44, 12, -2, -35 },
  { 3357, 25, 27, 30, 3, -36 },
  { 3442, 25, 16, 32, 4, -30 },
  { 3492, 25, 27, 30, 2, -36 },
  { 3577, 20, 50, 26, 6, -49 },
  { 3702, 48, 62, 53, 2, -47 },
  { 4074, 32, 48, 35, -2, -48 },
  { 4266, 30, 48, 35, 3, -48 },
  { 4446, 32, 50, 37, 4, -49 },
  { 4646, 33, 48, 38, 3, -48 },
  { 4844, 32, 48, 33, 3, -48 },
  { 5036, 33, 48, 33, 3, -48 },
  { 5234, 32, 50, 40, 5, -49 },
  { 5434, 36, 48, 41, 3, -48 },
  { 5650, 10, 48, 16, 4, -48 },
  { 5710, 30, 49, 32, 1, -48 },
  { 5894, 35, 48, 37, 3, -48 },
  { 6104, 22, 48, 30, 3, -48 },
  { 6236, 45, 48, 49, 3, -48 },
  { 6506, 37, 48, 41, 3, -48 },
  { 6728, 33, 50, 39, 4, -49 },
  { 6935, 32, 48, 35, 3, -48 },
  { 7127, 32, 58, 39, 4, -49 },
  { 7359, 33, 48, 38, 2, -48 },
  { 7557, 32, 50, 34, 2, -49 },
  { 7757, 30, 48, 35, 7, -48 },
  { 7937, 34, 49, 38, 4, -48 },
  { 8146, 32, 48, 35, 6, -48 },
  { 8338, 47, 48, 52, 7, -48 },
  { 8620, 38, 48, 35, -1, -48 },
  { 8848, 32, 48, 35, 6, -48 },
  { 9040, 36, 48, 35, 0, -48 },
  { 9256, 18, 65, 13, 1, -55 },
  { 9403, 9, 52, 22, 7, -48 },
  { 9462, 18, 65, 13, -4, -55 },
  { 9609, 18, 24, 24, 4, -48 },
  { 9663, 23, 2, 24, -3, 0 },
  { 9669, 8, 9, 17, 9, -51 },
  { 9678, 26, 38, 31, 1, -37 },
  { 9802, 27, 52, 32, 2, -51 },
  { 9978, 26, 38, 30, 2, -37 },
  { 10102, 29, 52, 32, 3, -51 },
  { 10291, 25, 38, 30, 2, -37 },
  { 10410, 20, 52, 19, 4, -52 },
  { 10540, 29, 51, 32, 0, -37 },
  { 10725, 26, 51, 32, 2, -51 },
  { 10891, 11, 50, 13, 2, -50 },
  { 10960, 22, 64, 13, -9, -50 },
  { 11136, 27, 51, 28, 2, -51 },
  { 11309, 11, 51, 13, 2, -51 },
  { 11380, 47, 37, 51, 1, -37 },
  { 11598, 26, 37, 32, 2, -37 },
  { 11719, 26, 38, 32, 3, -37 },
  { 11843, 30, 51, 32, -1, -37 },
  { 12035, 26, 51, 32, 3, -37 },
  { 12201, 20, 37, 20, 2, -37 },
  { 12294, 25, 38, 29, 1, -37 },
  { 12413, 14, 47, 19, 4, -46 },
  { 12496, 25, 37, 32, 4, -36 },
  { 12612, 25, 36, 28, 4, -36 },
  { 12725, 37, 36, 44, 6, -36 },
  { 12892, 29, 36, 28, -1, -36 },
  { 13023, 32, 50, 28, -3, -36 },
  { 13223, 28, 36, 28, -1, -36 },
  { 13349, 22, 68, 19, 2, -53 },
  { 13536, 11, 57, 13, 1, -48 },
  { 13615, 22, 68, 19, -5, -53 },
  { 13802, 31, 11, 40, 4, -26 },
};

const GFXfont RobotoCondensed_ThinItalic68pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ThinItalic68pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ThinItalic68pt7bGlyphs,
  0x20, 0x7E, 80
};

#endif // _ROBOTOCONDENSED_THINITALIC68PT7B_H_
