#ifndef _ROBOTOCONDENSED_THINITALIC61PT7B_H_
#define _ROBOTOCONDENSED_THINITALIC61PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ThinItalic.ttf
// Size: 61pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ThinItalic61pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x80, 0x20, 0x08, 0x06, 0x01, 0x80, 0x60, 0x10, 0x04, 0x01,
  0x00, 0xC0, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x18, 0x06, 0x01, 0x80,
  0x40, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x01, 0x80, 0x60,
  0x18, 0x04, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x0E, 0x01, 0x00, 0x20, 0x90, 0xD8, 0x6C,
  0x36, 0x1B, 0x0D, 0x04, 0x86, 0xC3, 0x61, 0xB0, 0xD0, 0x40, 0x00, 0x00,
  0xC0, 0x10, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x08, 0x03, 0x00, 0x00, 0x60,
  0x08, 0x00, 0x01, 0x80, 0x60, 0x00, 0x04, 0x01, 0x80, 0x00, 0x30, 0x04,
  0x00, 0x00, 0xC0, 0x30, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x18, 0x02, 0x00,
  0x00, 0x60, 0x18, 0x00, 0x01, 0x00, 0x60, 0x07, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xF0, 0x00, 0x80, 0x30, 0x00, 0x06, 0x00, 0x80, 0x00, 0x18,
  0x06, 0x00, 0x00, 0x40, 0x18, 0x00, 0x01, 0x00, 0x40, 0x00, 0x0C, 0x03,
  0x00, 0x00, 0x20, 0x0C, 0x00, 0x00, 0x80, 0x20, 0x00, 0x06, 0x01, 0x80,
  0x00, 0x10, 0x06, 0x00, 0x00, 0x40, 0x10, 0x00, 0x03, 0x00, 0x40, 0x00,
  0x0C, 0x03, 0x00, 0x00, 0x20, 0x08, 0x00, 0x01, 0x80, 0x20, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0x10, 0x06, 0x00, 0x00, 0xC0, 0x10, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x08, 0x03, 0x00, 0x00, 0x60, 0x08, 0x00, 0x01, 0x80, 0x60,
  0x00, 0x04, 0x01, 0x80, 0x00, 0x30, 0x04, 0x00, 0x00, 0xC0, 0x30, 0x00,
  0x02, 0x00, 0xC0, 0x00, 0x18, 0x02, 0x00, 0x00, 0x60, 0x18, 0x00, 0x01,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x3C, 0x1C, 0x00, 0x38, 0x03, 0x00,
  0x30, 0x00, 0xC0, 0x30, 0x00, 0x20, 0x18, 0x00, 0x18, 0x18, 0x00, 0x0C,
  0x08, 0x00, 0x02, 0x0C, 0x00, 0x01, 0x06, 0x00, 0x00, 0x83, 0x00, 0x00,
  0x41, 0x00, 0x00, 0x20, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x23, 0x00, 0x00, 0x11, 0x80, 0x00, 0x18, 0xC0, 0x00, 0x0C,
  0x60, 0x00, 0x06, 0x10, 0x00, 0x02, 0x08, 0x00, 0x03, 0x06, 0x00, 0x03,
  0x03, 0x00, 0x01, 0x80, 0xC0, 0x01, 0x80, 0x30, 0x03, 0x80, 0x0E, 0x07,
  0x80, 0x03, 0xFF, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0C, 0x30,
  0x00, 0x01, 0x81, 0x80, 0x00, 0x30, 0x08, 0x00, 0x02, 0x00, 0xC0, 0x00,
  0x60, 0x0C, 0x00, 0xC4, 0x00, 0xC0, 0x08, 0xC0, 0x0C, 0x01, 0x8C, 0x00,
  0xC0, 0x30, 0xC0, 0x0C, 0x06, 0x08, 0x00, 0x80, 0x60, 0x80, 0x08, 0x0C,
  0x08, 0x01, 0x81, 0x80, 0x80, 0x10, 0x10, 0x08, 0x03, 0x03, 0x00, 0xC0,
  0x30, 0x60, 0x04, 0x06, 0x04, 0x00, 0x61, 0xC0, 0xC0, 0x03, 0xF8, 0x18,
  0x00, 0x04, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x81, 0xFC, 0x00, 0x30,
  0x30, 0xE0, 0x02, 0x06, 0x02, 0x00, 0x60, 0xC0, 0x30, 0x0C, 0x08, 0x03,
  0x01, 0x81, 0x80, 0x10, 0x10, 0x18, 0x01, 0x03, 0x01, 0x00, 0x10, 0x60,
  0x30, 0x03, 0x04, 0x03, 0x00, 0x30, 0xC0, 0x30, 0x03, 0x18, 0x02, 0x00,
  0x21, 0x00, 0x20, 0x06, 0x30, 0x02, 0x00, 0x62, 0x00, 0x30, 0x04, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x18, 0x18, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x18, 0x0C, 0x00, 0x06, 0x00, 0xC0, 0x00, 0xC0,
  0x18, 0x00, 0x30, 0x01, 0x00, 0x06, 0x00, 0x20, 0x00, 0x80, 0x0C, 0x00,
  0x30, 0x01, 0x80, 0x06, 0x00, 0x20, 0x00, 0xC0, 0x0C, 0x00, 0x18, 0x01,
  0x00, 0x03, 0x00, 0x60, 0x00, 0x20, 0x18, 0x00, 0x04, 0x06, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x18, 0xE0, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x66, 0x00, 0x00, 0x18,
  0x40, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x80, 0xC0, 0x0C, 0x20, 0x18, 0x01,
  0x0C, 0x01, 0x80, 0x23, 0x00, 0x30, 0x0C, 0x40, 0x03, 0x01, 0x98, 0x00,
  0x20, 0x22, 0x00, 0x06, 0x0C, 0xC0, 0x00, 0x61, 0x98, 0x00, 0x0C, 0x63,
  0x00, 0x00, 0xCC, 0x60, 0x00, 0x1B, 0x0C, 0x00, 0x01, 0xC1, 0x80, 0x00,
  0x18, 0x30, 0x00, 0x07, 0x03, 0x00, 0x01, 0xB0, 0x60, 0x00, 0x66, 0x06,
  0x00, 0x18, 0x60, 0x70, 0x0C, 0x04, 0x07, 0xFF, 0x00, 0xC0, 0x1E, 0x00,
  0x00, 0x33, 0x33, 0x32, 0x66, 0x64, 0x4C, 0x00, 0x01, 0x00, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x40, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x02,
  0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x20, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10,
  0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20,
  0x00, 0x18, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00,
  0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x04, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x10,
  0x07, 0xE0, 0x20, 0x78, 0xF0, 0xC7, 0xC0, 0x3D, 0xBC, 0x00, 0x1F, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x34, 0x00, 0x00, 0xCC, 0x00, 0x01, 0x8C, 0x00,
  0x06, 0x18, 0x00, 0x18, 0x18, 0x00, 0x60, 0x30, 0x01, 0x80, 0x30, 0x07,
  0x00, 0x60, 0x1C, 0x00, 0x60, 0x10, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x10, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x40, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x08, 0x30, 0x60, 0xC1, 0x86, 0x0C,
  0x30, 0x61, 0x82, 0x00, 0xFF, 0xFF, 0xFF, 0x67, 0xF0, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x38, 0x38, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x04, 0x01, 0x80, 0x06,
  0x03, 0x00, 0x02, 0x02, 0x00, 0x02, 0x06, 0x00, 0x03, 0x04, 0x00, 0x03,
  0x0C, 0x00, 0x03, 0x08, 0x00, 0x03, 0x18, 0x00, 0x03, 0x18, 0x00, 0x03,
  0x10, 0x00, 0x03, 0x10, 0x00, 0x03, 0x30, 0x00, 0x03, 0x30, 0x00, 0x03,
  0x20, 0x00, 0x02, 0x20, 0x00, 0x02, 0x20, 0x00, 0x06, 0x60, 0x00, 0x06,
  0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x40, 0x00, 0x04, 0x40, 0x00, 0x04,
  0x40, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x08,
  0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x30,
  0xC0, 0x00, 0x30, 0xC0, 0x00, 0x20, 0xC0, 0x00, 0x60, 0x40, 0x00, 0x40,
  0x40, 0x00, 0xC0, 0x60, 0x01, 0x80, 0x20, 0x03, 0x00, 0x30, 0x06, 0x00,
  0x1C, 0x1C, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x03,
  0xC0, 0x76, 0x1E, 0x33, 0x81, 0x30, 0x0A, 0x00, 0x40, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x40, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x10,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0x80, 0x04, 0x00, 0x60, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xC1, 0xE0, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x03, 0x00,
  0x70, 0x00, 0x60, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x06, 0x03, 0x00, 0x00,
  0x81, 0x80, 0x00, 0x20, 0x60, 0x00, 0x08, 0x10, 0x00, 0x02, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x0E, 0x07, 0x00, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x30, 0x0C, 0x00,
  0x18, 0x0C, 0x00, 0x04, 0x06, 0x00, 0x03, 0x06, 0x00, 0x01, 0x83, 0x00,
  0x00, 0xC1, 0x00, 0x00, 0x61, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x18, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0xC0, 0x00,
  0x04, 0x60, 0x00, 0x02, 0x30, 0x00, 0x03, 0x18, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0x86, 0x00, 0x00, 0xC1, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0x30,
  0x00, 0x60, 0x0C, 0x00, 0xE0, 0x03, 0x81, 0xC0, 0x00, 0xFF, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x04, 0xC0, 0x00,
  0x03, 0x30, 0x00, 0x01, 0x88, 0x00, 0x00, 0x42, 0x00, 0x00, 0x31, 0x80,
  0x00, 0x18, 0x60, 0x00, 0x0C, 0x18, 0x00, 0x02, 0x06, 0x00, 0x01, 0x81,
  0x00, 0x00, 0xC0, 0x40, 0x00, 0x60, 0x30, 0x00, 0x10, 0x0C, 0x00, 0x0C,
  0x03, 0x00, 0x06, 0x00, 0x80, 0x03, 0x00, 0x20, 0x00, 0xC0, 0x08, 0x00,
  0x60, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0x60, 0x06, 0x00, 0x10,
  0x03, 0x00, 0x04, 0x01, 0x80, 0x03, 0x00, 0x60, 0x00, 0xC0, 0x30, 0x00,
  0x30, 0x18, 0x00, 0x0C, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x08, 0x7F, 0x00, 0x04, 0xFF, 0xE0, 0x07, 0xC0, 0x38, 0x03, 0x80,
  0x0C, 0x01, 0x80, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x61,
  0x00, 0x00, 0x30, 0x80, 0x00, 0x10, 0x40, 0x00, 0x08, 0x30, 0x00, 0x0C,
  0x18, 0x00, 0x04, 0x0C, 0x00, 0x06, 0x02, 0x00, 0x02, 0x01, 0x80, 0x03,
  0x00, 0x60, 0x03, 0x00, 0x30, 0x03, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x0F, 0xF0, 0x00,
  0xF0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x07,
  0xE0, 0x10, 0xFF, 0xE0, 0xC6, 0x01, 0xC3, 0x20, 0x03, 0x09, 0x00, 0x06,
  0x28, 0x00, 0x19, 0xC0, 0x00, 0x37, 0x00, 0x00, 0xD8, 0x00, 0x03, 0x60,
  0x00, 0x0D, 0x00, 0x00, 0x14, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x02, 0xC0, 0x00, 0x1B,
  0x00, 0x00, 0x6C, 0x00, 0x01, 0x30, 0x00, 0x0C, 0x40, 0x00, 0x21, 0x80,
  0x01, 0x86, 0x00, 0x0C, 0x0C, 0x00, 0x60, 0x18, 0x03, 0x80, 0x38, 0x38,
  0x00, 0x7F, 0xC0, 0x00, 0x10, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x78,
  0x38, 0x00, 0x1C, 0x01, 0x80, 0x06, 0x00, 0x18, 0x01, 0x80, 0x01, 0x80,
  0x20, 0x00, 0x30, 0x0C, 0x00, 0x02, 0x01, 0x00, 0x00, 0x40, 0x60, 0x00,
  0x0C, 0x08, 0x00, 0x01, 0x81, 0x00, 0x00, 0x20, 0x60, 0x00, 0x04, 0x0C,
  0x00, 0x01, 0x81, 0x80, 0x00, 0x30, 0x30, 0x00, 0x0C, 0x02, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x60, 0x0C, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x0C,
  0x03, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0x03, 0x80,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x01, 0x80, 0x30, 0x00, 0x18, 0x0C, 0x00,
  0x03, 0x03, 0x00, 0x00, 0x30, 0x60, 0x00, 0x06, 0x18, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x18, 0x40, 0x00, 0x03, 0x08, 0x00, 0x00, 0x61, 0x00, 0x00,
  0x08, 0x20, 0x00, 0x03, 0x04, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x18, 0x18,
  0x00, 0x02, 0x01, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x30, 0x03, 0x00, 0x1C,
  0x00, 0x38, 0x0E, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0xFF, 0x80, 0x03, 0x83, 0xC0, 0x1C, 0x01, 0x80, 0x30,
  0x01, 0x80, 0xC0, 0x01, 0x83, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x18, 0x00,
  0x06, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x19, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0xD8, 0x00, 0x01, 0xA0, 0x00, 0x03, 0x40, 0x00, 0x07,
  0x80, 0x00, 0x0B, 0x00, 0x00, 0x16, 0x00, 0x00, 0x64, 0x00, 0x00, 0xC8,
  0x00, 0x03, 0x90, 0x00, 0x07, 0x30, 0x00, 0x14, 0x60, 0x00, 0x68, 0x60,
  0x01, 0xB0, 0xE0, 0x06, 0x60, 0xE0, 0x38, 0x80, 0xFF, 0xE3, 0x00, 0x7E,
  0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x01,
  0xFE, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x02, 0x07, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0xE0,
  0xE0, 0x00, 0x00, 0x40, 0x1C, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0xC0, 0x30, 0x06, 0x00, 0x80, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x10, 0x1F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x00, 0x08, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x70, 0x30, 0x38, 0x06,
  0x18, 0x00, 0x86, 0x00, 0x33, 0x00, 0x0C, 0x80, 0x01, 0x60, 0x00, 0x50,
  0x00, 0x14, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0x00, 0x08, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x03, 0x80, 0x00, 0x00, 0x02, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x60, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x07, 0xE0, 0x00,
  0x80, 0xC0, 0x03, 0xFE, 0x00, 0x10, 0x30, 0x00, 0xC0, 0x60, 0x02, 0x06,
  0x00, 0x30, 0x06, 0x00, 0x41, 0x80, 0x0C, 0x00, 0xC0, 0x08, 0x30, 0x03,
  0x00, 0x18, 0x01, 0x04, 0x00, 0x40, 0x02, 0x00, 0x21, 0x80, 0x18, 0x00,
  0xC0, 0x04, 0x30, 0x02, 0x00, 0x18, 0x00, 0x8C, 0x00, 0xC0, 0x03, 0x00,
  0x11, 0x80, 0x10, 0x00, 0x40, 0x06, 0x30, 0x06, 0x00, 0x18, 0x00, 0xC4,
  0x00, 0xC0, 0x03, 0x00, 0x19, 0x80, 0x10, 0x00, 0x60, 0x03, 0x30, 0x06,
  0x00, 0x08, 0x00, 0x44, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x80, 0x10, 0x00,
  0x60, 0x03, 0x10, 0x02, 0x00, 0x0C, 0x00, 0x46, 0x00, 0xC0, 0x01, 0x00,
  0x08, 0xC0, 0x18, 0x00, 0x60, 0x03, 0x18, 0x03, 0x00, 0x0C, 0x00, 0x43,
  0x00, 0x40, 0x03, 0x80, 0x18, 0x60, 0x08, 0x00, 0x60, 0x03, 0x0C, 0x01,
  0x00, 0x1C, 0x00, 0xC1, 0x80, 0x20, 0x02, 0x80, 0x18, 0x30, 0x06, 0x00,
  0x98, 0x06, 0x06, 0x00, 0xC0, 0x23, 0x01, 0x80, 0xC0, 0x0C, 0x18, 0x30,
  0x60, 0x18, 0x00, 0xFE, 0x07, 0xF8, 0x01, 0x00, 0x07, 0x00, 0x38, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x10, 0x00, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x02, 0x80, 0x00, 0x00, 0x34,
  0x00, 0x00, 0x01, 0x30, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x8C, 0x00,
  0x00, 0x0C, 0x60, 0x00, 0x00, 0x61, 0x00, 0x00, 0x02, 0x08, 0x00, 0x00,
  0x30, 0x40, 0x00, 0x01, 0x02, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x80,
  0xC0, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x40, 0x10, 0x00, 0x06, 0x00, 0x80,
  0x00, 0x20, 0x04, 0x00, 0x03, 0x00, 0x20, 0x00, 0x10, 0x01, 0x80, 0x01,
  0x80, 0x0C, 0x00, 0x08, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x60, 0x00, 0x40, 0x02, 0x00, 0x02, 0x00, 0x30, 0x00, 0x18,
  0x01, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x06, 0x00, 0xFF, 0xFF, 0xF0, 0x0C,
  0x00, 0x00, 0x80, 0x40, 0x00, 0x04, 0x06, 0x00, 0x00, 0x20, 0x30, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x61, 0x80, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x46, 0x00, 0x00, 0x02, 0x60,
  0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x06, 0x00, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0x80, 0x03, 0x80, 0x18, 0x00, 0x1C,
  0x01, 0x80, 0x00, 0xC0, 0x10, 0x00, 0x06, 0x01, 0x00, 0x00, 0x60, 0x10,
  0x00, 0x02, 0x03, 0x00, 0x00, 0x20, 0x30, 0x00, 0x02, 0x03, 0x00, 0x00,
  0x20, 0x20, 0x00, 0x06, 0x02, 0x00, 0x00, 0x60, 0x60, 0x00, 0x06, 0x06,
  0x00, 0x00, 0xC0, 0x60, 0x00, 0x0C, 0x06, 0x00, 0x01, 0x80, 0x40, 0x00,
  0x30, 0x04, 0x00, 0x06, 0x00, 0xC0, 0x01, 0xC0, 0x0F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x00, 0x08, 0x00, 0x1C, 0x00, 0x80, 0x00, 0x60, 0x08, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x18, 0x18, 0x00, 0x01, 0x81, 0x80, 0x00, 0x08,
  0x10, 0x00, 0x00, 0x81, 0x00, 0x00, 0x08, 0x10, 0x00, 0x00, 0x83, 0x00,
  0x00, 0x08, 0x30, 0x00, 0x01, 0x83, 0x00, 0x00, 0x18, 0x20, 0x00, 0x01,
  0x02, 0x00, 0x00, 0x30, 0x60, 0x00, 0x02, 0x06, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x0C, 0x06, 0x00, 0x01, 0x80, 0x40, 0x00, 0x70, 0x04, 0x00, 0xFC,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x3C, 0x07, 0x00, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x00, 0xC0, 0x18,
  0x00, 0x06, 0x03, 0x00, 0x00, 0x60, 0x60, 0x00, 0x02, 0x06, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x03, 0x08, 0x00, 0x00, 0x31, 0x80, 0x00, 0x03, 0x18,
  0x00, 0x00, 0x31, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x33, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x88, 0x00, 0x00, 0x18, 0x80, 0x00, 0x01,
  0x08, 0x00, 0x00, 0x30, 0x80, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x20, 0xC0,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0x40, 0x60, 0x00, 0x0C, 0x06, 0x00, 0x01,
  0x80, 0x30, 0x00, 0x30, 0x01, 0x80, 0x0E, 0x00, 0x0E, 0x03, 0xC0, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x18, 0x00, 0x38, 0x00, 0x60, 0x00, 0x30, 0x01, 0x80,
  0x00, 0x60, 0x04, 0x00, 0x00, 0xC0, 0x10, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x06, 0x03, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x20, 0x30, 0x00, 0x00,
  0xC0, 0x80, 0x00, 0x03, 0x02, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x30,
  0x60, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x03, 0x04, 0x00, 0x00, 0x08, 0x10,
  0x00, 0x00, 0x20, 0x40, 0x00, 0x00, 0x83, 0x00, 0x00, 0x06, 0x0C, 0x00,
  0x00, 0x18, 0x30, 0x00, 0x00, 0x60, 0x80, 0x00, 0x01, 0x02, 0x00, 0x00,
  0x04, 0x08, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x08, 0x10, 0x00, 0x00, 0x20, 0x40, 0x00, 0x01, 0x81,
  0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x10, 0x30, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x06, 0x02, 0x00, 0x00, 0x18, 0x08, 0x00, 0x00, 0xC0, 0x60, 0x00,
  0x06, 0x01, 0x80, 0x00, 0x38, 0x06, 0x00, 0x01, 0xC0, 0x10, 0x00, 0x0C,
  0x00, 0x40, 0x00, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x18, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xF0, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0x80, 0xE0,
  0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x18, 0x06,
  0x00, 0x00, 0xC0, 0x60, 0x00, 0x03, 0x06, 0x00, 0x00, 0x18, 0x30, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x30, 0x80, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x60, 0x01, 0xFF, 0xE3, 0x00, 0x1F, 0xFF, 0x10,
  0x00, 0x00, 0x18, 0x80, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x04, 0x60, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0x20, 0x80, 0x00, 0x03, 0x04,
  0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x06, 0x06, 0x00,
  0x00, 0x60, 0x18, 0x00, 0x0E, 0x00, 0x60, 0x01, 0xE0, 0x01, 0xC0, 0x7C,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x40, 0x00, 0x00, 0x40, 0x60, 0x00, 0x00, 0x60, 0x30, 0x00,
  0x00, 0x30, 0x18, 0x00, 0x00, 0x18, 0x08, 0x00, 0x00, 0x08, 0x04, 0x00,
  0x00, 0x04, 0x06, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x03, 0x01, 0x80,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x00, 0x40, 0x20,
  0x00, 0x00, 0x20, 0x30, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x18, 0x0C,
  0x00, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x04, 0x02, 0x00, 0x00, 0x02, 0x01,
  0x00, 0x00, 0x01, 0x01, 0x80, 0x00, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xE0, 0x20, 0x00, 0x00, 0x20, 0x10, 0x00, 0x00, 0x10,
  0x08, 0x00, 0x00, 0x08, 0x0C, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x03, 0x01, 0x00, 0x00, 0x01, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x40, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00,
  0x30, 0x18, 0x00, 0x00, 0x18, 0x08, 0x00, 0x00, 0x08, 0x04, 0x00, 0x00,
  0x04, 0x06, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x80, 0x00, 0x00, 0x80, 0x40, 0x00, 0x00, 0x40, 0x20, 0x00,
  0x00, 0x20, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x08, 0x04, 0x06, 0x03, 0x01, 0x80, 0x80, 0x40, 0x20, 0x30, 0x18,
  0x0C, 0x04, 0x02, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x20, 0x10, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x00, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x08, 0x04, 0x06,
  0x03, 0x01, 0x80, 0x80, 0x40, 0x60, 0x30, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x02, 0x02, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x18, 0x18,
  0x00, 0x03, 0x03, 0x00, 0x00, 0x40, 0x60, 0x00, 0x18, 0x04, 0x00, 0x02,
  0x00, 0xC0, 0x00, 0xC0, 0x18, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x30,
  0x03, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x07, 0x00, 0x80, 0x00, 0x0E, 0x01, 0x80, 0x00,
  0x1C, 0x01, 0x80, 0x00, 0x38, 0x01, 0x80, 0x00, 0x70, 0x01, 0x00, 0x00,
  0xE0, 0x01, 0x00, 0x01, 0xC0, 0x03, 0x00, 0x03, 0x80, 0x03, 0x00, 0x07,
  0x00, 0x03, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x1C, 0x00, 0x02, 0x00, 0x38,
  0x00, 0x02, 0x00, 0x70, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x06, 0x01, 0xC0,
  0x00, 0x06, 0x03, 0x80, 0x00, 0x04, 0x07, 0x00, 0x00, 0x04, 0x0E, 0x00,
  0x00, 0x04, 0x1C, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x0C, 0x68, 0x00,
  0x00, 0x0C, 0xCC, 0x00, 0x00, 0x09, 0x84, 0x00, 0x00, 0x0B, 0x06, 0x00,
  0x00, 0x0E, 0x03, 0x00, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x18, 0x01, 0x80,
  0x00, 0x18, 0x01, 0x80, 0x00, 0x10, 0x00, 0xC0, 0x00, 0x10, 0x00, 0xC0,
  0x00, 0x10, 0x00, 0x60, 0x00, 0x30, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x20, 0x00, 0x18, 0x00, 0x20, 0x00, 0x0C,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x06, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x40, 0x00, 0x03, 0x00, 0x40, 0x00, 0x03, 0x00, 0x40, 0x00, 0x01,
  0x80, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x60,
  0x00, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x1E, 0x00, 0x00, 0x00, 0x50, 0x0B, 0x00, 0x00, 0x00, 0x68,
  0x04, 0x80, 0x00, 0x00, 0x64, 0x02, 0x40, 0x00, 0x00, 0x36, 0x03, 0x30,
  0x00, 0x00, 0x33, 0x01, 0x98, 0x00, 0x00, 0x19, 0x80, 0xCC, 0x00, 0x00,
  0x18, 0x80, 0x42, 0x00, 0x00, 0x08, 0x40, 0x21, 0x00, 0x00, 0x0C, 0x60,
  0x30, 0x80, 0x00, 0x04, 0x30, 0x18, 0x60, 0x00, 0x06, 0x18, 0x0C, 0x30,
  0x00, 0x02, 0x0C, 0x04, 0x18, 0x00, 0x03, 0x04, 0x02, 0x04, 0x00, 0x01,
  0x02, 0x01, 0x02, 0x00, 0x01, 0x83, 0x01, 0x81, 0x80, 0x00, 0x81, 0x80,
  0xC0, 0xC0, 0x00, 0xC0, 0xC0, 0x60, 0x60, 0x00, 0xC0, 0x60, 0x20, 0x10,
  0x00, 0x60, 0x20, 0x10, 0x08, 0x00, 0x60, 0x10, 0x08, 0x04, 0x00, 0x30,
  0x18, 0x0C, 0x03, 0x00, 0x30, 0x0C, 0x06, 0x01, 0x80, 0x10, 0x06, 0x03,
  0x00, 0x40, 0x18, 0x02, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x80, 0x10,
  0x0C, 0x00, 0x80, 0x40, 0x0C, 0x04, 0x00, 0xC0, 0x60, 0x06, 0x06, 0x00,
  0x60, 0x30, 0x03, 0x02, 0x00, 0x30, 0x18, 0x00, 0x83, 0x00, 0x10, 0x08,
  0x00, 0x43, 0x00, 0x08, 0x04, 0x00, 0x21, 0x80, 0x0C, 0x06, 0x00, 0x19,
  0x80, 0x06, 0x03, 0x00, 0x0C, 0xC0, 0x03, 0x01, 0x80, 0x02, 0xC0, 0x01,
  0x80, 0xC0, 0x01, 0x60, 0x00, 0x80, 0x40, 0x00, 0xE0, 0x00, 0x40, 0x20,
  0x00, 0x60, 0x00, 0x60, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x70, 0x00, 0x00, 0x20, 0x1C, 0x00, 0x00, 0x08, 0x07,
  0x80, 0x00, 0x06, 0x01, 0xA0, 0x00, 0x01, 0x80, 0x6C, 0x00, 0x00, 0x60,
  0x13, 0x00, 0x00, 0x18, 0x0C, 0x40, 0x00, 0x04, 0x03, 0x18, 0x00, 0x01,
  0x00, 0xC2, 0x00, 0x00, 0xC0, 0x30, 0xC0, 0x00, 0x30, 0x0C, 0x30, 0x00,
  0x0C, 0x02, 0x04, 0x00, 0x03, 0x01, 0x81, 0x80, 0x00, 0x80, 0x60, 0x20,
  0x00, 0x60, 0x18, 0x08, 0x00, 0x18, 0x06, 0x03, 0x00, 0x06, 0x01, 0x00,
  0x40, 0x01, 0x80, 0x40, 0x18, 0x00, 0x40, 0x30, 0x06, 0x00, 0x10, 0x0C,
  0x00, 0x80, 0x0C, 0x03, 0x00, 0x30, 0x03, 0x00, 0xC0, 0x04, 0x00, 0xC0,
  0x20, 0x01, 0x80, 0x30, 0x08, 0x00, 0x60, 0x08, 0x06, 0x00, 0x08, 0x02,
  0x01, 0x80, 0x03, 0x01, 0x80, 0x60, 0x00, 0x40, 0x60, 0x18, 0x00, 0x18,
  0x18, 0x04, 0x00, 0x06, 0x06, 0x01, 0x00, 0x00, 0x81, 0x00, 0xC0, 0x00,
  0x30, 0xC0, 0x30, 0x00, 0x04, 0x30, 0x0C, 0x00, 0x01, 0x8C, 0x02, 0x00,
  0x00, 0x63, 0x00, 0x80, 0x00, 0x08, 0xC0, 0x60, 0x00, 0x03, 0x20, 0x18,
  0x00, 0x00, 0x58, 0x06, 0x00, 0x00, 0x16, 0x01, 0x80, 0x00, 0x07, 0x80,
  0x40, 0x00, 0x00, 0xE0, 0x10, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xE0, 0x38,
  0x00, 0x0E, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x03, 0x00, 0x00, 0xC0,
  0x18, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x06, 0x02, 0x00, 0x00, 0x18, 0x18,
  0x00, 0x00, 0x20, 0x40, 0x00, 0x00, 0x83, 0x00, 0x00, 0x03, 0x08, 0x00,
  0x00, 0x0C, 0x60, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0xC6, 0x00, 0x00,
  0x02, 0x10, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x00, 0x23, 0x00, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x18, 0x80, 0x00, 0x00, 0x42,
  0x00, 0x00, 0x01, 0x18, 0x00, 0x00, 0x04, 0x60, 0x00, 0x00, 0x31, 0x80,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0x03, 0x10, 0x00, 0x00, 0x08, 0x40, 0x00,
  0x00, 0x23, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00,
  0x10, 0xC0, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x03, 0x04, 0x00, 0x00, 0x08,
  0x10, 0x00, 0x00, 0x60, 0x60, 0x00, 0x03, 0x01, 0x80, 0x00, 0x0C, 0x02,
  0x00, 0x00, 0x60, 0x0C, 0x00, 0x03, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30,
  0x01, 0xC0, 0x00, 0x70, 0x1E, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x60, 0x00,
  0x70, 0x03, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x06, 0x00, 0x80, 0x00, 0x18,
  0x04, 0x00, 0x00, 0x40, 0x20, 0x00, 0x03, 0x03, 0x00, 0x00, 0x18, 0x18,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x06, 0x04, 0x00, 0x00, 0x30, 0x20, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x06,
  0x06, 0x00, 0x00, 0x20, 0x20, 0x00, 0x03, 0x01, 0x00, 0x00, 0x10, 0x18,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x18, 0x06, 0x00, 0x03, 0x80, 0x20, 0x00,
  0x38, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xE0,
  0x38, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x03, 0x00, 0x00,
  0xC0, 0x18, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x06, 0x02, 0x00, 0x00, 0x18,
  0x18, 0x00, 0x00, 0x20, 0x40, 0x00, 0x00, 0x83, 0x00, 0x00, 0x02, 0x08,
  0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0x02, 0x10, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x00, 0x23, 0x00, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x18, 0x80, 0x00, 0x00,
  0x42, 0x00, 0x00, 0x01, 0x18, 0x00, 0x00, 0x04, 0x60, 0x00, 0x00, 0x31,
  0x80, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x03, 0x10, 0x00, 0x00, 0x08, 0x40,
  0x00, 0x00, 0x23, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x06, 0x30, 0x00,
  0x00, 0x10, 0xC0, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x03, 0x04, 0x00, 0x00,
  0x08, 0x10, 0x00, 0x00, 0x60, 0x60, 0x00, 0x03, 0x01, 0x80, 0x00, 0x0C,
  0x02, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x03, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x30, 0x01, 0xC0, 0x00, 0x70, 0x1E, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x60, 0x00, 0x70, 0x03, 0x00, 0x00, 0xC0, 0x10, 0x00, 0x03, 0x00,
  0x80, 0x00, 0x18, 0x04, 0x00, 0x00, 0x40, 0x60, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x18, 0x18, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x06, 0x04, 0x00, 0x00,
  0x30, 0x20, 0x00, 0x01, 0x83, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x40,
  0xC0, 0x00, 0x06, 0x04, 0x00, 0x00, 0x30, 0x20, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x18, 0x18, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x18, 0x04, 0x00, 0x01,
  0x80, 0x20, 0x00, 0x38, 0x01, 0xFB, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0xC0, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x20, 0x00, 0x60, 0x01, 0x00,
  0x03, 0x00, 0x08, 0x00, 0x08, 0x00, 0xC0, 0x00, 0x60, 0x06, 0x00, 0x03,
  0x00, 0x30, 0x00, 0x08, 0x01, 0x00, 0x00, 0x60, 0x08, 0x00, 0x03, 0x00,
  0x40, 0x00, 0x08, 0x06, 0x00, 0x00, 0x60, 0x30, 0x00, 0x03, 0x01, 0x80,
  0x00, 0x0C, 0x08, 0x00, 0x00, 0x60, 0x40, 0x00, 0x03, 0x06, 0x00, 0x00,
  0x0C, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xF0, 0x3C, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x60, 0x00, 0x30,
  0x03, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x01, 0x80, 0x40, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x08, 0x08, 0x00, 0x00, 0x20, 0x20, 0x00, 0x00, 0x81, 0x80,
  0x00, 0x02, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x10, 0x40, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x03,
  0x04, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x30, 0x60, 0x00, 0x01, 0x81,
  0x80, 0x00, 0x06, 0x06, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x01, 0x80, 0x18,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xE0, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x18, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00,
  0x81, 0x00, 0x00, 0x02, 0x04, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x01, 0x83, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x10, 0x20,
  0x00, 0x00, 0x40, 0x80, 0x00, 0x01, 0x06, 0x00, 0x00, 0x0C, 0x18, 0x00,
  0x00, 0x30, 0x60, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x02, 0x04, 0x00, 0x00,
  0x08, 0x10, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x01, 0x83, 0x00, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0x10, 0x20, 0x00, 0x00, 0x40, 0x80, 0x00, 0x01, 0x06,
  0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x02, 0x04, 0x00, 0x00, 0x08, 0x10, 0x00, 0x00, 0x20, 0xC0, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00,
  0x40, 0xC0, 0x00, 0x01, 0x03, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x20,
  0x30, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x04, 0x01, 0x00, 0x00, 0x30, 0x06,
  0x00, 0x01, 0x80, 0x0C, 0x00, 0x0C, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x78,
  0x0F, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x1A, 0x00, 0x00, 0x01, 0x90, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x21, 0x80, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x10, 0x20, 0x00, 0x01, 0x81, 0x00, 0x00, 0x08, 0x0C, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x04, 0x03, 0x00, 0x00, 0x60, 0x18, 0x00, 0x03,
  0x00, 0x40, 0x00, 0x30, 0x02, 0x00, 0x01, 0x80, 0x18, 0x00, 0x18, 0x00,
  0xC0, 0x00, 0xC0, 0x06, 0x00, 0x04, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80,
  0x02, 0x00, 0x04, 0x00, 0x30, 0x00, 0x20, 0x01, 0x00, 0x01, 0x80, 0x18,
  0x00, 0x0C, 0x00, 0x80, 0x00, 0x60, 0x0C, 0x00, 0x03, 0x00, 0x40, 0x00,
  0x08, 0x06, 0x00, 0x00, 0x40, 0x30, 0x00, 0x02, 0x03, 0x00, 0x00, 0x18,
  0x18, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x30, 0x40,
  0x00, 0x00, 0x86, 0x00, 0x00, 0x04, 0x20, 0x00, 0x00, 0x23, 0x00, 0x00,
  0x01, 0x90, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x68, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x50, 0x00, 0x06, 0xC0, 0x00, 0x16, 0x00, 0x01,
  0xB0, 0x00, 0x0D, 0x80, 0x00, 0x4C, 0x00, 0x02, 0x60, 0x00, 0x33, 0x00,
  0x01, 0x98, 0x00, 0x0C, 0x40, 0x00, 0x42, 0x00, 0x02, 0x10, 0x00, 0x10,
  0x80, 0x01, 0x84, 0x00, 0x0C, 0x20, 0x00, 0x61, 0x00, 0x02, 0x08, 0x00,
  0x30, 0x40, 0x01, 0x82, 0x00, 0x0C, 0x18, 0x00, 0x40, 0x80, 0x02, 0x06,
  0x00, 0x30, 0x20, 0x01, 0x81, 0x80, 0x0C, 0x0C, 0x00, 0x60, 0x60, 0x02,
  0x03, 0x00, 0x10, 0x18, 0x01, 0x80, 0xC0, 0x0C, 0x06, 0x00, 0x40, 0x30,
  0x02, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x01, 0x00, 0x60,
  0x18, 0x02, 0x00, 0x40, 0x10, 0x06, 0x01, 0x80, 0x10, 0x0C, 0x00, 0x80,
  0x40, 0x04, 0x03, 0x00, 0x20, 0x30, 0x01, 0x00, 0x80, 0x08, 0x0C, 0x00,
  0x60, 0x60, 0x02, 0x02, 0x00, 0x18, 0x10, 0x00, 0x81, 0x80, 0x06, 0x0C,
  0x00, 0x30, 0x40, 0x01, 0x83, 0x00, 0x0C, 0x30, 0x00, 0x60, 0x80, 0x03,
  0x0C, 0x00, 0x18, 0x60, 0x00, 0xC6, 0x00, 0x06, 0x18, 0x00, 0x31, 0x80,
  0x00, 0x84, 0x00, 0x0C, 0x40, 0x00, 0x23, 0x00, 0x03, 0x30, 0x00, 0x08,
  0x80, 0x00, 0xCC, 0x00, 0x02, 0x60, 0x00, 0x32, 0x00, 0x00, 0x98, 0x00,
  0x0D, 0x80, 0x00, 0x34, 0x00, 0x01, 0x40, 0x00, 0x0F, 0x00, 0x00, 0x70,
  0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00,
  0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x80, 0x30, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x60, 0x00, 0x06, 0x00, 0x08, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00,
  0x04, 0x01, 0x80, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x20, 0x60, 0x00,
  0x00, 0x0C, 0x10, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x00, 0x46, 0x00,
  0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x02, 0x80, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0C,
  0x80, 0x00, 0x00, 0x02, 0x30, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x18, 0x08, 0x00, 0x00,
  0x0C, 0x03, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x06, 0x00, 0x00, 0x60, 0x00, 0x80, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x01, 0x80, 0x03, 0x00, 0x00,
  0x60, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x03, 0x00, 0x30, 0x00,
  0x00, 0x40, 0x18, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x46, 0x00, 0x00,
  0x0C, 0x60, 0x00, 0x01, 0x82, 0x00, 0x00, 0x10, 0x30, 0x00, 0x03, 0x03,
  0x00, 0x00, 0x60, 0x30, 0x00, 0x04, 0x01, 0x80, 0x00, 0xC0, 0x18, 0x00,
  0x18, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00,
  0x0C, 0x00, 0xC0, 0x00, 0x40, 0x0C, 0x00, 0x06, 0x01, 0x80, 0x00, 0x60,
  0x30, 0x00, 0x02, 0x03, 0x00, 0x00, 0x30, 0x60, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x10, 0xC0, 0x00, 0x01, 0x98, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00,
  0xB0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xC0, 0x60, 0x10, 0x08,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x20, 0x10, 0x08, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x20, 0x10, 0x08, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x20, 0x10, 0x08,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x20, 0x10, 0x08, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x20, 0x10, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x20, 0x10, 0x0C,
  0x06, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x05, 0x00, 0x06, 0xC0, 0x02, 0x60,
  0x03, 0x10, 0x01, 0x08, 0x01, 0x84, 0x00, 0x82, 0x00, 0xC1, 0x80, 0x40,
  0xC0, 0x60, 0x60, 0x20, 0x10, 0x30, 0x08, 0x10, 0x04, 0x18, 0x03, 0x08,
  0x01, 0x8C, 0x00, 0xC4, 0x00, 0x66, 0x00, 0x12, 0x00, 0x08, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x60, 0xC0, 0xC1, 0x81, 0x81, 0x83, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x03, 0xC0, 0xE0, 0x0C, 0x00, 0x60, 0x30,
  0x00, 0xC0, 0xC0, 0x00, 0xC1, 0x00, 0x01, 0x86, 0x00, 0x03, 0x08, 0x00,
  0x06, 0x10, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x3F, 0xFE, 0x03, 0xFF, 0xFC,
  0x0E, 0x00, 0x10, 0x70, 0x00, 0x21, 0xC0, 0x00, 0x43, 0x00, 0x01, 0x8C,
  0x00, 0x03, 0x10, 0x00, 0x06, 0x60, 0x00, 0x08, 0xC0, 0x00, 0x11, 0x80,
  0x00, 0x62, 0x00, 0x01, 0xC6, 0x00, 0x07, 0x8C, 0x00, 0x1B, 0x08, 0x00,
  0x66, 0x18, 0x01, 0x8C, 0x1C, 0x1E, 0x18, 0x1F, 0xF0, 0x30, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x1F, 0xF0, 0x04, 0x70,
  0x38, 0x04, 0xC0, 0x0C, 0x0D, 0x80, 0x04, 0x0F, 0x00, 0x06, 0x0E, 0x00,
  0x06, 0x0C, 0x00, 0x02, 0x08, 0x00, 0x02, 0x08, 0x00, 0x03, 0x18, 0x00,
  0x03, 0x18, 0x00, 0x02, 0x18, 0x00, 0x02, 0x10, 0x00, 0x02, 0x10, 0x00,
  0x02, 0x10, 0x00, 0x06, 0x30, 0x00, 0x06, 0x30, 0x00, 0x06, 0x30, 0x00,
  0x06, 0x20, 0x00, 0x04, 0x20, 0x00, 0x04, 0x20, 0x00, 0x0C, 0x60, 0x00,
  0x0C, 0x60, 0x00, 0x08, 0x60, 0x00, 0x18, 0x40, 0x00, 0x18, 0x40, 0x00,
  0x30, 0xE0, 0x00, 0x30, 0xE0, 0x00, 0x60, 0xF0, 0x00, 0xC0, 0xD8, 0x01,
  0xC0, 0x8E, 0x07, 0x00, 0x83, 0xFE, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x07, 0x81, 0xC0, 0x1C, 0x01, 0xC0, 0x60, 0x01,
  0x81, 0x80, 0x01, 0x83, 0x00, 0x03, 0x0C, 0x00, 0x02, 0x18, 0x00, 0x04,
  0x60, 0x00, 0x08, 0xC0, 0x00, 0x11, 0x00, 0x00, 0x26, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x08, 0xC0, 0x00, 0x31, 0x80, 0x00,
  0x63, 0x00, 0x00, 0x82, 0x00, 0x03, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x30,
  0x0C, 0x00, 0xC0, 0x0E, 0x07, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x1F, 0xF0, 0x40, 0x07, 0x03, 0x08, 0x03, 0x80, 0x13, 0x00, 0x60, 0x01,
  0x60, 0x18, 0x00, 0x3C, 0x06, 0x00, 0x03, 0x00, 0x80, 0x00, 0x60, 0x30,
  0x00, 0x0C, 0x06, 0x00, 0x01, 0x80, 0x80, 0x00, 0x30, 0x30, 0x00, 0x06,
  0x06, 0x00, 0x00, 0x80, 0x80, 0x00, 0x10, 0x10, 0x00, 0x02, 0x06, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x18, 0x18, 0x00, 0x03, 0x03, 0x00, 0x00, 0x40,
  0x40, 0x00, 0x08, 0x08, 0x00, 0x03, 0x01, 0x00, 0x00, 0x60, 0x20, 0x00,
  0x0C, 0x04, 0x00, 0x01, 0x80, 0x80, 0x00, 0x20, 0x10, 0x00, 0x04, 0x02,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x30, 0x0C, 0x00, 0x0E, 0x00, 0x80, 0x02,
  0xC0, 0x18, 0x01, 0x90, 0x01, 0xC0, 0xE2, 0x00, 0x1F, 0xF0, 0xC0, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0xFF, 0xC0, 0x03, 0x81, 0xC0,
  0x1C, 0x00, 0xC0, 0x70, 0x01, 0x80, 0xC0, 0x01, 0x83, 0x00, 0x03, 0x0C,
  0x00, 0x02, 0x18, 0x00, 0x04, 0x60, 0x00, 0x08, 0xC0, 0x00, 0x11, 0x00,
  0x00, 0x26, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x9F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFE, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x08, 0x0E, 0x00, 0x70, 0x0F, 0x03, 0x80, 0x07,
  0xFC, 0x00, 0x00, 0x80, 0x00, 0x00, 0x07, 0x80, 0x0F, 0xF0, 0x07, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x01, 0xFF, 0xF0, 0xFF, 0xF8, 0x01, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x10, 0x03, 0x81,
  0x84, 0x03, 0x80, 0x33, 0x00, 0xC0, 0x02, 0xC0, 0x60, 0x00, 0xF0, 0x30,
  0x00, 0x18, 0x08, 0x00, 0x06, 0x06, 0x00, 0x01, 0x81, 0x80, 0x00, 0x60,
  0x40, 0x00, 0x18, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x02, 0x00, 0x00,
  0x40, 0x80, 0x00, 0x10, 0x60, 0x00, 0x0C, 0x18, 0x00, 0x03, 0x06, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x20, 0x40, 0x00, 0x08, 0x10, 0x00, 0x06, 0x04,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x04,
  0x04, 0x00, 0x01, 0x01, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x18, 0x00,
  0x1C, 0x02, 0x00, 0x0B, 0x00, 0xC0, 0x0C, 0x80, 0x1C, 0x0E, 0x20, 0x03,
  0xFE, 0x18, 0x00, 0x08, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x01, 0x00, 0x01,
  0x80, 0x60, 0x00, 0xC0, 0x18, 0x00, 0x60, 0x03, 0x80, 0x30, 0x00, 0x3C,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x83,
  0xFC, 0x02, 0x1C, 0x0C, 0x04, 0x60, 0x0C, 0x19, 0x80, 0x18, 0x36, 0x00,
  0x18, 0x68, 0x00, 0x30, 0xE0, 0x00, 0x61, 0x40, 0x00, 0xC3, 0x00, 0x01,
  0x8E, 0x00, 0x03, 0x18, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x10,
  0x80, 0x00, 0x21, 0x00, 0x00, 0xC6, 0x00, 0x01, 0x8C, 0x00, 0x03, 0x18,
  0x00, 0x04, 0x30, 0x00, 0x08, 0x40, 0x00, 0x10, 0x80, 0x00, 0x63, 0x00,
  0x00, 0xC6, 0x00, 0x01, 0x8C, 0x00, 0x02, 0x10, 0x00, 0x04, 0x20, 0x00,
  0x08, 0x40, 0x00, 0x31, 0x80, 0x00, 0x63, 0x00, 0x00, 0xC6, 0x00, 0x01,
  0x08, 0x00, 0x02, 0x10, 0x00, 0x0C, 0x00, 0x01, 0x80, 0xF0, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x01,
  0x80, 0x60, 0x10, 0x04, 0x01, 0x00, 0xC0, 0x30, 0x0C, 0x02, 0x00, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x40, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x08, 0x02, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x00, 0x40, 0x30, 0x0C,
  0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x06, 0x04, 0x00, 0x0C, 0x04, 0x00,
  0x18, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x0C, 0x01,
  0x80, 0x08, 0x03, 0x00, 0x08, 0x06, 0x00, 0x18, 0x0C, 0x00, 0x18, 0x18,
  0x00, 0x18, 0x70, 0x00, 0x18, 0xE0, 0x00, 0x11, 0x80, 0x00, 0x13, 0xC0,
  0x00, 0x36, 0x40, 0x00, 0x3C, 0x60, 0x00, 0x38, 0x20, 0x00, 0x30, 0x30,
  0x00, 0x20, 0x10, 0x00, 0x20, 0x18, 0x00, 0x60, 0x08, 0x00, 0x60, 0x0C,
  0x00, 0x60, 0x04, 0x00, 0x40, 0x06, 0x00, 0x40, 0x03, 0x00, 0x40, 0x03,
  0x00, 0xC0, 0x01, 0x80, 0xC0, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0x80, 0x00,
  0xC0, 0x80, 0x00, 0x60, 0x00, 0x80, 0x40, 0x60, 0x30, 0x18, 0x08, 0x04,
  0x02, 0x03, 0x01, 0x80, 0xC0, 0x40, 0x20, 0x30, 0x18, 0x0C, 0x06, 0x02,
  0x01, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x08, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0x80, 0x40, 0x60, 0x30, 0x18, 0x0C, 0x04, 0x02, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x20, 0x10, 0x18, 0x0C, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x83, 0xFE, 0x00, 0xFF, 0x80, 0x21, 0xC1, 0xC0, 0xF0, 0x70,
  0x18, 0xC0, 0x18, 0x70, 0x04, 0x06, 0x60, 0x06, 0x30, 0x01, 0x81, 0xB0,
  0x00, 0x98, 0x00, 0x20, 0x78, 0x00, 0x34, 0x00, 0x08, 0x14, 0x00, 0x0F,
  0x00, 0x03, 0x07, 0x00, 0x03, 0x80, 0x00, 0xC3, 0x80, 0x00, 0xC0, 0x00,
  0x30, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x08, 0x00, 0x02, 0x0C,
  0x00, 0x02, 0x00, 0x00, 0x82, 0x00, 0x00, 0x80, 0x00, 0x60, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x60, 0x00, 0x18, 0x00, 0x06, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x86, 0x00, 0x01, 0x00, 0x00, 0x41, 0x80, 0x00, 0x40, 0x00, 0x10,
  0x40, 0x00, 0x10, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC3, 0x00, 0x00, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x20,
  0x00, 0x08, 0x20, 0x00, 0x08, 0x00, 0x02, 0x08, 0x00, 0x02, 0x00, 0x01,
  0x86, 0x00, 0x01, 0x80, 0x00, 0x61, 0x80, 0x00, 0x60, 0x00, 0x18, 0x60,
  0x00, 0x18, 0x00, 0x04, 0x18, 0x00, 0x04, 0x00, 0x01, 0x04, 0x00, 0x01,
  0x00, 0x00, 0x41, 0x00, 0x00, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x1F, 0xE0, 0x10, 0xE0, 0x60, 0x23,
  0x00, 0x60, 0x4C, 0x00, 0xC1, 0xB0, 0x00, 0xC3, 0x40, 0x01, 0x87, 0x00,
  0x03, 0x0A, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x18, 0xC0, 0x00,
  0x31, 0x80, 0x00, 0x63, 0x00, 0x00, 0x84, 0x00, 0x01, 0x08, 0x00, 0x06,
  0x30, 0x00, 0x0C, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x21, 0x80, 0x00, 0x42,
  0x00, 0x00, 0x84, 0x00, 0x03, 0x18, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x60,
  0x00, 0x10, 0xC0, 0x00, 0x21, 0x00, 0x00, 0x42, 0x00, 0x01, 0x8C, 0x00,
  0x03, 0x18, 0x00, 0x06, 0x30, 0x00, 0x08, 0x40, 0x00, 0x10, 0x80, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xE0, 0x38, 0x01, 0x80,
  0x1C, 0x03, 0x00, 0x0C, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x0C, 0x00,
  0x02, 0x18, 0x00, 0x02, 0x18, 0x00, 0x03, 0x10, 0x00, 0x03, 0x30, 0x00,
  0x03, 0x30, 0x00, 0x03, 0x20, 0x00, 0x02, 0x60, 0x00, 0x02, 0x60, 0x00,
  0x02, 0x60, 0x00, 0x06, 0x40, 0x00, 0x06, 0x40, 0x00, 0x06, 0x40, 0x00,
  0x06, 0xC0, 0x00, 0x04, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00,
  0x08, 0xC0, 0x00, 0x18, 0x40, 0x00, 0x18, 0x40, 0x00, 0x30, 0x60, 0x00,
  0x30, 0x60, 0x00, 0x60, 0x30, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x1E, 0x07,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x20, 0x00, 0x18,
  0x7F, 0xC0, 0x02, 0x38, 0x1C, 0x00, 0x4C, 0x00, 0xC0, 0x0B, 0x00, 0x08,
  0x03, 0xC0, 0x01, 0x80, 0x70, 0x00, 0x10, 0x0C, 0x00, 0x02, 0x01, 0x00,
  0x00, 0x40, 0x20, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0x81, 0x80, 0x00, 0x30,
  0x30, 0x00, 0x04, 0x06, 0x00, 0x00, 0x80, 0x80, 0x00, 0x10, 0x10, 0x00,
  0x02, 0x06, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x18, 0x18, 0x00, 0x03, 0x02,
  0x00, 0x00, 0x40, 0x40, 0x00, 0x08, 0x08, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x60, 0x60, 0x00, 0x08, 0x0C, 0x00, 0x03, 0x01, 0x00, 0x00, 0x60, 0x20,
  0x00, 0x08, 0x0E, 0x00, 0x03, 0x01, 0xC0, 0x00, 0xC0, 0x3C, 0x00, 0x30,
  0x06, 0xC0, 0x0E, 0x00, 0x8E, 0x07, 0x00, 0x10, 0x7F, 0xC0, 0x06, 0x00,
  0x80, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC1, 0x00, 0xE0, 0x61,
  0x03, 0x80, 0x33, 0x03, 0x00, 0x0B, 0x06, 0x00, 0x0F, 0x0C, 0x00, 0x06,
  0x0C, 0x00, 0x06, 0x18, 0x00, 0x02, 0x18, 0x00, 0x06, 0x10, 0x00, 0x06,
  0x30, 0x00, 0x06, 0x30, 0x00, 0x04, 0x20, 0x00, 0x04, 0x20, 0x00, 0x04,
  0x60, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x08,
  0x40, 0x00, 0x08, 0x40, 0x00, 0x18, 0x40, 0x00, 0x18, 0x40, 0x00, 0x18,
  0x40, 0x00, 0x18, 0x40, 0x00, 0x10, 0x40, 0x00, 0x10, 0x40, 0x00, 0x30,
  0x40, 0x00, 0x30, 0x60, 0x00, 0x70, 0x20, 0x00, 0xE0, 0x30, 0x03, 0x20,
  0x1C, 0x0E, 0x20, 0x0F, 0xF8, 0x60, 0x00, 0x80, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x0F, 0xC1, 0x9C,
  0x00, 0x98, 0x00, 0x48, 0x00, 0x68, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x1E,
  0x07, 0x00, 0xE0, 0x06, 0x06, 0x00, 0x0C, 0x10, 0x00, 0x30, 0xC0, 0x00,
  0xC2, 0x00, 0x01, 0x08, 0x00, 0x04, 0x20, 0x00, 0x00, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x33, 0x00, 0x00, 0xCC, 0x00, 0x02, 0x30, 0x00, 0x18, 0x40, 0x00,
  0x61, 0x80, 0x03, 0x03, 0x00, 0x38, 0x07, 0x03, 0xC0, 0x0F, 0xFC, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x30, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x04, 0x0F, 0xFF, 0xFF, 0xF0, 0xC0, 0x0C, 0x00, 0xC0,
  0x08, 0x00, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0x01, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0x40, 0x06, 0x00, 0x3F, 0x00, 0x80, 0x0C, 0x00, 0x02, 0x10, 0x00, 0x04,
  0x20, 0x00, 0x18, 0xC0, 0x00, 0x31, 0x80, 0x00, 0x63, 0x00, 0x00, 0x86,
  0x00, 0x01, 0x08, 0x00, 0x02, 0x10, 0x00, 0x0C, 0x60, 0x00, 0x18, 0xC0,
  0x00, 0x31, 0x80, 0x00, 0x42, 0x00, 0x00, 0x84, 0x00, 0x03, 0x08, 0x00,
  0x06, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x21, 0x00, 0x00,
  0x42, 0x00, 0x01, 0x8C, 0x00, 0x03, 0x18, 0x00, 0x06, 0x30, 0x00, 0x0C,
  0x60, 0x00, 0x30, 0xC0, 0x00, 0x61, 0x80, 0x01, 0xC3, 0x00, 0x03, 0x82,
  0x00, 0x0F, 0x06, 0x00, 0x34, 0x0E, 0x00, 0xC8, 0x0E, 0x07, 0x10, 0x0F,
  0xF8, 0x60, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x6C, 0x00,
  0x01, 0xB0, 0x00, 0x04, 0x40, 0x00, 0x31, 0x00, 0x00, 0x86, 0x00, 0x06,
  0x18, 0x00, 0x10, 0x60, 0x00, 0xC1, 0x80, 0x02, 0x02, 0x00, 0x18, 0x08,
  0x00, 0x40, 0x20, 0x03, 0x00, 0xC0, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x00, 0x10, 0x0C, 0x00, 0x40, 0x20, 0x01, 0x01, 0x80, 0x06, 0x06, 0x00,
  0x18, 0x30, 0x00, 0x60, 0xC0, 0x00, 0x86, 0x00, 0x02, 0x18, 0x00, 0x08,
  0x40, 0x00, 0x33, 0x00, 0x00, 0xC8, 0x00, 0x03, 0x60, 0x00, 0x05, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xF0, 0x00, 0x30, 0x00, 0x6C, 0x00, 0x1C, 0x00, 0x1B, 0x00, 0x07,
  0x00, 0x04, 0xC0, 0x03, 0xC0, 0x03, 0x30, 0x00, 0x90, 0x00, 0xCC, 0x00,
  0x64, 0x00, 0x63, 0x00, 0x19, 0x00, 0x18, 0x40, 0x0C, 0x40, 0x0C, 0x10,
  0x03, 0x10, 0x03, 0x04, 0x01, 0x86, 0x00, 0xC1, 0x00, 0x61, 0x80, 0x60,
  0x60, 0x10, 0x60, 0x18, 0x18, 0x0C, 0x18, 0x0C, 0x06, 0x02, 0x06, 0x03,
  0x01, 0x81, 0x81, 0x80, 0x80, 0x60, 0x60, 0x20, 0x60, 0x18, 0x30, 0x08,
  0x18, 0x06, 0x0C, 0x02, 0x0C, 0x01, 0x86, 0x00, 0x83, 0x00, 0x61, 0x80,
  0x21, 0x80, 0x18, 0x40, 0x0C, 0x60, 0x02, 0x30, 0x03, 0x18, 0x00, 0x88,
  0x00, 0xCC, 0x00, 0x26, 0x00, 0x33, 0x00, 0x09, 0x80, 0x0C, 0x80, 0x02,
  0x40, 0x03, 0x60, 0x00, 0xB0, 0x00, 0x50, 0x00, 0x28, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0x18, 0x00, 0x30, 0x06,
  0x00, 0x18, 0x00, 0x80, 0x06, 0x00, 0x30, 0x03, 0x00, 0x0C, 0x01, 0x80,
  0x01, 0x80, 0x40, 0x00, 0x60, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x42, 0x00, 0x00, 0x19, 0x80, 0x00, 0x02, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0x20, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x61, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x18, 0x08, 0x00, 0x0C, 0x03, 0x00, 0x03, 0x00, 0xC0, 0x01, 0x80,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x00, 0xC0, 0x18, 0x00, 0x30, 0x0C,
  0x00, 0x04, 0x06, 0x00, 0x01, 0x83, 0x00, 0x00, 0x60, 0x01, 0x80, 0x00,
  0x18, 0x0C, 0x00, 0x00, 0x80, 0x60, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x40,
  0x08, 0x00, 0x06, 0x00, 0x60, 0x00, 0x20, 0x03, 0x00, 0x03, 0x00, 0x18,
  0x00, 0x10, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00,
  0xC0, 0x00, 0x80, 0x06, 0x00, 0x06, 0x00, 0x60, 0x00, 0x30, 0x03, 0x00,
  0x01, 0x80, 0x30, 0x00, 0x04, 0x01, 0x80, 0x00, 0x20, 0x18, 0x00, 0x01,
  0x00, 0xC0, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x60, 0x60, 0x00, 0x03, 0x06,
  0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x43, 0x00, 0x00, 0x02, 0x18, 0x00,
  0x00, 0x19, 0x80, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x13, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x20, 0x00, 0x1C, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0x40, 0x00, 0x30, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x10,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x30, 0x0C, 0x02, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x40, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x02, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x40, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x08, 0x02, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x40, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x08, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x40, 0x30, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x08, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x03, 0x18, 0x18, 0x00, 0x23, 0x00, 0xC0,
  0x02, 0x60, 0x0C, 0x00, 0x64, 0x00, 0x60, 0x04, 0xC0, 0x03, 0x00, 0xCC,
  0x00, 0x18, 0x18, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xC0,
};

const GFXglyph RobotoCondensed_ThinItalic61pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 10, 44, 11, 1, -43 },
  { 56, 9, 12, 15, 7, -46 },
  { 70, 30, 43, 29, 1, -43 },
  { 232, 25, 57, 29, 2, -50 },
  { 411, 28, 45, 38, 6, -44 },
  { 569, 27, 45, 32, 2, -44 },
  { 721, 4, 12, 10, 6, -46 },
  { 727, 16, 62, 16, 3, -48 },
  { 851, 17, 62, 16, -4, -48 },
  { 983, 23, 24, 25, 4, -43 },
  { 1052, 24, 31, 29, 3, -35 },
  { 1145, 7, 12, 11, -2, -5 },
  { 1156, 12, 2, 16, 2, -21 },
  { 1159, 4, 4, 13, 1, -3 },
  { 1161, 24, 47, 20, -2, -43 },
  { 1302, 24, 45, 29, 3, -44 },
  { 1437, 13, 43, 29, 8, -43 },
  { 1507, 26, 44, 29, 1, -44 },
  { 1650, 25, 45, 29, 2, -44 },
  { 1791, 26, 43, 29, 1, -43 },
  { 1931, 25, 44, 29, 4, -43 },
  { 2069, 22, 44, 29, 3, -43 },
  { 2190, 24, 43, 29, 5, -43 },
  { 2319, 27, 45, 29, 1, -44 },
  { 2471, 23, 44, 29, 4, -44 },
  { 2598, 8, 32, 11, 1, -31 },
  { 2630, 11, 38, 10, -2, -31 },
  { 2683, 23, 24, 27, 3, -32 },
  { 2752, 23, 14, 29, 3, -27 },
  { 2793, 22, 24, 27, 2, -32 },
  { 2859, 18, 45, 23, 5, -44 },
  { 2961, 43, 56, 48, 2, -42 },
  { 3262, 29, 43, 31, -2, -43 },
  { 3418, 28, 43, 31, 2, -43 },
  { 3569, 28, 45, 34, 4, -44 },
  { 3727, 30, 43, 34, 2, -43 },
  { 3889, 30, 43, 30, 2, -43 },
  { 4051, 30, 43, 30, 2, -43 },
  { 4213, 29, 45, 36, 4, -44 },
  { 4377, 33, 43, 36, 2, -43 },
  { 4555, 9, 43, 14, 3, -43 },
  { 4604, 27, 44, 29, 1, -43 },
  { 4753, 32, 43, 33, 2, -43 },
  { 4925, 20, 43, 27, 2, -43 },
  { 5033, 41, 43, 44, 2, -43 },
  { 5254, 34, 43, 37, 2, -43 },
  { 5437, 30, 45, 35, 3, -44 },
  { 5606, 29, 43, 31, 2, -43 },
  { 5762, 30, 52, 35, 3, -44 },
  { 5957, 29, 43, 34, 2, -43 },
  { 6113, 30, 45, 31, 1, -44 },
  { 6282, 28, 43, 31, 6, -43 },
  { 6433, 30, 44, 35, 4, -43 },
  { 6598, 29, 43, 31, 5, -43 },
  { 6754, 42, 43, 47, 6, -43 },
  { 6980, 34, 43, 31, -1, -43 },
  { 7163, 28, 43, 31, 6, -43 },
  { 7314, 32, 43, 31, 0, -43 },
  { 7486, 16, 59, 12, 1, -50 },
  { 7604, 9, 47, 20, 6, -43 },
  { 7657, 16, 59, 12, -4, -50 },
  { 7775, 17, 22, 22, 3, -43 },
  { 7822, 21, 2, 22, -3, 0 },
  { 7828, 7, 8, 16, 8, -46 },
  { 7835, 23, 34, 28, 1, -33 },
  { 7933, 24, 47, 29, 2, -46 },
  { 8074, 23, 34, 27, 2, -33 },
  { 8172, 27, 47, 29, 2, -46 },
  { 8331, 23, 34, 27, 2, -33 },
  { 8429, 18, 47, 17, 4, -47 },
  { 8535, 26, 45, 29, 0, -33 },
  { 8682, 23, 46, 29, 2, -46 },
  { 8815, 10, 44, 12, 2, -44 },
  { 8870, 20, 56, 12, -8, -44 },
  { 9010, 24, 46, 25, 2, -46 },
  { 9148, 9, 46, 12, 2, -46 },
  { 9200, 42, 33, 46, 1, -33 },
  { 9374, 23, 33, 29, 2, -33 },
  { 9469, 24, 34, 29, 2, -33 },
  { 9571, 27, 45, 29, -1, -33 },
  { 9723, 24, 45, 29, 2, -33 },
  { 9858, 17, 33, 18, 2, -33 },
  { 9929, 22, 34, 26, 1, -33 },
  { 10023, 12, 42, 17, 4, -41 },
  { 10086, 23, 33, 29, 3, -32 },
  { 10181, 22, 32, 25, 4, -32 },
  { 10269, 34, 32, 39, 5, -32 },
  { 10405, 26, 32, 25, -1, -32 },
  { 10509, 29, 44, 25, -3, -32 },
  { 10669, 25, 32, 25, 0, -32 },
  { 10769, 19, 61, 17, 2, -48 },
  { 10914, 10, 51, 12, 1, -43 },
  { 10978, 19, 61, 17, -4, -48 },
  { 11123, 28, 10, 36, 4, -23 },
};

const GFXfont RobotoCondensed_ThinItalic61pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ThinItalic61pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ThinItalic61pt7bGlyphs,
  0x20, 0x7E, 71
};

#endif // _ROBOTOCONDENSED_THINITALIC61PT7B_H_
