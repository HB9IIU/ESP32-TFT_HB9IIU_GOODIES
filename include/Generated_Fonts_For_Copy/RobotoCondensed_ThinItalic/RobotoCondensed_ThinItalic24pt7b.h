#ifndef _ROBOTOCONDENSED_THINITALIC24PT7B_H_
#define _ROBOTOCONDENSED_THINITALIC24PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ThinItalic.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ThinItalic24pt7bBitmaps[] PROGMEM = {
  0x00, 0x11, 0x11, 0x12, 0x22, 0x22, 0x44, 0x00, 0x00, 0x40, 0xB6, 0xDA,
  0x01, 0x10, 0x22, 0x02, 0x20, 0x22, 0x3F, 0xF0, 0x44, 0x04, 0x40, 0x88,
  0x08, 0x80, 0x88, 0x11, 0x01, 0x10, 0xFF, 0xC2, 0x20, 0x22, 0x02, 0x20,
  0x44, 0x00, 0x02, 0x00, 0x80, 0xF0, 0x42, 0x20, 0x48, 0x14, 0x04, 0x80,
  0x20, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x00, 0x28, 0x0A, 0x04, 0x81, 0x10,
  0x83, 0xC0, 0x40, 0x10, 0x00, 0x38, 0x08, 0x81, 0x10, 0xC2, 0x28, 0x49,
  0x12, 0x22, 0x43, 0x90, 0x04, 0x00, 0x9C, 0x24, 0x89, 0x12, 0x22, 0x44,
  0x50, 0x88, 0x11, 0x01, 0xC0, 0x0F, 0x04, 0x41, 0x08, 0x42, 0x21, 0x04,
  0x81, 0x40, 0x20, 0x18, 0x09, 0x14, 0x46, 0x09, 0x82, 0xA0, 0x68, 0x12,
  0x0A, 0x7C, 0x40, 0x55, 0x80, 0x02, 0x08, 0x20, 0x81, 0x04, 0x08, 0x20,
  0x40, 0x81, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x04, 0x08,
  0x10, 0x10, 0x10, 0x20, 0x81, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04,
  0x10, 0x82, 0x08, 0x21, 0x04, 0x20, 0x84, 0x20, 0x80, 0x04, 0x01, 0x00,
  0x43, 0x96, 0x1E, 0x03, 0x01, 0x40, 0x88, 0x42, 0x00, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x02, 0x0F, 0xFC, 0x20, 0x08, 0x02, 0x00, 0x80, 0x40,
  0x10, 0x00, 0x25, 0x28, 0xF8, 0x80, 0x00, 0x40, 0x20, 0x08, 0x04, 0x01,
  0x00, 0x80, 0x20, 0x10, 0x04, 0x02, 0x00, 0x80, 0x40, 0x10, 0x08, 0x02,
  0x01, 0x00, 0x40, 0x20, 0x00, 0x0F, 0x04, 0x22, 0x04, 0x81, 0x40, 0x50,
  0x14, 0x05, 0x02, 0x80, 0xA0, 0x28, 0x0A, 0x02, 0x81, 0x20, 0x48, 0x21,
  0x08, 0x3C, 0x00, 0x1B, 0x62, 0x10, 0x84, 0x42, 0x10, 0x84, 0x22, 0x10,
  0x84, 0x20, 0x0F, 0x08, 0x48, 0x28, 0x14, 0x08, 0x04, 0x02, 0x02, 0x02,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x00, 0xFF, 0x00, 0x0F, 0x04,
  0x22, 0x04, 0x81, 0x40, 0x40, 0x20, 0x08, 0x04, 0x1E, 0x00, 0x40, 0x08,
  0x02, 0x80, 0xA0, 0x48, 0x11, 0x08, 0x3C, 0x00, 0x00, 0x80, 0xC0, 0xA0,
  0x50, 0x48, 0x48, 0x44, 0x22, 0x21, 0x20, 0xA0, 0x9F, 0xF0, 0x20, 0x10,
  0x08, 0x04, 0x04, 0x00, 0x0F, 0xC2, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40,
  0x0F, 0x81, 0x08, 0x00, 0x80, 0x10, 0x02, 0x00, 0x48, 0x09, 0x01, 0x10,
  0x42, 0x10, 0x3C, 0x00, 0x03, 0x86, 0x04, 0x04, 0x02, 0x02, 0x01, 0x78,
  0xC2, 0x40, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x0A, 0x04, 0x84, 0x3C, 0x00,
  0xFF, 0x80, 0x20, 0x08, 0x04, 0x02, 0x00, 0x80, 0x40, 0x10, 0x08, 0x02,
  0x01, 0x00, 0x40, 0x20, 0x08, 0x04, 0x01, 0x00, 0x80, 0x00, 0x07, 0x81,
  0x08, 0x40, 0x88, 0x12, 0x02, 0x40, 0x48, 0x10, 0x84, 0x0F, 0x02, 0x10,
  0x81, 0x20, 0x24, 0x05, 0x00, 0x90, 0x22, 0x08, 0x3E, 0x00, 0x1E, 0x10,
  0x90, 0x50, 0x18, 0x0C, 0x06, 0x03, 0x02, 0x81, 0x43, 0x9E, 0x40, 0x40,
  0x20, 0x20, 0x10, 0x30, 0xE0, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x0C,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x44, 0x22, 0x00, 0x00, 0x81,
  0x83, 0x06, 0x0C, 0x06, 0x00, 0x80, 0x30, 0x04, 0x01, 0x80, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x40, 0x18, 0x02, 0x00, 0xC0, 0x10, 0x08,
  0x18, 0x30, 0x60, 0x40, 0x00, 0x3C, 0x85, 0x0C, 0x10, 0x20, 0x41, 0x04,
  0x10, 0x40, 0x81, 0x00, 0x00, 0x00, 0x00, 0x40, 0x01, 0xF8, 0x01, 0x03,
  0x03, 0x00, 0x81, 0x00, 0x21, 0x00, 0x11, 0x07, 0x04, 0x84, 0x42, 0x84,
  0x21, 0x44, 0x10, 0xC2, 0x10, 0xA1, 0x08, 0x51, 0x04, 0x28, 0x82, 0x14,
  0x42, 0x12, 0x21, 0x09, 0x11, 0x48, 0x87, 0x38, 0x40, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x80, 0x08, 0x01, 0x40,
  0x14, 0x02, 0x40, 0x24, 0x04, 0x40, 0x44, 0x08, 0x20, 0x82, 0x10, 0x21,
  0xFE, 0x20, 0x22, 0x02, 0x40, 0x24, 0x01, 0x80, 0x10, 0x1F, 0x84, 0x08,
  0x80, 0x90, 0x12, 0x02, 0x40, 0x88, 0x12, 0x04, 0x7E, 0x08, 0x31, 0x01,
  0x20, 0x24, 0x05, 0x00, 0xA0, 0x24, 0x08, 0xFE, 0x00, 0x07, 0xC0, 0x82,
  0x10, 0x22, 0x01, 0x20, 0x14, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x48, 0x04, 0x40, 0x84, 0x18, 0x3E, 0x00, 0x1F,
  0x82, 0x04, 0x20, 0x22, 0x02, 0x20, 0x12, 0x01, 0x20, 0x14, 0x02, 0x40,
  0x24, 0x02, 0x40, 0x24, 0x02, 0x40, 0x48, 0x04, 0x80, 0x88, 0x10, 0xFE,
  0x00, 0x1F, 0xE4, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00,
  0x7F, 0x88, 0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x04, 0x00, 0xFF,
  0x80, 0x1F, 0xF2, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x04,
  0x00, 0x7F, 0x84, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x00, 0x0F, 0x82, 0x08, 0x80, 0xA0, 0x14, 0x02, 0x80, 0x20,
  0x04, 0x00, 0x80, 0x10, 0xFA, 0x01, 0x40, 0x28, 0x05, 0x00, 0xA0, 0x22,
  0x0C, 0x3E, 0x00, 0x10, 0x09, 0x00, 0x48, 0x02, 0x40, 0x22, 0x01, 0x10,
  0x08, 0x80, 0x48, 0x02, 0x7F, 0xE2, 0x01, 0x10, 0x08, 0x80, 0x44, 0x02,
  0x40, 0x12, 0x00, 0x90, 0x08, 0x80, 0x40, 0x11, 0x12, 0x22, 0x22, 0x24,
  0x44, 0x44, 0x48, 0x80, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x48, 0x09, 0x01, 0x10,
  0x42, 0x10, 0x3C, 0x00, 0x10, 0x12, 0x02, 0x20, 0x42, 0x08, 0x21, 0x02,
  0x20, 0x24, 0x04, 0x80, 0x58, 0x06, 0x40, 0x44, 0x04, 0x20, 0x41, 0x08,
  0x10, 0x80, 0x88, 0x08, 0x80, 0x40, 0x10, 0x20, 0x20, 0x20, 0x20, 0x20,
  0x20, 0x40, 0x40, 0x40, 0x40, 0x40, 0x40, 0x80, 0x80, 0x80, 0xFF, 0x10,
  0x01, 0x10, 0x03, 0x30, 0x03, 0x28, 0x05, 0x28, 0x06, 0x28, 0x0A, 0x28,
  0x12, 0x48, 0x12, 0x48, 0x22, 0x44, 0x22, 0x44, 0x44, 0x44, 0x44, 0x44,
  0x84, 0x84, 0x84, 0x83, 0x04, 0x83, 0x04, 0x82, 0x08, 0x10, 0x08, 0x80,
  0x4A, 0x02, 0x50, 0x12, 0x81, 0x12, 0x08, 0x90, 0x48, 0x42, 0x42, 0x12,
  0x10, 0x90, 0x48, 0x82, 0x44, 0x0A, 0x40, 0x52, 0x02, 0x90, 0x08, 0x80,
  0x40, 0x07, 0xC0, 0x82, 0x10, 0x12, 0x01, 0x20, 0x14, 0x01, 0x40, 0x14,
  0x01, 0x40, 0x18, 0x02, 0x80, 0x28, 0x02, 0x80, 0x28, 0x04, 0x40, 0x84,
  0x18, 0x3E, 0x00, 0x1F, 0x84, 0x08, 0x80, 0x90, 0x12, 0x02, 0x40, 0x48,
  0x0A, 0x02, 0x40, 0x8F, 0xE1, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x00, 0x07, 0xC0, 0x82, 0x10, 0x12, 0x01, 0x20, 0x14, 0x01,
  0x40, 0x14, 0x01, 0x40, 0x18, 0x02, 0x80, 0x28, 0x02, 0x80, 0x28, 0x04,
  0x40, 0x84, 0x18, 0x3E, 0x00, 0x10, 0x01, 0x00, 0x08, 0x1F, 0x84, 0x0C,
  0x80, 0x90, 0x12, 0x02, 0x40, 0x50, 0x0A, 0x02, 0x40, 0x8F, 0xE1, 0x08,
  0x20, 0x88, 0x11, 0x01, 0x20, 0x24, 0x04, 0x80, 0x40, 0x0F, 0x82, 0x08,
  0x80, 0xA0, 0x14, 0x02, 0x80, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x02,
  0x00, 0x28, 0x05, 0x00, 0xA0, 0x26, 0x08, 0x3E, 0x00, 0xFF, 0xE0, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x00, 0x20, 0x12, 0x01,
  0x20, 0x12, 0x01, 0x20, 0x12, 0x01, 0x40, 0x24, 0x02, 0x40, 0x24, 0x02,
  0x40, 0x28, 0x02, 0x80, 0x48, 0x04, 0x40, 0x84, 0x10, 0x3E, 0x00, 0x80,
  0x30, 0x06, 0x01, 0x40, 0x24, 0x08, 0x81, 0x10, 0x42, 0x08, 0x41, 0x08,
  0x40, 0x88, 0x12, 0x02, 0x40, 0x50, 0x0A, 0x01, 0x80, 0x10, 0x00, 0x80,
  0x80, 0xC0, 0x40, 0x60, 0x50, 0x50, 0x28, 0x28, 0x24, 0x12, 0x12, 0x11,
  0x09, 0x08, 0x88, 0x88, 0x44, 0x44, 0x24, 0x22, 0x12, 0x12, 0x09, 0x09,
  0x05, 0x04, 0x82, 0x82, 0x81, 0x80, 0xC0, 0xC0, 0x40, 0x40, 0x20, 0x00,
  0x10, 0x08, 0x80, 0x84, 0x08, 0x10, 0x80, 0x84, 0x02, 0x40, 0x14, 0x00,
  0xA0, 0x02, 0x00, 0x30, 0x02, 0x40, 0x12, 0x01, 0x08, 0x10, 0x41, 0x01,
  0x08, 0x08, 0x80, 0x40, 0x80, 0x28, 0x05, 0x01, 0x20, 0x42, 0x08, 0x42,
  0x08, 0x80, 0x90, 0x14, 0x03, 0x00, 0x20, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x20, 0x00, 0x1F, 0xF0, 0x00, 0x80, 0x08, 0x00, 0x80, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0xFF, 0xC0, 0x0E, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x10, 0x20, 0x70, 0x84, 0x44, 0x44, 0x44, 0x22, 0x22, 0x22,
  0x21, 0x11, 0x0E, 0x04, 0x08, 0x10, 0x40, 0x81, 0x02, 0x04, 0x08, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x20, 0x40, 0x81, 0x02, 0x04, 0x30, 0x08,
  0x10, 0x50, 0xA2, 0x44, 0x91, 0x21, 0x82, 0xFF, 0x48, 0x80, 0x0F, 0x04,
  0x22, 0x04, 0x01, 0x00, 0x80, 0x21, 0xF8, 0x82, 0x40, 0xA0, 0x48, 0x12,
  0x0C, 0x7D, 0x00, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x79, 0xC2, 0x81,
  0x40, 0xA0, 0x50, 0x30, 0x18, 0x0C, 0x06, 0x05, 0x02, 0xC2, 0x5E, 0x00,
  0x1E, 0x10, 0x90, 0x28, 0x18, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0xA0,
  0x90, 0x47, 0xC0, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x47, 0x92, 0x19,
  0x02, 0x40, 0xA0, 0x28, 0x0A, 0x04, 0x81, 0x20, 0x48, 0x12, 0x04, 0x82,
  0x1F, 0x40, 0x1E, 0x10, 0x90, 0x28, 0x18, 0x0F, 0xFA, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x43, 0xC0, 0x07, 0x08, 0x10, 0x10, 0x10, 0x7C, 0x20,
  0x20, 0x20, 0x20, 0x20, 0x40, 0x40, 0x40, 0x40, 0x40, 0x40, 0x80, 0x0F,
  0x44, 0x32, 0x04, 0x81, 0x40, 0x50, 0x14, 0x09, 0x02, 0x40, 0x90, 0x24,
  0x09, 0x06, 0x3E, 0x80, 0x40, 0x10, 0x04, 0x82, 0x1F, 0x00, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x79, 0x42, 0xC1, 0x40, 0xA0, 0x50, 0x28, 0x18,
  0x14, 0x0A, 0x05, 0x02, 0x81, 0x40, 0x80, 0x20, 0x00, 0x22, 0x44, 0x44,
  0x48, 0x88, 0x88, 0x80, 0x03, 0x00, 0x00, 0x00, 0x02, 0x02, 0x04, 0x04,
  0x04, 0x04, 0x04, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10,
  0x20, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x05, 0x04, 0x84, 0x44,
  0x24, 0x14, 0x0E, 0x08, 0x84, 0x42, 0x11, 0x08, 0x82, 0x41, 0x00, 0x24,
  0x92, 0x4A, 0x49, 0x25, 0x24, 0x90, 0x4F, 0x1E, 0x50, 0xA1, 0x60, 0xC1,
  0x40, 0x81, 0x40, 0x81, 0x40, 0x81, 0x81, 0x01, 0x81, 0x02, 0x81, 0x02,
  0x81, 0x02, 0x81, 0x02, 0x81, 0x02, 0x82, 0x04, 0x2F, 0x28, 0x58, 0x28,
  0x14, 0x0A, 0x05, 0x03, 0x02, 0x81, 0x40, 0xA0, 0x50, 0x28, 0x10, 0x1E,
  0x10, 0x50, 0x28, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0xA0, 0x50,
  0x43, 0xC0, 0x17, 0x8E, 0x12, 0x04, 0x81, 0x20, 0x48, 0x14, 0x05, 0x01,
  0x40, 0x50, 0x24, 0x09, 0x84, 0x5E, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x00, 0x1E, 0x90, 0xD0, 0x28, 0x18, 0x0C, 0x06, 0x05, 0x02, 0x81, 0x40,
  0xA0, 0x50, 0x47, 0xE0, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x2C, 0xA1,
  0x82, 0x04, 0x08, 0x10, 0x40, 0x81, 0x02, 0x04, 0x08, 0x00, 0x0F, 0x18,
  0x48, 0x24, 0x02, 0x00, 0xC0, 0x18, 0x02, 0x01, 0x00, 0xA0, 0x48, 0x43,
  0xC0, 0x10, 0x89, 0xF2, 0x10, 0x84, 0x42, 0x10, 0x84, 0x21, 0x0E, 0x40,
  0xA0, 0x50, 0x28, 0x14, 0x0A, 0x06, 0x05, 0x02, 0x81, 0x40, 0xA0, 0xD0,
  0xA7, 0xA0, 0x80, 0xA0, 0x50, 0x48, 0x24, 0x22, 0x11, 0x10, 0x48, 0x28,
  0x14, 0x0C, 0x06, 0x02, 0x00, 0x82, 0x0C, 0x10, 0x61, 0x85, 0x0C, 0x28,
  0xA1, 0x44, 0x92, 0x44, 0x92, 0x28, 0x91, 0x45, 0x0A, 0x28, 0x60, 0x83,
  0x04, 0x10, 0x00, 0x20, 0x08, 0x21, 0x10, 0x48, 0x0A, 0x03, 0x00, 0x80,
  0x50, 0x14, 0x08, 0x84, 0x21, 0x04, 0x81, 0x00, 0x20, 0x22, 0x04, 0x41,
  0x08, 0x21, 0x08, 0x21, 0x04, 0x40, 0x48, 0x0A, 0x01, 0x40, 0x30, 0x06,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x80, 0x20, 0x18, 0x00, 0x3F, 0xC0, 0x20,
  0x10, 0x08, 0x02, 0x01, 0x00, 0x80, 0x40, 0x10, 0x08, 0x04, 0x02, 0x00,
  0xFF, 0x00, 0x02, 0x08, 0x20, 0x41, 0x02, 0x04, 0x08, 0x10, 0x40, 0x86,
  0x04, 0x08, 0x08, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x08, 0x08, 0x11,
  0x11, 0x11, 0x22, 0x22, 0x22, 0x44, 0x44, 0x44, 0x48, 0x08, 0x04, 0x02,
  0x02, 0x02, 0x02, 0x02, 0x04, 0x04, 0x04, 0x02, 0x01, 0x06, 0x04, 0x08,
  0x08, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x20, 0xC0, 0x38, 0x14, 0x42,
  0x42, 0x28, 0x1C,
};

const GFXglyph RobotoCondensed_ThinItalic24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 4, 17, 4, 0, -17 },
  { 10, 3, 5, 6, 3, -18 },
  { 12, 12, 17, 11, 0, -17 },
  { 38, 10, 21, 11, 1, -19 },
  { 65, 11, 17, 15, 2, -17 },
  { 89, 10, 17, 13, 1, -17 },
  { 111, 2, 5, 4, 2, -18 },
  { 113, 7, 24, 6, 1, -19 },
  { 134, 6, 25, 6, -1, -19 },
  { 153, 10, 9, 10, 1, -17 },
  { 165, 10, 13, 12, 1, -15 },
  { 182, 3, 5, 4, -1, -2 },
  { 184, 5, 1, 6, 1, -9 },
  { 185, 1, 1, 5, 1, -1 },
  { 186, 10, 18, 8, -1, -17 },
  { 209, 10, 17, 11, 1, -17 },
  { 231, 5, 17, 11, 3, -17 },
  { 242, 9, 17, 11, 1, -17 },
  { 262, 10, 17, 11, 1, -17 },
  { 284, 9, 17, 11, 1, -17 },
  { 304, 11, 17, 11, 1, -17 },
  { 328, 9, 17, 11, 1, -17 },
  { 348, 10, 17, 11, 2, -17 },
  { 370, 11, 17, 11, 0, -17 },
  { 394, 9, 17, 11, 2, -17 },
  { 414, 4, 12, 4, 0, -12 },
  { 420, 5, 15, 4, -1, -12 },
  { 430, 9, 10, 11, 1, -13 },
  { 442, 9, 6, 11, 1, -11 },
  { 449, 9, 10, 11, 1, -13 },
  { 461, 7, 17, 9, 2, -17 },
  { 476, 17, 22, 19, 1, -17 },
  { 523, 12, 17, 12, -1, -17 },
  { 549, 11, 17, 12, 1, -17 },
  { 573, 12, 17, 13, 1, -17 },
  { 599, 12, 17, 13, 1, -17 },
  { 625, 11, 17, 12, 1, -17 },
  { 649, 12, 17, 12, 1, -17 },
  { 675, 11, 17, 14, 2, -17 },
  { 699, 13, 17, 14, 1, -17 },
  { 727, 4, 17, 6, 1, -17 },
  { 736, 11, 17, 11, 0, -17 },
  { 760, 12, 17, 13, 1, -17 },
  { 786, 8, 17, 11, 1, -17 },
  { 803, 16, 17, 17, 1, -17 },
  { 837, 13, 17, 14, 1, -17 },
  { 865, 12, 17, 14, 1, -17 },
  { 891, 11, 17, 12, 1, -17 },
  { 915, 12, 20, 14, 1, -17 },
  { 945, 11, 17, 13, 1, -17 },
  { 969, 11, 17, 12, 1, -17 },
  { 993, 11, 17, 12, 2, -17 },
  { 1017, 12, 17, 14, 1, -17 },
  { 1043, 11, 17, 12, 2, -17 },
  { 1067, 17, 17, 18, 2, -17 },
  { 1104, 13, 17, 12, 0, -17 },
  { 1132, 11, 17, 12, 2, -17 },
  { 1156, 13, 17, 12, 0, -17 },
  { 1184, 7, 24, 5, 0, -20 },
  { 1205, 4, 18, 8, 2, -17 },
  { 1214, 7, 24, 5, -2, -20 },
  { 1235, 7, 9, 9, 1, -17 },
  { 1243, 8, 1, 9, -1, 0 },
  { 1244, 3, 3, 6, 3, -18 },
  { 1246, 10, 13, 11, 0, -13 },
  { 1263, 9, 18, 11, 1, -18 },
  { 1284, 9, 13, 10, 1, -13 },
  { 1299, 10, 18, 11, 1, -18 },
  { 1322, 9, 13, 11, 1, -13 },
  { 1337, 8, 18, 7, 1, -18 },
  { 1355, 10, 18, 11, 0, -13 },
  { 1378, 9, 18, 11, 1, -18 },
  { 1399, 4, 17, 5, 1, -17 },
  { 1408, 8, 22, 5, -3, -17 },
  { 1430, 9, 18, 10, 1, -18 },
  { 1451, 3, 18, 5, 1, -18 },
  { 1458, 16, 13, 18, 1, -13 },
  { 1484, 9, 13, 11, 1, -13 },
  { 1499, 9, 13, 11, 1, -13 },
  { 1514, 10, 18, 11, 0, -13 },
  { 1537, 9, 18, 11, 1, -13 },
  { 1558, 7, 13, 7, 1, -13 },
  { 1570, 9, 13, 10, 0, -13 },
  { 1585, 5, 16, 7, 1, -16 },
  { 1595, 9, 13, 11, 1, -13 },
  { 1610, 9, 13, 10, 1, -13 },
  { 1625, 13, 13, 15, 2, -13 },
  { 1647, 10, 13, 10, 0, -13 },
  { 1664, 11, 18, 10, -1, -13 },
  { 1689, 10, 13, 10, 0, -13 },
  { 1706, 7, 24, 7, 1, -19 },
  { 1727, 4, 20, 5, 0, -17 },
  { 1737, 8, 24, 7, -2, -19 },
  { 1761, 12, 4, 14, 1, -9 },
};

const GFXfont RobotoCondensed_ThinItalic24pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ThinItalic24pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ThinItalic24pt7bGlyphs,
  0x20, 0x7E, 28
};

#endif // _ROBOTOCONDENSED_THINITALIC24PT7B_H_
