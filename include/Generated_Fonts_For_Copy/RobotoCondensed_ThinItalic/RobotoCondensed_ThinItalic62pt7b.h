#ifndef _ROBOTOCONDENSED_THINITALIC62PT7B_H_
#define _ROBOTOCONDENSED_THINITALIC62PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ThinItalic.ttf
// Size: 62pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ThinItalic62pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x01, 0x80, 0x60, 0x18, 0x04, 0x01,
  0x00, 0x40, 0x30, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x08, 0x06, 0x01, 0x80,
  0x60, 0x10, 0x04, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x03, 0x80, 0x40, 0x00, 0x30, 0xC8,
  0x26, 0x09, 0x86, 0x61, 0x98, 0x66, 0x19, 0x04, 0xC3, 0x30, 0xCC, 0x33,
  0x0C, 0x00, 0x00, 0x40, 0x18, 0x00, 0x01, 0x80, 0x20, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x04, 0x01, 0x80, 0x00, 0x18, 0x02, 0x00, 0x00, 0x30, 0x04,
  0x00, 0x00, 0x40, 0x18, 0x00, 0x01, 0x80, 0x20, 0x00, 0x03, 0x00, 0x40,
  0x00, 0x04, 0x01, 0x80, 0x00, 0x18, 0x03, 0x00, 0x00, 0x30, 0x04, 0x00,
  0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0x00, 0x40, 0x00,
  0x04, 0x01, 0x80, 0x00, 0x18, 0x03, 0x00, 0x00, 0x30, 0x04, 0x00, 0x00,
  0x40, 0x18, 0x00, 0x00, 0x80, 0x30, 0x00, 0x03, 0x00, 0x40, 0x00, 0x04,
  0x01, 0x80, 0x00, 0x08, 0x03, 0x00, 0x00, 0x30, 0x04, 0x00, 0x00, 0x60,
  0x18, 0x00, 0x00, 0x80, 0x30, 0x00, 0x03, 0x00, 0x40, 0x00, 0x06, 0x01,
  0x80, 0x00, 0x08, 0x03, 0x00, 0x00, 0x30, 0x04, 0x00, 0x3F, 0xFF, 0xFF,
  0xF0, 0x00, 0x80, 0x30, 0x00, 0x03, 0x00, 0x40, 0x00, 0x06, 0x01, 0x80,
  0x00, 0x08, 0x03, 0x00, 0x00, 0x30, 0x04, 0x00, 0x00, 0x60, 0x18, 0x00,
  0x00, 0x80, 0x30, 0x00, 0x03, 0x00, 0x40, 0x00, 0x06, 0x00, 0x80, 0x00,
  0x08, 0x03, 0x00, 0x00, 0x30, 0x04, 0x00, 0x00, 0x60, 0x08, 0x00, 0x00,
  0x80, 0x30, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x3C, 0x0E, 0x00, 0x1C, 0x01,
  0xC0, 0x0E, 0x00, 0x30, 0x03, 0x00, 0x06, 0x01, 0x80, 0x01, 0x80, 0xC0,
  0x00, 0x20, 0x30, 0x00, 0x0C, 0x08, 0x00, 0x03, 0x06, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x30, 0x60, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x61, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x04, 0x30, 0x00, 0x01, 0x0C, 0x00, 0x00, 0xC1,
  0x00, 0x00, 0x30, 0x40, 0x00, 0x18, 0x18, 0x00, 0x06, 0x02, 0x00, 0x03,
  0x00, 0xC0, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x03, 0x80, 0xE0, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0x8E, 0x00, 0x00,
  0x30, 0x30, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x18, 0x06, 0x00, 0x01, 0x80,
  0x10, 0x01, 0x0C, 0x00, 0x80, 0x18, 0x40, 0x04, 0x01, 0x86, 0x00, 0x20,
  0x0C, 0x30, 0x03, 0x00, 0xC1, 0x80, 0x18, 0x0C, 0x08, 0x00, 0xC0, 0x40,
  0x40, 0x04, 0x06, 0x02, 0x00, 0x60, 0x60, 0x10, 0x03, 0x02, 0x00, 0xC0,
  0x10, 0x30, 0x06, 0x01, 0x83, 0x00, 0x18, 0x18, 0x30, 0x00, 0xE3, 0x81,
  0x80, 0x03, 0xF8, 0x18, 0x00, 0x02, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x7E, 0x00,
  0x06, 0x0E, 0x18, 0x00, 0x60, 0xE0, 0x60, 0x02, 0x06, 0x01, 0x00, 0x30,
  0x60, 0x08, 0x03, 0x02, 0x00, 0x60, 0x30, 0x30, 0x03, 0x01, 0x81, 0x80,
  0x18, 0x18, 0x08, 0x00, 0xC1, 0x80, 0x40, 0x04, 0x08, 0x02, 0x00, 0x20,
  0xC0, 0x30, 0x03, 0x0C, 0x01, 0x80, 0x18, 0x40, 0x0C, 0x00, 0xC6, 0x00,
  0x60, 0x0C, 0x20, 0x01, 0x00, 0x60, 0x00, 0x08, 0x06, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x01, 0x87, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x1C,
  0x06, 0x00, 0x03, 0x00, 0xC0, 0x00, 0xC0, 0x08, 0x00, 0x10, 0x01, 0x80,
  0x06, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x80, 0x06, 0x00,
  0x30, 0x00, 0xC0, 0x04, 0x00, 0x18, 0x01, 0x80, 0x03, 0x00, 0x60, 0x00,
  0x20, 0x18, 0x00, 0x04, 0x07, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x18, 0x60,
  0x00, 0x01, 0x98, 0x00, 0x00, 0x36, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0xC0, 0x80, 0x00, 0x30, 0x18, 0x01, 0x8C, 0x01, 0x80, 0x31, 0x00,
  0x30, 0x06, 0x60, 0x03, 0x00, 0x88, 0x00, 0x60, 0x33, 0x00, 0x06, 0x06,
  0x40, 0x00, 0x60, 0x98, 0x00, 0x0C, 0x33, 0x00, 0x00, 0xC6, 0x60, 0x00,
  0x19, 0x8C, 0x00, 0x01, 0xE1, 0x80, 0x00, 0x3C, 0x30, 0x00, 0x03, 0x06,
  0x00, 0x00, 0xF0, 0x60, 0x00, 0x36, 0x0C, 0x00, 0x0C, 0x60, 0xC0, 0x03,
  0x0C, 0x0E, 0x01, 0x80, 0xC0, 0xFF, 0xE0, 0x08, 0x03, 0xC0, 0x00, 0x00,
  0x13, 0x33, 0x33, 0x26, 0x66, 0x64, 0xC0, 0x00, 0x00, 0x80, 0x00, 0xC0,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18,
  0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00,
  0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00,
  0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x06, 0x00, 0x02, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x18,
  0x07, 0xE0, 0x20, 0x7C, 0xF8, 0x43, 0xC0, 0x3D, 0xBC, 0x00, 0x0F, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x6C, 0x00, 0x01, 0x8C, 0x00,
  0x06, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x60, 0x18, 0x01, 0x80, 0x30, 0x07,
  0x00, 0x30, 0x0C, 0x00, 0x60, 0x10, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x18,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x06, 0x08, 0x30,
  0x60, 0xC1, 0x86, 0x0C, 0x30, 0x61, 0x82, 0x00, 0xFF, 0xFF, 0xFF, 0x67,
  0xF0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x38, 0x38, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x06, 0x01, 0x80,
  0x06, 0x03, 0x00, 0x03, 0x03, 0x00, 0x03, 0x06, 0x00, 0x03, 0x06, 0x00,
  0x01, 0x0C, 0x00, 0x01, 0x0C, 0x00, 0x01, 0x08, 0x00, 0x01, 0x18, 0x00,
  0x01, 0x18, 0x00, 0x01, 0x10, 0x00, 0x01, 0x10, 0x00, 0x01, 0x30, 0x00,
  0x03, 0x30, 0x00, 0x03, 0x20, 0x00, 0x03, 0x20, 0x00, 0x03, 0x20, 0x00,
  0x02, 0x60, 0x00, 0x02, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x40, 0x00,
  0x06, 0x40, 0x00, 0x06, 0x40, 0x00, 0x04, 0xC0, 0x00, 0x0C, 0xC0, 0x00,
  0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x08, 0xC0, 0x00, 0x18, 0xC0, 0x00,
  0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x30, 0xC0, 0x00,
  0x60, 0x40, 0x00, 0x60, 0x60, 0x00, 0xC0, 0x60, 0x01, 0x80, 0x30, 0x03,
  0x80, 0x30, 0x07, 0x00, 0x1C, 0x1E, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x10, 0x07, 0x80, 0xF4, 0x1C, 0x67, 0x83, 0x70, 0x18, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x0E, 0x07, 0x00, 0x0C,
  0x01, 0xC0, 0x0C, 0x00, 0x60, 0x0C, 0x00, 0x18, 0x0C, 0x00, 0x0C, 0x06,
  0x00, 0x03, 0x06, 0x00, 0x01, 0x83, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x30, 0x80, 0x00, 0x18, 0x40, 0x00, 0x08, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xC1, 0xC0, 0x01, 0xC0, 0x18, 0x00,
  0xC0, 0x03, 0x00, 0x60, 0x00, 0x60, 0x30, 0x00, 0x18, 0x0C, 0x00, 0x06,
  0x06, 0x00, 0x00, 0x81, 0x80, 0x00, 0x20, 0x40, 0x00, 0x08, 0x30, 0x00,
  0x02, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x30, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0x43, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x0C, 0x30, 0x00,
  0x02, 0x0C, 0x00, 0x01, 0x81, 0x80, 0x00, 0x40, 0x60, 0x00, 0x30, 0x0C,
  0x00, 0x18, 0x01, 0x80, 0x1C, 0x00, 0x38, 0x1E, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x14, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x06, 0x40,
  0x00, 0x03, 0x30, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x63, 0x00, 0x00, 0x30,
  0x80, 0x00, 0x08, 0x20, 0x00, 0x06, 0x18, 0x00, 0x03, 0x06, 0x00, 0x01,
  0x81, 0x80, 0x00, 0x60, 0x60, 0x00, 0x30, 0x10, 0x00, 0x18, 0x04, 0x00,
  0x04, 0x03, 0x00, 0x03, 0x00, 0xC0, 0x01, 0x80, 0x30, 0x00, 0xC0, 0x0C,
  0x00, 0x30, 0x02, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x06, 0x00,
  0x18, 0x01, 0x80, 0x06, 0x00, 0xC0, 0x01, 0x80, 0x60, 0x00, 0x40, 0x18,
  0x00, 0x10, 0x0C, 0x00, 0x0C, 0x07, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x20, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x3F, 0x00, 0x02, 0x7F,
  0xF0, 0x00, 0xF0, 0x0E, 0x00, 0x70, 0x00, 0xC0, 0x18, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0xC0,
  0x00, 0x18, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x03, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x30, 0x30, 0x00, 0x18, 0x04, 0x00, 0x06, 0x01, 0x80, 0x03,
  0x00, 0x30, 0x01, 0x80, 0x0E, 0x00, 0xE0, 0x01, 0xC0, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x07, 0xF8,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x0C, 0x0F, 0xC0, 0x10, 0xFF, 0xE0, 0x23, 0x00, 0xE0, 0xCC, 0x00,
  0xE1, 0xA0, 0x00, 0xC2, 0x80, 0x00, 0xC6, 0x00, 0x01, 0x9C, 0x00, 0x03,
  0x30, 0x00, 0x02, 0x60, 0x00, 0x06, 0x80, 0x00, 0x0D, 0x00, 0x00, 0x1A,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x58, 0x00, 0x00, 0xB0, 0x00, 0x03, 0x60,
  0x00, 0x06, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x13, 0x00, 0x00, 0x66, 0x00,
  0x00, 0xCC, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x18, 0x00, 0x18, 0x18, 0x00,
  0x60, 0x30, 0x00, 0xC0, 0x30, 0x07, 0x00, 0x38, 0x1C, 0x00, 0x3F, 0xE0,
  0x00, 0x04, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x78, 0x3C, 0x00, 0x1C, 0x01, 0xC0,
  0x06, 0x00, 0x1C, 0x01, 0x80, 0x01, 0x80, 0x30, 0x00, 0x10, 0x0C, 0x00,
  0x03, 0x01, 0x00, 0x00, 0x60, 0x60, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0x81,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x81, 0x80, 0x00,
  0x30, 0x10, 0x00, 0x06, 0x02, 0x00, 0x01, 0x80, 0x60, 0x00, 0x70, 0x06,
  0x00, 0x0C, 0x00, 0xC0, 0x07, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0xFF, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0x03, 0x80, 0x03, 0x80, 0x1C, 0x00, 0xC0,
  0x01, 0x80, 0x30, 0x00, 0x18, 0x0C, 0x00, 0x01, 0x01, 0x00, 0x00, 0x30,
  0x60, 0x00, 0x06, 0x08, 0x00, 0x00, 0x43, 0x00, 0x00, 0x08, 0x60, 0x00,
  0x01, 0x08, 0x00, 0x00, 0x61, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x01, 0x84,
  0x00, 0x00, 0x60, 0x80, 0x00, 0x0C, 0x18, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x60, 0x30, 0x00, 0x18, 0x07, 0x00, 0x06, 0x00, 0x70, 0x03, 0x80, 0x07,
  0x81, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x03, 0x81, 0xC0, 0x0C, 0x01, 0xC0, 0x30, 0x01,
  0xC0, 0xC0, 0x01, 0x83, 0x00, 0x03, 0x04, 0x00, 0x03, 0x18, 0x00, 0x06,
  0x20, 0x00, 0x0C, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x16, 0x00, 0x00, 0x2C,
  0x00, 0x00, 0xD8, 0x00, 0x01, 0xA0, 0x00, 0x03, 0x40, 0x00, 0x06, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x34, 0x00, 0x00, 0xC8, 0x00,
  0x01, 0x98, 0x00, 0x07, 0x30, 0x00, 0x1E, 0x60, 0x00, 0x6C, 0x60, 0x01,
  0x90, 0xE0, 0x06, 0x20, 0xE0, 0x38, 0xC0, 0xFF, 0xE1, 0x80, 0x7F, 0x02,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x03, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0x03, 0x81, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x03, 0x81, 0xC0, 0x00, 0x00, 0x00, 0x60,
  0x1C, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0x60, 0x18, 0x06,
  0x00, 0xC0, 0x10, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x10, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x08, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x20, 0x00, 0xFF, 0x00,
  0xF0, 0x60, 0x70, 0x0C, 0x38, 0x01, 0x8C, 0x00, 0x66, 0x00, 0x09, 0x00,
  0x02, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x01, 0xF0, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x80, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00,
  0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0x00, 0x20, 0x18, 0x00, 0x00, 0x00,
  0x06, 0x03, 0x00, 0x03, 0xE0, 0x00, 0xC0, 0xC0, 0x01, 0xFF, 0x00, 0x18,
  0x18, 0x00, 0xE0, 0x30, 0x03, 0x06, 0x00, 0x38, 0x03, 0x00, 0x20, 0xC0,
  0x06, 0x00, 0x40, 0x04, 0x30, 0x01, 0x80, 0x18, 0x00, 0x86, 0x00, 0x60,
  0x03, 0x00, 0x11, 0x80, 0x08, 0x00, 0x60, 0x02, 0x30, 0x03, 0x00, 0x08,
  0x00, 0xC4, 0x00, 0x40, 0x01, 0x00, 0x19, 0x80, 0x18, 0x00, 0x60, 0x03,
  0x30, 0x02, 0x00, 0x0C, 0x00, 0x64, 0x00, 0xC0, 0x01, 0x00, 0x0C, 0x80,
  0x18, 0x00, 0x20, 0x01, 0x30, 0x02, 0x00, 0x0C, 0x00, 0x26, 0x00, 0xC0,
  0x01, 0x80, 0x0C, 0x80, 0x18, 0x00, 0x20, 0x01, 0x90, 0x02, 0x00, 0x04,
  0x00, 0x22, 0x00, 0x40, 0x01, 0x80, 0x0C, 0xC0, 0x18, 0x00, 0x30, 0x01,
  0x98, 0x03, 0x00, 0x04, 0x00, 0x23, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x60,
  0x0C, 0x00, 0x30, 0x01, 0x8C, 0x01, 0x80, 0x0E, 0x00, 0x21, 0x80, 0x30,
  0x01, 0xC0, 0x0C, 0x30, 0x06, 0x00, 0x58, 0x03, 0x06, 0x00, 0xC0, 0x19,
  0x00, 0x40, 0xC0, 0x08, 0x06, 0x20, 0x18, 0x18, 0x01, 0x83, 0x86, 0x0E,
  0x01, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x20, 0x00, 0xE0, 0x07, 0x80, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x01, 0x00, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x16,
  0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x08, 0x80, 0x00, 0x00, 0xC4, 0x00,
  0x00, 0x04, 0x20, 0x00, 0x00, 0x61, 0x00, 0x00, 0x02, 0x0C, 0x00, 0x00,
  0x30, 0x60, 0x00, 0x01, 0x03, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x80,
  0x40, 0x00, 0x0C, 0x02, 0x00, 0x00, 0x60, 0x10, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0x30, 0x06, 0x00, 0x01, 0x00, 0x30, 0x00, 0x18, 0x01, 0x80, 0x00,
  0x80, 0x0C, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x06, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x60, 0x03, 0x00, 0x03, 0x00, 0x10, 0x00, 0x18,
  0x01, 0x80, 0x00, 0xC0, 0x08, 0x00, 0x02, 0x00, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0x80, 0x60, 0x00, 0x06, 0x02, 0x00, 0x00, 0x30, 0x30, 0x00,
  0x01, 0x81, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x01,
  0x0C, 0x00, 0x00, 0x08, 0x60, 0x00, 0x00, 0x66, 0x00, 0x00, 0x03, 0x30,
  0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x30, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x80, 0x03,
  0x80, 0x18, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x60, 0x18, 0x00, 0x06, 0x01,
  0x00, 0x00, 0x30, 0x10, 0x00, 0x03, 0x01, 0x00, 0x00, 0x30, 0x30, 0x00,
  0x03, 0x03, 0x00, 0x00, 0x30, 0x30, 0x00, 0x03, 0x02, 0x00, 0x00, 0x20,
  0x20, 0x00, 0x06, 0x06, 0x00, 0x00, 0x60, 0x60, 0x00, 0x0C, 0x06, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x18, 0x04, 0x00, 0x07, 0x00, 0x40, 0x00, 0xE0,
  0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x0C, 0x00, 0x1E, 0x00, 0xC0,
  0x00, 0x70, 0x08, 0x00, 0x03, 0x00, 0x80, 0x00, 0x18, 0x18, 0x00, 0x01,
  0x81, 0x80, 0x00, 0x0C, 0x18, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x0C, 0x10,
  0x00, 0x00, 0xC1, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x08, 0x30, 0x00, 0x01, 0x82, 0x00, 0x00, 0x18, 0x20, 0x00, 0x03, 0x02,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0xC0, 0x60, 0x00,
  0x18, 0x04, 0x00, 0x07, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0x01, 0xE0, 0x00,
  0xE0, 0x03, 0x80, 0x0C, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x30, 0x0C, 0x00,
  0x00, 0xC0, 0x40, 0x00, 0x06, 0x06, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00,
  0x83, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0x31, 0x80, 0x00, 0x01, 0x88,
  0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x80, 0x00, 0x00, 0x84,
  0x00, 0x00, 0x0C, 0x20, 0x00, 0x00, 0x61, 0x80, 0x00, 0x06, 0x0C, 0x00,
  0x00, 0x30, 0x60, 0x00, 0x01, 0x01, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x18, 0x01, 0x80, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x1C, 0x07, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x08, 0x00, 0x1C, 0x00, 0x60,
  0x00, 0x38, 0x01, 0x80, 0x00, 0x70, 0x06, 0x00, 0x00, 0xC0, 0x10, 0x00,
  0x01, 0x80, 0x40, 0x00, 0x06, 0x03, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00,
  0x30, 0x30, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x03, 0x02, 0x00, 0x00, 0x04,
  0x08, 0x00, 0x00, 0x10, 0x60, 0x00, 0x00, 0x41, 0x80, 0x00, 0x01, 0x06,
  0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x30, 0x40, 0x00, 0x00, 0xC1, 0x00,
  0x00, 0x02, 0x0C, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0x20, 0xC0, 0x00,
  0x01, 0x82, 0x00, 0x00, 0x06, 0x08, 0x00, 0x00, 0x18, 0x20, 0x00, 0x00,
  0x41, 0x80, 0x00, 0x01, 0x06, 0x00, 0x00, 0x04, 0x18, 0x00, 0x00, 0x30,
  0x40, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x02, 0x04, 0x00, 0x00, 0x18, 0x30,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x03, 0x03, 0x00, 0x00, 0x0C, 0x08, 0x00,
  0x00, 0x60, 0x20, 0x00, 0x03, 0x00, 0x80, 0x00, 0x0C, 0x06, 0x00, 0x00,
  0x60, 0x18, 0x00, 0x07, 0x00, 0x60, 0x00, 0x38, 0x01, 0x00, 0x03, 0x80,
  0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xF0, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xC0, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xF0, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xE0,
  0x3C, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x60, 0x00, 0x70, 0x03, 0x00, 0x00,
  0xC0, 0x18, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x06, 0x02, 0x00, 0x00, 0x08,
  0x18, 0x00, 0x00, 0x20, 0x40, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x03, 0x08,
  0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x80, 0x07, 0xFF, 0x86, 0x00, 0x1F, 0xFE, 0x10, 0x00, 0x00, 0x18, 0x40,
  0x00, 0x00, 0x63, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x06, 0x30, 0x00,
  0x00, 0x10, 0xC0, 0x00, 0x00, 0x43, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x0C, 0x10, 0x00, 0x00, 0x30, 0x40, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x02,
  0x06, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x60, 0x30, 0x00, 0x03, 0x80,
  0x60, 0x00, 0x3C, 0x00, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x7C, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0,
  0x20, 0x00, 0x00, 0x30, 0x08, 0x00, 0x00, 0x08, 0x06, 0x00, 0x00, 0x02,
  0x01, 0x80, 0x00, 0x00, 0x80, 0x60, 0x00, 0x00, 0x60, 0x10, 0x00, 0x00,
  0x18, 0x04, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x01, 0x00, 0xC0, 0x00,
  0x00, 0x40, 0x30, 0x00, 0x00, 0x10, 0x0C, 0x00, 0x00, 0x0C, 0x02, 0x00,
  0x00, 0x03, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x20, 0x18,
  0x00, 0x00, 0x08, 0x06, 0x00, 0x00, 0x02, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x40, 0x00, 0x00, 0x60, 0x10, 0x00, 0x00, 0x18, 0x0F, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x00,
  0x30, 0x08, 0x00, 0x00, 0x0C, 0x02, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00,
  0x00, 0x80, 0x60, 0x00, 0x00, 0x20, 0x18, 0x00, 0x00, 0x18, 0x04, 0x00,
  0x00, 0x06, 0x01, 0x00, 0x00, 0x01, 0x80, 0x40, 0x00, 0x00, 0x40, 0x30,
  0x00, 0x00, 0x10, 0x0C, 0x00, 0x00, 0x04, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x80, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x00, 0x30, 0x08, 0x00, 0x00, 0x08,
  0x06, 0x00, 0x00, 0x02, 0x01, 0x80, 0x00, 0x00, 0x80, 0x60, 0x00, 0x00,
  0x60, 0x10, 0x00, 0x00, 0x18, 0x04, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x20, 0x18, 0x06, 0x01, 0x80, 0x60, 0x10, 0x04,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x00, 0x40, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x04, 0x01, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x80, 0x20,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x10, 0x04, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x40, 0x00, 0x0C,
  0x18, 0x00, 0x01, 0x03, 0x00, 0x00, 0x60, 0x60, 0x00, 0x0C, 0x0C, 0x00,
  0x03, 0x00, 0x80, 0x00, 0x60, 0x18, 0x00, 0x18, 0x03, 0x00, 0x06, 0x00,
  0x30, 0x00, 0xC0, 0x07, 0x00, 0x70, 0x00, 0x70, 0x3C, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x40, 0x00,
  0x03, 0x00, 0x20, 0x00, 0x03, 0x00, 0x30, 0x00, 0x03, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x04, 0x00, 0x03, 0x00, 0x02, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x03, 0x00, 0x00, 0xC0,
  0x03, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x20, 0x03, 0x00, 0x00, 0x10,
  0x03, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x01, 0x03, 0x00, 0x00, 0x00,
  0x83, 0x00, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x00, 0x63, 0x60, 0x00, 0x00,
  0x33, 0x10, 0x00, 0x00, 0x13, 0x0C, 0x00, 0x00, 0x0B, 0x03, 0x00, 0x00,
  0x07, 0x01, 0x80, 0x00, 0x07, 0x00, 0x60, 0x00, 0x03, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x0C, 0x00, 0x00, 0x80, 0x06, 0x00, 0x00, 0x40, 0x01, 0x80,
  0x00, 0x20, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x04, 0x00, 0x01, 0x80, 0x02, 0x00, 0x00,
  0xC0, 0x01, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x18, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x60, 0x00, 0x03, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x10, 0x00,
  0x00, 0x60, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00,
  0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x00,
  0x00, 0x70, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x00, 0x0A,
  0x01, 0xE0, 0x00, 0x00, 0x06, 0x80, 0x68, 0x00, 0x00, 0x01, 0x60, 0x12,
  0x00, 0x00, 0x00, 0xD8, 0x04, 0xC0, 0x00, 0x00, 0x26, 0x01, 0x30, 0x00,
  0x00, 0x19, 0x00, 0xCC, 0x00, 0x00, 0x04, 0x40, 0x33, 0x00, 0x00, 0x03,
  0x10, 0x0C, 0x40, 0x00, 0x00, 0x8C, 0x02, 0x10, 0x00, 0x00, 0x63, 0x00,
  0x86, 0x00, 0x00, 0x30, 0xC0, 0x61, 0x80, 0x00, 0x0C, 0x20, 0x18, 0x60,
  0x00, 0x06, 0x08, 0x06, 0x08, 0x00, 0x01, 0x86, 0x01, 0x82, 0x00, 0x00,
  0xC1, 0x80, 0x40, 0xC0, 0x00, 0x20, 0x60, 0x10, 0x30, 0x00, 0x18, 0x18,
  0x0C, 0x0C, 0x00, 0x04, 0x04, 0x03, 0x01, 0x00, 0x03, 0x01, 0x00, 0xC0,
  0x40, 0x00, 0x80, 0xC0, 0x20, 0x10, 0x00, 0x60, 0x30, 0x08, 0x06, 0x00,
  0x10, 0x0C, 0x02, 0x01, 0x80, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x02, 0x00,
  0x80, 0x60, 0x08, 0x01, 0x80, 0x20, 0x18, 0x02, 0x00, 0xC0, 0x18, 0x04,
  0x00, 0xC0, 0x30, 0x06, 0x01, 0x00, 0x30, 0x18, 0x01, 0x80, 0x40, 0x0C,
  0x06, 0x00, 0x60, 0x30, 0x01, 0x03, 0x00, 0x10, 0x0C, 0x00, 0x40, 0xC0,
  0x04, 0x03, 0x00, 0x10, 0x60, 0x03, 0x00, 0x80, 0x06, 0x10, 0x00, 0xC0,
  0x20, 0x01, 0x8C, 0x00, 0x30, 0x08, 0x00, 0x22, 0x00, 0x08, 0x06, 0x00,
  0x09, 0x80, 0x02, 0x01, 0x80, 0x02, 0x40, 0x01, 0x80, 0x60, 0x00, 0xB0,
  0x00, 0x60, 0x10, 0x00, 0x38, 0x00, 0x18, 0x04, 0x00, 0x0E, 0x00, 0x06,
  0x03, 0x00, 0x01, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x30,
  0x00, 0x00, 0x30, 0x1E, 0x00, 0x00, 0x0C, 0x07, 0x80, 0x00, 0x03, 0x01,
  0xA0, 0x00, 0x00, 0x80, 0x6C, 0x00, 0x00, 0x20, 0x19, 0x00, 0x00, 0x18,
  0x04, 0x40, 0x00, 0x06, 0x03, 0x18, 0x00, 0x01, 0x80, 0xC2, 0x00, 0x00,
  0x60, 0x30, 0xC0, 0x00, 0x10, 0x0C, 0x30, 0x00, 0x04, 0x03, 0x04, 0x00,
  0x03, 0x00, 0x81, 0x80, 0x00, 0xC0, 0x60, 0x20, 0x00, 0x30, 0x18, 0x0C,
  0x00, 0x0C, 0x06, 0x03, 0x00, 0x02, 0x01, 0x80, 0x40, 0x00, 0x80, 0x60,
  0x18, 0x00, 0x60, 0x10, 0x02, 0x00, 0x18, 0x0C, 0x00, 0xC0, 0x06, 0x03,
  0x00, 0x30, 0x01, 0x80, 0xC0, 0x04, 0x00, 0x40, 0x30, 0x01, 0x80, 0x30,
  0x08, 0x00, 0x20, 0x0C, 0x02, 0x00, 0x0C, 0x03, 0x01, 0x80, 0x03, 0x00,
  0xC0, 0x60, 0x00, 0x40, 0x30, 0x18, 0x00, 0x18, 0x08, 0x06, 0x00, 0x06,
  0x06, 0x01, 0x00, 0x00, 0x81, 0x80, 0x40, 0x00, 0x30, 0x60, 0x30, 0x00,
  0x04, 0x18, 0x0C, 0x00, 0x01, 0x86, 0x03, 0x00, 0x00, 0x61, 0x00, 0xC0,
  0x00, 0x08, 0xC0, 0x20, 0x00, 0x03, 0x30, 0x18, 0x00, 0x00, 0x4C, 0x06,
  0x00, 0x00, 0x1B, 0x01, 0x80, 0x00, 0x06, 0x80, 0x60, 0x00, 0x00, 0xE0,
  0x10, 0x00, 0x00, 0x38, 0x04, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xE0, 0x3C,
  0x00, 0x0E, 0x00, 0x38, 0x00, 0x60, 0x00, 0x30, 0x03, 0x00, 0x00, 0xC0,
  0x18, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x06, 0x03, 0x00, 0x00, 0x08, 0x18,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x0C, 0x20, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0xC6, 0x00, 0x00,
  0x03, 0x10, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0x02, 0x30, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x00, 0x62,
  0x00, 0x00, 0x01, 0x88, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x19, 0x80,
  0x00, 0x00, 0x46, 0x00, 0x00, 0x01, 0x18, 0x00, 0x00, 0x0C, 0x40, 0x00,
  0x00, 0x31, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x02, 0x30, 0x00, 0x00,
  0x18, 0xC0, 0x00, 0x00, 0x63, 0x00, 0x00, 0x01, 0x04, 0x00, 0x00, 0x0C,
  0x10, 0x00, 0x00, 0x30, 0x40, 0x00, 0x01, 0x81, 0x80, 0x00, 0x06, 0x06,
  0x00, 0x00, 0x30, 0x0C, 0x00, 0x01, 0x80, 0x30, 0x00, 0x0E, 0x00, 0x60,
  0x00, 0x70, 0x00, 0xC0, 0x03, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x08, 0x00, 0x1C, 0x00, 0x60, 0x00, 0x18, 0x01, 0x80, 0x00,
  0x30, 0x06, 0x00, 0x00, 0x40, 0x10, 0x00, 0x01, 0x80, 0x40, 0x00, 0x06,
  0x01, 0x00, 0x00, 0x08, 0x0C, 0x00, 0x00, 0x20, 0x30, 0x00, 0x00, 0x80,
  0xC0, 0x00, 0x02, 0x02, 0x00, 0x00, 0x18, 0x08, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x01, 0x81, 0x80, 0x00, 0x04, 0x06, 0x00, 0x00, 0x30, 0x18, 0x00,
  0x00, 0x80, 0x40, 0x00, 0x06, 0x01, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x01,
  0x80, 0x30, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0xE0, 0x03, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x20, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0xE0, 0x3C, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x60, 0x00, 0x30, 0x03, 0x00,
  0x00, 0xC0, 0x18, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x06, 0x03, 0x00, 0x00,
  0x08, 0x18, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0xC6,
  0x00, 0x00, 0x03, 0x10, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x02, 0x30, 0x00, 0x00, 0x08, 0xC0, 0x00,
  0x00, 0x62, 0x00, 0x00, 0x01, 0x88, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00,
  0x19, 0x80, 0x00, 0x00, 0x46, 0x00, 0x00, 0x01, 0x18, 0x00, 0x00, 0x0C,
  0x40, 0x00, 0x00, 0x31, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x02, 0x30,
  0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x63, 0x00, 0x00, 0x01, 0x0C, 0x00,
  0x00, 0x0C, 0x10, 0x00, 0x00, 0x30, 0x40, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x06, 0x06, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x01, 0x80, 0x30, 0x00, 0x0E,
  0x00, 0x60, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x00, 0x01, 0xC0, 0x78, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x41, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x60, 0x00,
  0x18, 0x01, 0x80, 0x00, 0x30, 0x04, 0x00, 0x00, 0x60, 0x10, 0x00, 0x01,
  0x80, 0x40, 0x00, 0x02, 0x03, 0x00, 0x00, 0x08, 0x0C, 0x00, 0x00, 0x20,
  0x30, 0x00, 0x00, 0x80, 0x80, 0x00, 0x02, 0x02, 0x00, 0x00, 0x08, 0x08,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x01, 0x81, 0x80, 0x00, 0x06, 0x06, 0x00,
  0x00, 0x30, 0x10, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x06, 0x03, 0x00, 0x00,
  0x30, 0x0C, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x60,
  0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x60, 0x01, 0x80, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x30, 0x00, 0x40,
  0x00, 0x60, 0x01, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x06, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0xC0, 0x00, 0x30, 0x02, 0x00, 0x00, 0x40, 0x08, 0x00, 0x01,
  0x80, 0x20, 0x00, 0x06, 0x01, 0x80, 0x00, 0x08, 0x06, 0x00, 0x00, 0x30,
  0x18, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x01, 0x01, 0x00, 0x00, 0x06, 0x04,
  0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x70,
  0x00, 0x30, 0x03, 0x00, 0x00, 0x60, 0x18, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x02, 0x03, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x30, 0x20, 0x00, 0x00,
  0xC0, 0x80, 0x00, 0x03, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x18, 0x40, 0x00, 0x00, 0x61, 0x00,
  0x00, 0x01, 0x84, 0x00, 0x00, 0x04, 0x10, 0x00, 0x00, 0x30, 0x60, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x03, 0x06, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00,
  0xC0, 0x30, 0x00, 0x07, 0x00, 0x60, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xC0,
  0x01, 0xE0, 0x3C, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x04, 0x18, 0x00, 0x00, 0x10, 0x60, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x03, 0x04, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00,
  0x83, 0x00, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x60,
  0x80, 0x00, 0x01, 0x82, 0x00, 0x00, 0x04, 0x18, 0x00, 0x00, 0x10, 0x60,
  0x00, 0x00, 0x41, 0x80, 0x00, 0x03, 0x06, 0x00, 0x00, 0x0C, 0x10, 0x00,
  0x00, 0x30, 0x40, 0x00, 0x00, 0x83, 0x00, 0x00, 0x02, 0x0C, 0x00, 0x00,
  0x08, 0x30, 0x00, 0x00, 0x60, 0x80, 0x00, 0x01, 0x82, 0x00, 0x00, 0x06,
  0x18, 0x00, 0x00, 0x10, 0x60, 0x00, 0x00, 0x41, 0x80, 0x00, 0x03, 0x06,
  0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x30, 0x40, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x02, 0x0C, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x06, 0x03, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0xC0,
  0x18, 0x00, 0x06, 0x00, 0x30, 0x00, 0x38, 0x00, 0x60, 0x03, 0x80, 0x00,
  0xE0, 0x3C, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x1A, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x0C, 0xC0, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x02, 0x30, 0x00, 0x00, 0x31, 0x80, 0x00, 0x01,
  0x04, 0x00, 0x00, 0x18, 0x20, 0x00, 0x00, 0x81, 0x80, 0x00, 0x0C, 0x0C,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x06, 0x03, 0x00, 0x00, 0x30, 0x18, 0x00,
  0x03, 0x00, 0x40, 0x00, 0x18, 0x02, 0x00, 0x00, 0x80, 0x18, 0x00, 0x0C,
  0x00, 0xC0, 0x00, 0x40, 0x06, 0x00, 0x06, 0x00, 0x30, 0x00, 0x20, 0x00,
  0x80, 0x03, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x01, 0x80, 0x01, 0x80,
  0x0C, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x60, 0x06, 0x00, 0x03, 0x00, 0x60,
  0x00, 0x08, 0x03, 0x00, 0x00, 0x40, 0x10, 0x00, 0x03, 0x01, 0x80, 0x00,
  0x18, 0x08, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x06, 0x04, 0x00, 0x00, 0x10,
  0x60, 0x00, 0x00, 0x82, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0x31, 0x00,
  0x00, 0x01, 0x98, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x01, 0x60, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0x60, 0x00, 0x0F, 0x00, 0x00,
  0x6C, 0x00, 0x01, 0xA0, 0x00, 0x0D, 0x80, 0x00, 0x24, 0x00, 0x03, 0x30,
  0x00, 0x0C, 0x80, 0x00, 0x62, 0x00, 0x01, 0x10, 0x00, 0x08, 0x40, 0x00,
  0x62, 0x00, 0x03, 0x08, 0x00, 0x0C, 0x40, 0x00, 0x61, 0x00, 0x01, 0x0C,
  0x00, 0x08, 0x30, 0x00, 0x61, 0x80, 0x03, 0x06, 0x00, 0x08, 0x30, 0x00,
  0x60, 0xC0, 0x03, 0x06, 0x00, 0x18, 0x18, 0x00, 0x60, 0xC0, 0x03, 0x03,
  0x00, 0x08, 0x08, 0x00, 0x40, 0x60, 0x03, 0x01, 0x00, 0x18, 0x0C, 0x00,
  0x40, 0x20, 0x03, 0x01, 0x80, 0x18, 0x04, 0x00, 0x40, 0x30, 0x03, 0x00,
  0x80, 0x18, 0x06, 0x00, 0xC0, 0x10, 0x03, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0xC0, 0x08, 0x02, 0x00, 0x60, 0x18, 0x01, 0x00, 0xC0, 0x0C, 0x02, 0x00,
  0x20, 0x18, 0x01, 0x80, 0xC0, 0x04, 0x06, 0x00, 0x30, 0x18, 0x00, 0xC0,
  0xC0, 0x06, 0x02, 0x00, 0x18, 0x10, 0x00, 0x40, 0xC0, 0x03, 0x06, 0x00,
  0x08, 0x18, 0x00, 0x60, 0xC0, 0x01, 0x06, 0x00, 0x0C, 0x30, 0x00, 0x20,
  0xC0, 0x01, 0x86, 0x00, 0x06, 0x10, 0x00, 0x30, 0x80, 0x00, 0xC6, 0x00,
  0x06, 0x30, 0x00, 0x18, 0xC0, 0x00, 0xC6, 0x00, 0x03, 0x10, 0x00, 0x19,
  0x80, 0x00, 0x66, 0x00, 0x03, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x24, 0x00,
  0x01, 0xB0, 0x00, 0x05, 0x80, 0x00, 0x36, 0x00, 0x00, 0xB0, 0x00, 0x02,
  0x80, 0x00, 0x14, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00,
  0x18, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00,
  0x30, 0x03, 0x00, 0x00, 0x04, 0x01, 0x80, 0x00, 0x01, 0x80, 0x40, 0x00,
  0x00, 0x20, 0x30, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x00, 0x43, 0x00, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x02, 0xC0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x00,
  0x8C, 0x00, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00,
  0x18, 0x08, 0x00, 0x00, 0x04, 0x03, 0x00, 0x00, 0x03, 0x00, 0x40, 0x00,
  0x01, 0x80, 0x18, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x30, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x80, 0x01, 0x80, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x18, 0x00, 0x00, 0x40, 0x0C, 0x00, 0x00, 0x18, 0x06, 0x00,
  0x00, 0x06, 0x03, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x01, 0x98, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x01, 0x86, 0x00, 0x00,
  0x0C, 0x10, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x60,
  0x10, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x60, 0x06, 0x00, 0x03, 0x00, 0x10,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x10, 0x01,
  0x80, 0x00, 0xC0, 0x18, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x10, 0x0C, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x06, 0x06, 0x00, 0x00, 0x10, 0x60, 0x00, 0x00,
  0x86, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x13, 0x00, 0x00, 0x00, 0xB0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x00, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xC0, 0x20, 0x10, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x20, 0x10, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x20, 0x10,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x20, 0x10, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0x40, 0x20, 0x10, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x40, 0x20, 0x10,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0x40, 0x20, 0x10, 0x0C, 0x06, 0x03, 0x00,
  0x7F, 0x80, 0x3F, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0F, 0x00,
  0x05, 0x80, 0x06, 0xC0, 0x02, 0x20, 0x03, 0x10, 0x01, 0x08, 0x01, 0x86,
  0x00, 0x83, 0x00, 0xC1, 0x80, 0x40, 0x40, 0x60, 0x20, 0x20, 0x10, 0x30,
  0x0C, 0x10, 0x06, 0x18, 0x03, 0x08, 0x01, 0x8C, 0x00, 0x44, 0x00, 0x26,
  0x00, 0x1A, 0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xC3, 0x86,
  0x0C, 0x30, 0x61, 0x83, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0xF0,
  0x38, 0x01, 0xC0, 0x0C, 0x03, 0x00, 0x06, 0x06, 0x00, 0x06, 0x06, 0x00,
  0x02, 0x0C, 0x00, 0x02, 0x0C, 0x00, 0x02, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x04, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xFC, 0x07, 0x00,
  0x0C, 0x1C, 0x00, 0x0C, 0x38, 0x00, 0x08, 0x30, 0x00, 0x08, 0x60, 0x00,
  0x18, 0x40, 0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00,
  0x30, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x70, 0xC0, 0x00, 0xF0, 0x40, 0x01,
  0xB0, 0x60, 0x07, 0x30, 0x38, 0x3C, 0x30, 0x1F, 0xF0, 0x30, 0x03, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x1F, 0xF0, 0x06, 0x38,
  0x18, 0x04, 0xE0, 0x0C, 0x05, 0x80, 0x06, 0x0F, 0x00, 0x06, 0x0E, 0x00,
  0x02, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x08, 0x00, 0x03, 0x08, 0x00,
  0x03, 0x18, 0x00, 0x03, 0x18, 0x00, 0x03, 0x18, 0x00, 0x03, 0x18, 0x00,
  0x03, 0x10, 0x00, 0x03, 0x10, 0x00, 0x02, 0x30, 0x00, 0x02, 0x30, 0x00,
  0x02, 0x30, 0x00, 0x06, 0x20, 0x00, 0x06, 0x20, 0x00, 0x06, 0x20, 0x00,
  0x04, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x08, 0x40, 0x00,
  0x18, 0x60, 0x00, 0x10, 0x60, 0x00, 0x30, 0xE0, 0x00, 0x60, 0xD0, 0x00,
  0x60, 0xD8, 0x01, 0xC0, 0x86, 0x07, 0x80, 0x83, 0xFE, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x02, 0x00, 0x00, 0xFF, 0xC0, 0x03, 0x81, 0xC0, 0x1C, 0x00,
  0xC0, 0x70, 0x00, 0xC0, 0xC0, 0x01, 0x83, 0x00, 0x01, 0x0C, 0x00, 0x03,
  0x18, 0x00, 0x06, 0x20, 0x00, 0x0C, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x32,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x19, 0x80, 0x00, 0x23, 0x00, 0x00, 0xC6, 0x00, 0x01, 0x04, 0x00, 0x06,
  0x0C, 0x00, 0x08, 0x18, 0x00, 0x30, 0x18, 0x01, 0xC0, 0x1C, 0x0F, 0x00,
  0x1F, 0xF8, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01,
  0x00, 0x01, 0x00, 0xC0, 0x0F, 0xF8, 0x30, 0x07, 0x03, 0x8C, 0x03, 0x00,
  0x32, 0x01, 0x80, 0x04, 0x80, 0xC0, 0x00, 0xA0, 0x20, 0x00, 0x38, 0x18,
  0x00, 0x06, 0x04, 0x00, 0x01, 0x83, 0x00, 0x00, 0x40, 0x80, 0x00, 0x10,
  0x60, 0x00, 0x04, 0x18, 0x00, 0x03, 0x06, 0x00, 0x00, 0xC1, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x08, 0x30, 0x00, 0x02, 0x0C, 0x00, 0x01, 0x83, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x18, 0x20, 0x00, 0x06, 0x08, 0x00, 0x01, 0x02,
  0x00, 0x00, 0x40, 0x80, 0x00, 0x30, 0x20, 0x00, 0x0C, 0x08, 0x00, 0x03,
  0x02, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x20, 0x30, 0x00, 0x18, 0x0C, 0x00,
  0x0E, 0x01, 0x80, 0x07, 0x80, 0x60, 0x06, 0x60, 0x0E, 0x07, 0x18, 0x01,
  0xFF, 0x04, 0x00, 0x04, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x7F, 0xC0,
  0x03, 0x81, 0xC0, 0x0C, 0x00, 0xC0, 0x30, 0x00, 0xC0, 0xC0, 0x01, 0x83,
  0x00, 0x01, 0x04, 0x00, 0x03, 0x18, 0x00, 0x06, 0x20, 0x00, 0x0C, 0xC0,
  0x00, 0x19, 0x00, 0x00, 0x36, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xDF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFE, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x18, 0x1C,
  0x00, 0xE0, 0x1E, 0x07, 0x80, 0x0F, 0xFC, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x07, 0xF0, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x20,
  0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x01, 0xFF, 0xF0, 0xFF,
  0xFC, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x03, 0xFE, 0x0C, 0x00, 0xE0, 0x71, 0x80, 0x30, 0x03,
  0x20, 0x0C, 0x00, 0x24, 0x03, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x70, 0x18,
  0x00, 0x0E, 0x06, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x10, 0x10, 0x00, 0x02,
  0x06, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x18, 0x10, 0x00, 0x03, 0x02, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x08, 0x18, 0x00, 0x01, 0x03, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x0C, 0x08, 0x00, 0x01, 0x81, 0x00, 0x00, 0x30, 0x20, 0x00,
  0x04, 0x04, 0x00, 0x00, 0x80, 0x80, 0x00, 0x30, 0x10, 0x00, 0x06, 0x02,
  0x00, 0x00, 0xC0, 0x40, 0x00, 0x18, 0x08, 0x00, 0x02, 0x01, 0x80, 0x00,
  0xC0, 0x30, 0x00, 0x38, 0x03, 0x00, 0x0F, 0x00, 0x60, 0x06, 0x60, 0x07,
  0x03, 0x8C, 0x00, 0x7F, 0xC1, 0x00, 0x00, 0x80, 0x20, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x20, 0x08, 0x00, 0x0C, 0x01, 0x80, 0x03, 0x00,
  0x38, 0x00, 0xC0, 0x03, 0x80, 0x30, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x20, 0x00, 0x00, 0xC0, 0x10, 0x01, 0x83, 0xFC, 0x03, 0x1C, 0x0C,
  0x04, 0x60, 0x0C, 0x09, 0x80, 0x0C, 0x32, 0x00, 0x18, 0x68, 0x00, 0x30,
  0xF0, 0x00, 0x21, 0xC0, 0x00, 0x43, 0x00, 0x00, 0x86, 0x00, 0x01, 0x1C,
  0x00, 0x06, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x31, 0x00,
  0x00, 0x42, 0x00, 0x00, 0x8C, 0x00, 0x03, 0x18, 0x00, 0x06, 0x30, 0x00,
  0x0C, 0x60, 0x00, 0x18, 0x80, 0x00, 0x21, 0x00, 0x00, 0x46, 0x00, 0x01,
  0x8C, 0x00, 0x03, 0x18, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x40, 0x00, 0x10,
  0x80, 0x00, 0x23, 0x00, 0x00, 0xC6, 0x00, 0x01, 0x8C, 0x00, 0x03, 0x18,
  0x00, 0x06, 0x20, 0x00, 0x08, 0x00, 0x01, 0xC0, 0x70, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x04, 0x01, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x80, 0x20,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x10, 0x04, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x02, 0x00, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x40, 0x10, 0x0C, 0x03,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x10,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0xFE,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x07, 0x06, 0x00, 0x0E, 0x04, 0x00, 0x1C, 0x04, 0x00, 0x38, 0x0C, 0x00,
  0x70, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x0C, 0x03, 0x00, 0x08, 0x06,
  0x00, 0x08, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x18, 0x30, 0x00, 0x18, 0x60,
  0x00, 0x18, 0xC0, 0x00, 0x11, 0xC0, 0x00, 0x13, 0xC0, 0x00, 0x36, 0x60,
  0x00, 0x3C, 0x60, 0x00, 0x30, 0x30, 0x00, 0x30, 0x30, 0x00, 0x20, 0x18,
  0x00, 0x20, 0x08, 0x00, 0x60, 0x0C, 0x00, 0x60, 0x04, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x02, 0x00, 0x40, 0x03, 0x00, 0x40, 0x01, 0x00, 0xC0, 0x01,
  0x80, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0xC0, 0x80, 0x00, 0x60, 0x80, 0x00,
  0x60, 0x00, 0xC0, 0x20, 0x08, 0x06, 0x01, 0x80, 0x60, 0x18, 0x04, 0x01,
  0x00, 0xC0, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x40, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x08, 0x02, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x00, 0x40, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x08,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x04, 0x01, 0x00, 0xC0, 0x30, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC1, 0xFE, 0x00, 0x7F, 0x80, 0x21,
  0xC0, 0xC0, 0x70, 0x30, 0x08, 0xC0, 0x18, 0x30, 0x06, 0x06, 0x60, 0x02,
  0x18, 0x00, 0xC1, 0xB0, 0x00, 0xCC, 0x00, 0x30, 0x68, 0x00, 0x36, 0x00,
  0x0C, 0x1C, 0x00, 0x0F, 0x00, 0x01, 0x07, 0x00, 0x01, 0x80, 0x00, 0x41,
  0x80, 0x00, 0x60, 0x00, 0x10, 0xE0, 0x00, 0x30, 0x00, 0x04, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC3, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x60, 0x00, 0x08, 0x00, 0x02,
  0x18, 0x00, 0x02, 0x00, 0x00, 0x86, 0x00, 0x01, 0x80, 0x00, 0x61, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x60, 0x00, 0x18, 0x00, 0x06, 0x10, 0x00, 0x04,
  0x00, 0x01, 0x8C, 0x00, 0x01, 0x00, 0x00, 0x43, 0x00, 0x00, 0xC0, 0x00,
  0x10, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x08,
  0x00, 0x03, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x80, 0x00, 0x31, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x60, 0x00, 0x18, 0x00, 0x02, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x86, 0x00, 0x01, 0x80, 0x00, 0x61, 0x00, 0x00, 0x60, 0x00, 0x18,
  0x40, 0x00, 0x10, 0x00, 0x06, 0x30, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x80, 0x0C, 0x1F, 0xE0, 0x18, 0x60, 0x60, 0x23, 0x80, 0x60, 0x4C,
  0x00, 0x61, 0x90, 0x00, 0xC3, 0x40, 0x01, 0x87, 0x80, 0x01, 0x0E, 0x00,
  0x02, 0x1C, 0x00, 0x04, 0x30, 0x00, 0x08, 0xE0, 0x00, 0x31, 0x80, 0x00,
  0x63, 0x00, 0x00, 0xC6, 0x00, 0x01, 0x88, 0x00, 0x02, 0x10, 0x00, 0x04,
  0x60, 0x00, 0x08, 0xC0, 0x00, 0x31, 0x80, 0x00, 0x63, 0x00, 0x00, 0xC4,
  0x00, 0x01, 0x08, 0x00, 0x02, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x18, 0xC0,
  0x00, 0x31, 0x80, 0x00, 0x62, 0x00, 0x00, 0x84, 0x00, 0x01, 0x18, 0x00,
  0x06, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x31, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0xF0, 0x38, 0x01, 0xC0,
  0x1C, 0x03, 0x00, 0x0E, 0x06, 0x00, 0x06, 0x06, 0x00, 0x02, 0x0C, 0x00,
  0x03, 0x08, 0x00, 0x03, 0x18, 0x00, 0x03, 0x10, 0x00, 0x03, 0x30, 0x00,
  0x03, 0x30, 0x00, 0x03, 0x20, 0x00, 0x03, 0x20, 0x00, 0x03, 0x60, 0x00,
  0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x02, 0x40, 0x00, 0x02, 0x40, 0x00,
  0x06, 0x40, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x04, 0xC0, 0x00,
  0x0C, 0xC0, 0x00, 0x0C, 0x40, 0x00, 0x08, 0x40, 0x00, 0x18, 0x60, 0x00,
  0x30, 0x60, 0x00, 0x30, 0x60, 0x00, 0x60, 0x30, 0x00, 0xC0, 0x18, 0x01,
  0x80, 0x0E, 0x07, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x18, 0x7F, 0xC0, 0x03, 0x1C, 0x0C, 0x00, 0x4E, 0x00, 0xC0,
  0x0B, 0x00, 0x0C, 0x03, 0xC0, 0x00, 0x80, 0x70, 0x00, 0x10, 0x0C, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x60, 0x20, 0x00, 0x0C, 0x04, 0x00, 0x01, 0x81,
  0x80, 0x00, 0x30, 0x30, 0x00, 0x06, 0x06, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x18, 0x10, 0x00, 0x03, 0x02, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x08, 0x18,
  0x00, 0x01, 0x03, 0x00, 0x00, 0x60, 0x60, 0x00, 0x0C, 0x08, 0x00, 0x01,
  0x81, 0x00, 0x00, 0x20, 0x60, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x20, 0x30, 0x00, 0x0C, 0x06, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x60,
  0x38, 0x00, 0x18, 0x06, 0x80, 0x03, 0x00, 0xDC, 0x01, 0xC0, 0x11, 0xE0,
  0xF0, 0x02, 0x0F, 0xF8, 0x00, 0x40, 0x10, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x83, 0x01, 0xC0, 0xE3, 0x03, 0x00,
  0x32, 0x06, 0x00, 0x12, 0x0C, 0x00, 0x0A, 0x18, 0x00, 0x0E, 0x18, 0x00,
  0x06, 0x30, 0x00, 0x06, 0x30, 0x00, 0x04, 0x20, 0x00, 0x04, 0x60, 0x00,
  0x0C, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0x40, 0x00, 0x0C, 0xC0, 0x00,
  0x08, 0xC0, 0x00, 0x08, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00,
  0x18, 0x80, 0x00, 0x18, 0x80, 0x00, 0x10, 0x80, 0x00, 0x10, 0x80, 0x00,
  0x30, 0x80, 0x00, 0x30, 0x80, 0x00, 0x30, 0x80, 0x00, 0x30, 0x80, 0x00,
  0x20, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0xE0, 0x60, 0x01, 0xE0, 0x60, 0x07,
  0x60, 0x38, 0x1C, 0x40, 0x1F, 0xF0, 0x40, 0x01, 0x00, 0x40, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x01, 0x87, 0xE0, 0x63, 0x00, 0x11, 0x80, 0x04, 0x80, 0x03, 0x40, 0x00,
  0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x03, 0x81, 0xC0,
  0x1C, 0x00, 0xC0, 0x30, 0x00, 0xC0, 0xC0, 0x00, 0x83, 0x00, 0x01, 0x86,
  0x00, 0x03, 0x08, 0x00, 0x06, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x23, 0x00, 0x00, 0xC6, 0x00, 0x01, 0x8C,
  0x00, 0x02, 0x08, 0x00, 0x0C, 0x18, 0x00, 0x30, 0x18, 0x00, 0xC0, 0x1C,
  0x0F, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x07, 0xFF,
  0xFF, 0xFC, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0x40, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x02, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x08,
  0x00, 0x60, 0x01, 0xF8, 0x02, 0x00, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x03,
  0x08, 0x00, 0x02, 0x08, 0x00, 0x02, 0x18, 0x00, 0x06, 0x18, 0x00, 0x06,
  0x18, 0x00, 0x06, 0x10, 0x00, 0x06, 0x10, 0x00, 0x04, 0x10, 0x00, 0x04,
  0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x20, 0x00, 0x0C,
  0x20, 0x00, 0x08, 0x20, 0x00, 0x08, 0x60, 0x00, 0x18, 0x60, 0x00, 0x18,
  0x60, 0x00, 0x18, 0x40, 0x00, 0x18, 0x40, 0x00, 0x10, 0xC0, 0x00, 0x10,
  0xC0, 0x00, 0x30, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x70,
  0xC0, 0x00, 0x60, 0xC0, 0x00, 0xA0, 0x40, 0x01, 0xE0, 0x60, 0x03, 0x60,
  0x30, 0x06, 0x60, 0x38, 0x1C, 0x40, 0x1F, 0xF0, 0x40, 0x01, 0x00, 0x00,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xB0, 0x00, 0x06, 0x40,
  0x00, 0x31, 0x00, 0x00, 0xC6, 0x00, 0x02, 0x18, 0x00, 0x18, 0x60, 0x00,
  0x41, 0x80, 0x03, 0x02, 0x00, 0x08, 0x08, 0x00, 0x60, 0x30, 0x01, 0x00,
  0xC0, 0x0C, 0x03, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x10, 0x06, 0x00, 0x40,
  0x30, 0x01, 0x80, 0xC0, 0x06, 0x06, 0x00, 0x18, 0x18, 0x00, 0x60, 0xC0,
  0x00, 0x83, 0x00, 0x02, 0x08, 0x00, 0x08, 0x60, 0x00, 0x31, 0x00, 0x00,
  0xCC, 0x00, 0x03, 0x20, 0x00, 0x05, 0x80, 0x00, 0x14, 0x00, 0x00, 0x70,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xF0,
  0x00, 0x30, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0B, 0x00, 0x07, 0x00, 0x06,
  0xC0, 0x01, 0x40, 0x01, 0xB0, 0x00, 0xD8, 0x00, 0xCC, 0x00, 0x26, 0x00,
  0x31, 0x00, 0x19, 0x80, 0x08, 0x40, 0x06, 0x60, 0x06, 0x10, 0x03, 0x18,
  0x01, 0x84, 0x00, 0xC6, 0x00, 0xC1, 0x80, 0x61, 0x80, 0x30, 0x60, 0x18,
  0x60, 0x18, 0x18, 0x04, 0x08, 0x06, 0x06, 0x03, 0x02, 0x01, 0x81, 0x80,
  0x80, 0x80, 0xC0, 0x60, 0x60, 0x20, 0x30, 0x18, 0x18, 0x0C, 0x18, 0x06,
  0x0C, 0x03, 0x06, 0x01, 0x83, 0x00, 0xC1, 0x00, 0x60, 0x80, 0x30, 0xC0,
  0x08, 0x60, 0x0C, 0x30, 0x02, 0x10, 0x03, 0x18, 0x00, 0x8C, 0x00, 0x46,
  0x00, 0x22, 0x00, 0x11, 0x00, 0x09, 0x80, 0x04, 0xC0, 0x02, 0x60, 0x01,
  0x30, 0x00, 0x90, 0x00, 0x48, 0x00, 0x3C, 0x00, 0x16, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0x18,
  0x00, 0x18, 0x06, 0x00, 0x0C, 0x00, 0x80, 0x06, 0x00, 0x30, 0x03, 0x00,
  0x0C, 0x00, 0xC0, 0x01, 0x80, 0x60, 0x00, 0x60, 0x30, 0x00, 0x0C, 0x08,
  0x00, 0x03, 0x06, 0x00, 0x00, 0x43, 0x00, 0x00, 0x19, 0x80, 0x00, 0x02,
  0x40, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xA0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x61, 0x00,
  0x00, 0x10, 0x60, 0x00, 0x0C, 0x18, 0x00, 0x06, 0x03, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x80, 0x18, 0x00, 0x60, 0x06, 0x00, 0x30, 0x00, 0x80, 0x18,
  0x00, 0x30, 0x06, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x81, 0x80, 0x00, 0x60,
  0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x08, 0x06, 0x00, 0x00, 0x60,
  0x18, 0x00, 0x01, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x80, 0x00, 0x20, 0x03,
  0x00, 0x01, 0x80, 0x0C, 0x00, 0x06, 0x00, 0x30, 0x00, 0x30, 0x00, 0xC0,
  0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x04, 0x00, 0x18, 0x00, 0x18, 0x00,
  0xC0, 0x00, 0x60, 0x03, 0x00, 0x01, 0x80, 0x18, 0x00, 0x06, 0x00, 0x60,
  0x00, 0x08, 0x03, 0x00, 0x00, 0x20, 0x0C, 0x00, 0x00, 0x80, 0x60, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x01, 0x06, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0x10,
  0xC0, 0x00, 0x00, 0x62, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x06, 0x40,
  0x00, 0x00, 0x0B, 0x00, 0x00, 0x00, 0x28, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x5E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x20, 0x00, 0x0E, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01,
  0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00,
  0x00, 0x20, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x10, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x10,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x02, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x10, 0x0C, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x80,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x08, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x01, 0x18, 0x18, 0x00, 0x33, 0x00, 0xC0, 0x03, 0x60, 0x06,
  0x00, 0x26, 0x00, 0x30, 0x06, 0xC0, 0x03, 0x00, 0xCC, 0x00, 0x18, 0x18,
  0xC0, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xE0,
};

const GFXglyph RobotoCondensed_ThinItalic62pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 10, 45, 11, 1, -44 },
  { 58, 10, 12, 16, 7, -47 },
  { 73, 31, 44, 29, 1, -44 },
  { 244, 26, 58, 29, 2, -51 },
  { 433, 29, 46, 39, 6, -45 },
  { 600, 27, 46, 32, 2, -45 },
  { 756, 4, 13, 10, 6, -47 },
  { 763, 17, 63, 16, 3, -49 },
  { 897, 17, 63, 17, -4, -49 },
  { 1031, 23, 24, 25, 4, -44 },
  { 1100, 25, 31, 30, 3, -36 },
  { 1197, 7, 12, 11, -2, -5 },
  { 1208, 12, 2, 16, 2, -21 },
  { 1211, 4, 4, 13, 1, -3 },
  { 1213, 25, 48, 21, -2, -44 },
  { 1363, 24, 46, 29, 3, -45 },
  { 1501, 13, 44, 29, 9, -44 },
  { 1573, 25, 45, 29, 2, -45 },
  { 1714, 26, 46, 29, 2, -45 },
  { 1864, 26, 44, 29, 1, -44 },
  { 2007, 26, 45, 29, 4, -44 },
  { 2154, 23, 45, 29, 3, -44 },
  { 2284, 25, 44, 29, 5, -44 },
  { 2422, 27, 46, 29, 1, -45 },
  { 2578, 23, 45, 29, 4, -45 },
  { 2708, 9, 33, 11, 1, -32 },
  { 2746, 11, 39, 11, -2, -32 },
  { 2800, 23, 24, 27, 3, -32 },
  { 2869, 24, 15, 30, 3, -28 },
  { 2914, 23, 24, 27, 2, -32 },
  { 2983, 18, 46, 23, 6, -45 },
  { 3087, 43, 57, 48, 2, -43 },
  { 3394, 29, 44, 32, -2, -44 },
  { 3554, 28, 44, 32, 2, -44 },
  { 3708, 29, 46, 34, 4, -45 },
  { 3875, 30, 44, 34, 2, -44 },
  { 4040, 30, 44, 30, 2, -44 },
  { 4205, 30, 44, 30, 2, -44 },
  { 4370, 30, 46, 36, 4, -45 },
  { 4543, 34, 44, 37, 2, -44 },
  { 4730, 10, 44, 14, 3, -44 },
  { 4785, 27, 45, 29, 1, -44 },
  { 4937, 33, 44, 33, 2, -44 },
  { 5119, 21, 44, 28, 2, -44 },
  { 5235, 42, 44, 45, 2, -44 },
  { 5466, 34, 44, 37, 2, -44 },
  { 5653, 30, 46, 35, 3, -45 },
  { 5826, 30, 44, 32, 2, -44 },
  { 5991, 30, 53, 35, 3, -45 },
  { 6190, 30, 44, 34, 2, -44 },
  { 6355, 30, 46, 31, 1, -45 },
  { 6528, 28, 44, 32, 6, -44 },
  { 6682, 30, 45, 35, 4, -44 },
  { 6851, 29, 44, 32, 5, -44 },
  { 7011, 43, 44, 47, 6, -44 },
  { 7248, 34, 44, 32, -1, -44 },
  { 7435, 29, 44, 32, 6, -44 },
  { 7595, 32, 44, 32, 0, -44 },
  { 7771, 16, 59, 12, 1, -50 },
  { 7889, 9, 48, 20, 6, -44 },
  { 7943, 17, 59, 12, -4, -50 },
  { 8069, 17, 22, 22, 3, -44 },
  { 8116, 22, 2, 22, -3, 0 },
  { 8122, 6, 8, 16, 9, -46 },
  { 8128, 24, 35, 28, 1, -34 },
  { 8233, 24, 48, 29, 2, -47 },
  { 8377, 23, 35, 27, 2, -34 },
  { 8478, 26, 48, 29, 3, -47 },
  { 8634, 23, 35, 27, 2, -34 },
  { 8735, 18, 48, 17, 4, -48 },
  { 8843, 27, 47, 29, 0, -34 },
  { 9002, 23, 47, 29, 2, -47 },
  { 9138, 10, 45, 12, 2, -45 },
  { 9195, 20, 58, 12, -8, -45 },
  { 9340, 24, 47, 25, 2, -47 },
  { 9481, 10, 47, 12, 2, -47 },
  { 9540, 42, 34, 47, 1, -34 },
  { 9719, 23, 34, 29, 2, -34 },
  { 9817, 24, 35, 29, 2, -34 },
  { 9922, 27, 47, 29, -1, -34 },
  { 10081, 24, 47, 29, 3, -34 },
  { 10222, 18, 34, 18, 2, -34 },
  { 10299, 23, 35, 27, 1, -34 },
  { 10400, 13, 43, 17, 4, -42 },
  { 10470, 24, 34, 29, 3, -33 },
  { 10572, 22, 33, 26, 4, -33 },
  { 10663, 34, 33, 40, 5, -33 },
  { 10804, 26, 33, 26, -1, -33 },
  { 10912, 30, 46, 25, -3, -33 },
  { 11085, 25, 33, 26, 0, -33 },
  { 11189, 20, 61, 18, 2, -48 },
  { 11342, 10, 52, 12, 1, -44 },
  { 11407, 19, 61, 18, -4, -48 },
  { 11552, 28, 10, 36, 4, -23 },
};

const GFXfont RobotoCondensed_ThinItalic62pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ThinItalic62pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ThinItalic62pt7bGlyphs,
  0x20, 0x7E, 73
};

#endif // _ROBOTOCONDENSED_THINITALIC62PT7B_H_
