#ifndef _ROBOTOCONDENSED_THINITALIC45PT7B_H_
#define _ROBOTOCONDENSED_THINITALIC45PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ThinItalic.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ThinItalic45pt7bBitmaps[] PROGMEM = {
  0x00, 0x02, 0x0C, 0x10, 0x20, 0x40, 0x81, 0x06, 0x08, 0x10, 0x20, 0x40,
  0x82, 0x04, 0x08, 0x10, 0x20, 0xC1, 0x02, 0x04, 0x08, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x60, 0x62, 0xC5, 0x1A, 0x34, 0x48, 0xB1, 0x42,
  0x8C, 0x00, 0x08, 0x18, 0x00, 0x60, 0x40, 0x01, 0x01, 0x00, 0x04, 0x0C,
  0x00, 0x30, 0x20, 0x00, 0x80, 0x80, 0x02, 0x06, 0x00, 0x08, 0x10, 0x00,
  0x40, 0x40, 0x7F, 0xFF, 0xF0, 0x04, 0x08, 0x00, 0x20, 0x20, 0x00, 0x81,
  0x80, 0x02, 0x04, 0x00, 0x10, 0x10, 0x00, 0x40, 0x40, 0x01, 0x02, 0x00,
  0x08, 0x08, 0x00, 0x20, 0x20, 0x00, 0x81, 0x00, 0x06, 0x04, 0x00, 0x10,
  0x10, 0x0F, 0xFF, 0xFE, 0x03, 0x02, 0x00, 0x08, 0x08, 0x00, 0x20, 0x40,
  0x01, 0x81, 0x00, 0x04, 0x04, 0x00, 0x10, 0x30, 0x00, 0xC0, 0x80, 0x02,
  0x02, 0x00, 0x08, 0x18, 0x00, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x60, 0x00, 0x7E, 0x00, 0x60, 0xC0, 0x30, 0x18, 0x10, 0x02, 0x0C,
  0x00, 0xC2, 0x00, 0x11, 0x80, 0x04, 0x40, 0x01, 0x10, 0x00, 0x44, 0x00,
  0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x02, 0x00, 0x00, 0xC0, 0x00, 0x12, 0x00, 0x04, 0x80, 0x03, 0x20, 0x00,
  0x88, 0x00, 0x22, 0x00, 0x18, 0x40, 0x0C, 0x18, 0x06, 0x03, 0x83, 0x00,
  0x3F, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x0F,
  0x80, 0x00, 0xC6, 0x00, 0x0C, 0x10, 0x00, 0x40, 0x80, 0x04, 0x06, 0x02,
  0x20, 0x10, 0x11, 0x01, 0x81, 0x18, 0x08, 0x10, 0x80, 0x41, 0x84, 0x02,
  0x08, 0x20, 0x30, 0x81, 0x81, 0x0C, 0x04, 0x18, 0x40, 0x31, 0x84, 0x00,
  0xF0, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x02, 0x0F, 0x00, 0x30,
  0x84, 0x01, 0x08, 0x30, 0x10, 0x80, 0x81, 0x04, 0x04, 0x18, 0x60, 0x20,
  0x82, 0x01, 0x08, 0x10, 0x08, 0xC0, 0x80, 0x44, 0x04, 0x04, 0x40, 0x20,
  0x20, 0x01, 0x03, 0x00, 0x08, 0x10, 0x00, 0x23, 0x00, 0x00, 0xF0, 0x00,
  0x3E, 0x00, 0x06, 0x30, 0x00, 0x81, 0x00, 0x10, 0x18, 0x01, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x01, 0x80, 0x20, 0x10, 0x02, 0x03, 0x00, 0x20, 0x60,
  0x02, 0x0C, 0x00, 0x31, 0x80, 0x01, 0x30, 0x00, 0x1C, 0x00, 0x00, 0x80,
  0x00, 0x3C, 0x00, 0x06, 0x40, 0x00, 0xC6, 0x00, 0x18, 0x20, 0x11, 0x01,
  0x01, 0x20, 0x18, 0x36, 0x00, 0x82, 0x40, 0x0C, 0x24, 0x00, 0x44, 0x40,
  0x06, 0x4C, 0x00, 0x28, 0x40, 0x01, 0x84, 0x00, 0x38, 0x60, 0x06, 0x82,
  0x00, 0xCC, 0x18, 0x30, 0x40, 0xFC, 0x06, 0x49, 0x2D, 0xA4, 0x80, 0x00,
  0x10, 0x03, 0x00, 0x60, 0x04, 0x00, 0x80, 0x10, 0x03, 0x00, 0x20, 0x06,
  0x00, 0x40, 0x0C, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x01, 0x00, 0x30,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0xC0, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x20,
  0x02, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x30, 0x01, 0x00, 0x08, 0x00, 0x40, 0x06, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x80, 0x04, 0x00, 0x60, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00,
  0x80, 0x0C, 0x00, 0x40, 0x04, 0x00, 0x40, 0x06, 0x00, 0x40, 0x00, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x07,
  0x82, 0x0E, 0x71, 0x38, 0x07, 0xE0, 0x00, 0xC0, 0x00, 0xA0, 0x00, 0x88,
  0x00, 0xC6, 0x00, 0xC1, 0x00, 0xC0, 0xC0, 0xC0, 0x20, 0x40, 0x18, 0x00,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C,
  0x03, 0xFF, 0xFF, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x30, 0x00, 0x11, 0x13, 0x32, 0x6C, 0x80, 0xFF, 0xF8, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01,
  0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18,
  0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x70, 0xC0, 0x30, 0x10, 0x18, 0x02, 0x04, 0x00, 0x82, 0x00,
  0x30, 0x80, 0x04, 0x40, 0x01, 0x10, 0x00, 0x44, 0x00, 0x12, 0x00, 0x04,
  0x80, 0x01, 0x20, 0x00, 0xC8, 0x00, 0x26, 0x00, 0x09, 0x00, 0x02, 0x40,
  0x00, 0x90, 0x00, 0x24, 0x00, 0x1B, 0x00, 0x04, 0xC0, 0x01, 0x20, 0x00,
  0x48, 0x00, 0x32, 0x00, 0x08, 0x80, 0x02, 0x30, 0x01, 0x84, 0x00, 0x41,
  0x00, 0x20, 0x40, 0x18, 0x08, 0x0C, 0x03, 0x06, 0x00, 0x3E, 0x00, 0x00,
  0xC0, 0xE1, 0xC9, 0xC2, 0x80, 0x80, 0x20, 0x18, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x03, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x30, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x06,
  0x01, 0x00, 0x40, 0x00, 0x7E, 0x00, 0x38, 0x60, 0x0C, 0x02, 0x03, 0x00,
  0x60, 0x40, 0x04, 0x18, 0x00, 0x82, 0x00, 0x10, 0xC0, 0x02, 0x10, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x10, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3E, 0x00, 0x18, 0x30,
  0x04, 0x03, 0x01, 0x00, 0x20, 0x40, 0x06, 0x08, 0x00, 0x42, 0x00, 0x08,
  0x40, 0x01, 0x18, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x0F, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x26, 0x00, 0x04, 0xC0, 0x01, 0x98, 0x00, 0x21, 0x00, 0x04, 0x20,
  0x01, 0x06, 0x00, 0x60, 0x60, 0x18, 0x07, 0x0E, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0x40, 0x00, 0x68, 0x00,
  0x09, 0x00, 0x02, 0x20, 0x00, 0x8C, 0x00, 0x31, 0x00, 0x04, 0x20, 0x01,
  0x04, 0x00, 0x60, 0x80, 0x18, 0x10, 0x02, 0x06, 0x00, 0x80, 0x80, 0x30,
  0x10, 0x04, 0x02, 0x01, 0x00, 0x40, 0x40, 0x08, 0x18, 0x03, 0x02, 0x00,
  0x40, 0x80, 0x08, 0x3F, 0xFF, 0xF8, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01,
  0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0xC0, 0x03, 0xFF, 0xE0, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x3F, 0x00, 0x3C, 0x30,
  0x0C, 0x01, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x0C,
  0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x84, 0x00, 0x10,
  0x80, 0x02, 0x10, 0x00, 0xC2, 0x00, 0x10, 0x60, 0x06, 0x04, 0x00, 0x80,
  0xC0, 0x20, 0x0C, 0x18, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x1C, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x1F, 0x02, 0x30, 0xC1, 0x60,
  0x11, 0xE0, 0x0C, 0xA0, 0x02, 0x60, 0x01, 0x20, 0x00, 0x90, 0x00, 0x68,
  0x00, 0x3C, 0x00, 0x14, 0x00, 0x0A, 0x00, 0x05, 0x00, 0x02, 0x80, 0x03,
  0x60, 0x01, 0x10, 0x01, 0x88, 0x00, 0x86, 0x00, 0xC1, 0x80, 0xC0, 0x61,
  0xC0, 0x1F, 0x80, 0x7F, 0xFF, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04,
  0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06,
  0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x0C, 0x18, 0x01, 0x80, 0xC0, 0x20,
  0x06, 0x06, 0x00, 0x20, 0x40, 0x02, 0x08, 0x00, 0x20, 0x80, 0x02, 0x08,
  0x00, 0x20, 0x80, 0x02, 0x08, 0x00, 0x40, 0x80, 0x04, 0x0C, 0x00, 0x80,
  0x60, 0x30, 0x03, 0x0E, 0x00, 0x1F, 0x80, 0x06, 0x06, 0x00, 0x80, 0x30,
  0x10, 0x01, 0x02, 0x00, 0x08, 0x60, 0x00, 0x84, 0x00, 0x08, 0x40, 0x00,
  0x88, 0x00, 0x08, 0x80, 0x00, 0x88, 0x00, 0x18, 0xC0, 0x01, 0x04, 0x00,
  0x30, 0x40, 0x06, 0x02, 0x00, 0xC0, 0x18, 0x38, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x01, 0x86, 0x03, 0x00, 0x81, 0x00, 0x61, 0x00, 0x11, 0x80, 0x08,
  0x80, 0x06, 0xC0, 0x03, 0x40, 0x00, 0xA0, 0x00, 0xD0, 0x00, 0x78, 0x00,
  0x38, 0x00, 0x14, 0x00, 0x0A, 0x00, 0x05, 0x80, 0x06, 0x40, 0x03, 0x20,
  0x03, 0x98, 0x02, 0x84, 0x02, 0x41, 0x86, 0x20, 0x7E, 0x20, 0x00, 0x10,
  0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x0C, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0C, 0x18, 0x00, 0x07, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x10, 0x10, 0x30, 0x30, 0x20, 0x60, 0x40, 0xC0, 0x80, 0x00, 0x00, 0x80,
  0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x04, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x10, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x40, 0x00, 0x00, 0x07,
  0xC0, 0x61, 0x84, 0x04, 0x40, 0x16, 0x00, 0xA0, 0x07, 0x00, 0x30, 0x01,
  0x00, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x02, 0x00, 0x20, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x01, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x0C, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0x81, 0xE0, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0xC0, 0x00, 0x04, 0x00, 0x80, 0x00, 0x06, 0x01, 0x00, 0x00, 0x02, 0x03,
  0x00, 0x00, 0x02, 0x06, 0x00, 0x78, 0x02, 0x04, 0x01, 0x84, 0x03, 0x0C,
  0x02, 0x02, 0x01, 0x08, 0x04, 0x02, 0x01, 0x18, 0x0C, 0x02, 0x01, 0x10,
  0x08, 0x06, 0x01, 0x10, 0x10, 0x04, 0x01, 0x30, 0x10, 0x04, 0x03, 0x20,
  0x30, 0x04, 0x02, 0x20, 0x20, 0x0C, 0x02, 0x60, 0x20, 0x08, 0x02, 0x40,
  0x60, 0x08, 0x02, 0x40, 0x40, 0x08, 0x06, 0x40, 0x40, 0x18, 0x04, 0x40,
  0x40, 0x10, 0x04, 0x40, 0x40, 0x10, 0x0C, 0x40, 0x40, 0x30, 0x08, 0x40,
  0x40, 0x70, 0x18, 0x40, 0x40, 0x50, 0x10, 0x40, 0x40, 0x90, 0x20, 0x40,
  0x63, 0x08, 0xC0, 0x40, 0x3E, 0x0F, 0x80, 0x40, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x40, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x14, 0x00, 0x00, 0xA0, 0x00, 0x0D, 0x00, 0x00, 0x48,
  0x00, 0x06, 0x40, 0x00, 0x22, 0x00, 0x03, 0x10, 0x00, 0x10, 0xC0, 0x00,
  0x82, 0x00, 0x08, 0x10, 0x00, 0x40, 0x80, 0x04, 0x04, 0x00, 0x20, 0x20,
  0x02, 0x01, 0x00, 0x10, 0x0C, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x80,
  0x08, 0x04, 0x00, 0x40, 0x40, 0x02, 0x03, 0xFF, 0xF0, 0x20, 0x00, 0xC1,
  0x00, 0x06, 0x18, 0x00, 0x10, 0x80, 0x00, 0x8C, 0x00, 0x04, 0x40, 0x00,
  0x26, 0x00, 0x01, 0x20, 0x00, 0x0B, 0x00, 0x00, 0x70, 0x00, 0x03, 0x07,
  0xFE, 0x00, 0x40, 0x18, 0x04, 0x00, 0x40, 0x40, 0x02, 0x0C, 0x00, 0x20,
  0x80, 0x03, 0x08, 0x00, 0x30, 0x80, 0x03, 0x08, 0x00, 0x20, 0x80, 0x02,
  0x18, 0x00, 0x21, 0x00, 0x04, 0x10, 0x00, 0xC1, 0x00, 0x18, 0x10, 0x06,
  0x01, 0xFF, 0xC0, 0x30, 0x03, 0x02, 0x00, 0x18, 0x20, 0x00, 0x82, 0x00,
  0x04, 0x20, 0x00, 0x42, 0x00, 0x04, 0x60, 0x00, 0x44, 0x00, 0x04, 0x40,
  0x00, 0x44, 0x00, 0x08, 0x40, 0x00, 0x84, 0x00, 0x10, 0x80, 0x03, 0x08,
  0x00, 0x60, 0x80, 0x1C, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x0E, 0x0E,
  0x00, 0xC0, 0x18, 0x0C, 0x00, 0x60, 0xC0, 0x01, 0x04, 0x00, 0x08, 0x40,
  0x00, 0x42, 0x00, 0x03, 0x20, 0x00, 0x19, 0x00, 0x00, 0xC8, 0x00, 0x00,
  0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x01, 0x10, 0x00, 0x08, 0x80, 0x00,
  0xC4, 0x00, 0x04, 0x20, 0x00, 0x60, 0x80, 0x02, 0x04, 0x00, 0x20, 0x10,
  0x02, 0x00, 0x60, 0xE0, 0x01, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x10, 0x07,
  0x00, 0x40, 0x06, 0x01, 0x00, 0x0C, 0x0C, 0x00, 0x10, 0x20, 0x00, 0x60,
  0x80, 0x00, 0x82, 0x00, 0x02, 0x08, 0x00, 0x08, 0x20, 0x00, 0x21, 0x80,
  0x00, 0x84, 0x00, 0x02, 0x10, 0x00, 0x08, 0x40, 0x00, 0x21, 0x00, 0x00,
  0x84, 0x00, 0x06, 0x30, 0x00, 0x10, 0x80, 0x00, 0x42, 0x00, 0x01, 0x08,
  0x00, 0x04, 0x20, 0x00, 0x10, 0x80, 0x00, 0x86, 0x00, 0x02, 0x10, 0x00,
  0x08, 0x40, 0x00, 0x41, 0x00, 0x03, 0x04, 0x00, 0x08, 0x10, 0x00, 0x40,
  0x80, 0x03, 0x02, 0x00, 0x30, 0x08, 0x03, 0x80, 0x3F, 0xF8, 0x00, 0x07,
  0xFF, 0xF8, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x03, 0xFF, 0xF0, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x07,
  0xFF, 0xF8, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x30, 0x00, 0x00, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x03, 0x83, 0x80, 0x10, 0x03, 0x00,
  0x80, 0x04, 0x04, 0x00, 0x18, 0x20, 0x00, 0x20, 0x80, 0x00, 0x84, 0x00,
  0x02, 0x10, 0x00, 0x08, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x00, 0x00, 0x04, 0x01, 0xFF, 0x30, 0x00, 0x0C, 0x80, 0x00,
  0x22, 0x00, 0x00, 0x88, 0x00, 0x02, 0x20, 0x00, 0x08, 0x80, 0x00, 0x63,
  0x00, 0x01, 0x04, 0x00, 0x04, 0x10, 0x00, 0x10, 0x20, 0x00, 0xC0, 0xC0,
  0x0E, 0x01, 0xC1, 0xE0, 0x01, 0xFC, 0x00, 0x04, 0x00, 0x01, 0x04, 0x00,
  0x01, 0x04, 0x00, 0x03, 0x04, 0x00, 0x02, 0x0C, 0x00, 0x02, 0x08, 0x00,
  0x02, 0x08, 0x00, 0x02, 0x08, 0x00, 0x02, 0x08, 0x00, 0x06, 0x08, 0x00,
  0x04, 0x18, 0x00, 0x04, 0x10, 0x00, 0x04, 0x10, 0x00, 0x04, 0x10, 0x00,
  0x04, 0x10, 0x00, 0x0C, 0x1F, 0xFF, 0xF8, 0x30, 0x00, 0x08, 0x20, 0x00,
  0x08, 0x20, 0x00, 0x08, 0x20, 0x00, 0x08, 0x20, 0x00, 0x18, 0x20, 0x00,
  0x10, 0x60, 0x00, 0x10, 0x40, 0x00, 0x10, 0x40, 0x00, 0x10, 0x40, 0x00,
  0x10, 0x40, 0x00, 0x30, 0x40, 0x00, 0x20, 0x80, 0x00, 0x20, 0x80, 0x00,
  0x20, 0x80, 0x00, 0x20, 0x80, 0x00, 0x20, 0x02, 0x04, 0x18, 0x20, 0x40,
  0x81, 0x02, 0x0C, 0x10, 0x20, 0x40, 0x81, 0x06, 0x08, 0x10, 0x20, 0x40,
  0x83, 0x04, 0x08, 0x10, 0x20, 0xC1, 0x82, 0x04, 0x08, 0x10, 0x60, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00,
  0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x08, 0x00, 0x20, 0x80,
  0x02, 0x08, 0x00, 0x60, 0x80, 0x04, 0x0C, 0x00, 0xC0, 0x40, 0x08, 0x06,
  0x01, 0x00, 0x30, 0x60, 0x00, 0xF8, 0x00, 0x04, 0x00, 0x06, 0x08, 0x00,
  0x18, 0x10, 0x00, 0x60, 0x20, 0x01, 0x80, 0xC0, 0x06, 0x01, 0x00, 0x18,
  0x02, 0x00, 0x60, 0x04, 0x01, 0x80, 0x08, 0x06, 0x00, 0x10, 0x18, 0x00,
  0x60, 0x60, 0x00, 0x81, 0x80, 0x01, 0x06, 0x00, 0x02, 0x18, 0x00, 0x04,
  0x60, 0x00, 0x09, 0xC0, 0x00, 0x36, 0x40, 0x00, 0x50, 0xC0, 0x00, 0xC0,
  0x80, 0x01, 0x01, 0x80, 0x02, 0x01, 0x00, 0x04, 0x03, 0x00, 0x18, 0x02,
  0x00, 0x20, 0x06, 0x00, 0x40, 0x04, 0x00, 0x80, 0x0C, 0x01, 0x00, 0x08,
  0x02, 0x00, 0x08, 0x08, 0x00, 0x18, 0x10, 0x00, 0x10, 0x20, 0x00, 0x30,
  0x40, 0x00, 0x20, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x7F, 0xFE, 0x06, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x70, 0x60,
  0x00, 0x01, 0x81, 0x80, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x28, 0x24, 0x00,
  0x01, 0xA0, 0x90, 0x00, 0x04, 0x82, 0x40, 0x00, 0x26, 0x09, 0x00, 0x00,
  0x90, 0x26, 0x00, 0x04, 0x41, 0x88, 0x00, 0x11, 0x04, 0x20, 0x00, 0x84,
  0x10, 0x80, 0x02, 0x10, 0x42, 0x00, 0x10, 0xC1, 0x08, 0x00, 0x42, 0x04,
  0x10, 0x02, 0x08, 0x30, 0x40, 0x18, 0x20, 0x81, 0x00, 0x40, 0x82, 0x04,
  0x03, 0x02, 0x08, 0x10, 0x08, 0x18, 0x20, 0x60, 0x60, 0x40, 0x80, 0x81,
  0x01, 0x06, 0x02, 0x0C, 0x04, 0x10, 0x08, 0x20, 0x10, 0x40, 0x21, 0x00,
  0xC1, 0x00, 0x84, 0x03, 0x04, 0x01, 0x20, 0x08, 0x10, 0x04, 0x80, 0x20,
  0xC0, 0x14, 0x00, 0x82, 0x00, 0x50, 0x02, 0x08, 0x01, 0x80, 0x18, 0x20,
  0x02, 0x00, 0x40, 0x06, 0x00, 0x01, 0x06, 0x00, 0x01, 0x06, 0x00, 0x01,
  0x05, 0x00, 0x03, 0x0D, 0x00, 0x03, 0x0D, 0x80, 0x02, 0x08, 0x80, 0x02,
  0x08, 0x80, 0x02, 0x08, 0x40, 0x02, 0x08, 0x40, 0x06, 0x18, 0x40, 0x06,
  0x18, 0x20, 0x04, 0x10, 0x20, 0x04, 0x10, 0x30, 0x04, 0x10, 0x10, 0x04,
  0x10, 0x10, 0x0C, 0x30, 0x08, 0x08, 0x20, 0x08, 0x08, 0x20, 0x0C, 0x08,
  0x20, 0x04, 0x08, 0x20, 0x04, 0x08, 0x20, 0x02, 0x18, 0x60, 0x02, 0x10,
  0x40, 0x03, 0x10, 0x40, 0x01, 0x10, 0x40, 0x01, 0x10, 0x40, 0x00, 0xB0,
  0xC0, 0x00, 0xB0, 0xC0, 0x00, 0xA0, 0x80, 0x00, 0x60, 0x80, 0x00, 0x60,
  0x80, 0x00, 0x60, 0x00, 0x1F, 0x80, 0x03, 0x83, 0x80, 0x18, 0x03, 0x00,
  0xC0, 0x06, 0x06, 0x00, 0x08, 0x10, 0x00, 0x30, 0x80, 0x00, 0x42, 0x00,
  0x01, 0x10, 0x00, 0x04, 0x40, 0x00, 0x13, 0x00, 0x00, 0x48, 0x00, 0x01,
  0x20, 0x00, 0x04, 0x80, 0x00, 0x32, 0x00, 0x00, 0x88, 0x00, 0x02, 0x60,
  0x00, 0x09, 0x00, 0x00, 0x24, 0x00, 0x01, 0x90, 0x00, 0x04, 0x40, 0x00,
  0x11, 0x00, 0x00, 0x4C, 0x00, 0x01, 0x10, 0x00, 0x08, 0x40, 0x00, 0x21,
  0x00, 0x01, 0x84, 0x00, 0x04, 0x18, 0x00, 0x20, 0x20, 0x01, 0x00, 0x40,
  0x08, 0x00, 0xC1, 0xC0, 0x01, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x20, 0x06,
  0x01, 0x00, 0x18, 0x08, 0x00, 0x60, 0xC0, 0x01, 0x04, 0x00, 0x0C, 0x20,
  0x00, 0x61, 0x00, 0x01, 0x08, 0x00, 0x18, 0x40, 0x00, 0x86, 0x00, 0x04,
  0x20, 0x00, 0x21, 0x00, 0x02, 0x08, 0x00, 0x30, 0x40, 0x03, 0x02, 0x00,
  0x30, 0x30, 0x07, 0x01, 0xFF, 0xE0, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x03, 0x83,
  0x80, 0x18, 0x03, 0x00, 0xC0, 0x06, 0x06, 0x00, 0x08, 0x10, 0x00, 0x20,
  0x80, 0x00, 0x46, 0x00, 0x01, 0x10, 0x00, 0x04, 0x40, 0x00, 0x13, 0x00,
  0x00, 0x48, 0x00, 0x01, 0x20, 0x00, 0x04, 0x80, 0x00, 0x32, 0x00, 0x00,
  0x98, 0x00, 0x02, 0x60, 0x00, 0x09, 0x00, 0x00, 0x24, 0x00, 0x01, 0x90,
  0x00, 0x04, 0x40, 0x00, 0x13, 0x00, 0x00, 0x4C, 0x00, 0x03, 0x30, 0x00,
  0x08, 0x40, 0x00, 0x21, 0x00, 0x01, 0x04, 0x00, 0x04, 0x18, 0x00, 0x20,
  0x20, 0x01, 0x00, 0x40, 0x08, 0x00, 0xC1, 0xC0, 0x01, 0xFE, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x00, 0x00, 0x02, 0x00, 0x07, 0xFF, 0x00, 0x20, 0x06, 0x01, 0x00, 0x08,
  0x08, 0x00, 0x20, 0xC0, 0x01, 0x04, 0x00, 0x0C, 0x20, 0x00, 0x21, 0x00,
  0x01, 0x08, 0x00, 0x08, 0x40, 0x00, 0xC6, 0x00, 0x04, 0x20, 0x00, 0x21,
  0x00, 0x03, 0x08, 0x00, 0x10, 0x40, 0x01, 0x06, 0x00, 0x10, 0x20, 0x03,
  0x01, 0xFF, 0xE0, 0x08, 0x02, 0x00, 0x40, 0x18, 0x02, 0x00, 0x40, 0x30,
  0x02, 0x01, 0x00, 0x18, 0x08, 0x00, 0x40, 0x40, 0x02, 0x02, 0x00, 0x18,
  0x10, 0x00, 0x41, 0x80, 0x02, 0x08, 0x00, 0x18, 0x40, 0x00, 0x42, 0x00,
  0x03, 0x10, 0x00, 0x18, 0x00, 0x3F, 0x80, 0x03, 0x83, 0x80, 0x18, 0x03,
  0x00, 0x80, 0x04, 0x04, 0x00, 0x08, 0x30, 0x00, 0x20, 0x80, 0x00, 0x82,
  0x00, 0x02, 0x08, 0x00, 0x08, 0x20, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x02, 0x30, 0x00, 0x08, 0x80, 0x00,
  0x22, 0x00, 0x01, 0x8C, 0x00, 0x04, 0x10, 0x00, 0x30, 0x60, 0x01, 0x80,
  0xC0, 0x0C, 0x01, 0xC1, 0xC0, 0x01, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x04, 0x20,
  0x00, 0x10, 0x80, 0x00, 0xC6, 0x00, 0x02, 0x10, 0x00, 0x08, 0x40, 0x00,
  0x21, 0x00, 0x00, 0x84, 0x00, 0x02, 0x30, 0x00, 0x18, 0x80, 0x00, 0x42,
  0x00, 0x01, 0x08, 0x00, 0x04, 0x20, 0x00, 0x10, 0x80, 0x00, 0x46, 0x00,
  0x02, 0x10, 0x00, 0x08, 0x40, 0x00, 0x21, 0x00, 0x00, 0x84, 0x00, 0x02,
  0x10, 0x00, 0x18, 0xC0, 0x00, 0x42, 0x00, 0x01, 0x08, 0x00, 0x04, 0x20,
  0x00, 0x10, 0x80, 0x00, 0xC2, 0x00, 0x02, 0x08, 0x00, 0x18, 0x30, 0x00,
  0x40, 0x40, 0x02, 0x01, 0x80, 0x30, 0x03, 0x83, 0x80, 0x03, 0xF8, 0x00,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xB0, 0x00, 0x05, 0x80, 0x00, 0x44, 0x00,
  0x02, 0x20, 0x00, 0x21, 0x00, 0x01, 0x08, 0x00, 0x18, 0x40, 0x00, 0x83,
  0x00, 0x0C, 0x08, 0x00, 0x40, 0x40, 0x06, 0x02, 0x00, 0x20, 0x10, 0x03,
  0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x30, 0x08, 0x00, 0x80, 0x40, 0x04,
  0x04, 0x00, 0x20, 0x20, 0x01, 0x02, 0x00, 0x08, 0x10, 0x00, 0x61, 0x80,
  0x01, 0x08, 0x00, 0x08, 0xC0, 0x00, 0x44, 0x00, 0x02, 0x20, 0x00, 0x12,
  0x00, 0x00, 0x90, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x02, 0x40, 0x03, 0x80, 0x02,
  0x40, 0x02, 0x80, 0x04, 0x40, 0x02, 0x80, 0x04, 0x40, 0x04, 0x80, 0x0C,
  0x40, 0x04, 0x80, 0x08, 0x40, 0x0C, 0x80, 0x08, 0x40, 0x08, 0x80, 0x18,
  0x40, 0x08, 0x40, 0x10, 0x40, 0x10, 0x40, 0x10, 0x40, 0x10, 0x40, 0x20,
  0x40, 0x30, 0x40, 0x20, 0x60, 0x20, 0x40, 0x60, 0x60, 0x20, 0x40, 0x40,
  0x60, 0x40, 0x40, 0x40, 0x60, 0x40, 0x40, 0xC0, 0x20, 0xC0, 0x40, 0x80,
  0x20, 0x80, 0x40, 0x80, 0x20, 0x80, 0x61, 0x00, 0x21, 0x00, 0x61, 0x00,
  0x21, 0x00, 0x23, 0x00, 0x23, 0x00, 0x22, 0x00, 0x22, 0x00, 0x22, 0x00,
  0x22, 0x00, 0x26, 0x00, 0x24, 0x00, 0x24, 0x00, 0x24, 0x00, 0x24, 0x00,
  0x2C, 0x00, 0x28, 0x00, 0x28, 0x00, 0x28, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x02, 0x00, 0x01, 0x81,
  0x80, 0x00, 0x80, 0x40, 0x00, 0x80, 0x20, 0x00, 0xC0, 0x08, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x03, 0x00, 0x40, 0x00, 0x80, 0x60, 0x00, 0x60, 0x20,
  0x00, 0x10, 0x20, 0x00, 0x08, 0x30, 0x00, 0x02, 0x30, 0x00, 0x01, 0x10,
  0x00, 0x00, 0xD0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0A, 0x00, 0x00, 0x08, 0x80, 0x00, 0x0C, 0x40, 0x00, 0x04,
  0x30, 0x00, 0x04, 0x08, 0x00, 0x06, 0x06, 0x00, 0x02, 0x01, 0x00, 0x02,
  0x00, 0x80, 0x02, 0x00, 0x20, 0x03, 0x00, 0x10, 0x01, 0x00, 0x0C, 0x01,
  0x00, 0x02, 0x01, 0x80, 0x01, 0x81, 0x80, 0x00, 0x40, 0x80, 0x00, 0x20,
  0xC0, 0x00, 0x1A, 0x00, 0x00, 0x90, 0x00, 0x0C, 0xC0, 0x00, 0xC2, 0x00,
  0x04, 0x10, 0x00, 0x60, 0xC0, 0x06, 0x02, 0x00, 0x20, 0x10, 0x02, 0x00,
  0xC0, 0x30, 0x02, 0x01, 0x00, 0x10, 0x10, 0x00, 0xC1, 0x80, 0x02, 0x08,
  0x00, 0x10, 0x80, 0x00, 0x8C, 0x00, 0x02, 0x40, 0x00, 0x14, 0x00, 0x00,
  0xE0, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x01, 0xF0, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x30, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x06, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x18, 0x01, 0x80, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x03, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x07, 0xC0, 0x82, 0x08, 0x20, 0x83, 0x04, 0x10,
  0x41, 0x04, 0x10, 0x60, 0x82, 0x08, 0x20, 0x83, 0x0C, 0x10, 0x41, 0x04,
  0x10, 0x61, 0x82, 0x08, 0x20, 0x82, 0x0C, 0x30, 0x40, 0x01, 0xF0, 0x01,
  0x00, 0x10, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x18, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x30, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x0C, 0x0F, 0x80, 0x01, 0x80, 0x30, 0x0A, 0x01, 0x40, 0x48, 0x08, 0x82,
  0x10, 0x42, 0x18, 0x42, 0x08, 0xC1, 0x10, 0x36, 0x02, 0x80, 0x70, 0x0C,
  0x01, 0xFF, 0xFE, 0x43, 0x08, 0x61, 0x0C, 0x00, 0xFC, 0x01, 0x83, 0x01,
  0x00, 0xC1, 0x00, 0x21, 0x00, 0x18, 0x80, 0x04, 0xC0, 0x06, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x7F, 0xE0, 0xE0, 0x31, 0x80,
  0x11, 0x80, 0x08, 0x80, 0x04, 0x80, 0x02, 0x40, 0x01, 0x20, 0x01, 0x90,
  0x01, 0x88, 0x01, 0xC6, 0x01, 0x21, 0x83, 0x10, 0x7E, 0x08, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x87, 0xE0, 0x27,
  0x0C, 0x0B, 0x01, 0x83, 0x00, 0x21, 0x80, 0x0C, 0x60, 0x01, 0x10, 0x00,
  0x44, 0x00, 0x11, 0x00, 0x04, 0x40, 0x03, 0x30, 0x00, 0xC8, 0x00, 0x22,
  0x00, 0x08, 0x80, 0x02, 0x20, 0x00, 0x88, 0x00, 0x66, 0x00, 0x11, 0x00,
  0x04, 0x40, 0x03, 0x10, 0x00, 0x86, 0x00, 0x41, 0x40, 0x30, 0xCC, 0x38,
  0x21, 0xF8, 0x00, 0x00, 0xFC, 0x01, 0x83, 0x01, 0x00, 0xC1, 0x00, 0x31,
  0x80, 0x08, 0x80, 0x04, 0xC0, 0x02, 0x40, 0x01, 0x20, 0x00, 0x30, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x02, 0x60, 0x01, 0x10, 0x01, 0x88, 0x00, 0x86, 0x00, 0xC1,
  0x00, 0xC0, 0x61, 0xC0, 0x1F, 0x80, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x07, 0xC2, 0x03, 0x06, 0x40, 0xC0,
  0x68, 0x30, 0x05, 0x04, 0x00, 0x61, 0x00, 0x0C, 0x20, 0x01, 0x08, 0x00,
  0x21, 0x00, 0x04, 0x20, 0x00, 0x84, 0x00, 0x11, 0x80, 0x06, 0x20, 0x00,
  0x84, 0x00, 0x10, 0x80, 0x02, 0x10, 0x00, 0x42, 0x00, 0x08, 0x40, 0x03,
  0x08, 0x00, 0x41, 0x00, 0x08, 0x30, 0x03, 0x02, 0x01, 0xA0, 0x30, 0xE4,
  0x03, 0xF1, 0x80, 0x00, 0xFC, 0x01, 0x83, 0x01, 0x80, 0xC1, 0x00, 0x21,
  0x80, 0x08, 0x80, 0x04, 0x80, 0x02, 0x40, 0x01, 0x60, 0x00, 0xA0, 0x00,
  0x5F, 0xFF, 0xE8, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x10, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x60, 0x60, 0xE0, 0x1F, 0x80, 0x00, 0xF8, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0x40, 0x3F, 0xF0,
  0x10, 0x01, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x0C,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x60, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x00, 0x00, 0x7C, 0x20, 0x30, 0x64, 0x0C, 0x06, 0x83, 0x00, 0x50,
  0x40, 0x06, 0x10, 0x00, 0xC2, 0x00, 0x10, 0x80, 0x02, 0x10, 0x00, 0x42,
  0x00, 0x08, 0x40, 0x01, 0x18, 0x00, 0x62, 0x00, 0x08, 0x40, 0x01, 0x08,
  0x00, 0x21, 0x00, 0x04, 0x20, 0x00, 0x84, 0x00, 0x30, 0x80, 0x04, 0x10,
  0x00, 0x83, 0x00, 0x30, 0x20, 0x1A, 0x03, 0x0E, 0xC0, 0x3F, 0x18, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x41, 0x80,
  0x10, 0x18, 0x06, 0x01, 0x83, 0x80, 0x0F, 0xC0, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x0F, 0x81, 0x18, 0x60, 0x90,
  0x18, 0x50, 0x04, 0x30, 0x02, 0x38, 0x01, 0x18, 0x00, 0x8C, 0x00, 0x44,
  0x00, 0x22, 0x00, 0x13, 0x00, 0x09, 0x80, 0x0C, 0x80, 0x04, 0x40, 0x02,
  0x20, 0x01, 0x10, 0x00, 0x98, 0x00, 0x48, 0x00, 0x64, 0x00, 0x22, 0x00,
  0x11, 0x00, 0x08, 0x80, 0x04, 0xC0, 0x02, 0x40, 0x03, 0x00, 0x07, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x08, 0x08, 0x08, 0x08, 0x08,
  0x18, 0x10, 0x10, 0x10, 0x10, 0x10, 0x30, 0x20, 0x20, 0x20, 0x20, 0x20,
  0x60, 0x40, 0x40, 0x40, 0x40, 0xC0, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x06, 0x00, 0xF0, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x0C,
  0x20, 0x06, 0x08, 0x02, 0x02, 0x01, 0x00, 0x80, 0x80, 0x60, 0x40, 0x10,
  0x20, 0x04, 0x10, 0x01, 0x08, 0x00, 0x44, 0x00, 0x32, 0x00, 0x0B, 0x40,
  0x03, 0x90, 0x00, 0xC2, 0x00, 0x20, 0xC0, 0x08, 0x10, 0x06, 0x06, 0x01,
  0x00, 0x80, 0x40, 0x30, 0x10, 0x04, 0x04, 0x01, 0x81, 0x00, 0x20, 0xC0,
  0x0C, 0x20, 0x01, 0x00, 0x02, 0x04, 0x08, 0x10, 0x60, 0xC1, 0x02, 0x04,
  0x08, 0x30, 0x40, 0x81, 0x02, 0x04, 0x18, 0x20, 0x40, 0x81, 0x02, 0x0C,
  0x10, 0x20, 0x40, 0x81, 0x06, 0x08, 0x10, 0x20, 0x41, 0x80, 0x08, 0x7E,
  0x01, 0xF0, 0x23, 0x0C, 0x18, 0x60, 0x90, 0x19, 0x80, 0xC6, 0x80, 0x24,
  0x01, 0x1C, 0x00, 0xA0, 0x04, 0x50, 0x03, 0x00, 0x11, 0x80, 0x0C, 0x00,
  0x44, 0x00, 0x20, 0x01, 0x10, 0x00, 0x80, 0x04, 0xC0, 0x02, 0x00, 0x13,
  0x00, 0x08, 0x00, 0x48, 0x00, 0x40, 0x03, 0x20, 0x01, 0x00, 0x0C, 0x80,
  0x04, 0x00, 0x22, 0x00, 0x10, 0x00, 0x98, 0x00, 0x40, 0x02, 0x40, 0x03,
  0x00, 0x09, 0x00, 0x08, 0x00, 0x64, 0x00, 0x20, 0x01, 0x10, 0x00, 0x80,
  0x04, 0x40, 0x02, 0x00, 0x13, 0x00, 0x08, 0x00, 0x48, 0x00, 0x60, 0x01,
  0x20, 0x01, 0x00, 0x0C, 0x08, 0x3E, 0x04, 0x61, 0x82, 0x40, 0x61, 0x40,
  0x11, 0xC0, 0x08, 0xE0, 0x04, 0x60, 0x02, 0x30, 0x01, 0x10, 0x00, 0x88,
  0x00, 0x4C, 0x00, 0x26, 0x00, 0x32, 0x00, 0x11, 0x00, 0x08, 0x80, 0x04,
  0x40, 0x02, 0x60, 0x01, 0x20, 0x01, 0x90, 0x00, 0x88, 0x00, 0x44, 0x00,
  0x22, 0x00, 0x13, 0x00, 0x09, 0x00, 0x0C, 0x01, 0xF8, 0x03, 0x87, 0x03,
  0x00, 0xC3, 0x00, 0x21, 0x00, 0x11, 0x00, 0x0C, 0x80, 0x02, 0xC0, 0x01,
  0x40, 0x00, 0xA0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x14, 0x00,
  0x0A, 0x00, 0x05, 0x00, 0x06, 0x80, 0x02, 0x40, 0x01, 0x20, 0x01, 0x90,
  0x00, 0x84, 0x00, 0x83, 0x00, 0x80, 0xC1, 0x80, 0x3F, 0x80, 0x04, 0x3F,
  0x00, 0x9C, 0x30, 0x16, 0x03, 0x03, 0x00, 0x20, 0xC0, 0x06, 0x18, 0x00,
  0x42, 0x00, 0x08, 0x40, 0x01, 0x08, 0x00, 0x21, 0x00, 0x04, 0x60, 0x01,
  0x88, 0x00, 0x21, 0x00, 0x04, 0x20, 0x00, 0x84, 0x00, 0x10, 0x80, 0x06,
  0x30, 0x00, 0x84, 0x00, 0x10, 0x80, 0x06, 0x10, 0x00, 0x83, 0x00, 0x20,
  0x50, 0x0C, 0x19, 0x87, 0x02, 0x1F, 0x80, 0x40, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x83, 0x06, 0x43, 0x01, 0xA3,
  0x00, 0x51, 0x00, 0x19, 0x00, 0x0C, 0x80, 0x04, 0xC0, 0x02, 0x40, 0x01,
  0x20, 0x00, 0x90, 0x00, 0x58, 0x00, 0x68, 0x00, 0x24, 0x00, 0x12, 0x00,
  0x09, 0x00, 0x04, 0x80, 0x02, 0x40, 0x03, 0x20, 0x01, 0x10, 0x00, 0x8C,
  0x00, 0xC2, 0x01, 0xA0, 0xC3, 0xB0, 0x3F, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x78, 0x4C, 0x02, 0xC0, 0x14, 0x01, 0xC0,
  0x0C, 0x00, 0x60, 0x02, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x60, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x03, 0x00, 0x10, 0x00, 0x01, 0xF8, 0x07, 0x0E, 0x0C,
  0x02, 0x18, 0x01, 0x10, 0x01, 0x10, 0x01, 0x30, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x80, 0x04, 0x80, 0x04, 0xC0,
  0x08, 0x40, 0x18, 0x30, 0x60, 0x0F, 0x80, 0x0C, 0x06, 0x02, 0x01, 0x00,
  0x80, 0x43, 0xFE, 0x20, 0x10, 0x08, 0x04, 0x02, 0x03, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x18, 0x08, 0x04, 0x02, 0x01, 0x01, 0x80, 0x80, 0x40,
  0x20, 0x10, 0x04, 0x03, 0xE0, 0x10, 0x00, 0x88, 0x00, 0x44, 0x00, 0x22,
  0x00, 0x13, 0x00, 0x09, 0x00, 0x0C, 0x80, 0x04, 0x40, 0x02, 0x20, 0x01,
  0x10, 0x00, 0x98, 0x00, 0x48, 0x00, 0x64, 0x00, 0x22, 0x00, 0x11, 0x00,
  0x08, 0x80, 0x04, 0xC0, 0x06, 0x60, 0x03, 0x30, 0x03, 0x18, 0x01, 0x84,
  0x01, 0x43, 0x01, 0x20, 0xC3, 0x30, 0x3F, 0x18, 0x80, 0x01, 0x80, 0x02,
  0x80, 0x02, 0xC0, 0x04, 0x40, 0x04, 0x40, 0x08, 0x40, 0x08, 0x40, 0x18,
  0x40, 0x10, 0x60, 0x30, 0x20, 0x20, 0x20, 0x60, 0x20, 0x40, 0x20, 0x40,
  0x20, 0x80, 0x30, 0x80, 0x31, 0x00, 0x11, 0x00, 0x12, 0x00, 0x12, 0x00,
  0x14, 0x00, 0x14, 0x00, 0x18, 0x00, 0x08, 0x00, 0x80, 0x18, 0x01, 0x40,
  0x0C, 0x00, 0xA0, 0x06, 0x00, 0xD0, 0x05, 0x00, 0x48, 0x02, 0x80, 0x64,
  0x02, 0x40, 0x22, 0x01, 0x20, 0x11, 0x01, 0x90, 0x18, 0x80, 0x88, 0x08,
  0x60, 0xC6, 0x0C, 0x30, 0x43, 0x04, 0x18, 0x20, 0x82, 0x04, 0x20, 0x43,
  0x02, 0x10, 0x21, 0x01, 0x18, 0x11, 0x80, 0x88, 0x08, 0x80, 0x4C, 0x04,
  0x40, 0x24, 0x02, 0x60, 0x12, 0x01, 0x20, 0x0A, 0x00, 0xB0, 0x05, 0x00,
  0x50, 0x03, 0x00, 0x38, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x04,
  0x00, 0x20, 0x80, 0x08, 0x18, 0x03, 0x01, 0x00, 0xC0, 0x30, 0x10, 0x02,
  0x04, 0x00, 0x41, 0x80, 0x04, 0x20, 0x00, 0x88, 0x00, 0x0A, 0x00, 0x01,
  0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x60, 0x00, 0x64, 0x00, 0x08,
  0x80, 0x02, 0x08, 0x00, 0x81, 0x00, 0x30, 0x30, 0x04, 0x02, 0x01, 0x00,
  0x60, 0x60, 0x04, 0x18, 0x00, 0xC2, 0x00, 0x08, 0x04, 0x00, 0x08, 0x20,
  0x00, 0xC1, 0x80, 0x04, 0x04, 0x00, 0x60, 0x20, 0x02, 0x01, 0x00, 0x30,
  0x08, 0x01, 0x00, 0x40, 0x18, 0x03, 0x00, 0x80, 0x18, 0x0C, 0x00, 0x40,
  0x40, 0x02, 0x06, 0x00, 0x10, 0x20, 0x00, 0x83, 0x00, 0x04, 0x10, 0x00,
  0x31, 0x80, 0x00, 0x88, 0x00, 0x04, 0xC0, 0x00, 0x24, 0x00, 0x01, 0x60,
  0x00, 0x0A, 0x00, 0x00, 0x70, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x06, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x0C, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x10,
  0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x80, 0x02, 0x00, 0x10, 0x03, 0x80, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x02, 0x04, 0x18, 0x30, 0x40, 0x81, 0x02, 0x0C, 0x18, 0x20, 0x40, 0x81,
  0x06, 0x0C, 0x18, 0x20, 0x40, 0x81, 0x06, 0x0C, 0x10, 0x20, 0x40, 0x83,
  0x06, 0x0C, 0x10, 0x20, 0x40, 0x83, 0x06, 0x08, 0x10, 0x00, 0x01, 0x00,
  0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x70, 0x00, 0xC0, 0x0C, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x20, 0x01,
  0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0x80, 0x00, 0x1F, 0x00, 0x13, 0x18, 0x01, 0x60, 0xC0,
  0x14, 0x06, 0x02, 0xC0, 0x30, 0x68, 0x01, 0x8C, 0x80, 0x0F, 0x80,
};

const GFXglyph RobotoCondensed_ThinItalic45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 7, 32, 8, 1, -32 },
  { 29, 7, 9, 11, 5, -34 },
  { 37, 22, 32, 21, 1, -32 },
  { 125, 18, 40, 21, 2, -36 },
  { 215, 21, 32, 28, 4, -32 },
  { 299, 20, 32, 23, 1, -32 },
  { 379, 3, 9, 7, 5, -34 },
  { 383, 12, 46, 12, 2, -36 },
  { 452, 13, 46, 12, -3, -36 },
  { 527, 17, 17, 18, 3, -32 },
  { 564, 18, 23, 22, 2, -26 },
  { 616, 4, 9, 8, -1, -3 },
  { 621, 8, 1, 12, 2, -15 },
  { 622, 3, 2, 9, 1, -2 },
  { 623, 19, 35, 15, -2, -32 },
  { 707, 18, 32, 21, 2, -32 },
  { 779, 10, 32, 21, 6, -32 },
  { 819, 19, 32, 21, 1, -32 },
  { 895, 19, 32, 21, 1, -32 },
  { 971, 19, 32, 21, 1, -32 },
  { 1047, 19, 32, 21, 3, -32 },
  { 1123, 17, 32, 21, 2, -32 },
  { 1191, 18, 32, 21, 4, -32 },
  { 1263, 20, 32, 21, 1, -32 },
  { 1343, 17, 32, 21, 3, -32 },
  { 1411, 7, 23, 8, 0, -23 },
  { 1432, 8, 29, 8, -1, -23 },
  { 1461, 17, 17, 20, 2, -23 },
  { 1498, 17, 10, 21, 2, -20 },
  { 1520, 17, 18, 20, 1, -24 },
  { 1559, 13, 32, 17, 4, -32 },
  { 1611, 32, 41, 35, 1, -31 },
  { 1775, 21, 32, 23, -1, -32 },
  { 1859, 20, 32, 23, 2, -32 },
  { 1939, 21, 32, 25, 3, -32 },
  { 2023, 22, 32, 25, 2, -32 },
  { 2111, 21, 32, 22, 2, -32 },
  { 2195, 22, 32, 22, 2, -32 },
  { 2283, 22, 32, 26, 3, -32 },
  { 2371, 24, 32, 27, 2, -32 },
  { 2467, 7, 32, 11, 2, -32 },
  { 2495, 20, 32, 21, 1, -32 },
  { 2575, 23, 32, 24, 2, -32 },
  { 2667, 15, 32, 20, 2, -32 },
  { 2727, 30, 32, 33, 2, -32 },
  { 2847, 24, 32, 27, 2, -32 },
  { 2943, 22, 32, 26, 2, -32 },
  { 3031, 21, 32, 23, 2, -32 },
  { 3115, 22, 38, 26, 2, -32 },
  { 3220, 21, 32, 25, 2, -32 },
  { 3304, 22, 32, 23, 1, -32 },
  { 3392, 21, 32, 23, 4, -32 },
  { 3476, 22, 32, 25, 3, -32 },
  { 3564, 21, 32, 23, 4, -32 },
  { 3648, 32, 32, 34, 4, -32 },
  { 3776, 25, 32, 23, -1, -32 },
  { 3876, 21, 32, 23, 4, -32 },
  { 3960, 24, 32, 23, 0, -32 },
  { 4056, 12, 44, 9, 0, -37 },
  { 4122, 6, 35, 15, 5, -32 },
  { 4149, 12, 44, 9, -3, -37 },
  { 4215, 11, 16, 16, 3, -32 },
  { 4237, 15, 1, 16, -2, 0 },
  { 4239, 5, 6, 12, 6, -34 },
  { 4243, 17, 24, 20, 1, -24 },
  { 4294, 18, 34, 21, 1, -34 },
  { 4371, 17, 24, 20, 1, -24 },
  { 4422, 19, 34, 21, 2, -34 },
  { 4503, 17, 24, 20, 1, -24 },
  { 4554, 13, 34, 13, 3, -34 },
  { 4610, 19, 33, 21, 0, -24 },
  { 4689, 17, 34, 21, 1, -34 },
  { 4762, 8, 32, 9, 1, -32 },
  { 4794, 15, 41, 9, -6, -32 },
  { 4871, 18, 34, 18, 1, -34 },
  { 4948, 7, 34, 9, 1, -34 },
  { 4978, 30, 24, 34, 1, -24 },
  { 5068, 17, 24, 21, 1, -24 },
  { 5119, 17, 24, 21, 2, -24 },
  { 5170, 19, 33, 21, 0, -24 },
  { 5249, 17, 33, 21, 2, -24 },
  { 5320, 13, 24, 13, 1, -24 },
  { 5359, 16, 24, 19, 1, -24 },
  { 5407, 9, 30, 13, 3, -30 },
  { 5441, 17, 24, 21, 2, -24 },
  { 5492, 16, 24, 19, 3, -24 },
  { 5540, 25, 24, 29, 4, -24 },
  { 5615, 19, 24, 19, -1, -24 },
  { 5672, 21, 33, 18, -2, -24 },
  { 5759, 18, 24, 19, 0, -24 },
  { 5813, 14, 45, 13, 2, -35 },
  { 5892, 7, 38, 9, 1, -32 },
  { 5926, 14, 45, 13, -3, -35 },
  { 6005, 20, 7, 26, 3, -17 },
};

const GFXfont RobotoCondensed_ThinItalic45pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ThinItalic45pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ThinItalic45pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _ROBOTOCONDENSED_THINITALIC45PT7B_H_
