#ifndef _ROBOTOCONDENSED_THINITALIC6PT7B_H_
#define _ROBOTOCONDENSED_THINITALIC6PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ThinItalic.ttf
// Size: 6pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ThinItalic6pt7bBitmaps[] PROGMEM = {
  0x00, 0x60, 0x80, 0x6B, 0x80, 0x53, 0x16, 0x00, 0xED, 0x4B, 0x70, 0x00,
  0x2A, 0xA0, 0x78, 0x50, 0x09, 0x00, 0x00, 0x00, 0x00, 0x18, 0xF6, 0xE0,
  0xE0, 0x25, 0x40, 0x2C, 0x30, 0x0B, 0x00, 0x58, 0xF0, 0x3F, 0x68, 0xFE,
  0xF0, 0xF5, 0x20, 0x00, 0x00, 0x50, 0x60, 0x70, 0xC0, 0x7B, 0xFB, 0xC0,
  0x4A, 0x90, 0xF6, 0x30, 0xD2, 0x70, 0x36, 0xA0, 0x12, 0x00, 0x12, 0x00,
  0xD2, 0x70, 0x16, 0x80, 0x70, 0x24, 0xA0, 0x2A, 0x10, 0x28, 0x09, 0xF5,
  0x8D, 0xA2, 0xF6, 0xF0, 0xF6, 0x00, 0xF6, 0xF0, 0xF6, 0x00, 0xC8, 0xB0,
  0x28, 0x16, 0xF0, 0x3A, 0x0D, 0xE0, 0x29, 0x00, 0x28, 0x29, 0x20, 0x2A,
  0x80, 0x60, 0x78, 0x40, 0x00, 0x00, 0xD8, 0x1A, 0xDE, 0xA8, 0x0E, 0xDC,
  0xF8, 0x1A, 0x80, 0xF7, 0x20, 0x2F, 0x00, 0x20, 0x05, 0x00, 0x13, 0x40,
  0x70, 0x3B, 0x00, 0xF0, 0xF7, 0x00, 0xF7, 0x80, 0xF7, 0x00, 0xA0, 0x94,
  0x2A, 0x16, 0x00, 0x99, 0x00, 0x15, 0x20, 0x10, 0x99, 0x00, 0x50, 0x10,
  0x80, 0x70, 0x48, 0xE0,
};

const GFXglyph RobotoCondensed_ThinItalic6pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 1, 0, -1 },
  { 1, 1, 4, 1, 0, -4 },
  { 2, 1, 2, 2, 1, -5 },
  { 3, 3, 4, 3, 0, -4 },
  { 5, 3, 6, 3, 0, -5 },
  { 8, 2, 4, 4, 1, -4 },
  { 9, 3, 4, 3, 0, -4 },
  { 11, 1, 2, 1, 0, -5 },
  { 12, 2, 6, 2, 0, -5 },
  { 14, 1, 6, 2, 0, -5 },
  { 15, 3, 2, 2, 0, -4 },
  { 16, 3, 4, 3, 0, -4 },
  { 18, 1, 1, 1, 0, 0 },
  { 19, 1, 1, 2, 0, -2 },
  { 20, 1, 1, 1, 0, -1 },
  { 21, 2, 4, 2, 0, -4 },
  { 22, 3, 4, 3, 0, -4 },
  { 24, 1, 4, 3, 1, -4 },
  { 25, 3, 4, 3, 0, -4 },
  { 27, 3, 4, 3, 0, -4 },
  { 29, 3, 4, 3, 0, -4 },
  { 31, 3, 4, 3, 0, -4 },
  { 33, 2, 4, 3, 0, -4 },
  { 34, 2, 4, 3, 1, -4 },
  { 35, 3, 4, 3, 0, -4 },
  { 37, 3, 4, 3, 0, -4 },
  { 39, 1, 3, 1, 0, -3 },
  { 40, 1, 4, 1, 0, -3 },
  { 41, 3, 2, 3, 0, -3 },
  { 42, 3, 2, 3, 0, -3 },
  { 43, 2, 2, 3, 0, -3 },
  { 44, 1, 4, 2, 1, -4 },
  { 45, 4, 5, 5, 0, -4 },
  { 48, 3, 4, 3, 0, -4 },
  { 50, 3, 4, 3, 0, -4 },
  { 52, 3, 4, 3, 0, -4 },
  { 54, 3, 4, 3, 0, -4 },
  { 56, 3, 4, 3, 0, -4 },
  { 58, 3, 4, 3, 0, -4 },
  { 60, 3, 4, 4, 0, -4 },
  { 62, 3, 4, 4, 0, -4 },
  { 64, 1, 4, 1, 0, -4 },
  { 65, 3, 4, 3, 0, -4 },
  { 67, 3, 4, 3, 0, -4 },
  { 69, 2, 4, 3, 0, -4 },
  { 70, 4, 4, 4, 0, -4 },
  { 72, 4, 4, 4, 0, -4 },
  { 74, 3, 4, 3, 0, -4 },
  { 76, 3, 4, 3, 0, -4 },
  { 78, 3, 5, 3, 0, -4 },
  { 80, 3, 4, 3, 0, -4 },
  { 82, 3, 4, 3, 0, -4 },
  { 84, 2, 4, 3, 1, -4 },
  { 85, 3, 4, 3, 0, -4 },
  { 87, 2, 4, 3, 1, -4 },
  { 88, 4, 4, 5, 1, -4 },
  { 90, 3, 4, 3, 0, -4 },
  { 92, 2, 4, 3, 1, -4 },
  { 93, 3, 4, 3, 0, -4 },
  { 95, 2, 6, 1, 0, -5 },
  { 97, 1, 4, 2, 1, -4 },
  { 98, 1, 6, 1, 0, -5 },
  { 99, 2, 2, 2, 0, -4 },
  { 100, 2, 1, 2, 0, 0 },
  { 101, 1, 1, 2, 1, -5 },
  { 102, 2, 3, 3, 0, -3 },
  { 103, 3, 5, 3, 0, -5 },
  { 105, 2, 3, 3, 0, -3 },
  { 106, 3, 5, 3, 0, -5 },
  { 108, 2, 3, 3, 0, -3 },
  { 109, 2, 5, 2, 0, -5 },
  { 111, 3, 4, 3, 0, -3 },
  { 113, 2, 5, 3, 0, -5 },
  { 115, 1, 4, 1, 0, -4 },
  { 116, 2, 5, 1, -1, -4 },
  { 118, 3, 5, 2, 0, -5 },
  { 120, 1, 5, 1, 0, -5 },
  { 121, 4, 3, 5, 0, -3 },
  { 123, 2, 3, 3, 0, -3 },
  { 124, 3, 3, 3, 0, -3 },
  { 126, 3, 4, 3, 0, -3 },
  { 128, 3, 4, 3, 0, -3 },
  { 130, 2, 3, 2, 0, -3 },
  { 131, 2, 3, 3, 0, -3 },
  { 132, 2, 4, 2, 0, -4 },
  { 133, 3, 3, 3, 0, -3 },
  { 135, 3, 3, 2, 0, -3 },
  { 137, 4, 3, 4, 0, -3 },
  { 139, 2, 3, 2, 0, -3 },
  { 140, 3, 4, 2, 0, -3 },
  { 142, 2, 3, 2, 0, -3 },
  { 143, 2, 6, 2, 0, -5 },
  { 145, 1, 5, 1, 0, -4 },
  { 146, 1, 6, 2, 0, -5 },
  { 147, 3, 1, 4, 0, -2 },
};

const GFXfont RobotoCondensed_ThinItalic6pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ThinItalic6pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ThinItalic6pt7bGlyphs,
  0x20, 0x7E, 7
};

#endif // _ROBOTOCONDENSED_THINITALIC6PT7B_H_
