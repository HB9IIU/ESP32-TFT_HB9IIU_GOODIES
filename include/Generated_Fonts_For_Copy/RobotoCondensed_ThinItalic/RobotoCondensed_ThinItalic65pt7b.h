#ifndef _ROBOTOCONDENSED_THINITALIC65PT7B_H_
#define _ROBOTOCONDENSED_THINITALIC65PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ThinItalic.ttf
// Size: 65pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ThinItalic65pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x40, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x04, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x02, 0x00, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x40, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x08, 0x02, 0x01, 0x80, 0x60, 0x18, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x38, 0x04, 0x00,
  0x30, 0x4C, 0x33, 0x0C, 0xC3, 0x30, 0xD8, 0x36, 0x09, 0x86, 0x61, 0x98,
  0x64, 0x1B, 0x06, 0xC1, 0x00, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x30,
  0x06, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x08, 0x01, 0x00, 0x00, 0x0C,
  0x01, 0x80, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x40, 0x00, 0x03,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x80, 0x10, 0x00, 0x00,
  0xC0, 0x18, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x20, 0x04, 0x00, 0x3F,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x08, 0x01, 0x00, 0x00,
  0x0C, 0x01, 0x80, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x40, 0x00,
  0x03, 0x00, 0x60, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x80, 0x10, 0x00,
  0x00, 0xC0, 0x18, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x20, 0x04, 0x00,
  0x00, 0x30, 0x06, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x08, 0x01, 0x00,
  0x00, 0x0C, 0x01, 0x80, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x40,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xC0, 0x10,
  0x00, 0x00, 0x40, 0x18, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x30, 0x06,
  0x00, 0x00, 0x10, 0x06, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x0C, 0x01,
  0x80, 0x00, 0x04, 0x00, 0x80, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x60, 0x00, 0x01, 0x00, 0x20, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0xC0,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x1C, 0x07, 0x00, 0x06, 0x00,
  0x70, 0x01, 0x80, 0x07, 0x00, 0x60, 0x00, 0x60, 0x18, 0x00, 0x0C, 0x03,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x18, 0x18, 0x00, 0x03, 0x02, 0x00, 0x00,
  0x60, 0x40, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x83, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x40, 0x00, 0x03, 0x08, 0x00, 0x00,
  0x61, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x01, 0x04, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x0C, 0x18, 0x00, 0x03, 0x03, 0x00, 0x00, 0x60, 0x30, 0x00, 0x18,
  0x07, 0x00, 0x06, 0x00, 0x70, 0x01, 0x80, 0x07, 0x00, 0xE0, 0x00, 0x3F,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x38, 0x70,
  0x00, 0x00, 0xC0, 0x60, 0x00, 0x01, 0x80, 0x60, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0x08, 0x01, 0x80, 0x08, 0x30, 0x01, 0x00, 0x18, 0x60, 0x06, 0x00,
  0x60, 0x80, 0x0C, 0x01, 0x83, 0x00, 0x18, 0x02, 0x06, 0x00, 0x30, 0x0C,
  0x0C, 0x00, 0x40, 0x30, 0x18, 0x00, 0x80, 0xC0, 0x30, 0x03, 0x01, 0x80,
  0x60, 0x04, 0x06, 0x00, 0xC0, 0x18, 0x18, 0x00, 0xC0, 0x60, 0x30, 0x01,
  0x81, 0xC0, 0xC0, 0x01, 0xDF, 0x03, 0x00, 0x01, 0xF8, 0x06, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x60, 0x3F, 0x80, 0x01, 0x80, 0xF7, 0x80, 0x02, 0x03, 0x03, 0x00, 0x0C,
  0x0C, 0x03, 0x00, 0x30, 0x30, 0x06, 0x00, 0xC0, 0x60, 0x04, 0x01, 0x80,
  0x80, 0x08, 0x06, 0x03, 0x00, 0x10, 0x18, 0x06, 0x00, 0x20, 0x30, 0x08,
  0x00, 0xC0, 0xC0, 0x10, 0x01, 0x83, 0x00, 0x60, 0x03, 0x04, 0x00, 0xC0,
  0x06, 0x18, 0x01, 0x80, 0x08, 0x60, 0x03, 0x00, 0x30, 0x00, 0x02, 0x00,
  0x40, 0x00, 0x04, 0x01, 0x80, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x0C, 0x18,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0x83, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x03,
  0x00, 0x60, 0x00, 0x10, 0x01, 0x80, 0x01, 0x80, 0x0C, 0x00, 0x08, 0x00,
  0x60, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x01, 0x80,
  0x01, 0x80, 0x0C, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x60, 0x06, 0x00, 0x03,
  0x00, 0x60, 0x00, 0x18, 0x06, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x03, 0x06,
  0x00, 0x00, 0x18, 0xE0, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0x18, 0x30, 0x00, 0x01, 0x81, 0x80, 0x00, 0x1C, 0x06,
  0x00, 0x20, 0xC0, 0x30, 0x01, 0x0C, 0x00, 0xC0, 0x18, 0xC0, 0x03, 0x00,
  0xC6, 0x00, 0x18, 0x06, 0x60, 0x00, 0x60, 0x63, 0x00, 0x03, 0x03, 0x10,
  0x00, 0x0C, 0x11, 0x80, 0x00, 0x61, 0x8C, 0x00, 0x01, 0x88, 0x60, 0x00,
  0x06, 0xC3, 0x00, 0x00, 0x3C, 0x18, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x78, 0x18, 0x00, 0x06, 0xC0, 0x60, 0x00, 0x63, 0x03,
  0x80, 0x0E, 0x0C, 0x0F, 0x01, 0xC0, 0x60, 0x1F, 0xFC, 0x01, 0x80, 0x1E,
  0x00, 0x00, 0x33, 0x36, 0x66, 0x66, 0x4C, 0xCC, 0xC0, 0x00, 0x00, 0x40,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00,
  0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x01, 0x78,
  0x04, 0x07, 0xCF, 0x06, 0x0F, 0x01, 0xF3, 0x3C, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0xE0, 0x60, 0x00, 0xE0, 0x18,
  0x00, 0x60, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x60, 0x01, 0x80, 0x20, 0x00,
  0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x0C, 0x18, 0x60, 0xC1, 0x83, 0x0C,
  0x18, 0x61, 0xC3, 0x04, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x27, 0x76, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x03, 0x80, 0xE0, 0x01, 0xC0, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x30,
  0x00, 0x40, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x06, 0x03, 0x00, 0x00, 0x81,
  0x80, 0x00, 0x20, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0xC2, 0x00, 0x00, 0x31, 0x80, 0x00, 0x0C, 0x60, 0x00, 0x03, 0x18, 0x00,
  0x00, 0xC4, 0x00, 0x00, 0x23, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x06, 0x30,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0x62, 0x00, 0x00, 0x18, 0x80, 0x00, 0x06,
  0x60, 0x00, 0x01, 0x18, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x31, 0x80, 0x00,
  0x0C, 0x40, 0x00, 0x03, 0x10, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x06, 0x30, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x01,
  0x81, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x18, 0x00, 0x18, 0x06, 0x00,
  0x0C, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x03, 0x80, 0x07, 0x03, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0C, 0x01, 0xE0, 0x1E, 0x81,
  0xC6, 0x3C, 0x1B, 0xC0, 0x68, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x10,
  0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x03, 0x80,
  0xE0, 0x01, 0xC0, 0x0C, 0x00, 0xC0, 0x01, 0x80, 0x60, 0x00, 0x60, 0x18,
  0x00, 0x0C, 0x0C, 0x00, 0x03, 0x02, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x30,
  0x60, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xF0, 0x1C, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x18, 0x03, 0x80, 0x01, 0x80, 0x60, 0x00, 0x30,
  0x18, 0x00, 0x02, 0x03, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x0C, 0x18, 0x00,
  0x01, 0x82, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x63, 0x00, 0x00, 0x0C, 0x60, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0x21, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x01, 0x86,
  0x00, 0x00, 0x20, 0x60, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x60, 0x18, 0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x1C, 0x07, 0x80, 0x01,
  0xFF, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0D, 0x80, 0x00,
  0x06, 0x40, 0x00, 0x01, 0x10, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x06, 0x08, 0x00, 0x03, 0x06,
  0x00, 0x01, 0x81, 0x80, 0x00, 0x60, 0x60, 0x00, 0x30, 0x18, 0x00, 0x18,
  0x06, 0x00, 0x0C, 0x01, 0x00, 0x03, 0x00, 0xC0, 0x01, 0x80, 0x30, 0x00,
  0xC0, 0x0C, 0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x20,
  0x06, 0x00, 0x18, 0x01, 0x80, 0x06, 0x00, 0xC0, 0x01, 0x80, 0x60, 0x00,
  0x60, 0x30, 0x00, 0x10, 0x0C, 0x00, 0x04, 0x06, 0x00, 0x03, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00,
  0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x87, 0xF0,
  0x00, 0x33, 0xFF, 0x80, 0x05, 0xC0, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x38,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x83, 0x00, 0x00, 0x30, 0x60, 0x00,
  0x06, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x30, 0x30, 0x00, 0x06, 0x02,
  0x00, 0x00, 0x80, 0x60, 0x00, 0x30, 0x0C, 0x00, 0x0C, 0x00, 0xC0, 0x03,
  0x00, 0x1C, 0x00, 0xE0, 0x01, 0xE0, 0x78, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x01, 0xFF, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x18, 0x0F, 0xC0, 0x18, 0x7F, 0xF0, 0x10, 0xC0, 0x38,
  0x33, 0x00, 0x1C, 0x36, 0x00, 0x0C, 0x3C, 0x00, 0x06, 0x28, 0x00, 0x06,
  0x30, 0x00, 0x02, 0x70, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03,
  0x60, 0x00, 0x03, 0x40, 0x00, 0x03, 0x40, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x02, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06,
  0xC0, 0x00, 0x04, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0x60, 0x00, 0x18,
  0x60, 0x00, 0x18, 0x60, 0x00, 0x30, 0x30, 0x00, 0x70, 0x38, 0x00, 0xE0,
  0x1C, 0x01, 0xC0, 0x0E, 0x03, 0x80, 0x07, 0xFE, 0x00, 0x00, 0xF0, 0x00,
  0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x30, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x30, 0x00, 0x30, 0x03, 0x00,
  0x00, 0xC0, 0x10, 0x00, 0x06, 0x01, 0x80, 0x00, 0x30, 0x08, 0x00, 0x00,
  0x80, 0xC0, 0x00, 0x04, 0x06, 0x00, 0x00, 0x20, 0x30, 0x00, 0x03, 0x01,
  0x00, 0x00, 0x18, 0x08, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x0C, 0x03, 0x00,
  0x00, 0x60, 0x18, 0x00, 0x06, 0x00, 0x40, 0x00, 0x70, 0x03, 0x00, 0x07,
  0x00, 0x0C, 0x00, 0x70, 0x00, 0x38, 0x0F, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0,
  0x01, 0x80, 0x1C, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x18, 0x0C, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x06, 0x06, 0x00, 0x00, 0x10, 0x20, 0x00, 0x00, 0x83,
  0x00, 0x00, 0x04, 0x18, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x03, 0x04, 0x00,
  0x00, 0x18, 0x20, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00,
  0x60, 0x60, 0x00, 0x06, 0x03, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x03, 0x00,
  0x70, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x7F, 0xE0,
  0x01, 0xE0, 0x70, 0x03, 0x80, 0x18, 0x07, 0x00, 0x1C, 0x0E, 0x00, 0x0C,
  0x0C, 0x00, 0x06, 0x18, 0x00, 0x06, 0x18, 0x00, 0x06, 0x30, 0x00, 0x06,
  0x30, 0x00, 0x02, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x40, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x06,
  0x80, 0x00, 0x06, 0x80, 0x00, 0x06, 0x80, 0x00, 0x06, 0x80, 0x00, 0x06,
  0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x1C, 0x40, 0x00, 0x3C,
  0x60, 0x00, 0x6C, 0x60, 0x00, 0xC8, 0x30, 0x01, 0x98, 0x1C, 0x07, 0x18,
  0x0F, 0xFE, 0x18, 0x03, 0xF0, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x7F, 0x80, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0x03, 0xC1, 0xE0, 0x40, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0x01, 0xC0, 0xE0, 0x60, 0x00, 0x00, 0x60, 0x0F, 0x00, 0xF0, 0x04,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x06, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80,
  0x38, 0x03, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x10, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF8, 0x08, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x7F,
  0xE0, 0x1C, 0x0E, 0x06, 0x00, 0xC1, 0x80, 0x0C, 0x60, 0x01, 0x8C, 0x00,
  0x13, 0x00, 0x03, 0x60, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x02, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x0E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x60, 0x01, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x1C,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x20, 0x0C, 0x00,
  0x00, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x7E, 0x00, 0x0C, 0x06, 0x00, 0x0F,
  0xF8, 0x00, 0x60, 0x60, 0x00, 0xC0, 0x60, 0x03, 0x03, 0x00, 0x0C, 0x01,
  0x80, 0x08, 0x30, 0x00, 0xC0, 0x0C, 0x00, 0x41, 0x80, 0x0C, 0x00, 0x60,
  0x02, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x10, 0xC0, 0x06, 0x00, 0x10, 0x00,
  0x84, 0x00, 0x60, 0x01, 0x80, 0x04, 0x60, 0x02, 0x00, 0x0C, 0x00, 0x23,
  0x00, 0x30, 0x00, 0x60, 0x03, 0x30, 0x01, 0x80, 0x02, 0x00, 0x19, 0x80,
  0x18, 0x00, 0x30, 0x00, 0xCC, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x40, 0x04,
  0x00, 0x0C, 0x00, 0x36, 0x00, 0x60, 0x00, 0x40, 0x01, 0x30, 0x03, 0x00,
  0x06, 0x00, 0x19, 0x80, 0x18, 0x00, 0x30, 0x00, 0xC8, 0x00, 0x80, 0x01,
  0x80, 0x06, 0x40, 0x0C, 0x00, 0x08, 0x00, 0x22, 0x00, 0x60, 0x00, 0x40,
  0x03, 0x30, 0x03, 0x00, 0x06, 0x00, 0x19, 0x80, 0x10, 0x00, 0x30, 0x00,
  0x8C, 0x00, 0x80, 0x03, 0x00, 0x0C, 0x60, 0x04, 0x00, 0x18, 0x00, 0x63,
  0x00, 0x20, 0x01, 0xC0, 0x06, 0x18, 0x01, 0x00, 0x0A, 0x00, 0x30, 0xC0,
  0x0C, 0x00, 0x90, 0x03, 0x06, 0x00, 0x60, 0x0C, 0xC0, 0x30, 0x30, 0x03,
  0x00, 0xC6, 0x03, 0x00, 0x80, 0x0C, 0x1C, 0x18, 0x30, 0x06, 0x00, 0x3F,
  0x80, 0xFF, 0x00, 0x30, 0x00, 0x70, 0x01, 0xC0, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x18, 0x00, 0x00, 0x01, 0xF0, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x2C, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x01, 0x10, 0x00, 0x00, 0x06,
  0x20, 0x00, 0x00, 0x08, 0x40, 0x00, 0x00, 0x30, 0x80, 0x00, 0x00, 0x41,
  0x80, 0x00, 0x01, 0x83, 0x00, 0x00, 0x02, 0x06, 0x00, 0x00, 0x0C, 0x0C,
  0x00, 0x00, 0x10, 0x08, 0x00, 0x00, 0x60, 0x10, 0x00, 0x00, 0xC0, 0x20,
  0x00, 0x03, 0x00, 0x60, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x18, 0x01, 0x80,
  0x00, 0x30, 0x03, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x01, 0x80, 0x04, 0x00,
  0x06, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x80, 0x00, 0xC0, 0x03, 0x00, 0x01, 0x80, 0x04,
  0x00, 0x01, 0x00, 0x18, 0x00, 0x02, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFC, 0x01, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x30, 0x08, 0x00,
  0x00, 0x60, 0x30, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x00, 0x81, 0x80, 0x00,
  0x01, 0x03, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00,
  0x0C, 0x60, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x00, 0x58, 0x00, 0x00, 0x00, 0xC0, 0x00, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x80, 0x00, 0x30, 0x02, 0x00, 0x00, 0x60, 0x18, 0x00, 0x01, 0x80,
  0x60, 0x00, 0x06, 0x01, 0x80, 0x00, 0x08, 0x06, 0x00, 0x00, 0x20, 0x10,
  0x00, 0x00, 0x80, 0xC0, 0x00, 0x06, 0x03, 0x00, 0x00, 0x18, 0x0C, 0x00,
  0x00, 0x60, 0x30, 0x00, 0x03, 0x00, 0x80, 0x00, 0x0C, 0x02, 0x00, 0x00,
  0x60, 0x18, 0x00, 0x01, 0x80, 0x60, 0x00, 0x0C, 0x01, 0x80, 0x00, 0xE0,
  0x06, 0x00, 0x0F, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x03,
  0x00, 0x03, 0xC0, 0x0C, 0x00, 0x03, 0x80, 0x30, 0x00, 0x07, 0x00, 0xC0,
  0x00, 0x0C, 0x02, 0x00, 0x00, 0x18, 0x08, 0x00, 0x00, 0x60, 0x60, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x06, 0x06, 0x00, 0x00, 0x18, 0x10, 0x00, 0x00,
  0x60, 0x40, 0x00, 0x01, 0x83, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x10,
  0x30, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x03, 0x02, 0x00, 0x00, 0x18, 0x08,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x03, 0x01, 0x80, 0x00, 0x18, 0x06, 0x00,
  0x01, 0xC0, 0x18, 0x00, 0x0E, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xE0,
  0x1C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x30, 0x03, 0x00, 0x00,
  0xE0, 0x18, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x06, 0x06, 0x00, 0x00, 0x0C,
  0x18, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x03, 0x08,
  0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0xC4, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0x04, 0x30, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x02,
  0x0C, 0x00, 0x00, 0x18, 0x10, 0x00, 0x00, 0x40, 0x60, 0x00, 0x03, 0x01,
  0x80, 0x00, 0x18, 0x03, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x07, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x38, 0x03, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xC0,
  0x01, 0xE0, 0x00, 0x80, 0x00, 0x70, 0x00, 0x80, 0x00, 0x38, 0x01, 0x80,
  0x00, 0x1C, 0x01, 0x80, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x06, 0x01, 0x80,
  0x00, 0x06, 0x01, 0x00, 0x00, 0x06, 0x01, 0x00, 0x00, 0x02, 0x03, 0x00,
  0x00, 0x03, 0x03, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x03, 0x02, 0x00, 0x00, 0x03, 0x02, 0x00, 0x00, 0x03, 0x06, 0x00,
  0x00, 0x02, 0x06, 0x00, 0x00, 0x02, 0x06, 0x00, 0x00, 0x06, 0x06, 0x00,
  0x00, 0x06, 0x04, 0x00, 0x00, 0x06, 0x04, 0x00, 0x00, 0x06, 0x0C, 0x00,
  0x00, 0x04, 0x0C, 0x00, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x0C, 0x0C, 0x00,
  0x00, 0x0C, 0x08, 0x00, 0x00, 0x0C, 0x08, 0x00, 0x00, 0x0C, 0x18, 0x00,
  0x00, 0x08, 0x18, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x18, 0x10, 0x00,
  0x00, 0x18, 0x10, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x30, 0x30, 0x00,
  0x00, 0x60, 0x30, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0xC0, 0x20, 0x00,
  0x01, 0x80, 0x20, 0x00, 0x03, 0x80, 0x60, 0x00, 0x07, 0x00, 0x60, 0x00,
  0x0E, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x60, 0x00, 0xF0, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0x80, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x38,
  0x03, 0x80, 0x01, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x01, 0x80, 0x1C, 0x00,
  0x01, 0x80, 0x30, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x06, 0x04, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x18, 0x20, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x80, 0x03, 0xFF, 0xE3, 0x00,
  0x07, 0xFF, 0xC6, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x02, 0x10, 0x00,
  0x00, 0x04, 0x20, 0x00, 0x00, 0x18, 0x40, 0x00, 0x00, 0x31, 0x80, 0x00,
  0x00, 0x61, 0x00, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x01, 0x04, 0x00, 0x00,
  0x06, 0x0C, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00,
  0x30, 0x20, 0x00, 0x00, 0x60, 0x60, 0x00, 0x01, 0x80, 0x60, 0x00, 0x07,
  0x00, 0xC0, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x0F, 0x80,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x0C, 0x00, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x08, 0x00,
  0x00, 0x06, 0x00, 0x80, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x06, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x04, 0x01, 0x80, 0x00, 0x00,
  0x40, 0x10, 0x00, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x30, 0x00,
  0x00, 0x0C, 0x03, 0x00, 0x00, 0x00, 0x80, 0x30, 0x00, 0x00, 0x08, 0x03,
  0x00, 0x00, 0x00, 0x80, 0x20, 0x00, 0x00, 0x18, 0x02, 0x00, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x01, 0x00, 0x60, 0x00,
  0x00, 0x10, 0x06, 0x00, 0x00, 0x03, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xFF, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x02,
  0x00, 0xC0, 0x00, 0x00, 0x20, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x80, 0x00,
  0x00, 0x60, 0x08, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x00, 0x60, 0x18,
  0x00, 0x00, 0x04, 0x01, 0x80, 0x00, 0x00, 0x40, 0x10, 0x00, 0x00, 0x0C,
  0x01, 0x00, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x30, 0x00, 0x00, 0x08, 0x03, 0x00, 0x00, 0x00, 0x80, 0x20,
  0x00, 0x00, 0x18, 0x02, 0x00, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x18,
  0x06, 0x00, 0x00, 0x01, 0x00, 0x60, 0x00, 0x00, 0x10, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x40, 0x00, 0x00, 0x30, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x40,
  0x10, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x08, 0x02, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x10, 0x04, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x02, 0x00,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x40, 0x10, 0x00, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x02, 0x00, 0x00, 0x30,
  0x10, 0x00, 0x01, 0x81, 0x80, 0x00, 0x18, 0x0C, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x04, 0x01, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x03, 0x00, 0x60, 0x00,
  0x30, 0x03, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x03, 0x80,
  0x01, 0xC0, 0x78, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x00,
  0x70, 0x02, 0x00, 0x00, 0x38, 0x00, 0x80, 0x00, 0x1C, 0x00, 0x60, 0x00,
  0x0E, 0x00, 0x18, 0x00, 0x07, 0x00, 0x06, 0x00, 0x03, 0x80, 0x01, 0x80,
  0x01, 0xC0, 0x00, 0x40, 0x00, 0xE0, 0x00, 0x10, 0x00, 0x70, 0x00, 0x0C,
  0x00, 0x38, 0x00, 0x03, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x0E, 0x00, 0x00,
  0x30, 0x07, 0x00, 0x00, 0x08, 0x03, 0x80, 0x00, 0x02, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x18, 0x18, 0x00,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0x01, 0x0F, 0x00, 0x00, 0x00, 0x47, 0x60,
  0x00, 0x00, 0x33, 0x98, 0x00, 0x00, 0x0D, 0x83, 0x00, 0x00, 0x03, 0xC0,
  0xC0, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x08,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x18, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00,
  0x60, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x30, 0x00, 0x04, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x02, 0x00, 0x00, 0x60, 0x00, 0x80, 0x00,
  0x0C, 0x00, 0x60, 0x00, 0x03, 0x80, 0x18, 0x00, 0x00, 0x60, 0x06, 0x00,
  0x00, 0x0C, 0x01, 0x80, 0x00, 0x03, 0x00, 0x40, 0x00, 0x00, 0x60, 0x10,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF0, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xF0, 0x0A, 0x00, 0x00, 0x00, 0x0E, 0x00, 0xB0, 0x00,
  0x00, 0x01, 0xA0, 0x0B, 0x00, 0x00, 0x00, 0x16, 0x01, 0xB0, 0x00, 0x00,
  0x03, 0x60, 0x1B, 0x00, 0x00, 0x00, 0x26, 0x01, 0x90, 0x00, 0x00, 0x06,
  0x60, 0x11, 0x00, 0x00, 0x00, 0x44, 0x01, 0x18, 0x00, 0x00, 0x0C, 0x40,
  0x31, 0x80, 0x00, 0x00, 0x8C, 0x03, 0x18, 0x00, 0x00, 0x18, 0xC0, 0x30,
  0x80, 0x00, 0x03, 0x0C, 0x03, 0x08, 0x00, 0x00, 0x30, 0xC0, 0x20, 0xC0,
  0x00, 0x06, 0x08, 0x02, 0x0C, 0x00, 0x00, 0x60, 0x80, 0x60, 0xC0, 0x00,
  0x0C, 0x18, 0x06, 0x04, 0x00, 0x00, 0xC1, 0x80, 0x60, 0x40, 0x00, 0x18,
  0x18, 0x06, 0x04, 0x00, 0x01, 0x81, 0x80, 0x40, 0x60, 0x00, 0x30, 0x10,
  0x04, 0x06, 0x00, 0x02, 0x03, 0x00, 0xC0, 0x60, 0x00, 0x60, 0x30, 0x0C,
  0x02, 0x00, 0x04, 0x03, 0x00, 0xC0, 0x20, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0x08, 0x03, 0x00, 0x80, 0x30, 0x01, 0x80, 0x20, 0x08, 0x03, 0x00,
  0x30, 0x06, 0x01, 0x80, 0x10, 0x03, 0x00, 0x60, 0x18, 0x01, 0x00, 0x60,
  0x06, 0x01, 0x80, 0x10, 0x06, 0x00, 0x60, 0x18, 0x01, 0x80, 0xC0, 0x04,
  0x01, 0x00, 0x18, 0x0C, 0x00, 0x40, 0x30, 0x00, 0x81, 0x80, 0x0C, 0x03,
  0x00, 0x08, 0x18, 0x00, 0xC0, 0x30, 0x00, 0x83, 0x00, 0x0C, 0x03, 0x00,
  0x0C, 0x20, 0x00, 0xC0, 0x20, 0x00, 0xC6, 0x00, 0x08, 0x02, 0x00, 0x0C,
  0x40, 0x00, 0x80, 0x60, 0x00, 0x4C, 0x00, 0x18, 0x06, 0x00, 0x05, 0x80,
  0x01, 0x80, 0x60, 0x00, 0x58, 0x00, 0x18, 0x06, 0x00, 0x07, 0x00, 0x01,
  0x80, 0x40, 0x00, 0x70, 0x00, 0x10, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x03, 0x00, 0xE0, 0x00,
  0x00, 0x30, 0x0F, 0x00, 0x00, 0x02, 0x00, 0xF0, 0x00, 0x00, 0x60, 0x19,
  0x00, 0x00, 0x06, 0x01, 0x98, 0x00, 0x00, 0x60, 0x19, 0x80, 0x00, 0x06,
  0x01, 0x88, 0x00, 0x00, 0x60, 0x18, 0xC0, 0x00, 0x04, 0x01, 0x04, 0x00,
  0x00, 0xC0, 0x30, 0x60, 0x00, 0x0C, 0x03, 0x06, 0x00, 0x00, 0xC0, 0x30,
  0x20, 0x00, 0x0C, 0x03, 0x03, 0x00, 0x00, 0xC0, 0x30, 0x10, 0x00, 0x08,
  0x02, 0x01, 0x80, 0x01, 0x80, 0x60, 0x18, 0x00, 0x18, 0x06, 0x00, 0x80,
  0x01, 0x80, 0x60, 0x0C, 0x00, 0x18, 0x06, 0x00, 0xC0, 0x01, 0x00, 0x60,
  0x06, 0x00, 0x30, 0x04, 0x00, 0x60, 0x03, 0x00, 0xC0, 0x02, 0x00, 0x30,
  0x0C, 0x00, 0x30, 0x03, 0x00, 0xC0, 0x03, 0x00, 0x30, 0x0C, 0x00, 0x10,
  0x02, 0x00, 0x80, 0x01, 0x80, 0x60, 0x08, 0x00, 0x08, 0x06, 0x01, 0x80,
  0x00, 0xC0, 0x60, 0x18, 0x00, 0x0C, 0x06, 0x01, 0x80, 0x00, 0x40, 0x60,
  0x18, 0x00, 0x06, 0x04, 0x01, 0x00, 0x00, 0x20, 0xC0, 0x30, 0x00, 0x03,
  0x0C, 0x03, 0x00, 0x00, 0x30, 0xC0, 0x30, 0x00, 0x01, 0x0C, 0x03, 0x00,
  0x00, 0x18, 0xC0, 0x30, 0x00, 0x00, 0x88, 0x02, 0x00, 0x00, 0x0D, 0x80,
  0x60, 0x00, 0x00, 0xD8, 0x06, 0x00, 0x00, 0x05, 0x80, 0x60, 0x00, 0x00,
  0x78, 0x06, 0x00, 0x00, 0x07, 0x80, 0x60, 0x00, 0x00, 0x30, 0x04, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x0F, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x30, 0x00, 0x70, 0x00, 0x18, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x02, 0x06, 0x00, 0x00, 0x02, 0x06,
  0x00, 0x00, 0x03, 0x04, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x03, 0x08, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x03, 0x18,
  0x00, 0x00, 0x02, 0x18, 0x00, 0x00, 0x02, 0x10, 0x00, 0x00, 0x06, 0x10,
  0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x06, 0x30,
  0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0x04, 0x20, 0x00, 0x00, 0x0C, 0x20,
  0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x0C, 0x60,
  0x00, 0x00, 0x08, 0x60, 0x00, 0x00, 0x18, 0x40, 0x00, 0x00, 0x18, 0x40,
  0x00, 0x00, 0x18, 0x40, 0x00, 0x00, 0x10, 0x40, 0x00, 0x00, 0x30, 0x40,
  0x00, 0x00, 0x30, 0x40, 0x00, 0x00, 0x20, 0x60, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x00, 0x40, 0x60, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x01, 0x80, 0x30,
  0x00, 0x03, 0x80, 0x18, 0x00, 0x07, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x03,
  0x00, 0x03, 0xC0, 0x06, 0x00, 0x01, 0x80, 0x08, 0x00, 0x01, 0x80, 0x10,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x02, 0x01, 0x80,
  0x00, 0x06, 0x03, 0x00, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x18, 0x18, 0x00,
  0x00, 0x30, 0x30, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x01, 0x01, 0x00, 0x00, 0x06, 0x02, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00,
  0x10, 0x18, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x03,
  0x00, 0x80, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0xC0,
  0x0C, 0x00, 0x07, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F,
  0x00, 0xE0, 0x00, 0x18, 0x00, 0x30, 0x00, 0x70, 0x00, 0x18, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0xC0, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x06, 0x03, 0x00,
  0x00, 0x06, 0x03, 0x00, 0x00, 0x02, 0x06, 0x00, 0x00, 0x02, 0x06, 0x00,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x03, 0x18, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x03, 0x18, 0x00,
  0x00, 0x02, 0x18, 0x00, 0x00, 0x02, 0x10, 0x00, 0x00, 0x06, 0x30, 0x00,
  0x00, 0x06, 0x30, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x06, 0x30, 0x00,
  0x00, 0x04, 0x30, 0x00, 0x00, 0x04, 0x20, 0x00, 0x00, 0x0C, 0x60, 0x00,
  0x00, 0x0C, 0x60, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x0C, 0x60, 0x00,
  0x00, 0x08, 0x60, 0x00, 0x00, 0x18, 0x40, 0x00, 0x00, 0x18, 0x40, 0x00,
  0x00, 0x18, 0x40, 0x00, 0x00, 0x10, 0x40, 0x00, 0x00, 0x30, 0x40, 0x00,
  0x00, 0x30, 0x40, 0x00, 0x00, 0x20, 0x60, 0x00, 0x00, 0x60, 0x60, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x01, 0x80, 0x30, 0x00,
  0x03, 0x80, 0x18, 0x00, 0x07, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3E,
  0x70, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x03, 0x00, 0x01, 0xC0, 0x04, 0x00, 0x01, 0xC0, 0x08, 0x00,
  0x01, 0x80, 0x30, 0x00, 0x01, 0x80, 0x60, 0x00, 0x01, 0x00, 0xC0, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x06, 0x02, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00,
  0x18, 0x18, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00,
  0xC0, 0x80, 0x00, 0x01, 0x01, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x0C,
  0x0C, 0x00, 0x00, 0x10, 0x18, 0x00, 0x00, 0x60, 0x30, 0x00, 0x01, 0x80,
  0x40, 0x00, 0x03, 0x00, 0x80, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x70, 0x06,
  0x00, 0x01, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x20,
  0x00, 0xC0, 0x00, 0x40, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00,
  0x03, 0x00, 0x06, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x10, 0x00,
  0x0C, 0x00, 0x20, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x18, 0x01, 0x80, 0x00,
  0x30, 0x03, 0x00, 0x00, 0x30, 0x04, 0x00, 0x00, 0x60, 0x08, 0x00, 0x00,
  0xC0, 0x30, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x03,
  0x01, 0x80, 0x00, 0x03, 0x02, 0x00, 0x00, 0x06, 0x04, 0x00, 0x00, 0x0C,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x78, 0x07, 0x80, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x03,
  0x80, 0x18, 0x00, 0x03, 0x00, 0x60, 0x00, 0x03, 0x01, 0x80, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x30,
  0x30, 0x00, 0x00, 0x60, 0x40, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x03,
  0x08, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0x30,
  0x60, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x07, 0x01,
  0x80, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x70, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xE0, 0x1E, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x02, 0x00, 0x00, 0x03,
  0x02, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x02,
  0x06, 0x00, 0x00, 0x02, 0x06, 0x00, 0x00, 0x06, 0x04, 0x00, 0x00, 0x06,
  0x04, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x04,
  0x0C, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x0C, 0x08, 0x00, 0x00, 0x0C,
  0x08, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0x08,
  0x18, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x18, 0x10, 0x00, 0x00, 0x18,
  0x30, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x10, 0x30, 0x00, 0x00, 0x10,
  0x30, 0x00, 0x00, 0x30, 0x20, 0x00, 0x00, 0x30, 0x20, 0x00, 0x00, 0x30,
  0x60, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x20, 0x60, 0x00, 0x00, 0x20,
  0x60, 0x00, 0x00, 0x60, 0x40, 0x00, 0x00, 0x60, 0x40, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x01, 0x80, 0x60, 0x00, 0x03, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00,
  0x0E, 0x01, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x01, 0xB0,
  0x00, 0x00, 0x04, 0xC0, 0x00, 0x00, 0x31, 0x00, 0x00, 0x00, 0xC4, 0x00,
  0x00, 0x06, 0x18, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x03, 0x06, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x60, 0x20, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x20, 0x0C, 0x00, 0x01, 0x80,
  0x30, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x30, 0x01, 0x00, 0x00, 0x80, 0x04,
  0x00, 0x06, 0x00, 0x18, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x18, 0x00, 0x60, 0x00, 0x20, 0x03,
  0x00, 0x00, 0x80, 0x0C, 0x00, 0x03, 0x00, 0x20, 0x00, 0x0C, 0x01, 0x80,
  0x00, 0x30, 0x04, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x01, 0x00, 0x80, 0x00,
  0x04, 0x06, 0x00, 0x00, 0x10, 0x10, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x23,
  0x00, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x03, 0x20, 0x00, 0x00, 0x0D, 0x80,
  0x00, 0x00, 0x34, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x64, 0x00, 0x00, 0x70, 0x00, 0x01, 0x90, 0x00,
  0x01, 0x40, 0x00, 0x04, 0x40, 0x00, 0x0D, 0x00, 0x00, 0x31, 0x80, 0x00,
  0x24, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x98, 0x00, 0x06, 0x18, 0x00, 0x06,
  0x60, 0x00, 0x18, 0x60, 0x00, 0x11, 0x80, 0x00, 0x41, 0x80, 0x00, 0xC6,
  0x00, 0x03, 0x06, 0x00, 0x02, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x20,
  0x00, 0x20, 0x60, 0x00, 0x60, 0x80, 0x01, 0x81, 0x80, 0x01, 0x02, 0x00,
  0x06, 0x06, 0x00, 0x0C, 0x08, 0x00, 0x30, 0x18, 0x00, 0x20, 0x20, 0x00,
  0xC0, 0x60, 0x01, 0x80, 0x80, 0x02, 0x00, 0x80, 0x06, 0x03, 0x00, 0x18,
  0x02, 0x00, 0x10, 0x0C, 0x00, 0x60, 0x08, 0x00, 0xC0, 0x30, 0x01, 0x00,
  0x30, 0x02, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x0C, 0x01, 0x00, 0x10, 0x06, 0x00, 0x30,
  0x0C, 0x00, 0x40, 0x10, 0x00, 0xC0, 0x20, 0x01, 0x00, 0xC0, 0x03, 0x01,
  0x80, 0x04, 0x03, 0x00, 0x0C, 0x06, 0x00, 0x18, 0x08, 0x00, 0x30, 0x30,
  0x00, 0x60, 0x60, 0x00, 0xC0, 0xC0, 0x01, 0x81, 0x80, 0x03, 0x02, 0x00,
  0x06, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x30, 0x00, 0x10, 0x60, 0x00,
  0x60, 0x80, 0x00, 0x43, 0x00, 0x01, 0x86, 0x00, 0x01, 0x0C, 0x00, 0x06,
  0x18, 0x00, 0x06, 0x20, 0x00, 0x08, 0x40, 0x00, 0x19, 0x80, 0x00, 0x23,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x8C, 0x00, 0x01, 0x90, 0x00, 0x02, 0x60,
  0x00, 0x06, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x1A, 0x00, 0x00, 0x34, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x03, 0x00, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x00, 0x40, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x03, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x01, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x60, 0x00, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x00, 0x0C, 0xC0, 0x00,
  0x00, 0x00, 0xD8, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x19, 0x80, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x00, 0x20, 0x80, 0x00,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x18, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x18, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00,
  0x0D, 0x80, 0x00, 0x00, 0x66, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x0C,
  0x30, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x01, 0x83, 0x00, 0x00, 0x0C, 0x04,
  0x00, 0x00, 0x60, 0x18, 0x00, 0x01, 0x80, 0x60, 0x00, 0x0C, 0x00, 0x80,
  0x00, 0x60, 0x03, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x0C, 0x00, 0x10, 0x00,
  0x60, 0x00, 0x60, 0x01, 0x80, 0x01, 0x80, 0x0C, 0x00, 0x06, 0x00, 0x60,
  0x00, 0x0C, 0x01, 0x80, 0x00, 0x30, 0x0C, 0x00, 0x00, 0xC0, 0x60, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00,
  0x21, 0x80, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x05,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x80, 0x60, 0x30, 0x18,
  0x0C, 0x02, 0x01, 0x00, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x02, 0x01, 0x00,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x02, 0x01, 0x00, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x02, 0x01, 0x00, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x02, 0x01, 0x00,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x02, 0x01, 0x00, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x02, 0x01, 0x00, 0xC0, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x07, 0xF8, 0x03, 0xF8, 0x00, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x0E, 0x00, 0x05, 0x80, 0x06, 0xC0, 0x02, 0x60, 0x03, 0x30, 0x01, 0x08,
  0x01, 0x84, 0x00, 0x83, 0x00, 0xC1, 0x80, 0x40, 0xC0, 0x60, 0x60, 0x60,
  0x10, 0x30, 0x08, 0x30, 0x06, 0x18, 0x03, 0x18, 0x01, 0x8C, 0x00, 0xCC,
  0x00, 0x66, 0x00, 0x16, 0x00, 0x0F, 0x00, 0x06, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xE0, 0xC0, 0xC1, 0x81, 0x83, 0x03, 0x03, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0xFC, 0x00, 0x1C, 0x07, 0x00, 0x38, 0x00, 0xC0, 0x38, 0x00,
  0x30, 0x18, 0x00, 0x18, 0x18, 0x00, 0x04, 0x08, 0x00, 0x02, 0x0C, 0x00,
  0x01, 0x06, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00,
  0x3F, 0xFE, 0x00, 0xFF, 0xFF, 0x01, 0xE0, 0x01, 0x81, 0xC0, 0x00, 0xC1,
  0x80, 0x00, 0x61, 0x80, 0x00, 0x21, 0x80, 0x00, 0x10, 0xC0, 0x00, 0x18,
  0x40, 0x00, 0x0C, 0x60, 0x00, 0x06, 0x30, 0x00, 0x03, 0x18, 0x00, 0x03,
  0x0C, 0x00, 0x03, 0x86, 0x00, 0x03, 0xC3, 0x00, 0x03, 0x60, 0x80, 0x03,
  0xB0, 0x60, 0x03, 0x18, 0x1C, 0x07, 0x0C, 0x07, 0xFE, 0x06, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x0F,
  0x80, 0x0C, 0x1F, 0xF8, 0x06, 0x38, 0x0E, 0x03, 0x30, 0x03, 0x81, 0xB0,
  0x00, 0xC0, 0xA0, 0x00, 0x20, 0x60, 0x00, 0x18, 0x70, 0x00, 0x0C, 0x30,
  0x00, 0x06, 0x18, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x84, 0x00, 0x00, 0xC2,
  0x00, 0x00, 0x63, 0x00, 0x00, 0x31, 0x80, 0x00, 0x18, 0xC0, 0x00, 0x0C,
  0x60, 0x00, 0x06, 0x20, 0x00, 0x03, 0x30, 0x00, 0x01, 0x18, 0x00, 0x00,
  0x8C, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x62, 0x00, 0x00, 0x31, 0x00, 0x00,
  0x11, 0x80, 0x00, 0x18, 0xC0, 0x00, 0x0C, 0x60, 0x00, 0x04, 0x30, 0x00,
  0x06, 0x18, 0x00, 0x02, 0x0C, 0x00, 0x03, 0x0F, 0x00, 0x03, 0x06, 0xC0,
  0x01, 0x83, 0x30, 0x03, 0x81, 0x8E, 0x03, 0x80, 0x83, 0xFF, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0xE0, 0x38,
  0x01, 0x80, 0x0C, 0x03, 0x00, 0x06, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x03,
  0x0C, 0x00, 0x03, 0x18, 0x00, 0x03, 0x18, 0x00, 0x03, 0x30, 0x00, 0x03,
  0x30, 0x00, 0x03, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x08,
  0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x30, 0x60, 0x00, 0x20,
  0x30, 0x00, 0x60, 0x38, 0x01, 0xC0, 0x1C, 0x07, 0x80, 0x0F, 0xFE, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x08, 0x00, 0x1F, 0x00, 0x80, 0x07, 0xFC, 0x18, 0x01,
  0xC0, 0x71, 0x80, 0x38, 0x01, 0x98, 0x06, 0x00, 0x0D, 0x80, 0xC0, 0x00,
  0x50, 0x0C, 0x00, 0x07, 0x01, 0x80, 0x00, 0x30, 0x18, 0x00, 0x03, 0x03,
  0x00, 0x00, 0x30, 0x30, 0x00, 0x03, 0x02, 0x00, 0x00, 0x20, 0x60, 0x00,
  0x06, 0x06, 0x00, 0x00, 0x60, 0x60, 0x00, 0x06, 0x04, 0x00, 0x00, 0x60,
  0x40, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x0C, 0x0C, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x08,
  0x08, 0x00, 0x00, 0x80, 0x80, 0x00, 0x18, 0x08, 0x00, 0x01, 0x80, 0x80,
  0x00, 0x18, 0x08, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x10, 0x0C, 0x00, 0x03,
  0x00, 0x40, 0x00, 0x70, 0x06, 0x00, 0x0F, 0x00, 0x70, 0x03, 0xB0, 0x03,
  0x80, 0xE3, 0x00, 0x1F, 0xF8, 0x20, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0xE0, 0x38, 0x01, 0xC0, 0x0C, 0x03, 0x00,
  0x06, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x18, 0x00,
  0x03, 0x18, 0x00, 0x03, 0x30, 0x00, 0x03, 0x30, 0x00, 0x03, 0x20, 0x00,
  0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x30, 0x18, 0x00,
  0xE0, 0x0E, 0x03, 0xC0, 0x07, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x03, 0xFC, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00,
  0x7F, 0xFE, 0x0F, 0xFF, 0xC0, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xFF, 0x83, 0x00, 0x38, 0x0E, 0x30, 0x06, 0x00, 0x33, 0x00,
  0xC0, 0x01, 0xB0, 0x18, 0x00, 0x0A, 0x01, 0x80, 0x00, 0xE0, 0x30, 0x00,
  0x06, 0x03, 0x00, 0x00, 0x60, 0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0x40,
  0x40, 0x00, 0x04, 0x0C, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x0C, 0x0C, 0x00,
  0x00, 0xC0, 0x80, 0x00, 0x0C, 0x08, 0x00, 0x00, 0x81, 0x80, 0x00, 0x08,
  0x18, 0x00, 0x01, 0x81, 0x80, 0x00, 0x18, 0x18, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x18, 0x10, 0x00, 0x01, 0x01, 0x00, 0x00, 0x10, 0x10, 0x00, 0x03,
  0x01, 0x00, 0x00, 0x30, 0x10, 0x00, 0x03, 0x01, 0x00, 0x00, 0x30, 0x18,
  0x00, 0x06, 0x01, 0x80, 0x00, 0x60, 0x18, 0x00, 0x0E, 0x00, 0xC0, 0x01,
  0xE0, 0x0E, 0x00, 0x76, 0x00, 0x70, 0x1C, 0x60, 0x03, 0xFF, 0x84, 0x00,
  0x07, 0xC0, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x40, 0x00, 0x30, 0x06, 0x00, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80,
  0x38, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x02, 0x01, 0xE0, 0x06, 0x0F, 0xFC, 0x06, 0x1C, 0x0E,
  0x06, 0x30, 0x06, 0x06, 0x60, 0x03, 0x04, 0xC0, 0x03, 0x05, 0x80, 0x01,
  0x0D, 0x00, 0x01, 0x0F, 0x00, 0x01, 0x0E, 0x00, 0x01, 0x0C, 0x00, 0x01,
  0x0C, 0x00, 0x01, 0x0C, 0x00, 0x03, 0x18, 0x00, 0x03, 0x18, 0x00, 0x03,
  0x18, 0x00, 0x03, 0x18, 0x00, 0x03, 0x10, 0x00, 0x02, 0x10, 0x00, 0x06,
  0x30, 0x00, 0x06, 0x30, 0x00, 0x06, 0x30, 0x00, 0x06, 0x30, 0x00, 0x06,
  0x20, 0x00, 0x04, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x0C,
  0x60, 0x00, 0x0C, 0x60, 0x00, 0x08, 0x40, 0x00, 0x08, 0xC0, 0x00, 0x18,
  0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18, 0x80, 0x00, 0x10,
  0x01, 0xC0, 0x70, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x80, 0x20, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x10, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x02, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x00, 0x40, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x04, 0x03, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x01, 0xFC,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x06, 0x06, 0x00, 0x07,
  0x01, 0x80, 0x03, 0x80, 0x60, 0x01, 0xC0, 0x10, 0x00, 0xE0, 0x04, 0x00,
  0x70, 0x03, 0x00, 0x38, 0x00, 0xC0, 0x1C, 0x00, 0x30, 0x0C, 0x00, 0x0C,
  0x06, 0x00, 0x02, 0x03, 0x00, 0x00, 0x81, 0x80, 0x00, 0x60, 0xC0, 0x00,
  0x18, 0x60, 0x00, 0x06, 0x30, 0x00, 0x01, 0x9E, 0x00, 0x00, 0x4D, 0x80,
  0x00, 0x16, 0x30, 0x00, 0x0E, 0x0C, 0x00, 0x03, 0x01, 0x80, 0x00, 0xC0,
  0x60, 0x00, 0x30, 0x0C, 0x00, 0x08, 0x03, 0x00, 0x06, 0x00, 0x60, 0x01,
  0x80, 0x18, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x18,
  0x01, 0x00, 0x06, 0x00, 0xC0, 0x00, 0xC0, 0x30, 0x00, 0x38, 0x0C, 0x00,
  0x06, 0x03, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0x80, 0x20, 0x18, 0x06, 0x01, 0x80, 0x60, 0x10, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x02, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x40, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x04, 0x01, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x30, 0x7F, 0xC0, 0x0F, 0xF8, 0x03, 0x1C,
  0x07, 0x03, 0xC0, 0xE0, 0x33, 0x80, 0x30, 0x70, 0x06, 0x02, 0x60, 0x01,
  0x8C, 0x00, 0x30, 0x24, 0x00, 0x19, 0x80, 0x03, 0x06, 0xC0, 0x01, 0xB0,
  0x00, 0x30, 0x78, 0x00, 0x0A, 0x00, 0x01, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x10, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10,
  0xE0, 0x00, 0x18, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0xC0, 0x00,
  0x10, 0x00, 0x03, 0x08, 0x00, 0x01, 0x00, 0x00, 0x21, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x18, 0x00, 0x03, 0x00, 0x00, 0x61, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x18, 0x00, 0x03, 0x00, 0x00, 0x61, 0x80, 0x00, 0x20, 0x00, 0x06,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x43, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x20, 0x00, 0x04,
  0x00, 0x00, 0x86, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x86, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x84, 0x00, 0x00, 0x80, 0x00, 0x10, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x01, 0xE0, 0x02, 0x0F, 0xFC, 0x06, 0x1C, 0x0E, 0x06, 0x30, 0x06,
  0x06, 0x60, 0x03, 0x06, 0xC0, 0x03, 0x05, 0x80, 0x01, 0x0D, 0x00, 0x01,
  0x0F, 0x00, 0x01, 0x0E, 0x00, 0x01, 0x0C, 0x00, 0x01, 0x0C, 0x00, 0x01,
  0x0C, 0x00, 0x01, 0x18, 0x00, 0x03, 0x18, 0x00, 0x03, 0x18, 0x00, 0x03,
  0x18, 0x00, 0x03, 0x10, 0x00, 0x02, 0x10, 0x00, 0x06, 0x30, 0x00, 0x06,
  0x30, 0x00, 0x06, 0x30, 0x00, 0x06, 0x30, 0x00, 0x06, 0x20, 0x00, 0x04,
  0x20, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x0C,
  0x60, 0x00, 0x08, 0x40, 0x00, 0x08, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18,
  0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18, 0x80, 0x00, 0x10, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0xFC, 0x00, 0x3C, 0x07, 0x00, 0x38, 0x00, 0xC0, 0x38, 0x00,
  0x30, 0x18, 0x00, 0x18, 0x18, 0x00, 0x06, 0x18, 0x00, 0x03, 0x0C, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x22, 0x00, 0x00, 0x13, 0x00,
  0x00, 0x09, 0x80, 0x00, 0x04, 0xC0, 0x00, 0x06, 0x40, 0x00, 0x03, 0x60,
  0x00, 0x01, 0xB0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x24,
  0x00, 0x00, 0x12, 0x00, 0x00, 0x19, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x04,
  0x40, 0x00, 0x06, 0x20, 0x00, 0x03, 0x10, 0x00, 0x03, 0x0C, 0x00, 0x01,
  0x86, 0x00, 0x01, 0x83, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0xC0, 0x60, 0x00,
  0xC0, 0x18, 0x00, 0xE0, 0x07, 0x01, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x0C, 0x1F, 0xF8, 0x00, 0xC7, 0x01,
  0xC0, 0x0C, 0xC0, 0x0C, 0x00, 0xD8, 0x00, 0x60, 0x0A, 0x00, 0x02, 0x00,
  0xC0, 0x00, 0x30, 0x1C, 0x00, 0x03, 0x01, 0x80, 0x00, 0x30, 0x18, 0x00,
  0x01, 0x01, 0x80, 0x00, 0x10, 0x10, 0x00, 0x01, 0x03, 0x00, 0x00, 0x10,
  0x30, 0x00, 0x03, 0x03, 0x00, 0x00, 0x30, 0x30, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x30, 0x20, 0x00, 0x03, 0x02, 0x00, 0x00, 0x20, 0x60, 0x00, 0x02,
  0x06, 0x00, 0x00, 0x60, 0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0x60, 0x40,
  0x00, 0x04, 0x0C, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x0C, 0x0C, 0x00, 0x00,
  0x80, 0xC0, 0x00, 0x18, 0x0C, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x30, 0x1E,
  0x00, 0x06, 0x01, 0xB0, 0x00, 0xE0, 0x19, 0x80, 0x1C, 0x01, 0x8E, 0x03,
  0x80, 0x10, 0x7F, 0xE0, 0x01, 0x00, 0xF8, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0xE0, 0xC0, 0x70, 0x1C, 0x60,
  0x60, 0x03, 0x30, 0x60, 0x00, 0xD0, 0x60, 0x00, 0x28, 0x30, 0x00, 0x1C,
  0x30, 0x00, 0x06, 0x18, 0x00, 0x03, 0x18, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0x84, 0x00, 0x00, 0x46, 0x00, 0x00, 0x23, 0x00, 0x00, 0x31, 0x80, 0x00,
  0x18, 0x80, 0x00, 0x0C, 0x40, 0x00, 0x04, 0x60, 0x00, 0x02, 0x30, 0x00,
  0x03, 0x18, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x21, 0x00, 0x00, 0x10, 0x80, 0x00, 0x18, 0x40, 0x00, 0x0C, 0x20,
  0x00, 0x06, 0x10, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x06, 0x00, 0x01, 0x83,
  0x00, 0x01, 0xC0, 0xC0, 0x01, 0xE0, 0x70, 0x03, 0xB0, 0x1C, 0x07, 0x10,
  0x07, 0xFF, 0x08, 0x00, 0x78, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0xC0, 0x43,
  0xF8, 0x18, 0xE0, 0x03, 0x30, 0x00, 0x6C, 0x00, 0x0F, 0x00, 0x01, 0x40,
  0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x7F, 0xF0, 0x00, 0xE0, 0x3C, 0x01, 0x80, 0x0C, 0x03, 0x00, 0x06, 0x06,
  0x00, 0x02, 0x04, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0,
  0x00, 0x10, 0x60, 0x00, 0x30, 0x60, 0x00, 0x60, 0x30, 0x01, 0xC0, 0x1C,
  0x07, 0x80, 0x0F, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x01, 0x80, 0x08, 0x00,
  0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x30,
  0x3F, 0xFF, 0xFF, 0xF0, 0x60, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x03, 0x00, 0x18, 0x00, 0x7E, 0x00, 0xF0, 0x00, 0x0C, 0x00,
  0x01, 0x86, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x61, 0x80, 0x00, 0x30, 0x80,
  0x00, 0x10, 0x40, 0x00, 0x08, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x06, 0x18,
  0x00, 0x03, 0x0C, 0x00, 0x01, 0x84, 0x00, 0x00, 0x82, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x61, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x08,
  0x20, 0x00, 0x04, 0x30, 0x00, 0x06, 0x18, 0x00, 0x03, 0x0C, 0x00, 0x01,
  0x86, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x41, 0x00, 0x00, 0x21, 0x80, 0x00,
  0x30, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x0E, 0x18, 0x00,
  0x0E, 0x04, 0x00, 0x05, 0x03, 0x00, 0x07, 0x81, 0x80, 0x06, 0xC0, 0x60,
  0x06, 0x60, 0x38, 0x0E, 0x30, 0x0F, 0xFC, 0x10, 0x00, 0xF0, 0x00, 0x00,
  0xC0, 0x00, 0x02, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x04, 0x40, 0x00, 0x0C,
  0x60, 0x00, 0x08, 0x60, 0x00, 0x18, 0x60, 0x00, 0x10, 0x60, 0x00, 0x30,
  0x60, 0x00, 0x20, 0x20, 0x00, 0x60, 0x30, 0x00, 0x60, 0x30, 0x00, 0xC0,
  0x30, 0x00, 0xC0, 0x30, 0x01, 0x80, 0x30, 0x01, 0x80, 0x10, 0x03, 0x00,
  0x18, 0x03, 0x00, 0x18, 0x06, 0x00, 0x18, 0x06, 0x00, 0x18, 0x0C, 0x00,
  0x18, 0x0C, 0x00, 0x08, 0x08, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x10, 0x00,
  0x0C, 0x30, 0x00, 0x0C, 0x20, 0x00, 0x0C, 0x60, 0x00, 0x04, 0x40, 0x00,
  0x04, 0xC0, 0x00, 0x06, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x3C, 0x00,
  0x06, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x64, 0x00, 0x0E, 0x00, 0x06,
  0x40, 0x00, 0xB0, 0x00, 0x64, 0x00, 0x1B, 0x00, 0x0C, 0x60, 0x01, 0x30,
  0x00, 0xC6, 0x00, 0x33, 0x00, 0x18, 0x60, 0x03, 0x30, 0x01, 0x86, 0x00,
  0x63, 0x00, 0x30, 0x60, 0x06, 0x30, 0x03, 0x06, 0x00, 0xC3, 0x00, 0x30,
  0x60, 0x0C, 0x10, 0x06, 0x06, 0x00, 0x81, 0x00, 0x60, 0x60, 0x18, 0x10,
  0x0C, 0x06, 0x01, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x81, 0x80, 0x20, 0x60, 0x18, 0x18, 0x02, 0x06, 0x01, 0x83, 0x00,
  0x30, 0xC0, 0x18, 0x30, 0x03, 0x0C, 0x01, 0x86, 0x00, 0x30, 0x80, 0x18,
  0x60, 0x03, 0x18, 0x00, 0x86, 0x00, 0x31, 0x00, 0x08, 0xC0, 0x03, 0x30,
  0x00, 0x8C, 0x00, 0x33, 0x00, 0x09, 0x80, 0x03, 0x60, 0x00, 0xD8, 0x00,
  0x36, 0x00, 0x0D, 0x80, 0x03, 0x40, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x60, 0x18, 0x00, 0x0E, 0x01, 0x80,
  0x00, 0xC0, 0x18, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x60, 0x06, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x30, 0x18, 0x00, 0x03,
  0x01, 0x80, 0x00, 0x10, 0x30, 0x00, 0x01, 0x86, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0x90,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x06, 0x18, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x0C, 0x0C, 0x00, 0x01, 0x80, 0x60, 0x00, 0x30, 0x06, 0x00, 0x03, 0x00,
  0x30, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x01, 0x80,
  0x18, 0x00, 0x18, 0x03, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x0C, 0x0C, 0x00,
  0x00, 0x60, 0x01, 0x80, 0x00, 0x06, 0x01, 0x00, 0x00, 0x18, 0x02, 0x00,
  0x00, 0x30, 0x06, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x01, 0x80, 0x18, 0x00,
  0x06, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x30, 0x00, 0x40, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x08, 0x00, 0xC0,
  0x00, 0x10, 0x03, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x60, 0x18, 0x00,
  0x00, 0xC0, 0x30, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x01, 0x01, 0x80, 0x00,
  0x02, 0x06, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00,
  0x18, 0x60, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x23, 0x00, 0x00, 0x00,
  0x4C, 0x00, 0x00, 0x00, 0x98, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x03, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x60, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01,
  0x80, 0x30, 0x00, 0x00, 0x20, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00,
  0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x04, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x31, 0x81, 0xC0, 0x00, 0x8C, 0x01, 0x80,
  0x06, 0x20, 0x07, 0x00, 0x19, 0x80, 0x0E, 0x00, 0x44, 0x00, 0x18, 0x03,
  0x30, 0x00, 0x38, 0x18, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7C, 0x00,
};

const GFXglyph RobotoCondensed_ThinItalic65pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 10, 47, 12, 1, -46 },
  { 60, 10, 13, 16, 7, -49 },
  { 77, 33, 46, 31, 1, -46 },
  { 267, 27, 60, 31, 2, -53 },
  { 470, 31, 48, 41, 6, -47 },
  { 656, 29, 48, 34, 2, -47 },
  { 830, 4, 13, 11, 7, -49 },
  { 837, 18, 66, 17, 3, -51 },
  { 986, 18, 66, 18, -4, -51 },
  { 1135, 25, 25, 26, 4, -46 },
  { 1214, 26, 34, 31, 3, -39 },
  { 1325, 7, 13, 12, -2, -5 },
  { 1337, 13, 2, 17, 2, -22 },
  { 1341, 4, 4, 14, 1, -3 },
  { 1343, 26, 50, 22, -2, -46 },
  { 1506, 26, 48, 31, 3, -47 },
  { 1662, 14, 46, 31, 9, -46 },
  { 1743, 26, 47, 31, 2, -47 },
  { 1896, 27, 48, 31, 2, -47 },
  { 2058, 26, 46, 31, 2, -46 },
  { 2208, 27, 47, 31, 4, -46 },
  { 2367, 24, 47, 31, 3, -46 },
  { 2508, 25, 46, 31, 6, -46 },
  { 2652, 29, 48, 31, 1, -47 },
  { 2826, 24, 47, 31, 5, -47 },
  { 2967, 9, 34, 11, 1, -33 },
  { 3006, 12, 41, 11, -2, -33 },
  { 3068, 24, 26, 29, 3, -34 },
  { 3146, 24, 16, 31, 4, -29 },
  { 3194, 24, 26, 29, 2, -34 },
  { 3272, 19, 48, 25, 6, -47 },
  { 3386, 45, 59, 51, 2, -45 },
  { 3718, 31, 46, 33, -2, -46 },
  { 3897, 30, 46, 34, 2, -46 },
  { 4070, 30, 48, 36, 4, -47 },
  { 4250, 32, 46, 36, 2, -46 },
  { 4434, 32, 46, 32, 2, -46 },
  { 4618, 32, 46, 32, 2, -46 },
  { 4802, 31, 48, 38, 4, -47 },
  { 4988, 36, 46, 39, 2, -46 },
  { 5195, 10, 46, 15, 3, -46 },
  { 5253, 29, 47, 31, 1, -46 },
  { 5424, 34, 46, 35, 2, -46 },
  { 5620, 22, 46, 29, 2, -46 },
  { 5747, 44, 46, 47, 2, -46 },
  { 6000, 36, 46, 39, 2, -46 },
  { 6207, 32, 48, 37, 3, -47 },
  { 6399, 31, 46, 33, 2, -46 },
  { 6578, 32, 55, 37, 3, -47 },
  { 6798, 31, 46, 36, 2, -46 },
  { 6977, 31, 48, 33, 2, -47 },
  { 7163, 30, 46, 33, 6, -46 },
  { 7336, 32, 47, 37, 4, -46 },
  { 7524, 30, 46, 33, 6, -46 },
  { 7697, 46, 46, 50, 6, -46 },
  { 7962, 36, 46, 33, -1, -46 },
  { 8169, 30, 46, 33, 6, -46 },
  { 8342, 34, 46, 33, 0, -46 },
  { 8538, 17, 63, 13, 1, -53 },
  { 8672, 9, 50, 21, 7, -46 },
  { 8729, 17, 63, 13, -4, -53 },
  { 8863, 17, 23, 23, 4, -46 },
  { 8912, 22, 2, 23, -3, 0 },
  { 8918, 7, 8, 17, 9, -48 },
  { 8925, 25, 36, 30, 1, -35 },
  { 9038, 25, 50, 31, 2, -49 },
  { 9195, 24, 36, 28, 2, -35 },
  { 9303, 28, 50, 31, 3, -49 },
  { 9478, 24, 36, 29, 2, -35 },
  { 9586, 19, 50, 18, 4, -50 },
  { 9705, 28, 48, 31, 0, -35 },
  { 9873, 24, 49, 30, 2, -49 },
  { 10020, 10, 46, 12, 2, -46 },
  { 10078, 22, 59, 13, -9, -46 },
  { 10241, 26, 49, 27, 2, -49 },
  { 10401, 10, 49, 12, 2, -49 },
  { 10463, 44, 35, 49, 1, -35 },
  { 10656, 24, 35, 30, 2, -35 },
  { 10761, 25, 36, 31, 2, -35 },
  { 10874, 28, 48, 31, -1, -35 },
  { 11042, 25, 48, 31, 3, -35 },
  { 11192, 19, 35, 19, 2, -35 },
  { 11276, 24, 36, 28, 1, -35 },
  { 11384, 13, 45, 18, 4, -44 },
  { 11458, 25, 35, 30, 3, -34 },
  { 11568, 24, 34, 27, 4, -34 },
  { 11670, 36, 34, 42, 5, -34 },
  { 11823, 28, 34, 27, -1, -34 },
  { 11942, 31, 47, 27, -3, -34 },
  { 12125, 26, 34, 27, 0, -34 },
  { 12236, 21, 65, 18, 2, -51 },
  { 12407, 11, 55, 13, 1, -46 },
  { 12483, 20, 65, 18, -4, -51 },
  { 12646, 30, 10, 38, 4, -24 },
};

const GFXfont RobotoCondensed_ThinItalic65pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ThinItalic65pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ThinItalic65pt7bGlyphs,
  0x20, 0x7E, 76
};

#endif // _ROBOTOCONDENSED_THINITALIC65PT7B_H_
