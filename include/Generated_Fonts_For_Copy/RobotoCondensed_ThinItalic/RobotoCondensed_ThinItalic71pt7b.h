#ifndef _ROBOTOCONDENSED_THINITALIC71PT7B_H_
#define _ROBOTOCONDENSED_THINITALIC71PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ThinItalic.ttf
// Size: 71pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ThinItalic71pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0x80, 0x10, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x40, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x20, 0x0C, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x00,
  0x30, 0x66, 0x0C, 0xC1, 0x98, 0x33, 0x0C, 0xC1, 0x98, 0x33, 0x06, 0x60,
  0xCC, 0x33, 0x06, 0x60, 0xCC, 0x19, 0x83, 0x00, 0x00, 0x00, 0x18, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x10, 0x01, 0x00, 0x00, 0x03,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x02, 0x00, 0x20, 0x00,
  0x00, 0x60, 0x06, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0x40, 0x04,
  0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x08,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x18, 0x01, 0x80, 0x03,
  0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x18, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00,
  0x20, 0x06, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0x60, 0x06, 0x00,
  0x00, 0x04, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x80, 0x08, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x18, 0x00, 0x00, 0x10, 0x01, 0x00, 0x00, 0x03, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x03, 0x00, 0x00, 0x02, 0x00, 0x20, 0x00, 0x00, 0x60, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0x40, 0x04, 0x00, 0x00, 0x0C,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x80, 0x00,
  0x01, 0x80, 0x18, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1E,
  0x03, 0x80, 0x01, 0xC0, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x01, 0xC0, 0x00,
  0xC0, 0x0C, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x18, 0x0C, 0x00, 0x00, 0xC0,
  0x60, 0x00, 0x03, 0x03, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0x30, 0x60, 0x00, 0x01, 0x83, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x61, 0x80, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x18,
  0x60, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x03, 0x06, 0x00, 0x00, 0x18, 0x18, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x1C, 0x07, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x01, 0xC0, 0x3C, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x70, 0x60,
  0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x06, 0x00,
  0x60, 0x00, 0x03, 0x80, 0x18, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x30,
  0x01, 0x80, 0x0C, 0x18, 0x00, 0x60, 0x03, 0x06, 0x00, 0x18, 0x01, 0x81,
  0x80, 0x06, 0x00, 0xC0, 0x60, 0x01, 0x80, 0x30, 0x18, 0x00, 0x40, 0x18,
  0x04, 0x00, 0x30, 0x0C, 0x01, 0x00, 0x0C, 0x07, 0x00, 0x60, 0x02, 0x01,
  0x80, 0x18, 0x01, 0x80, 0xC0, 0x06, 0x00, 0xE0, 0x60, 0x01, 0xC0, 0x30,
  0x18, 0x00, 0x30, 0x38, 0x0C, 0x00, 0x07, 0xFC, 0x06, 0x00, 0x00, 0xFE,
  0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x3F, 0x00, 0x00, 0x60, 0x3F,
  0xF0, 0x00, 0x30, 0x1C, 0x0C, 0x00, 0x0C, 0x06, 0x01, 0x80, 0x06, 0x03,
  0x00, 0x60, 0x03, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x60, 0x03, 0x00, 0x60,
  0x10, 0x00, 0xC0, 0x30, 0x0C, 0x00, 0x30, 0x18, 0x03, 0x00, 0x0C, 0x06,
  0x00, 0xC0, 0x02, 0x03, 0x00, 0x20, 0x01, 0x81, 0x80, 0x18, 0x00, 0x60,
  0x60, 0x06, 0x00, 0x18, 0x30, 0x01, 0x80, 0x06, 0x18, 0x00, 0x60, 0x03,
  0x06, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x18, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0xC0,
  0x1C, 0x00, 0x03, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x60, 0x00, 0x20, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03,
  0x00, 0x03, 0x00, 0x04, 0x00, 0x06, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x70,
  0x00, 0x18, 0x00, 0xC0, 0x00, 0x30, 0x03, 0x00, 0x00, 0x60, 0x0C, 0x00,
  0x00, 0xC0, 0x30, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x01, 0x83, 0x00, 0x00,
  0x03, 0x1C, 0x00, 0x00, 0x03, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x03,
  0x9C, 0x00, 0x00, 0x0E, 0x18, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0xE0,
  0x30, 0x00, 0xC1, 0x80, 0x30, 0x01, 0x86, 0x00, 0x60, 0x03, 0x18, 0x00,
  0x60, 0x06, 0x30, 0x00, 0x60, 0x18, 0xC0, 0x00, 0xC0, 0x31, 0x00, 0x00,
  0xC0, 0x66, 0x00, 0x01, 0x81, 0x8C, 0x00, 0x01, 0x83, 0x18, 0x00, 0x03,
  0x8C, 0x60, 0x00, 0x03, 0x18, 0xC0, 0x00, 0x03, 0x61, 0x80, 0x00, 0x06,
  0xC3, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x3C,
  0x0C, 0x00, 0x00, 0xFC, 0x1C, 0x00, 0x03, 0x18, 0x1C, 0x00, 0x0C, 0x18,
  0x1C, 0x00, 0x30, 0x30, 0x1E, 0x03, 0xC0, 0x30, 0x0F, 0xFE, 0x00, 0x60,
  0x03, 0xE0, 0x00, 0x00, 0x18, 0xCE, 0x63, 0x18, 0xC6, 0x63, 0x18, 0xC6,
  0x60, 0x00, 0x00, 0x20, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00,
  0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x10,
  0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0xC0, 0x1F, 0xE0, 0x18, 0x0F, 0x8F, 0x83, 0x0F, 0x80, 0x7C, 0x67, 0x80,
  0x01, 0xFF, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x0E, 0x60, 0x00, 0x03, 0x8C, 0x00, 0x00, 0xE0, 0xC0, 0x00,
  0x18, 0x1C, 0x00, 0x06, 0x01, 0x80, 0x01, 0x80, 0x18, 0x00, 0x60, 0x03,
  0x00, 0x1C, 0x00, 0x30, 0x07, 0x00, 0x07, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x06, 0x0C, 0x18, 0x30, 0x61, 0x83, 0x06, 0x18, 0x30,
  0xC3, 0x8E, 0x08, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x6F, 0xEC, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0x07,
  0x80, 0x01, 0x80, 0x1C, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x06, 0x00,
  0xC0, 0x00, 0x60, 0x1C, 0x00, 0x03, 0x01, 0x80, 0x00, 0x30, 0x30, 0x00,
  0x03, 0x03, 0x00, 0x00, 0x30, 0x20, 0x00, 0x03, 0x06, 0x00, 0x00, 0x30,
  0x60, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x30, 0x80, 0x00, 0x03, 0x18, 0x00, 0x00, 0x31, 0x80, 0x00, 0x03,
  0x18, 0x00, 0x00, 0x31, 0x80, 0x00, 0x03, 0x10, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x06, 0x30, 0x00, 0x00, 0x63, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00,
  0x62, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x66, 0x00, 0x00, 0x0C, 0x60,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0xC6, 0x00, 0x00,
  0x0C, 0x40, 0x00, 0x01, 0x84, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x01, 0x8C,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x04, 0x00, 0x00, 0x30, 0x40, 0x00,
  0x06, 0x06, 0x00, 0x00, 0x60, 0x60, 0x00, 0x0C, 0x06, 0x00, 0x00, 0xC0,
  0x60, 0x00, 0x18, 0x03, 0x00, 0x03, 0x80, 0x30, 0x00, 0x30, 0x01, 0x80,
  0x06, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0xE0, 0x78, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x06, 0x00, 0x38, 0x03, 0xF0, 0x1E, 0x61,
  0xE0, 0xCF, 0x01, 0xB8, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0x80,
  0xE0, 0x00, 0x70, 0x03, 0x80, 0x07, 0x00, 0x06, 0x00, 0x70, 0x00, 0x38,
  0x03, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x06, 0x01, 0x80, 0x00, 0x30, 0x18,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x30, 0x60, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0x00, 0x38, 0x00, 0x30,
  0x00, 0x70, 0x01, 0x80, 0x00, 0xC0, 0x0C, 0x00, 0x03, 0x80, 0x60, 0x00,
  0x06, 0x01, 0x80, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x60, 0x30, 0x00, 0x01,
  0x80, 0xC0, 0x00, 0x06, 0x06, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x43, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x18,
  0x18, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x18, 0x03,
  0x80, 0x00, 0xC0, 0x06, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x19, 0x80,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0x18, 0x40, 0x00, 0x00, 0xC6, 0x00, 0x00,
  0x0C, 0x30, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x06, 0x02, 0x00, 0x00, 0x60, 0x30, 0x00, 0x03, 0x01, 0x80,
  0x00, 0x30, 0x0C, 0x00, 0x03, 0x00, 0x60, 0x00, 0x30, 0x03, 0x00, 0x01,
  0x80, 0x30, 0x00, 0x18, 0x01, 0x80, 0x01, 0x80, 0x0C, 0x00, 0x1C, 0x00,
  0x60, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x10, 0x00, 0xC0, 0x01, 0x80,
  0x0E, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x60, 0x06, 0x00, 0x03, 0x00, 0x60,
  0x00, 0x18, 0x07, 0x00, 0x00, 0x80, 0x30, 0x00, 0x0C, 0x03, 0x00, 0x00,
  0x60, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x06, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x83, 0xF8, 0x00, 0x06, 0x7F, 0xF8, 0x00, 0x17, 0x80, 0x70, 0x00, 0xF8,
  0x00, 0xE0, 0x03, 0x80, 0x01, 0xC0, 0x04, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x81, 0x00, 0x00, 0x06, 0x04, 0x00,
  0x00, 0x30, 0x10, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x03, 0x01, 0x80, 0x00,
  0x18, 0x06, 0x00, 0x00, 0x60, 0x18, 0x00, 0x03, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0xC0, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x07, 0x00, 0x18, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x7F, 0x00, 0x60, 0x7F, 0xF0, 0x18, 0x70, 0x0E, 0x06, 0x30, 0x01, 0xC1,
  0x38, 0x00, 0x38, 0xC8, 0x00, 0x06, 0x34, 0x00, 0x01, 0x8F, 0x00, 0x00,
  0x33, 0x80, 0x00, 0x0C, 0xC0, 0x00, 0x03, 0x70, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x03, 0x60, 0x00, 0x00, 0xD0,
  0x00, 0x00, 0x34, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x64, 0x00, 0x00, 0x19, 0x80, 0x00, 0x06, 0x60, 0x00,
  0x03, 0x18, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x18, 0x30,
  0x00, 0x0C, 0x0E, 0x00, 0x06, 0x01, 0xC0, 0x03, 0x80, 0x38, 0x01, 0xC0,
  0x07, 0x81, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x7F, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x70, 0x03, 0x80, 0x01, 0xC0, 0x01,
  0x80, 0x07, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x03, 0x00, 0x30, 0x00, 0x07,
  0x00, 0xC0, 0x00, 0x06, 0x01, 0x80, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x18,
  0x0C, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x60, 0x20, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x01, 0x81, 0x80, 0x00, 0x06, 0x03, 0x00, 0x00, 0x0C, 0x06,
  0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x01, 0x80, 0x1C,
  0x00, 0x07, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x70, 0x00, 0x1C,
  0x03, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xE0,
  0x38, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x18, 0x00, 0xE0, 0x00,
  0x18, 0x03, 0x80, 0x00, 0x18, 0x06, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00,
  0x70, 0x30, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x01,
  0x86, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x0C,
  0x30, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x03, 0x03, 0x00, 0x00, 0x06, 0x07, 0x00, 0x00, 0x18, 0x06,
  0x00, 0x00, 0x60, 0x0E, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x07, 0x00, 0x0E,
  0x00, 0x3C, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0x01,
  0xC0, 0x07, 0x00, 0x38, 0x03, 0x80, 0x07, 0x00, 0xC0, 0x00, 0xE0, 0x60,
  0x00, 0x18, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x31,
  0x80, 0x00, 0x0C, 0xC0, 0x00, 0x03, 0x30, 0x00, 0x00, 0xD8, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x03, 0x40, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x03,
  0x98, 0x00, 0x01, 0xE6, 0x00, 0x00, 0xD9, 0x80, 0x00, 0x34, 0x30, 0x00,
  0x1B, 0x0E, 0x00, 0x1C, 0xC1, 0x80, 0x0E, 0x30, 0x38, 0x0F, 0x08, 0x07,
  0xFF, 0x06, 0x00, 0x7F, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x01, 0x80, 0xF0, 0x3C, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x0F, 0x03, 0xC0, 0x60, 0x00,
  0x00, 0x30, 0x03, 0xC0, 0x1E, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0x80, 0x18, 0x01, 0xC0, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x02,
  0x00, 0x1F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0x04, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x07, 0xFC, 0x00, 0xF0, 0x38, 0x0E, 0x00, 0xC0, 0xE0,
  0x03, 0x0E, 0x00, 0x18, 0x60, 0x00, 0x66, 0x00, 0x03, 0x30, 0x00, 0x1B,
  0x00, 0x00, 0xD8, 0x00, 0x06, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x7C, 0x00, 0x02, 0x01, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0x80, 0x60, 0x00, 0x70, 0x38, 0x00, 0x30, 0x38, 0x00,
  0x30, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x06, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC1, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x60,
  0x01, 0x80, 0x03, 0x00, 0x0C, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x0C,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC6, 0x00, 0x18, 0x00, 0x18, 0x00, 0x21,
  0x80, 0x06, 0x00, 0x06, 0x00, 0x08, 0x60, 0x03, 0x00, 0x01, 0x00, 0x06,
  0x30, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x8C, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x63, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x18, 0xC0, 0x06, 0x00, 0x02, 0x00,
  0x06, 0x20, 0x03, 0x00, 0x01, 0x80, 0x03, 0x18, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0xC6, 0x00, 0x30, 0x00, 0x18, 0x00, 0x31, 0x80, 0x0C, 0x00, 0x04,
  0x00, 0x08, 0x60, 0x02, 0x00, 0x03, 0x00, 0x06, 0x18, 0x01, 0x80, 0x00,
  0xC0, 0x01, 0x84, 0x00, 0x60, 0x00, 0x30, 0x00, 0x41, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x30, 0x40, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x30, 0x01, 0x80,
  0x03, 0x80, 0x06, 0x0C, 0x00, 0x60, 0x01, 0xE0, 0x01, 0x83, 0x00, 0x18,
  0x00, 0x58, 0x00, 0xC0, 0xC0, 0x06, 0x00, 0x36, 0x00, 0x70, 0x10, 0x01,
  0x80, 0x18, 0x80, 0x38, 0x06, 0x00, 0x30, 0x0C, 0x30, 0x1C, 0x01, 0x80,
  0x0E, 0x0E, 0x0E, 0x1E, 0x00, 0x60, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x18,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x00, 0x13, 0x00, 0x00, 0x00, 0x18, 0x80, 0x00, 0x00, 0x08,
  0x40, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x00, 0x04, 0x18, 0x00, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0x02, 0x06, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x01,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x40, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x00,
  0xC0, 0x18, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00,
  0x30, 0x03, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x18, 0x00, 0x40, 0x00,
  0x18, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x03, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x20, 0x01, 0x80, 0x00, 0x18,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x30, 0x00, 0x00, 0xC0, 0x10, 0x00, 0x00,
  0x60, 0x18, 0x00, 0x00, 0x18, 0x08, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00,
  0x06, 0x06, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x01, 0x83, 0x00, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0x19, 0x80, 0x00,
  0x00, 0x0C, 0xC0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x03, 0x60, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x03, 0x00, 0x03, 0xC0, 0x06, 0x00, 0x01, 0xC0, 0x08,
  0x00, 0x01, 0xC0, 0x30, 0x00, 0x01, 0x80, 0x60, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x03, 0x01, 0x80, 0x00, 0x06, 0x03, 0x00, 0x00, 0x0C, 0x04, 0x00,
  0x00, 0x18, 0x18, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x60, 0x60, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x01, 0x81, 0x80, 0x00, 0x06, 0x02, 0x00, 0x00,
  0x0C, 0x0C, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x38, 0x01, 0x00, 0x01, 0xE0,
  0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x18, 0x00, 0x0F, 0x00,
  0x30, 0x00, 0x07, 0x00, 0x40, 0x00, 0x07, 0x01, 0x80, 0x00, 0x07, 0x03,
  0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x0C, 0x18,
  0x00, 0x00, 0x18, 0x20, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x61, 0x80,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x02, 0x0C, 0x00,
  0x00, 0x0C, 0x10, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x03, 0x03, 0x00, 0x00, 0x06, 0x04, 0x00, 0x00,
  0x18, 0x08, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x03, 0x80, 0x60, 0x00, 0x1E,
  0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x0E,
  0x00, 0x00, 0x30, 0x07, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x06,
  0x06, 0x00, 0x00, 0x01, 0x83, 0x00, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00,
  0x18, 0x30, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x30, 0x00,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0x01, 0x83, 0x00, 0x00, 0x00, 0x60, 0x40,
  0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x06, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x60,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0C,
  0x00, 0x0F, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x80, 0x00, 0x0C, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x70, 0x06, 0x00, 0x00, 0x0C,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x60, 0x10, 0x00, 0x00,
  0x18, 0x0C, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x00, 0x30, 0x30, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x03, 0x02, 0x00,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x0C, 0x18,
  0x00, 0x00, 0x02, 0x06, 0x00, 0x00, 0x00, 0x81, 0x00, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x00, 0x30, 0x20, 0x00, 0x00,
  0x0C, 0x18, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x00, 0x30, 0x60, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0x06, 0x04, 0x00,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x30, 0x30,
  0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x80, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x18,
  0x06, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x07, 0x00, 0x40, 0x00, 0x03,
  0x80, 0x10, 0x00, 0x01, 0xC0, 0x0C, 0x00, 0x01, 0xC0, 0x03, 0x00, 0x03,
  0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0C, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x0C, 0x00, 0x00, 0x30, 0x06,
  0x00, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x00,
  0x83, 0x00, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x7F, 0xFE, 0x18, 0x00, 0x3F, 0xFF,
  0x84, 0x00, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x00,
  0x0C, 0x30, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x02, 0x0C, 0x00,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x18, 0x30,
  0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0xC0,
  0x60, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x70, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x1F,
  0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x30, 0x00, 0x00, 0x03, 0x00, 0x80, 0x00, 0x00, 0x08, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x06,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x00, 0x40, 0x10, 0x00,
  0x00, 0x01, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x00, 0x08, 0x02, 0x00, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x60, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x10, 0x00, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x03,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x30, 0x00, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x02, 0x00, 0x00, 0x00, 0x20, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x00,
  0x18, 0x06, 0x00, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x01, 0x00, 0x40,
  0x00, 0x00, 0x04, 0x03, 0x00, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x30, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x03, 0x00,
  0x00, 0x00, 0x20, 0x08, 0x00, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x06,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x00, 0x60, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x40, 0x00, 0x00, 0x04, 0x01, 0x00, 0x00, 0x00, 0x30,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x10, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x02, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x40, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x04, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x00, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x18, 0x0C, 0x00,
  0x00, 0x30, 0x18, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x18, 0x03, 0x00, 0x00,
  0x60, 0x06, 0x00, 0x01, 0xC0, 0x06, 0x00, 0x03, 0x00, 0x0E, 0x00, 0x0C,
  0x00, 0x0E, 0x00, 0x70, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x06, 0x00,
  0x00, 0x07, 0x00, 0x30, 0x00, 0x00, 0x70, 0x01, 0x80, 0x00, 0x07, 0x00,
  0x08, 0x00, 0x00, 0x70, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x06, 0x00, 0x00,
  0x70, 0x00, 0x30, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C,
  0x00, 0x07, 0x00, 0x00, 0x40, 0x00, 0x70, 0x00, 0x06, 0x00, 0x07, 0x00,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x01, 0x80, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x02, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x03, 0x00, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x0C, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x02, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x30, 0x00, 0x00, 0x01, 0x83, 0xC0, 0x00, 0x00, 0x0C, 0x76, 0x00, 0x00,
  0x00, 0x67, 0x18, 0x00, 0x00, 0x03, 0x70, 0xC0, 0x00, 0x00, 0x17, 0x03,
  0x00, 0x00, 0x01, 0xE0, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x03, 0x80, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x70,
  0x00, 0x00, 0x80, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x04, 0x00, 0x00, 0xE0, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0xC0, 0x00, 0x03, 0x80, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x00,
  0x70, 0x03, 0x00, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x0B, 0x00, 0x00,
  0x00, 0x03, 0x60, 0x36, 0x00, 0x00, 0x00, 0x06, 0x80, 0x6C, 0x00, 0x00,
  0x00, 0x1B, 0x00, 0xD8, 0x00, 0x00, 0x00, 0x36, 0x01, 0x90, 0x00, 0x00,
  0x00, 0xCC, 0x03, 0x30, 0x00, 0x00, 0x01, 0x18, 0x04, 0x60, 0x00, 0x00,
  0x06, 0x30, 0x18, 0xC0, 0x00, 0x00, 0x08, 0xC0, 0x31, 0x80, 0x00, 0x00,
  0x31, 0x80, 0x61, 0x00, 0x00, 0x00, 0xC3, 0x00, 0xC3, 0x00, 0x00, 0x01,
  0x86, 0x01, 0x86, 0x00, 0x00, 0x06, 0x0C, 0x02, 0x0C, 0x00, 0x00, 0x0C,
  0x10, 0x0C, 0x18, 0x00, 0x00, 0x30, 0x60, 0x18, 0x10, 0x00, 0x00, 0x60,
  0xC0, 0x30, 0x30, 0x00, 0x01, 0x81, 0x80, 0x60, 0x60, 0x00, 0x03, 0x03,
  0x00, 0x80, 0xC0, 0x00, 0x0C, 0x06, 0x01, 0x01, 0x80, 0x00, 0x18, 0x08,
  0x06, 0x03, 0x00, 0x00, 0x60, 0x30, 0x0C, 0x02, 0x00, 0x00, 0x80, 0x60,
  0x18, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x00, 0x0C, 0x01, 0x80,
  0x40, 0x18, 0x00, 0x18, 0x03, 0x01, 0x80, 0x30, 0x00, 0x60, 0x04, 0x03,
  0x00, 0x20, 0x00, 0xC0, 0x18, 0x06, 0x00, 0x60, 0x03, 0x00, 0x30, 0x0C,
  0x00, 0xC0, 0x06, 0x00, 0x60, 0x18, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x20,
  0x03, 0x00, 0x30, 0x01, 0x80, 0xC0, 0x02, 0x00, 0xC0, 0x06, 0x01, 0x80,
  0x04, 0x01, 0x80, 0x0C, 0x03, 0x00, 0x0C, 0x06, 0x00, 0x18, 0x06, 0x00,
  0x18, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x30, 0x00, 0x60, 0x10, 0x00,
  0x20, 0xC0, 0x00, 0x80, 0x60, 0x00, 0x41, 0x80, 0x03, 0x00, 0xC0, 0x00,
  0xC6, 0x00, 0x06, 0x01, 0x80, 0x01, 0x8C, 0x00, 0x0C, 0x03, 0x00, 0x03,
  0x30, 0x00, 0x18, 0x06, 0x00, 0x06, 0x60, 0x00, 0x30, 0x08, 0x00, 0x05,
  0x80, 0x00, 0x40, 0x30, 0x00, 0x0B, 0x00, 0x01, 0x80, 0x60, 0x00, 0x1C,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x01, 0xC0, 0x00, 0x00,
  0x18, 0x03, 0x80, 0x00, 0x00, 0x30, 0x07, 0x80, 0x00, 0x00, 0x60, 0x0F,
  0x00, 0x00, 0x00, 0xC0, 0x32, 0x00, 0x00, 0x01, 0x80, 0x66, 0x00, 0x00,
  0x06, 0x00, 0xCC, 0x00, 0x00, 0x0C, 0x01, 0x8C, 0x00, 0x00, 0x18, 0x03,
  0x18, 0x00, 0x00, 0x30, 0x06, 0x10, 0x00, 0x00, 0x60, 0x18, 0x30, 0x00,
  0x00, 0xC0, 0x30, 0x60, 0x00, 0x03, 0x00, 0x60, 0x60, 0x00, 0x06, 0x00,
  0xC0, 0xC0, 0x00, 0x0C, 0x01, 0x80, 0x80, 0x00, 0x18, 0x03, 0x01, 0x80,
  0x00, 0x30, 0x0C, 0x03, 0x00, 0x00, 0x40, 0x18, 0x03, 0x00, 0x01, 0x80,
  0x30, 0x06, 0x00, 0x03, 0x00, 0x60, 0x0C, 0x00, 0x06, 0x00, 0xC0, 0x0C,
  0x00, 0x0C, 0x03, 0x00, 0x18, 0x00, 0x18, 0x06, 0x00, 0x10, 0x00, 0x60,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x18, 0x00, 0x60, 0x01, 0x80, 0x30, 0x00,
  0x60, 0x03, 0x00, 0x60, 0x00, 0xC0, 0x06, 0x01, 0x80, 0x00, 0x80, 0x0C,
  0x03, 0x00, 0x01, 0x80, 0x30, 0x06, 0x00, 0x03, 0x00, 0x60, 0x0C, 0x00,
  0x03, 0x00, 0xC0, 0x18, 0x00, 0x06, 0x01, 0x80, 0x30, 0x00, 0x04, 0x03,
  0x00, 0xC0, 0x00, 0x0C, 0x06, 0x01, 0x80, 0x00, 0x18, 0x18, 0x03, 0x00,
  0x00, 0x18, 0x30, 0x06, 0x00, 0x00, 0x30, 0x60, 0x0C, 0x00, 0x00, 0x20,
  0xC0, 0x10, 0x00, 0x00, 0x61, 0x80, 0x60, 0x00, 0x00, 0xC7, 0x00, 0xC0,
  0x00, 0x00, 0xCC, 0x01, 0x80, 0x00, 0x01, 0x98, 0x03, 0x00, 0x00, 0x01,
  0x30, 0x06, 0x00, 0x00, 0x03, 0x60, 0x08, 0x00, 0x00, 0x06, 0xC0, 0x30,
  0x00, 0x00, 0x07, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x00,
  0x1C, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x78, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00,
  0x30, 0x07, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x00, 0x60, 0x30, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0x03, 0x06, 0x00,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x0C, 0x20,
  0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x00, 0x31,
  0x80, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x00,
  0x8C, 0x00, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00,
  0x06, 0x30, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x00, 0x31, 0x80, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x03, 0x18, 0x00,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x0C, 0xC0,
  0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00,
  0x18, 0x30, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x70, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x3E, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x30, 0x00, 0x1E,
  0x00, 0x18, 0x00, 0x03, 0x80, 0x08, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x00,
  0x30, 0x06, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x00, 0x60, 0x60, 0x00,
  0x00, 0x30, 0x30, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x0C, 0x0C, 0x00,
  0x00, 0x06, 0x06, 0x00, 0x00, 0x02, 0x02, 0x00, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x00, 0xE0, 0x30, 0x00, 0x00, 0x60, 0x10, 0x00, 0x00, 0x60, 0x18,
  0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x70, 0x06, 0x00, 0x00, 0xF0, 0x03,
  0x00, 0x01, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x78, 0x07, 0x80, 0x00, 0x78, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x30, 0x07, 0x00, 0x00,
  0x04, 0x01, 0x80, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x60, 0x30, 0x00,
  0x00, 0x08, 0x18, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x03, 0x18,
  0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x0C,
  0xC0, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00,
  0x01, 0x98, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0x31, 0x80, 0x00,
  0x00, 0x0C, 0x60, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x00, 0x06, 0x30,
  0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0x18,
  0xC0, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00,
  0x0C, 0x06, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x00, 0xC0, 0x0C, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x38, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x3E, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFC, 0xE0, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x0C, 0x00, 0x07, 0x80, 0x02, 0x00, 0x00, 0x70, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x00, 0x30,
  0x06, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x01, 0x80, 0x40, 0x00, 0x00,
  0x60, 0x30, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x18, 0x08, 0x00,
  0x00, 0x06, 0x06, 0x00, 0x00, 0x01, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x06, 0x01,
  0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x00, 0x60,
  0x0C, 0x00, 0x00, 0x70, 0x03, 0x00, 0x00, 0x38, 0x00, 0x80, 0x00, 0x38,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x03, 0x00, 0x00, 0x60, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x02,
  0x00, 0x00, 0x38, 0x01, 0x80, 0x00, 0x06, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x18, 0x00, 0x00, 0x70, 0x06, 0x00, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x03,
  0x00, 0x40, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00,
  0x06, 0x03, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x30, 0x20, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x78, 0x07, 0x80, 0x00, 0x78, 0x00, 0x70, 0x00, 0x38, 0x00, 0x06,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x30, 0x07, 0x00, 0x00,
  0x06, 0x01, 0x80, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x60, 0x30, 0x00,
  0x00, 0x18, 0x0C, 0x00, 0x00, 0x06, 0x02, 0x00, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x00,
  0x83, 0x00, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00,
  0x06, 0x0C, 0x00, 0x00, 0x03, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x60, 0x00,
  0x00, 0x60, 0x1C, 0x00, 0x00, 0x38, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x60,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x1F, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x30, 0x00, 0x00,
  0x0C, 0x04, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0x30, 0x30, 0x00,
  0x00, 0x06, 0x06, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x10, 0x18,
  0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x18,
  0x18, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x00, 0x40, 0x60, 0x00, 0x00,
  0x08, 0x08, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x00, 0x60, 0x60, 0x00,
  0x00, 0x0C, 0x0C, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0x20, 0x30,
  0x00, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0x30,
  0x30, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00,
  0x10, 0x18, 0x00, 0x00, 0x06, 0x02, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x00, 0x18, 0x18, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x00, 0x40, 0x60,
  0x00, 0x00, 0x08, 0x0C, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00,
  0x20, 0x30, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x01, 0x80, 0x80, 0x00,
  0x00, 0x30, 0x10, 0x00, 0x00, 0x06, 0x02, 0x00, 0x00, 0x01, 0x80, 0x60,
  0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x30, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x78, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00,
  0x31, 0x80, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x18, 0x20, 0x00, 0x00,
  0x18, 0x18, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x06, 0x03, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x30, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0xC0, 0x0C, 0x00,
  0x00, 0xC0, 0x06, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x60, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x40, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x04, 0x00, 0x03,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x03, 0x00, 0x00, 0x40, 0x03, 0x00, 0x00,
  0x30, 0x01, 0x80, 0x00, 0x18, 0x01, 0x80, 0x00, 0x0C, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0x80, 0x60, 0x00,
  0x00, 0x60, 0x30, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x18, 0x18, 0x00,
  0x00, 0x0C, 0x08, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x03, 0x04, 0x00,
  0x00, 0x00, 0x86, 0x00, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x06, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x34, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x12, 0x00, 0x00, 0x33, 0x00, 0x00, 0x19, 0x00, 0x00, 0x19, 0x80, 0x00,
  0x08, 0x80, 0x00, 0x0C, 0x40, 0x00, 0x0C, 0x40, 0x00, 0x0C, 0x30, 0x00,
  0x06, 0x30, 0x00, 0x06, 0x18, 0x00, 0x06, 0x18, 0x00, 0x02, 0x0C, 0x00,
  0x03, 0x0C, 0x00, 0x03, 0x06, 0x00, 0x01, 0x06, 0x00, 0x01, 0x83, 0x00,
  0x01, 0x83, 0x00, 0x01, 0x81, 0x80, 0x00, 0xC1, 0x80, 0x00, 0xC0, 0xC0,
  0x00, 0xC0, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x60, 0x20, 0x00, 0x60, 0x30,
  0x00, 0x20, 0x10, 0x00, 0x30, 0x18, 0x00, 0x30, 0x08, 0x00, 0x30, 0x0C,
  0x00, 0x18, 0x06, 0x00, 0x18, 0x06, 0x00, 0x18, 0x03, 0x00, 0x0C, 0x03,
  0x00, 0x0C, 0x01, 0x80, 0x0C, 0x01, 0x80, 0x04, 0x00, 0xC0, 0x06, 0x00,
  0x40, 0x06, 0x00, 0x60, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x18, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x01, 0x80, 0x0C, 0x01, 0x80,
  0x06, 0x01, 0x80, 0x02, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x01, 0x00, 0x60,
  0x01, 0x80, 0x60, 0x00, 0x80, 0x60, 0x00, 0xC0, 0x60, 0x00, 0x60, 0x30,
  0x00, 0x60, 0x30, 0x00, 0x30, 0x10, 0x00, 0x30, 0x30, 0x00, 0x18, 0x18,
  0x00, 0x18, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x06, 0x0C,
  0x00, 0x06, 0x0C, 0x00, 0x03, 0x06, 0x00, 0x03, 0x06, 0x00, 0x01, 0x83,
  0x00, 0x01, 0x86, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x43, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x31, 0x80, 0x00, 0x10, 0x80, 0x00, 0x19, 0x80, 0x00, 0x08,
  0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x06, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x03,
  0x60, 0x00, 0x03, 0x60, 0x00, 0x01, 0xB0, 0x00, 0x01, 0xA0, 0x00, 0x00,
  0xD8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x01, 0xC0, 0x00, 0x00,
  0x60, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x03, 0x00, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x00,
  0x00, 0xC0, 0x18, 0x00, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x01, 0x81,
  0x80, 0x00, 0x00, 0x03, 0x07, 0x00, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x00, 0x06, 0x30, 0x00, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x00, 0x00, 0x0D,
  0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x00, 0x07,
  0x60, 0x00, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x00, 0x60, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x1C,
  0x00, 0x00, 0x60, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x01,
  0xC0, 0x03, 0x00, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0x03, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x03, 0xB8, 0x00,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0xE0, 0x38,
  0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x70, 0x03,
  0x80, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x60, 0x00, 0x38, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x06, 0x00, 0x1C, 0x00,
  0x03, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x60, 0x0E, 0x00,
  0x00, 0x30, 0x06, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x06, 0x07, 0x00,
  0x00, 0x03, 0x03, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0,
  0x07, 0xFC, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x00, 0xC0, 0x10, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x20, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0x40, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x04, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x08, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x10, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x20, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x00, 0x06, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x03, 0x20, 0x00, 0x64, 0x00,
  0x18, 0xC0, 0x03, 0x18, 0x00, 0xC3, 0x00, 0x18, 0x60, 0x06, 0x04, 0x00,
  0xC0, 0x80, 0x30, 0x18, 0x06, 0x03, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x0C,
  0x01, 0x81, 0x80, 0x10, 0x60, 0x03, 0x0C, 0x00, 0x63, 0x00, 0x0C, 0x60,
  0x01, 0x98, 0x00, 0x33, 0x00, 0x02, 0xC0, 0x00, 0x60, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xC1, 0xC1, 0x81, 0x83, 0x03, 0x07, 0x06, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xF0, 0x1C, 0x00, 0x78, 0x00,
  0xC0, 0x1C, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x18, 0x30,
  0x00, 0x03, 0x06, 0x00, 0x00, 0x60, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x3E, 0x00, 0x18, 0x0E, 0x00,
  0x03, 0x03, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x01, 0x0E,
  0x00, 0x00, 0x21, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0x31, 0x80, 0x00, 0x06, 0x30, 0x00, 0x01, 0x86, 0x00, 0x00, 0x70, 0xC0,
  0x00, 0x1E, 0x18, 0x00, 0x03, 0xC1, 0x80, 0x01, 0xD8, 0x30, 0x00, 0x73,
  0x03, 0x00, 0x1C, 0x60, 0x78, 0x1E, 0x0C, 0x03, 0xFF, 0x01, 0x80, 0x1F,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x01, 0x00, 0xF0, 0x00, 0x30, 0x7F, 0xF0, 0x03, 0x1E,
  0x07, 0x80, 0x33, 0x80, 0x1C, 0x03, 0x60, 0x00, 0xC0, 0x2C, 0x00, 0x06,
  0x07, 0x80, 0x00, 0x60, 0x70, 0x00, 0x06, 0x06, 0x00, 0x00, 0x20, 0x60,
  0x00, 0x03, 0x06, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x20, 0x80, 0x00, 0x06, 0x18, 0x00, 0x00, 0x61, 0x80, 0x00,
  0x06, 0x18, 0x00, 0x00, 0x61, 0x80, 0x00, 0x06, 0x18, 0x00, 0x00, 0x61,
  0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x0C, 0x30, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x18, 0x20, 0x00, 0x01, 0x86, 0x00, 0x00, 0x18,
  0x60, 0x00, 0x03, 0x06, 0x00, 0x00, 0x30, 0x60, 0x00, 0x06, 0x07, 0x00,
  0x00, 0x60, 0x58, 0x00, 0x0C, 0x0C, 0xC0, 0x01, 0x80, 0xC6, 0x00, 0x30,
  0x0C, 0x38, 0x1E, 0x00, 0xC1, 0xFF, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xE0, 0x38, 0x00, 0x70, 0x01,
  0x80, 0x18, 0x00, 0x18, 0x06, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x30, 0x30,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x08, 0x60, 0x00, 0x01,
  0x0C, 0x00, 0x00, 0x21, 0x80, 0x00, 0x04, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x31, 0x80, 0x00, 0x06, 0x30, 0x00, 0x01, 0x83, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x0C, 0x0C, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x60, 0x1C, 0x00, 0x18,
  0x01, 0xC0, 0x06, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x06, 0x00, 0x01, 0xF0, 0x0C,
  0x00, 0x1F, 0xF8, 0x18, 0x00, 0xF0, 0x1C, 0x30, 0x03, 0x80, 0x1C, 0x60,
  0x0E, 0x00, 0x0D, 0x80, 0x18, 0x00, 0x0B, 0x00, 0x60, 0x00, 0x1E, 0x01,
  0x80, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0x60, 0x18,
  0x00, 0x00, 0xC0, 0x20, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x03, 0x01, 0x80,
  0x00, 0x06, 0x03, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x10, 0x18, 0x00,
  0x00, 0x60, 0x30, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x03, 0x01, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x08, 0x0C, 0x00, 0x00,
  0x30, 0x18, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x01,
  0x80, 0xC0, 0x00, 0x03, 0x01, 0x80, 0x00, 0x04, 0x03, 0x00, 0x00, 0x18,
  0x06, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0xC0,
  0x30, 0x00, 0x03, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x3C, 0x00,
  0xE0, 0x00, 0xD8, 0x00, 0xE0, 0x07, 0x30, 0x00, 0xE0, 0x3C, 0x60, 0x00,
  0xFF, 0xE0, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xFF, 0x80, 0x01, 0xE0, 0x38, 0x00, 0x70, 0x01, 0x80, 0x1C, 0x00,
  0x38, 0x07, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x06, 0x0C,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x18, 0x60, 0x00, 0x01, 0x0C, 0x00, 0x00,
  0x23, 0x00, 0x00, 0x04, 0x60, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x13, 0x00,
  0x00, 0x06, 0x60, 0x00, 0x00, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x0E, 0x01, 0xC0, 0x03,
  0x80, 0x1E, 0x03, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x7F, 0xFF, 0x81, 0xFF, 0xFC,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x30,
  0x03, 0xC0, 0x70, 0x80, 0x1C, 0x00, 0xE6, 0x00, 0xE0, 0x00, 0xD8, 0x07,
  0x00, 0x03, 0x60, 0x18, 0x00, 0x07, 0x80, 0xC0, 0x00, 0x0E, 0x03, 0x00,
  0x00, 0x30, 0x18, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x03, 0x01, 0x00, 0x00,
  0x0C, 0x0C, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x02,
  0x06, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x60, 0x60, 0x00, 0x01, 0x81,
  0x80, 0x00, 0x06, 0x06, 0x00, 0x00, 0x18, 0x10, 0x00, 0x00, 0x40, 0xC0,
  0x00, 0x03, 0x03, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x30, 0x30, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x03, 0x03, 0x00, 0x00, 0x08, 0x0C, 0x00, 0x00,
  0x60, 0x30, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x06, 0x03, 0x00, 0x00, 0x18,
  0x0C, 0x00, 0x00, 0x60, 0x30, 0x00, 0x03, 0x00, 0x60, 0x00, 0x1C, 0x01,
  0x80, 0x00, 0xF0, 0x07, 0x00, 0x06, 0xC0, 0x0E, 0x00, 0x73, 0x00, 0x1C,
  0x07, 0x0C, 0x00, 0x3F, 0xF8, 0x20, 0x00, 0x3F, 0x01, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80,
  0x30, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x03,
  0x80, 0x3C, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40,
  0x1E, 0x00, 0x18, 0x1F, 0xF8, 0x03, 0x0F, 0x03, 0x80, 0x63, 0x80, 0x30,
  0x0C, 0xC0, 0x03, 0x01, 0xB0, 0x00, 0x60, 0x24, 0x00, 0x06, 0x0D, 0x80,
  0x00, 0xC1, 0xE0, 0x00, 0x18, 0x38, 0x00, 0x03, 0x07, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x0C, 0x38, 0x00, 0x01, 0x86, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x06, 0x18, 0x00, 0x00, 0x83, 0x00, 0x00, 0x30, 0x40, 0x00, 0x06, 0x18,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x18, 0x60, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x41, 0x80, 0x00, 0x18, 0x20, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x61, 0x80,
  0x00, 0x0C, 0x30, 0x00, 0x01, 0x86, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x0C,
  0x10, 0x00, 0x01, 0x86, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x06, 0x18, 0x00,
  0x00, 0x83, 0x00, 0x00, 0x30, 0x40, 0x00, 0x06, 0x18, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x18, 0x60, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x60,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0xC0, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0xFE, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x07, 0x03, 0x00,
  0x00, 0xE0, 0x30, 0x00, 0x18, 0x03, 0x00, 0x03, 0x00, 0x20, 0x00, 0x60,
  0x02, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0x60,
  0x06, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x40, 0x18, 0x00, 0x0C, 0x03, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x0C,
  0x70, 0x00, 0x00, 0x8E, 0x00, 0x00, 0x19, 0xF0, 0x00, 0x01, 0xBB, 0x00,
  0x00, 0x1E, 0x18, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x18, 0x0C, 0x00, 0x01,
  0x00, 0xC0, 0x00, 0x30, 0x06, 0x00, 0x03, 0x00, 0x60, 0x00, 0x30, 0x03,
  0x00, 0x03, 0x00, 0x30, 0x00, 0x30, 0x01, 0x80, 0x02, 0x00, 0x1C, 0x00,
  0x60, 0x00, 0xC0, 0x06, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x60, 0x06, 0x00,
  0x07, 0x00, 0x40, 0x00, 0x30, 0x0C, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x18,
  0x0C, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20, 0x0C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x07, 0xC0, 0x03, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0x0E, 0x07,
  0x80, 0xF0, 0x38, 0x02, 0x18, 0x01, 0x81, 0xC0, 0x0C, 0x06, 0x30, 0x00,
  0xC3, 0x80, 0x06, 0x06, 0x60, 0x00, 0xC6, 0x00, 0x06, 0x06, 0xC0, 0x00,
  0x4C, 0x00, 0x06, 0x06, 0x80, 0x00, 0x6C, 0x00, 0x02, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x02, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x04, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x08, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x10, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x20, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x78, 0x00, 0x60, 0x7F, 0xE0, 0x0C, 0x3C,
  0x0E, 0x01, 0x8E, 0x00, 0xC0, 0x33, 0x00, 0x0C, 0x04, 0xC0, 0x01, 0x81,
  0x90, 0x00, 0x18, 0x36, 0x00, 0x03, 0x07, 0x80, 0x00, 0x60, 0xE0, 0x00,
  0x0C, 0x1C, 0x00, 0x01, 0x83, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x06, 0x18,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x18, 0x60, 0x00, 0x02, 0x0C, 0x00, 0x00,
  0xC1, 0x00, 0x00, 0x18, 0x60, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x61, 0x80,
  0x00, 0x0C, 0x30, 0x00, 0x01, 0x06, 0x00, 0x00, 0x61, 0x80, 0x00, 0x0C,
  0x30, 0x00, 0x01, 0x86, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x06, 0x18, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x06, 0x18, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x18, 0x60, 0x00, 0x02, 0x0C, 0x00, 0x00, 0xC1, 0x00, 0x00,
  0x18, 0x60, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x61, 0x80, 0x00, 0x0C, 0x30,
  0x00, 0x01, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xE0,
  0x38, 0x00, 0x70, 0x03, 0x80, 0x18, 0x00, 0x38, 0x06, 0x00, 0x03, 0x01,
  0x80, 0x00, 0x30, 0x70, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x0C, 0x60, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x33, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x09, 0x80, 0x00, 0x03, 0x20, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x0D, 0x80, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x04,
  0xC0, 0x00, 0x01, 0x98, 0x00, 0x00, 0x33, 0x00, 0x00, 0x06, 0x60, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0x31, 0x80, 0x00, 0x06, 0x30, 0x00, 0x01, 0x86,
  0x00, 0x00, 0x70, 0x60, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x81, 0x80, 0x00,
  0xE0, 0x18, 0x00, 0x38, 0x03, 0x80, 0x0E, 0x00, 0x3C, 0x07, 0x80, 0x01,
  0xFF, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xC1,
  0xFF, 0x80, 0x01, 0x8F, 0x03, 0xC0, 0x03, 0x38, 0x01, 0xC0, 0x04, 0xC0,
  0x01, 0x80, 0x0B, 0x00, 0x01, 0x80, 0x3C, 0x00, 0x03, 0x00, 0x70, 0x00,
  0x06, 0x00, 0xC0, 0x00, 0x04, 0x01, 0x80, 0x00, 0x0C, 0x02, 0x00, 0x00,
  0x18, 0x0C, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00,
  0xC0, 0x60, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x03, 0x01, 0x00, 0x00, 0x04,
  0x06, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x60,
  0x30, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x01, 0x80, 0x80, 0x00, 0x03, 0x03,
  0x00, 0x00, 0x04, 0x06, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x30, 0x18,
  0x00, 0x00, 0x60, 0x30, 0x00, 0x01, 0x80, 0x40, 0x00, 0x03, 0x01, 0x80,
  0x00, 0x06, 0x03, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x30, 0x0C, 0x00,
  0x00, 0xC0, 0x1C, 0x00, 0x01, 0x80, 0x2C, 0x00, 0x06, 0x00, 0xDC, 0x00,
  0x18, 0x01, 0x9C, 0x00, 0x60, 0x03, 0x0E, 0x07, 0x80, 0x06, 0x0F, 0xFE,
  0x00, 0x08, 0x03, 0xE0, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xFF, 0x03, 0x00, 0xF0, 0x3C, 0x20, 0x1C, 0x00, 0xE2, 0x03, 0x80,
  0x03, 0x60, 0x70, 0x00, 0x36, 0x06, 0x00, 0x01, 0xE0, 0xC0, 0x00, 0x0E,
  0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x0C, 0x18, 0x00, 0x00, 0xC1, 0x00,
  0x00, 0x0C, 0x30, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00,
  0x86, 0x00, 0x00, 0x18, 0x60, 0x00, 0x01, 0x86, 0x00, 0x00, 0x18, 0x60,
  0x00, 0x01, 0x86, 0x00, 0x00, 0x18, 0x60, 0x00, 0x01, 0x0C, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x06, 0x0C, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x40,
  0xC0, 0x00, 0x0C, 0x06, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x3C, 0x07, 0x00,
  0x06, 0xC0, 0x38, 0x01, 0xCC, 0x01, 0xC0, 0x78, 0x80, 0x0F, 0xFE, 0x18,
  0x00, 0x3F, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0xF0, 0x18, 0x3F, 0x80, 0xC7, 0x80, 0x06, 0x70,
  0x00, 0x36, 0x00, 0x01, 0x20, 0x00, 0x1B, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xFF, 0x00, 0x07, 0x80, 0xE0, 0x03, 0x80, 0x0C, 0x01, 0x80,
  0x01, 0x80, 0xC0, 0x00, 0x70, 0x60, 0x00, 0x0C, 0x18, 0x00, 0x03, 0x06,
  0x00, 0x00, 0xC1, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x18, 0x40, 0x00, 0x0C, 0x18, 0x00, 0x03, 0x06,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0xE0, 0x38, 0x00, 0xE0, 0x07, 0x80, 0xF0,
  0x00, 0x7F, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x02,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00,
  0x06, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x30, 0x00, 0x60, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1F,
  0xC0, 0x07, 0x80, 0x0C, 0x00, 0x00, 0x61, 0x80, 0x00, 0x0C, 0x30, 0x00,
  0x01, 0x04, 0x00, 0x00, 0x61, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x01, 0x86,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x04, 0x18, 0x00, 0x01, 0x82, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x06, 0x18, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x18, 0x60,
  0x00, 0x02, 0x0C, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x18, 0x60, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x61, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x01, 0x06, 0x00,
  0x00, 0x60, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x01, 0x86, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x06, 0x18, 0x00, 0x00, 0x83, 0x00, 0x00, 0x30, 0x60, 0x00,
  0x06, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x38, 0x30, 0x00, 0x07, 0x06,
  0x00, 0x01, 0xC0, 0xC0, 0x00, 0x78, 0x18, 0x00, 0x1B, 0x01, 0x80, 0x07,
  0x60, 0x38, 0x01, 0xCC, 0x03, 0x80, 0xE1, 0x80, 0x3F, 0xF8, 0x20, 0x00,
  0xF0, 0x00, 0x00, 0x40, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x19, 0x80, 0x00, 0x0C, 0x60, 0x00, 0x03, 0x18, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x03,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x30, 0x06, 0x00, 0x0C,
  0x01, 0x80, 0x06, 0x00, 0x60, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x08, 0x00, 0x20, 0x06, 0x00, 0x0C, 0x01, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0xC0, 0x30, 0x00, 0x30, 0x18, 0x00, 0x0C, 0x06, 0x00,
  0x01, 0x03, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x06, 0x18,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0x63, 0x00, 0x00, 0x09, 0x80, 0x00, 0x03,
  0x60, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x07,
  0x80, 0x00, 0x70, 0x00, 0x1F, 0x00, 0x00, 0xE0, 0x00, 0x36, 0x00, 0x03,
  0xC0, 0x00, 0x6C, 0x00, 0x05, 0x80, 0x01, 0x98, 0x00, 0x1B, 0x00, 0x03,
  0x30, 0x00, 0x36, 0x00, 0x0E, 0x60, 0x00, 0xCC, 0x00, 0x18, 0xC0, 0x01,
  0x98, 0x00, 0x31, 0x80, 0x02, 0x30, 0x00, 0xC3, 0x00, 0x0C, 0x60, 0x01,
  0x83, 0x00, 0x18, 0xC0, 0x07, 0x06, 0x00, 0x60, 0x80, 0x0C, 0x0C, 0x00,
  0xC1, 0x80, 0x18, 0x18, 0x03, 0x03, 0x00, 0x60, 0x30, 0x06, 0x06, 0x00,
  0xC0, 0x60, 0x18, 0x0C, 0x03, 0x80, 0xC0, 0x30, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x30, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x30, 0x06, 0x03, 0x00, 0xC0,
  0x60, 0x0C, 0x0C, 0x01, 0x81, 0x80, 0x18, 0x18, 0x03, 0x03, 0x00, 0x30,
  0x60, 0x02, 0x0E, 0x00, 0x60, 0xC0, 0x04, 0x18, 0x00, 0x41, 0x00, 0x0C,
  0x30, 0x00, 0xC6, 0x00, 0x18, 0xC0, 0x01, 0x8C, 0x00, 0x31, 0x80, 0x03,
  0x30, 0x00, 0x63, 0x00, 0x06, 0x60, 0x00, 0xCC, 0x00, 0x0D, 0x80, 0x01,
  0x98, 0x00, 0x1B, 0x00, 0x03, 0x60, 0x00, 0x34, 0x00, 0x06, 0xC0, 0x00,
  0x78, 0x00, 0x05, 0x80, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x03,
  0x00, 0x30, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x18, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x30, 0x03, 0x00, 0x00,
  0xE0, 0x18, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x06, 0x03, 0x00, 0x00, 0x0C,
  0x18, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x66, 0x00, 0x00, 0x01, 0x98,
  0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x33, 0x00, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x30, 0x60, 0x00, 0x01,
  0x81, 0x80, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x01, 0x80,
  0x18, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x0C, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x18, 0x03, 0x80, 0x00, 0x60,
  0x0C, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x03, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00,
  0xC0, 0x18, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x60, 0x02, 0x00, 0x00,
  0x30, 0x01, 0x80, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x06, 0x00, 0x01, 0x80, 0x03, 0x00, 0x00, 0xC0,
  0x03, 0x00, 0x00, 0x60, 0x01, 0x80, 0x00, 0x30, 0x01, 0x80, 0x00, 0x18,
  0x00, 0xC0, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00,
  0x30, 0x18, 0x00, 0x00, 0x08, 0x1C, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00,
  0x03, 0x0E, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x00, 0xC7, 0x00, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x00, 0x11, 0x80, 0x00, 0x00, 0x09, 0x80, 0x00,
  0x00, 0x06, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x03, 0x80, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x07,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x03, 0x80, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xC3, 0x83, 0x80, 0x00, 0x63,
  0x00, 0x60, 0x00, 0x63, 0x00, 0x18, 0x00, 0x31, 0x80, 0x06, 0x00, 0x11,
  0x80, 0x03, 0x80, 0x18, 0xC0, 0x00, 0xE0, 0x18, 0x60, 0x00, 0x38, 0x18,
  0x60, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
};

const GFXglyph RobotoCondensed_ThinItalic71pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 11, 51, 13, 1, -50 },
  { 72, 11, 14, 18, 8, -53 },
  { 92, 36, 50, 33, 1, -50 },
  { 317, 29, 65, 33, 3, -57 },
  { 553, 34, 52, 45, 6, -51 },
  { 774, 31, 52, 37, 2, -51 },
  { 976, 5, 14, 11, 7, -53 },
  { 985, 20, 72, 19, 3, -56 },
  { 1165, 19, 72, 19, -4, -56 },
  { 1336, 27, 27, 29, 4, -50 },
  { 1428, 29, 37, 34, 3, -43 },
  { 1563, 7, 14, 13, -2, -5 },
  { 1576, 13, 2, 19, 3, -24 },
  { 1580, 4, 4, 15, 2, -3 },
  { 1582, 29, 54, 24, -3, -50 },
  { 1778, 28, 52, 33, 3, -51 },
  { 1960, 15, 50, 33, 10, -50 },
  { 2054, 29, 51, 33, 2, -51 },
  { 2239, 30, 52, 33, 2, -51 },
  { 2434, 29, 50, 33, 2, -50 },
  { 2616, 30, 51, 33, 4, -50 },
  { 2808, 26, 51, 33, 3, -50 },
  { 2974, 28, 50, 33, 6, -50 },
  { 3149, 31, 52, 33, 1, -51 },
  { 3351, 26, 51, 33, 5, -51 },
  { 3517, 10, 37, 12, 1, -36 },
  { 3564, 13, 45, 12, -2, -36 },
  { 3638, 27, 28, 31, 3, -37 },
  { 3733, 26, 16, 34, 4, -31 },
  { 3785, 26, 28, 31, 2, -37 },
  { 3876, 21, 52, 27, 6, -51 },
  { 4013, 50, 65, 55, 2, -49 },
  { 4420, 33, 50, 36, -2, -50 },
  { 4627, 31, 50, 37, 3, -50 },
  { 4821, 34, 52, 39, 4, -51 },
  { 5042, 34, 50, 39, 3, -50 },
  { 5255, 34, 50, 35, 3, -50 },
  { 5468, 34, 50, 35, 3, -50 },
  { 5681, 34, 52, 41, 5, -51 },
  { 5902, 38, 50, 42, 3, -50 },
  { 6140, 10, 50, 17, 4, -50 },
  { 6203, 31, 51, 33, 1, -50 },
  { 6401, 37, 50, 38, 3, -50 },
  { 6633, 23, 50, 32, 3, -50 },
  { 6777, 47, 50, 51, 3, -50 },
  { 7071, 39, 50, 43, 3, -50 },
  { 7315, 34, 52, 40, 4, -51 },
  { 7536, 33, 50, 36, 3, -50 },
  { 7743, 34, 60, 40, 4, -51 },
  { 7998, 34, 50, 39, 3, -50 },
  { 8211, 34, 52, 36, 2, -51 },
  { 8432, 32, 50, 36, 7, -50 },
  { 8632, 35, 51, 40, 4, -50 },
  { 8856, 33, 50, 36, 6, -50 },
  { 9063, 49, 50, 54, 7, -50 },
  { 9370, 39, 50, 36, -1, -50 },
  { 9614, 33, 50, 36, 7, -50 },
  { 9821, 37, 50, 36, 0, -50 },
  { 10053, 19, 69, 14, 1, -58 },
  { 10217, 10, 54, 23, 7, -50 },
  { 10285, 19, 69, 14, -5, -58 },
  { 10449, 19, 25, 26, 4, -50 },
  { 10509, 24, 2, 26, -3, 0 },
  { 10515, 7, 9, 18, 10, -53 },
  { 10523, 27, 40, 32, 1, -39 },
  { 10658, 28, 54, 33, 2, -53 },
  { 10847, 27, 40, 31, 2, -39 },
  { 10982, 31, 54, 33, 3, -53 },
  { 11192, 27, 40, 31, 2, -39 },
  { 11327, 22, 54, 20, 4, -54 },
  { 11476, 30, 53, 33, 1, -39 },
  { 11675, 27, 53, 33, 2, -53 },
  { 11854, 12, 52, 13, 2, -52 },
  { 11932, 23, 66, 14, -9, -52 },
  { 12122, 28, 53, 29, 2, -53 },
  { 12308, 11, 53, 13, 2, -53 },
  { 12381, 48, 39, 54, 2, -39 },
  { 12615, 27, 39, 33, 2, -39 },
  { 12747, 27, 40, 33, 3, -39 },
  { 12882, 31, 53, 33, -1, -39 },
  { 13088, 28, 53, 33, 3, -39 },
  { 13274, 21, 39, 21, 2, -39 },
  { 13377, 26, 40, 30, 1, -39 },
  { 13507, 15, 49, 20, 4, -48 },
  { 13599, 27, 39, 33, 4, -38 },
  { 13731, 26, 38, 29, 4, -38 },
  { 13855, 39, 38, 46, 6, -38 },
  { 14041, 30, 38, 29, -1, -38 },
  { 14184, 33, 52, 29, -3, -38 },
  { 14399, 30, 38, 29, -1, -38 },
  { 14542, 23, 70, 20, 2, -55 },
  { 14744, 12, 59, 14, 1, -50 },
  { 14833, 23, 70, 20, -5, -55 },
  { 15035, 33, 11, 42, 4, -26 },
};

const GFXfont RobotoCondensed_ThinItalic71pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ThinItalic71pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ThinItalic71pt7bGlyphs,
  0x20, 0x7E, 83
};

#endif // _ROBOTOCONDENSED_THINITALIC71PT7B_H_
