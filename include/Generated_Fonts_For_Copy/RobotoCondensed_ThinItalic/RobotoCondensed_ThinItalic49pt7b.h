#ifndef _ROBOTOCONDENSED_THINITALIC49PT7B_H_
#define _ROBOTOCONDENSED_THINITALIC49PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ThinItalic.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ThinItalic49pt7bBitmaps[] PROGMEM = {
  0x00, 0x02, 0x02, 0x02, 0x02, 0x06, 0x06, 0x04, 0x04, 0x04, 0x04, 0x0C,
  0x0C, 0x08, 0x08, 0x08, 0x08, 0x18, 0x10, 0x10, 0x10, 0x10, 0x10, 0x30,
  0x20, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0xC0,
  0x21, 0x21, 0x23, 0x23, 0x62, 0x62, 0x42, 0x42, 0x46, 0xC6, 0x00, 0x04,
  0x04, 0x00, 0x04, 0x04, 0x00, 0x0C, 0x04, 0x00, 0x08, 0x0C, 0x00, 0x08,
  0x08, 0x00, 0x18, 0x08, 0x00, 0x10, 0x18, 0x00, 0x10, 0x10, 0x00, 0x30,
  0x10, 0x00, 0x20, 0x30, 0x0F, 0xFF, 0xFF, 0x00, 0x60, 0x20, 0x00, 0x40,
  0x60, 0x00, 0x40, 0x40, 0x00, 0xC0, 0x40, 0x00, 0x80, 0xC0, 0x00, 0x80,
  0x80, 0x01, 0x80, 0x80, 0x01, 0x01, 0x80, 0x01, 0x01, 0x00, 0x01, 0x01,
  0x00, 0x02, 0x03, 0x00, 0x02, 0x02, 0x00, 0x02, 0x02, 0x00, 0xFF, 0xFF,
  0xF0, 0x04, 0x04, 0x00, 0x04, 0x04, 0x00, 0x0C, 0x04, 0x00, 0x08, 0x08,
  0x00, 0x08, 0x08, 0x00, 0x18, 0x08, 0x00, 0x10, 0x18, 0x00, 0x10, 0x10,
  0x00, 0x30, 0x10, 0x00, 0x20, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x3F, 0x00, 0x0E, 0x18, 0x01, 0x80,
  0x40, 0x30, 0x06, 0x06, 0x00, 0x20, 0x40, 0x03, 0x08, 0x00, 0x10, 0x80,
  0x01, 0x08, 0x00, 0x10, 0x80, 0x01, 0x18, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x88, 0x00, 0x08, 0x80, 0x00,
  0x88, 0x00, 0x08, 0x80, 0x01, 0x8C, 0x00, 0x10, 0x40, 0x03, 0x06, 0x00,
  0x60, 0x30, 0x0C, 0x01, 0x83, 0x80, 0x07, 0xE0, 0x00, 0x10, 0x00, 0x01,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x07, 0xC0, 0x00,
  0x0C, 0x60, 0x00, 0x18, 0x20, 0x00, 0x30, 0x30, 0x00, 0x20, 0x10, 0x00,
  0x60, 0x10, 0x08, 0x40, 0x10, 0x18, 0x40, 0x10, 0x30, 0x40, 0x30, 0x20,
  0x40, 0x20, 0x40, 0x40, 0x20, 0xC0, 0x40, 0x60, 0x80, 0x40, 0x41, 0x00,
  0x60, 0xC3, 0x00, 0x33, 0x86, 0x00, 0x1E, 0x04, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x78, 0x00, 0x61, 0x8C,
  0x00, 0xC3, 0x06, 0x00, 0x82, 0x02, 0x01, 0x06, 0x02, 0x03, 0x04, 0x02,
  0x02, 0x04, 0x02, 0x04, 0x0C, 0x02, 0x0C, 0x08, 0x02, 0x08, 0x08, 0x02,
  0x10, 0x08, 0x06, 0x20, 0x08, 0x04, 0x00, 0x0C, 0x0C, 0x00, 0x04, 0x18,
  0x00, 0x06, 0x30, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xC6, 0x00,
  0x04, 0x0C, 0x00, 0x20, 0x10, 0x01, 0x80, 0x40, 0x04, 0x01, 0x00, 0x10,
  0x04, 0x00, 0xC0, 0x10, 0x03, 0x00, 0xC0, 0x0C, 0x02, 0x00, 0x30, 0x10,
  0x00, 0x40, 0x80, 0x01, 0x04, 0x00, 0x06, 0x20, 0x00, 0x0B, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xC0, 0x00, 0x05, 0x80, 0x00, 0x22, 0x00, 0x01, 0x04,
  0x00, 0x08, 0x18, 0x04, 0x40, 0x20, 0x33, 0x00, 0xC0, 0xC8, 0x01, 0x02,
  0x60, 0x06, 0x19, 0x00, 0x08, 0x44, 0x00, 0x11, 0x10, 0x00, 0x68, 0x40,
  0x00, 0xE1, 0x00, 0x03, 0x04, 0x00, 0x0C, 0x18, 0x00, 0x58, 0x30, 0x02,
  0x20, 0x60, 0x30, 0x40, 0xFF, 0x01, 0x80, 0x40, 0x00, 0x25, 0xB6, 0x92,
  0xD0, 0x00, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x03, 0x00,
  0x08, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00,
  0x20, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x02,
  0x00, 0x0C, 0x00, 0x10, 0x00, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40,
  0x02, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x20, 0x03,
  0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x20, 0x01, 0x00,
  0x10, 0x00, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0x80, 0x20, 0x10, 0x17, 0x02, 0x0E, 0x1C, 0x4E,
  0x00, 0xFF, 0x00, 0x03, 0x00, 0x00, 0xA0, 0x00, 0x36, 0x00, 0x0C, 0x40,
  0x03, 0x0C, 0x00, 0xC0, 0xC0, 0x10, 0x08, 0x04, 0x01, 0x81, 0x80, 0x10,
  0x00, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00,
  0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0xFF, 0xFF, 0xF0, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x00, 0x00, 0x18, 0xC4, 0x23, 0x18, 0x8C, 0xC4, 0x00, 0xFF,
  0x80, 0x5F, 0x00, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00,
  0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60,
  0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x10,
  0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x0E, 0x18, 0x01, 0x80, 0xC0, 0x30, 0x06,
  0x06, 0x00, 0x20, 0x40, 0x02, 0x0C, 0x00, 0x20, 0x80, 0x03, 0x08, 0x00,
  0x31, 0x00, 0x03, 0x10, 0x00, 0x31, 0x00, 0x03, 0x30, 0x00, 0x22, 0x00,
  0x02, 0x20, 0x00, 0x22, 0x00, 0x02, 0x20, 0x00, 0x26, 0x00, 0x06, 0x40,
  0x00, 0x64, 0x00, 0x04, 0x40, 0x00, 0x44, 0x00, 0x04, 0x40, 0x00, 0xCC,
  0x00, 0x08, 0xC0, 0x00, 0x8C, 0x00, 0x08, 0xC0, 0x01, 0x84, 0x00, 0x10,
  0x40, 0x03, 0x04, 0x00, 0x20, 0x40, 0x06, 0x02, 0x00, 0xC0, 0x30, 0x18,
  0x01, 0x87, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xC0, 0xF0, 0xED, 0xC2, 0xC0,
  0x80, 0x20, 0x08, 0x02, 0x01, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x30, 0x08, 0x02, 0x00, 0x80, 0x20, 0x18, 0x06, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x00, 0x80, 0x60, 0x10, 0x04,
  0x01, 0x00, 0x00, 0x3F, 0x00, 0x0E, 0x1C, 0x01, 0x80, 0x60, 0x30, 0x02,
  0x06, 0x00, 0x30, 0x40, 0x01, 0x0C, 0x00, 0x10, 0x80, 0x01, 0x08, 0x00,
  0x11, 0x80, 0x01, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x06, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x04, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x03, 0x86, 0x00,
  0x20, 0x18, 0x02, 0x00, 0x60, 0x20, 0x01, 0x03, 0x00, 0x08, 0x10, 0x00,
  0x61, 0x80, 0x03, 0x08, 0x00, 0x18, 0x40, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x0F, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x62,
  0x00, 0x03, 0x10, 0x00, 0x10, 0x80, 0x00, 0x84, 0x00, 0x0C, 0x20, 0x00,
  0x41, 0x80, 0x06, 0x06, 0x00, 0x60, 0x18, 0x06, 0x00, 0x70, 0xE0, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0A,
  0x00, 0x01, 0x20, 0x00, 0x26, 0x00, 0x06, 0x60, 0x00, 0x44, 0x00, 0x08,
  0x40, 0x01, 0x84, 0x00, 0x30, 0x40, 0x02, 0x0C, 0x00, 0x40, 0x80, 0x0C,
  0x08, 0x01, 0x80, 0x80, 0x10, 0x08, 0x03, 0x00, 0x80, 0x60, 0x18, 0x04,
  0x01, 0x00, 0x80, 0x10, 0x18, 0x01, 0x03, 0x00, 0x10, 0x20, 0x03, 0x04,
  0x00, 0x30, 0xFF, 0xFF, 0xF0, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x03, 0xFF, 0xF0, 0x10, 0x00, 0x00,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x80, 0x00, 0x08, 0xFC, 0x00, 0x5C, 0x38, 0x03, 0x80, 0x60,
  0x10, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x84,
  0x00, 0x04, 0x20, 0x00, 0x61, 0x00, 0x02, 0x0C, 0x00, 0x10, 0x20, 0x01,
  0x01, 0x00, 0x18, 0x0C, 0x00, 0x80, 0x30, 0x08, 0x00, 0xE3, 0x80, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x03, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x10, 0x7C, 0x0C, 0x61, 0xC2, 0x60, 0x18,
  0xB0, 0x02, 0x30, 0x00, 0xDC, 0x00, 0x36, 0x00, 0x05, 0x80, 0x01, 0x40,
  0x00, 0x50, 0x00, 0x14, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x09, 0x00, 0x02, 0x40, 0x01, 0x10, 0x00, 0xC6, 0x00, 0x20,
  0x80, 0x18, 0x30, 0x0C, 0x07, 0x0E, 0x00, 0x7E, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x03,
  0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00,
  0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x03, 0x87, 0x00, 0x30, 0x1C, 0x03, 0x00, 0x60,
  0x30, 0x01, 0x83, 0x00, 0x04, 0x10, 0x00, 0x20, 0x80, 0x01, 0x0C, 0x00,
  0x08, 0x40, 0x00, 0x42, 0x00, 0x06, 0x10, 0x00, 0x20, 0xC0, 0x03, 0x02,
  0x00, 0x10, 0x18, 0x01, 0x00, 0x60, 0x30, 0x01, 0xC7, 0x00, 0x0F, 0xE0,
  0x01, 0xC0, 0xC0, 0x18, 0x03, 0x01, 0x80, 0x0C, 0x18, 0x00, 0x20, 0x80,
  0x01, 0x8C, 0x00, 0x04, 0x40, 0x00, 0x22, 0x00, 0x01, 0x30, 0x00, 0x19,
  0x80, 0x00, 0x8C, 0x00, 0x04, 0x20, 0x00, 0x41, 0x00, 0x06, 0x0C, 0x00,
  0x60, 0x30, 0x06, 0x00, 0xE0, 0xE0, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x70, 0xE0, 0x18, 0x06, 0x06, 0x00, 0x40, 0x80, 0x0C, 0x30, 0x00, 0x84,
  0x00, 0x11, 0x00, 0x02, 0x20, 0x00, 0x6C, 0x00, 0x0D, 0x00, 0x01, 0xA0,
  0x00, 0x24, 0x00, 0x04, 0x80, 0x00, 0x90, 0x00, 0x12, 0x00, 0x06, 0x40,
  0x00, 0xC8, 0x00, 0x39, 0x00, 0x06, 0x30, 0x01, 0x42, 0x00, 0x68, 0x60,
  0x1B, 0x07, 0x0C, 0x40, 0x3E, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00,
  0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x18, 0x30,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0xC1, 0x80, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x10, 0x08,
  0x0C, 0x06, 0x02, 0x03, 0x01, 0x01, 0x80, 0x80, 0x00, 0x00, 0x40, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07,
  0x00, 0x00, 0x60, 0x00, 0x08, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x10, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0x80, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0x40, 0x00, 0x00, 0x03, 0xE0, 0x0C, 0x30, 0x60, 0x30, 0x80, 0x22,
  0x00, 0x44, 0x00, 0xD0, 0x01, 0xA0, 0x03, 0xC0, 0x06, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x60, 0x00, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x04,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0xE0, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0xE0, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x06, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x0C, 0x00, 0x00, 0x10, 0x06, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x00,
  0x80, 0x80, 0x00, 0x00, 0x20, 0x60, 0x07, 0xC0, 0x08, 0x30, 0x03, 0x18,
  0x02, 0x08, 0x03, 0x01, 0x00, 0xC6, 0x00, 0x80, 0x40, 0x31, 0x00, 0x40,
  0x10, 0x0C, 0x40, 0x30, 0x04, 0x03, 0x30, 0x08, 0x03, 0x00, 0xC8, 0x04,
  0x00, 0x80, 0x36, 0x01, 0x00, 0x20, 0x09, 0x00, 0xC0, 0x08, 0x02, 0x40,
  0x20, 0x06, 0x00, 0x90, 0x08, 0x01, 0x00, 0x2C, 0x06, 0x00, 0x40, 0x1A,
  0x01, 0x00, 0x10, 0x04, 0x80, 0x40, 0x0C, 0x01, 0x20, 0x10, 0x02, 0x00,
  0x48, 0x04, 0x00, 0x80, 0x32, 0x03, 0x00, 0x60, 0x08, 0x80, 0xC0, 0x18,
  0x06, 0x20, 0x30, 0x0A, 0x01, 0x08, 0x0C, 0x02, 0x80, 0xC2, 0x01, 0x01,
  0x20, 0x60, 0x80, 0x61, 0x8C, 0x30, 0x20, 0x0F, 0xC1, 0xF8, 0x0C, 0x00,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x02, 0x00,
  0x00, 0x0F, 0x0F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x05, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x24,
  0x00, 0x00, 0x4C, 0x00, 0x01, 0x08, 0x00, 0x02, 0x10, 0x00, 0x0C, 0x20,
  0x00, 0x10, 0x40, 0x00, 0x60, 0x80, 0x00, 0x81, 0x00, 0x03, 0x02, 0x00,
  0x04, 0x06, 0x00, 0x18, 0x04, 0x00, 0x20, 0x08, 0x00, 0xC0, 0x10, 0x01,
  0x00, 0x20, 0x06, 0x00, 0x40, 0x08, 0x00, 0x80, 0x10, 0x01, 0x80, 0x40,
  0x03, 0x00, 0x80, 0x02, 0x02, 0x00, 0x04, 0x07, 0xFF, 0xF8, 0x10, 0x00,
  0x10, 0x20, 0x00, 0x20, 0xC0, 0x00, 0x61, 0x00, 0x00, 0xC6, 0x00, 0x01,
  0x88, 0x00, 0x01, 0x30, 0x00, 0x02, 0x40, 0x00, 0x05, 0x80, 0x00, 0x0A,
  0x00, 0x00, 0x18, 0x03, 0xFF, 0x80, 0x08, 0x03, 0x80, 0x60, 0x03, 0x01,
  0x80, 0x06, 0x04, 0x00, 0x08, 0x10, 0x00, 0x20, 0x40, 0x00, 0xC1, 0x00,
  0x03, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x20, 0x80, 0x00, 0x82, 0x00, 0x06,
  0x08, 0x00, 0x10, 0x20, 0x00, 0xC1, 0x80, 0x06, 0x06, 0x00, 0x30, 0x10,
  0x07, 0x00, 0x7F, 0xFC, 0x01, 0x00, 0x1C, 0x04, 0x00, 0x18, 0x30, 0x00,
  0x60, 0x80, 0x00, 0xC2, 0x00, 0x03, 0x08, 0x00, 0x04, 0x20, 0x00, 0x11,
  0x80, 0x00, 0x46, 0x00, 0x03, 0x10, 0x00, 0x08, 0x40, 0x00, 0x21, 0x00,
  0x01, 0x84, 0x00, 0x0C, 0x30, 0x00, 0x60, 0xC0, 0x03, 0x02, 0x00, 0x38,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xE0, 0xE0, 0x06, 0x00,
  0x60, 0x18, 0x00, 0x40, 0x60, 0x00, 0xC1, 0x80, 0x00, 0x82, 0x00, 0x01,
  0x0C, 0x00, 0x03, 0x10, 0x00, 0x06, 0x20, 0x00, 0x0C, 0xC0, 0x00, 0x19,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x80, 0x00, 0x11, 0x00, 0x00, 0x22, 0x00, 0x00, 0xC4, 0x00, 0x01,
  0x0C, 0x00, 0x06, 0x08, 0x00, 0x08, 0x10, 0x00, 0x20, 0x30, 0x00, 0xC0,
  0x30, 0x03, 0x00, 0x38, 0x38, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFF, 0x80,
  0x02, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x06, 0x00, 0x08, 0x04, 0x00, 0x0C,
  0x04, 0x00, 0x04, 0x04, 0x00, 0x06, 0x04, 0x00, 0x02, 0x0C, 0x00, 0x02,
  0x0C, 0x00, 0x02, 0x08, 0x00, 0x02, 0x08, 0x00, 0x02, 0x08, 0x00, 0x02,
  0x08, 0x00, 0x02, 0x18, 0x00, 0x02, 0x10, 0x00, 0x02, 0x10, 0x00, 0x06,
  0x10, 0x00, 0x06, 0x10, 0x00, 0x04, 0x10, 0x00, 0x04, 0x30, 0x00, 0x04,
  0x20, 0x00, 0x04, 0x20, 0x00, 0x0C, 0x20, 0x00, 0x08, 0x20, 0x00, 0x08,
  0x60, 0x00, 0x18, 0x60, 0x00, 0x10, 0x40, 0x00, 0x30, 0x40, 0x00, 0x20,
  0x40, 0x00, 0x60, 0x40, 0x00, 0xC0, 0xC0, 0x01, 0x80, 0xC0, 0x07, 0x00,
  0x80, 0x3C, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFE, 0x04, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x40, 0x00,
  0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x70, 0x70, 0x00, 0xC0, 0x18, 0x01, 0x00, 0x0C, 0x02, 0x00, 0x06, 0x06,
  0x00, 0x02, 0x0C, 0x00, 0x02, 0x08, 0x00, 0x02, 0x18, 0x00, 0x03, 0x10,
  0x00, 0x03, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x0F, 0xFC, 0x40, 0x00, 0x0C, 0x40,
  0x00, 0x08, 0x40, 0x00, 0x08, 0xC0, 0x00, 0x08, 0xC0, 0x00, 0x08, 0xC0,
  0x00, 0x18, 0x40, 0x00, 0x18, 0x40, 0x00, 0x10, 0x40, 0x00, 0x10, 0x60,
  0x00, 0x10, 0x20, 0x00, 0x30, 0x30, 0x00, 0x60, 0x18, 0x01, 0xC0, 0x0E,
  0x1F, 0x00, 0x03, 0xF8, 0x00, 0x02, 0x00, 0x00, 0x40, 0x80, 0x00, 0x10,
  0x60, 0x00, 0x04, 0x18, 0x00, 0x01, 0x04, 0x00, 0x00, 0xC1, 0x00, 0x00,
  0x20, 0x40, 0x00, 0x08, 0x10, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x83, 0x00,
  0x00, 0x20, 0x80, 0x00, 0x18, 0x20, 0x00, 0x04, 0x08, 0x00, 0x01, 0x02,
  0x00, 0x00, 0x41, 0x80, 0x00, 0x10, 0x40, 0x00, 0x0C, 0x10, 0x00, 0x03,
  0x07, 0xFF, 0xFF, 0x81, 0x00, 0x00, 0x20, 0x40, 0x00, 0x08, 0x30, 0x00,
  0x02, 0x08, 0x00, 0x01, 0x82, 0x00, 0x00, 0x60, 0x80, 0x00, 0x10, 0x20,
  0x00, 0x04, 0x18, 0x00, 0x01, 0x06, 0x00, 0x00, 0x41, 0x00, 0x00, 0x30,
  0x40, 0x00, 0x0C, 0x10, 0x00, 0x02, 0x04, 0x00, 0x00, 0x83, 0x00, 0x00,
  0x20, 0xC0, 0x00, 0x08, 0x20, 0x00, 0x06, 0x08, 0x00, 0x01, 0x00, 0x02,
  0x0C, 0x10, 0x20, 0x40, 0x83, 0x06, 0x08, 0x10, 0x20, 0x41, 0x83, 0x04,
  0x08, 0x10, 0x20, 0xC1, 0x82, 0x04, 0x08, 0x10, 0x60, 0xC1, 0x02, 0x04,
  0x08, 0x30, 0x40, 0x81, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x86,
  0x00, 0x04, 0x20, 0x00, 0x61, 0x00, 0x02, 0x08, 0x00, 0x30, 0x60, 0x01,
  0x01, 0x00, 0x18, 0x08, 0x01, 0x80, 0x60, 0x18, 0x01, 0xC3, 0x80, 0x03,
  0xF0, 0x00, 0x02, 0x00, 0x01, 0x81, 0x00, 0x01, 0x81, 0x80, 0x01, 0x80,
  0xC0, 0x01, 0x80, 0x40, 0x01, 0x80, 0x20, 0x01, 0x80, 0x10, 0x01, 0x80,
  0x08, 0x01, 0x80, 0x0C, 0x01, 0x80, 0x06, 0x01, 0x80, 0x02, 0x01, 0x80,
  0x01, 0x01, 0x80, 0x00, 0x81, 0x80, 0x00, 0x41, 0x80, 0x00, 0x61, 0x80,
  0x00, 0x21, 0x80, 0x00, 0x11, 0xC0, 0x00, 0x09, 0xB0, 0x00, 0x05, 0x88,
  0x00, 0x03, 0x86, 0x00, 0x03, 0x81, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x80,
  0x20, 0x00, 0x40, 0x08, 0x00, 0x20, 0x06, 0x00, 0x30, 0x01, 0x00, 0x18,
  0x00, 0xC0, 0x08, 0x00, 0x20, 0x04, 0x00, 0x18, 0x02, 0x00, 0x04, 0x01,
  0x00, 0x03, 0x01, 0x80, 0x00, 0x80, 0xC0, 0x00, 0x60, 0x40, 0x00, 0x10,
  0x20, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00,
  0xFF, 0xFF, 0x03, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0x00, 0xC0, 0xE0, 0x00, 0x00, 0xA0, 0x50, 0x00, 0x00, 0x50, 0x2C,
  0x00, 0x00, 0x48, 0x12, 0x00, 0x00, 0x6C, 0x09, 0x00, 0x00, 0x24, 0x0C,
  0x80, 0x00, 0x32, 0x04, 0x40, 0x00, 0x11, 0x02, 0x30, 0x00, 0x18, 0x81,
  0x18, 0x00, 0x08, 0xC0, 0x84, 0x00, 0x0C, 0x60, 0x42, 0x00, 0x04, 0x20,
  0x61, 0x00, 0x06, 0x10, 0x20, 0x80, 0x02, 0x08, 0x10, 0x60, 0x03, 0x04,
  0x08, 0x10, 0x01, 0x06, 0x04, 0x08, 0x01, 0x03, 0x02, 0x04, 0x00, 0x81,
  0x03, 0x02, 0x00, 0x80, 0x81, 0x01, 0x00, 0x40, 0x40, 0x80, 0x40, 0x40,
  0x20, 0x40, 0x20, 0x60, 0x30, 0x20, 0x10, 0x20, 0x18, 0x30, 0x08, 0x30,
  0x08, 0x18, 0x04, 0x10, 0x04, 0x08, 0x03, 0x18, 0x02, 0x04, 0x00, 0x88,
  0x01, 0x02, 0x00, 0x4C, 0x01, 0x81, 0x00, 0x24, 0x00, 0xC1, 0x80, 0x16,
  0x00, 0x40, 0xC0, 0x0A, 0x00, 0x20, 0x40, 0x03, 0x00, 0x10, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x60, 0x60, 0x00, 0x08, 0x1C, 0x00,
  0x01, 0x03, 0xC0, 0x00, 0x20, 0x68, 0x00, 0x04, 0x09, 0x00, 0x01, 0x81,
  0x30, 0x00, 0x30, 0x22, 0x00, 0x04, 0x0C, 0x40, 0x00, 0x81, 0x84, 0x00,
  0x10, 0x20, 0x80, 0x02, 0x04, 0x18, 0x00, 0xC0, 0x81, 0x00, 0x18, 0x10,
  0x20, 0x02, 0x06, 0x02, 0x00, 0x40, 0xC0, 0x40, 0x08, 0x10, 0x0C, 0x03,
  0x02, 0x00, 0x80, 0x60, 0x40, 0x10, 0x0C, 0x08, 0x03, 0x01, 0x03, 0x00,
  0x20, 0x20, 0x60, 0x04, 0x04, 0x08, 0x00, 0x41, 0x81, 0x00, 0x08, 0x30,
  0x20, 0x01, 0x84, 0x0C, 0x00, 0x10, 0x81, 0x80, 0x02, 0x10, 0x30, 0x00,
  0x22, 0x04, 0x00, 0x04, 0xC0, 0x80, 0x00, 0xD8, 0x10, 0x00, 0x0A, 0x06,
  0x00, 0x01, 0x40, 0xC0, 0x00, 0x38, 0x10, 0x00, 0x03, 0x02, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xE0, 0xE0, 0x06, 0x00, 0x60, 0x18,
  0x00, 0x40, 0x60, 0x00, 0x41, 0x80, 0x00, 0x82, 0x00, 0x01, 0x8C, 0x00,
  0x01, 0x10, 0x00, 0x02, 0x60, 0x00, 0x04, 0x80, 0x00, 0x09, 0x00, 0x00,
  0x12, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x58, 0x00, 0x01, 0xA0, 0x00, 0x03,
  0x40, 0x00, 0x04, 0x80, 0x00, 0x09, 0x00, 0x00, 0x16, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0xD0, 0x00, 0x01, 0x20, 0x00, 0x02, 0x40, 0x00, 0x04, 0x80,
  0x00, 0x19, 0x00, 0x00, 0x22, 0x00, 0x00, 0x44, 0x00, 0x01, 0x88, 0x00,
  0x02, 0x18, 0x00, 0x08, 0x10, 0x00, 0x30, 0x30, 0x00, 0xC0, 0x30, 0x03,
  0x00, 0x38, 0x38, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x04, 0x00,
  0xE0, 0x18, 0x00, 0x60, 0x30, 0x00, 0x60, 0x40, 0x00, 0x40, 0x80, 0x00,
  0x81, 0x00, 0x01, 0x82, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x18, 0x00, 0x0C,
  0x20, 0x00, 0x10, 0x40, 0x00, 0x20, 0x80, 0x00, 0x41, 0x00, 0x01, 0x86,
  0x00, 0x06, 0x0C, 0x00, 0x08, 0x10, 0x00, 0x30, 0x20, 0x01, 0xC0, 0x40,
  0x0E, 0x00, 0xFF, 0xF0, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0xE0, 0xE0, 0x06, 0x00, 0x60, 0x18, 0x00, 0x40,
  0x60, 0x00, 0x41, 0x80, 0x00, 0x82, 0x00, 0x01, 0x8C, 0x00, 0x01, 0x10,
  0x00, 0x02, 0x60, 0x00, 0x04, 0x80, 0x00, 0x09, 0x00, 0x00, 0x12, 0x00,
  0x00, 0x2C, 0x00, 0x00, 0x58, 0x00, 0x01, 0xA0, 0x00, 0x02, 0x40, 0x00,
  0x04, 0x80, 0x00, 0x09, 0x00, 0x00, 0x16, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0xD0, 0x00, 0x01, 0x20, 0x00, 0x02, 0x40, 0x00, 0x04, 0x80, 0x00, 0x19,
  0x00, 0x00, 0x22, 0x00, 0x00, 0x44, 0x00, 0x01, 0x08, 0x00, 0x02, 0x18,
  0x00, 0x08, 0x10, 0x00, 0x30, 0x30, 0x00, 0xC0, 0x30, 0x03, 0x00, 0x38,
  0x38, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x03, 0xFF,
  0xC0, 0x04, 0x00, 0xE0, 0x18, 0x00, 0x60, 0x20, 0x00, 0x60, 0x40, 0x00,
  0x40, 0x80, 0x00, 0xC1, 0x00, 0x01, 0x86, 0x00, 0x01, 0x0C, 0x00, 0x02,
  0x10, 0x00, 0x04, 0x20, 0x00, 0x18, 0x40, 0x00, 0x20, 0x80, 0x00, 0x43,
  0x00, 0x01, 0x86, 0x00, 0x02, 0x08, 0x00, 0x08, 0x10, 0x00, 0x30, 0x20,
  0x00, 0xC0, 0x40, 0x06, 0x01, 0xFF, 0xF0, 0x03, 0x00, 0x60, 0x04, 0x00,
  0x40, 0x08, 0x00, 0xC0, 0x10, 0x01, 0x80, 0x20, 0x01, 0x00, 0xC0, 0x03,
  0x01, 0x00, 0x06, 0x02, 0x00, 0x04, 0x04, 0x00, 0x0C, 0x08, 0x00, 0x18,
  0x10, 0x00, 0x10, 0x60, 0x00, 0x30, 0x80, 0x00, 0x61, 0x00, 0x00, 0x42,
  0x00, 0x00, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x78, 0x38, 0x00, 0xC0, 0x0C,
  0x01, 0x00, 0x04, 0x02, 0x00, 0x06, 0x06, 0x00, 0x02, 0x04, 0x00, 0x02,
  0x0C, 0x00, 0x02, 0x08, 0x00, 0x02, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18,
  0xC0, 0x00, 0x10, 0x40, 0x00, 0x10, 0x40, 0x00, 0x30, 0x60, 0x00, 0x60,
  0x20, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x0E, 0x0F, 0x00, 0x03, 0xF8, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x01, 0x0C, 0x00, 0x01, 0x08, 0x00, 0x01, 0x08, 0x00,
  0x03, 0x08, 0x00, 0x02, 0x08, 0x00, 0x02, 0x18, 0x00, 0x02, 0x18, 0x00,
  0x02, 0x10, 0x00, 0x02, 0x10, 0x00, 0x06, 0x10, 0x00, 0x04, 0x10, 0x00,
  0x04, 0x30, 0x00, 0x04, 0x20, 0x00, 0x04, 0x20, 0x00, 0x0C, 0x20, 0x00,
  0x0C, 0x20, 0x00, 0x08, 0x20, 0x00, 0x08, 0x60, 0x00, 0x08, 0x40, 0x00,
  0x08, 0x40, 0x00, 0x18, 0x40, 0x00, 0x10, 0x40, 0x00, 0x10, 0xC0, 0x00,
  0x10, 0xC0, 0x00, 0x10, 0x80, 0x00, 0x30, 0x80, 0x00, 0x20, 0x80, 0x00,
  0x20, 0xC0, 0x00, 0x60, 0x40, 0x00, 0x40, 0x40, 0x00, 0xC0, 0x60, 0x01,
  0x80, 0x30, 0x07, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0xF0, 0x00, 0xC0, 0x00,
  0x02, 0x80, 0x00, 0x0D, 0x00, 0x00, 0x12, 0x00, 0x00, 0x64, 0x00, 0x00,
  0x88, 0x00, 0x03, 0x18, 0x00, 0x04, 0x30, 0x00, 0x18, 0x20, 0x00, 0x20,
  0x40, 0x00, 0xC0, 0x80, 0x01, 0x01, 0x00, 0x02, 0x03, 0x00, 0x08, 0x06,
  0x00, 0x10, 0x0C, 0x00, 0x60, 0x08, 0x00, 0x80, 0x10, 0x03, 0x00, 0x20,
  0x04, 0x00, 0x40, 0x18, 0x00, 0xC0, 0x20, 0x01, 0x80, 0xC0, 0x01, 0x01,
  0x00, 0x02, 0x02, 0x00, 0x04, 0x08, 0x00, 0x08, 0x10, 0x00, 0x10, 0x40,
  0x00, 0x30, 0x80, 0x00, 0x63, 0x00, 0x00, 0x44, 0x00, 0x00, 0x98, 0x00,
  0x01, 0x20, 0x00, 0x02, 0xC0, 0x00, 0x05, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x28,
  0x00, 0x14, 0x00, 0x0A, 0x00, 0x05, 0x00, 0x06, 0x80, 0x03, 0x40, 0x01,
  0x30, 0x00, 0x90, 0x00, 0x4C, 0x00, 0x24, 0x00, 0x33, 0x00, 0x11, 0x00,
  0x08, 0xC0, 0x04, 0x40, 0x06, 0x30, 0x03, 0x10, 0x01, 0x0C, 0x00, 0x86,
  0x00, 0x41, 0x00, 0x21, 0x80, 0x30, 0x40, 0x10, 0x20, 0x08, 0x10, 0x04,
  0x08, 0x02, 0x04, 0x03, 0x02, 0x01, 0x81, 0x00, 0x80, 0x80, 0x40, 0x40,
  0x20, 0x20, 0x30, 0x10, 0x10, 0x08, 0x08, 0x04, 0x04, 0x02, 0x02, 0x01,
  0x03, 0x00, 0x81, 0x80, 0x40, 0x80, 0x20, 0x40, 0x18, 0x20, 0x0C, 0x10,
  0x06, 0x10, 0x03, 0x0C, 0x01, 0x84, 0x00, 0xC2, 0x00, 0x63, 0x00, 0x11,
  0x80, 0x18, 0x80, 0x04, 0x40, 0x02, 0x60, 0x01, 0x10, 0x00, 0x90, 0x00,
  0x4C, 0x00, 0x24, 0x00, 0x12, 0x00, 0x0B, 0x00, 0x04, 0x80, 0x02, 0x80,
  0x01, 0x60, 0x00, 0xA0, 0x00, 0x50, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x20, 0x00, 0x08, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x00, 0xC0, 0x08, 0x00,
  0x10, 0x01, 0x80, 0x04, 0x00, 0x10, 0x01, 0x80, 0x03, 0x00, 0x60, 0x00,
  0x20, 0x08, 0x00, 0x04, 0x02, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x08, 0x10,
  0x00, 0x01, 0x84, 0x00, 0x00, 0x11, 0x80, 0x00, 0x02, 0x60, 0x00, 0x00,
  0x28, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0D, 0x80, 0x00, 0x01, 0x10, 0x00, 0x00, 0x63, 0x00, 0x00, 0x18,
  0x20, 0x00, 0x02, 0x04, 0x00, 0x00, 0x80, 0x40, 0x00, 0x30, 0x08, 0x00,
  0x0C, 0x01, 0x80, 0x01, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x18, 0x00,
  0x20, 0x02, 0x00, 0x04, 0x00, 0x80, 0x00, 0xC0, 0x30, 0x00, 0x08, 0x0C,
  0x00, 0x01, 0x81, 0x00, 0x00, 0x10, 0x00, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x2C, 0x00, 0x01, 0x90, 0x00, 0x04, 0x60, 0x00, 0x21, 0x80, 0x01, 0x82,
  0x00, 0x04, 0x08, 0x00, 0x20, 0x30, 0x01, 0x80, 0x40, 0x04, 0x01, 0x00,
  0x20, 0x06, 0x01, 0x80, 0x08, 0x04, 0x00, 0x20, 0x20, 0x00, 0xC1, 0x80,
  0x01, 0x04, 0x00, 0x04, 0x20, 0x00, 0x19, 0x80, 0x00, 0x24, 0x00, 0x00,
  0xA0, 0x00, 0x03, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x00, 0xFC, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x07, 0xC0,
  0x00, 0x81, 0x83, 0x02, 0x04, 0x08, 0x10, 0x20, 0x60, 0xC0, 0x81, 0x02,
  0x04, 0x08, 0x18, 0x30, 0x20, 0x40, 0x81, 0x02, 0x06, 0x0C, 0x08, 0x10,
  0x20, 0x40, 0x81, 0x83, 0x02, 0x04, 0x08, 0x10, 0x20, 0x60, 0xC0, 0x01,
  0xF8, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x80,
  0x0C, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x03, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x06, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x03, 0xF0, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x02, 0x80, 0x26,
  0x01, 0x10, 0x10, 0x80, 0x84, 0x08, 0x20, 0x41, 0x04, 0x0C, 0x20, 0x62,
  0x01, 0x10, 0x09, 0x00, 0x48, 0x02, 0x80, 0x18, 0xFF, 0xFF, 0x80, 0xC2,
  0x18, 0x61, 0x0C, 0x00, 0x7E, 0x00, 0x70, 0xC0, 0x60, 0x08, 0x30, 0x03,
  0x08, 0x00, 0x46, 0x00, 0x11, 0x00, 0x04, 0x40, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x01, 0xFF, 0x83, 0xE0, 0x21, 0x80,
  0x08, 0x80, 0x06, 0x60, 0x01, 0xB0, 0x00, 0x48, 0x00, 0x12, 0x00, 0x04,
  0x80, 0x03, 0x20, 0x01, 0xC8, 0x00, 0xB3, 0x00, 0xCC, 0x70, 0xE2, 0x07,
  0xE0, 0x80, 0x01, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x43, 0xF0, 0x0C, 0xE1, 0x80, 0xD8,
  0x04, 0x0A, 0x00, 0x60, 0xC0, 0x02, 0x08, 0x00, 0x20, 0x80, 0x02, 0x18,
  0x00, 0x21, 0x80, 0x02, 0x10, 0x00, 0x21, 0x00, 0x02, 0x10, 0x00, 0x21,
  0x00, 0x02, 0x30, 0x00, 0x23, 0x00, 0x06, 0x20, 0x00, 0x42, 0x00, 0x04,
  0x20, 0x00, 0x42, 0x00, 0x0C, 0x60, 0x00, 0x86, 0x00, 0x18, 0x60, 0x01,
  0x07, 0x00, 0x30, 0x58, 0x06, 0x0C, 0xE1, 0xC0, 0xC3, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x38, 0x60, 0x18, 0x02, 0x02, 0x00, 0x60, 0x80, 0x04, 0x30,
  0x00, 0xC4, 0x00, 0x19, 0x80, 0x03, 0x20, 0x00, 0x64, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x02, 0x20, 0x00, 0x84, 0x00,
  0x10, 0x80, 0x06, 0x18, 0x01, 0x81, 0x80, 0x60, 0x1C, 0x38, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x00, 0x00, 0x08, 0x01, 0xF0, 0x40, 0x30, 0x62, 0x03,
  0x00, 0x90, 0x20, 0x03, 0x83, 0x00, 0x18, 0x10, 0x00, 0x41, 0x80, 0x02,
  0x08, 0x00, 0x10, 0x40, 0x01, 0x86, 0x00, 0x0C, 0x20, 0x00, 0x41, 0x00,
  0x02, 0x08, 0x00, 0x10, 0xC0, 0x00, 0x86, 0x00, 0x0C, 0x20, 0x00, 0x41,
  0x00, 0x02, 0x08, 0x00, 0x10, 0x40, 0x00, 0x82, 0x00, 0x04, 0x18, 0x00,
  0x60, 0xC0, 0x02, 0x02, 0x00, 0x30, 0x18, 0x06, 0x80, 0x70, 0xC4, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x38, 0x70, 0x0C, 0x02, 0x02, 0x00,
  0x60, 0x80, 0x04, 0x30, 0x00, 0xC4, 0x00, 0x19, 0x80, 0x03, 0x20, 0x00,
  0x64, 0x00, 0x0D, 0x80, 0x01, 0x3F, 0xFF, 0xE4, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x81, 0x80, 0x30,
  0x1C, 0x3C, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x06, 0x00, 0x08,
  0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x60, 0x07, 0xFE, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x0C,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x00, 0x00, 0x3E, 0x08, 0x06, 0x0C, 0x40, 0x60,
  0x12, 0x04, 0x00, 0x70, 0x60, 0x03, 0x02, 0x00, 0x08, 0x30, 0x00, 0x41,
  0x00, 0x02, 0x18, 0x00, 0x10, 0x80, 0x01, 0x84, 0x00, 0x08, 0x20, 0x00,
  0x41, 0x00, 0x02, 0x18, 0x00, 0x10, 0xC0, 0x01, 0x84, 0x00, 0x0C, 0x20,
  0x00, 0x41, 0x00, 0x02, 0x08, 0x00, 0x10, 0x40, 0x00, 0x82, 0x00, 0x0C,
  0x18, 0x00, 0x60, 0x40, 0x06, 0x03, 0x00, 0xD0, 0x0E, 0x1C, 0x80, 0x3F,
  0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x40, 0x40, 0x04, 0x03, 0x00, 0x60, 0x0E, 0x0C,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x0F, 0x80, 0xC6, 0x18, 0x19,
  0x00, 0x82, 0x40, 0x18, 0x50, 0x01, 0x0A, 0x00, 0x21, 0x80, 0x04, 0x70,
  0x00, 0x8C, 0x00, 0x11, 0x80, 0x06, 0x20, 0x00, 0xC4, 0x00, 0x10, 0x80,
  0x02, 0x30, 0x00, 0x46, 0x00, 0x08, 0x80, 0x03, 0x10, 0x00, 0x62, 0x00,
  0x08, 0x40, 0x01, 0x18, 0x00, 0x23, 0x00, 0x04, 0x40, 0x01, 0x88, 0x00,
  0x21, 0x00, 0x04, 0x20, 0x00, 0x8C, 0x00, 0x10, 0x00, 0x0C, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x40, 0x83, 0x06, 0x08, 0x10, 0x20,
  0x41, 0x83, 0x04, 0x08, 0x10, 0x20, 0xC1, 0x02, 0x04, 0x08, 0x30, 0x60,
  0x81, 0x02, 0x04, 0x00, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18,
  0x00, 0x20, 0x01, 0x80, 0x1E, 0x00, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x06, 0x0C, 0x00, 0xC0, 0xC0, 0x18, 0x08, 0x03, 0x00, 0x80, 0x60, 0x08,
  0x0C, 0x00, 0x81, 0x80, 0x18, 0x30, 0x01, 0x86, 0x00, 0x10, 0xC0, 0x01,
  0x18, 0x00, 0x13, 0x00, 0x01, 0x78, 0x00, 0x38, 0x80, 0x03, 0x0C, 0x00,
  0x20, 0x40, 0x02, 0x06, 0x00, 0x20, 0x20, 0x02, 0x03, 0x00, 0x60, 0x10,
  0x04, 0x01, 0x80, 0x40, 0x0C, 0x04, 0x00, 0x40, 0x40, 0x06, 0x04, 0x00,
  0x20, 0xC0, 0x03, 0x00, 0x02, 0x04, 0x18, 0x30, 0x40, 0x81, 0x02, 0x0C,
  0x18, 0x20, 0x40, 0x81, 0x06, 0x0C, 0x10, 0x20, 0x40, 0x83, 0x06, 0x08,
  0x10, 0x20, 0x41, 0x82, 0x04, 0x08, 0x10, 0x60, 0xC1, 0x02, 0x04, 0x08,
  0x00, 0x0C, 0x3F, 0x00, 0x7C, 0x06, 0x30, 0xC0, 0xE1, 0x82, 0x20, 0x10,
  0x80, 0x41, 0x20, 0x08, 0x80, 0x30, 0xA0, 0x06, 0x80, 0x08, 0x60, 0x01,
  0x80, 0x04, 0x70, 0x00, 0xC0, 0x02, 0x30, 0x00, 0x40, 0x01, 0x18, 0x00,
  0x60, 0x00, 0x88, 0x00, 0x30, 0x00, 0x44, 0x00, 0x10, 0x00, 0x62, 0x00,
  0x08, 0x00, 0x33, 0x00, 0x04, 0x00, 0x11, 0x80, 0x02, 0x00, 0x08, 0x80,
  0x03, 0x00, 0x04, 0x40, 0x01, 0x80, 0x02, 0x20, 0x00, 0x80, 0x03, 0x10,
  0x00, 0x40, 0x01, 0x98, 0x00, 0x20, 0x00, 0x8C, 0x00, 0x10, 0x00, 0x44,
  0x00, 0x18, 0x00, 0x22, 0x00, 0x08, 0x00, 0x11, 0x00, 0x04, 0x00, 0x19,
  0x80, 0x02, 0x00, 0x0C, 0xC0, 0x01, 0x00, 0x04, 0x40, 0x00, 0x80, 0x02,
  0x00, 0x04, 0x1F, 0x01, 0x8C, 0x30, 0x32, 0x01, 0x04, 0x80, 0x30, 0xA0,
  0x06, 0x14, 0x00, 0x43, 0x00, 0x08, 0xE0, 0x01, 0x18, 0x00, 0x23, 0x00,
  0x0C, 0x40, 0x01, 0x88, 0x00, 0x21, 0x00, 0x04, 0x60, 0x00, 0x8C, 0x00,
  0x11, 0x00, 0x06, 0x20, 0x00, 0xC4, 0x00, 0x10, 0x80, 0x02, 0x30, 0x00,
  0x46, 0x00, 0x08, 0x80, 0x03, 0x10, 0x00, 0x42, 0x00, 0x08, 0x40, 0x01,
  0x18, 0x00, 0x20, 0x00, 0xFC, 0x00, 0x70, 0xE0, 0x18, 0x06, 0x06, 0x00,
  0x61, 0x80, 0x04, 0x20, 0x00, 0x8C, 0x00, 0x11, 0x00, 0x03, 0x60, 0x00,
  0x68, 0x00, 0x0D, 0x00, 0x01, 0x20, 0x00, 0x2C, 0x00, 0x05, 0x80, 0x00,
  0xA0, 0x00, 0x14, 0x00, 0x06, 0x80, 0x00, 0x90, 0x00, 0x12, 0x00, 0x06,
  0x40, 0x00, 0x8C, 0x00, 0x31, 0x80, 0x04, 0x10, 0x01, 0x01, 0x00, 0xE0,
  0x38, 0x70, 0x01, 0xF8, 0x00, 0x02, 0x1F, 0x80, 0x33, 0x86, 0x01, 0xB0,
  0x08, 0x0A, 0x00, 0x60, 0x60, 0x01, 0x02, 0x00, 0x08, 0x10, 0x00, 0x41,
  0x80, 0x02, 0x0C, 0x00, 0x18, 0x40, 0x00, 0x82, 0x00, 0x04, 0x10, 0x00,
  0x20, 0x80, 0x01, 0x0C, 0x00, 0x08, 0x40, 0x00, 0xC2, 0x00, 0x06, 0x10,
  0x00, 0x20, 0x80, 0x01, 0x04, 0x00, 0x18, 0x60, 0x00, 0x83, 0x00, 0x0C,
  0x18, 0x00, 0x40, 0xE0, 0x06, 0x05, 0x80, 0x60, 0x67, 0x0E, 0x03, 0x0F,
  0xC0, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x20, 0x70, 0xC4, 0x18, 0x04, 0x84,
  0x00, 0x71, 0x80, 0x0C, 0x20, 0x00, 0x8C, 0x00, 0x11, 0x00, 0x02, 0x60,
  0x00, 0x4C, 0x00, 0x19, 0x00, 0x02, 0x20, 0x00, 0x44, 0x00, 0x09, 0x80,
  0x01, 0x30, 0x00, 0x64, 0x00, 0x0C, 0x80, 0x01, 0x10, 0x00, 0x22, 0x00,
  0x04, 0x40, 0x00, 0x88, 0x00, 0x31, 0x80, 0x06, 0x10, 0x01, 0x83, 0x00,
  0xD0, 0x38, 0x62, 0x03, 0xF0, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x04, 0x3C, 0x19, 0xC0, 0x36, 0x00,
  0x58, 0x00, 0xA0, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x00, 0x00, 0xFC, 0x00, 0xE1, 0xC0,
  0x60, 0x18, 0x20, 0x02, 0x18, 0x00, 0xC4, 0x00, 0x31, 0x00, 0x0C, 0x40,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0,
  0x00, 0x32, 0x00, 0x0C, 0x80, 0x02, 0x30, 0x00, 0x84, 0x00, 0x41, 0x80,
  0x30, 0x38, 0x70, 0x03, 0xF0, 0x00, 0x04, 0x01, 0x00, 0x40, 0x10, 0x0C,
  0x03, 0x00, 0x83, 0xFF, 0x08, 0x02, 0x01, 0x80, 0x60, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x08, 0x06, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x03, 0x00, 0xC0, 0x30, 0x04, 0x01, 0x80, 0x3C, 0x00,
  0x10, 0x00, 0x4C, 0x00, 0x13, 0x00, 0x04, 0x80, 0x03, 0x20, 0x00, 0x88,
  0x00, 0x22, 0x00, 0x09, 0x80, 0x02, 0x40, 0x00, 0x90, 0x00, 0x64, 0x00,
  0x11, 0x00, 0x04, 0xC0, 0x01, 0x30, 0x00, 0x48, 0x00, 0x32, 0x00, 0x0C,
  0x80, 0x02, 0x20, 0x00, 0x88, 0x00, 0x62, 0x00, 0x18, 0x80, 0x0E, 0x20,
  0x03, 0x8C, 0x01, 0x43, 0x00, 0x90, 0x70, 0xC4, 0x07, 0xC1, 0x00, 0x80,
  0x00, 0xF0, 0x00, 0x2C, 0x00, 0x19, 0x00, 0x04, 0x40, 0x03, 0x10, 0x00,
  0x84, 0x00, 0x61, 0x80, 0x10, 0x60, 0x0C, 0x08, 0x02, 0x02, 0x01, 0x80,
  0x80, 0x40, 0x20, 0x10, 0x0C, 0x08, 0x03, 0x02, 0x00, 0x41, 0x00, 0x10,
  0x40, 0x04, 0x30, 0x01, 0x08, 0x00, 0x66, 0x00, 0x19, 0x00, 0x02, 0xC0,
  0x00, 0xA0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x04,
  0x00, 0x30, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x01, 0x60, 0x0F, 0x00, 0x6C,
  0x01, 0x60, 0x09, 0x80, 0x2C, 0x03, 0x30, 0x0D, 0x80, 0x66, 0x01, 0x10,
  0x08, 0x40, 0x62, 0x03, 0x08, 0x08, 0x40, 0x41, 0x03, 0x08, 0x18, 0x20,
  0x41, 0x02, 0x04, 0x08, 0x20, 0x40, 0x82, 0x04, 0x18, 0x10, 0x40, 0x82,
  0x02, 0x18, 0x18, 0xC0, 0x42, 0x03, 0x10, 0x0C, 0xC0, 0x62, 0x01, 0x90,
  0x04, 0xC0, 0x36, 0x00, 0x90, 0x06, 0x80, 0x16, 0x00, 0xD0, 0x02, 0x80,
  0x0C, 0x00, 0x50, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x01, 0x80, 0x04, 0x00,
  0x30, 0x00, 0x04, 0x00, 0x18, 0x30, 0x01, 0x80, 0x80, 0x08, 0x06, 0x00,
  0xC0, 0x10, 0x0C, 0x00, 0xC0, 0x40, 0x02, 0x04, 0x00, 0x10, 0x60, 0x00,
  0xC6, 0x00, 0x02, 0x20, 0x00, 0x1A, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x01, 0x40, 0x00, 0x11, 0x00, 0x01, 0x88, 0x00, 0x08,
  0x60, 0x00, 0x81, 0x00, 0x0C, 0x0C, 0x00, 0xC0, 0x20, 0x04, 0x01, 0x80,
  0x40, 0x0C, 0x06, 0x00, 0x20, 0x60, 0x01, 0x82, 0x00, 0x04, 0x00, 0x06,
  0x00, 0x06, 0x0C, 0x00, 0x08, 0x08, 0x00, 0x30, 0x10, 0x00, 0x40, 0x20,
  0x01, 0x80, 0x40, 0x02, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x10, 0x01, 0x00,
  0x20, 0x02, 0x00, 0x80, 0x04, 0x01, 0x00, 0x08, 0x04, 0x00, 0x10, 0x08,
  0x00, 0x30, 0x20, 0x00, 0x20, 0x40, 0x00, 0x41, 0x00, 0x00, 0x82, 0x00,
  0x01, 0x0C, 0x00, 0x02, 0x10, 0x00, 0x06, 0x60, 0x00, 0x0C, 0x80, 0x00,
  0x0B, 0x00, 0x00, 0x14, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x60, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x02, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x06, 0x00, 0x18, 0x00,
  0x20, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00,
  0x20, 0x00, 0x40, 0x01, 0x00, 0x06, 0x00, 0x70, 0x00, 0xC0, 0x00, 0x40,
  0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x18, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x03, 0x03, 0x02, 0x02,
  0x02, 0x06, 0x06, 0x06, 0x04, 0x04, 0x04, 0x04, 0x0C, 0x0C, 0x0C, 0x08,
  0x08, 0x08, 0x18, 0x18, 0x18, 0x10, 0x10, 0x10, 0x10, 0x30, 0x30, 0x20,
  0x20, 0x20, 0x20, 0x60, 0x60, 0x60, 0x40, 0x40, 0x40, 0xC0, 0xC0, 0xC0,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x07, 0x00, 0x06,
  0x00, 0x30, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x00, 0x0F, 0x80, 0x04,
  0x31, 0x80, 0x08, 0xC1, 0x80, 0x13, 0x01, 0x80, 0x64, 0x01, 0x80, 0x88,
  0x01, 0x02, 0x30, 0x01, 0x8C, 0x40, 0x01, 0xE0,
};

const GFXglyph RobotoCondensed_ThinItalic49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 8, 35, 9, 1, -35 },
  { 36, 8, 10, 12, 5, -37 },
  { 46, 24, 35, 23, 1, -35 },
  { 151, 20, 44, 23, 2, -39 },
  { 261, 24, 35, 31, 4, -35 },
  { 366, 22, 36, 26, 1, -35 },
  { 465, 3, 10, 8, 5, -37 },
  { 469, 14, 50, 13, 2, -39 },
  { 557, 13, 50, 13, -3, -39 },
  { 639, 19, 19, 20, 3, -35 },
  { 685, 20, 25, 24, 2, -29 },
  { 748, 5, 10, 9, -1, -4 },
  { 755, 9, 1, 13, 2, -16 },
  { 757, 3, 3, 10, 1, -3 },
  { 759, 20, 38, 16, -2, -35 },
  { 854, 20, 35, 23, 2, -35 },
  { 942, 10, 35, 23, 7, -35 },
  { 986, 20, 35, 23, 1, -35 },
  { 1074, 21, 35, 23, 1, -35 },
  { 1166, 20, 35, 23, 1, -35 },
  { 1254, 21, 35, 23, 3, -35 },
  { 1346, 18, 35, 23, 2, -35 },
  { 1425, 20, 35, 23, 4, -35 },
  { 1513, 21, 35, 23, 1, -35 },
  { 1605, 19, 35, 23, 3, -35 },
  { 1689, 7, 26, 9, 1, -26 },
  { 1712, 9, 32, 8, -2, -26 },
  { 1748, 18, 20, 22, 2, -26 },
  { 1793, 18, 10, 23, 3, -21 },
  { 1816, 19, 20, 22, 1, -26 },
  { 1864, 15, 35, 19, 4, -35 },
  { 1930, 34, 45, 38, 2, -34 },
  { 2122, 23, 35, 25, -1, -35 },
  { 2223, 22, 35, 25, 2, -35 },
  { 2320, 23, 35, 27, 3, -35 },
  { 2421, 24, 35, 27, 2, -35 },
  { 2526, 23, 35, 24, 2, -35 },
  { 2627, 24, 35, 24, 2, -35 },
  { 2732, 24, 35, 29, 3, -35 },
  { 2837, 26, 35, 29, 2, -35 },
  { 2951, 7, 35, 11, 3, -35 },
  { 2982, 21, 35, 23, 1, -35 },
  { 3074, 25, 35, 26, 2, -35 },
  { 3184, 16, 35, 22, 2, -35 },
  { 3254, 33, 35, 36, 2, -35 },
  { 3399, 27, 35, 29, 2, -35 },
  { 3518, 23, 35, 28, 3, -35 },
  { 3619, 23, 35, 25, 2, -35 },
  { 3720, 23, 41, 28, 3, -35 },
  { 3838, 23, 35, 27, 2, -35 },
  { 3939, 24, 35, 25, 1, -35 },
  { 4044, 22, 35, 25, 5, -35 },
  { 4141, 24, 35, 28, 3, -35 },
  { 4246, 23, 35, 25, 4, -35 },
  { 4347, 34, 35, 37, 5, -35 },
  { 4496, 27, 35, 25, -1, -35 },
  { 4615, 22, 35, 25, 5, -35 },
  { 4712, 26, 35, 25, 0, -35 },
  { 4826, 14, 47, 10, 0, -40 },
  { 4909, 7, 38, 16, 5, -35 },
  { 4943, 13, 47, 10, -3, -40 },
  { 5020, 13, 17, 18, 3, -35 },
  { 5048, 17, 1, 18, -2, 0 },
  { 5051, 5, 6, 13, 7, -36 },
  { 5055, 18, 26, 22, 1, -26 },
  { 5114, 20, 37, 23, 1, -37 },
  { 5207, 19, 26, 21, 1, -26 },
  { 5269, 21, 37, 23, 2, -37 },
  { 5367, 19, 26, 21, 1, -26 },
  { 5429, 15, 38, 14, 3, -38 },
  { 5501, 21, 36, 23, 0, -26 },
  { 5596, 19, 37, 23, 1, -37 },
  { 5684, 7, 36, 9, 2, -36 },
  { 5716, 15, 46, 10, -6, -36 },
  { 5803, 20, 37, 20, 1, -37 },
  { 5896, 7, 37, 9, 2, -37 },
  { 5929, 33, 26, 37, 1, -26 },
  { 6037, 19, 26, 23, 1, -26 },
  { 6099, 19, 26, 23, 2, -26 },
  { 6161, 21, 36, 23, 0, -26 },
  { 6256, 19, 36, 23, 2, -26 },
  { 6342, 15, 26, 14, 1, -26 },
  { 6391, 18, 26, 21, 1, -26 },
  { 6450, 10, 33, 14, 3, -33 },
  { 6492, 18, 26, 23, 3, -26 },
  { 6551, 18, 26, 20, 3, -26 },
  { 6610, 27, 26, 31, 4, -26 },
  { 6698, 21, 26, 20, -1, -26 },
  { 6767, 23, 36, 20, -2, -26 },
  { 6871, 20, 26, 20, 0, -26 },
  { 6936, 15, 49, 14, 2, -38 },
  { 7028, 8, 41, 10, 1, -35 },
  { 7069, 15, 49, 14, -3, -38 },
  { 7161, 23, 8, 29, 3, -19 },
};

const GFXfont RobotoCondensed_ThinItalic49pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ThinItalic49pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ThinItalic49pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _ROBOTOCONDENSED_THINITALIC49PT7B_H_
