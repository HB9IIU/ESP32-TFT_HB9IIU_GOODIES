#ifndef _ROBOTOCONDENSED_THINITALIC57PT7B_H_
#define _ROBOTOCONDENSED_THINITALIC57PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ThinItalic.ttf
// Size: 57pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ThinItalic57pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0x80, 0xC0, 0x40, 0x20, 0x10, 0x18, 0x0C, 0x06, 0x02, 0x01,
  0x00, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x08, 0x04, 0x06, 0x03, 0x01, 0x80,
  0x80, 0x40, 0x20, 0x30, 0x18, 0x0C, 0x04, 0x02, 0x01, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0xE0, 0x00,
  0x00, 0x30, 0x98, 0xC8, 0x64, 0x36, 0x1B, 0x09, 0x84, 0xC6, 0x43, 0x21,
  0xB0, 0x80, 0x00, 0x01, 0x80, 0x40, 0x00, 0x10, 0x04, 0x00, 0x01, 0x00,
  0xC0, 0x00, 0x30, 0x08, 0x00, 0x02, 0x00, 0x80, 0x00, 0x20, 0x18, 0x00,
  0x06, 0x01, 0x00, 0x00, 0x40, 0x10, 0x00, 0x04, 0x03, 0x00, 0x00, 0xC0,
  0x20, 0x00, 0x0C, 0x02, 0x00, 0x00, 0x80, 0x60, 0x0F, 0xFF, 0xFF, 0xF0,
  0x01, 0x80, 0x40, 0x00, 0x10, 0x0C, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x30,
  0x08, 0x00, 0x02, 0x01, 0x80, 0x00, 0x60, 0x18, 0x00, 0x06, 0x01, 0x00,
  0x00, 0x40, 0x30, 0x00, 0x04, 0x03, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x08,
  0x02, 0x00, 0x00, 0x80, 0x60, 0x00, 0x18, 0x04, 0x00, 0x01, 0x00, 0x40,
  0x00, 0x10, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x20, 0x08, 0x00, 0x02,
  0x01, 0x80, 0x00, 0x60, 0x10, 0x00, 0x06, 0x01, 0x00, 0x00, 0x40, 0x30,
  0x00, 0x0C, 0x02, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x08, 0x06, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x18, 0x04, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x10, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x70, 0x38, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x04, 0x01, 0x00, 0x06, 0x03,
  0x00, 0x06, 0x06, 0x00, 0x02, 0x06, 0x00, 0x02, 0x04, 0x00, 0x02, 0x04,
  0x00, 0x02, 0x0C, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x10, 0xC0, 0x00, 0x10, 0xC0,
  0x00, 0x30, 0xC0, 0x00, 0x30, 0x40, 0x00, 0x60, 0x60, 0x00, 0x40, 0x20,
  0x00, 0xC0, 0x30, 0x03, 0x80, 0x1C, 0x07, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x00, 0x80, 0x00, 0x60, 0x10,
  0x00, 0x18, 0x02, 0x00, 0x63, 0x00, 0x60, 0x18, 0x40, 0x08, 0x02, 0x08,
  0x01, 0x00, 0xC1, 0x00, 0x20, 0x30, 0x60, 0x04, 0x04, 0x0C, 0x01, 0x81,
  0x81, 0x80, 0x20, 0x60, 0x30, 0x0C, 0x08, 0x02, 0x01, 0x03, 0x00, 0x60,
  0x60, 0xC0, 0x06, 0x18, 0x10, 0x00, 0xFE, 0x04, 0x00, 0x02, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x10, 0x3F, 0x80, 0x06, 0x0C, 0x18, 0x01, 0x83, 0x01,
  0x00, 0x20, 0x40, 0x30, 0x0C, 0x18, 0x06, 0x03, 0x02, 0x00, 0xC0, 0x40,
  0xC0, 0x18, 0x18, 0x18, 0x03, 0x06, 0x02, 0x00, 0x60, 0x80, 0x40, 0x08,
  0x30, 0x08, 0x01, 0x0C, 0x01, 0x00, 0x21, 0x00, 0x20, 0x0C, 0x40, 0x04,
  0x01, 0x00, 0x00, 0x80, 0x60, 0x00, 0x18, 0x18, 0x00, 0x01, 0x86, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x0E, 0x18, 0x00, 0x0C, 0x06, 0x00, 0x0C, 0x01, 0x00, 0x06,
  0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x00, 0x10, 0x00,
  0x80, 0x08, 0x00, 0x40, 0x0C, 0x00, 0x20, 0x04, 0x00, 0x10, 0x04, 0x00,
  0x08, 0x06, 0x00, 0x06, 0x06, 0x00, 0x03, 0x06, 0x00, 0x00, 0x86, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0D, 0x80, 0x00, 0x08, 0x40, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x0C,
  0x01, 0x8C, 0x06, 0x00, 0xCC, 0x01, 0x80, 0x44, 0x00, 0x40, 0x66, 0x00,
  0x30, 0x32, 0x00, 0x08, 0x13, 0x00, 0x06, 0x19, 0x80, 0x01, 0x8C, 0xC0,
  0x00, 0xCC, 0x40, 0x00, 0x36, 0x20, 0x00, 0x0E, 0x18, 0x00, 0x06, 0x0C,
  0x00, 0x03, 0x06, 0x00, 0x02, 0xC1, 0x80, 0x02, 0x20, 0x60, 0x06, 0x18,
  0x1C, 0x0E, 0x06, 0x07, 0xFC, 0x03, 0x00, 0x20, 0x00, 0x00, 0x22, 0x26,
  0x66, 0x64, 0x4C, 0xC8, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x04, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x0C,
  0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10,
  0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04,
  0x00, 0x0C, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80, 0x01,
  0x80, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0xC0, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0,
  0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x03,
  0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x80, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x01, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x10, 0x04, 0x01, 0xF0, 0x10, 0x3C, 0x78, 0xC7, 0x80, 0x7B, 0x78,
  0x00, 0x3F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x60, 0x00, 0x19, 0x80, 0x00,
  0x43, 0x00, 0x03, 0x0C, 0x00, 0x18, 0x18, 0x00, 0xC0, 0x20, 0x06, 0x00,
  0xC0, 0x30, 0x01, 0x80, 0x80, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x04, 0x30,
  0xC3, 0x0C, 0x61, 0x8C, 0x31, 0x84, 0x00, 0xFF, 0xE0, 0xEE, 0x40, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0xFF, 0x00,
  0x06, 0x06, 0x00, 0x30, 0x0C, 0x01, 0x80, 0x18, 0x0C, 0x00, 0x20, 0x60,
  0x00, 0xC1, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x20, 0x00, 0x10, 0x80, 0x00,
  0x46, 0x00, 0x01, 0x10, 0x00, 0x04, 0x40, 0x00, 0x13, 0x00, 0x00, 0x4C,
  0x00, 0x03, 0x20, 0x00, 0x0C, 0x80, 0x00, 0x36, 0x00, 0x00, 0xD8, 0x00,
  0x02, 0x60, 0x00, 0x09, 0x00, 0x00, 0x24, 0x00, 0x01, 0x90, 0x00, 0x06,
  0xC0, 0x00, 0x1B, 0x00, 0x00, 0x4C, 0x00, 0x01, 0x20, 0x00, 0x0C, 0x80,
  0x00, 0x32, 0x00, 0x00, 0x88, 0x00, 0x02, 0x20, 0x00, 0x18, 0x80, 0x00,
  0x42, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x60, 0xC0, 0x01, 0x81,
  0x00, 0x0C, 0x06, 0x00, 0x60, 0x0C, 0x03, 0x00, 0x18, 0x18, 0x00, 0x3F,
  0xC0, 0x00, 0x10, 0x00, 0x00, 0x00, 0x30, 0x0F, 0x07, 0xA1, 0xC2, 0x70,
  0x2C, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0x80, 0x08, 0x00, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x70, 0x38, 0x00, 0xE0, 0x0C, 0x01, 0x80, 0x06, 0x01, 0x80,
  0x06, 0x03, 0x00, 0x02, 0x02, 0x00, 0x02, 0x06, 0x00, 0x03, 0x04, 0x00,
  0x03, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xC0, 0xE0, 0x06, 0x00,
  0xC0, 0x18, 0x00, 0xC0, 0x60, 0x00, 0x81, 0x80, 0x01, 0x83, 0x00, 0x03,
  0x04, 0x00, 0x02, 0x18, 0x00, 0x04, 0x20, 0x00, 0x08, 0x40, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x40, 0x00, 0x0C, 0x80, 0x00, 0x11,
  0x00, 0x00, 0x23, 0x00, 0x00, 0xC6, 0x00, 0x01, 0x0C, 0x00, 0x06, 0x0C,
  0x00, 0x08, 0x18, 0x00, 0x30, 0x18, 0x01, 0xC0, 0x1C, 0x06, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x14, 0x00, 0x00, 0x34, 0x00, 0x00, 0x64, 0x00,
  0x00, 0x4C, 0x00, 0x00, 0xCC, 0x00, 0x01, 0x8C, 0x00, 0x01, 0x08, 0x00,
  0x02, 0x08, 0x00, 0x06, 0x08, 0x00, 0x0C, 0x18, 0x00, 0x08, 0x18, 0x00,
  0x18, 0x18, 0x00, 0x30, 0x10, 0x00, 0x20, 0x10, 0x00, 0x60, 0x10, 0x00,
  0xC0, 0x30, 0x01, 0x80, 0x30, 0x01, 0x00, 0x30, 0x03, 0x00, 0x20, 0x06,
  0x00, 0x20, 0x04, 0x00, 0x20, 0x0C, 0x00, 0x60, 0x18, 0x00, 0x60, 0x30,
  0x00, 0x40, 0x30, 0x00, 0x40, 0x60, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x01, 0xFF, 0xFE, 0x02,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x0C, 0x7E, 0x00, 0x13, 0xEF, 0x00, 0x3C, 0x03, 0x00,
  0x60, 0x03, 0x00, 0x80, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x20, 0x00,
  0x18, 0x40, 0x00, 0x30, 0x80, 0x00, 0x41, 0x00, 0x01, 0x83, 0x00, 0x03,
  0x06, 0x00, 0x0C, 0x04, 0x00, 0x18, 0x0C, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x0C, 0x0E, 0x00, 0x0F, 0xF8, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x3F, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0xF8,
  0x06, 0x3C, 0xF0, 0x33, 0x00, 0xC1, 0x20, 0x03, 0x0A, 0x00, 0x08, 0xE0,
  0x00, 0x67, 0x00, 0x03, 0x30, 0x00, 0x09, 0x00, 0x00, 0x48, 0x00, 0x02,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xB0, 0x00, 0x05, 0x00, 0x00, 0x28, 0x00,
  0x01, 0x40, 0x00, 0x1A, 0x00, 0x00, 0xD0, 0x00, 0x04, 0xC0, 0x00, 0x66,
  0x00, 0x03, 0x30, 0x00, 0x30, 0x80, 0x01, 0x86, 0x00, 0x18, 0x30, 0x01,
  0x80, 0xC0, 0x18, 0x03, 0x81, 0x80, 0x0F, 0xF8, 0x00, 0x04, 0x00, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x40, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0,
  0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x0E, 0x07, 0x00, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x18,
  0x04, 0x00, 0x04, 0x06, 0x00, 0x03, 0x02, 0x00, 0x01, 0x81, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x30, 0x40, 0x00, 0x10, 0x20, 0x00,
  0x18, 0x10, 0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x06, 0x00, 0x06, 0x01, 0x80,
  0x06, 0x00, 0xC0, 0x06, 0x00, 0x38, 0x0E, 0x00, 0x0F, 0xBC, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0x03, 0x80, 0x0E, 0x00, 0x60, 0x0C, 0x00, 0x18, 0x0C,
  0x00, 0x0C, 0x04, 0x00, 0x03, 0x06, 0x00, 0x01, 0x82, 0x00, 0x00, 0x43,
  0x00, 0x00, 0x21, 0x00, 0x00, 0x10, 0x80, 0x00, 0x08, 0x40, 0x00, 0x0C,
  0x60, 0x00, 0x06, 0x10, 0x00, 0x02, 0x08, 0x00, 0x03, 0x06, 0x00, 0x03,
  0x03, 0x00, 0x01, 0x00, 0xC0, 0x01, 0x80, 0x30, 0x03, 0x80, 0x0E, 0x07,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x08, 0x00, 0x07,
  0xFC, 0x00, 0x70, 0x70, 0x06, 0x00, 0xC0, 0x60, 0x03, 0x06, 0x00, 0x18,
  0x60, 0x00, 0x42, 0x00, 0x03, 0x30, 0x00, 0x19, 0x00, 0x00, 0xD8, 0x00,
  0x06, 0xC0, 0x00, 0x34, 0x00, 0x01, 0xA0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x05, 0x80, 0x00,
  0x6C, 0x00, 0x07, 0x20, 0x00, 0x39, 0x80, 0x02, 0xCC, 0x00, 0x34, 0x30,
  0x03, 0x20, 0xC0, 0x73, 0x03, 0xDF, 0x18, 0x0F, 0xC0, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x3F, 0x80, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0xE0, 0x38, 0x02, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x30, 0x06, 0x00, 0x80, 0x10, 0x06, 0x00,
  0xC0, 0x30, 0x04, 0x01, 0x80, 0x20, 0x00, 0x00, 0x00, 0x08, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x01,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xF8, 0x10, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x03, 0x81, 0x83, 0x00, 0x63, 0x00,
  0x31, 0x80, 0x09, 0x80, 0x06, 0x80, 0x03, 0x40, 0x01, 0xE0, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C,
  0x00, 0x04, 0x00, 0x06, 0x00, 0x06, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0xE0, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x1C, 0x00, 0x00, 0x18, 0x00, 0x38, 0x00, 0x00, 0x08, 0x00, 0x70, 0x00,
  0x00, 0x0C, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x01, 0x80, 0x00, 0x00, 0x06, 0x01, 0x00, 0x00, 0x00, 0x02, 0x03, 0x00,
  0x07, 0xC0, 0x02, 0x06, 0x00, 0x1E, 0xE0, 0x02, 0x06, 0x00, 0x70, 0x30,
  0x02, 0x0C, 0x00, 0xC0, 0x18, 0x02, 0x0C, 0x00, 0x80, 0x18, 0x03, 0x18,
  0x01, 0x80, 0x10, 0x03, 0x18, 0x03, 0x00, 0x10, 0x02, 0x10, 0x02, 0x00,
  0x30, 0x02, 0x30, 0x06, 0x00, 0x30, 0x02, 0x30, 0x04, 0x00, 0x20, 0x02,
  0x20, 0x0C, 0x00, 0x20, 0x02, 0x60, 0x0C, 0x00, 0x60, 0x06, 0x60, 0x08,
  0x00, 0x60, 0x06, 0x40, 0x18, 0x00, 0x40, 0x04, 0x40, 0x18, 0x00, 0x40,
  0x04, 0x40, 0x10, 0x00, 0xC0, 0x0C, 0xC0, 0x10, 0x00, 0xC0, 0x0C, 0xC0,
  0x30, 0x00, 0x80, 0x08, 0xC0, 0x30, 0x01, 0x80, 0x18, 0xC0, 0x30, 0x01,
  0x80, 0x18, 0x80, 0x20, 0x03, 0x80, 0x10, 0x80, 0x20, 0x03, 0x80, 0x30,
  0x80, 0x20, 0x05, 0x80, 0x60, 0xC0, 0x30, 0x0D, 0x80, 0x40, 0xC0, 0x10,
  0x18, 0x80, 0xC0, 0xC0, 0x18, 0x30, 0xC3, 0x80, 0xC0, 0x0F, 0xC0, 0x7E,
  0x00, 0xC0, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x01, 0xFD, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x50, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x02, 0x40, 0x00,
  0x00, 0xC8, 0x00, 0x00, 0x11, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x86,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x04, 0x08, 0x00, 0x01, 0x81, 0x00, 0x00,
  0x20, 0x20, 0x00, 0x0C, 0x04, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x60, 0x18,
  0x00, 0x08, 0x03, 0x00, 0x01, 0x00, 0x60, 0x00, 0x60, 0x04, 0x00, 0x08,
  0x00, 0x80, 0x03, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x18, 0x00, 0x60,
  0x02, 0x00, 0x0C, 0x00, 0xC0, 0x01, 0x80, 0x10, 0x00, 0x30, 0x06, 0x00,
  0x02, 0x00, 0x80, 0x00, 0x40, 0x3F, 0xFF, 0xF8, 0x04, 0x00, 0x01, 0x81,
  0x80, 0x00, 0x30, 0x20, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xC1, 0x00, 0x00,
  0x08, 0x60, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x21, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0xC8, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00,
  0x60, 0x01, 0xFF, 0xE0, 0x00, 0x40, 0x1F, 0x00, 0x10, 0x00, 0xE0, 0x04,
  0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x08,
  0x08, 0x00, 0x02, 0x02, 0x00, 0x00, 0x80, 0x80, 0x00, 0x20, 0x60, 0x00,
  0x08, 0x18, 0x00, 0x02, 0x06, 0x00, 0x01, 0x81, 0x00, 0x00, 0x40, 0x40,
  0x00, 0x30, 0x10, 0x00, 0x0C, 0x0C, 0x00, 0x06, 0x03, 0x00, 0x03, 0x00,
  0x80, 0x03, 0x80, 0x20, 0x0F, 0x80, 0x0F, 0xFF, 0xE0, 0x02, 0x00, 0x1E,
  0x01, 0x80, 0x01, 0xC0, 0x60, 0x00, 0x30, 0x10, 0x00, 0x06, 0x04, 0x00,
  0x00, 0x81, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x82, 0x00, 0x00, 0x20, 0x80, 0x00, 0x08, 0x20, 0x00, 0x06,
  0x18, 0x00, 0x01, 0x06, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x20, 0x40, 0x00,
  0x18, 0x10, 0x00, 0x1C, 0x04, 0x00, 0x0E, 0x03, 0x00, 0x3E, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xE0,
  0x1C, 0x00, 0x30, 0x01, 0xC0, 0x0C, 0x00, 0x18, 0x03, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x30, 0x30, 0x00, 0x02, 0x06, 0x00, 0x00, 0x61, 0x80, 0x00,
  0x0C, 0x30, 0x00, 0x01, 0x84, 0x00, 0x00, 0x31, 0x80, 0x00, 0x06, 0x30,
  0x00, 0x00, 0xC4, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x02, 0x30, 0x00, 0x00, 0xC6,
  0x00, 0x00, 0x18, 0x40, 0x00, 0x02, 0x08, 0x00, 0x00, 0xC1, 0x00, 0x00,
  0x10, 0x30, 0x00, 0x06, 0x06, 0x00, 0x00, 0x80, 0x60, 0x00, 0x30, 0x0C,
  0x00, 0x0C, 0x00, 0xC0, 0x07, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0xFF, 0xE0,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x10, 0x07, 0xC0,
  0x01, 0x00, 0x07, 0x00, 0x10, 0x00, 0x38, 0x03, 0x00, 0x01, 0x80, 0x30,
  0x00, 0x0C, 0x03, 0x00, 0x00, 0x40, 0x20, 0x00, 0x06, 0x02, 0x00, 0x00,
  0x20, 0x20, 0x00, 0x02, 0x06, 0x00, 0x00, 0x20, 0x60, 0x00, 0x03, 0x06,
  0x00, 0x00, 0x30, 0x40, 0x00, 0x03, 0x04, 0x00, 0x00, 0x30, 0x40, 0x00,
  0x02, 0x0C, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x02, 0x08, 0x00, 0x00, 0x60,
  0x80, 0x00, 0x06, 0x08, 0x00, 0x00, 0x61, 0x80, 0x00, 0x04, 0x18, 0x00,
  0x00, 0x41, 0x80, 0x00, 0x04, 0x10, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x0C,
  0x10, 0x00, 0x00, 0x83, 0x00, 0x00, 0x08, 0x30, 0x00, 0x01, 0x83, 0x00,
  0x00, 0x18, 0x20, 0x00, 0x01, 0x02, 0x00, 0x00, 0x30, 0x20, 0x00, 0x06,
  0x06, 0x00, 0x00, 0x60, 0x60, 0x00, 0x0C, 0x06, 0x00, 0x01, 0x80, 0x40,
  0x00, 0x30, 0x04, 0x00, 0x06, 0x00, 0x40, 0x01, 0xC0, 0x0C, 0x01, 0xF0,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x10, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x10, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xE0, 0x3C, 0x00, 0x70, 0x01, 0xC0, 0x18, 0x00, 0x18, 0x02, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x10, 0x30, 0x00, 0x03, 0x04, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x0C, 0x20, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x31, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x40, 0x07, 0xFF, 0x98, 0x00, 0x00, 0x33, 0x00, 0x00, 0x04,
  0x60, 0x00, 0x00, 0x88, 0x00, 0x00, 0x11, 0x00, 0x00, 0x06, 0x20, 0x00,
  0x00, 0xC4, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x02, 0x18, 0x00, 0x00, 0x43,
  0x00, 0x00, 0x18, 0x20, 0x00, 0x03, 0x06, 0x00, 0x00, 0x60, 0x40, 0x00,
  0x1C, 0x0C, 0x00, 0x07, 0x00, 0xC0, 0x03, 0x80, 0x0E, 0x03, 0xE0, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x06, 0x02,
  0x00, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x18, 0x08, 0x00, 0x00, 0x20, 0x30,
  0x00, 0x00, 0x40, 0x60, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x03, 0x01, 0x00,
  0x00, 0x06, 0x02, 0x00, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x10, 0x18, 0x00,
  0x00, 0x20, 0x30, 0x00, 0x00, 0x40, 0x60, 0x00, 0x01, 0x80, 0x80, 0x00,
  0x03, 0x01, 0x00, 0x00, 0x06, 0x02, 0x00, 0x00, 0x08, 0x0C, 0x00, 0x00,
  0x10, 0x18, 0x00, 0x00, 0x20, 0x20, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x01,
  0x80, 0xFF, 0xFF, 0xFF, 0x03, 0x00, 0x00, 0x04, 0x06, 0x00, 0x00, 0x08,
  0x0C, 0x00, 0x00, 0x10, 0x10, 0x00, 0x00, 0x60, 0x20, 0x00, 0x00, 0xC0,
  0x40, 0x00, 0x01, 0x81, 0x80, 0x00, 0x02, 0x03, 0x00, 0x00, 0x04, 0x06,
  0x00, 0x00, 0x08, 0x08, 0x00, 0x00, 0x30, 0x10, 0x00, 0x00, 0x60, 0x20,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x01, 0x01, 0x80, 0x00, 0x02, 0x03, 0x00,
  0x00, 0x04, 0x04, 0x00, 0x00, 0x18, 0x08, 0x00, 0x00, 0x30, 0x10, 0x00,
  0x00, 0x40, 0x60, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x80, 0x40, 0x60, 0x30, 0x18, 0x08, 0x04, 0x02, 0x03, 0x01, 0x80, 0xC0,
  0x40, 0x20, 0x30, 0x18, 0x0C, 0x06, 0x02, 0x01, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x10, 0x08, 0x0C, 0x06, 0x03, 0x01, 0x00, 0x80, 0x40, 0x60, 0x30,
  0x18, 0x08, 0x04, 0x02, 0x03, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x83, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x40, 0xC0, 0x00, 0x20, 0x60, 0x00, 0x30, 0x30, 0x00, 0x10, 0x08, 0x00,
  0x18, 0x04, 0x00, 0x18, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x18, 0x00, 0x30,
  0x18, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x04, 0x00, 0x00, 0xC0, 0x10, 0x00, 0x06, 0x00, 0x40, 0x00, 0x30,
  0x03, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x80, 0x03, 0x00, 0x02, 0x00, 0x18, 0x00, 0x08, 0x00, 0xC0, 0x00, 0x60,
  0x07, 0x00, 0x01, 0x80, 0x38, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x10, 0x06,
  0x00, 0x00, 0x40, 0x30, 0x00, 0x01, 0x01, 0x80, 0x00, 0x0C, 0x0C, 0x00,
  0x00, 0x30, 0x60, 0x00, 0x00, 0x83, 0x00, 0x00, 0x02, 0x1C, 0x00, 0x00,
  0x08, 0xD8, 0x00, 0x00, 0x64, 0x20, 0x00, 0x01, 0xA0, 0xC0, 0x00, 0x07,
  0x01, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x40, 0x0C, 0x00, 0x01, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x30, 0x01, 0x80, 0x00, 0xC0, 0x03,
  0x00, 0x02, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x20, 0x00, 0x20,
  0x01, 0x80, 0x00, 0xC0, 0x06, 0x00, 0x01, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x40, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x30, 0x04, 0x00, 0x00, 0x60, 0x30,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x06, 0x00, 0x00, 0x00, 0x30, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x70, 0x00, 0x00, 0x0F, 0x03, 0x40, 0x00, 0x00, 0x2C, 0x0D, 0x00, 0x00,
  0x01, 0xA0, 0x34, 0x00, 0x00, 0x04, 0x80, 0x98, 0x00, 0x00, 0x32, 0x02,
  0x60, 0x00, 0x00, 0x98, 0x09, 0x80, 0x00, 0x06, 0x60, 0x62, 0x00, 0x00,
  0x11, 0x81, 0x88, 0x00, 0x00, 0xC4, 0x04, 0x20, 0x00, 0x02, 0x10, 0x10,
  0xC0, 0x00, 0x18, 0x40, 0x43, 0x00, 0x00, 0x43, 0x01, 0x04, 0x00, 0x03,
  0x0C, 0x0C, 0x10, 0x00, 0x08, 0x30, 0x30, 0x40, 0x00, 0x60, 0x80, 0x81,
  0x00, 0x01, 0x02, 0x02, 0x06, 0x00, 0x0C, 0x08, 0x08, 0x18, 0x00, 0x20,
  0x60, 0x20, 0x20, 0x01, 0x81, 0x81, 0x80, 0x80, 0x0C, 0x06, 0x06, 0x02,
  0x00, 0x30, 0x10, 0x10, 0x0C, 0x01, 0x80, 0x40, 0x40, 0x30, 0x04, 0x01,
  0x01, 0x00, 0x40, 0x30, 0x0C, 0x0C, 0x01, 0x00, 0x80, 0x30, 0x30, 0x04,
  0x06, 0x00, 0xC0, 0xC0, 0x10, 0x10, 0x02, 0x02, 0x00, 0x60, 0xC0, 0x08,
  0x08, 0x01, 0x82, 0x00, 0x20, 0x20, 0x02, 0x18, 0x01, 0x81, 0x80, 0x08,
  0x40, 0x06, 0x06, 0x00, 0x23, 0x00, 0x18, 0x18, 0x00, 0xC8, 0x00, 0x40,
  0x40, 0x03, 0x60, 0x01, 0x01, 0x00, 0x05, 0x00, 0x0C, 0x04, 0x00, 0x1C,
  0x00, 0x30, 0x30, 0x00, 0x60, 0x00, 0xC0, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x01, 0x80, 0x00, 0x02, 0x03, 0x00, 0x00, 0x04, 0x07, 0x00, 0x00, 0x18,
  0x0A, 0x00, 0x00, 0x30, 0x34, 0x00, 0x00, 0x60, 0x6C, 0x00, 0x00, 0x80,
  0xC8, 0x00, 0x01, 0x01, 0x98, 0x00, 0x02, 0x02, 0x30, 0x00, 0x0C, 0x0C,
  0x20, 0x00, 0x18, 0x18, 0x60, 0x00, 0x30, 0x30, 0x40, 0x00, 0x40, 0x60,
  0x80, 0x00, 0x80, 0x81, 0x80, 0x03, 0x01, 0x01, 0x00, 0x06, 0x06, 0x03,
  0x00, 0x0C, 0x0C, 0x02, 0x00, 0x18, 0x18, 0x04, 0x00, 0x20, 0x30, 0x0C,
  0x00, 0x40, 0x40, 0x08, 0x01, 0x80, 0x80, 0x18, 0x03, 0x03, 0x00, 0x30,
  0x06, 0x06, 0x00, 0x20, 0x0C, 0x0C, 0x00, 0x60, 0x10, 0x18, 0x00, 0x40,
  0x20, 0x20, 0x00, 0x80, 0xC0, 0x40, 0x01, 0x81, 0x81, 0x80, 0x01, 0x03,
  0x03, 0x00, 0x03, 0x06, 0x06, 0x00, 0x02, 0x08, 0x0C, 0x00, 0x04, 0x10,
  0x10, 0x00, 0x0C, 0x60, 0x20, 0x00, 0x08, 0xC0, 0xC0, 0x00, 0x19, 0x81,
  0x80, 0x00, 0x33, 0x03, 0x00, 0x00, 0x24, 0x04, 0x00, 0x00, 0x68, 0x08,
  0x00, 0x00, 0x70, 0x10, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x01, 0xC0, 0xC0,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x38,
  0x07, 0x00, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x01, 0x80, 0x18, 0x00, 0x0C,
  0x03, 0x00, 0x00, 0x40, 0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x02, 0x08, 0x00, 0x00, 0x20, 0x80, 0x00, 0x02, 0x18, 0x00, 0x00,
  0x21, 0x00, 0x00, 0x02, 0x10, 0x00, 0x00, 0x23, 0x00, 0x00, 0x02, 0x30,
  0x00, 0x00, 0x23, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0x62, 0x00, 0x00,
  0x06, 0x20, 0x00, 0x00, 0x46, 0x00, 0x00, 0x04, 0x60, 0x00, 0x00, 0x46,
  0x00, 0x00, 0x0C, 0x40, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x0C, 0x40, 0x00,
  0x00, 0x8C, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x18,
  0xC0, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x20, 0x40, 0x00, 0x06, 0x04, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x08,
  0x02, 0x00, 0x01, 0x80, 0x30, 0x00, 0x30, 0x01, 0x80, 0x0E, 0x00, 0x0E,
  0x03, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x20, 0x07, 0xC0, 0x04, 0x00, 0x0C, 0x00, 0x80, 0x00, 0xC0,
  0x30, 0x00, 0x0C, 0x06, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x10, 0x10, 0x00,
  0x03, 0x02, 0x00, 0x00, 0x60, 0x40, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x83,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x04, 0x08, 0x00, 0x00, 0x81, 0x00, 0x00,
  0x30, 0x20, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x81, 0x80, 0x00, 0x30, 0x20,
  0x00, 0x0C, 0x04, 0x00, 0x03, 0x00, 0x80, 0x00, 0xE0, 0x10, 0x00, 0x70,
  0x06, 0x00, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x38, 0x06, 0x00, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x01, 0x80, 0x18,
  0x00, 0x0C, 0x03, 0x00, 0x00, 0x40, 0x60, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x02, 0x08, 0x00, 0x00, 0x20, 0x80, 0x00, 0x02, 0x18,
  0x00, 0x00, 0x21, 0x00, 0x00, 0x02, 0x10, 0x00, 0x00, 0x23, 0x00, 0x00,
  0x02, 0x30, 0x00, 0x00, 0x23, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0x62,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x46, 0x00, 0x00, 0x04, 0x60, 0x00,
  0x00, 0x46, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x0C,
  0xC0, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x20, 0x40, 0x00, 0x06, 0x04, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x08, 0x02, 0x00, 0x01, 0x80, 0x30, 0x00, 0x30, 0x01, 0x80, 0x0E,
  0x00, 0x0E, 0x03, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x21, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x20, 0x07, 0xC0, 0x04, 0x00, 0x0C, 0x01, 0x80, 0x00, 0xC0, 0x30,
  0x00, 0x0C, 0x06, 0x00, 0x00, 0x80, 0x80, 0x00, 0x18, 0x10, 0x00, 0x03,
  0x02, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x04, 0x18, 0x00, 0x01, 0x83, 0x00,
  0x00, 0x30, 0x40, 0x00, 0x06, 0x08, 0x00, 0x00, 0x81, 0x00, 0x00, 0x30,
  0x60, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x81, 0x80, 0x00, 0x20, 0x20, 0x00,
  0x0C, 0x04, 0x00, 0x03, 0x00, 0x80, 0x01, 0xC0, 0x30, 0x01, 0xE0, 0x07,
  0xFF, 0xF0, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x08,
  0x00, 0x40, 0x01, 0x80, 0x18, 0x00, 0x30, 0x03, 0x00, 0x02, 0x00, 0x40,
  0x00, 0x60, 0x08, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x80, 0x20, 0x00, 0x18,
  0x0C, 0x00, 0x03, 0x01, 0x80, 0x00, 0x20, 0x20, 0x00, 0x06, 0x04, 0x00,
  0x00, 0xC0, 0x80, 0x00, 0x18, 0x30, 0x00, 0x01, 0x86, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x3C, 0x07, 0x00, 0x07, 0x00, 0x18, 0x00, 0xC0, 0x00, 0xC0, 0x18, 0x00,
  0x06, 0x01, 0x00, 0x00, 0x60, 0x30, 0x00, 0x02, 0x02, 0x00, 0x00, 0x20,
  0x60, 0x00, 0x02, 0x06, 0x00, 0x00, 0x20, 0x40, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x10, 0x40, 0x00, 0x01, 0x04, 0x00, 0x00, 0x10, 0x40, 0x00, 0x01, 0x04,
  0x00, 0x00, 0x30, 0x40, 0x00, 0x03, 0x06, 0x00, 0x00, 0x60, 0x60, 0x00,
  0x06, 0x03, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x18, 0x01, 0xC0, 0x07, 0x00,
  0x0F, 0x01, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x10, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x18,
  0x10, 0x00, 0x00, 0x81, 0x80, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x20, 0x60,
  0x00, 0x03, 0x02, 0x00, 0x00, 0x18, 0x10, 0x00, 0x00, 0xC0, 0x80, 0x00,
  0x04, 0x0C, 0x00, 0x00, 0x20, 0x60, 0x00, 0x01, 0x03, 0x00, 0x00, 0x18,
  0x10, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x20, 0x60,
  0x00, 0x01, 0x03, 0x00, 0x00, 0x08, 0x10, 0x00, 0x00, 0xC0, 0x80, 0x00,
  0x06, 0x04, 0x00, 0x00, 0x30, 0x60, 0x00, 0x01, 0x03, 0x00, 0x00, 0x08,
  0x18, 0x00, 0x00, 0x40, 0x80, 0x00, 0x06, 0x04, 0x00, 0x00, 0x30, 0x20,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0x40, 0xC0, 0x00,
  0x02, 0x04, 0x00, 0x00, 0x30, 0x20, 0x00, 0x01, 0x81, 0x00, 0x00, 0x08,
  0x08, 0x00, 0x00, 0x40, 0x40, 0x00, 0x06, 0x02, 0x00, 0x00, 0x20, 0x18,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0x30, 0x02, 0x00, 0x01, 0x80, 0x18, 0x00,
  0x18, 0x00, 0x60, 0x03, 0x80, 0x01, 0xC0, 0x78, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x58, 0x00, 0x00, 0x1B,
  0x00, 0x00, 0x03, 0x20, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x18, 0x80, 0x00,
  0x06, 0x18, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x10, 0x60, 0x00, 0x06, 0x0C,
  0x00, 0x00, 0x80, 0x80, 0x00, 0x30, 0x10, 0x00, 0x04, 0x02, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x20, 0x0C, 0x00, 0x0C, 0x01, 0x80, 0x01, 0x80, 0x30,
  0x00, 0x60, 0x02, 0x00, 0x0C, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x60,
  0x01, 0x80, 0x08, 0x00, 0x30, 0x03, 0x00, 0x06, 0x00, 0x40, 0x00, 0x40,
  0x18, 0x00, 0x08, 0x02, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x20, 0x18, 0x00,
  0x06, 0x02, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x18, 0x10, 0x00, 0x01, 0x06,
  0x00, 0x00, 0x20, 0x80, 0x00, 0x04, 0x30, 0x00, 0x00, 0x84, 0x00, 0x00,
  0x19, 0x80, 0x00, 0x03, 0x20, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x05, 0x00,
  0x00, 0x00, 0xA0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00,
  0xC0, 0x00, 0x14, 0x00, 0x03, 0xC0, 0x00, 0x68, 0x00, 0x05, 0x80, 0x00,
  0xD8, 0x00, 0x1B, 0x00, 0x01, 0x30, 0x00, 0x22, 0x00, 0x06, 0x60, 0x00,
  0x44, 0x00, 0x0C, 0xC0, 0x01, 0x88, 0x00, 0x11, 0x80, 0x02, 0x10, 0x00,
  0x63, 0x00, 0x0C, 0x20, 0x00, 0x86, 0x00, 0x18, 0x40, 0x03, 0x0C, 0x00,
  0x20, 0x80, 0x06, 0x18, 0x00, 0xC1, 0x80, 0x08, 0x10, 0x01, 0x03, 0x00,
  0x30, 0x20, 0x06, 0x06, 0x00, 0x60, 0x40, 0x0C, 0x0C, 0x00, 0x80, 0x80,
  0x10, 0x18, 0x03, 0x01, 0x00, 0x60, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x04, 0x03, 0x00, 0x40, 0x30, 0x0C, 0x06, 0x00, 0x80, 0x40, 0x18,
  0x08, 0x01, 0x01, 0x80, 0x30, 0x30, 0x02, 0x03, 0x00, 0x60, 0x40, 0x06,
  0x04, 0x00, 0xC1, 0x80, 0x0C, 0x18, 0x01, 0x83, 0x00, 0x18, 0x20, 0x03,
  0x04, 0x00, 0x30, 0x40, 0x06, 0x18, 0x00, 0x61, 0x80, 0x04, 0x20, 0x00,
  0xC2, 0x00, 0x08, 0xC0, 0x00, 0x8C, 0x00, 0x11, 0x80, 0x01, 0x18, 0x00,
  0x22, 0x00, 0x02, 0x20, 0x00, 0x4C, 0x00, 0x04, 0xC0, 0x00, 0x90, 0x00,
  0x09, 0x80, 0x01, 0x20, 0x00, 0x12, 0x00, 0x02, 0xC0, 0x00, 0x2C, 0x00,
  0x05, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00,
  0x01, 0xC0, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x01, 0x80, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x60, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60,
  0x00, 0x30, 0x00, 0xC0, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x10, 0x01, 0x80,
  0x00, 0x18, 0x03, 0x00, 0x00, 0x08, 0x02, 0x00, 0x00, 0x0C, 0x06, 0x00,
  0x00, 0x04, 0x0C, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x06, 0x10, 0x00,
  0x00, 0x02, 0x30, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x01, 0x40, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x06, 0x40, 0x00, 0x00, 0x04, 0x40, 0x00, 0x00, 0x0C, 0x60, 0x00,
  0x00, 0x18, 0x20, 0x00, 0x00, 0x10, 0x30, 0x00, 0x00, 0x30, 0x10, 0x00,
  0x00, 0x60, 0x18, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x80, 0x08, 0x00,
  0x01, 0x80, 0x0C, 0x00, 0x03, 0x00, 0x04, 0x00, 0x02, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x10, 0x00, 0x01, 0x00, 0x30, 0x00, 0x01, 0x80, 0x60, 0x00, 0x01, 0x80,
  0x40, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x19, 0x80,
  0x00, 0x06, 0x30, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0x60, 0x00, 0x0C,
  0x0C, 0x00, 0x01, 0x80, 0x80, 0x00, 0x60, 0x18, 0x00, 0x18, 0x03, 0x00,
  0x03, 0x00, 0x20, 0x00, 0xC0, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x06, 0x00,
  0x08, 0x01, 0x80, 0x01, 0x80, 0x20, 0x00, 0x30, 0x0C, 0x00, 0x02, 0x03,
  0x00, 0x00, 0x60, 0x40, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x86, 0x00, 0x00,
  0x10, 0x80, 0x00, 0x03, 0x30, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x05, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFE, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x10, 0x00, 0x3F, 0x00, 0x00, 0x80, 0xC0, 0xC0, 0xC0, 0x40, 0x40, 0x40,
  0x40, 0x60, 0x60, 0x60, 0x20, 0x20, 0x20, 0x20, 0x30, 0x30, 0x30, 0x10,
  0x10, 0x10, 0x10, 0x18, 0x18, 0x18, 0x18, 0x08, 0x08, 0x08, 0x0C, 0x0C,
  0x0C, 0x0C, 0x04, 0x04, 0x04, 0x06, 0x06, 0x06, 0x06, 0x02, 0x02, 0x02,
  0x03, 0x03, 0x00, 0x7F, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00,
  0x02, 0x00, 0xFE, 0x00, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x02, 0x80,
  0x0D, 0x80, 0x13, 0x00, 0x62, 0x00, 0x84, 0x03, 0x08, 0x04, 0x10, 0x18,
  0x30, 0x20, 0x60, 0xC0, 0x41, 0x00, 0x86, 0x01, 0x18, 0x02, 0x30, 0x06,
  0xC0, 0x0D, 0x80, 0x1E, 0x00, 0x10, 0xFF, 0xFF, 0xF0, 0xC1, 0x86, 0x0C,
  0x10, 0x60, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x1C, 0x07, 0x00,
  0xC0, 0x0C, 0x06, 0x00, 0x18, 0x10, 0x00, 0x20, 0xC0, 0x00, 0x82, 0x00,
  0x02, 0x18, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x07, 0xFF, 0x00, 0xFC, 0x04, 0x0E,
  0x00, 0x10, 0x60, 0x00, 0xC3, 0x00, 0x03, 0x18, 0x00, 0x08, 0x40, 0x00,
  0x23, 0x00, 0x00, 0x8C, 0x00, 0x06, 0x20, 0x00, 0x18, 0x80, 0x00, 0xE2,
  0x00, 0x03, 0x0C, 0x00, 0x14, 0x30, 0x00, 0x90, 0x60, 0x0C, 0x41, 0xC0,
  0xE3, 0x01, 0xFE, 0x0C, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x10, 0x00, 0x43, 0xFE, 0x01,
  0x9C, 0x0E, 0x03, 0x60, 0x04, 0x05, 0x80, 0x0C, 0x0E, 0x00, 0x08, 0x18,
  0x00, 0x18, 0x60, 0x00, 0x30, 0xC0, 0x00, 0x61, 0x80, 0x00, 0xC2, 0x00,
  0x01, 0x84, 0x00, 0x03, 0x08, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x60, 0x00,
  0x10, 0xC0, 0x00, 0x21, 0x00, 0x00, 0x42, 0x00, 0x00, 0x84, 0x00, 0x03,
  0x18, 0x00, 0x06, 0x30, 0x00, 0x08, 0x60, 0x00, 0x10, 0x80, 0x00, 0x61,
  0x00, 0x00, 0x82, 0x00, 0x03, 0x0C, 0x00, 0x04, 0x1C, 0x00, 0x18, 0x38,
  0x00, 0x60, 0x4C, 0x01, 0x80, 0x8C, 0x06, 0x01, 0x0F, 0xF8, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x70, 0x38, 0x0E, 0x00,
  0xC0, 0x40, 0x03, 0x06, 0x00, 0x08, 0x60, 0x00, 0x62, 0x00, 0x03, 0x30,
  0x00, 0x19, 0x00, 0x00, 0xC8, 0x00, 0x06, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x01, 0x90, 0x00, 0x08, 0xC0, 0x00, 0x46, 0x00, 0x06, 0x10, 0x00,
  0x60, 0xC0, 0x02, 0x03, 0x00, 0x70, 0x1C, 0x06, 0x00, 0x3F, 0xE0, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x07, 0xFC, 0x30, 0x06, 0x03,
  0x10, 0x06, 0x00, 0xC8, 0x06, 0x00, 0x34, 0x06, 0x00, 0x0E, 0x02, 0x00,
  0x03, 0x03, 0x00, 0x01, 0x81, 0x00, 0x00, 0x81, 0x80, 0x00, 0x40, 0xC0,
  0x00, 0x20, 0x40, 0x00, 0x30, 0x20, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x18,
  0x00, 0x04, 0x0C, 0x00, 0x02, 0x04, 0x00, 0x01, 0x02, 0x00, 0x01, 0x81,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x20, 0x60, 0x00, 0x10,
  0x30, 0x00, 0x08, 0x18, 0x00, 0x0C, 0x04, 0x00, 0x06, 0x02, 0x00, 0x02,
  0x01, 0x00, 0x03, 0x00, 0xC0, 0x02, 0x80, 0x30, 0x06, 0xC0, 0x0C, 0x0E,
  0x60, 0x03, 0xFC, 0x30, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x0E, 0x07, 0x00, 0x60, 0x0C, 0x03, 0x00, 0x18, 0x18, 0x00,
  0x20, 0xC0, 0x00, 0xC2, 0x00, 0x03, 0x18, 0x00, 0x0C, 0x40, 0x00, 0x33,
  0x00, 0x00, 0xCC, 0x00, 0x03, 0x20, 0x00, 0x0C, 0x80, 0x00, 0x37, 0xFF,
  0xFF, 0x98, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00,
  0x10, 0x18, 0x01, 0xC0, 0x38, 0x1C, 0x00, 0x7F, 0xE0, 0x00, 0x10, 0x00,
  0x00, 0x02, 0x00, 0x07, 0xE0, 0x07, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x07, 0xFF, 0x80, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0xC0, 0x18, 0x0C,
  0x40, 0x18, 0x03, 0x20, 0x18, 0x00, 0xD0, 0x18, 0x00, 0x38, 0x08, 0x00,
  0x1C, 0x0C, 0x00, 0x06, 0x04, 0x00, 0x02, 0x06, 0x00, 0x01, 0x03, 0x00,
  0x00, 0x81, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x30, 0x60,
  0x00, 0x10, 0x20, 0x00, 0x08, 0x10, 0x00, 0x04, 0x08, 0x00, 0x06, 0x04,
  0x00, 0x03, 0x06, 0x00, 0x01, 0x83, 0x00, 0x00, 0x81, 0x80, 0x00, 0x40,
  0xC0, 0x00, 0x20, 0x60, 0x00, 0x30, 0x30, 0x00, 0x18, 0x08, 0x00, 0x0C,
  0x04, 0x00, 0x0C, 0x03, 0x00, 0x0A, 0x00, 0xC0, 0x19, 0x00, 0x30, 0x39,
  0x80, 0x0F, 0xF0, 0xC0, 0x00, 0x80, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x06, 0x03, 0x00, 0x06, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x06, 0x00, 0x0F,
  0x1E, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x3F, 0xC0, 0x63, 0x83, 0x81,
  0x98, 0x02, 0x06, 0xC0, 0x0C, 0x12, 0x00, 0x30, 0x50, 0x00, 0x41, 0xC0,
  0x01, 0x0E, 0x00, 0x04, 0x30, 0x00, 0x10, 0xC0, 0x00, 0x43, 0x00, 0x03,
  0x08, 0x00, 0x0C, 0x60, 0x00, 0x31, 0x80, 0x00, 0x86, 0x00, 0x02, 0x10,
  0x00, 0x08, 0x40, 0x00, 0x61, 0x00, 0x01, 0x8C, 0x00, 0x06, 0x30, 0x00,
  0x10, 0xC0, 0x00, 0x42, 0x00, 0x01, 0x08, 0x00, 0x0C, 0x20, 0x00, 0x31,
  0x80, 0x00, 0xC6, 0x00, 0x02, 0x18, 0x00, 0x08, 0x40, 0x00, 0x21, 0x00,
  0x01, 0x84, 0x00, 0x06, 0x00, 0x01, 0x81, 0xC0, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x40, 0x20, 0x30, 0x18, 0x0C,
  0x04, 0x02, 0x01, 0x01, 0x80, 0xC0, 0x60, 0x20, 0x10, 0x18, 0x0C, 0x06,
  0x02, 0x01, 0x00, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x08, 0x04, 0x06, 0x03,
  0x01, 0x80, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x80,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x27, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x40, 0x01, 0xC1, 0x80, 0x07, 0x03, 0x00, 0x1C, 0x06, 0x00, 0x60, 0x08,
  0x01, 0x80, 0x10, 0x06, 0x00, 0x20, 0x18, 0x00, 0xC0, 0x60, 0x01, 0x81,
  0x80, 0x02, 0x06, 0x00, 0x04, 0x18, 0x00, 0x08, 0x60, 0x00, 0x31, 0x80,
  0x00, 0x67, 0x00, 0x00, 0xDA, 0x00, 0x01, 0x46, 0x00, 0x03, 0x04, 0x00,
  0x04, 0x0C, 0x00, 0x18, 0x0C, 0x00, 0x30, 0x18, 0x00, 0x60, 0x18, 0x00,
  0x80, 0x30, 0x01, 0x00, 0x30, 0x02, 0x00, 0x60, 0x0C, 0x00, 0x60, 0x18,
  0x00, 0xC0, 0x30, 0x00, 0xC0, 0x40, 0x00, 0x80, 0x80, 0x01, 0x81, 0x00,
  0x01, 0x00, 0x01, 0x80, 0x80, 0x40, 0x20, 0x30, 0x18, 0x0C, 0x04, 0x02,
  0x01, 0x01, 0x80, 0xC0, 0x60, 0x20, 0x10, 0x08, 0x0C, 0x06, 0x03, 0x01,
  0x00, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x08, 0x04, 0x06, 0x03, 0x01, 0x80,
  0x80, 0x40, 0x20, 0x30, 0x18, 0x0C, 0x04, 0x02, 0x01, 0x01, 0x80, 0xC0,
  0x60, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x3F, 0xC0, 0x1F,
  0xE0, 0x18, 0xC0, 0xE0, 0xE0, 0x60, 0x33, 0x00, 0xC3, 0x00, 0x60, 0x4C,
  0x00, 0xCC, 0x00, 0x40, 0xB0, 0x01, 0xB0, 0x00, 0xC3, 0x40, 0x01, 0x40,
  0x01, 0x87, 0x00, 0x03, 0x80, 0x03, 0x0E, 0x00, 0x06, 0x00, 0x06, 0x18,
  0x00, 0x08, 0x00, 0x0C, 0x30, 0x00, 0x30, 0x00, 0x18, 0x40, 0x00, 0x60,
  0x00, 0x31, 0x80, 0x00, 0xC0, 0x00, 0x43, 0x00, 0x01, 0x00, 0x00, 0x86,
  0x00, 0x02, 0x00, 0x03, 0x08, 0x00, 0x04, 0x00, 0x06, 0x10, 0x00, 0x18,
  0x00, 0x0C, 0x20, 0x00, 0x30, 0x00, 0x10, 0xC0, 0x00, 0x60, 0x00, 0x21,
  0x80, 0x00, 0x80, 0x00, 0x43, 0x00, 0x01, 0x00, 0x01, 0x84, 0x00, 0x02,
  0x00, 0x03, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x10, 0x00, 0x18, 0x00, 0x08,
  0x60, 0x00, 0x30, 0x00, 0x10, 0xC0, 0x00, 0x40, 0x00, 0x21, 0x80, 0x00,
  0x80, 0x00, 0xC2, 0x00, 0x01, 0x00, 0x01, 0x84, 0x00, 0x06, 0x00, 0x03,
  0x08, 0x00, 0x0C, 0x00, 0x04, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x00, 0x08, 0x3F, 0xC0, 0x63, 0x83, 0x81, 0x98, 0x02, 0x06, 0xC0,
  0x0C, 0x12, 0x00, 0x30, 0x50, 0x00, 0x41, 0xC0, 0x01, 0x0E, 0x00, 0x04,
  0x30, 0x00, 0x10, 0xC0, 0x00, 0x43, 0x00, 0x03, 0x08, 0x00, 0x0C, 0x20,
  0x00, 0x31, 0x80, 0x00, 0x86, 0x00, 0x02, 0x18, 0x00, 0x08, 0x40, 0x00,
  0x61, 0x00, 0x01, 0x8C, 0x00, 0x06, 0x30, 0x00, 0x10, 0xC0, 0x00, 0x42,
  0x00, 0x01, 0x08, 0x00, 0x0C, 0x20, 0x00, 0x31, 0x80, 0x00, 0xC6, 0x00,
  0x02, 0x18, 0x00, 0x08, 0x40, 0x00, 0x21, 0x00, 0x01, 0x84, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x1C, 0x06, 0x00, 0xC0, 0x0C,
  0x06, 0x00, 0x18, 0x30, 0x00, 0x60, 0xC0, 0x00, 0x86, 0x00, 0x03, 0x10,
  0x00, 0x0C, 0xC0, 0x00, 0x33, 0x00, 0x00, 0xC8, 0x00, 0x03, 0x60, 0x00,
  0x0D, 0x80, 0x00, 0x34, 0x00, 0x00, 0xD0, 0x00, 0x02, 0x40, 0x00, 0x09,
  0x00, 0x00, 0x2C, 0x00, 0x01, 0xB0, 0x00, 0x06, 0xC0, 0x00, 0x13, 0x00,
  0x00, 0x4C, 0x00, 0x03, 0x30, 0x00, 0x08, 0x40, 0x00, 0x61, 0x00, 0x01,
  0x06, 0x00, 0x0C, 0x18, 0x00, 0x60, 0x30, 0x03, 0x00, 0x70, 0x38, 0x00,
  0xFF, 0x80, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40, 0x00, 0x43, 0xFC, 0x00,
  0x67, 0x03, 0x80, 0x36, 0x00, 0x40, 0x1E, 0x00, 0x30, 0x0E, 0x00, 0x08,
  0x06, 0x00, 0x06, 0x02, 0x00, 0x03, 0x03, 0x00, 0x01, 0x81, 0x80, 0x00,
  0xC0, 0xC0, 0x00, 0x60, 0x40, 0x00, 0x30, 0x20, 0x00, 0x18, 0x30, 0x00,
  0x0C, 0x18, 0x00, 0x04, 0x0C, 0x00, 0x02, 0x04, 0x00, 0x01, 0x02, 0x00,
  0x00, 0x81, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x20, 0x60,
  0x00, 0x10, 0x20, 0x00, 0x18, 0x10, 0x00, 0x08, 0x08, 0x00, 0x0C, 0x0C,
  0x00, 0x04, 0x07, 0x00, 0x06, 0x03, 0x80, 0x06, 0x01, 0x30, 0x06, 0x00,
  0x8C, 0x06, 0x00, 0x43, 0xFE, 0x00, 0x60, 0x10, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x0C, 0x07, 0x03, 0x10, 0x18, 0x03, 0x20, 0x60, 0x03, 0x41, 0x80,
  0x03, 0x82, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x10, 0x00, 0x08, 0x60, 0x00,
  0x10, 0xC0, 0x00, 0x21, 0x00, 0x00, 0xC2, 0x00, 0x01, 0x8C, 0x00, 0x03,
  0x18, 0x00, 0x04, 0x30, 0x00, 0x08, 0x40, 0x00, 0x10, 0x80, 0x00, 0x61,
  0x00, 0x00, 0xC6, 0x00, 0x01, 0x8C, 0x00, 0x02, 0x18, 0x00, 0x04, 0x30,
  0x00, 0x08, 0x60, 0x00, 0x30, 0xC0, 0x00, 0x60, 0x80, 0x00, 0x81, 0x00,
  0x03, 0x03, 0x00, 0x0E, 0x03, 0x00, 0x64, 0x03, 0x03, 0x98, 0x03, 0xFC,
  0x30, 0x00, 0x80, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x01, 0x0F, 0xC1, 0x8C, 0x00, 0xC8, 0x00, 0x68, 0x00, 0x28,
  0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x70, 0x38, 0x06, 0x00, 0x60, 0x60, 0x01, 0x06, 0x00, 0x0C, 0x20, 0x00,
  0x61, 0x00, 0x03, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x46,
  0x00, 0x06, 0x30, 0x00, 0x20, 0xC0, 0x03, 0x06, 0x00, 0x30, 0x1C, 0x07,
  0x00, 0x3F, 0xE0, 0x00, 0x10, 0x00, 0x01, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x02, 0x00, 0x20, 0x06, 0x00, 0x60, 0x7F, 0xF0, 0x40, 0x04, 0x00, 0x40,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x08, 0x00, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x00, 0x10, 0x01, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00,
  0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x06, 0x00,
  0x20, 0x03, 0xF0, 0x04, 0x00, 0x18, 0x00, 0x0C, 0x60, 0x00, 0x21, 0x80,
  0x00, 0x84, 0x00, 0x02, 0x10, 0x00, 0x18, 0x40, 0x00, 0x63, 0x00, 0x01,
  0x8C, 0x00, 0x04, 0x30, 0x00, 0x10, 0x80, 0x00, 0x42, 0x00, 0x03, 0x08,
  0x00, 0x0C, 0x60, 0x00, 0x31, 0x80, 0x00, 0x86, 0x00, 0x02, 0x10, 0x00,
  0x08, 0x40, 0x00, 0x61, 0x00, 0x01, 0x8C, 0x00, 0x06, 0x30, 0x00, 0x10,
  0xC0, 0x00, 0x43, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x70, 0xC0,
  0x01, 0x83, 0x00, 0x0A, 0x04, 0x00, 0x68, 0x18, 0x03, 0x60, 0x30, 0x39,
  0x80, 0x7F, 0x86, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x38, 0x00, 0x02,
  0x80, 0x00, 0x6C, 0x00, 0x04, 0xC0, 0x00, 0xCC, 0x00, 0x0C, 0x40, 0x00,
  0x84, 0x00, 0x18, 0x40, 0x01, 0x06, 0x00, 0x30, 0x60, 0x02, 0x06, 0x00,
  0x60, 0x20, 0x04, 0x02, 0x00, 0xC0, 0x20, 0x08, 0x03, 0x01, 0x80, 0x30,
  0x10, 0x03, 0x03, 0x00, 0x10, 0x20, 0x01, 0x06, 0x00, 0x10, 0x40, 0x01,
  0x8C, 0x00, 0x18, 0x80, 0x01, 0x98, 0x00, 0x09, 0x00, 0x00, 0xB0, 0x00,
  0x0B, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x80, 0x01,
  0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x14, 0x00, 0x38,
  0x00, 0x6C, 0x00, 0x58, 0x00, 0x98, 0x01, 0xB0, 0x03, 0x30, 0x02, 0x60,
  0x06, 0x60, 0x0C, 0xC0, 0x18, 0xC0, 0x19, 0x80, 0x31, 0x80, 0x23, 0x00,
  0x43, 0x00, 0xC2, 0x01, 0x86, 0x01, 0x04, 0x03, 0x0C, 0x06, 0x08, 0x0C,
  0x08, 0x08, 0x10, 0x18, 0x10, 0x30, 0x20, 0x20, 0x20, 0x60, 0x60, 0xC0,
  0x41, 0x80, 0xC1, 0x00, 0x83, 0x01, 0x86, 0x01, 0x04, 0x03, 0x0C, 0x03,
  0x18, 0x06, 0x30, 0x06, 0x20, 0x04, 0x60, 0x0C, 0xC0, 0x08, 0x80, 0x19,
  0x00, 0x13, 0x00, 0x36, 0x00, 0x26, 0x00, 0x6C, 0x00, 0x48, 0x00, 0xD0,
  0x00, 0xB0, 0x01, 0xE0, 0x01, 0x40, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x03, 0x03, 0x00,
  0x06, 0x03, 0x00, 0x06, 0x01, 0x80, 0x0C, 0x01, 0x80, 0x18, 0x00, 0x80,
  0x10, 0x00, 0xC0, 0x30, 0x00, 0x40, 0x60, 0x00, 0x60, 0xC0, 0x00, 0x60,
  0x80, 0x00, 0x31, 0x80, 0x00, 0x33, 0x00, 0x00, 0x16, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x34, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x46, 0x00, 0x00, 0xC3, 0x00, 0x01, 0x83, 0x00, 0x03, 0x01,
  0x00, 0x02, 0x01, 0x80, 0x06, 0x00, 0x80, 0x0C, 0x00, 0xC0, 0x18, 0x00,
  0xC0, 0x18, 0x00, 0x60, 0x30, 0x00, 0x60, 0x60, 0x00, 0x30, 0xC0, 0x00,
  0x30, 0x02, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x08, 0x0C,
  0x00, 0x06, 0x03, 0x00, 0x01, 0x00, 0x40, 0x00, 0xC0, 0x10, 0x00, 0x20,
  0x04, 0x00, 0x18, 0x01, 0x80, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0x80, 0x02, 0x00, 0x60, 0x00, 0x80, 0x10, 0x00, 0x20, 0x0C, 0x00, 0x0C,
  0x02, 0x00, 0x03, 0x01, 0x80, 0x00, 0xC0, 0x40, 0x00, 0x10, 0x30, 0x00,
  0x04, 0x08, 0x00, 0x01, 0x06, 0x00, 0x00, 0x41, 0x80, 0x00, 0x18, 0xC0,
  0x00, 0x06, 0x30, 0x00, 0x01, 0x98, 0x00, 0x00, 0x26, 0x00, 0x00, 0x0B,
  0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03,
  0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30,
  0x00, 0x08, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x03, 0xC0, 0x00,
  0xE0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01,
  0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x38,
  0x00, 0x02, 0x00, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x08, 0x04, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x40, 0x20, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x00, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x08, 0x04, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x20, 0x10, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x80, 0x40,
  0x60, 0x30, 0x18, 0x0C, 0x04, 0x02, 0x03, 0x01, 0x80, 0xC0, 0x00, 0x00,
  0x40, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01,
  0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01,
  0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x0C,
  0x60, 0x60, 0x01, 0x18, 0x06, 0x00, 0x62, 0x00, 0x60, 0x0C, 0xC0, 0x04,
  0x03, 0x10, 0x00, 0xC0, 0xC2, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x7C, 0x00,
};

const GFXglyph RobotoCondensed_ThinItalic57pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 9, 42, 10, 1, -41 },
  { 49, 9, 11, 14, 6, -43 },
  { 62, 28, 41, 27, 1, -41 },
  { 206, 24, 53, 27, 2, -47 },
  { 365, 27, 43, 36, 5, -42 },
  { 511, 25, 43, 30, 2, -42 },
  { 646, 4, 12, 9, 6, -43 },
  { 652, 15, 58, 15, 3, -45 },
  { 761, 15, 58, 15, -3, -45 },
  { 870, 22, 22, 23, 3, -41 },
  { 931, 24, 29, 27, 2, -33 },
  { 1018, 6, 11, 10, -2, -4 },
  { 1027, 11, 1, 15, 2, -19 },
  { 1029, 4, 3, 12, 1, -2 },
  { 1031, 23, 44, 19, -2, -41 },
  { 1158, 22, 43, 27, 3, -42 },
  { 1277, 12, 41, 27, 8, -41 },
  { 1339, 24, 42, 27, 1, -42 },
  { 1465, 23, 43, 27, 2, -42 },
  { 1589, 24, 41, 27, 1, -41 },
  { 1712, 23, 42, 27, 4, -41 },
  { 1833, 21, 42, 27, 3, -41 },
  { 1944, 22, 41, 27, 5, -41 },
  { 2057, 25, 43, 27, 1, -42 },
  { 2192, 21, 42, 27, 4, -42 },
  { 2303, 8, 30, 10, 1, -29 },
  { 2333, 11, 36, 10, -2, -29 },
  { 2383, 21, 23, 25, 3, -30 },
  { 2444, 21, 11, 27, 3, -24 },
  { 2473, 21, 23, 25, 2, -30 },
  { 2534, 17, 43, 22, 5, -42 },
  { 2626, 40, 52, 45, 2, -39 },
  { 2886, 27, 41, 29, -2, -41 },
  { 3025, 26, 41, 29, 2, -41 },
  { 3159, 27, 43, 31, 3, -42 },
  { 3305, 28, 41, 32, 2, -41 },
  { 3449, 28, 41, 28, 2, -41 },
  { 3593, 28, 41, 28, 2, -41 },
  { 3737, 27, 43, 33, 4, -42 },
  { 3883, 31, 41, 34, 2, -41 },
  { 4042, 9, 41, 13, 3, -41 },
  { 4089, 25, 42, 27, 1, -41 },
  { 4221, 30, 41, 31, 2, -41 },
  { 4375, 19, 41, 25, 2, -41 },
  { 4473, 38, 41, 41, 2, -41 },
  { 4668, 31, 41, 34, 2, -41 },
  { 4827, 28, 43, 32, 3, -42 },
  { 4978, 27, 41, 29, 2, -41 },
  { 5117, 28, 49, 32, 3, -42 },
  { 5289, 27, 41, 32, 2, -41 },
  { 5428, 28, 43, 29, 1, -42 },
  { 5579, 25, 41, 29, 6, -41 },
  { 5708, 29, 42, 32, 3, -41 },
  { 5861, 27, 41, 29, 5, -41 },
  { 6000, 39, 41, 43, 6, -41 },
  { 6200, 32, 41, 29, -1, -41 },
  { 6364, 27, 41, 29, 5, -41 },
  { 6503, 30, 41, 29, 0, -41 },
  { 6657, 15, 55, 11, 1, -46 },
  { 6761, 8, 45, 19, 6, -41 },
  { 6806, 16, 55, 11, -4, -46 },
  { 6916, 15, 20, 21, 3, -41 },
  { 6954, 20, 1, 20, -3, 0 },
  { 6957, 6, 7, 15, 8, -42 },
  { 6963, 22, 32, 26, 1, -31 },
  { 7051, 23, 44, 27, 1, -43 },
  { 7178, 21, 32, 25, 2, -31 },
  { 7262, 25, 44, 27, 2, -43 },
  { 7400, 22, 32, 25, 1, -31 },
  { 7488, 18, 44, 16, 3, -44 },
  { 7587, 25, 43, 27, 0, -31 },
  { 7722, 22, 43, 27, 1, -43 },
  { 7841, 9, 41, 11, 2, -41 },
  { 7888, 19, 53, 11, -8, -41 },
  { 8014, 23, 43, 23, 1, -43 },
  { 8138, 9, 43, 11, 2, -43 },
  { 8187, 39, 31, 43, 1, -31 },
  { 8339, 22, 31, 27, 1, -31 },
  { 8425, 22, 32, 27, 2, -31 },
  { 8513, 25, 43, 27, -1, -31 },
  { 8648, 23, 43, 27, 2, -31 },
  { 8772, 17, 31, 17, 1, -31 },
  { 8838, 21, 32, 24, 1, -31 },
  { 8922, 12, 39, 16, 3, -38 },
  { 8981, 22, 31, 27, 3, -30 },
  { 9067, 20, 30, 23, 4, -30 },
  { 9142, 31, 30, 37, 5, -30 },
  { 9259, 24, 30, 23, -1, -30 },
  { 9349, 26, 42, 23, -2, -30 },
  { 9486, 23, 30, 23, 0, -30 },
  { 9573, 18, 56, 16, 2, -44 },
  { 9699, 9, 49, 11, 1, -41 },
  { 9755, 18, 56, 16, -4, -44 },
  { 9881, 27, 9, 33, 3, -21 },
};

const GFXfont RobotoCondensed_ThinItalic57pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ThinItalic57pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ThinItalic57pt7bGlyphs,
  0x20, 0x7E, 67
};

#endif // _ROBOTOCONDENSED_THINITALIC57PT7B_H_
