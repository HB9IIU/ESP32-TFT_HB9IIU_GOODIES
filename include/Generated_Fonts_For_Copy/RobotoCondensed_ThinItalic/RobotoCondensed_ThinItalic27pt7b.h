#ifndef _ROBOTOCONDENSED_THINITALIC27PT7B_H_
#define _ROBOTOCONDENSED_THINITALIC27PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ThinItalic.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ThinItalic27pt7bBitmaps[] PROGMEM = {
  0x00, 0x11, 0x22, 0x22, 0x22, 0x44, 0x44, 0x44, 0x00, 0x00, 0x80, 0x55,
  0x99, 0x90, 0x01, 0x08, 0x04, 0x20, 0x11, 0x00, 0x84, 0x02, 0x10, 0x7F,
  0xF0, 0x42, 0x01, 0x08, 0x04, 0x40, 0x11, 0x00, 0x84, 0x02, 0x20, 0x08,
  0x83, 0xFF, 0xC1, 0x10, 0x04, 0x40, 0x21, 0x00, 0x88, 0x02, 0x20, 0x00,
  0x01, 0x00, 0x20, 0x1E, 0x04, 0x21, 0x02, 0x40, 0x48, 0x09, 0x01, 0x20,
  0x04, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0x00, 0x14, 0x02, 0x80, 0x50,
  0x12, 0x02, 0x20, 0x83, 0xE0, 0x10, 0x02, 0x00, 0x1C, 0x01, 0x10, 0x10,
  0x84, 0x84, 0x24, 0x22, 0x41, 0x22, 0x12, 0x08, 0x90, 0x39, 0x00, 0x10,
  0x00, 0x9C, 0x09, 0x10, 0x90, 0x88, 0x84, 0x44, 0x24, 0x21, 0x41, 0x08,
  0x08, 0x80, 0x38, 0x07, 0x80, 0x84, 0x10, 0x41, 0x04, 0x10, 0x81, 0x08,
  0x11, 0x00, 0xE0, 0x08, 0x01, 0x40, 0x24, 0x14, 0x21, 0x82, 0x28, 0x12,
  0x80, 0xC8, 0x0C, 0x80, 0xC4, 0x14, 0x3E, 0x20, 0x6A, 0x80, 0x01, 0x02,
  0x04, 0x08, 0x08, 0x10, 0x10, 0x20, 0x20, 0x20, 0x40, 0x40, 0x40, 0x40,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x40, 0x40, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x02, 0x02, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x02, 0x02, 0x02, 0x02, 0x02, 0x04, 0x04, 0x08, 0x08, 0x10,
  0x10, 0x20, 0x40, 0x80, 0x04, 0x01, 0x00, 0x42, 0x23, 0x6B, 0x07, 0x01,
  0x40, 0x90, 0x42, 0x20, 0x80, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x08, 0x01, 0x07, 0xFF, 0x04, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x24, 0xA8, 0xF8, 0x80, 0x00, 0x20, 0x08, 0x01, 0x00, 0x40,
  0x08, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80,
  0x10, 0x04, 0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x20, 0x08, 0x00, 0x07,
  0x81, 0x08, 0x40, 0x90, 0x12, 0x02, 0x40, 0x50, 0x0A, 0x01, 0x40, 0x28,
  0x05, 0x01, 0x40, 0x28, 0x05, 0x00, 0xA0, 0x24, 0x04, 0x41, 0x08, 0x40,
  0xF0, 0x00, 0x0B, 0xE2, 0x10, 0x84, 0x42, 0x10, 0x84, 0x22, 0x10, 0x84,
  0x21, 0x10, 0x07, 0x83, 0x08, 0x40, 0x90, 0x12, 0x02, 0x80, 0x40, 0x10,
  0x02, 0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x03, 0xFE, 0x00, 0x07, 0x83, 0x08, 0x40, 0x90, 0x12, 0x02,
  0x00, 0x40, 0x08, 0x02, 0x00, 0x81, 0xE0, 0x06, 0x00, 0x20, 0x05, 0x00,
  0xA0, 0x14, 0x04, 0x80, 0x88, 0x20, 0xF8, 0x00, 0x00, 0x40, 0x18, 0x03,
  0x00, 0xA0, 0x24, 0x08, 0x81, 0x20, 0x44, 0x10, 0x82, 0x10, 0x82, 0x20,
  0x48, 0x11, 0xFF, 0xC0, 0x40, 0x08, 0x01, 0x00, 0x40, 0x08, 0x00, 0x1F,
  0xE2, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x10, 0x02, 0xF0, 0x61, 0x00,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x20, 0x24, 0x08, 0x81, 0x18, 0x40,
  0xF0, 0x00, 0x01, 0xC1, 0x80, 0x80, 0x40, 0x10, 0x08, 0x02, 0x01, 0x3C,
  0x50, 0x98, 0x14, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x02, 0x40, 0x90,
  0x41, 0xE0, 0x7F, 0xE0, 0x08, 0x01, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40,
  0x10, 0x02, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x20, 0x04, 0x01, 0x00,
  0x20, 0x08, 0x02, 0x00, 0x00, 0x07, 0x81, 0x08, 0x40, 0x90, 0x12, 0x02,
  0x40, 0x48, 0x09, 0x02, 0x10, 0x81, 0xE0, 0xC2, 0x20, 0x28, 0x05, 0x00,
  0xA0, 0x14, 0x02, 0x80, 0x88, 0x20, 0xF0, 0x00, 0x0F, 0x0C, 0x22, 0x05,
  0x01, 0x40, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x28, 0x19, 0x0A, 0x3C,
  0x80, 0x40, 0x10, 0x08, 0x04, 0x02, 0x0E, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0C, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x11,
  0x08, 0x80, 0x00, 0x40, 0x60, 0x60, 0x60, 0x60, 0x20, 0x06, 0x00, 0x40,
  0x0C, 0x00, 0xC0, 0x08, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x60, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x60, 0x60, 0x60,
  0x60, 0x20, 0x00, 0x1E, 0x21, 0x41, 0x41, 0x81, 0x01, 0x01, 0x02, 0x04,
  0x04, 0x08, 0x10, 0x20, 0x20, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x7E,
  0x00, 0x30, 0x20, 0x08, 0x02, 0x02, 0x00, 0x20, 0x80, 0x04, 0x20, 0x00,
  0x48, 0x1E, 0x09, 0x04, 0x21, 0x41, 0x04, 0x28, 0x41, 0x05, 0x08, 0x20,
  0xC2, 0x04, 0x28, 0x40, 0x85, 0x08, 0x20, 0xA1, 0x04, 0x14, 0x20, 0x84,
  0x84, 0x30, 0x90, 0x8A, 0x22, 0x1E, 0x38, 0x40, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x81, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x40,
  0x02, 0x00, 0x28, 0x01, 0x40, 0x12, 0x00, 0x90, 0x08, 0x80, 0x44, 0x04,
  0x10, 0x20, 0x82, 0x04, 0x10, 0x21, 0xFF, 0x08, 0x08, 0x80, 0x44, 0x01,
  0x40, 0x0A, 0x00, 0x60, 0x02, 0x1F, 0xC1, 0x02, 0x10, 0x11, 0x01, 0x20,
  0x12, 0x01, 0x20, 0x12, 0x02, 0x20, 0x43, 0xF8, 0x40, 0x44, 0x02, 0x40,
  0x24, 0x02, 0x40, 0x28, 0x02, 0x80, 0x48, 0x08, 0xFF, 0x00, 0x07, 0xC1,
  0x02, 0x20, 0x12, 0x01, 0x40, 0x14, 0x01, 0x40, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x02, 0x80, 0x48, 0x04, 0x80, 0x84,
  0x10, 0x3E, 0x00, 0x1F, 0xC0, 0x81, 0x04, 0x04, 0x20, 0x12, 0x00, 0x90,
  0x04, 0x80, 0x24, 0x01, 0x20, 0x09, 0x00, 0x50, 0x02, 0x80, 0x24, 0x01,
  0x20, 0x09, 0x00, 0x90, 0x04, 0x80, 0x44, 0x0C, 0x3F, 0x80, 0x1F, 0xF8,
  0x80, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0xFE, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x80, 0x04, 0x00, 0x20, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0xFE, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x00,
  0x07, 0xC0, 0x41, 0x84, 0x04, 0x40, 0x14, 0x00, 0xA0, 0x01, 0x00, 0x08,
  0x00, 0x80, 0x04, 0x00, 0x20, 0xFD, 0x00, 0x28, 0x02, 0x40, 0x12, 0x00,
  0x90, 0x04, 0x80, 0x22, 0x06, 0x07, 0xC0, 0x10, 0x02, 0x20, 0x04, 0x40,
  0x10, 0x80, 0x22, 0x00, 0x44, 0x00, 0x88, 0x01, 0x10, 0x04, 0x20, 0x08,
  0x7F, 0xF1, 0x00, 0x22, 0x00, 0x44, 0x00, 0x88, 0x02, 0x10, 0x04, 0x40,
  0x08, 0x80, 0x11, 0x00, 0x22, 0x00, 0x40, 0x11, 0x11, 0x11, 0x22, 0x22,
  0x22, 0x44, 0x44, 0x44, 0x80, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x04, 0x00,
  0x48, 0x04, 0x80, 0x44, 0x08, 0x40, 0x84, 0x10, 0x3E, 0x00, 0x10, 0x04,
  0x40, 0x21, 0x01, 0x04, 0x08, 0x20, 0x40, 0x82, 0x02, 0x10, 0x08, 0x80,
  0x24, 0x00, 0xF0, 0x02, 0x20, 0x10, 0x80, 0x41, 0x01, 0x04, 0x04, 0x08,
  0x20, 0x20, 0x80, 0x42, 0x00, 0x88, 0x02, 0x00, 0x10, 0x08, 0x04, 0x02,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x01, 0x00, 0x80, 0x40, 0x3F, 0xE0, 0x10, 0x00, 0x46, 0x00, 0x31, 0x80,
  0x0C, 0x60, 0x05, 0x28, 0x01, 0x8A, 0x00, 0xA2, 0x40, 0x28, 0x90, 0x12,
  0x24, 0x08, 0x89, 0x02, 0x24, 0x41, 0x11, 0x08, 0x44, 0x42, 0x21, 0x10,
  0x88, 0x44, 0x24, 0x12, 0x09, 0x04, 0x81, 0x82, 0x20, 0x60, 0x88, 0x10,
  0x20, 0x10, 0x02, 0x30, 0x04, 0x60, 0x10, 0xA0, 0x22, 0x40, 0x44, 0x80,
  0x88, 0x81, 0x11, 0x02, 0x21, 0x08, 0x42, 0x11, 0x04, 0x22, 0x04, 0x44,
  0x08, 0x88, 0x11, 0x10, 0x14, 0x20, 0x28, 0x80, 0x31, 0x00, 0x62, 0x00,
  0x40, 0x03, 0xE0, 0x30, 0x41, 0x00, 0x84, 0x02, 0x20, 0x04, 0x80, 0x14,
  0x00, 0x50, 0x02, 0x40, 0x09, 0x00, 0x24, 0x00, 0x90, 0x02, 0x80, 0x12,
  0x00, 0x48, 0x01, 0x10, 0x08, 0x40, 0x40, 0x82, 0x01, 0xF0, 0x00, 0x1F,
  0xE0, 0x80, 0x84, 0x04, 0x20, 0x12, 0x00, 0x90, 0x04, 0x80, 0x44, 0x02,
  0x20, 0x21, 0x03, 0x0F, 0xE0, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x00, 0x03, 0xE0, 0x60, 0x84, 0x02, 0x20,
  0x12, 0x00, 0x90, 0x05, 0x00, 0x28, 0x01, 0x40, 0x0A, 0x00, 0x50, 0x02,
  0x80, 0x18, 0x01, 0x40, 0x0A, 0x00, 0x48, 0x04, 0x40, 0x41, 0x06, 0x07,
  0xC0, 0x01, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x1F, 0xE0, 0x80, 0x84,
  0x04, 0x20, 0x12, 0x00, 0x90, 0x04, 0x80, 0x24, 0x02, 0x20, 0x22, 0x03,
  0x1F, 0xE0, 0x82, 0x04, 0x08, 0x20, 0x41, 0x01, 0x10, 0x08, 0x80, 0x44,
  0x01, 0x20, 0x08, 0x07, 0xC0, 0x41, 0x84, 0x04, 0x40, 0x22, 0x01, 0x10,
  0x00, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x02,
  0x40, 0x12, 0x00, 0x90, 0x04, 0x80, 0x42, 0x04, 0x0F, 0xC0, 0xFF, 0xF0,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x00, 0x20, 0x09, 0x00, 0x48, 0x02, 0x80, 0x14, 0x01, 0x20,
  0x09, 0x00, 0x48, 0x02, 0x40, 0x14, 0x01, 0x20, 0x09, 0x00, 0x48, 0x02,
  0x40, 0x12, 0x01, 0x10, 0x08, 0x80, 0x82, 0x08, 0x0F, 0x80, 0x80, 0x0C,
  0x00, 0x90, 0x04, 0x80, 0x44, 0x02, 0x20, 0x11, 0x01, 0x08, 0x08, 0x20,
  0x81, 0x04, 0x08, 0x40, 0x42, 0x02, 0x20, 0x11, 0x00, 0x90, 0x02, 0x80,
  0x18, 0x00, 0xC0, 0x04, 0x00, 0x80, 0x80, 0x20, 0x30, 0x18, 0x0C, 0x06,
  0x05, 0x02, 0x81, 0x40, 0xA0, 0x90, 0x28, 0x24, 0x12, 0x11, 0x04, 0x84,
  0x42, 0x21, 0x10, 0x88, 0x82, 0x22, 0x20, 0x90, 0x90, 0x24, 0x24, 0x0A,
  0x09, 0x02, 0x81, 0x80, 0xA0, 0x60, 0x30, 0x10, 0x0C, 0x04, 0x02, 0x00,
  0x10, 0x04, 0x20, 0x10, 0x20, 0x20, 0x40, 0x80, 0x42, 0x00, 0x84, 0x01,
  0x10, 0x01, 0x40, 0x03, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x24, 0x00, 0x88,
  0x01, 0x08, 0x04, 0x10, 0x10, 0x20, 0x40, 0x20, 0x80, 0x42, 0x00, 0x40,
  0x80, 0x18, 0x02, 0x80, 0x44, 0x04, 0x40, 0x84, 0x10, 0x21, 0x02, 0x20,
  0x24, 0x01, 0x40, 0x18, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x00, 0x0F, 0xFC, 0x00, 0x20, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00,
  0x0F, 0xFE, 0x00, 0x0E, 0x10, 0x20, 0x40, 0x82, 0x04, 0x08, 0x10, 0x20,
  0x41, 0x02, 0x04, 0x08, 0x10, 0x20, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x81, 0xE0, 0x88, 0x88, 0x88, 0x44, 0x44, 0x44, 0x42, 0x22, 0x22, 0x22,
  0x10, 0x0E, 0x04, 0x08, 0x10, 0x20, 0x40, 0x82, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x82, 0x04, 0x08, 0x10, 0x20, 0x41, 0x02, 0x04, 0x08, 0x11, 0xE0,
  0x08, 0x30, 0x50, 0xA2, 0x44, 0x91, 0x22, 0x83, 0x04, 0xFF, 0x80, 0x91,
  0x20, 0x07, 0x83, 0x08, 0x80, 0x90, 0x10, 0x02, 0x00, 0x80, 0x10, 0xFE,
  0x20, 0x48, 0x09, 0x01, 0x40, 0x48, 0x08, 0x87, 0x0F, 0x20, 0x10, 0x04,
  0x01, 0x00, 0x80, 0x20, 0x08, 0x02, 0xF8, 0xC1, 0x20, 0x50, 0x14, 0x05,
  0x01, 0x40, 0x50, 0x14, 0x06, 0x01, 0x80, 0xA0, 0x28, 0x0B, 0x04, 0xBE,
  0x00, 0x0F, 0x0C, 0x22, 0x05, 0x01, 0x40, 0x60, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x0A, 0x02, 0x81, 0x10, 0x83, 0xC0, 0x00, 0x10, 0x01, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x02, 0x0F, 0x21, 0x0A, 0x20, 0x44, 0x04, 0x40,
  0x44, 0x04, 0x80, 0x48, 0x04, 0x80, 0x88, 0x08, 0x80, 0x88, 0x08, 0x81,
  0x84, 0x28, 0x3D, 0x00, 0x0F, 0x04, 0x22, 0x05, 0x01, 0x40, 0x60, 0x1F,
  0xFE, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x10, 0x43, 0xE0, 0x0F,
  0x10, 0x10, 0x20, 0x20, 0x20, 0xFC, 0x20, 0x20, 0x40, 0x40, 0x40, 0x40,
  0x40, 0x40, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x07, 0x90, 0x85, 0x10,
  0x22, 0x02, 0x20, 0x22, 0x02, 0x40, 0x24, 0x02, 0x40, 0x44, 0x04, 0x40,
  0x44, 0x04, 0x40, 0xC2, 0x14, 0x1E, 0x80, 0x08, 0x00, 0x80, 0x10, 0x43,
  0x03, 0xC0, 0x10, 0x04, 0x01, 0x00, 0x80, 0x20, 0x08, 0x02, 0x78, 0xA1,
  0x30, 0x48, 0x14, 0x05, 0x01, 0x40, 0x50, 0x14, 0x06, 0x02, 0x80, 0xA0,
  0x28, 0x0A, 0x02, 0x80, 0x80, 0x10, 0x00, 0x02, 0x22, 0x24, 0x44, 0x44,
  0x48, 0x88, 0x88, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x08, 0x04, 0x02,
  0x01, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x80, 0x40, 0x20, 0x20, 0xE0, 0x00, 0x10, 0x04, 0x01, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x04, 0x82, 0x21, 0x10, 0x84, 0x41, 0x20, 0x50,
  0x1A, 0x04, 0x82, 0x10, 0x84, 0x20, 0x88, 0x22, 0x04, 0x81, 0x00, 0x11,
  0x11, 0x22, 0x22, 0x22, 0x44, 0x44, 0x44, 0x88, 0x88, 0x80, 0x27, 0x87,
  0x8A, 0x16, 0x15, 0x06, 0x05, 0x81, 0x81, 0x40, 0x40, 0x50, 0x10, 0x14,
  0x04, 0x05, 0x01, 0x02, 0x40, 0x80, 0xA0, 0x20, 0x28, 0x08, 0x0A, 0x02,
  0x02, 0x80, 0x80, 0xA0, 0x20, 0x28, 0x10, 0x10, 0x27, 0x8A, 0x13, 0x04,
  0x81, 0x40, 0x50, 0x14, 0x05, 0x01, 0x40, 0x60, 0x28, 0x0A, 0x02, 0x80,
  0xA0, 0x28, 0x08, 0x0F, 0x84, 0x12, 0x05, 0x01, 0x40, 0x50, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x0A, 0x02, 0x81, 0x10, 0xC3, 0xC0, 0x17, 0xC3,
  0x04, 0x40, 0x90, 0x12, 0x02, 0x40, 0x48, 0x09, 0x01, 0x40, 0x28, 0x05,
  0x01, 0x20, 0x24, 0x04, 0xC1, 0x17, 0x84, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x00, 0x0F, 0x22, 0x14, 0x81, 0x20, 0x24, 0x04, 0x80, 0xA0, 0x14,
  0x02, 0x80, 0x90, 0x12, 0x02, 0x40, 0x48, 0x18, 0x85, 0x0F, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x2E, 0x30, 0x20, 0x20, 0x40, 0x40,
  0x40, 0x40, 0x40, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x0F, 0x84, 0x12,
  0x04, 0x80, 0x20, 0x04, 0x00, 0x80, 0x18, 0x01, 0x00, 0x20, 0x08, 0x02,
  0x40, 0x90, 0x43, 0xE0, 0x21, 0x09, 0xF2, 0x21, 0x08, 0x42, 0x11, 0x08,
  0x42, 0x10, 0x87, 0x00, 0x20, 0x24, 0x04, 0x81, 0x20, 0x24, 0x04, 0x80,
  0x90, 0x12, 0x02, 0x40, 0x90, 0x12, 0x02, 0x40, 0x48, 0x18, 0x85, 0x0F,
  0x40, 0x80, 0xC0, 0x60, 0x50, 0x28, 0x14, 0x11, 0x08, 0x88, 0x44, 0x24,
  0x12, 0x0A, 0x05, 0x01, 0x00, 0x80, 0x81, 0x03, 0x02, 0x06, 0x0C, 0x14,
  0x18, 0x28, 0x48, 0x50, 0x91, 0x21, 0x22, 0x24, 0x48, 0x48, 0x90, 0xA1,
  0x21, 0x42, 0x83, 0x05, 0x06, 0x0C, 0x08, 0x08, 0x10, 0x10, 0x00, 0x20,
  0x22, 0x08, 0x42, 0x08, 0x40, 0x90, 0x14, 0x01, 0x00, 0x20, 0x0C, 0x02,
  0x40, 0x48, 0x10, 0x84, 0x10, 0x81, 0x20, 0x20, 0x10, 0x00, 0x80, 0x84,
  0x04, 0x20, 0x41, 0x02, 0x08, 0x20, 0x21, 0x01, 0x10, 0x08, 0x80, 0x48,
  0x02, 0x40, 0x14, 0x00, 0x60, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00,
  0x80, 0x04, 0x01, 0xC0, 0x00, 0x1F, 0xE0, 0x08, 0x02, 0x00, 0x40, 0x10,
  0x04, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x3F, 0xE0, 0x01, 0x02, 0x04, 0x08, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10,
  0x10, 0x20, 0x20, 0xC0, 0x40, 0x20, 0x20, 0x20, 0x20, 0x20, 0x40, 0x40,
  0x40, 0x40, 0x20, 0x20, 0x10, 0x11, 0x12, 0x22, 0x22, 0x24, 0x44, 0x44,
  0x44, 0x88, 0x88, 0x88, 0x80, 0x08, 0x02, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x0C, 0x08, 0x08, 0x04,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x20, 0x10, 0x10, 0x30, 0x00,
  0x38, 0x14, 0x41, 0x82, 0x28, 0x1C,
};

const GFXglyph RobotoCondensed_ThinItalic27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 4, 19, 5, 1, -19 },
  { 11, 4, 5, 7, 3, -20 },
  { 14, 14, 19, 13, 0, -19 },
  { 48, 11, 23, 13, 1, -21 },
  { 80, 13, 19, 17, 2, -19 },
  { 111, 12, 19, 14, 1, -19 },
  { 140, 2, 5, 4, 3, -20 },
  { 142, 8, 27, 7, 1, -21 },
  { 169, 8, 27, 7, -2, -21 },
  { 196, 10, 10, 11, 2, -19 },
  { 209, 11, 15, 13, 1, -17 },
  { 230, 3, 5, 5, -1, -2 },
  { 232, 5, 1, 7, 1, -9 },
  { 233, 1, 1, 6, 1, -1 },
  { 234, 11, 21, 9, -1, -19 },
  { 263, 11, 19, 13, 1, -19 },
  { 290, 5, 19, 13, 4, -19 },
  { 302, 11, 19, 13, 1, -19 },
  { 329, 11, 19, 13, 1, -19 },
  { 356, 11, 19, 13, 1, -19 },
  { 383, 11, 19, 13, 2, -19 },
  { 410, 10, 19, 13, 1, -19 },
  { 434, 11, 19, 13, 2, -19 },
  { 461, 11, 19, 13, 1, -19 },
  { 488, 10, 19, 13, 2, -19 },
  { 512, 4, 14, 5, 0, -14 },
  { 519, 5, 17, 5, -1, -14 },
  { 530, 10, 11, 12, 1, -14 },
  { 544, 11, 7, 13, 1, -12 },
  { 554, 10, 10, 12, 1, -14 },
  { 567, 8, 19, 10, 2, -19 },
  { 586, 19, 25, 21, 1, -19 },
  { 646, 13, 19, 14, -1, -19 },
  { 677, 12, 19, 14, 1, -19 },
  { 706, 12, 19, 15, 2, -19 },
  { 735, 13, 19, 15, 1, -19 },
  { 766, 13, 19, 13, 1, -19 },
  { 797, 13, 19, 13, 1, -19 },
  { 828, 13, 19, 16, 2, -19 },
  { 859, 15, 19, 16, 1, -19 },
  { 895, 4, 19, 6, 1, -19 },
  { 905, 12, 19, 13, 0, -19 },
  { 934, 14, 19, 15, 1, -19 },
  { 968, 9, 19, 12, 1, -19 },
  { 990, 18, 19, 20, 1, -19 },
  { 1033, 15, 19, 16, 1, -19 },
  { 1069, 14, 19, 15, 1, -19 },
  { 1103, 13, 19, 14, 1, -19 },
  { 1134, 13, 23, 15, 1, -19 },
  { 1172, 13, 19, 15, 1, -19 },
  { 1203, 13, 19, 14, 1, -19 },
  { 1234, 12, 19, 14, 3, -19 },
  { 1263, 13, 19, 15, 2, -19 },
  { 1294, 13, 19, 14, 2, -19 },
  { 1325, 18, 19, 21, 3, -19 },
  { 1368, 15, 19, 14, 0, -19 },
  { 1404, 12, 19, 14, 3, -19 },
  { 1433, 14, 19, 14, 0, -19 },
  { 1467, 7, 26, 5, 0, -22 },
  { 1490, 4, 21, 9, 3, -19 },
  { 1501, 7, 26, 5, -2, -22 },
  { 1524, 7, 10, 10, 2, -19 },
  { 1533, 9, 1, 10, -1, 0 },
  { 1535, 3, 4, 7, 4, -21 },
  { 1537, 11, 15, 12, 0, -15 },
  { 1558, 10, 21, 13, 1, -21 },
  { 1585, 10, 15, 12, 1, -15 },
  { 1604, 12, 21, 13, 1, -21 },
  { 1636, 10, 15, 12, 1, -15 },
  { 1655, 8, 21, 8, 2, -21 },
  { 1676, 12, 20, 13, 0, -15 },
  { 1706, 10, 21, 13, 1, -21 },
  { 1733, 4, 20, 5, 1, -20 },
  { 1743, 9, 25, 5, -4, -20 },
  { 1772, 10, 21, 11, 1, -21 },
  { 1799, 4, 21, 5, 1, -21 },
  { 1810, 18, 15, 20, 1, -15 },
  { 1844, 10, 15, 13, 1, -15 },
  { 1863, 10, 15, 13, 1, -15 },
  { 1882, 11, 20, 13, 0, -15 },
  { 1910, 11, 20, 13, 1, -15 },
  { 1938, 8, 15, 8, 1, -15 },
  { 1953, 10, 15, 12, 0, -15 },
  { 1972, 5, 18, 8, 2, -18 },
  { 1984, 11, 15, 13, 1, -15 },
  { 2005, 9, 15, 11, 2, -15 },
  { 2022, 15, 15, 17, 2, -15 },
  { 2051, 11, 15, 11, 0, -15 },
  { 2072, 13, 20, 11, -1, -15 },
  { 2105, 11, 15, 11, 0, -15 },
  { 2126, 8, 27, 8, 1, -21 },
  { 2153, 4, 23, 5, 1, -19 },
  { 2165, 9, 27, 8, -2, -21 },
  { 2196, 12, 4, 16, 2, -10 },
};

const GFXfont RobotoCondensed_ThinItalic27pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ThinItalic27pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ThinItalic27pt7bGlyphs,
  0x20, 0x7E, 32
};

#endif // _ROBOTOCONDENSED_THINITALIC27PT7B_H_
