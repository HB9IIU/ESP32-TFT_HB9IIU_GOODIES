#ifndef _ROBOTOCONDENSED_THINITALIC39PT7B_H_
#define _ROBOTOCONDENSED_THINITALIC39PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ThinItalic.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ThinItalic39pt7bBitmaps[] PROGMEM = {
  0x00, 0x04, 0x30, 0x82, 0x08, 0x20, 0x84, 0x10, 0x41, 0x04, 0x10, 0x82,
  0x08, 0x20, 0x82, 0x10, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x20, 0x24, 0xC9,
  0x12, 0x24, 0x49, 0x92, 0x44, 0x00, 0x20, 0x40, 0x04, 0x10, 0x01, 0x02,
  0x00, 0x20, 0x40, 0x04, 0x10, 0x01, 0x02, 0x00, 0x20, 0x40, 0x04, 0x10,
  0x1F, 0xFF, 0xE0, 0x20, 0x40, 0x04, 0x10, 0x00, 0x82, 0x00, 0x20, 0x40,
  0x04, 0x18, 0x00, 0x82, 0x00, 0x20, 0x40, 0x04, 0x08, 0x00, 0x82, 0x00,
  0x20, 0x40, 0x7F, 0xFF, 0x80, 0x82, 0x00, 0x20, 0x40, 0x04, 0x08, 0x00,
  0x82, 0x00, 0x20, 0x40, 0x04, 0x08, 0x00, 0x82, 0x00, 0x20, 0x40, 0x00,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x0F, 0x80, 0x08,
  0x30, 0x18, 0x0C, 0x08, 0x02, 0x08, 0x01, 0x04, 0x00, 0x82, 0x00, 0x42,
  0x00, 0x21, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x40, 0x04, 0x20, 0x02, 0x10, 0x01, 0x08, 0x01, 0x84,
  0x00, 0x81, 0x00, 0x80, 0xC1, 0x80, 0x1F, 0x80, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x1E, 0x00, 0x08, 0x40, 0x04, 0x10, 0x01,
  0x02, 0x00, 0x80, 0x81, 0x20, 0x20, 0x88, 0x10, 0x62, 0x04, 0x10, 0x81,
  0x08, 0x20, 0x44, 0x08, 0x21, 0x03, 0x10, 0x80, 0x78, 0x40, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x3C, 0x03, 0x18, 0x80, 0x88, 0x20, 0x42, 0x04,
  0x21, 0x01, 0x08, 0x40, 0x44, 0x10, 0x12, 0x04, 0x09, 0x81, 0x02, 0x40,
  0x40, 0x80, 0x10, 0x40, 0x02, 0x20, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xC6,
  0x00, 0xC1, 0x00, 0x40, 0x80, 0x40, 0x40, 0x20, 0x20, 0x10, 0x10, 0x08,
  0x10, 0x04, 0x18, 0x02, 0x18, 0x00, 0x98, 0x00, 0x50, 0x00, 0x10, 0x00,
  0x38, 0x00, 0x32, 0x00, 0x31, 0x00, 0x10, 0x40, 0x90, 0x20, 0x50, 0x08,
  0x28, 0x06, 0x24, 0x01, 0x14, 0x00, 0x52, 0x00, 0x29, 0x00, 0x08, 0x40,
  0x0C, 0x30, 0x09, 0x0C, 0x18, 0xC3, 0xF0, 0x20, 0x49, 0x25, 0xA4, 0x00,
  0x40, 0x30, 0x08, 0x04, 0x02, 0x01, 0x80, 0x40, 0x20, 0x08, 0x04, 0x01,
  0x00, 0x40, 0x20, 0x08, 0x02, 0x01, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x10, 0x04, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00,
  0x40, 0x02, 0x00, 0x80, 0x10, 0x02, 0x00, 0x80, 0x20, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x00, 0x80, 0x40, 0x10, 0x04,
  0x03, 0x00, 0x80, 0x20, 0x10, 0x04, 0x02, 0x00, 0x80, 0x40, 0x20, 0x08,
  0x04, 0x02, 0x00, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x08, 0x20, 0xCE, 0x4E, 0x03, 0xE0, 0x03, 0x00, 0x0D, 0x00, 0x12, 0x00,
  0x42, 0x01, 0x06, 0x04, 0x04, 0x18, 0x0C, 0x00, 0x00, 0x40, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x03, 0xFF, 0xF8, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x11, 0x32, 0x26, 0x48, 0xFF, 0xF0, 0x00, 0x02, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x40, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80,
  0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x00, 0x01, 0xF0, 0x06, 0x18, 0x10, 0x10, 0x40, 0x11, 0x80,
  0x22, 0x00, 0x4C, 0x00, 0x90, 0x01, 0x20, 0x02, 0x40, 0x05, 0x00, 0x0A,
  0x00, 0x14, 0x00, 0x28, 0x00, 0xD0, 0x01, 0x40, 0x02, 0x80, 0x05, 0x00,
  0x0A, 0x00, 0x14, 0x00, 0x48, 0x00, 0x90, 0x01, 0x20, 0x04, 0x40, 0x08,
  0x40, 0x20, 0x80, 0x80, 0x82, 0x00, 0xF8, 0x00, 0x01, 0x83, 0x8E, 0x58,
  0x20, 0x10, 0x08, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x10,
  0x08, 0x04, 0x02, 0x00, 0x00, 0xF8, 0x03, 0x04, 0x04, 0x02, 0x0C, 0x02,
  0x08, 0x01, 0x10, 0x01, 0x10, 0x01, 0x10, 0x01, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x30, 0x00, 0x60, 0x00, 0x40, 0x00, 0xFF, 0xFC,
  0x00, 0xF8, 0x03, 0x06, 0x06, 0x02, 0x04, 0x01, 0x08, 0x01, 0x18, 0x01,
  0x10, 0x01, 0x10, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x03, 0xE0, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06,
  0x00, 0x02, 0x00, 0x02, 0x80, 0x04, 0x80, 0x04, 0x80, 0x04, 0x40, 0x08,
  0x40, 0x08, 0x60, 0x10, 0x30, 0x60, 0x0F, 0x80, 0x00, 0x02, 0x00, 0x06,
  0x00, 0x0A, 0x00, 0x0A, 0x00, 0x12, 0x00, 0x24, 0x00, 0x64, 0x00, 0x44,
  0x00, 0x84, 0x01, 0x04, 0x01, 0x04, 0x02, 0x08, 0x04, 0x08, 0x0C, 0x08,
  0x08, 0x08, 0x10, 0x08, 0x20, 0x08, 0x60, 0x10, 0x40, 0x10, 0xFF, 0xFF,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x20, 0x07, 0xFF, 0x82, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0xF8, 0x03, 0x82, 0x01, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x88, 0x00,
  0x44, 0x00, 0x41, 0x00, 0x20, 0x80, 0x10, 0x40, 0x10, 0x10, 0x10, 0x0C,
  0x18, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x03, 0x00, 0x10, 0x01, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0x02, 0x3E, 0x13,
  0x04, 0x50, 0x09, 0x80, 0x34, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x28, 0x00, 0xA0, 0x04, 0x40, 0x11,
  0x80, 0x83, 0x0C, 0x07, 0xE0, 0x7F, 0xFF, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80, 0x01, 0x00, 0x01,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x00, 0xF8, 0x01, 0x83, 0x01, 0x80, 0xC0, 0x80, 0x20, 0x80, 0x10,
  0x40, 0x04, 0x40, 0x02, 0x20, 0x02, 0x10, 0x01, 0x08, 0x00, 0x86, 0x00,
  0x81, 0x00, 0x80, 0x41, 0x80, 0x1F, 0x00, 0x30, 0x60, 0x20, 0x18, 0x20,
  0x04, 0x20, 0x01, 0x10, 0x00, 0x90, 0x00, 0x48, 0x00, 0x24, 0x00, 0x32,
  0x00, 0x11, 0x00, 0x08, 0x40, 0x08, 0x20, 0x08, 0x0C, 0x18, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x30, 0xC1, 0x80, 0x8C, 0x03, 0x20, 0x05, 0x00, 0x14,
  0x00, 0x50, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0E,
  0x00, 0x28, 0x01, 0xB0, 0x0E, 0x40, 0x68, 0x83, 0x21, 0xF1, 0x00, 0x04,
  0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0xE0,
  0x3C, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x06, 0x30, 0x06, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0xC1, 0x02, 0x04,
  0x10, 0x60, 0x80, 0x00, 0x04, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x20, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x10,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x20, 0x00, 0x00, 0x07, 0xC1, 0x86, 0x30, 0x22, 0x01, 0x40, 0x14,
  0x01, 0x40, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x0C, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x06, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0x80, 0xC0, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x00, 0x40,
  0x08, 0x00, 0x04, 0x02, 0x00, 0x00, 0x80, 0x80, 0x00, 0x08, 0x20, 0x00,
  0x01, 0x0C, 0x03, 0xC0, 0x21, 0x00, 0x86, 0x04, 0x60, 0x20, 0x40, 0x88,
  0x08, 0x08, 0x11, 0x02, 0x01, 0x02, 0x40, 0x40, 0x40, 0x48, 0x10, 0x08,
  0x09, 0x02, 0x01, 0x01, 0x40, 0x80, 0x20, 0x28, 0x10, 0x08, 0x05, 0x02,
  0x01, 0x01, 0x20, 0x40, 0x20, 0x24, 0x10, 0x0C, 0x05, 0x02, 0x01, 0x01,
  0x20, 0x40, 0x60, 0x24, 0x08, 0x0C, 0x08, 0x81, 0x02, 0x81, 0x10, 0x10,
  0x88, 0xC1, 0x01, 0xE0, 0xE0, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x02, 0x80, 0x00, 0xA0, 0x00, 0x28, 0x00, 0x12, 0x00,
  0x04, 0x80, 0x02, 0x20, 0x00, 0x88, 0x00, 0x41, 0x00, 0x10, 0x40, 0x08,
  0x10, 0x02, 0x04, 0x01, 0x01, 0x00, 0x40, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x04, 0x00, 0x81, 0x00, 0x20, 0x80, 0x08, 0x3F, 0xFE, 0x18, 0x00, 0x84,
  0x00, 0x23, 0x00, 0x08, 0x80, 0x03, 0x20, 0x00, 0x50, 0x00, 0x14, 0x00,
  0x06, 0x00, 0x01, 0x07, 0xFC, 0x01, 0x00, 0xC0, 0x40, 0x08, 0x10, 0x02,
  0x0C, 0x00, 0x42, 0x00, 0x10, 0x80, 0x04, 0x20, 0x01, 0x08, 0x00, 0x82,
  0x00, 0x21, 0x00, 0x10, 0x40, 0x0C, 0x10, 0x0C, 0x07, 0xFE, 0x01, 0x00,
  0x60, 0x40, 0x08, 0x20, 0x01, 0x08, 0x00, 0x42, 0x00, 0x10, 0x80, 0x04,
  0x20, 0x01, 0x08, 0x00, 0x44, 0x00, 0x11, 0x00, 0x08, 0x40, 0x06, 0x10,
  0x03, 0x04, 0x01, 0x81, 0xFF, 0x80, 0x00, 0x7E, 0x00, 0x30, 0x60, 0x18,
  0x02, 0x02, 0x00, 0x60, 0x80, 0x04, 0x20, 0x00, 0x84, 0x00, 0x11, 0x80,
  0x02, 0x20, 0x00, 0x44, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x88, 0x00, 0x11, 0x80, 0x02, 0x10, 0x00,
  0x82, 0x00, 0x10, 0x40, 0x04, 0x04, 0x01, 0x00, 0x40, 0xC0, 0x07, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x80, 0x60, 0x10, 0x02, 0x02, 0x00, 0x20, 0xC0,
  0x04, 0x10, 0x00, 0x42, 0x00, 0x08, 0x40, 0x01, 0x08, 0x00, 0x21, 0x00,
  0x04, 0x40, 0x00, 0x88, 0x00, 0x11, 0x00, 0x02, 0x20, 0x00, 0x44, 0x00,
  0x10, 0x80, 0x02, 0x20, 0x00, 0x44, 0x00, 0x08, 0x80, 0x01, 0x10, 0x00,
  0x42, 0x00, 0x08, 0x40, 0x03, 0x10, 0x00, 0x42, 0x00, 0x10, 0x40, 0x06,
  0x08, 0x01, 0x81, 0x00, 0xC0, 0x3F, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x80,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x3F, 0xFC, 0x04, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x3F, 0xFC,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0xC0, 0xC0, 0x40, 0x18, 0x20, 0x02, 0x18, 0x00, 0x44, 0x00, 0x12,
  0x00, 0x04, 0x80, 0x01, 0x20, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x08, 0x00, 0x02, 0x01, 0xFE, 0x80, 0x00,
  0xA0, 0x00, 0x48, 0x00, 0x12, 0x00, 0x04, 0x80, 0x01, 0x20, 0x00, 0x48,
  0x00, 0x32, 0x00, 0x08, 0x40, 0x02, 0x18, 0x03, 0x03, 0x03, 0x80, 0x3F,
  0x00, 0x04, 0x00, 0x04, 0x10, 0x00, 0x20, 0x40, 0x00, 0x81, 0x00, 0x02,
  0x0C, 0x00, 0x08, 0x20, 0x00, 0x20, 0x80, 0x01, 0x02, 0x00, 0x04, 0x08,
  0x00, 0x10, 0x20, 0x00, 0x41, 0x00, 0x01, 0x04, 0x00, 0x04, 0x10, 0x00,
  0x20, 0x7F, 0xFF, 0x81, 0x00, 0x02, 0x04, 0x00, 0x08, 0x20, 0x00, 0x20,
  0x80, 0x00, 0x82, 0x00, 0x04, 0x08, 0x00, 0x10, 0x20, 0x00, 0x40, 0x80,
  0x01, 0x04, 0x00, 0x04, 0x10, 0x00, 0x10, 0x40, 0x00, 0x81, 0x00, 0x02,
  0x04, 0x00, 0x08, 0x10, 0x00, 0x20, 0x04, 0x10, 0x82, 0x08, 0x20, 0x82,
  0x10, 0x41, 0x04, 0x10, 0x42, 0x08, 0x20, 0x82, 0x18, 0x41, 0x04, 0x10,
  0x43, 0x08, 0x20, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x08, 0x00, 0x84,
  0x00, 0x42, 0x00, 0x41, 0x00, 0x20, 0x80, 0x20, 0x20, 0x30, 0x18, 0x30,
  0x03, 0xE0, 0x00, 0x04, 0x00, 0x10, 0x20, 0x01, 0x01, 0x00, 0x10, 0x08,
  0x01, 0x00, 0xC0, 0x10, 0x04, 0x01, 0x00, 0x20, 0x10, 0x01, 0x01, 0x00,
  0x08, 0x10, 0x00, 0x41, 0x00, 0x04, 0x10, 0x00, 0x21, 0x00, 0x01, 0x10,
  0x00, 0x09, 0x40, 0x00, 0x52, 0x00, 0x03, 0x08, 0x00, 0x30, 0x60, 0x01,
  0x01, 0x00, 0x08, 0x0C, 0x00, 0x40, 0x20, 0x02, 0x01, 0x80, 0x10, 0x04,
  0x01, 0x00, 0x10, 0x08, 0x00, 0x80, 0x40, 0x02, 0x02, 0x00, 0x10, 0x10,
  0x00, 0x40, 0x80, 0x02, 0x00, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0xC0, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x06, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0xFF, 0xF0, 0x06, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x18, 0x18, 0x00,
  0x03, 0x03, 0x00, 0x00, 0xA0, 0xA0, 0x00, 0x14, 0x12, 0x00, 0x04, 0x82,
  0x40, 0x00, 0x90, 0x48, 0x00, 0x24, 0x09, 0x00, 0x04, 0x81, 0x20, 0x01,
  0x10, 0x42, 0x00, 0x22, 0x08, 0x40, 0x08, 0x41, 0x08, 0x01, 0x18, 0x21,
  0x00, 0x42, 0x04, 0x20, 0x08, 0x40, 0x84, 0x02, 0x08, 0x20, 0x40, 0xC1,
  0x04, 0x08, 0x10, 0x20, 0x81, 0x06, 0x0C, 0x10, 0x20, 0x81, 0x02, 0x04,
  0x20, 0x20, 0x40, 0x44, 0x04, 0x10, 0x09, 0x00, 0x82, 0x01, 0x20, 0x10,
  0x40, 0x28, 0x04, 0x08, 0x05, 0x00, 0x81, 0x00, 0x40, 0x10, 0x20, 0x08,
  0x02, 0x00, 0x04, 0x00, 0x04, 0x18, 0x00, 0x30, 0x60, 0x00, 0x81, 0x40,
  0x02, 0x0D, 0x00, 0x08, 0x24, 0x00, 0x20, 0x88, 0x00, 0x82, 0x20, 0x06,
  0x08, 0x40, 0x10, 0x21, 0x00, 0x41, 0x84, 0x01, 0x04, 0x08, 0x04, 0x10,
  0x20, 0x10, 0x40, 0x80, 0xC1, 0x01, 0x02, 0x04, 0x04, 0x08, 0x30, 0x08,
  0x20, 0x80, 0x20, 0x82, 0x00, 0x82, 0x08, 0x01, 0x18, 0x20, 0x04, 0x40,
  0x80, 0x09, 0x04, 0x00, 0x24, 0x10, 0x00, 0x90, 0x40, 0x01, 0x41, 0x00,
  0x06, 0x04, 0x00, 0x18, 0x10, 0x00, 0x20, 0x00, 0x7E, 0x00, 0x30, 0x60,
  0x18, 0x02, 0x02, 0x00, 0x20, 0x80, 0x04, 0x20, 0x00, 0x44, 0x00, 0x09,
  0x00, 0x01, 0x20, 0x00, 0x24, 0x00, 0x04, 0x80, 0x00, 0xA0, 0x00, 0x24,
  0x00, 0x04, 0x80, 0x00, 0x90, 0x00, 0x12, 0x00, 0x02, 0x40, 0x00, 0x50,
  0x00, 0x12, 0x00, 0x02, 0x40, 0x00, 0x48, 0x00, 0x19, 0x00, 0x02, 0x20,
  0x00, 0x42, 0x00, 0x10, 0x40, 0x04, 0x04, 0x01, 0x00, 0x60, 0xC0, 0x07,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x80, 0x30, 0x10, 0x03, 0x02, 0x00, 0x20,
  0xC0, 0x04, 0x10, 0x00, 0x42, 0x00, 0x08, 0x40, 0x01, 0x08, 0x00, 0x41,
  0x00, 0x08, 0x40, 0x01, 0x08, 0x00, 0x41, 0x00, 0x18, 0x20, 0x06, 0x04,
  0x01, 0x80, 0xFF, 0xC0, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x30, 0x20, 0x18, 0x02, 0x02, 0x00, 0x20, 0x80, 0x04, 0x20, 0x00, 0x44,
  0x00, 0x09, 0x00, 0x01, 0x20, 0x00, 0x24, 0x00, 0x04, 0x80, 0x00, 0xA0,
  0x00, 0x24, 0x00, 0x04, 0x80, 0x00, 0x90, 0x00, 0x12, 0x00, 0x02, 0x40,
  0x00, 0x50, 0x00, 0x12, 0x00, 0x02, 0x40, 0x00, 0x48, 0x00, 0x19, 0x00,
  0x02, 0x20, 0x00, 0x42, 0x00, 0x10, 0x40, 0x04, 0x04, 0x01, 0x00, 0x40,
  0xC0, 0x07, 0xF0, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x07, 0xFE, 0x00, 0x80, 0x30, 0x10, 0x03, 0x02,
  0x00, 0x20, 0x80, 0x02, 0x10, 0x00, 0x42, 0x00, 0x08, 0x40, 0x01, 0x08,
  0x00, 0x21, 0x00, 0x08, 0x40, 0x01, 0x08, 0x00, 0x41, 0x00, 0x08, 0x20,
  0x02, 0x04, 0x01, 0x80, 0xFF, 0xC0, 0x20, 0x10, 0x04, 0x01, 0x00, 0x80,
  0x20, 0x10, 0x04, 0x02, 0x00, 0x40, 0x40, 0x08, 0x10, 0x01, 0x02, 0x00,
  0x10, 0x40, 0x02, 0x08, 0x00, 0x41, 0x00, 0x04, 0x40, 0x00, 0x80, 0x00,
  0x7E, 0x00, 0x30, 0x30, 0x18, 0x02, 0x06, 0x00, 0x20, 0x80, 0x04, 0x20,
  0x00, 0x84, 0x00, 0x10, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x60, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x88, 0x00,
  0x11, 0x00, 0x02, 0x20, 0x00, 0x44, 0x00, 0x10, 0x40, 0x06, 0x0C, 0x01,
  0x80, 0xC0, 0xE0, 0x07, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x10,
  0x80, 0x02, 0x08, 0x00, 0x21, 0x00, 0x02, 0x10, 0x00, 0x21, 0x00, 0x02,
  0x10, 0x00, 0x21, 0x00, 0x04, 0x10, 0x00, 0x42, 0x00, 0x04, 0x20, 0x00,
  0x42, 0x00, 0x04, 0x20, 0x00, 0x42, 0x00, 0x08, 0x20, 0x00, 0x84, 0x00,
  0x08, 0x40, 0x00, 0x84, 0x00, 0x08, 0x40, 0x01, 0x04, 0x00, 0x10, 0x40,
  0x01, 0x04, 0x00, 0x10, 0x40, 0x02, 0x04, 0x00, 0x20, 0x40, 0x04, 0x02,
  0x00, 0x80, 0x10, 0x30, 0x00, 0xFC, 0x00, 0xC0, 0x00, 0x48, 0x00, 0x09,
  0x00, 0x03, 0x20, 0x00, 0x44, 0x00, 0x18, 0x80, 0x02, 0x10, 0x00, 0x41,
  0x00, 0x10, 0x20, 0x02, 0x04, 0x00, 0x80, 0x80, 0x10, 0x10, 0x04, 0x02,
  0x00, 0x80, 0x40, 0x20, 0x04, 0x04, 0x00, 0x81, 0x80, 0x10, 0x20, 0x02,
  0x04, 0x00, 0x41, 0x00, 0x08, 0x20, 0x00, 0x88, 0x00, 0x11, 0x00, 0x02,
  0x40, 0x00, 0x48, 0x00, 0x0A, 0x00, 0x01, 0x40, 0x00, 0x30, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x04, 0x00, 0x30, 0x01, 0x80, 0x0A, 0x00, 0x30, 0x01,
  0x40, 0x0A, 0x00, 0x28, 0x01, 0x40, 0x09, 0x00, 0x24, 0x01, 0x20, 0x08,
  0x80, 0x24, 0x01, 0x10, 0x08, 0x80, 0x42, 0x01, 0x18, 0x08, 0x40, 0x41,
  0x01, 0x08, 0x08, 0x20, 0x41, 0x01, 0x04, 0x08, 0x20, 0x40, 0x82, 0x04,
  0x08, 0x10, 0x40, 0x81, 0x02, 0x08, 0x10, 0x40, 0x42, 0x02, 0x08, 0x08,
  0x40, 0x22, 0x01, 0x18, 0x04, 0x40, 0x22, 0x00, 0x88, 0x04, 0x40, 0x12,
  0x00, 0x90, 0x02, 0x40, 0x12, 0x00, 0x48, 0x02, 0xC0, 0x0A, 0x00, 0x50,
  0x01, 0x40, 0x0A, 0x00, 0x38, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0,
  0x00, 0x04, 0x00, 0x0C, 0x08, 0x00, 0x20, 0x20, 0x01, 0x00, 0xC0, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x08, 0x08, 0x00, 0x20, 0x60, 0x00,
  0x41, 0x00, 0x01, 0x08, 0x00, 0x04, 0x40, 0x00, 0x0B, 0x00, 0x00, 0x28,
  0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x48, 0x00,
  0x02, 0x30, 0x00, 0x10, 0x40, 0x00, 0x41, 0x00, 0x02, 0x02, 0x00, 0x10,
  0x08, 0x00, 0xC0, 0x10, 0x02, 0x00, 0x40, 0x10, 0x01, 0x00, 0x80, 0x02,
  0x06, 0x00, 0x08, 0x10, 0x00, 0x10, 0x80, 0x00, 0xA0, 0x00, 0x2C, 0x00,
  0x11, 0x00, 0x0C, 0x40, 0x02, 0x18, 0x01, 0x02, 0x00, 0xC0, 0x80, 0x20,
  0x30, 0x10, 0x04, 0x0C, 0x01, 0x02, 0x00, 0x41, 0x00, 0x08, 0xC0, 0x02,
  0x20, 0x00, 0x90, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x0C,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xE0, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x06, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x30, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0xF0, 0x00,
  0x84, 0x20, 0x84, 0x21, 0x08, 0x42, 0x08, 0x42, 0x10, 0x84, 0x20, 0x84,
  0x21, 0x08, 0x42, 0x08, 0x42, 0x10, 0x84, 0x07, 0xC0, 0x10, 0x04, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x40, 0x10, 0x3C, 0x00, 0x01, 0x00, 0x60, 0x0A, 0x02,
  0x40, 0x48, 0x11, 0x02, 0x20, 0x84, 0x10, 0x44, 0x08, 0x81, 0x20, 0x24,
  0x05, 0x80, 0x80, 0xFF, 0xFC, 0x43, 0x08, 0x61, 0x00, 0x01, 0xF8, 0x03,
  0x04, 0x04, 0x02, 0x08, 0x02, 0x10, 0x02, 0x10, 0x02, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x02, 0x03, 0xFE, 0x0C, 0x04, 0x10, 0x04, 0x20, 0x04, 0x40,
  0x04, 0x40, 0x04, 0x40, 0x0C, 0x40, 0x08, 0x40, 0x18, 0x40, 0x28, 0x20,
  0xC8, 0x1F, 0x08, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0xF8, 0x26, 0x18, 0x50, 0x18,
  0xC0, 0x11, 0x00, 0x22, 0x00, 0x4C, 0x00, 0x90, 0x01, 0x20, 0x02, 0x40,
  0x04, 0x80, 0x09, 0x00, 0x14, 0x00, 0x68, 0x00, 0x90, 0x01, 0x20, 0x02,
  0x40, 0x08, 0x80, 0x12, 0x80, 0x44, 0x83, 0x08, 0xF8, 0x00, 0x03, 0xF0,
  0x0C, 0x10, 0x20, 0x10, 0x80, 0x22, 0x00, 0x64, 0x00, 0x48, 0x00, 0xA0,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x02, 0x40, 0x04, 0x80, 0x10, 0x80, 0x21, 0x00, 0x81, 0x86, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x07, 0xC2, 0x0C, 0x32, 0x10, 0x0A,
  0x20, 0x0C, 0x20, 0x04, 0x40, 0x04, 0x40, 0x04, 0x40, 0x04, 0x80, 0x04,
  0x80, 0x08, 0x80, 0x08, 0x80, 0x08, 0x80, 0x08, 0x80, 0x08, 0x80, 0x18,
  0x80, 0x10, 0x80, 0x10, 0x80, 0x30, 0x80, 0x50, 0x61, 0x90, 0x3E, 0x20,
  0x01, 0xF0, 0x0C, 0x30, 0x20, 0x10, 0x80, 0x23, 0x00, 0x64, 0x00, 0x58,
  0x00, 0xA0, 0x01, 0x40, 0x06, 0xFF, 0xFB, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x41,
  0x83, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x30, 0x02, 0x00, 0x40, 0x04, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x7F, 0x80, 0x80, 0x08, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0x00,
  0x01, 0xF0, 0x81, 0x86, 0x41, 0x00, 0xC1, 0x00, 0x60, 0x80, 0x10, 0x80,
  0x08, 0x40, 0x04, 0x20, 0x02, 0x20, 0x02, 0x10, 0x01, 0x08, 0x00, 0x84,
  0x00, 0x42, 0x00, 0x21, 0x00, 0x10, 0x80, 0x10, 0x40, 0x08, 0x20, 0x04,
  0x10, 0x06, 0x0C, 0x05, 0x03, 0x0C, 0x80, 0xF8, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x10, 0x00, 0x08, 0x10, 0x08, 0x04, 0x18, 0x01,
  0xF8, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0xF8, 0x22, 0x08, 0x48, 0x10, 0xA0,
  0x11, 0x80, 0x22, 0x00, 0x44, 0x00, 0x90, 0x01, 0x20, 0x02, 0x40, 0x08,
  0x80, 0x11, 0x00, 0x22, 0x00, 0x48, 0x00, 0x90, 0x01, 0x20, 0x04, 0x40,
  0x08, 0x80, 0x12, 0x00, 0x24, 0x00, 0x48, 0x01, 0x00, 0x04, 0x30, 0x00,
  0x00, 0x00, 0x02, 0x08, 0x41, 0x04, 0x10, 0x43, 0x08, 0x20, 0x82, 0x08,
  0x61, 0x04, 0x10, 0x41, 0x0C, 0x20, 0x00, 0x10, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x60, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x03, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00,
  0x60, 0x06, 0x01, 0xE0, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x02, 0x10,
  0x04, 0x10, 0x18, 0x10, 0x30, 0x10, 0x60, 0x10, 0xC0, 0x11, 0x80, 0x23,
  0x00, 0x26, 0x00, 0x2C, 0x00, 0x3A, 0x00, 0x23, 0x00, 0x21, 0x00, 0x41,
  0x80, 0x40, 0x80, 0x40, 0xC0, 0x40, 0x40, 0x40, 0x60, 0x80, 0x20, 0x80,
  0x30, 0x80, 0x10, 0x04, 0x10, 0x41, 0x0C, 0x20, 0x82, 0x08, 0x21, 0x04,
  0x10, 0x41, 0x04, 0x20, 0x82, 0x08, 0x20, 0x84, 0x10, 0x41, 0x04, 0x30,
  0x80, 0x10, 0xF8, 0x1F, 0x04, 0xC3, 0x18, 0x21, 0x60, 0x4C, 0x04, 0x50,
  0x0A, 0x01, 0x18, 0x03, 0x00, 0x4C, 0x00, 0x80, 0x13, 0x00, 0x20, 0x04,
  0x80, 0x08, 0x01, 0x20, 0x04, 0x00, 0x48, 0x01, 0x00, 0x12, 0x00, 0x40,
  0x0D, 0x80, 0x10, 0x02, 0x40, 0x04, 0x00, 0x90, 0x01, 0x00, 0x24, 0x00,
  0x80, 0x09, 0x00, 0x20, 0x02, 0x40, 0x08, 0x01, 0xB0, 0x02, 0x00, 0x48,
  0x00, 0x80, 0x12, 0x00, 0x20, 0x04, 0x80, 0x10, 0x01, 0x00, 0x10, 0xF8,
  0x22, 0x08, 0x48, 0x10, 0xA0, 0x11, 0x80, 0x22, 0x00, 0x4C, 0x00, 0x98,
  0x01, 0x20, 0x02, 0x40, 0x08, 0x80, 0x11, 0x00, 0x24, 0x00, 0x48, 0x00,
  0x90, 0x01, 0x20, 0x04, 0x40, 0x08, 0x80, 0x12, 0x00, 0x24, 0x00, 0x48,
  0x01, 0x00, 0x01, 0xF0, 0x0C, 0x18, 0x30, 0x10, 0xC0, 0x11, 0x00, 0x24,
  0x00, 0x48, 0x00, 0x90, 0x01, 0x40, 0x02, 0x80, 0x05, 0x00, 0x0A, 0x00,
  0x14, 0x00, 0x28, 0x00, 0x90, 0x01, 0x20, 0x06, 0x40, 0x08, 0x80, 0x31,
  0x80, 0xC1, 0x83, 0x00, 0xF8, 0x00, 0x08, 0x7C, 0x09, 0x86, 0x0A, 0x03,
  0x0C, 0x01, 0x08, 0x01, 0x08, 0x01, 0x10, 0x01, 0x10, 0x01, 0x10, 0x01,
  0x10, 0x01, 0x10, 0x01, 0x10, 0x01, 0x20, 0x01, 0x20, 0x02, 0x20, 0x02,
  0x20, 0x02, 0x20, 0x04, 0x20, 0x04, 0x50, 0x08, 0x48, 0x30, 0x47, 0xE0,
  0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x07, 0xC2, 0x18, 0x64, 0x40, 0x31, 0x00, 0x62,
  0x00, 0x48, 0x00, 0x90, 0x01, 0x20, 0x02, 0x80, 0x09, 0x00, 0x12, 0x00,
  0x24, 0x00, 0x48, 0x00, 0x90, 0x01, 0x20, 0x04, 0x40, 0x08, 0x80, 0x11,
  0x00, 0x62, 0x01, 0x43, 0x0C, 0x83, 0xE2, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18,
  0xE2, 0x60, 0x50, 0x0C, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x02,
  0x00, 0x40, 0x08, 0x00, 0x03, 0xE0, 0x30, 0x61, 0x00, 0x8C, 0x01, 0x20,
  0x04, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x40, 0x01, 0x00, 0x04, 0x80, 0x12, 0x00, 0x4C,
  0x02, 0x18, 0x30, 0x1F, 0x00, 0x0C, 0x08, 0x08, 0x08, 0x08, 0xFF, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20, 0x20, 0x20, 0x60, 0x40,
  0x40, 0x40, 0x40, 0x40, 0x40, 0x40, 0x38, 0x20, 0x02, 0x40, 0x04, 0x80,
  0x11, 0x00, 0x22, 0x00, 0x44, 0x00, 0x90, 0x01, 0x20, 0x02, 0x40, 0x08,
  0x80, 0x11, 0x00, 0x22, 0x00, 0x48, 0x00, 0x90, 0x01, 0x20, 0x04, 0x40,
  0x08, 0x80, 0x31, 0x00, 0x61, 0x01, 0x43, 0x0C, 0x83, 0xE2, 0x00, 0x40,
  0x04, 0x80, 0x09, 0x00, 0x22, 0x00, 0x44, 0x01, 0x08, 0x02, 0x10, 0x0C,
  0x10, 0x10, 0x20, 0x20, 0x40, 0x80, 0x81, 0x01, 0x04, 0x02, 0x08, 0x02,
  0x20, 0x04, 0x40, 0x09, 0x00, 0x12, 0x00, 0x28, 0x00, 0x50, 0x00, 0x40,
  0x00, 0x80, 0x00, 0x80, 0x30, 0x0E, 0x00, 0xC0, 0x28, 0x05, 0x00, 0xA0,
  0x14, 0x04, 0xC0, 0x50, 0x11, 0x02, 0x40, 0xC4, 0x09, 0x02, 0x10, 0x44,
  0x08, 0x41, 0x10, 0x41, 0x0C, 0x41, 0x04, 0x21, 0x0C, 0x10, 0x84, 0x20,
  0x44, 0x08, 0x81, 0x10, 0x24, 0x04, 0x80, 0x90, 0x12, 0x02, 0xC0, 0x50,
  0x0A, 0x01, 0x40, 0x28, 0x05, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x20, 0x0C,
  0x00, 0x08, 0x01, 0x82, 0x00, 0x81, 0x00, 0x80, 0xC0, 0x80, 0x20, 0x40,
  0x10, 0x40, 0x04, 0x40, 0x02, 0x60, 0x00, 0xA0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x28, 0x00, 0x14, 0x00, 0x11, 0x00, 0x10, 0x80, 0x18, 0x20, 0x08,
  0x10, 0x08, 0x0C, 0x08, 0x02, 0x0C, 0x01, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x60, 0x80, 0x08, 0x10, 0x03, 0x02, 0x00, 0x40, 0x40, 0x18, 0x08, 0x02,
  0x00, 0x80, 0x40, 0x10, 0x10, 0x02, 0x02, 0x00, 0x40, 0x80, 0x08, 0x10,
  0x01, 0x04, 0x00, 0x10, 0x80, 0x02, 0x20, 0x00, 0x44, 0x00, 0x09, 0x00,
  0x01, 0x20, 0x00, 0x28, 0x00, 0x05, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x60, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x18, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x00, 0xFF,
  0xF8, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x00, 0x80, 0x0C,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x08, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x04, 0x00, 0x30, 0x00, 0x80, 0x04, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x04, 0x10, 0xC2, 0x08, 0x20, 0x82, 0x08, 0x61, 0x04,
  0x10, 0x41, 0x0C, 0x20, 0x82, 0x08, 0x20, 0x86, 0x10, 0x41, 0x04, 0x10,
  0xC2, 0x08, 0x20, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00,
  0x30, 0x06, 0x00, 0x40, 0x06, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0xC0,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x4C, 0x60, 0x12, 0x0C,
  0x05, 0x01, 0x82, 0x40, 0x31, 0x30, 0x07, 0x80,
};

const GFXglyph RobotoCondensed_ThinItalic39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 6, 28, 7, 1, -28 },
  { 22, 7, 8, 10, 4, -29 },
  { 29, 19, 28, 18, 1, -28 },
  { 96, 17, 36, 18, 1, -32 },
  { 173, 18, 28, 25, 4, -28 },
  { 236, 17, 28, 20, 1, -28 },
  { 296, 3, 8, 6, 4, -29 },
  { 299, 10, 40, 10, 2, -31 },
  { 349, 10, 40, 11, -2, -31 },
  { 399, 15, 15, 16, 2, -28 },
  { 428, 15, 21, 19, 2, -23 },
  { 468, 4, 8, 7, -1, -3 },
  { 472, 8, 1, 10, 1, -13 },
  { 473, 2, 2, 8, 1, -2 },
  { 474, 15, 30, 13, -1, -28 },
  { 531, 15, 28, 18, 2, -28 },
  { 584, 9, 28, 18, 5, -28 },
  { 616, 16, 28, 18, 1, -28 },
  { 672, 16, 28, 18, 1, -28 },
  { 728, 16, 28, 18, 1, -28 },
  { 784, 17, 28, 18, 2, -28 },
  { 844, 14, 28, 18, 2, -28 },
  { 893, 16, 28, 18, 3, -28 },
  { 949, 17, 28, 18, 1, -28 },
  { 1009, 14, 28, 18, 3, -28 },
  { 1058, 6, 20, 7, 0, -20 },
  { 1073, 7, 25, 7, -1, -20 },
  { 1095, 14, 15, 17, 2, -20 },
  { 1122, 15, 9, 19, 2, -17 },
  { 1139, 15, 15, 17, 1, -20 },
  { 1168, 12, 28, 15, 3, -28 },
  { 1210, 27, 36, 30, 1, -27 },
  { 1332, 18, 28, 20, -1, -28 },
  { 1395, 18, 28, 20, 1, -28 },
  { 1458, 19, 28, 22, 2, -28 },
  { 1525, 19, 28, 22, 1, -28 },
  { 1592, 19, 28, 19, 1, -28 },
  { 1659, 19, 28, 19, 1, -28 },
  { 1726, 18, 28, 23, 3, -28 },
  { 1789, 22, 28, 23, 1, -28 },
  { 1866, 6, 28, 9, 2, -28 },
  { 1887, 17, 28, 18, 1, -28 },
  { 1947, 21, 28, 21, 1, -28 },
  { 2021, 13, 28, 17, 1, -28 },
  { 2067, 27, 28, 28, 1, -28 },
  { 2162, 22, 28, 23, 1, -28 },
  { 2239, 19, 28, 22, 2, -28 },
  { 2306, 19, 28, 20, 1, -28 },
  { 2373, 19, 33, 22, 2, -28 },
  { 2452, 19, 28, 22, 1, -28 },
  { 2519, 19, 28, 20, 1, -28 },
  { 2586, 18, 28, 20, 4, -28 },
  { 2649, 20, 28, 22, 2, -28 },
  { 2719, 19, 28, 20, 3, -28 },
  { 2786, 27, 28, 30, 4, -28 },
  { 2881, 22, 28, 20, -1, -28 },
  { 2958, 18, 28, 20, 4, -28 },
  { 3021, 20, 28, 20, 0, -28 },
  { 3091, 11, 38, 8, 0, -32 },
  { 3144, 5, 30, 13, 4, -28 },
  { 3163, 10, 38, 8, -2, -32 },
  { 3211, 11, 14, 14, 2, -28 },
  { 3231, 14, 1, 14, -2, 0 },
  { 3233, 5, 5, 10, 5, -29 },
  { 3237, 16, 21, 18, 0, -21 },
  { 3279, 15, 29, 18, 1, -29 },
  { 3334, 15, 21, 17, 1, -21 },
  { 3374, 16, 29, 18, 2, -29 },
  { 3432, 15, 21, 17, 1, -21 },
  { 3472, 12, 29, 11, 2, -29 },
  { 3516, 17, 29, 18, 0, -21 },
  { 3578, 15, 29, 18, 1, -29 },
  { 3633, 6, 28, 7, 1, -28 },
  { 3654, 13, 36, 8, -5, -28 },
  { 3713, 16, 29, 16, 1, -29 },
  { 3771, 6, 29, 7, 1, -29 },
  { 3793, 26, 21, 29, 1, -21 },
  { 3862, 15, 21, 18, 1, -21 },
  { 3902, 15, 21, 18, 1, -21 },
  { 3942, 16, 29, 18, 0, -21 },
  { 4000, 15, 29, 18, 2, -21 },
  { 4055, 11, 21, 11, 1, -21 },
  { 4084, 14, 21, 17, 1, -21 },
  { 4121, 8, 26, 11, 2, -26 },
  { 4147, 15, 21, 18, 2, -21 },
  { 4187, 15, 21, 16, 2, -21 },
  { 4227, 22, 21, 25, 3, -21 },
  { 4285, 17, 21, 16, -1, -21 },
  { 4330, 19, 29, 16, -2, -21 },
  { 4399, 16, 21, 16, 0, -21 },
  { 4441, 13, 38, 11, 1, -30 },
  { 4503, 6, 33, 8, 1, -28 },
  { 4528, 13, 38, 11, -3, -30 },
  { 4590, 18, 6, 23, 2, -14 },
};

const GFXfont RobotoCondensed_ThinItalic39pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ThinItalic39pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ThinItalic39pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _ROBOTOCONDENSED_THINITALIC39PT7B_H_
