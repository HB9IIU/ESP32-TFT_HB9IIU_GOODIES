#ifndef _ROBOTOCONDENSED_THINITALIC18PT7B_H_
#define _ROBOTOCONDENSED_THINITALIC18PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ThinItalic.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ThinItalic18pt7bBitmaps[] PROGMEM = {
  0x00, 0x04, 0x92, 0x92, 0x40, 0x08, 0xB6, 0xC0, 0x00, 0x84, 0x82, 0x41,
  0xF1, 0x10, 0x90, 0x48, 0x24, 0x24, 0x3F, 0x89, 0x09, 0x04, 0x80, 0x00,
  0x10, 0x51, 0x14, 0x28, 0x10, 0x30, 0x10, 0x18, 0x10, 0x28, 0x50, 0x96,
  0x10, 0x20, 0x60, 0x90, 0x92, 0x94, 0x94, 0xE8, 0x10, 0x17, 0x29, 0x49,
  0x49, 0x89, 0x0E, 0x0E, 0x12, 0x12, 0x22, 0x14, 0x18, 0x10, 0x28, 0x45,
  0x85, 0x82, 0x42, 0x3D, 0xE0, 0x08, 0x88, 0x44, 0x22, 0x10, 0x84, 0x21,
  0x08, 0x42, 0x10, 0x82, 0x00, 0x00, 0x82, 0x10, 0x84, 0x21, 0x08, 0x44,
  0x21, 0x08, 0x84, 0x44, 0x00, 0x10, 0x22, 0x4B, 0xE3, 0x09, 0x22, 0x00,
  0x00, 0x20, 0x43, 0xE1, 0x02, 0x08, 0x10, 0x56, 0x40, 0x80, 0x00, 0x02,
  0x02, 0x04, 0x04, 0x08, 0x08, 0x10, 0x10, 0x20, 0x20, 0x40, 0x40, 0x00,
  0x1C, 0x45, 0x0A, 0x18, 0x30, 0x60, 0xC1, 0x85, 0x0A, 0x14, 0x47, 0x00,
  0x35, 0x11, 0x11, 0x22, 0x22, 0x22, 0x00, 0x1E, 0x21, 0x21, 0x01, 0x01,
  0x02, 0x04, 0x04, 0x08, 0x10, 0x20, 0x40, 0xFC, 0x3C, 0x85, 0x08, 0x10,
  0x20, 0x8E, 0x02, 0x04, 0x0A, 0x14, 0x27, 0x80, 0x00, 0x02, 0x06, 0x0A,
  0x12, 0x12, 0x22, 0x42, 0xFE, 0x04, 0x04, 0x04, 0x00, 0x3E, 0x20, 0x20,
  0x40, 0x40, 0x78, 0x04, 0x02, 0x02, 0x82, 0x84, 0x84, 0x78, 0x0C, 0xC2,
  0x10, 0x42, 0xEC, 0x61, 0x86, 0x18, 0x61, 0x78, 0x7C, 0x08, 0x10, 0x40,
  0x82, 0x04, 0x10, 0x20, 0x81, 0x04, 0x00, 0x00, 0x0E, 0x11, 0x21, 0x21,
  0x21, 0x22, 0x1C, 0x22, 0x42, 0x81, 0x82, 0x82, 0x7C, 0x3C, 0x85, 0x0C,
  0x18, 0x30, 0x60, 0xC2, 0x7C, 0x08, 0x20, 0xC6, 0x00, 0x20, 0x00, 0x00,
  0x80, 0x10, 0x00, 0x00, 0x00, 0x44, 0x48, 0x04, 0x31, 0x84, 0x04, 0x06,
  0x02, 0x00, 0x3C, 0x01, 0xE0, 0x20, 0x30, 0x10, 0x10, 0xC6, 0x10, 0x00,
  0x74, 0x42, 0x10, 0x88, 0x88, 0x00, 0x00, 0x08, 0x00, 0x07, 0xC1, 0x82,
  0x20, 0x12, 0x01, 0x47, 0x18, 0x89, 0x88, 0x99, 0x11, 0x91, 0x19, 0x12,
  0x92, 0x29, 0xDC, 0x80, 0x08, 0x00, 0x40, 0x03, 0xC0, 0x02, 0x01, 0x01,
  0x40, 0xA0, 0x90, 0x48, 0x44, 0x22, 0x2E, 0x90, 0x50, 0x28, 0x10, 0x08,
  0x3E, 0x41, 0x41, 0x41, 0x41, 0x42, 0x7C, 0x82, 0x82, 0x82, 0x82, 0x84,
  0x78, 0x1E, 0x10, 0x90, 0x28, 0x04, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x90, 0x47, 0xC0, 0x1E, 0x41, 0x41, 0x41, 0x41, 0x41, 0x41, 0x81,
  0x81, 0x81, 0x82, 0x84, 0x78, 0x1E, 0x40, 0x40, 0x40, 0x40, 0x40, 0x7C,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x78, 0x1E, 0x40, 0x40, 0x40, 0x40, 0x40,
  0x7C, 0x80, 0x80, 0x80, 0x80, 0x80, 0x00, 0x1E, 0x10, 0x90, 0x28, 0x14,
  0x02, 0x02, 0x01, 0x0C, 0x81, 0x40, 0xA0, 0x48, 0x63, 0xC0, 0x00, 0x20,
  0x50, 0x28, 0x14, 0x0A, 0x05, 0xFB, 0x02, 0x81, 0x40, 0xA0, 0x50, 0x20,
  0x00, 0x25, 0x24, 0x92, 0x92, 0x48, 0x00, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x02, 0x02, 0x02, 0x82, 0x84, 0x84, 0x78, 0x00, 0xA0, 0x90, 0x88, 0x84,
  0x82, 0x81, 0xC0, 0xA0, 0x88, 0x42, 0x21, 0x10, 0x40, 0x20, 0x01, 0x04,
  0x10, 0x41, 0x04, 0x20, 0x82, 0x08, 0x20, 0x78, 0x20, 0x12, 0x03, 0x60,
  0x26, 0x06, 0x50, 0xA5, 0x0A, 0x51, 0x29, 0x12, 0x92, 0x28, 0xA4, 0x8C,
  0x48, 0xC4, 0x08, 0x40, 0x20, 0x08, 0x15, 0x09, 0x42, 0x50, 0x92, 0x24,
  0x8A, 0x24, 0x85, 0x21, 0x48, 0x32, 0x0C, 0x01, 0x00, 0x1E, 0x10, 0x90,
  0x28, 0x18, 0x0C, 0x06, 0x05, 0x02, 0x81, 0x40, 0xA0, 0x90, 0x47, 0xC0,
  0x3E, 0x41, 0x41, 0x41, 0x41, 0x41, 0x42, 0xBC, 0x80, 0x80, 0x80, 0x80,
  0x00, 0x1E, 0x10, 0x90, 0x28, 0x18, 0x0C, 0x06, 0x05, 0x02, 0x81, 0x40,
  0xA0, 0x90, 0x47, 0xC0, 0x20, 0x08, 0x7E, 0x41, 0x41, 0x41, 0x41, 0x42,
  0xBC, 0x84, 0x84, 0x84, 0x84, 0x82, 0x02, 0x1F, 0x10, 0x48, 0x24, 0x02,
  0x00, 0x80, 0x30, 0x04, 0x01, 0x00, 0xA0, 0x48, 0x43, 0xC0, 0x7E, 0x10,
  0x10, 0x10, 0x10, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x40, 0x00, 0x00,
  0xA0, 0x50, 0x28, 0x14, 0x12, 0x0A, 0x05, 0x02, 0x81, 0x40, 0xA0, 0x90,
  0x47, 0xC0, 0x01, 0x81, 0x82, 0x82, 0x84, 0x84, 0x88, 0x88, 0x50, 0x50,
  0x60, 0x60, 0x40, 0x82, 0x08, 0x41, 0x86, 0x18, 0xA2, 0x8A, 0x29, 0x22,
  0x92, 0x49, 0x24, 0xA2, 0x8A, 0x28, 0xC1, 0x04, 0x10, 0x01, 0x00, 0x20,
  0x08, 0x21, 0x10, 0x48, 0x12, 0x03, 0x00, 0x80, 0x50, 0x14, 0x08, 0x84,
  0x21, 0x08, 0x81, 0x00, 0x81, 0x82, 0x82, 0x44, 0x48, 0x48, 0x50, 0x20,
  0x20, 0x20, 0x20, 0x40, 0x00, 0x1F, 0x80, 0x40, 0x40, 0x40, 0x20, 0x20,
  0x20, 0x20, 0x10, 0x10, 0x10, 0x08, 0x0F, 0xE0, 0x11, 0x08, 0x42, 0x10,
  0x84, 0x42, 0x10, 0x84, 0x22, 0x10, 0x84, 0x00, 0x2A, 0xA5, 0x55, 0x40,
  0x18, 0x42, 0x21, 0x08, 0x42, 0x11, 0x08, 0x42, 0x10, 0x84, 0x42, 0x00,
  0x11, 0x8C, 0x94, 0xC4, 0x78, 0x50, 0x1C, 0x45, 0x08, 0x13, 0xA8, 0x60,
  0xC1, 0x84, 0xF8, 0x00, 0x20, 0x20, 0x20, 0x3E, 0x21, 0x41, 0x41, 0x41,
  0x41, 0x42, 0x42, 0x44, 0x38, 0x39, 0x18, 0x20, 0x82, 0x08, 0x20, 0x89,
  0xC0, 0x00, 0x01, 0x02, 0x02, 0x3A, 0x46, 0x82, 0x84, 0x84, 0x84, 0x84,
  0x84, 0x88, 0x70, 0x1C, 0x45, 0x0A, 0x1B, 0xF0, 0x20, 0x40, 0x40, 0x70,
  0x11, 0x08, 0x44, 0x21, 0x08, 0x42, 0x21, 0x08, 0x40, 0x1D, 0x23, 0x41,
  0x42, 0x42, 0x42, 0x82, 0x82, 0x44, 0x3A, 0x04, 0x04, 0x84, 0x78, 0x00,
  0x40, 0x81, 0x03, 0xE4, 0x48, 0xA1, 0x42, 0x85, 0x0A, 0x18, 0x20, 0x00,
  0x00, 0x56, 0xAA, 0x80, 0x00, 0x00, 0x00, 0x84, 0x22, 0x10, 0x84, 0x21,
  0x10, 0x84, 0x22, 0x00, 0x00, 0x20, 0x20, 0x20, 0x22, 0x24, 0x48, 0x50,
  0x60, 0x50, 0x48, 0x48, 0x84, 0x04, 0x15, 0x56, 0xAA, 0x80, 0x1E, 0x71,
  0x14, 0x50, 0x42, 0x84, 0x14, 0x20, 0xA1, 0x09, 0x08, 0x48, 0x42, 0x82,
  0x14, 0x00, 0x00, 0x1E, 0x44, 0x8A, 0x14, 0x28, 0x50, 0xA1, 0x82, 0x00,
  0x3C, 0x8A, 0x0C, 0x18, 0x30, 0x61, 0x42, 0x88, 0xE0, 0x1E, 0x21, 0x41,
  0x41, 0x41, 0x41, 0x42, 0x42, 0x44, 0xB8, 0x80, 0x80, 0x80, 0x00, 0x3A,
  0x8E, 0x0C, 0x28, 0x50, 0xA1, 0x42, 0x88, 0xE8, 0x20, 0x40, 0x81, 0x00,
  0x18, 0x84, 0x10, 0x41, 0x04, 0x10, 0x80, 0x00, 0x3C, 0x85, 0x0A, 0x03,
  0x01, 0x81, 0x02, 0x84, 0xF0, 0x02, 0x44, 0x44, 0x48, 0x88, 0x88, 0x02,
  0x86, 0x0C, 0x28, 0x50, 0xA1, 0x42, 0x88, 0xE0, 0x81, 0x0A, 0x14, 0x44,
  0x8A, 0x14, 0x30, 0x60, 0x00, 0x84, 0x21, 0x18, 0xC6, 0x32, 0x94, 0x95,
  0x26, 0x51, 0x8C, 0x42, 0x10, 0x80, 0x42, 0x44, 0x90, 0xC1, 0x02, 0x0A,
  0x24, 0x45, 0x08, 0x20, 0x10, 0x88, 0x44, 0x41, 0x20, 0xA0, 0x50, 0x28,
  0x18, 0x04, 0x04, 0x02, 0x02, 0x02, 0x00, 0x1E, 0x04, 0x10, 0x41, 0x02,
  0x08, 0x20, 0x81, 0xF0, 0x08, 0x88, 0x42, 0x11, 0x08, 0x84, 0x10, 0x84,
  0x42, 0x10, 0x42, 0x00, 0x24, 0x92, 0x52, 0x49, 0x29, 0x20, 0x10, 0x82,
  0x10, 0x88, 0x42, 0x08, 0x84, 0x42, 0x10, 0x84, 0x44, 0x00, 0x70, 0x89,
  0x86,
};

const GFXglyph RobotoCondensed_ThinItalic18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 3, 13, 3, 0, -13 },
  { 6, 3, 4, 5, 2, -14 },
  { 8, 9, 13, 8, 0, -13 },
  { 23, 7, 17, 8, 1, -15 },
  { 38, 8, 13, 11, 2, -13 },
  { 51, 8, 13, 9, 0, -13 },
  { 64, 1, 4, 3, 2, -14 },
  { 65, 5, 18, 5, 1, -14 },
  { 77, 5, 18, 5, -1, -14 },
  { 89, 7, 7, 7, 1, -13 },
  { 96, 7, 8, 9, 1, -10 },
  { 103, 2, 4, 3, -1, -1 },
  { 104, 3, 1, 5, 1, -7 },
  { 105, 1, 1, 4, 0, -1 },
  { 106, 8, 14, 6, -1, -13 },
  { 120, 7, 13, 8, 1, -13 },
  { 132, 4, 13, 8, 2, -13 },
  { 139, 8, 13, 8, 0, -13 },
  { 152, 7, 13, 8, 1, -13 },
  { 164, 8, 13, 8, 0, -13 },
  { 177, 8, 13, 8, 1, -13 },
  { 190, 6, 13, 8, 1, -13 },
  { 200, 7, 13, 8, 2, -13 },
  { 212, 8, 13, 8, 0, -13 },
  { 225, 7, 13, 8, 1, -13 },
  { 237, 3, 9, 3, 0, -9 },
  { 241, 4, 12, 3, -1, -9 },
  { 247, 7, 7, 8, 1, -9 },
  { 254, 7, 3, 9, 1, -7 },
  { 257, 7, 7, 8, 0, -9 },
  { 264, 5, 13, 7, 2, -13 },
  { 273, 12, 16, 14, 1, -12 },
  { 297, 9, 13, 9, -1, -13 },
  { 312, 8, 13, 9, 1, -13 },
  { 325, 9, 13, 10, 1, -13 },
  { 340, 8, 13, 10, 1, -13 },
  { 353, 8, 13, 9, 1, -13 },
  { 366, 8, 13, 9, 1, -13 },
  { 379, 9, 13, 11, 1, -13 },
  { 394, 9, 13, 11, 1, -13 },
  { 409, 3, 13, 4, 1, -13 },
  { 414, 8, 13, 8, 0, -13 },
  { 427, 9, 13, 10, 1, -13 },
  { 442, 6, 13, 8, 1, -13 },
  { 452, 12, 13, 13, 1, -13 },
  { 472, 10, 13, 11, 1, -13 },
  { 489, 9, 13, 10, 1, -13 },
  { 504, 8, 13, 9, 1, -13 },
  { 517, 9, 15, 10, 1, -13 },
  { 534, 8, 13, 10, 1, -13 },
  { 547, 9, 13, 9, 0, -13 },
  { 562, 8, 13, 9, 2, -13 },
  { 575, 9, 13, 10, 1, -13 },
  { 590, 8, 13, 9, 2, -13 },
  { 603, 12, 13, 14, 2, -13 },
  { 623, 10, 13, 9, 0, -13 },
  { 640, 8, 13, 9, 2, -13 },
  { 653, 9, 13, 9, 0, -13 },
  { 668, 5, 18, 4, 0, -15 },
  { 680, 2, 14, 6, 2, -13 },
  { 684, 5, 18, 4, -1, -15 },
  { 696, 5, 6, 6, 1, -13 },
  { 700, 6, 1, 6, -1, 0 },
  { 701, 2, 2, 5, 2, -13 },
  { 702, 7, 10, 8, 0, -10 },
  { 711, 8, 14, 8, 0, -14 },
  { 725, 6, 10, 8, 1, -10 },
  { 733, 8, 14, 8, 1, -14 },
  { 747, 7, 10, 8, 0, -10 },
  { 756, 5, 14, 5, 1, -14 },
  { 765, 8, 14, 8, 0, -10 },
  { 779, 7, 14, 8, 0, -14 },
  { 792, 2, 14, 3, 1, -14 },
  { 796, 5, 18, 4, -2, -14 },
  { 808, 8, 14, 7, 0, -14 },
  { 822, 2, 14, 3, 1, -14 },
  { 826, 13, 10, 14, 0, -10 },
  { 843, 7, 10, 8, 0, -10 },
  { 852, 7, 10, 8, 1, -10 },
  { 861, 8, 14, 8, 0, -10 },
  { 875, 7, 14, 8, 1, -10 },
  { 888, 6, 10, 5, 0, -10 },
  { 896, 7, 10, 8, 0, -10 },
  { 905, 4, 12, 5, 1, -12 },
  { 911, 7, 10, 8, 1, -10 },
  { 920, 7, 10, 7, 1, -10 },
  { 929, 10, 10, 12, 1, -10 },
  { 942, 7, 10, 7, 0, -10 },
  { 951, 9, 14, 7, -1, -10 },
  { 967, 7, 10, 7, 0, -10 },
  { 976, 5, 18, 5, 1, -14 },
  { 988, 3, 15, 4, 0, -13 },
  { 994, 5, 18, 5, -1, -14 },
  { 1006, 8, 3, 11, 1, -7 },
};

const GFXfont RobotoCondensed_ThinItalic18pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ThinItalic18pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ThinItalic18pt7bGlyphs,
  0x20, 0x7E, 21
};

#endif // _ROBOTOCONDENSED_THINITALIC18PT7B_H_
