#ifndef _ROBOTOCONDENSED_THINITALIC33PT7B_H_
#define _ROBOTOCONDENSED_THINITALIC33PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ThinItalic.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ThinItalic33pt7bBitmaps[] PROGMEM = {
  0x00, 0x08, 0x44, 0x21, 0x08, 0x44, 0x21, 0x08, 0x42, 0x21, 0x08, 0x00,
  0x00, 0x00, 0x42, 0x00, 0x4C, 0x63, 0x29, 0x4A, 0x40, 0x00, 0x41, 0x00,
  0x21, 0x00, 0x10, 0x80, 0x10, 0x40, 0x08, 0x20, 0x04, 0x20, 0x7F, 0xFE,
  0x02, 0x08, 0x01, 0x08, 0x01, 0x04, 0x00, 0x82, 0x00, 0x42, 0x00, 0x41,
  0x00, 0x20, 0x80, 0x10, 0x80, 0x10, 0x40, 0x7F, 0xFC, 0x04, 0x20, 0x04,
  0x10, 0x02, 0x08, 0x01, 0x08, 0x01, 0x04, 0x00, 0x82, 0x00, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x78, 0x06, 0x18, 0x20, 0x21, 0x00, 0x44, 0x01,
  0x10, 0x04, 0x40, 0x11, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x20, 0x00, 0x40, 0x01, 0x20, 0x04, 0x80, 0x12, 0x00,
  0x44, 0x02, 0x10, 0x18, 0x20, 0xC0, 0x7C, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x1C, 0x00, 0x22, 0x00, 0x41, 0x00, 0x41, 0x04, 0x81, 0x08, 0x81,
  0x08, 0x82, 0x10, 0x82, 0x20, 0x82, 0x40, 0x44, 0x40, 0x78, 0x80, 0x01,
  0x00, 0x01, 0x1C, 0x02, 0x22, 0x04, 0x42, 0x08, 0x81, 0x08, 0x82, 0x10,
  0x82, 0x20, 0x82, 0x40, 0x82, 0x00, 0x84, 0x00, 0x84, 0x00, 0x78, 0x01,
  0xE0, 0x04, 0x20, 0x10, 0x40, 0x40, 0x80, 0x81, 0x01, 0x02, 0x02, 0x08,
  0x04, 0x20, 0x08, 0x80, 0x0E, 0x00, 0x10, 0x00, 0x50, 0x01, 0x10, 0x44,
  0x20, 0x90, 0x21, 0x20, 0x42, 0x80, 0x49, 0x00, 0x52, 0x00, 0xC4, 0x01,
  0x84, 0x05, 0x0C, 0x11, 0x07, 0xC2, 0x00, 0x49, 0x24, 0xA0, 0x00, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x40, 0x40, 0x20, 0x20, 0x10, 0x08, 0x08, 0x04,
  0x02, 0x01, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x01, 0x00, 0x80, 0x20, 0x08,
  0x00, 0x04, 0x01, 0x00, 0x80, 0x20, 0x10, 0x08, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x08, 0x04, 0x02, 0x02, 0x01, 0x01, 0x00, 0x80, 0x80, 0x40,
  0x40, 0x40, 0x40, 0x00, 0x01, 0x00, 0x10, 0x00, 0x80, 0x04, 0x08, 0x21,
  0x31, 0x30, 0x7E, 0x00, 0xC0, 0x0A, 0x00, 0x88, 0x0C, 0x40, 0x41, 0x04,
  0x0C, 0x00, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x40, 0xFF, 0xFC, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x22, 0x22, 0x44, 0x80,
  0xFE, 0xA0, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x20,
  0x01, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x02,
  0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x20, 0x02, 0x00,
  0x10, 0x01, 0x00, 0x08, 0x00, 0x80, 0x00, 0x03, 0xC0, 0x61, 0x04, 0x04,
  0x20, 0x22, 0x00, 0x90, 0x05, 0x00, 0x28, 0x01, 0x40, 0x12, 0x00, 0xA0,
  0x05, 0x00, 0x28, 0x01, 0x40, 0x0A, 0x00, 0x90, 0x04, 0x80, 0x24, 0x02,
  0x20, 0x11, 0x01, 0x88, 0x08, 0x20, 0x80, 0xF0, 0x00, 0x04, 0xFC, 0x41,
  0x04, 0x10, 0x82, 0x08, 0x20, 0x82, 0x10, 0x41, 0x04, 0x10, 0x82, 0x08,
  0x20, 0x82, 0x00, 0x03, 0xE0, 0x20, 0x82, 0x02, 0x20, 0x11, 0x00, 0x90,
  0x04, 0x80, 0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x80, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x06,
  0x00, 0x60, 0x03, 0xFF, 0xC0, 0x03, 0xE0, 0x10, 0x40, 0x80, 0x84, 0x02,
  0x10, 0x04, 0x80, 0x10, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x40, 0x06,
  0x01, 0xE0, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x04, 0x80, 0x12, 0x00,
  0x48, 0x01, 0x20, 0x08, 0x40, 0x60, 0x83, 0x01, 0xF0, 0x00, 0x00, 0x08,
  0x00, 0xC0, 0x0A, 0x00, 0xA0, 0x05, 0x00, 0x48, 0x04, 0x40, 0x42, 0x02,
  0x20, 0x21, 0x02, 0x08, 0x10, 0x41, 0x02, 0x10, 0x11, 0x01, 0x08, 0x08,
  0xFF, 0xF8, 0x02, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x0F, 0xFC, 0x20, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x08, 0x00, 0x2F, 0x80, 0xC1, 0x02, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x04, 0x80, 0x22, 0x00, 0x88, 0x02, 0x20, 0x10, 0x40,
  0x40, 0x86, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x30, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x20, 0x04, 0x00, 0x4F, 0x85, 0x04, 0xA0, 0x2C, 0x02, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x28, 0x02, 0x80, 0x28, 0x04, 0xC0,
  0x86, 0x18, 0x3E, 0x00, 0xFF, 0xF8, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02,
  0x00, 0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40,
  0x04, 0x00, 0x20, 0x02, 0x00, 0x00, 0x01, 0xE0, 0x18, 0x60, 0x80, 0x84,
  0x01, 0x10, 0x04, 0x40, 0x12, 0x00, 0x48, 0x02, 0x10, 0x08, 0x40, 0x40,
  0x82, 0x01, 0xF0, 0x18, 0x60, 0x80, 0x44, 0x01, 0x20, 0x04, 0x80, 0x12,
  0x00, 0x48, 0x01, 0x20, 0x08, 0xC0, 0x61, 0x83, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x41, 0x04, 0x04, 0x40, 0x26, 0x01, 0x20, 0x05, 0x00, 0x30, 0x02,
  0x80, 0x14, 0x00, 0xA0, 0x04, 0x80, 0x64, 0x05, 0x10, 0x50, 0x7C, 0x80,
  0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x30, 0x03, 0x01, 0xC0,
  0x00, 0x08, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0xC0,
  0x04, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x08,
  0x20, 0x84, 0x10, 0x80, 0x00, 0x08, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80,
  0x02, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFE, 0x20, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00,
  0x10, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x00, 0x80, 0x00, 0x1F, 0x08,
  0x24, 0x09, 0x01, 0x80, 0x60, 0x20, 0x08, 0x02, 0x01, 0x00, 0x80, 0x60,
  0x20, 0x10, 0x04, 0x02, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x10, 0x04, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xC0, 0x60, 0x02, 0x00, 0x20,
  0x18, 0x00, 0x20, 0x20, 0x00, 0x40, 0x80, 0x00, 0x82, 0x00, 0x00, 0x8C,
  0x07, 0x01, 0x10, 0x31, 0x82, 0x40, 0x81, 0x04, 0x81, 0x02, 0x09, 0x04,
  0x08, 0x14, 0x08, 0x10, 0x28, 0x20, 0x20, 0x50, 0x40, 0x40, 0xC1, 0x01,
  0x02, 0x82, 0x02, 0x05, 0x04, 0x04, 0x0A, 0x08, 0x10, 0x24, 0x10, 0x20,
  0x48, 0x20, 0xC1, 0x10, 0x42, 0x44, 0x20, 0x78, 0x70, 0x20, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x10, 0x00, 0x28, 0x00, 0x28,
  0x00, 0x28, 0x00, 0x48, 0x00, 0x48, 0x00, 0x88, 0x00, 0x88, 0x01, 0x04,
  0x01, 0x04, 0x02, 0x04, 0x02, 0x04, 0x04, 0x04, 0x04, 0x04, 0x08, 0x04,
  0x0F, 0xFC, 0x10, 0x02, 0x10, 0x02, 0x20, 0x02, 0x20, 0x02, 0x40, 0x02,
  0x40, 0x02, 0x80, 0x02, 0x0F, 0xF0, 0x10, 0x18, 0x20, 0x10, 0x40, 0x11,
  0x00, 0x22, 0x00, 0x44, 0x00, 0x88, 0x02, 0x10, 0x04, 0x20, 0x10, 0x80,
  0x41, 0xFF, 0x02, 0x01, 0x04, 0x01, 0x08, 0x01, 0x20, 0x02, 0x40, 0x04,
  0x80, 0x09, 0x00, 0x22, 0x00, 0x44, 0x01, 0x10, 0x0C, 0x3F, 0xE0, 0x00,
  0x01, 0xF0, 0x0C, 0x18, 0x20, 0x18, 0x80, 0x13, 0x00, 0x24, 0x00, 0x48,
  0x00, 0xA0, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x02, 0x80, 0x09, 0x00, 0x12, 0x00, 0x24,
  0x00, 0x84, 0x02, 0x04, 0x08, 0x07, 0xE0, 0x00, 0x0F, 0xF0, 0x08, 0x0C,
  0x08, 0x02, 0x08, 0x02, 0x10, 0x01, 0x10, 0x01, 0x10, 0x01, 0x10, 0x01,
  0x10, 0x01, 0x10, 0x01, 0x20, 0x01, 0x20, 0x01, 0x20, 0x02, 0x20, 0x02,
  0x20, 0x02, 0x40, 0x02, 0x40, 0x04, 0x40, 0x04, 0x40, 0x08, 0x40, 0x08,
  0x40, 0x10, 0x80, 0x60, 0xFF, 0x80, 0x0F, 0xFF, 0x08, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x3F, 0xF8, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x80, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x3F, 0xF8, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x01, 0xF8, 0x06, 0x04, 0x08, 0x02, 0x18, 0x02, 0x10, 0x01,
  0x20, 0x01, 0x20, 0x01, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x40, 0xFE, 0x40, 0x02, 0x80, 0x04, 0x80, 0x04, 0x80, 0x04,
  0x80, 0x04, 0x80, 0x04, 0x40, 0x04, 0x40, 0x08, 0x30, 0x30, 0x0F, 0x80,
  0x08, 0x00, 0x42, 0x00, 0x10, 0x80, 0x04, 0x20, 0x01, 0x10, 0x00, 0x84,
  0x00, 0x21, 0x00, 0x08, 0x40, 0x02, 0x10, 0x00, 0x84, 0x00, 0x22, 0x00,
  0x10, 0xFF, 0xFC, 0x20, 0x01, 0x08, 0x00, 0x42, 0x00, 0x11, 0x00, 0x08,
  0x40, 0x02, 0x10, 0x00, 0x84, 0x00, 0x21, 0x00, 0x08, 0x40, 0x02, 0x20,
  0x01, 0x08, 0x00, 0x40, 0x08, 0x84, 0x21, 0x08, 0x44, 0x21, 0x08, 0x42,
  0x21, 0x08, 0x42, 0x21, 0x08, 0x42, 0x00, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x08, 0x80,
  0x22, 0x00, 0x88, 0x04, 0x20, 0x10, 0x80, 0x81, 0x04, 0x03, 0xE0, 0x00,
  0x08, 0x00, 0x84, 0x00, 0x82, 0x00, 0x81, 0x00, 0x81, 0x00, 0x80, 0x80,
  0x80, 0x40, 0x80, 0x20, 0x80, 0x10, 0x80, 0x08, 0x80, 0x08, 0x80, 0x04,
  0xA0, 0x03, 0x90, 0x01, 0x04, 0x00, 0x82, 0x00, 0x80, 0x80, 0x40, 0x40,
  0x20, 0x10, 0x10, 0x08, 0x08, 0x02, 0x04, 0x00, 0x84, 0x00, 0x42, 0x00,
  0x10, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x3F, 0xF8, 0x0C, 0x00, 0x04,
  0x30, 0x00, 0x30, 0xC0, 0x00, 0xC3, 0x00, 0x05, 0x14, 0x00, 0x14, 0x48,
  0x00, 0xA1, 0x20, 0x02, 0x84, 0x80, 0x12, 0x12, 0x00, 0x48, 0x48, 0x02,
  0x22, 0x10, 0x10, 0x88, 0x40, 0x44, 0x21, 0x02, 0x10, 0x84, 0x08, 0x42,
  0x10, 0x41, 0x08, 0x41, 0x04, 0x40, 0x88, 0x11, 0x02, 0x20, 0x84, 0x09,
  0x02, 0x10, 0x24, 0x08, 0x40, 0xA0, 0x22, 0x01, 0x00, 0x88, 0x04, 0x02,
  0x00, 0x08, 0x00, 0x43, 0x00, 0x10, 0xC0, 0x04, 0x28, 0x01, 0x12, 0x00,
  0x44, 0x80, 0x21, 0x10, 0x08, 0x44, 0x02, 0x10, 0x80, 0x84, 0x20, 0x22,
  0x08, 0x10, 0x81, 0x04, 0x20, 0x41, 0x08, 0x08, 0x42, 0x02, 0x10, 0x80,
  0x84, 0x40, 0x12, 0x10, 0x04, 0x84, 0x00, 0xA1, 0x00, 0x28, 0x40, 0x0A,
  0x20, 0x01, 0x88, 0x00, 0x40, 0x01, 0xF0, 0x06, 0x0C, 0x08, 0x02, 0x10,
  0x02, 0x20, 0x02, 0x20, 0x01, 0x20, 0x01, 0x40, 0x01, 0x40, 0x01, 0x40,
  0x02, 0x40, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x04, 0x80,
  0x04, 0x80, 0x04, 0x80, 0x08, 0x80, 0x08, 0x80, 0x10, 0x40, 0x30, 0x20,
  0x40, 0x1F, 0x80, 0x0F, 0xF8, 0x08, 0x04, 0x08, 0x02, 0x08, 0x02, 0x10,
  0x01, 0x10, 0x01, 0x10, 0x01, 0x10, 0x02, 0x10, 0x02, 0x10, 0x04, 0x20,
  0x04, 0x20, 0x18, 0x3F, 0xE0, 0x20, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x01, 0xF0, 0x06, 0x0C, 0x08, 0x02, 0x10, 0x02, 0x20, 0x02, 0x20,
  0x01, 0x20, 0x01, 0x40, 0x01, 0x40, 0x01, 0x40, 0x02, 0x40, 0x02, 0x80,
  0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x04, 0x80, 0x04, 0x80, 0x04, 0x80,
  0x08, 0x80, 0x08, 0x80, 0x10, 0x40, 0x30, 0x20, 0x40, 0x1F, 0x80, 0x00,
  0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x0F, 0xF8, 0x08, 0x04, 0x08,
  0x02, 0x08, 0x01, 0x10, 0x01, 0x10, 0x01, 0x10, 0x01, 0x10, 0x02, 0x10,
  0x02, 0x20, 0x02, 0x20, 0x04, 0x20, 0x18, 0x3F, 0xE0, 0x20, 0x40, 0x20,
  0x20, 0x40, 0x20, 0x40, 0x20, 0x40, 0x10, 0x40, 0x10, 0x40, 0x10, 0x40,
  0x08, 0x80, 0x08, 0x80, 0x04, 0x01, 0xF8, 0x06, 0x04, 0x08, 0x02, 0x10,
  0x02, 0x10, 0x02, 0x20, 0x02, 0x20, 0x00, 0x10, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00,
  0x04, 0x80, 0x04, 0x80, 0x04, 0x80, 0x08, 0x80, 0x08, 0x40, 0x10, 0x20,
  0x60, 0x1F, 0x80, 0xFF, 0xFE, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x00, 0x10,
  0x01, 0x10, 0x01, 0x10, 0x01, 0x20, 0x01, 0x20, 0x01, 0x20, 0x02, 0x20,
  0x02, 0x20, 0x02, 0x20, 0x02, 0x40, 0x02, 0x40, 0x02, 0x40, 0x04, 0x40,
  0x04, 0x40, 0x04, 0x80, 0x04, 0x80, 0x04, 0x80, 0x08, 0x80, 0x08, 0x80,
  0x08, 0x80, 0x10, 0x40, 0x20, 0x20, 0x40, 0x1F, 0x80, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x14, 0x00, 0x24, 0x00, 0x88, 0x01, 0x10, 0x04, 0x20, 0x08,
  0x40, 0x20, 0x80, 0x41, 0x01, 0x01, 0x02, 0x02, 0x08, 0x04, 0x10, 0x08,
  0x20, 0x10, 0x80, 0x21, 0x00, 0x24, 0x00, 0x48, 0x00, 0xA0, 0x01, 0x40,
  0x03, 0x00, 0x06, 0x00, 0x00, 0x80, 0x10, 0x03, 0x00, 0x20, 0x06, 0x00,
  0xA0, 0x14, 0x01, 0x40, 0x28, 0x04, 0x80, 0x48, 0x09, 0x01, 0x10, 0x12,
  0x02, 0x20, 0x44, 0x08, 0x40, 0x88, 0x10, 0x82, 0x10, 0x21, 0x04, 0x20,
  0x82, 0x10, 0x41, 0x04, 0x20, 0x84, 0x08, 0x40, 0x88, 0x11, 0x01, 0x10,
  0x22, 0x02, 0x40, 0x48, 0x04, 0x80, 0x90, 0x09, 0x01, 0x20, 0x14, 0x02,
  0x80, 0x28, 0x03, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x00,
  0x08, 0x00, 0x82, 0x00, 0x20, 0x80, 0x10, 0x10, 0x08, 0x04, 0x04, 0x00,
  0x81, 0x00, 0x20, 0x80, 0x04, 0x40, 0x01, 0x20, 0x00, 0x48, 0x00, 0x0C,
  0x00, 0x02, 0x00, 0x01, 0x40, 0x00, 0x50, 0x00, 0x22, 0x00, 0x10, 0x80,
  0x08, 0x10, 0x02, 0x04, 0x01, 0x01, 0x00, 0x80, 0x20, 0x40, 0x08, 0x10,
  0x01, 0x08, 0x00, 0x40, 0x80, 0x02, 0x80, 0x09, 0x00, 0x12, 0x00, 0x42,
  0x01, 0x04, 0x02, 0x08, 0x08, 0x08, 0x20, 0x10, 0x40, 0x21, 0x00, 0x24,
  0x00, 0x48, 0x00, 0xA0, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0xFF,
  0xF0, 0x07, 0x82, 0x01, 0x00, 0x80, 0x40, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x01,
  0xE0, 0x82, 0x10, 0x84, 0x21, 0x08, 0x21, 0x08, 0x42, 0x10, 0x82, 0x10,
  0x84, 0x21, 0x04, 0x21, 0x08, 0x07, 0x80, 0x40, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x01, 0x00, 0x80, 0x41, 0xE0, 0x02, 0x03, 0x02, 0x81, 0x41, 0x20, 0x88,
  0x44, 0x42, 0x21, 0x20, 0x90, 0x50, 0x10, 0xFF, 0xF0, 0x89, 0x10, 0x03,
  0xE0, 0x60, 0x82, 0x02, 0x20, 0x12, 0x00, 0x80, 0x04, 0x00, 0x20, 0x02,
  0x07, 0xF0, 0xC0, 0x88, 0x04, 0x80, 0x24, 0x02, 0x40, 0x11, 0x01, 0x88,
  0x34, 0x3E, 0x20, 0x08, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x13, 0xE1, 0x60, 0x8C, 0x04, 0x40, 0x12, 0x00,
  0x90, 0x04, 0x80, 0x28, 0x01, 0x40, 0x0A, 0x00, 0x90, 0x04, 0x80, 0x28,
  0x02, 0x40, 0x13, 0x01, 0x14, 0x18, 0x9F, 0x00, 0x07, 0xC1, 0x82, 0x10,
  0x12, 0x01, 0x40, 0x14, 0x01, 0x40, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x02, 0x80, 0x28, 0x04, 0x40, 0x46, 0x18, 0x3E, 0x00, 0x00, 0x02,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x04, 0x07, 0xC8, 0x10, 0x50, 0x40, 0x61, 0x00, 0x42, 0x01, 0x08, 0x02,
  0x10, 0x04, 0x20, 0x08, 0x40, 0x11, 0x00, 0x22, 0x00, 0x84, 0x01, 0x08,
  0x02, 0x10, 0x04, 0x10, 0x18, 0x20, 0xD0, 0x3E, 0x40, 0x07, 0xC0, 0x82,
  0x10, 0x12, 0x01, 0x40, 0x14, 0x01, 0x40, 0x1F, 0xFF, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x40, 0x06, 0x0C, 0x1F, 0x00, 0x03,
  0xC1, 0x00, 0x80, 0x20, 0x10, 0x04, 0x01, 0x00, 0x40, 0xFF, 0x04, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x20, 0x08, 0x02, 0x00, 0x80, 0x00, 0x03, 0xE4, 0x10, 0x50, 0x80,
  0xC4, 0x03, 0x10, 0x04, 0x80, 0x22, 0x00, 0x88, 0x02, 0x20, 0x09, 0x00,
  0x24, 0x00, 0x90, 0x04, 0x40, 0x11, 0x00, 0x42, 0x03, 0x08, 0x34, 0x1F,
  0x10, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x42, 0x01, 0x04, 0x08, 0x0F,
  0xC0, 0x08, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x13, 0xE2, 0x41, 0x28, 0x13, 0x01, 0x30, 0x12, 0x01, 0x20, 0x14,
  0x01, 0x40, 0x14, 0x01, 0x40, 0x14, 0x02, 0x40, 0x28, 0x02, 0x80, 0x28,
  0x02, 0x80, 0x20, 0x08, 0x40, 0x00, 0x00, 0x02, 0x10, 0x88, 0x42, 0x10,
  0x88, 0x42, 0x10, 0x84, 0x42, 0x10, 0x00, 0x40, 0x10, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x80, 0x20, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x80, 0x20, 0x08, 0x04, 0x0E, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x11,
  0x01, 0x08, 0x10, 0x41, 0x02, 0x10, 0x11, 0x00, 0x90, 0x09, 0x00, 0x54,
  0x03, 0x20, 0x10, 0x80, 0x84, 0x04, 0x10, 0x40, 0x82, 0x02, 0x10, 0x08,
  0x80, 0x40, 0x08, 0x42, 0x11, 0x08, 0x42, 0x10, 0x88, 0x42, 0x10, 0x84,
  0x42, 0x10, 0x84, 0x22, 0x10, 0x80, 0x13, 0xE0, 0xF0, 0x90, 0x4C, 0x22,
  0x81, 0x40, 0x4C, 0x05, 0x01, 0x30, 0x08, 0x04, 0x80, 0x40, 0x12, 0x01,
  0x00, 0x50, 0x04, 0x01, 0x40, 0x10, 0x05, 0x00, 0x40, 0x24, 0x02, 0x00,
  0x90, 0x08, 0x02, 0x80, 0x20, 0x0A, 0x00, 0x80, 0x28, 0x02, 0x01, 0x20,
  0x08, 0x04, 0x80, 0x40, 0x10, 0x13, 0xE1, 0x41, 0x28, 0x13, 0x01, 0x30,
  0x12, 0x01, 0x20, 0x14, 0x01, 0x40, 0x14, 0x01, 0x40, 0x14, 0x02, 0x40,
  0x28, 0x02, 0x80, 0x28, 0x02, 0x80, 0x20, 0x07, 0xC0, 0x41, 0x84, 0x04,
  0x40, 0x12, 0x00, 0xA0, 0x05, 0x00, 0x28, 0x01, 0x40, 0x0C, 0x00, 0xA0,
  0x05, 0x00, 0x28, 0x02, 0x40, 0x11, 0x01, 0x0C, 0x10, 0x1F, 0x00, 0x09,
  0xF0, 0x38, 0x21, 0x80, 0x84, 0x01, 0x10, 0x04, 0x40, 0x11, 0x00, 0x48,
  0x01, 0x20, 0x04, 0x80, 0x22, 0x00, 0x88, 0x02, 0x20, 0x11, 0x00, 0x46,
  0x02, 0x14, 0x18, 0x4F, 0x81, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x07, 0xC8, 0x41, 0x44, 0x06, 0x40, 0x12,
  0x00, 0xA0, 0x09, 0x00, 0x48, 0x02, 0x40, 0x14, 0x00, 0xA0, 0x05, 0x00,
  0x48, 0x02, 0x40, 0x11, 0x01, 0x88, 0x34, 0x3E, 0x20, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x13, 0x8A, 0x0A, 0x06,
  0x02, 0x01, 0x00, 0x80, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x00, 0x0F, 0xC1, 0x02, 0x20, 0x22, 0x01, 0x40, 0x12,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x40, 0x04, 0x80, 0x48,
  0x04, 0x80, 0x44, 0x18, 0x3E, 0x00, 0x10, 0x20, 0x40, 0x81, 0x1F, 0xC8,
  0x10, 0x20, 0x40, 0x82, 0x04, 0x08, 0x10, 0x20, 0x41, 0x02, 0x04, 0x08,
  0x0E, 0x00, 0x20, 0x14, 0x01, 0x40, 0x14, 0x01, 0x40, 0x14, 0x02, 0x40,
  0x28, 0x02, 0x80, 0x28, 0x02, 0x80, 0x48, 0x04, 0x80, 0x48, 0x0C, 0x81,
  0x4C, 0x34, 0x7C, 0x80, 0x80, 0x18, 0x02, 0x80, 0x24, 0x04, 0x40, 0x44,
  0x08, 0x40, 0x84, 0x10, 0x41, 0x02, 0x20, 0x22, 0x02, 0x40, 0x24, 0x02,
  0x80, 0x28, 0x01, 0x00, 0x10, 0x00, 0x80, 0x80, 0x60, 0x20, 0x28, 0x14,
  0x0A, 0x05, 0x02, 0x82, 0x41, 0x20, 0x90, 0x48, 0x44, 0x22, 0x11, 0x08,
  0x84, 0x44, 0x22, 0x11, 0x08, 0x84, 0x42, 0x41, 0x20, 0x50, 0x48, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x00, 0x80, 0x40, 0x20, 0x00, 0x08, 0x04, 0x10,
  0x10, 0x10, 0x20, 0x20, 0x80, 0x42, 0x00, 0x48, 0x00, 0x90, 0x00, 0xC0,
  0x01, 0x00, 0x05, 0x00, 0x12, 0x00, 0x22, 0x00, 0x84, 0x02, 0x04, 0x08,
  0x08, 0x10, 0x10, 0x40, 0x10, 0x10, 0x02, 0x20, 0x08, 0x20, 0x10, 0x40,
  0x40, 0x80, 0x81, 0x02, 0x02, 0x04, 0x04, 0x08, 0x08, 0x20, 0x08, 0x40,
  0x11, 0x00, 0x22, 0x00, 0x48, 0x00, 0x90, 0x01, 0x40, 0x01, 0x80, 0x02,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00,
  0x70, 0x00, 0x1F, 0xF8, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x08, 0x00, 0xFF, 0xE0, 0x00, 0x40, 0x20, 0x10, 0x08, 0x02,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01,
  0x00, 0x80, 0xC0, 0x08, 0x02, 0x00, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x01, 0x00, 0x40, 0x0C, 0x00,
  0x08, 0x42, 0x21, 0x08, 0x42, 0x11, 0x08, 0x42, 0x10, 0x88, 0x42, 0x10,
  0x84, 0x42, 0x10, 0x84, 0x20, 0x04, 0x00, 0x80, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x06, 0x00, 0x40, 0x60, 0x20, 0x08, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x00, 0x1C,
  0x02, 0xC4, 0x05, 0x04, 0x14, 0x04, 0x28, 0x07, 0x80,
};

const GFXglyph RobotoCondensed_ThinItalic33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 5, 23, 6, 1, -23 },
  { 16, 5, 7, 8, 4, -25 },
  { 21, 17, 23, 16, 0, -23 },
  { 70, 14, 29, 15, 1, -26 },
  { 121, 16, 23, 21, 3, -23 },
  { 167, 15, 23, 17, 1, -23 },
  { 211, 3, 7, 5, 3, -25 },
  { 214, 9, 34, 9, 2, -26 },
  { 253, 9, 34, 9, -2, -26 },
  { 292, 13, 13, 13, 2, -23 },
  { 314, 14, 17, 16, 1, -19 },
  { 344, 4, 7, 6, -1, -3 },
  { 348, 7, 1, 9, 1, -11 },
  { 349, 2, 2, 7, 1, -2 },
  { 350, 13, 25, 11, -1, -23 },
  { 391, 13, 23, 15, 2, -23 },
  { 429, 6, 23, 15, 5, -23 },
  { 447, 13, 23, 15, 1, -23 },
  { 485, 14, 23, 15, 1, -23 },
  { 526, 13, 23, 15, 1, -23 },
  { 564, 14, 23, 15, 2, -23 },
  { 605, 12, 23, 15, 2, -23 },
  { 640, 13, 23, 15, 3, -23 },
  { 678, 14, 23, 15, 1, -23 },
  { 719, 13, 23, 15, 2, -23 },
  { 757, 5, 17, 6, 0, -17 },
  { 768, 6, 21, 6, -1, -17 },
  { 784, 13, 13, 15, 1, -17 },
  { 806, 12, 8, 16, 2, -15 },
  { 818, 12, 13, 15, 1, -17 },
  { 838, 10, 23, 12, 3, -23 },
  { 867, 23, 30, 26, 1, -23 },
  { 954, 16, 23, 17, -1, -23 },
  { 1000, 15, 23, 17, 1, -23 },
  { 1044, 15, 23, 18, 2, -23 },
  { 1088, 16, 23, 18, 1, -23 },
  { 1134, 16, 23, 16, 1, -23 },
  { 1180, 16, 23, 16, 1, -23 },
  { 1226, 16, 23, 19, 2, -23 },
  { 1272, 18, 23, 20, 1, -23 },
  { 1324, 5, 23, 8, 2, -23 },
  { 1339, 14, 23, 16, 1, -23 },
  { 1380, 17, 23, 18, 1, -23 },
  { 1429, 11, 23, 15, 1, -23 },
  { 1461, 22, 23, 24, 1, -23 },
  { 1525, 18, 23, 20, 1, -23 },
  { 1577, 16, 23, 19, 2, -23 },
  { 1623, 16, 23, 17, 1, -23 },
  { 1669, 16, 27, 19, 2, -23 },
  { 1723, 16, 23, 18, 1, -23 },
  { 1769, 16, 23, 17, 1, -23 },
  { 1815, 15, 23, 17, 3, -23 },
  { 1859, 16, 23, 19, 2, -23 },
  { 1905, 15, 23, 17, 3, -23 },
  { 1949, 23, 23, 25, 3, -23 },
  { 2016, 18, 23, 17, 0, -23 },
  { 2068, 15, 23, 17, 3, -23 },
  { 2112, 17, 23, 17, 0, -23 },
  { 2161, 9, 32, 7, 0, -27 },
  { 2197, 5, 25, 11, 3, -23 },
  { 2213, 9, 32, 7, -2, -27 },
  { 2249, 9, 12, 12, 2, -23 },
  { 2263, 12, 1, 12, -2, 0 },
  { 2265, 3, 4, 8, 5, -24 },
  { 2267, 13, 17, 15, 0, -17 },
  { 2295, 13, 25, 15, 1, -25 },
  { 2336, 12, 17, 14, 1, -17 },
  { 2362, 15, 25, 16, 1, -25 },
  { 2409, 12, 17, 14, 1, -17 },
  { 2435, 10, 25, 9, 2, -25 },
  { 2467, 14, 24, 16, 0, -17 },
  { 2509, 12, 25, 15, 1, -25 },
  { 2547, 5, 24, 6, 1, -24 },
  { 2562, 10, 31, 7, -4, -24 },
  { 2601, 13, 25, 14, 1, -25 },
  { 2642, 5, 25, 6, 1, -25 },
  { 2658, 22, 17, 25, 1, -17 },
  { 2705, 12, 17, 15, 1, -17 },
  { 2731, 13, 17, 16, 1, -17 },
  { 2759, 14, 24, 15, 0, -17 },
  { 2801, 13, 24, 15, 1, -17 },
  { 2840, 9, 17, 10, 1, -17 },
  { 2860, 12, 17, 14, 1, -17 },
  { 2886, 7, 22, 9, 2, -22 },
  { 2906, 12, 17, 15, 2, -17 },
  { 2932, 12, 17, 14, 2, -17 },
  { 2958, 18, 17, 21, 3, -17 },
  { 2997, 15, 17, 14, -1, -17 },
  { 3029, 15, 24, 14, -1, -17 },
  { 3074, 13, 17, 14, 0, -17 },
  { 3102, 10, 33, 9, 1, -26 },
  { 3144, 5, 27, 6, 1, -23 },
  { 3161, 10, 33, 9, -2, -26 },
  { 3203, 15, 5, 19, 2, -12 },
};

const GFXfont RobotoCondensed_ThinItalic33pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ThinItalic33pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ThinItalic33pt7bGlyphs,
  0x20, 0x7E, 39
};

#endif // _ROBOTOCONDENSED_THINITALIC33PT7B_H_
