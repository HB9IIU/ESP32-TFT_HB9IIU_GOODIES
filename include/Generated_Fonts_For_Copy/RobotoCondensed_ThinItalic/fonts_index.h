#pragma once

// Auto-generated by fontMaker.py
#include <TFT_eSPI.h>

struct FontEntry
{
  const GFXfont *font;
  uint16_t sizePt;
  const char *name;
};

// Includes are in all_fonts.h (include that before this file)
static const FontEntry kFonts[] = {
  { &RobotoCondensed_ThinItalic6pt7b, 6, "RobotoCondensed_ThinItalic6pt7b" },
  { &RobotoCondensed_ThinItalic7pt7b, 7, "RobotoCondensed_ThinItalic7pt7b" },
  { &RobotoCondensed_ThinItalic8pt7b, 8, "RobotoCondensed_ThinItalic8pt7b" },
  { &RobotoCondensed_ThinItalic9pt7b, 9, "RobotoCondensed_ThinItalic9pt7b" },
  { &RobotoCondensed_ThinItalic10pt7b, 10, "RobotoCondensed_ThinItalic10pt7b" },
  { &RobotoCondensed_ThinItalic11pt7b, 11, "RobotoCondensed_ThinItalic11pt7b" },
  { &RobotoCondensed_ThinItalic12pt7b, 12, "RobotoCondensed_ThinItalic12pt7b" },
  { &RobotoCondensed_ThinItalic13pt7b, 13, "RobotoCondensed_ThinItalic13pt7b" },
  { &RobotoCondensed_ThinItalic14pt7b, 14, "RobotoCondensed_ThinItalic14pt7b" },
  { &RobotoCondensed_ThinItalic15pt7b, 15, "RobotoCondensed_ThinItalic15pt7b" },
  { &RobotoCondensed_ThinItalic16pt7b, 16, "RobotoCondensed_ThinItalic16pt7b" },
  { &RobotoCondensed_ThinItalic17pt7b, 17, "RobotoCondensed_ThinItalic17pt7b" },
  { &RobotoCondensed_ThinItalic18pt7b, 18, "RobotoCondensed_ThinItalic18pt7b" },
  { &RobotoCondensed_ThinItalic19pt7b, 19, "RobotoCondensed_ThinItalic19pt7b" },
  { &RobotoCondensed_ThinItalic20pt7b, 20, "RobotoCondensed_ThinItalic20pt7b" },
  { &RobotoCondensed_ThinItalic21pt7b, 21, "RobotoCondensed_ThinItalic21pt7b" },
  { &RobotoCondensed_ThinItalic22pt7b, 22, "RobotoCondensed_ThinItalic22pt7b" },
  { &RobotoCondensed_ThinItalic23pt7b, 23, "RobotoCondensed_ThinItalic23pt7b" },
  { &RobotoCondensed_ThinItalic24pt7b, 24, "RobotoCondensed_ThinItalic24pt7b" },
  { &RobotoCondensed_ThinItalic25pt7b, 25, "RobotoCondensed_ThinItalic25pt7b" },
  { &RobotoCondensed_ThinItalic26pt7b, 26, "RobotoCondensed_ThinItalic26pt7b" },
  { &RobotoCondensed_ThinItalic27pt7b, 27, "RobotoCondensed_ThinItalic27pt7b" },
  { &RobotoCondensed_ThinItalic28pt7b, 28, "RobotoCondensed_ThinItalic28pt7b" },
  { &RobotoCondensed_ThinItalic29pt7b, 29, "RobotoCondensed_ThinItalic29pt7b" },
  { &RobotoCondensed_ThinItalic30pt7b, 30, "RobotoCondensed_ThinItalic30pt7b" },
  { &RobotoCondensed_ThinItalic31pt7b, 31, "RobotoCondensed_ThinItalic31pt7b" },
  { &RobotoCondensed_ThinItalic32pt7b, 32, "RobotoCondensed_ThinItalic32pt7b" },
  { &RobotoCondensed_ThinItalic33pt7b, 33, "RobotoCondensed_ThinItalic33pt7b" },
  { &RobotoCondensed_ThinItalic34pt7b, 34, "RobotoCondensed_ThinItalic34pt7b" },
  { &RobotoCondensed_ThinItalic35pt7b, 35, "RobotoCondensed_ThinItalic35pt7b" },
  { &RobotoCondensed_ThinItalic36pt7b, 36, "RobotoCondensed_ThinItalic36pt7b" },
  { &RobotoCondensed_ThinItalic37pt7b, 37, "RobotoCondensed_ThinItalic37pt7b" },
  { &RobotoCondensed_ThinItalic38pt7b, 38, "RobotoCondensed_ThinItalic38pt7b" },
  { &RobotoCondensed_ThinItalic39pt7b, 39, "RobotoCondensed_ThinItalic39pt7b" },
  { &RobotoCondensed_ThinItalic40pt7b, 40, "RobotoCondensed_ThinItalic40pt7b" },
  { &RobotoCondensed_ThinItalic41pt7b, 41, "RobotoCondensed_ThinItalic41pt7b" },
  { &RobotoCondensed_ThinItalic42pt7b, 42, "RobotoCondensed_ThinItalic42pt7b" },
  { &RobotoCondensed_ThinItalic43pt7b, 43, "RobotoCondensed_ThinItalic43pt7b" },
  { &RobotoCondensed_ThinItalic44pt7b, 44, "RobotoCondensed_ThinItalic44pt7b" },
  { &RobotoCondensed_ThinItalic45pt7b, 45, "RobotoCondensed_ThinItalic45pt7b" },
  { &RobotoCondensed_ThinItalic46pt7b, 46, "RobotoCondensed_ThinItalic46pt7b" },
  { &RobotoCondensed_ThinItalic47pt7b, 47, "RobotoCondensed_ThinItalic47pt7b" },
  { &RobotoCondensed_ThinItalic48pt7b, 48, "RobotoCondensed_ThinItalic48pt7b" },
  { &RobotoCondensed_ThinItalic49pt7b, 49, "RobotoCondensed_ThinItalic49pt7b" },
  { &RobotoCondensed_ThinItalic50pt7b, 50, "RobotoCondensed_ThinItalic50pt7b" },
  { &RobotoCondensed_ThinItalic51pt7b, 51, "RobotoCondensed_ThinItalic51pt7b" },
  { &RobotoCondensed_ThinItalic52pt7b, 52, "RobotoCondensed_ThinItalic52pt7b" },
  { &RobotoCondensed_ThinItalic53pt7b, 53, "RobotoCondensed_ThinItalic53pt7b" },
  { &RobotoCondensed_ThinItalic54pt7b, 54, "RobotoCondensed_ThinItalic54pt7b" },
  { &RobotoCondensed_ThinItalic55pt7b, 55, "RobotoCondensed_ThinItalic55pt7b" },
  { &RobotoCondensed_ThinItalic56pt7b, 56, "RobotoCondensed_ThinItalic56pt7b" },
  { &RobotoCondensed_ThinItalic57pt7b, 57, "RobotoCondensed_ThinItalic57pt7b" },
  { &RobotoCondensed_ThinItalic58pt7b, 58, "RobotoCondensed_ThinItalic58pt7b" },
  { &RobotoCondensed_ThinItalic59pt7b, 59, "RobotoCondensed_ThinItalic59pt7b" },
  { &RobotoCondensed_ThinItalic60pt7b, 60, "RobotoCondensed_ThinItalic60pt7b" },
  { &RobotoCondensed_ThinItalic61pt7b, 61, "RobotoCondensed_ThinItalic61pt7b" },
  { &RobotoCondensed_ThinItalic62pt7b, 62, "RobotoCondensed_ThinItalic62pt7b" },
  { &RobotoCondensed_ThinItalic63pt7b, 63, "RobotoCondensed_ThinItalic63pt7b" },
  { &RobotoCondensed_ThinItalic64pt7b, 64, "RobotoCondensed_ThinItalic64pt7b" },
  { &RobotoCondensed_ThinItalic65pt7b, 65, "RobotoCondensed_ThinItalic65pt7b" },
  { &RobotoCondensed_ThinItalic66pt7b, 66, "RobotoCondensed_ThinItalic66pt7b" },
  { &RobotoCondensed_ThinItalic67pt7b, 67, "RobotoCondensed_ThinItalic67pt7b" },
  { &RobotoCondensed_ThinItalic68pt7b, 68, "RobotoCondensed_ThinItalic68pt7b" },
  { &RobotoCondensed_ThinItalic69pt7b, 69, "RobotoCondensed_ThinItalic69pt7b" },
  { &RobotoCondensed_ThinItalic70pt7b, 70, "RobotoCondensed_ThinItalic70pt7b" },
  { &RobotoCondensed_ThinItalic71pt7b, 71, "RobotoCondensed_ThinItalic71pt7b" },
  { &RobotoCondensed_ThinItalic72pt7b, 72, "RobotoCondensed_ThinItalic72pt7b" },
};
static constexpr size_t kFontCount = sizeof(kFonts) / sizeof(kFonts[0]);
