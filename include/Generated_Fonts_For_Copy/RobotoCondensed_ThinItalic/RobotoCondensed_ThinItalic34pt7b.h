#ifndef _ROBOTOCONDENSED_THINITALIC34PT7B_H_
#define _ROBOTOCONDENSED_THINITALIC34PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ThinItalic.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ThinItalic34pt7bBitmaps[] PROGMEM = {
  0x00, 0x08, 0x42, 0x21, 0x08, 0x42, 0x21, 0x08, 0x42, 0x11, 0x08, 0x40,
  0x00, 0x00, 0x02, 0x10, 0x4A, 0x53, 0x19, 0x4A, 0x40, 0x00, 0x42, 0x00,
  0x41, 0x00, 0x20, 0x80, 0x10, 0x80, 0x10, 0x40, 0x08, 0x20, 0x04, 0x20,
  0x7F, 0xFF, 0x02, 0x08, 0x01, 0x08, 0x01, 0x04, 0x00, 0x82, 0x00, 0x42,
  0x00, 0x41, 0x00, 0x20, 0x80, 0x10, 0x80, 0xFF, 0xFC, 0x08, 0x20, 0x04,
  0x20, 0x04, 0x10, 0x02, 0x08, 0x01, 0x08, 0x01, 0x04, 0x00, 0x82, 0x00,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x7C, 0x06, 0x08, 0x30, 0x30, 0x80,
  0x44, 0x01, 0x10, 0x04, 0x40, 0x11, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x01, 0x00, 0x04, 0x80,
  0x0A, 0x00, 0x48, 0x01, 0x10, 0x04, 0x40, 0x20, 0x83, 0x01, 0xF0, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x1E, 0x00, 0x23, 0x00, 0x41, 0x00, 0x41,
  0x02, 0x81, 0x04, 0x81, 0x08, 0x81, 0x08, 0x82, 0x10, 0x82, 0x20, 0x44,
  0x40, 0x38, 0x40, 0x00, 0x80, 0x01, 0x00, 0x01, 0x1E, 0x02, 0x22, 0x04,
  0x41, 0x08, 0x41, 0x08, 0x81, 0x10, 0x81, 0x20, 0x81, 0x20, 0x82, 0x00,
  0x82, 0x00, 0x44, 0x00, 0x38, 0x01, 0xE0, 0x04, 0x20, 0x10, 0x40, 0x20,
  0x40, 0x81, 0x01, 0x02, 0x02, 0x08, 0x04, 0x10, 0x08, 0xC0, 0x0A, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x90, 0x02, 0x20, 0x48, 0x20, 0xA0, 0x42, 0x40,
  0x45, 0x00, 0x8A, 0x00, 0xA4, 0x00, 0xC8, 0x01, 0x08, 0x05, 0x18, 0x32,
  0x0F, 0x82, 0x29, 0x24, 0x90, 0x00, 0x80, 0x80, 0x80, 0x80, 0x40, 0x40,
  0x20, 0x20, 0x10, 0x10, 0x08, 0x04, 0x04, 0x02, 0x01, 0x00, 0x80, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x01, 0x00, 0x80, 0x40, 0x10, 0x04, 0x00, 0x04, 0x01, 0x00,
  0x40, 0x20, 0x10, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x20, 0x10, 0x08, 0x04, 0x04,
  0x02, 0x01, 0x01, 0x00, 0x80, 0x80, 0x40, 0x40, 0x20, 0x20, 0x20, 0x20,
  0x00, 0x01, 0x00, 0x08, 0x00, 0x40, 0x04, 0x08, 0x20, 0xB9, 0x38, 0x3E,
  0x00, 0xC0, 0x09, 0x00, 0xC8, 0x04, 0x20, 0x41, 0x04, 0x04, 0x00, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x7F, 0xFC, 0x04, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x01, 0x00, 0x04, 0x00, 0x22, 0x22, 0x64, 0x80, 0xFE, 0xB0, 0x00,
  0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00,
  0x10, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00,
  0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00,
  0x80, 0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x00, 0x03, 0xE0, 0x21,
  0x82, 0x04, 0x20, 0x12, 0x00, 0x90, 0x04, 0x80, 0x28, 0x01, 0x40, 0x0A,
  0x00, 0x50, 0x03, 0x00, 0x28, 0x01, 0x40, 0x0A, 0x00, 0x50, 0x02, 0x80,
  0x24, 0x01, 0x20, 0x09, 0x00, 0x88, 0x04, 0x40, 0x41, 0x04, 0x07, 0xC0,
  0x06, 0x37, 0x90, 0x20, 0x40, 0x81, 0x02, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x82, 0x04, 0x08, 0x10, 0x03, 0xE0, 0x10,
  0x60, 0x80, 0x84, 0x02, 0x10, 0x04, 0x80, 0x12, 0x00, 0x40, 0x02, 0x00,
  0x08, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x80, 0x04,
  0x00, 0x3F, 0xFC, 0x01, 0xF0, 0x18, 0x60, 0x80, 0x82, 0x01, 0x10, 0x04,
  0x40, 0x12, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x01, 0xF0,
  0x00, 0x60, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x0A, 0x00, 0x28, 0x01,
  0x20, 0x04, 0xC0, 0x21, 0x00, 0x82, 0x0C, 0x07, 0xC0, 0x00, 0x08, 0x00,
  0x60, 0x02, 0x80, 0x0A, 0x00, 0x48, 0x02, 0x40, 0x11, 0x00, 0x44, 0x02,
  0x10, 0x10, 0x40, 0x81, 0x02, 0x08, 0x10, 0x20, 0x80, 0x86, 0x02, 0x10,
  0x08, 0xFF, 0xFC, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x08, 0x00, 0x20, 0x0F, 0xFC, 0x20, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00, 0x9E, 0x03, 0x86, 0x08, 0x08,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x12, 0x00, 0x48, 0x01,
  0x20, 0x08, 0x40, 0x21, 0x01, 0x02, 0x08, 0x07, 0xC0, 0x00, 0xF0, 0x30,
  0x04, 0x00, 0x80, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x47, 0x85, 0x86,
  0x60, 0x2C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x28, 0x02, 0x80, 0x44, 0x0C, 0x61, 0x81, 0xE0, 0xFF, 0xF8, 0x00,
  0x40, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x80,
  0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08,
  0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00,
  0x01, 0xF0, 0x0C, 0x10, 0x20, 0x10, 0x40, 0x21, 0x00, 0x42, 0x00, 0x88,
  0x01, 0x10, 0x02, 0x10, 0x08, 0x20, 0x30, 0x20, 0xC0, 0x3E, 0x01, 0x86,
  0x04, 0x02, 0x10, 0x04, 0x20, 0x04, 0x80, 0x09, 0x00, 0x12, 0x00, 0x24,
  0x00, 0x88, 0x01, 0x08, 0x04, 0x18, 0x30, 0x0F, 0x80, 0x07, 0xC0, 0x41,
  0x84, 0x04, 0x40, 0x12, 0x00, 0xA0, 0x05, 0x00, 0x28, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x06, 0x80, 0x24, 0x03, 0x20, 0x28, 0x82, 0x43, 0xE4, 0x00,
  0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x80, 0x18, 0x0F, 0x00,
  0x08, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x46, 0x00,
  0x04, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08,
  0x20, 0x82, 0x10, 0x42, 0x00, 0x00, 0x10, 0x06, 0x01, 0x80, 0x60, 0x08,
  0x03, 0x00, 0xC0, 0x08, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x00,
  0x80, 0x04, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00,
  0x30, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x30, 0x06, 0x00,
  0x40, 0x00, 0x0F, 0x0C, 0x26, 0x05, 0x01, 0x80, 0x60, 0x10, 0x04, 0x02,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x02, 0x01, 0x00, 0x80, 0x20, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x01, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x70, 0x10, 0x00, 0xC0, 0x0C, 0x01, 0x00, 0x04, 0x02, 0x00, 0x02, 0x04,
  0x00, 0x02, 0x08, 0x00, 0x02, 0x08, 0x0F, 0x01, 0x10, 0x10, 0x81, 0x10,
  0x20, 0x81, 0x20, 0x40, 0x81, 0x20, 0x80, 0x81, 0x40, 0x80, 0x81, 0x41,
  0x01, 0x02, 0x41, 0x01, 0x02, 0x41, 0x01, 0x02, 0x82, 0x02, 0x02, 0x82,
  0x02, 0x04, 0x82, 0x02, 0x04, 0x82, 0x06, 0x08, 0x82, 0x0A, 0x08, 0x81,
  0x12, 0x10, 0x81, 0xE1, 0xE0, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C,
  0x0C, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x18, 0x00, 0x18, 0x00, 0x28, 0x00,
  0x28, 0x00, 0x48, 0x00, 0x48, 0x00, 0x84, 0x00, 0x84, 0x01, 0x04, 0x01,
  0x04, 0x01, 0x04, 0x02, 0x04, 0x02, 0x04, 0x04, 0x02, 0x04, 0x02, 0x08,
  0x02, 0x0F, 0xFE, 0x10, 0x02, 0x10, 0x02, 0x20, 0x02, 0x20, 0x01, 0x40,
  0x01, 0x40, 0x01, 0x80, 0x01, 0x0F, 0xF0, 0x08, 0x0C, 0x08, 0x02, 0x08,
  0x02, 0x08, 0x02, 0x10, 0x02, 0x10, 0x02, 0x10, 0x02, 0x10, 0x04, 0x10,
  0x04, 0x10, 0x18, 0x3F, 0xE0, 0x20, 0x18, 0x20, 0x0C, 0x20, 0x04, 0x20,
  0x04, 0x20, 0x04, 0x40, 0x04, 0x40, 0x04, 0x40, 0x04, 0x40, 0x08, 0x40,
  0x10, 0x80, 0x20, 0xFF, 0xC0, 0x01, 0xF8, 0x06, 0x04, 0x08, 0x02, 0x10,
  0x02, 0x10, 0x01, 0x20, 0x01, 0x20, 0x01, 0x20, 0x01, 0x40, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x04, 0x80, 0x04, 0x80, 0x08, 0x80, 0x08, 0x40, 0x10, 0x40,
  0x30, 0x20, 0x60, 0x1F, 0x80, 0x0F, 0xF8, 0x04, 0x02, 0x02, 0x00, 0x81,
  0x00, 0x20, 0x80, 0x10, 0x80, 0x04, 0x40, 0x02, 0x20, 0x01, 0x10, 0x00,
  0x88, 0x00, 0x44, 0x00, 0x44, 0x00, 0x22, 0x00, 0x11, 0x00, 0x08, 0x80,
  0x04, 0x40, 0x04, 0x20, 0x02, 0x20, 0x01, 0x10, 0x01, 0x08, 0x00, 0x84,
  0x00, 0x82, 0x00, 0x82, 0x01, 0x81, 0xFF, 0x00, 0x0F, 0xFF, 0x84, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x07, 0xFF, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x02, 0x00, 0x01, 0xFF, 0xF0, 0x0F,
  0xFF, 0x84, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x07, 0xFF,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x01, 0xF8, 0x01, 0x03, 0x01, 0x00, 0x81, 0x00, 0x21, 0x00,
  0x10, 0x80, 0x08, 0x80, 0x04, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x07, 0xF1, 0x00, 0x09, 0x00, 0x04,
  0x80, 0x02, 0x40, 0x01, 0x20, 0x01, 0x08, 0x00, 0x84, 0x00, 0x41, 0x00,
  0x60, 0xC0, 0xC0, 0x1F, 0x80, 0x08, 0x00, 0x21, 0x00, 0x08, 0x20, 0x01,
  0x04, 0x00, 0x20, 0x80, 0x04, 0x20, 0x00, 0x84, 0x00, 0x10, 0x80, 0x04,
  0x10, 0x00, 0x82, 0x00, 0x10, 0x40, 0x02, 0x1F, 0xFF, 0xC2, 0x00, 0x08,
  0x40, 0x02, 0x08, 0x00, 0x41, 0x00, 0x08, 0x20, 0x01, 0x08, 0x00, 0x21,
  0x00, 0x04, 0x20, 0x01, 0x04, 0x00, 0x20, 0x80, 0x04, 0x20, 0x00, 0x84,
  0x00, 0x10, 0x08, 0x44, 0x21, 0x08, 0x42, 0x21, 0x08, 0x42, 0x11, 0x08,
  0x42, 0x10, 0x88, 0x42, 0x10, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x11, 0x00, 0x42, 0x00, 0x84, 0x01, 0x08, 0x04, 0x10, 0x18, 0x10, 0x60,
  0x1F, 0x00, 0x08, 0x00, 0x82, 0x00, 0x40, 0x80, 0x20, 0x20, 0x10, 0x08,
  0x08, 0x04, 0x04, 0x01, 0x02, 0x00, 0x41, 0x00, 0x10, 0x80, 0x04, 0x40,
  0x01, 0x20, 0x00, 0x94, 0x00, 0x29, 0x00, 0x0C, 0x20, 0x02, 0x08, 0x00,
  0x81, 0x00, 0x20, 0x40, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x40, 0x40,
  0x18, 0x10, 0x02, 0x08, 0x00, 0x42, 0x00, 0x10, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x07, 0xFF, 0x0C, 0x00, 0x02, 0x18, 0x00, 0x0C, 0x30,
  0x00, 0x28, 0x60, 0x00, 0x50, 0xA0, 0x01, 0x42, 0x40, 0x02, 0x84, 0x80,
  0x09, 0x09, 0x00, 0x12, 0x12, 0x00, 0x44, 0x24, 0x00, 0x90, 0x44, 0x02,
  0x21, 0x08, 0x04, 0x42, 0x10, 0x10, 0x84, 0x20, 0x21, 0x08, 0x40, 0x82,
  0x10, 0x41, 0x08, 0x20, 0x84, 0x10, 0x81, 0x10, 0x21, 0x02, 0x20, 0x42,
  0x04, 0x80, 0x84, 0x05, 0x01, 0x08, 0x0C, 0x04, 0x10, 0x18, 0x08, 0x40,
  0x20, 0x10, 0x0C, 0x00, 0x21, 0x80, 0x04, 0x30, 0x01, 0x05, 0x00, 0x20,
  0xA0, 0x04, 0x22, 0x00, 0x84, 0x40, 0x10, 0x88, 0x02, 0x10, 0x80, 0x82,
  0x10, 0x10, 0x41, 0x02, 0x10, 0x20, 0x42, 0x04, 0x08, 0x40, 0x41, 0x08,
  0x08, 0x41, 0x01, 0x08, 0x20, 0x11, 0x08, 0x02, 0x21, 0x00, 0x24, 0x20,
  0x04, 0x84, 0x00, 0xA0, 0x80, 0x0C, 0x10, 0x01, 0x84, 0x00, 0x10, 0x01,
  0xF8, 0x06, 0x04, 0x08, 0x02, 0x10, 0x01, 0x10, 0x01, 0x20, 0x01, 0x20,
  0x01, 0x40, 0x01, 0x40, 0x01, 0x40, 0x01, 0x40, 0x01, 0x40, 0x01, 0x80,
  0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x04, 0x80,
  0x04, 0x80, 0x08, 0x80, 0x08, 0x40, 0x10, 0x20, 0x60, 0x1F, 0x80, 0x0F,
  0xF8, 0x08, 0x06, 0x08, 0x02, 0x08, 0x01, 0x08, 0x01, 0x10, 0x01, 0x10,
  0x01, 0x10, 0x01, 0x10, 0x01, 0x10, 0x02, 0x10, 0x02, 0x20, 0x04, 0x20,
  0x18, 0x3F, 0xE0, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80, 0x00, 0x01,
  0xF8, 0x06, 0x04, 0x08, 0x02, 0x10, 0x01, 0x10, 0x01, 0x20, 0x01, 0x20,
  0x01, 0x40, 0x01, 0x40, 0x01, 0x40, 0x01, 0x40, 0x01, 0x40, 0x01, 0x80,
  0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x04, 0x80,
  0x04, 0x80, 0x08, 0x80, 0x08, 0x40, 0x10, 0x20, 0x60, 0x1F, 0xC0, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0x0F, 0xF8, 0x08, 0x06, 0x08,
  0x02, 0x08, 0x01, 0x08, 0x01, 0x10, 0x01, 0x10, 0x01, 0x10, 0x01, 0x10,
  0x01, 0x10, 0x02, 0x10, 0x02, 0x20, 0x04, 0x20, 0x08, 0x3F, 0xF0, 0x20,
  0x20, 0x20, 0x20, 0x40, 0x20, 0x40, 0x10, 0x40, 0x10, 0x40, 0x08, 0x40,
  0x08, 0x40, 0x08, 0x80, 0x04, 0x80, 0x04, 0x01, 0xF8, 0x06, 0x06, 0x08,
  0x02, 0x18, 0x01, 0x10, 0x01, 0x10, 0x01, 0x20, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x04, 0x80, 0x04, 0x80, 0x04, 0x80, 0x04, 0x80,
  0x08, 0x40, 0x10, 0x20, 0x60, 0x1F, 0x80, 0xFF, 0xFF, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x88, 0x00, 0x44,
  0x00, 0x22, 0x00, 0x22, 0x00, 0x11, 0x00, 0x08, 0x80, 0x04, 0x40, 0x02,
  0x20, 0x02, 0x10, 0x01, 0x10, 0x00, 0x88, 0x00, 0x44, 0x00, 0x22, 0x00,
  0x11, 0x00, 0x11, 0x00, 0x08, 0x80, 0x04, 0x40, 0x02, 0x20, 0x01, 0x10,
  0x01, 0x04, 0x01, 0x82, 0x01, 0x80, 0x81, 0x80, 0x3F, 0x00, 0x80, 0x01,
  0x80, 0x02, 0x80, 0x02, 0x80, 0x04, 0x40, 0x04, 0x40, 0x08, 0x40, 0x08,
  0x40, 0x10, 0x40, 0x10, 0x40, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x40,
  0x20, 0x40, 0x20, 0x80, 0x20, 0x80, 0x21, 0x00, 0x11, 0x00, 0x12, 0x00,
  0x12, 0x00, 0x14, 0x00, 0x14, 0x00, 0x18, 0x00, 0x08, 0x00, 0x80, 0x08,
  0x01, 0x80, 0x18, 0x02, 0x80, 0x18, 0x02, 0x40, 0x28, 0x02, 0x40, 0x28,
  0x04, 0x40, 0x48, 0x04, 0x40, 0x48, 0x04, 0x40, 0x48, 0x08, 0x40, 0x84,
  0x08, 0x40, 0x84, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04,
  0x20, 0x42, 0x04, 0x20, 0x42, 0x04, 0x20, 0x44, 0x04, 0x40, 0x44, 0x04,
  0x40, 0x44, 0x04, 0x80, 0x28, 0x04, 0x80, 0x28, 0x02, 0x80, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x20, 0x03, 0x00, 0x20, 0x02, 0x00, 0x04, 0x00,
  0x20, 0x80, 0x08, 0x08, 0x02, 0x01, 0x00, 0x40, 0x20, 0x10, 0x02, 0x04,
  0x00, 0x41, 0x80, 0x04, 0x20, 0x00, 0x88, 0x00, 0x0A, 0x00, 0x01, 0x40,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x40, 0x00, 0x44, 0x00, 0x08, 0x80,
  0x02, 0x08, 0x00, 0x81, 0x00, 0x10, 0x20, 0x04, 0x02, 0x01, 0x00, 0x40,
  0x40, 0x04, 0x08, 0x00, 0x82, 0x00, 0x08, 0x80, 0x01, 0x40, 0x02, 0x40,
  0x04, 0x40, 0x04, 0x20, 0x08, 0x20, 0x10, 0x20, 0x10, 0x10, 0x20, 0x10,
  0x40, 0x10, 0x40, 0x08, 0x80, 0x09, 0x00, 0x09, 0x00, 0x06, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0xFF,
  0xF0, 0x07, 0x82, 0x01, 0x00, 0x80, 0x40, 0x20, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0xF0, 0x00, 0x42, 0x10, 0x84, 0x21, 0x04, 0x21, 0x08, 0x42, 0x10,
  0x42, 0x10, 0x84, 0x21, 0x04, 0x21, 0x08, 0x40, 0x07, 0x80, 0x40, 0x20,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x80, 0x40, 0x20, 0xF0, 0x00, 0x02, 0x03,
  0x01, 0x81, 0x20, 0x90, 0x88, 0x44, 0x42, 0x21, 0x20, 0x50, 0x30, 0x10,
  0xFF, 0xF0, 0x89, 0x10, 0x03, 0xE0, 0x10, 0x60, 0x80, 0x84, 0x02, 0x10,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x07, 0xF8, 0x60, 0x22, 0x01, 0x10,
  0x04, 0x40, 0x11, 0x00, 0x48, 0x03, 0x10, 0x14, 0x41, 0xA0, 0xF8, 0x80,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x13, 0xE0, 0xA0, 0x8A, 0x02, 0x60, 0x12, 0x00, 0x90, 0x04, 0x80,
  0x24, 0x01, 0x40, 0x0A, 0x00, 0x50, 0x02, 0x80, 0x24, 0x01, 0x20, 0x0B,
  0x00, 0x98, 0x0C, 0xA0, 0xC4, 0xF8, 0x00, 0x07, 0xC0, 0x41, 0x84, 0x04,
  0x40, 0x12, 0x00, 0xA0, 0x05, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x02, 0x40, 0x12, 0x00, 0x88, 0x08, 0x60, 0x80, 0xF8,
  0x00, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x07, 0xC4, 0x10, 0x48, 0x40, 0x61, 0x00, 0x42,
  0x00, 0x88, 0x01, 0x10, 0x02, 0x20, 0x08, 0x40, 0x10, 0x80, 0x22, 0x00,
  0x44, 0x00, 0x88, 0x01, 0x10, 0x04, 0x10, 0x08, 0x20, 0x30, 0x60, 0xA0,
  0x3E, 0x40, 0x07, 0xC0, 0x41, 0x84, 0x04, 0x40, 0x12, 0x00, 0xA0, 0x05,
  0x00, 0x2F, 0xFE, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x08, 0x00, 0x20, 0xC0, 0xF8, 0x00, 0x03, 0xC1, 0x00, 0xC0,
  0x20, 0x08, 0x04, 0x01, 0x00, 0x40, 0xFF, 0x04, 0x01, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x02, 0x00, 0x80, 0x20, 0x00, 0x03, 0xE2, 0x08, 0x24, 0x20, 0x30, 0x80,
  0x21, 0x00, 0x44, 0x00, 0x88, 0x01, 0x10, 0x04, 0x20, 0x08, 0x40, 0x11,
  0x00, 0x22, 0x00, 0x44, 0x00, 0x88, 0x02, 0x08, 0x04, 0x10, 0x18, 0x30,
  0x50, 0x3F, 0x20, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x04, 0x20, 0x10,
  0x30, 0x40, 0x1F, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x11, 0xE0, 0xB0, 0x8A, 0x02, 0x50, 0x13,
  0x00, 0x90, 0x04, 0x80, 0x24, 0x01, 0x40, 0x12, 0x00, 0x90, 0x04, 0x80,
  0x24, 0x01, 0x20, 0x0A, 0x00, 0x90, 0x04, 0x80, 0x24, 0x01, 0x00, 0x08,
  0x40, 0x00, 0x00, 0x02, 0x10, 0x84, 0x42, 0x10, 0x84, 0x42, 0x10, 0x84,
  0x22, 0x10, 0x80, 0x00, 0x20, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x08, 0x07, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x08, 0x80, 0x88, 0x18, 0x41, 0x82, 0x18,
  0x11, 0x80, 0x98, 0x05, 0x00, 0x54, 0x03, 0x20, 0x10, 0x80, 0x84, 0x04,
  0x10, 0x20, 0x82, 0x02, 0x10, 0x10, 0x80, 0x44, 0x02, 0x00, 0x08, 0x42,
  0x10, 0x88, 0x42, 0x10, 0x84, 0x42, 0x10, 0x84, 0x22, 0x10, 0x84, 0x21,
  0x10, 0x84, 0x00, 0x11, 0xE0, 0xF8, 0x2C, 0x22, 0x08, 0xA0, 0x28, 0x11,
  0x80, 0x60, 0x13, 0x00, 0x80, 0x24, 0x01, 0x00, 0x48, 0x02, 0x00, 0xA0,
  0x08, 0x02, 0x40, 0x10, 0x04, 0x80, 0x20, 0x09, 0x00, 0x40, 0x12, 0x00,
  0x80, 0x24, 0x01, 0x00, 0x50, 0x04, 0x01, 0x20, 0x08, 0x02, 0x40, 0x10,
  0x04, 0x80, 0x20, 0x09, 0x00, 0x40, 0x10, 0x11, 0xE0, 0xB0, 0x86, 0x02,
  0x50, 0x13, 0x00, 0x90, 0x04, 0x80, 0x24, 0x01, 0x40, 0x12, 0x00, 0x90,
  0x04, 0x80, 0x24, 0x01, 0x20, 0x0A, 0x00, 0x90, 0x04, 0x80, 0x24, 0x01,
  0x00, 0x03, 0xE0, 0x60, 0x84, 0x02, 0x60, 0x12, 0x00, 0xA0, 0x05, 0x00,
  0x28, 0x01, 0x40, 0x0A, 0x00, 0x60, 0x03, 0x00, 0x28, 0x01, 0x40, 0x09,
  0x00, 0x88, 0x08, 0x20, 0xC0, 0xF8, 0x00, 0x09, 0xF0, 0x28, 0x21, 0x40,
  0x46, 0x01, 0x10, 0x04, 0x40, 0x11, 0x00, 0x44, 0x01, 0x20, 0x04, 0x80,
  0x12, 0x00, 0x48, 0x02, 0x20, 0x08, 0x80, 0x26, 0x01, 0x18, 0x0C, 0x50,
  0x61, 0x3E, 0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x00, 0x07, 0xC4, 0x20, 0x91, 0x01, 0x88, 0x02, 0x20, 0x09,
  0x00, 0x24, 0x00, 0x90, 0x04, 0x40, 0x11, 0x00, 0x48, 0x01, 0x20, 0x04,
  0x80, 0x12, 0x00, 0x84, 0x02, 0x10, 0x18, 0x60, 0xA0, 0xFC, 0x80, 0x02,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x13,
  0xC5, 0x01, 0x80, 0xC0, 0x30, 0x08, 0x02, 0x00, 0x80, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x08, 0x02, 0x00, 0x80, 0x20, 0x00, 0x07, 0xC1,
  0x82, 0x20, 0x12, 0x01, 0x20, 0x12, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x40, 0x04, 0x00, 0x28, 0x02, 0x80, 0x48, 0x04, 0x41, 0x83,
  0xE0, 0x08, 0x20, 0x40, 0x81, 0x1F, 0xC4, 0x10, 0x20, 0x40, 0x81, 0x02,
  0x08, 0x10, 0x20, 0x40, 0x82, 0x04, 0x08, 0x08, 0x1C, 0x00, 0x20, 0x09,
  0x00, 0x50, 0x04, 0x80, 0x24, 0x01, 0x20, 0x09, 0x00, 0x48, 0x02, 0x80,
  0x24, 0x01, 0x20, 0x09, 0x00, 0x48, 0x02, 0x40, 0x22, 0x01, 0x10, 0x18,
  0x43, 0x41, 0xE2, 0x00, 0x80, 0x18, 0x01, 0x80, 0x24, 0x02, 0x40, 0x44,
  0x04, 0x40, 0x84, 0x08, 0x41, 0x02, 0x10, 0x22, 0x02, 0x20, 0x22, 0x02,
  0x40, 0x24, 0x01, 0x80, 0x18, 0x01, 0x00, 0x80, 0x40, 0x50, 0x18, 0x0A,
  0x03, 0x01, 0x40, 0xA0, 0x48, 0x14, 0x09, 0x04, 0x82, 0x20, 0x90, 0x44,
  0x22, 0x08, 0x84, 0x42, 0x10, 0x84, 0x42, 0x20, 0x90, 0x24, 0x12, 0x05,
  0x02, 0xC0, 0xA0, 0x50, 0x18, 0x0A, 0x03, 0x01, 0x80, 0x40, 0x30, 0x08,
  0x04, 0x00, 0x08, 0x06, 0x10, 0x08, 0x10, 0x20, 0x20, 0x80, 0x21, 0x00,
  0x44, 0x00, 0x90, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0A, 0x00, 0x22,
  0x00, 0x44, 0x01, 0x08, 0x04, 0x08, 0x10, 0x10, 0x20, 0x10, 0x80, 0x20,
  0x10, 0x02, 0x10, 0x02, 0x08, 0x04, 0x08, 0x04, 0x08, 0x08, 0x08, 0x08,
  0x08, 0x10, 0x08, 0x10, 0x04, 0x20, 0x04, 0x20, 0x04, 0x40, 0x04, 0x40,
  0x04, 0x40, 0x04, 0x80, 0x04, 0x80, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x00,
  0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x03, 0xFF, 0x80, 0x00, 0x20,
  0x18, 0x04, 0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x80, 0x20, 0x18, 0x00, 0x80,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x00, 0x80, 0x18, 0x01, 0x80, 0x08, 0x42, 0x11,
  0x08, 0x42, 0x10, 0x88, 0x42, 0x10, 0x84, 0x42, 0x10, 0x84, 0x23, 0x10,
  0x84, 0x21, 0x00, 0x04, 0x00, 0x80, 0x10, 0x04, 0x01, 0x00, 0x20, 0x08,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x00,
  0x80, 0x10, 0x18, 0x08, 0x02, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x20, 0x08, 0x02, 0x01, 0x00, 0x80, 0x60, 0x20, 0x00, 0x1C, 0x01,
  0x23, 0x02, 0x41, 0x82, 0x80, 0xC4, 0x80, 0x78,
};

const GFXglyph RobotoCondensed_ThinItalic34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 5, 24, 6, 1, -24 },
  { 16, 5, 7, 9, 4, -26 },
  { 21, 17, 24, 16, 1, -24 },
  { 72, 14, 30, 16, 1, -27 },
  { 125, 16, 24, 21, 3, -24 },
  { 173, 15, 24, 18, 1, -24 },
  { 218, 3, 7, 6, 3, -26 },
  { 221, 9, 35, 9, 2, -27 },
  { 261, 9, 35, 9, -2, -27 },
  { 301, 13, 13, 14, 2, -24 },
  { 323, 14, 17, 16, 1, -20 },
  { 353, 4, 7, 6, -1, -3 },
  { 357, 7, 1, 9, 1, -12 },
  { 358, 2, 2, 7, 1, -2 },
  { 359, 14, 26, 11, -1, -24 },
  { 405, 13, 24, 16, 2, -24 },
  { 444, 7, 24, 16, 5, -24 },
  { 465, 14, 24, 16, 1, -24 },
  { 507, 14, 24, 16, 1, -24 },
  { 549, 14, 24, 16, 1, -24 },
  { 591, 14, 24, 16, 2, -24 },
  { 633, 12, 24, 16, 2, -24 },
  { 669, 13, 24, 16, 3, -24 },
  { 708, 15, 24, 16, 1, -24 },
  { 753, 13, 24, 16, 2, -24 },
  { 792, 5, 18, 6, 0, -18 },
  { 804, 6, 22, 6, -1, -18 },
  { 821, 12, 14, 15, 2, -18 },
  { 842, 13, 8, 16, 2, -15 },
  { 855, 13, 14, 15, 1, -18 },
  { 878, 10, 24, 13, 3, -24 },
  { 908, 24, 31, 27, 1, -23 },
  { 1001, 16, 24, 17, -1, -24 },
  { 1049, 16, 24, 18, 1, -24 },
  { 1097, 16, 24, 19, 2, -24 },
  { 1145, 17, 24, 19, 1, -24 },
  { 1196, 17, 24, 17, 1, -24 },
  { 1247, 17, 24, 17, 1, -24 },
  { 1298, 17, 24, 20, 2, -24 },
  { 1349, 19, 24, 20, 1, -24 },
  { 1406, 5, 24, 8, 2, -24 },
  { 1421, 15, 24, 16, 1, -24 },
  { 1466, 18, 24, 18, 1, -24 },
  { 1520, 11, 24, 15, 1, -24 },
  { 1553, 23, 24, 25, 1, -24 },
  { 1622, 19, 24, 20, 1, -24 },
  { 1679, 16, 24, 19, 2, -24 },
  { 1727, 16, 24, 17, 1, -24 },
  { 1775, 16, 28, 19, 2, -24 },
  { 1831, 16, 24, 19, 1, -24 },
  { 1879, 16, 24, 17, 1, -24 },
  { 1927, 16, 24, 17, 3, -24 },
  { 1975, 17, 24, 19, 2, -24 },
  { 2026, 16, 24, 17, 3, -24 },
  { 2074, 24, 24, 26, 3, -24 },
  { 2146, 19, 24, 17, -1, -24 },
  { 2203, 16, 24, 17, 3, -24 },
  { 2251, 18, 24, 17, 0, -24 },
  { 2305, 9, 33, 7, 0, -28 },
  { 2343, 5, 26, 11, 3, -24 },
  { 2360, 9, 33, 7, -2, -28 },
  { 2398, 9, 12, 12, 2, -24 },
  { 2412, 12, 1, 12, -2, 0 },
  { 2414, 3, 4, 9, 5, -25 },
  { 2416, 14, 18, 15, 0, -18 },
  { 2448, 13, 26, 16, 1, -26 },
  { 2491, 13, 18, 15, 1, -18 },
  { 2521, 15, 26, 16, 1, -26 },
  { 2570, 13, 18, 15, 1, -18 },
  { 2600, 10, 26, 9, 2, -26 },
  { 2633, 15, 25, 16, 0, -18 },
  { 2680, 13, 26, 16, 1, -26 },
  { 2723, 5, 25, 6, 1, -25 },
  { 2739, 12, 32, 7, -5, -25 },
  { 2787, 13, 26, 14, 1, -26 },
  { 2830, 5, 26, 6, 1, -26 },
  { 2847, 23, 18, 26, 1, -18 },
  { 2899, 13, 18, 16, 1, -18 },
  { 2929, 13, 18, 16, 1, -18 },
  { 2959, 14, 25, 16, 0, -18 },
  { 3003, 14, 25, 16, 1, -18 },
  { 3047, 10, 18, 10, 1, -18 },
  { 3070, 12, 18, 15, 1, -18 },
  { 3097, 7, 23, 10, 2, -23 },
  { 3118, 13, 18, 16, 2, -18 },
  { 3148, 12, 18, 14, 2, -18 },
  { 3175, 19, 18, 22, 3, -18 },
  { 3218, 15, 18, 14, -1, -18 },
  { 3252, 16, 25, 14, -1, -18 },
  { 3302, 14, 18, 14, 0, -18 },
  { 3334, 11, 34, 10, 1, -27 },
  { 3381, 5, 28, 7, 1, -24 },
  { 3399, 10, 34, 10, -2, -27 },
  { 3442, 16, 5, 20, 2, -12 },
};

const GFXfont RobotoCondensed_ThinItalic34pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ThinItalic34pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ThinItalic34pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _ROBOTOCONDENSED_THINITALIC34PT7B_H_
