#ifndef _ROBOTOCONDENSED_THINITALIC8PT7B_H_
#define _ROBOTOCONDENSED_THINITALIC8PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ThinItalic.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ThinItalic8pt7bBitmaps[] PROGMEM = {
  0x00, 0x60, 0x00, 0x02, 0x56, 0x60, 0x25, 0x54, 0x29, 0xA4, 0x8E, 0xA6,
  0x55, 0x66, 0x4A, 0xAE, 0x00, 0x0A, 0x49, 0x20, 0x15, 0x58, 0x03, 0x40,
  0x02, 0x40, 0x80, 0x00, 0x00, 0x05, 0x28, 0x00, 0x65, 0x99, 0xAE, 0x55,
  0x80, 0x61, 0x12, 0x4C, 0x61, 0x16, 0x1E, 0x05, 0x96, 0x00, 0x34, 0x61,
  0x1A, 0x29, 0xDB, 0xC0, 0xE5, 0x28, 0x00, 0x65, 0x5A, 0x9E, 0xD6, 0xE5,
  0x80, 0x00, 0x10, 0x71, 0x00, 0x68, 0x07, 0x00, 0xD4, 0x00, 0x39, 0x16,
  0x69, 0xD7, 0xE8, 0x10, 0x22, 0x65, 0x90, 0x65, 0x5A, 0x9E, 0x34, 0x88,
  0x8F, 0x65, 0x59, 0x9E, 0x74, 0x48, 0x8C, 0x74, 0x48, 0x88, 0x72, 0x7B,
  0xC0, 0x0A, 0x53, 0x69, 0x40, 0x56, 0x80, 0x11, 0x12, 0x2E, 0x05, 0x68,
  0xA8, 0x09, 0x49, 0x80, 0x45, 0x24, 0xAD, 0xAA, 0x80, 0x4A, 0x53, 0x59,
  0x48, 0x35, 0x99, 0x9F, 0x75, 0x56, 0x88, 0x35, 0x99, 0x9F, 0x00, 0x75,
  0x96, 0xA8, 0x78, 0x42, 0x1E, 0xE9, 0x28, 0x00, 0x05, 0x99, 0x9B, 0x16,
  0xE8, 0x00, 0x25, 0x7B, 0x5B, 0x40, 0x05, 0x24, 0x60, 0x17, 0x48, 0x00,
  0x71, 0x24, 0x44, 0x56, 0xA8, 0x7C, 0x24, 0x94, 0x92, 0x48, 0x00, 0x00,
  0x80, 0x2E, 0xF0, 0x0A, 0xDB, 0xC0, 0xD2, 0x70, 0x17, 0x99, 0xAA, 0xFE,
  0x60, 0x09, 0x28, 0x00, 0xF6, 0xD3, 0x80, 0x0A, 0xDB, 0x00, 0x02, 0xA0,
  0x20, 0x24, 0x94, 0x0A, 0xAD, 0x40, 0x1A, 0xA0, 0x5E, 0x5A, 0x40, 0x76,
  0xC0, 0xF6, 0xD0, 0x76, 0xF8, 0x00, 0xF6, 0xD2, 0x00, 0x92, 0x40, 0xC8,
  0xB0, 0x1A, 0x00, 0x16, 0xF0, 0x15, 0x20, 0x5A, 0xA2, 0x29, 0x40, 0x15,
  0x25, 0x00, 0x29, 0x20, 0x09, 0x01, 0x20, 0x7C, 0x04, 0x90, 0x90, 0x60,
};

const GFXglyph RobotoCondensed_ThinItalic8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 6, 1, 0, -6 },
  { 2, 1, 2, 2, 1, -6 },
  { 3, 4, 6, 4, 0, -6 },
  { 6, 4, 8, 4, 0, -7 },
  { 10, 4, 6, 5, 1, -6 },
  { 13, 4, 6, 4, 0, -6 },
  { 16, 1, 2, 1, 1, -6 },
  { 17, 3, 8, 2, 0, -6 },
  { 20, 2, 8, 2, 0, -6 },
  { 22, 4, 3, 3, 0, -6 },
  { 24, 4, 4, 4, 0, -5 },
  { 26, 1, 2, 1, 0, -1 },
  { 27, 2, 1, 2, 0, -3 },
  { 28, 1, 1, 2, 0, -1 },
  { 29, 3, 6, 3, 0, -6 },
  { 32, 4, 6, 4, 0, -6 },
  { 35, 2, 6, 4, 1, -6 },
  { 37, 4, 6, 4, 0, -6 },
  { 40, 4, 6, 4, 0, -6 },
  { 43, 3, 6, 4, 0, -6 },
  { 46, 4, 6, 4, 0, -6 },
  { 49, 3, 6, 4, 0, -6 },
  { 52, 3, 6, 4, 1, -6 },
  { 55, 4, 6, 4, 0, -6 },
  { 58, 3, 6, 4, 1, -6 },
  { 61, 1, 4, 1, 0, -4 },
  { 62, 1, 5, 1, 0, -4 },
  { 63, 3, 3, 4, 0, -4 },
  { 65, 3, 2, 4, 0, -4 },
  { 66, 3, 3, 4, 0, -4 },
  { 68, 2, 6, 3, 1, -6 },
  { 70, 6, 8, 6, 0, -6 },
  { 76, 4, 6, 4, 0, -6 },
  { 79, 4, 6, 4, 0, -6 },
  { 82, 4, 6, 4, 0, -6 },
  { 85, 4, 6, 4, 0, -6 },
  { 88, 4, 6, 4, 0, -6 },
  { 91, 4, 6, 4, 0, -6 },
  { 94, 3, 6, 5, 1, -6 },
  { 97, 5, 6, 5, 0, -6 },
  { 101, 2, 6, 2, 0, -6 },
  { 103, 4, 6, 4, 0, -6 },
  { 106, 4, 6, 4, 0, -6 },
  { 109, 3, 6, 4, 0, -6 },
  { 112, 6, 6, 6, 0, -6 },
  { 117, 5, 6, 5, 0, -6 },
  { 121, 4, 6, 5, 0, -6 },
  { 124, 4, 6, 4, 0, -6 },
  { 127, 4, 7, 5, 0, -6 },
  { 131, 4, 6, 4, 0, -6 },
  { 134, 4, 6, 4, 0, -6 },
  { 137, 3, 6, 4, 1, -6 },
  { 140, 4, 6, 5, 0, -6 },
  { 143, 3, 6, 4, 1, -6 },
  { 146, 5, 6, 6, 1, -6 },
  { 150, 4, 6, 4, 0, -6 },
  { 153, 3, 6, 4, 1, -6 },
  { 156, 4, 6, 4, 0, -6 },
  { 159, 2, 8, 2, 0, -7 },
  { 161, 1, 7, 3, 1, -6 },
  { 162, 3, 8, 2, -1, -7 },
  { 165, 3, 3, 3, 0, -6 },
  { 167, 2, 1, 3, 0, 0 },
  { 168, 1, 1, 2, 1, -6 },
  { 169, 3, 4, 4, 0, -4 },
  { 171, 3, 6, 4, 0, -6 },
  { 174, 3, 4, 4, 0, -4 },
  { 176, 4, 6, 4, 0, -6 },
  { 179, 3, 4, 4, 0, -4 },
  { 181, 3, 6, 2, 0, -6 },
  { 184, 3, 6, 4, 0, -4 },
  { 187, 3, 6, 4, 0, -6 },
  { 190, 2, 6, 2, 0, -6 },
  { 192, 3, 8, 2, -1, -6 },
  { 195, 3, 6, 3, 0, -6 },
  { 198, 2, 6, 2, 0, -6 },
  { 200, 6, 4, 6, 0, -4 },
  { 203, 3, 4, 4, 0, -4 },
  { 205, 3, 4, 4, 0, -4 },
  { 207, 3, 6, 4, 0, -4 },
  { 210, 3, 6, 4, 0, -4 },
  { 213, 3, 4, 2, 0, -4 },
  { 215, 3, 4, 3, 0, -4 },
  { 217, 2, 5, 2, 0, -5 },
  { 219, 3, 4, 4, 0, -4 },
  { 221, 3, 4, 3, 0, -4 },
  { 223, 4, 4, 5, 1, -4 },
  { 225, 3, 4, 3, 0, -4 },
  { 227, 3, 6, 3, 0, -4 },
  { 230, 3, 4, 3, 0, -4 },
  { 232, 3, 8, 2, 0, -6 },
  { 235, 1, 7, 2, 0, -6 },
  { 236, 3, 8, 2, -1, -6 },
  { 239, 4, 1, 5, 0, -3 },
};

const GFXfont RobotoCondensed_ThinItalic8pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ThinItalic8pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ThinItalic8pt7bGlyphs,
  0x20, 0x7E, 9
};

#endif // _ROBOTOCONDENSED_THINITALIC8PT7B_H_
