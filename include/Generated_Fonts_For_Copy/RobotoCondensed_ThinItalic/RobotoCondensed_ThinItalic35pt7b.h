#ifndef _ROBOTOCONDENSED_THINITALIC35PT7B_H_
#define _ROBOTOCONDENSED_THINITALIC35PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ThinItalic.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ThinItalic35pt7bBitmaps[] PROGMEM = {
  0x00, 0x08, 0x42, 0x11, 0x08, 0x42, 0x11, 0x08, 0x42, 0x10, 0x88, 0x42,
  0x00, 0x00, 0x00, 0x10, 0x80, 0x4A, 0x53, 0x18, 0xCA, 0x40, 0x00, 0x41,
  0x00, 0x21, 0x00, 0x20, 0x80, 0x10, 0x40, 0x08, 0x40, 0x08, 0x20, 0x04,
  0x10, 0x7F, 0xFF, 0x02, 0x08, 0x01, 0x04, 0x00, 0x82, 0x00, 0x82, 0x00,
  0x41, 0x00, 0x20, 0x80, 0x20, 0x80, 0x10, 0x40, 0x08, 0x20, 0x7F, 0xFE,
  0x04, 0x10, 0x02, 0x08, 0x02, 0x08, 0x01, 0x04, 0x00, 0x82, 0x00, 0x82,
  0x00, 0x41, 0x00, 0x00, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x0F, 0x80,
  0x20, 0x80, 0x80, 0x82, 0x01, 0x08, 0x01, 0x10, 0x02, 0x20, 0x04, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40,
  0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x90, 0x01, 0x20, 0x02, 0x40,
  0x08, 0x40, 0x10, 0x80, 0x40, 0x81, 0x00, 0xFC, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x00, 0x1E, 0x00, 0x18, 0x80, 0x08, 0x40, 0x08, 0x20, 0x44,
  0x10, 0x24, 0x08, 0x22, 0x04, 0x21, 0x02, 0x20, 0x81, 0x10, 0x41, 0x10,
  0x11, 0x10, 0x07, 0x08, 0x00, 0x08, 0x00, 0x08, 0x70, 0x04, 0xC4, 0x04,
  0x42, 0x04, 0x40, 0x84, 0x20, 0x42, 0x10, 0x42, 0x10, 0x22, 0x08, 0x11,
  0x04, 0x08, 0x01, 0x08, 0x00, 0x8C, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x06,
  0x20, 0x10, 0x20, 0x20, 0x40, 0x80, 0x81, 0x01, 0x02, 0x04, 0x04, 0x10,
  0x04, 0x40, 0x09, 0x00, 0x14, 0x00, 0x30, 0x00, 0xB0, 0x02, 0x20, 0x08,
  0x20, 0x90, 0x41, 0x40, 0x42, 0x80, 0x8A, 0x00, 0x94, 0x01, 0xC8, 0x01,
  0x90, 0x03, 0x10, 0x0A, 0x30, 0x62, 0x1F, 0x04, 0x5A, 0xA8, 0x00, 0x80,
  0x80, 0x80, 0x40, 0x40, 0x40, 0x20, 0x20, 0x10, 0x10, 0x08, 0x04, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x00, 0x80, 0x40, 0x20,
  0x08, 0x02, 0x00, 0x04, 0x01, 0x00, 0x40, 0x20, 0x10, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x10, 0x08, 0x04, 0x02, 0x02, 0x01, 0x00, 0x80, 0x80, 0x40,
  0x40, 0x20, 0x20, 0x10, 0x10, 0x10, 0x10, 0x00, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x71, 0x0C, 0x6B, 0x80, 0xE0, 0x06, 0x00, 0x48,
  0x06, 0x20, 0x61, 0x02, 0x04, 0x20, 0x20, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0xFF, 0xFC, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x12, 0x22, 0x64, 0x80, 0xFE,
  0xF0, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x80,
  0x02, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00,
  0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00,
  0x10, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00,
  0x00, 0x03, 0xE0, 0x10, 0x40, 0x80, 0x84, 0x02, 0x10, 0x08, 0x80, 0x22,
  0x00, 0x90, 0x02, 0x40, 0x09, 0x00, 0x24, 0x00, 0x90, 0x02, 0x80, 0x0A,
  0x00, 0x28, 0x01, 0x20, 0x04, 0x80, 0x12, 0x00, 0x48, 0x02, 0x20, 0x08,
  0x80, 0x22, 0x01, 0x04, 0x08, 0x10, 0x40, 0x3E, 0x00, 0x02, 0x3D, 0x8C,
  0x10, 0x40, 0x81, 0x02, 0x04, 0x08, 0x20, 0x40, 0x81, 0x02, 0x04, 0x10,
  0x20, 0x40, 0x81, 0x02, 0x08, 0x10, 0x20, 0x01, 0xF0, 0x18, 0x60, 0x80,
  0xC6, 0x01, 0x10, 0x04, 0x80, 0x12, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00,
  0x20, 0x01, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x60, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x06, 0x00, 0x30,
  0x00, 0xFF, 0xF0, 0x01, 0xF0, 0x0C, 0x10, 0x30, 0x10, 0x40, 0x21, 0x00,
  0x42, 0x00, 0x88, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x60,
  0x01, 0x80, 0x7C, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x12, 0x00, 0x24, 0x00, 0x48, 0x01, 0x08, 0x02, 0x10, 0x08, 0x10, 0x20,
  0x1F, 0x80, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x0A, 0x00, 0x48, 0x01,
  0x20, 0x08, 0x80, 0x44, 0x03, 0x10, 0x08, 0x40, 0x41, 0x02, 0x04, 0x08,
  0x10, 0x40, 0x82, 0x02, 0x18, 0x08, 0x40, 0x23, 0xFF, 0xF0, 0x02, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x07, 0xFE,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x4F, 0x80, 0xE0, 0x81, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x22, 0x00, 0x44, 0x00, 0x88,
  0x02, 0x08, 0x04, 0x10, 0x10, 0x10, 0x40, 0x1F, 0x00, 0x00, 0x70, 0x0C,
  0x01, 0x80, 0x18, 0x00, 0x80, 0x08, 0x00, 0x80, 0x04, 0x00, 0x20, 0x02,
  0x3E, 0x16, 0x08, 0xC0, 0x2C, 0x01, 0x60, 0x0A, 0x00, 0x50, 0x02, 0x80,
  0x14, 0x00, 0xA0, 0x05, 0x00, 0x28, 0x02, 0x40, 0x11, 0x01, 0x0C, 0x10,
  0x1F, 0x00, 0x7F, 0xFC, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00,
  0x80, 0x02, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x40, 0x01,
  0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x04,
  0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x80, 0x00, 0x01, 0xF0,
  0x04, 0x10, 0x10, 0x10, 0x40, 0x31, 0x00, 0x22, 0x00, 0x44, 0x00, 0x88,
  0x01, 0x10, 0x04, 0x20, 0x08, 0x40, 0x20, 0x61, 0x80, 0x3C, 0x03, 0x04,
  0x08, 0x04, 0x20, 0x04, 0x40, 0x09, 0x00, 0x12, 0x00, 0x24, 0x00, 0x48,
  0x00, 0x90, 0x02, 0x10, 0x08, 0x30, 0x60, 0x1F, 0x00, 0x03, 0xE0, 0x61,
  0x86, 0x06, 0x20, 0x12, 0x00, 0x90, 0x05, 0x00, 0x28, 0x01, 0x40, 0x0A,
  0x00, 0x60, 0x02, 0x80, 0x14, 0x01, 0xA0, 0x15, 0x81, 0xC4, 0x1A, 0x1F,
  0x10, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0,
  0x78, 0x00, 0x08, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x46, 0x00, 0x04, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x08, 0x20, 0x82, 0x10, 0x42, 0x00, 0x00, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x02, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x00, 0x04, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x02,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x06, 0x01, 0xC0, 0x30, 0x06, 0x00,
  0xC0, 0x08, 0x00, 0x00, 0x0F, 0x0C, 0x22, 0x05, 0x01, 0x40, 0x60, 0x10,
  0x04, 0x01, 0x00, 0x80, 0x20, 0x10, 0x08, 0x04, 0x02, 0x00, 0x80, 0x40,
  0x10, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x40, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x18, 0x0C, 0x00, 0x30, 0x01, 0x00, 0x30, 0x00,
  0x40, 0x30, 0x00, 0x20, 0x30, 0x00, 0x08, 0x10, 0x00, 0x04, 0x10, 0x0E,
  0x02, 0x18, 0x10, 0xC1, 0x08, 0x10, 0x20, 0x48, 0x10, 0x10, 0x24, 0x08,
  0x10, 0x22, 0x08, 0x08, 0x12, 0x04, 0x04, 0x09, 0x04, 0x02, 0x04, 0x82,
  0x02, 0x02, 0x41, 0x01, 0x01, 0x40, 0x80, 0x81, 0x20, 0x80, 0x40, 0x90,
  0x40, 0x40, 0x48, 0x20, 0x60, 0x44, 0x10, 0x30, 0x42, 0x04, 0x64, 0x61,
  0x01, 0xC1, 0xC0, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x30,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x24,
  0x00, 0x24, 0x00, 0x44, 0x00, 0x44, 0x00, 0x84, 0x00, 0x84, 0x01, 0x04,
  0x01, 0x04, 0x02, 0x02, 0x02, 0x02, 0x04, 0x02, 0x04, 0x02, 0x04, 0x02,
  0x08, 0x02, 0x0F, 0xFE, 0x10, 0x01, 0x10, 0x01, 0x20, 0x01, 0x20, 0x01,
  0x40, 0x01, 0x40, 0x01, 0x80, 0x01, 0x07, 0xF8, 0x08, 0x04, 0x08, 0x02,
  0x08, 0x01, 0x08, 0x01, 0x08, 0x01, 0x10, 0x01, 0x10, 0x01, 0x10, 0x02,
  0x10, 0x02, 0x10, 0x04, 0x10, 0x18, 0x3F, 0xE0, 0x20, 0x18, 0x20, 0x04,
  0x20, 0x04, 0x20, 0x02, 0x20, 0x02, 0x40, 0x02, 0x40, 0x04, 0x40, 0x04,
  0x40, 0x08, 0x40, 0x18, 0x40, 0x30, 0xFF, 0xC0, 0x01, 0xF8, 0x02, 0x06,
  0x0C, 0x02, 0x08, 0x01, 0x10, 0x01, 0x30, 0x01, 0x20, 0x01, 0x20, 0x01,
  0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x02, 0x80, 0x04, 0x80, 0x04,
  0x80, 0x08, 0x40, 0x08, 0x40, 0x10, 0x30, 0x60, 0x1F, 0x80, 0x07, 0xF8,
  0x04, 0x03, 0x02, 0x00, 0xC1, 0x00, 0x20, 0x80, 0x08, 0x40, 0x04, 0x40,
  0x02, 0x20, 0x01, 0x10, 0x00, 0x88, 0x00, 0x44, 0x00, 0x22, 0x00, 0x12,
  0x00, 0x09, 0x00, 0x08, 0x80, 0x04, 0x40, 0x02, 0x20, 0x01, 0x10, 0x00,
  0x90, 0x00, 0x88, 0x00, 0x44, 0x00, 0x42, 0x00, 0x41, 0x00, 0x40, 0x80,
  0xC0, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x84, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0xFF, 0xC1, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0x84, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03,
  0xFF, 0xC1, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x01, 0x81, 0x01, 0x00, 0x41, 0x00,
  0x21, 0x00, 0x08, 0x80, 0x04, 0x80, 0x02, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x03, 0xF9, 0x00, 0x04,
  0x80, 0x04, 0x80, 0x02, 0x40, 0x01, 0x20, 0x00, 0x88, 0x00, 0x44, 0x00,
  0x22, 0x00, 0x20, 0x80, 0x30, 0x20, 0x60, 0x0F, 0xC0, 0x00, 0x08, 0x00,
  0x21, 0x00, 0x04, 0x20, 0x00, 0x84, 0x00, 0x10, 0x80, 0x02, 0x10, 0x00,
  0x84, 0x00, 0x10, 0x80, 0x02, 0x10, 0x00, 0x42, 0x00, 0x08, 0x40, 0x01,
  0x08, 0x00, 0x43, 0xFF, 0xF8, 0x40, 0x01, 0x08, 0x00, 0x21, 0x00, 0x04,
  0x20, 0x00, 0x84, 0x00, 0x21, 0x00, 0x04, 0x20, 0x00, 0x84, 0x00, 0x10,
  0x80, 0x02, 0x10, 0x00, 0x82, 0x00, 0x10, 0x80, 0x02, 0x00, 0x08, 0x42,
  0x21, 0x08, 0x42, 0x11, 0x08, 0x42, 0x10, 0x88, 0x42, 0x10, 0x84, 0x42,
  0x10, 0x80, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x22,
  0x00, 0x44, 0x01, 0x08, 0x02, 0x10, 0x08, 0x20, 0x10, 0x20, 0xC0, 0x3E,
  0x00, 0x08, 0x00, 0x41, 0x00, 0x10, 0x20, 0x04, 0x04, 0x01, 0x00, 0x80,
  0x40, 0x10, 0x10, 0x04, 0x04, 0x00, 0x81, 0x00, 0x10, 0x40, 0x02, 0x10,
  0x00, 0x44, 0x00, 0x09, 0x80, 0x02, 0x50, 0x00, 0x51, 0x00, 0x0C, 0x20,
  0x01, 0x02, 0x00, 0x20, 0x40, 0x04, 0x04, 0x01, 0x00, 0x80, 0x20, 0x08,
  0x04, 0x01, 0x00, 0x80, 0x10, 0x10, 0x03, 0x02, 0x00, 0x20, 0x80, 0x06,
  0x00, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04,
  0x00, 0xFF, 0xF0, 0x04, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x06,
  0x0A, 0x00, 0x06, 0x0A, 0x00, 0x0A, 0x0A, 0x00, 0x0A, 0x12, 0x00, 0x12,
  0x12, 0x00, 0x12, 0x12, 0x00, 0x24, 0x11, 0x00, 0x44, 0x11, 0x00, 0x44,
  0x11, 0x00, 0x84, 0x21, 0x00, 0x84, 0x21, 0x01, 0x04, 0x20, 0x81, 0x08,
  0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x84, 0x08, 0x40, 0x84, 0x08,
  0x40, 0x88, 0x08, 0x40, 0x48, 0x10, 0x40, 0x50, 0x10, 0x40, 0x50, 0x10,
  0x40, 0x60, 0x10, 0x80, 0x60, 0x10, 0x04, 0x00, 0x21, 0x80, 0x04, 0x28,
  0x00, 0x85, 0x00, 0x10, 0xA0, 0x02, 0x12, 0x00, 0x44, 0x40, 0x10, 0x88,
  0x02, 0x10, 0x80, 0x42, 0x10, 0x08, 0x41, 0x01, 0x08, 0x20, 0x22, 0x04,
  0x08, 0x40, 0x41, 0x08, 0x08, 0x21, 0x00, 0x84, 0x20, 0x10, 0x84, 0x02,
  0x31, 0x00, 0x24, 0x20, 0x04, 0x84, 0x00, 0x50, 0x80, 0x0A, 0x10, 0x01,
  0x42, 0x00, 0x10, 0x80, 0x02, 0x00, 0x01, 0xF8, 0x01, 0x03, 0x03, 0x00,
  0x81, 0x00, 0x21, 0x00, 0x11, 0x00, 0x04, 0x80, 0x02, 0x40, 0x01, 0x40,
  0x00, 0xA0, 0x00, 0x50, 0x00, 0x48, 0x00, 0x24, 0x00, 0x14, 0x00, 0x0A,
  0x00, 0x05, 0x00, 0x04, 0x80, 0x02, 0x40, 0x01, 0x20, 0x00, 0x90, 0x00,
  0x88, 0x00, 0x42, 0x00, 0x41, 0x00, 0x40, 0x60, 0xC0, 0x1F, 0x80, 0x00,
  0x07, 0xFC, 0x04, 0x01, 0x02, 0x00, 0x41, 0x00, 0x20, 0x80, 0x08, 0x40,
  0x04, 0x40, 0x02, 0x20, 0x02, 0x10, 0x01, 0x08, 0x00, 0x84, 0x00, 0x82,
  0x00, 0x82, 0x00, 0x81, 0xFF, 0x80, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x01, 0x03, 0x03, 0x00,
  0x81, 0x00, 0x21, 0x00, 0x11, 0x00, 0x04, 0x80, 0x02, 0x40, 0x01, 0x40,
  0x00, 0xA0, 0x00, 0x50, 0x00, 0x48, 0x00, 0x24, 0x00, 0x14, 0x00, 0x0A,
  0x00, 0x05, 0x00, 0x04, 0x80, 0x02, 0x40, 0x01, 0x20, 0x00, 0x90, 0x00,
  0x88, 0x00, 0x42, 0x00, 0x41, 0x00, 0x40, 0x60, 0xC0, 0x1F, 0xC0, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x40, 0x0F, 0xFC,
  0x04, 0x01, 0x02, 0x00, 0x41, 0x00, 0x20, 0x80, 0x08, 0x40, 0x04, 0x40,
  0x02, 0x20, 0x01, 0x10, 0x01, 0x08, 0x00, 0x84, 0x00, 0x82, 0x00, 0xC2,
  0x00, 0x81, 0xFF, 0x80, 0x80, 0x80, 0x40, 0x40, 0x20, 0x10, 0x20, 0x08,
  0x10, 0x04, 0x08, 0x01, 0x04, 0x00, 0x82, 0x00, 0x41, 0x00, 0x11, 0x00,
  0x08, 0x80, 0x04, 0x00, 0x01, 0xF8, 0x01, 0x03, 0x03, 0x00, 0xC1, 0x00,
  0x21, 0x00, 0x10, 0x80, 0x08, 0x40, 0x04, 0x20, 0x00, 0x10, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x01, 0x20, 0x00, 0x90, 0x00, 0x88, 0x00,
  0x44, 0x00, 0x41, 0x00, 0x60, 0x60, 0x40, 0x0F, 0xC0, 0x00, 0xFF, 0xFF,
  0x00, 0x80, 0x00, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x88, 0x00, 0x44, 0x00, 0x22, 0x00, 0x11, 0x00, 0x09, 0x00,
  0x04, 0x80, 0x04, 0x40, 0x02, 0x20, 0x01, 0x10, 0x00, 0x88, 0x00, 0x48,
  0x00, 0x44, 0x00, 0x22, 0x00, 0x11, 0x00, 0x08, 0x80, 0x04, 0x80, 0x02,
  0x40, 0x02, 0x20, 0x01, 0x10, 0x00, 0x88, 0x00, 0x82, 0x00, 0x41, 0x00,
  0x40, 0x60, 0xC0, 0x1F, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x02,
  0x40, 0x02, 0x40, 0x04, 0x40, 0x04, 0x40, 0x08, 0x40, 0x08, 0x40, 0x08,
  0x40, 0x10, 0x20, 0x10, 0x20, 0x20, 0x20, 0x20, 0x20, 0x40, 0x20, 0x40,
  0x20, 0x80, 0x10, 0x80, 0x11, 0x00, 0x11, 0x00, 0x12, 0x00, 0x12, 0x00,
  0x12, 0x00, 0x14, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x80, 0x08, 0x00, 0xA0,
  0x04, 0x00, 0x90, 0x06, 0x00, 0x48, 0x02, 0x80, 0x24, 0x02, 0x40, 0x22,
  0x01, 0x20, 0x11, 0x01, 0x10, 0x10, 0x80, 0x88, 0x08, 0x40, 0x44, 0x04,
  0x20, 0x42, 0x04, 0x10, 0x21, 0x02, 0x08, 0x20, 0x81, 0x04, 0x10, 0x41,
  0x02, 0x08, 0x20, 0x81, 0x08, 0x08, 0x80, 0x84, 0x04, 0x40, 0x44, 0x02,
  0x20, 0x12, 0x01, 0x20, 0x09, 0x00, 0x90, 0x05, 0x00, 0x48, 0x02, 0x80,
  0x28, 0x01, 0x80, 0x14, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x20,
  0x03, 0x00, 0x00, 0x04, 0x00, 0x20, 0x40, 0x02, 0x02, 0x00, 0x40, 0x20,
  0x08, 0x03, 0x01, 0x80, 0x10, 0x10, 0x01, 0x02, 0x00, 0x08, 0x40, 0x00,
  0x84, 0x00, 0x04, 0x80, 0x00, 0x50, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00,
  0x06, 0x00, 0x00, 0x90, 0x00, 0x11, 0x00, 0x01, 0x08, 0x00, 0x20, 0x80,
  0x04, 0x08, 0x00, 0xC0, 0x40, 0x08, 0x04, 0x01, 0x00, 0x20, 0x20, 0x02,
  0x02, 0x00, 0x10, 0x40, 0x01, 0x00, 0xC0, 0x01, 0x20, 0x01, 0x90, 0x00,
  0x88, 0x00, 0x82, 0x00, 0xC1, 0x00, 0x40, 0x80, 0x40, 0x20, 0x20, 0x10,
  0x20, 0x08, 0x20, 0x02, 0x10, 0x01, 0x10, 0x00, 0x90, 0x00, 0x28, 0x00,
  0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xC1, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0xF8, 0x00, 0x88, 0x88, 0x88, 0x44, 0x44, 0x44, 0x42, 0x22, 0x22,
  0x22, 0x11, 0x11, 0x11, 0x10, 0x07, 0x80, 0x40, 0x20, 0x10, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x80, 0x40, 0x20, 0xF0, 0x00, 0x02, 0x03, 0x01, 0x41, 0x20,
  0x90, 0x88, 0x44, 0x42, 0x20, 0xA0, 0x50, 0x30, 0x10, 0xFF, 0xF0, 0x84,
  0x42, 0x20, 0x03, 0xF0, 0x10, 0x20, 0x80, 0x84, 0x01, 0x10, 0x04, 0x00,
  0x10, 0x00, 0x80, 0x02, 0x07, 0xF8, 0x60, 0x22, 0x00, 0x90, 0x02, 0x40,
  0x11, 0x00, 0x48, 0x03, 0x10, 0x14, 0x61, 0x90, 0xF8, 0x40, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x13, 0xE0, 0x50, 0x61, 0x80, 0x8C, 0x02, 0x20, 0x04, 0x80, 0x12, 0x00,
  0x48, 0x01, 0x40, 0x09, 0x00, 0x24, 0x00, 0x90, 0x02, 0x40, 0x11, 0x00,
  0x44, 0x01, 0x30, 0x08, 0xB0, 0x42, 0x3E, 0x00, 0x07, 0xE0, 0x40, 0x84,
  0x06, 0x40, 0x12, 0x00, 0xA0, 0x05, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x01, 0x40, 0x12, 0x00, 0x88, 0x08, 0x60, 0x80,
  0xF8, 0x00, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x03, 0xC4, 0x0C, 0x34, 0x10, 0x0C,
  0x30, 0x0C, 0x20, 0x08, 0x20, 0x08, 0x40, 0x08, 0x40, 0x08, 0x40, 0x08,
  0x40, 0x10, 0x40, 0x10, 0x80, 0x10, 0x80, 0x10, 0x80, 0x10, 0x40, 0x30,
  0x40, 0x60, 0x20, 0xA0, 0x1E, 0x20, 0x03, 0xE0, 0x60, 0x84, 0x02, 0x40,
  0x12, 0x00, 0xA0, 0x05, 0x00, 0x2F, 0xFF, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x08, 0x04, 0x20, 0xC0, 0xF8, 0x00,
  0x01, 0xE0, 0xC0, 0x10, 0x04, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x7F,
  0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x10, 0x00,
  0x03, 0xE2, 0x08, 0x34, 0x20, 0x18, 0xC0, 0x31, 0x00, 0x42, 0x00, 0x88,
  0x01, 0x10, 0x02, 0x20, 0x04, 0x40, 0x10, 0x80, 0x22, 0x00, 0x44, 0x00,
  0x88, 0x01, 0x08, 0x06, 0x10, 0x18, 0x30, 0x50, 0x1F, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x02, 0x00, 0x04, 0x30, 0x10, 0x30, 0x40, 0x1F, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x11, 0xF0, 0x90, 0xC5, 0x02, 0x50, 0x13, 0x00, 0x98, 0x04, 0x80, 0x24,
  0x01, 0x20, 0x0A, 0x00, 0x50, 0x04, 0x80, 0x24, 0x01, 0x20, 0x0A, 0x00,
  0x50, 0x02, 0x80, 0x24, 0x01, 0x00, 0x0C, 0x20, 0x00, 0x00, 0x00, 0x04,
  0x10, 0x41, 0x08, 0x20, 0x82, 0x08, 0x21, 0x04, 0x10, 0x41, 0x04, 0x20,
  0x80, 0x00, 0x30, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x0F,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x08, 0x40, 0x41, 0x02, 0x08, 0x10, 0x20, 0x80,
  0x84, 0x02, 0x20, 0x0B, 0x00, 0x3C, 0x01, 0x90, 0x04, 0x20, 0x10, 0xC0,
  0x41, 0x01, 0x02, 0x08, 0x08, 0x20, 0x10, 0x80, 0x42, 0x00, 0x80, 0x08,
  0x20, 0x82, 0x08, 0x21, 0x04, 0x10, 0x41, 0x04, 0x20, 0x82, 0x08, 0x20,
  0x84, 0x10, 0x41, 0x04, 0x10, 0x82, 0x00, 0x11, 0xE0, 0x7C, 0x2C, 0x23,
  0x04, 0xB0, 0x2C, 0x09, 0x40, 0x50, 0x13, 0x00, 0xC0, 0x24, 0x01, 0x00,
  0x48, 0x02, 0x00, 0x90, 0x04, 0x01, 0x40, 0x08, 0x02, 0x80, 0x20, 0x05,
  0x00, 0x40, 0x0A, 0x00, 0x80, 0x24, 0x01, 0x00, 0x48, 0x02, 0x00, 0xA0,
  0x04, 0x01, 0x40, 0x10, 0x02, 0x80, 0x20, 0x05, 0x00, 0x40, 0x10, 0x11,
  0xE0, 0x90, 0xC5, 0x02, 0x50, 0x13, 0x00, 0x98, 0x04, 0x80, 0x24, 0x01,
  0x20, 0x0A, 0x00, 0x50, 0x04, 0x80, 0x24, 0x01, 0x20, 0x09, 0x00, 0x50,
  0x02, 0x80, 0x24, 0x01, 0x00, 0x03, 0xE0, 0x30, 0x41, 0x00, 0x84, 0x02,
  0x20, 0x04, 0x80, 0x14, 0x00, 0x50, 0x01, 0x40, 0x09, 0x00, 0x28, 0x00,
  0xA0, 0x02, 0x80, 0x12, 0x00, 0x44, 0x03, 0x10, 0x08, 0x20, 0xC0, 0x7C,
  0x00, 0x09, 0xF0, 0x14, 0x18, 0x30, 0x10, 0xC0, 0x11, 0x00, 0x22, 0x00,
  0x44, 0x00, 0x88, 0x01, 0x10, 0x04, 0x40, 0x08, 0x80, 0x11, 0x00, 0x22,
  0x00, 0x84, 0x01, 0x08, 0x02, 0x30, 0x08, 0x58, 0x20, 0x8F, 0x81, 0x00,
  0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x00,
  0x07, 0xC4, 0x30, 0xD1, 0x00, 0xCC, 0x03, 0x20, 0x08, 0x80, 0x24, 0x00,
  0x90, 0x02, 0x40, 0x09, 0x00, 0x24, 0x01, 0x20, 0x04, 0x80, 0x12, 0x00,
  0x44, 0x03, 0x10, 0x18, 0x60, 0xA0, 0x7C, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x13, 0xC5, 0x01, 0x80,
  0xA0, 0x30, 0x08, 0x02, 0x00, 0x80, 0x20, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x08, 0x02, 0x00, 0x80, 0x20, 0x00, 0x07, 0xC1, 0x82, 0x20, 0x12,
  0x01, 0x20, 0x12, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40,
  0x02, 0x00, 0x28, 0x02, 0x80, 0x28, 0x04, 0x41, 0x83, 0xE0, 0x08, 0x10,
  0x40, 0x81, 0x1F, 0xC4, 0x08, 0x20, 0x40, 0x81, 0x02, 0x08, 0x10, 0x20,
  0x40, 0x81, 0x04, 0x08, 0x08, 0x1E, 0x00, 0x20, 0x09, 0x00, 0x48, 0x02,
  0x80, 0x14, 0x01, 0x20, 0x09, 0x00, 0x48, 0x02, 0x80, 0x14, 0x00, 0xA0,
  0x09, 0x00, 0x48, 0x02, 0x40, 0x32, 0x01, 0x90, 0x18, 0x41, 0x41, 0xE2,
  0x00, 0x80, 0x0C, 0x00, 0x90, 0x04, 0x80, 0x44, 0x02, 0x20, 0x21, 0x01,
  0x08, 0x10, 0x20, 0x81, 0x08, 0x08, 0x40, 0x44, 0x02, 0x20, 0x12, 0x00,
  0x50, 0x03, 0x00, 0x18, 0x00, 0x80, 0x00, 0x80, 0x40, 0x30, 0x18, 0x06,
  0x03, 0x01, 0x40, 0x60, 0x28, 0x14, 0x09, 0x02, 0x41, 0x20, 0x88, 0x64,
  0x11, 0x08, 0x84, 0x21, 0x10, 0x84, 0x41, 0x20, 0x88, 0x24, 0x12, 0x05,
  0x02, 0x40, 0xA0, 0x48, 0x14, 0x0A, 0x03, 0x01, 0x40, 0x60, 0x10, 0x08,
  0x02, 0x00, 0x08, 0x02, 0x10, 0x08, 0x10, 0x20, 0x20, 0x40, 0x21, 0x00,
  0x44, 0x00, 0x50, 0x00, 0xA0, 0x01, 0x80, 0x03, 0x00, 0x0A, 0x00, 0x22,
  0x00, 0x44, 0x01, 0x04, 0x04, 0x08, 0x10, 0x08, 0x20, 0x10, 0x80, 0x30,
  0x10, 0x01, 0x08, 0x02, 0x08, 0x02, 0x08, 0x04, 0x08, 0x04, 0x08, 0x08,
  0x08, 0x08, 0x08, 0x10, 0x04, 0x10, 0x04, 0x20, 0x04, 0x20, 0x04, 0x40,
  0x04, 0x40, 0x04, 0x80, 0x02, 0x80, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x00,
  0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0x20,
  0x18, 0x06, 0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x80, 0x10, 0x02, 0x00, 0x80, 0x20, 0x18, 0x00, 0x80,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x10, 0x03, 0x00, 0x10, 0x00, 0x08,
  0x42, 0x10, 0x88, 0x42, 0x10, 0x84, 0x42, 0x10, 0x84, 0x21, 0x10, 0x84,
  0x21, 0x08, 0xC4, 0x21, 0x08, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x00, 0x80, 0x0C, 0x06, 0x01, 0x80, 0x20, 0x04,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x00, 0x1E, 0x01, 0x23, 0x01, 0x41,
  0x01, 0x40, 0x82, 0x80, 0x46, 0x80, 0x38,
};

const GFXglyph RobotoCondensed_ThinItalic35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 5, 25, 6, 1, -25 },
  { 17, 5, 7, 9, 4, -26 },
  { 22, 17, 25, 17, 1, -25 },
  { 76, 15, 31, 16, 1, -28 },
  { 135, 17, 25, 22, 3, -25 },
  { 189, 15, 25, 18, 1, -25 },
  { 236, 2, 7, 6, 4, -26 },
  { 238, 9, 36, 9, 2, -28 },
  { 279, 9, 36, 9, -2, -28 },
  { 320, 13, 14, 14, 2, -25 },
  { 343, 15, 19, 17, 1, -21 },
  { 379, 4, 7, 6, -1, -3 },
  { 383, 7, 1, 9, 1, -12 },
  { 384, 2, 2, 7, 1, -2 },
  { 385, 14, 27, 12, -1, -25 },
  { 433, 14, 25, 16, 2, -25 },
  { 477, 7, 25, 16, 5, -25 },
  { 499, 14, 25, 16, 1, -25 },
  { 543, 15, 25, 16, 1, -25 },
  { 590, 14, 25, 16, 1, -25 },
  { 634, 15, 25, 16, 2, -25 },
  { 681, 13, 25, 16, 2, -25 },
  { 722, 14, 25, 16, 3, -25 },
  { 766, 15, 25, 16, 1, -25 },
  { 813, 13, 25, 16, 2, -25 },
  { 854, 5, 18, 6, 0, -18 },
  { 866, 6, 22, 6, -1, -18 },
  { 883, 13, 13, 15, 2, -18 },
  { 905, 13, 8, 17, 2, -15 },
  { 918, 13, 13, 15, 1, -18 },
  { 940, 10, 25, 13, 3, -25 },
  { 972, 25, 32, 27, 1, -24 },
  { 1072, 16, 25, 18, -1, -25 },
  { 1122, 16, 25, 18, 1, -25 },
  { 1172, 16, 25, 19, 2, -25 },
  { 1222, 17, 25, 19, 1, -25 },
  { 1276, 17, 25, 17, 1, -25 },
  { 1330, 17, 25, 17, 1, -25 },
  { 1384, 17, 25, 20, 2, -25 },
  { 1438, 19, 25, 21, 1, -25 },
  { 1498, 5, 25, 8, 2, -25 },
  { 1514, 15, 25, 16, 1, -25 },
  { 1561, 19, 25, 19, 1, -25 },
  { 1621, 12, 25, 16, 1, -25 },
  { 1659, 24, 25, 25, 1, -25 },
  { 1734, 19, 25, 21, 1, -25 },
  { 1794, 17, 25, 20, 2, -25 },
  { 1848, 17, 25, 18, 1, -25 },
  { 1902, 17, 30, 20, 2, -25 },
  { 1966, 17, 25, 19, 1, -25 },
  { 2020, 17, 25, 18, 1, -25 },
  { 2074, 16, 25, 18, 3, -25 },
  { 2124, 17, 25, 20, 2, -25 },
  { 2178, 16, 25, 18, 3, -25 },
  { 2228, 25, 25, 27, 3, -25 },
  { 2307, 20, 25, 18, -1, -25 },
  { 2370, 17, 25, 18, 3, -25 },
  { 2424, 18, 25, 18, 0, -25 },
  { 2481, 10, 33, 7, 0, -28 },
  { 2523, 4, 27, 12, 4, -25 },
  { 2537, 9, 33, 7, -2, -28 },
  { 2575, 9, 12, 13, 2, -25 },
  { 2589, 13, 1, 13, -2, 0 },
  { 2591, 4, 5, 9, 5, -27 },
  { 2594, 14, 18, 16, 0, -18 },
  { 2626, 14, 26, 16, 1, -26 },
  { 2672, 13, 18, 15, 1, -18 },
  { 2702, 16, 26, 16, 1, -26 },
  { 2754, 13, 18, 15, 1, -18 },
  { 2784, 11, 26, 10, 2, -26 },
  { 2820, 15, 25, 16, 0, -18 },
  { 2867, 13, 26, 16, 1, -26 },
  { 2910, 6, 25, 7, 1, -25 },
  { 2929, 12, 32, 7, -5, -25 },
  { 2977, 14, 26, 14, 1, -26 },
  { 3023, 6, 26, 7, 1, -26 },
  { 3043, 23, 18, 26, 1, -18 },
  { 3095, 13, 18, 16, 1, -18 },
  { 3125, 14, 18, 16, 1, -18 },
  { 3157, 15, 25, 16, 0, -18 },
  { 3204, 14, 25, 16, 1, -18 },
  { 3248, 10, 18, 10, 1, -18 },
  { 3271, 12, 18, 15, 1, -18 },
  { 3298, 7, 23, 10, 2, -23 },
  { 3319, 13, 18, 16, 2, -18 },
  { 3349, 13, 18, 14, 2, -18 },
  { 3379, 19, 18, 22, 3, -18 },
  { 3422, 15, 18, 14, -1, -18 },
  { 3456, 16, 25, 14, -1, -18 },
  { 3506, 14, 18, 14, 0, -18 },
  { 3538, 11, 35, 10, 1, -27 },
  { 3587, 5, 30, 7, 1, -25 },
  { 3606, 11, 35, 10, -2, -27 },
  { 3655, 16, 6, 21, 2, -14 },
};

const GFXfont RobotoCondensed_ThinItalic35pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ThinItalic35pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ThinItalic35pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _ROBOTOCONDENSED_THINITALIC35PT7B_H_
