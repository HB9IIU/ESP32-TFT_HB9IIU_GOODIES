#ifndef _ROBOTOCONDENSED_THINITALIC30PT7B_H_
#define _ROBOTOCONDENSED_THINITALIC30PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ThinItalic.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ThinItalic30pt7bBitmaps[] PROGMEM = {
  0x00, 0x11, 0x11, 0x12, 0x22, 0x22, 0x24, 0x44, 0x44, 0x00, 0x00, 0x88,
  0x4A, 0x52, 0x99, 0x48, 0x00, 0x84, 0x01, 0x08, 0x02, 0x10, 0x08, 0x40,
  0x10, 0x80, 0x21, 0x07, 0xFF, 0x81, 0x08, 0x02, 0x10, 0x04, 0x20, 0x10,
  0x80, 0x21, 0x00, 0x42, 0x01, 0x08, 0x02, 0x10, 0x7F, 0xFC, 0x10, 0x80,
  0x21, 0x00, 0x42, 0x01, 0x08, 0x02, 0x10, 0x04, 0x20, 0x00, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x3C, 0x0C, 0x20, 0x81, 0x10, 0x11, 0x01, 0x20, 0x12,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x40,
  0x02, 0x00, 0x28, 0x02, 0x80, 0x28, 0x04, 0x40, 0x44, 0x08, 0x3F, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x3C, 0x01, 0x10, 0x04, 0x20, 0x20, 0x84, 0x82,
  0x12, 0x08, 0x88, 0x44, 0x21, 0x10, 0x88, 0x81, 0xC4, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x78, 0x12, 0x20, 0x88, 0x44, 0x41, 0x11, 0x04, 0x84, 0x14,
  0x10, 0x80, 0x42, 0x01, 0x10, 0x03, 0x80, 0x03, 0xC0, 0x21, 0x02, 0x08,
  0x10, 0x40, 0x82, 0x08, 0x20, 0x41, 0x01, 0x10, 0x0B, 0x00, 0x20, 0x03,
  0x00, 0x24, 0x02, 0x20, 0xA0, 0x85, 0x04, 0x30, 0x12, 0x80, 0x94, 0x03,
  0x20, 0x09, 0x00, 0xC4, 0x19, 0x1F, 0x08, 0x56, 0xA0, 0x00, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x40, 0x40, 0x20, 0x10, 0x10, 0x08, 0x04, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x10, 0x08, 0x04, 0x02, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x02, 0x01, 0x00, 0x40, 0x04, 0x02, 0x02, 0x02,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x02, 0x02, 0x02, 0x02, 0x04, 0x04, 0x08, 0x08, 0x10, 0x10,
  0x20, 0x40, 0x80, 0x02, 0x00, 0x40, 0x10, 0x02, 0x08, 0x46, 0xEB, 0x03,
  0x80, 0x60, 0x12, 0x04, 0x41, 0x04, 0x60, 0xC0, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x0F, 0xFF, 0x02, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x24, 0x95, 0x00, 0xFC, 0xC0,
  0x00, 0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08,
  0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80,
  0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00,
  0x03, 0xC0, 0x42, 0x08, 0x11, 0x01, 0x10, 0x12, 0x01, 0x20, 0x12, 0x01,
  0x40, 0x14, 0x01, 0x40, 0x14, 0x01, 0x40, 0x14, 0x02, 0x80, 0x28, 0x02,
  0x80, 0x48, 0x04, 0x40, 0x44, 0x08, 0x21, 0x01, 0xE0, 0x04, 0xFC, 0x41,
  0x04, 0x10, 0x82, 0x08, 0x20, 0x82, 0x10, 0x41, 0x04, 0x10, 0x42, 0x08,
  0x20, 0x80, 0x07, 0xC0, 0x82, 0x10, 0x12, 0x01, 0x20, 0x12, 0x01, 0x00,
  0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x0F, 0xFC, 0x03,
  0xC0, 0xC2, 0x10, 0x11, 0x01, 0x20, 0x12, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x20, 0x04, 0x07, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x20, 0x02, 0x80,
  0x28, 0x02, 0x80, 0x44, 0x04, 0x41, 0x83, 0xE0, 0x00, 0x30, 0x02, 0x00,
  0x60, 0x0A, 0x01, 0x20, 0x12, 0x02, 0x20, 0x44, 0x04, 0x40, 0x84, 0x10,
  0x41, 0x04, 0x20, 0x44, 0x08, 0x40, 0x8F, 0xFF, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x10, 0x01, 0x00, 0x10, 0x0F, 0xF1, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x2F, 0x03, 0x08, 0x00, 0x40, 0x04, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x04, 0x80, 0x48, 0x04, 0x80, 0x88, 0x08, 0x41,
  0x03, 0xE0, 0x00, 0xE0, 0x60, 0x10, 0x04, 0x01, 0x00, 0x20, 0x08, 0x01,
  0x00, 0x27, 0x8B, 0x09, 0x80, 0xA0, 0x14, 0x02, 0x80, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x05, 0x01, 0x20, 0x22, 0x18, 0x3C, 0x00, 0xFF, 0xE0, 0x04,
  0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x10,
  0x02, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x20,
  0x08, 0x01, 0x00, 0x00, 0x03, 0xC0, 0x61, 0x84, 0x04, 0x20, 0x12, 0x00,
  0x90, 0x04, 0x80, 0x44, 0x02, 0x20, 0x20, 0x82, 0x03, 0xE0, 0x21, 0x82,
  0x04, 0x20, 0x12, 0x00, 0x90, 0x04, 0x80, 0x24, 0x01, 0x20, 0x11, 0x00,
  0x84, 0x18, 0x1F, 0x00, 0x0F, 0x82, 0x08, 0x80, 0x90, 0x14, 0x02, 0x80,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x34, 0x0C, 0x82, 0x8F,
  0x90, 0x04, 0x00, 0x80, 0x10, 0x04, 0x01, 0x00, 0xC0, 0xE0, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x08, 0x21, 0x04, 0x20,
  0x00, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x10, 0x06, 0x00, 0x40, 0x03, 0x00,
  0x08, 0x00, 0x60, 0x01, 0x80, 0x04, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x20, 0x02, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00,
  0xC0, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x40, 0x00, 0x1E, 0x30, 0x90,
  0x50, 0x28, 0x08, 0x08, 0x04, 0x02, 0x02, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x00, 0x80, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x3F,
  0x00, 0x06, 0x06, 0x00, 0x40, 0x08, 0x04, 0x00, 0x20, 0x40, 0x01, 0x04,
  0x00, 0x04, 0x40, 0xF0, 0x22, 0x08, 0x41, 0x20, 0x82, 0x09, 0x04, 0x10,
  0x50, 0x40, 0x82, 0x82, 0x08, 0x14, 0x20, 0x40, 0xC1, 0x02, 0x0A, 0x08,
  0x10, 0x50, 0x81, 0x02, 0x84, 0x08, 0x24, 0x20, 0x41, 0x21, 0x06, 0x11,
  0x04, 0x50, 0x88, 0x3C, 0x70, 0x40, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x06, 0x04, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x20, 0x00, 0x80, 0x05, 0x00, 0x14, 0x00, 0x90, 0x02, 0x40, 0x11,
  0x00, 0x44, 0x02, 0x08, 0x08, 0x20, 0x40, 0x81, 0x02, 0x08, 0x08, 0x20,
  0x20, 0xFF, 0x84, 0x02, 0x10, 0x04, 0x80, 0x12, 0x00, 0x50, 0x01, 0x40,
  0x06, 0x00, 0x10, 0x0F, 0xE0, 0x40, 0x41, 0x00, 0x84, 0x02, 0x10, 0x04,
  0x40, 0x21, 0x00, 0x88, 0x02, 0x20, 0x10, 0x80, 0x83, 0xFC, 0x08, 0x08,
  0x20, 0x11, 0x00, 0x44, 0x00, 0x90, 0x02, 0x40, 0x11, 0x00, 0x44, 0x01,
  0x20, 0x08, 0x80, 0x43, 0xFE, 0x00, 0x03, 0xE0, 0x30, 0x41, 0x00, 0x84,
  0x02, 0x20, 0x05, 0x00, 0x14, 0x00, 0x50, 0x00, 0x40, 0x01, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x04, 0x80, 0x12,
  0x00, 0x88, 0x02, 0x10, 0x10, 0x40, 0x80, 0xFC, 0x00, 0x0F, 0xE0, 0x20,
  0x30, 0x40, 0x20, 0x80, 0x21, 0x00, 0x42, 0x00, 0x44, 0x00, 0x90, 0x01,
  0x20, 0x02, 0x40, 0x08, 0x80, 0x11, 0x00, 0x22, 0x00, 0x48, 0x00, 0x90,
  0x01, 0x20, 0x04, 0x40, 0x08, 0x80, 0x21, 0x00, 0x44, 0x01, 0x08, 0x0C,
  0x1F, 0xE0, 0x00, 0x0F, 0xFC, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0xFF, 0xC1,
  0x00, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x00, 0xFF, 0xC1, 0x00, 0x02, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x00, 0x03, 0xF0, 0x10, 0x20, 0x80, 0x44, 0x01, 0x20, 0x04,
  0x80, 0x14, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00,
  0x81, 0xFA, 0x00, 0x28, 0x00, 0xA0, 0x02, 0x80, 0x0A, 0x00, 0x48, 0x01,
  0x10, 0x04, 0x20, 0x60, 0x7E, 0x00, 0x08, 0x01, 0x10, 0x01, 0x10, 0x01,
  0x10, 0x01, 0x10, 0x01, 0x10, 0x01, 0x10, 0x02, 0x20, 0x02, 0x20, 0x02,
  0x20, 0x02, 0x3F, 0xFE, 0x20, 0x02, 0x20, 0x04, 0x40, 0x04, 0x40, 0x04,
  0x40, 0x04, 0x40, 0x04, 0x40, 0x04, 0x40, 0x08, 0x80, 0x08, 0x80, 0x08,
  0x80, 0x08, 0x11, 0x11, 0x22, 0x22, 0x22, 0x44, 0x44, 0x44, 0x88, 0x88,
  0x88, 0x00, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x01, 0x00, 0x08, 0x80, 0x44, 0x02, 0x20, 0x21, 0x02, 0x04, 0x30, 0x1E,
  0x00, 0x08, 0x02, 0x10, 0x04, 0x10, 0x08, 0x10, 0x10, 0x10, 0x20, 0x10,
  0x40, 0x10, 0x80, 0x21, 0x80, 0x21, 0x00, 0x22, 0x00, 0x26, 0x00, 0x2A,
  0x00, 0x31, 0x00, 0x41, 0x00, 0x40, 0x80, 0x40, 0x80, 0x40, 0x40, 0x40,
  0x40, 0x40, 0x20, 0x80, 0x20, 0x80, 0x10, 0x80, 0x10, 0x08, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x3F,
  0xF0, 0x08, 0x00, 0x10, 0x80, 0x03, 0x18, 0x00, 0x31, 0x40, 0x05, 0x14,
  0x00, 0x51, 0x40, 0x0A, 0x14, 0x00, 0xA2, 0x40, 0x12, 0x22, 0x01, 0x22,
  0x20, 0x22, 0x22, 0x02, 0x22, 0x20, 0x44, 0x22, 0x04, 0x44, 0x20, 0x84,
  0x41, 0x08, 0x44, 0x11, 0x04, 0x41, 0x10, 0x44, 0x12, 0x08, 0x41, 0x20,
  0x88, 0x14, 0x08, 0x80, 0x80, 0x88, 0x08, 0x08, 0x08, 0x00, 0x84, 0x00,
  0x85, 0x00, 0x42, 0x80, 0x21, 0x40, 0x10, 0x90, 0x08, 0x48, 0x04, 0x42,
  0x04, 0x21, 0x02, 0x10, 0x81, 0x08, 0x20, 0x84, 0x10, 0x42, 0x08, 0x22,
  0x02, 0x21, 0x01, 0x10, 0x80, 0x48, 0x40, 0x24, 0x20, 0x12, 0x10, 0x05,
  0x10, 0x03, 0x08, 0x00, 0x84, 0x00, 0x40, 0x03, 0xE0, 0x30, 0x41, 0x00,
  0x88, 0x01, 0x20, 0x05, 0x00, 0x14, 0x00, 0x50, 0x01, 0x40, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x02, 0x80, 0x0A, 0x00, 0x28, 0x00, 0xA0, 0x02, 0x80,
  0x12, 0x00, 0x48, 0x02, 0x20, 0x10, 0x40, 0x80, 0xFC, 0x00, 0x0F, 0xF0,
  0x40, 0x21, 0x00, 0x44, 0x01, 0x10, 0x04, 0x40, 0x11, 0x00, 0x48, 0x01,
  0x20, 0x04, 0x80, 0x22, 0x01, 0x08, 0x08, 0x3F, 0xC1, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x00, 0x03, 0xE0, 0x30, 0x41, 0x00, 0x88, 0x01, 0x20, 0x05, 0x00, 0x14,
  0x00, 0x50, 0x01, 0x40, 0x06, 0x00, 0x18, 0x00, 0x60, 0x02, 0x80, 0x0A,
  0x00, 0x28, 0x00, 0xA0, 0x02, 0x80, 0x12, 0x00, 0x48, 0x02, 0x20, 0x10,
  0x40, 0x80, 0xFC, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x0F,
  0xF0, 0x40, 0x21, 0x00, 0x44, 0x01, 0x10, 0x04, 0x40, 0x11, 0x00, 0x48,
  0x01, 0x20, 0x04, 0x80, 0x22, 0x01, 0x08, 0x0C, 0x3F, 0xC1, 0x02, 0x04,
  0x04, 0x10, 0x10, 0x40, 0x41, 0x00, 0x84, 0x02, 0x20, 0x04, 0x80, 0x12,
  0x00, 0x40, 0x03, 0xE0, 0x30, 0x61, 0x00, 0x84, 0x01, 0x20, 0x04, 0x80,
  0x12, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x70, 0x00, 0x30, 0x00,
  0x20, 0x00, 0x40, 0x01, 0x00, 0x04, 0x80, 0x12, 0x00, 0x48, 0x01, 0x20,
  0x08, 0x60, 0xC0, 0x7C, 0x00, 0xFF, 0xF8, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x00, 0x20, 0x02, 0x40, 0x04,
  0x80, 0x11, 0x00, 0x22, 0x00, 0x44, 0x00, 0x90, 0x01, 0x20, 0x02, 0x40,
  0x08, 0x80, 0x11, 0x00, 0x22, 0x00, 0x48, 0x00, 0x90, 0x01, 0x20, 0x04,
  0x40, 0x08, 0x80, 0x11, 0x00, 0x22, 0x00, 0x84, 0x02, 0x04, 0x08, 0x07,
  0xE0, 0x00, 0x80, 0x02, 0x00, 0x28, 0x00, 0xA0, 0x04, 0x80, 0x12, 0x00,
  0x88, 0x02, 0x10, 0x10, 0x40, 0x41, 0x02, 0x04, 0x08, 0x10, 0x20, 0x41,
  0x00, 0x84, 0x02, 0x20, 0x08, 0x80, 0x24, 0x00, 0x90, 0x02, 0x80, 0x0A,
  0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x20, 0x0C, 0x03, 0x00, 0xA0, 0x18,
  0x05, 0x01, 0x40, 0x28, 0x0A, 0x02, 0x40, 0x50, 0x12, 0x04, 0x40, 0x90,
  0x22, 0x08, 0x81, 0x10, 0x44, 0x10, 0x84, 0x10, 0x84, 0x20, 0x88, 0x21,
  0x04, 0x41, 0x10, 0x22, 0x08, 0x81, 0x20, 0x44, 0x09, 0x02, 0x40, 0x50,
  0x12, 0x02, 0x80, 0x90, 0x14, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x00, 0x80,
  0x20, 0x04, 0x00, 0x10, 0x01, 0x08, 0x02, 0x08, 0x04, 0x08, 0x04, 0x04,
  0x08, 0x04, 0x10, 0x02, 0x10, 0x02, 0x20, 0x01, 0x40, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x02, 0x80, 0x04, 0x40, 0x04, 0x40, 0x08, 0x40, 0x10,
  0x20, 0x10, 0x20, 0x20, 0x10, 0x40, 0x10, 0x40, 0x10, 0x80, 0x08, 0x80,
  0x02, 0x00, 0x24, 0x01, 0x10, 0x04, 0x40, 0x21, 0x01, 0x02, 0x04, 0x08,
  0x20, 0x21, 0x00, 0x44, 0x01, 0x20, 0x05, 0x00, 0x0C, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x00, 0x0F, 0xFF, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0xFF, 0xF0, 0x07, 0x04,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x40, 0x40, 0x40, 0x40, 0x40,
  0x40, 0x80, 0xF0, 0x88, 0x88, 0x44, 0x44, 0x44, 0x42, 0x22, 0x22, 0x22,
  0x11, 0x11, 0x11, 0x07, 0x01, 0x01, 0x01, 0x02, 0x02, 0x02, 0x02, 0x02,
  0x02, 0x02, 0x04, 0x04, 0x04, 0x04, 0x04, 0x04, 0x08, 0x08, 0x08, 0x08,
  0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10, 0xF0, 0x04, 0x0C, 0x0C, 0x12,
  0x12, 0x22, 0x22, 0x42, 0x42, 0x82, 0x81, 0xFF, 0xC0, 0x88, 0x90, 0x07,
  0xC0, 0x82, 0x10, 0x12, 0x01, 0x20, 0x10, 0x01, 0x00, 0x20, 0xFE, 0x30,
  0x24, 0x02, 0x40, 0x28, 0x02, 0x80, 0x48, 0x0C, 0x41, 0x43, 0xE4, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x20, 0x02, 0x7C, 0x28,
  0x23, 0x02, 0x20, 0x12, 0x01, 0x40, 0x14, 0x01, 0x40, 0x24, 0x02, 0x40,
  0x28, 0x02, 0x80, 0x48, 0x04, 0xC0, 0x8A, 0x18, 0x9E, 0x00, 0x07, 0x82,
  0x08, 0x80, 0xA0, 0x14, 0x02, 0x80, 0x60, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x28, 0x05, 0x01, 0x10, 0x41, 0xF0, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x41, 0xF2, 0x10, 0x51, 0x01,
  0x88, 0x08, 0x80, 0x44, 0x02, 0x20, 0x11, 0x00, 0x90, 0x04, 0x80, 0x44,
  0x02, 0x20, 0x11, 0x00, 0x88, 0x0C, 0x20, 0xA0, 0xFA, 0x00, 0x0F, 0x82,
  0x08, 0x80, 0xA0, 0x14, 0x02, 0x80, 0x7F, 0xFC, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x10, 0x61, 0xF0, 0x07, 0x84, 0x02, 0x02,
  0x01, 0x00, 0x80, 0x81, 0xFC, 0x20, 0x10, 0x08, 0x04, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x20, 0x10, 0x08, 0x04, 0x02, 0x00, 0x07, 0xC8,
  0x41, 0x44, 0x06, 0x20, 0x22, 0x01, 0x10, 0x08, 0x80, 0x48, 0x02, 0x40,
  0x12, 0x01, 0x10, 0x08, 0x80, 0x44, 0x02, 0x20, 0x30, 0x82, 0x83, 0xE8,
  0x00, 0x40, 0x02, 0x00, 0x11, 0x01, 0x04, 0x10, 0x1F, 0x00, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x08, 0x01, 0x1E, 0x2C, 0x26, 0x04,
  0xC0, 0x90, 0x12, 0x02, 0x80, 0x50, 0x0A, 0x01, 0x40, 0x28, 0x0A, 0x01,
  0x40, 0x28, 0x05, 0x00, 0xA0, 0x10, 0x00, 0xC0, 0x00, 0x00, 0x84, 0x21,
  0x08, 0x44, 0x21, 0x08, 0x42, 0x21, 0x08, 0x40, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x20, 0x08, 0x02, 0x01, 0x03, 0x80, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x20, 0x02, 0x02, 0x20, 0x42, 0x08, 0x21, 0x02,
  0x20, 0x44, 0x04, 0x80, 0x58, 0x06, 0x80, 0x44, 0x04, 0x20, 0x82, 0x08,
  0x10, 0x81, 0x08, 0x08, 0x80, 0x80, 0x08, 0x84, 0x21, 0x08, 0x44, 0x21,
  0x08, 0x42, 0x21, 0x08, 0x42, 0x11, 0x08, 0x42, 0x00, 0x27, 0xC3, 0xE2,
  0x82, 0x42, 0x30, 0x28, 0x12, 0x03, 0x01, 0x20, 0x20, 0x14, 0x02, 0x01,
  0x40, 0x20, 0x14, 0x02, 0x01, 0x40, 0x20, 0x24, 0x04, 0x02, 0x80, 0x40,
  0x28, 0x04, 0x02, 0x80, 0x40, 0x28, 0x04, 0x02, 0x80, 0x40, 0x48, 0x08,
  0x04, 0x23, 0xC5, 0x84, 0xC0, 0x98, 0x12, 0x02, 0x40, 0x50, 0x0A, 0x01,
  0x40, 0x28, 0x05, 0x01, 0x40, 0x28, 0x05, 0x00, 0xA0, 0x14, 0x02, 0x07,
  0xC1, 0x86, 0x20, 0x22, 0x01, 0x40, 0x14, 0x01, 0x40, 0x18, 0x02, 0x80,
  0x28, 0x02, 0x80, 0x28, 0x04, 0x80, 0x44, 0x08, 0x41, 0x83, 0xE0, 0x13,
  0xE0, 0xA0, 0x86, 0x04, 0x20, 0x11, 0x00, 0x90, 0x04, 0x80, 0x24, 0x02,
  0x20, 0x11, 0x00, 0x90, 0x04, 0x80, 0x44, 0x02, 0x30, 0x21, 0x43, 0x09,
  0xE0, 0x40, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x00, 0x0F,
  0x91, 0x05, 0x20, 0x32, 0x02, 0x40, 0x24, 0x02, 0x40, 0x24, 0x02, 0x80,
  0x28, 0x04, 0x80, 0x48, 0x04, 0x80, 0x48, 0x0C, 0x41, 0x43, 0xE8, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x10, 0x27, 0x14, 0x0C, 0x04,
  0x02, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x07, 0xC1, 0x82, 0x10, 0x22, 0x01, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x40, 0x04, 0x40, 0x44, 0x04, 0x60,
  0x81, 0xF0, 0x10, 0x41, 0x08, 0xFC, 0x82, 0x08, 0x41, 0x04, 0x10, 0x41,
  0x08, 0x20, 0x82, 0x08, 0x1C, 0x40, 0x28, 0x05, 0x00, 0xA0, 0x14, 0x05,
  0x00, 0xA0, 0x14, 0x02, 0x80, 0x50, 0x12, 0x02, 0x40, 0x48, 0x09, 0x03,
  0x20, 0xA3, 0xE8, 0x80, 0x10, 0x0A, 0x01, 0x40, 0x48, 0x08, 0x82, 0x10,
  0x42, 0x10, 0x42, 0x08, 0x81, 0x10, 0x14, 0x02, 0x80, 0x60, 0x0C, 0x01,
  0x00, 0x80, 0x80, 0xC0, 0x40, 0x50, 0x60, 0x48, 0x28, 0x24, 0x24, 0x22,
  0x12, 0x11, 0x11, 0x10, 0x88, 0x88, 0x44, 0x44, 0x24, 0x24, 0x12, 0x12,
  0x0A, 0x0A, 0x05, 0x05, 0x03, 0x02, 0x81, 0x80, 0x80, 0x80, 0x40, 0x20,
  0x11, 0x02, 0x10, 0x40, 0x84, 0x08, 0x80, 0x50, 0x05, 0x00, 0x20, 0x06,
  0x00, 0xA0, 0x09, 0x01, 0x10, 0x20, 0x84, 0x08, 0x40, 0x88, 0x04, 0x10,
  0x04, 0x40, 0x21, 0x00, 0x84, 0x04, 0x08, 0x10, 0x20, 0x80, 0x82, 0x02,
  0x10, 0x08, 0x40, 0x22, 0x00, 0x48, 0x01, 0x40, 0x05, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x10, 0x03,
  0x80, 0x00, 0x1F, 0xF0, 0x02, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x0F, 0xFC, 0x00, 0x80, 0x80, 0x80, 0x80, 0x40, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x02, 0x01, 0x01, 0x03, 0x00, 0xC0, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x02, 0x00, 0x80, 0x11,
  0x11, 0x11, 0x22, 0x22, 0x22, 0x24, 0x44, 0x44, 0x48, 0x88, 0x88, 0x88,
  0x04, 0x01, 0x00, 0x80, 0x20, 0x10, 0x08, 0x04, 0x02, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x08, 0x02, 0x06, 0x02, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x40, 0x20, 0x10, 0x08, 0x08, 0x04, 0x0C, 0x08, 0x00, 0x38, 0x05, 0x10,
  0x28, 0x20, 0xA0, 0x44, 0x80, 0xE0,
};

const GFXglyph RobotoCondensed_ThinItalic30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 4, 22, 5, 1, -22 },
  { 12, 5, 6, 8, 3, -23 },
  { 16, 15, 22, 14, 0, -22 },
  { 58, 12, 28, 14, 1, -25 },
  { 100, 14, 22, 19, 3, -22 },
  { 139, 13, 22, 16, 1, -22 },
  { 175, 2, 6, 5, 3, -23 },
  { 177, 9, 31, 8, 1, -24 },
  { 212, 8, 31, 8, -2, -24 },
  { 243, 11, 12, 12, 2, -22 },
  { 260, 12, 15, 14, 1, -18 },
  { 283, 3, 6, 5, -1, -2 },
  { 286, 6, 1, 8, 1, -10 },
  { 287, 1, 2, 6, 1, -2 },
  { 288, 12, 24, 10, -1, -22 },
  { 324, 12, 22, 14, 1, -22 },
  { 357, 6, 22, 14, 4, -22 },
  { 374, 12, 22, 14, 1, -22 },
  { 407, 12, 22, 14, 1, -22 },
  { 440, 12, 22, 14, 1, -22 },
  { 473, 12, 22, 14, 2, -22 },
  { 506, 11, 22, 14, 1, -22 },
  { 537, 11, 22, 14, 3, -22 },
  { 568, 13, 22, 14, 1, -22 },
  { 604, 11, 22, 14, 2, -22 },
  { 635, 5, 16, 5, 0, -16 },
  { 645, 6, 20, 5, -1, -16 },
  { 660, 12, 12, 13, 1, -16 },
  { 678, 11, 7, 14, 2, -13 },
  { 688, 11, 12, 13, 1, -16 },
  { 705, 9, 22, 11, 3, -22 },
  { 730, 21, 28, 23, 1, -21 },
  { 804, 14, 22, 15, -1, -22 },
  { 843, 14, 22, 15, 1, -22 },
  { 882, 14, 22, 17, 2, -22 },
  { 921, 15, 22, 17, 1, -22 },
  { 963, 15, 22, 15, 1, -22 },
  { 1005, 15, 22, 15, 1, -22 },
  { 1047, 14, 22, 18, 2, -22 },
  { 1086, 16, 22, 18, 1, -22 },
  { 1130, 4, 22, 7, 2, -22 },
  { 1141, 13, 22, 14, 1, -22 },
  { 1177, 16, 22, 16, 1, -22 },
  { 1221, 10, 22, 13, 1, -22 },
  { 1249, 20, 22, 22, 1, -22 },
  { 1304, 17, 22, 18, 1, -22 },
  { 1351, 14, 22, 17, 2, -22 },
  { 1390, 14, 22, 15, 1, -22 },
  { 1429, 14, 26, 17, 2, -22 },
  { 1475, 14, 22, 17, 1, -22 },
  { 1514, 14, 22, 15, 1, -22 },
  { 1553, 14, 22, 15, 3, -22 },
  { 1592, 15, 22, 17, 2, -22 },
  { 1634, 14, 22, 15, 3, -22 },
  { 1673, 21, 22, 23, 3, -22 },
  { 1731, 16, 22, 15, 0, -22 },
  { 1775, 14, 22, 15, 3, -22 },
  { 1814, 16, 22, 15, 0, -22 },
  { 1858, 8, 29, 6, 0, -24 },
  { 1887, 4, 24, 10, 3, -22 },
  { 1899, 8, 29, 6, -2, -24 },
  { 1928, 8, 11, 11, 2, -22 },
  { 1939, 10, 1, 11, -1, 0 },
  { 1941, 3, 4, 8, 4, -23 },
  { 1943, 12, 16, 14, 0, -16 },
  { 1967, 12, 23, 14, 1, -23 },
  { 2002, 11, 16, 13, 1, -16 },
  { 2024, 13, 23, 14, 1, -23 },
  { 2062, 11, 16, 13, 1, -16 },
  { 2084, 9, 23, 8, 2, -23 },
  { 2110, 13, 22, 14, 0, -16 },
  { 2146, 11, 23, 14, 1, -23 },
  { 2178, 5, 22, 6, 1, -22 },
  { 2192, 10, 28, 6, -4, -22 },
  { 2227, 12, 23, 12, 1, -23 },
  { 2262, 5, 23, 6, 1, -23 },
  { 2277, 20, 16, 23, 1, -16 },
  { 2317, 11, 16, 14, 1, -16 },
  { 2339, 12, 16, 14, 1, -16 },
  { 2363, 13, 22, 14, 0, -16 },
  { 2399, 12, 22, 14, 1, -16 },
  { 2432, 9, 16, 9, 1, -16 },
  { 2450, 12, 16, 13, 0, -16 },
  { 2474, 6, 20, 8, 2, -20 },
  { 2489, 11, 16, 14, 2, -16 },
  { 2511, 11, 16, 12, 2, -16 },
  { 2533, 17, 16, 19, 2, -16 },
  { 2567, 12, 16, 12, 0, -16 },
  { 2591, 14, 22, 12, -1, -16 },
  { 2630, 12, 16, 12, 0, -16 },
  { 2654, 9, 29, 9, 1, -23 },
  { 2687, 4, 26, 6, 1, -22 },
  { 2700, 9, 29, 9, -2, -23 },
  { 2733, 14, 5, 18, 2, -12 },
};

const GFXfont RobotoCondensed_ThinItalic30pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ThinItalic30pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ThinItalic30pt7bGlyphs,
  0x20, 0x7E, 35
};

#endif // _ROBOTOCONDENSED_THINITALIC30PT7B_H_
