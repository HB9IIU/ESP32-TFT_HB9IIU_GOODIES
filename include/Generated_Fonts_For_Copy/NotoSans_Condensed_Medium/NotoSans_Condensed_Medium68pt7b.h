#ifndef _NOTOSANS_CONDENSED_MEDIUM68PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUM68PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Medium.ttf
// Size: 68pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Medium68pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xBF, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F,
  0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7,
  0xF3, 0xF9, 0xFC, 0xFE, 0x3F, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8,
  0x7C, 0x3E, 0x1F, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x3F,
  0x9F, 0xDF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0x7F, 0x0E, 0x00, 0xFE, 0x0F,
  0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0,
  0x7E, 0xFE, 0x07, 0xEF, 0xE0, 0x7E, 0xFE, 0x07, 0xE7, 0xE0, 0x7E, 0x7E,
  0x07, 0xE7, 0xE0, 0x7E, 0x7C, 0x07, 0xE7, 0xC0, 0x7E, 0x7C, 0x07, 0xE7,
  0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x00, 0x0F, 0x80, 0xF8, 0x00,
  0x07, 0xC0, 0x7C, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x03, 0xF0, 0x3E, 0x00,
  0x01, 0xF0, 0x1F, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x7C, 0x07, 0xC0,
  0x00, 0x3E, 0x03, 0xE0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0xF8,
  0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x03, 0xE0, 0x3E,
  0x00, 0x01, 0xF0, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0x80, 0xF8, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x03, 0xE0,
  0x3E, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0xF8,
  0x0F, 0x80, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x1F,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x07, 0xC0, 0x7C, 0x03, 0xFF,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3E, 0x03, 0xE0, 0x00,
  0x1F, 0x01, 0xF0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x0F, 0x80, 0xF8, 0x00,
  0x07, 0xC0, 0x7C, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x01, 0xF0, 0x1F, 0x00,
  0x00, 0xF8, 0x0F, 0x80, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x3E, 0x07, 0xC0,
  0x00, 0x3E, 0x03, 0xE0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0xF8,
  0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC7, 0xF8,
  0xE0, 0x70, 0xFE, 0x1C, 0x02, 0x3F, 0x83, 0x80, 0x07, 0xF0, 0x70, 0x00,
  0xFC, 0x0E, 0x00, 0x1F, 0x81, 0xC0, 0x03, 0xF8, 0x38, 0x00, 0x7F, 0x07,
  0x00, 0x0F, 0xE0, 0xE0, 0x00, 0xFE, 0x1C, 0x00, 0x1F, 0xF3, 0x80, 0x01,
  0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x77, 0xFC, 0x00, 0x0E, 0x3F, 0xC0, 0x01, 0xC3,
  0xF8, 0x00, 0x38, 0x3F, 0x00, 0x07, 0x07, 0xF0, 0x00, 0xE0, 0xFE, 0x00,
  0x1C, 0x1F, 0xC0, 0x03, 0x83, 0xF8, 0x00, 0x70, 0x7E, 0x80, 0x0E, 0x1F,
  0xDE, 0x01, 0xC7, 0xFB, 0xF8, 0x3B, 0xFE, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F,
  0x80, 0x07, 0xFF, 0xF0, 0x00, 0xF8, 0x00, 0x3F, 0x0F, 0x80, 0x07, 0xC0,
  0x01, 0xF0, 0x7E, 0x00, 0x7E, 0x00, 0x1F, 0x83, 0xF0, 0x03, 0xE0, 0x00,
  0xFC, 0x0F, 0x80, 0x3F, 0x00, 0x07, 0xC0, 0x7C, 0x01, 0xF0, 0x00, 0x3E,
  0x03, 0xE0, 0x1F, 0x80, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x00, 0x0F, 0x80,
  0xFC, 0x07, 0xC0, 0x00, 0x7C, 0x07, 0xE0, 0x7E, 0x00, 0x03, 0xE0, 0x3F,
  0x03, 0xE0, 0x00, 0x1F, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0xF8, 0x0F, 0xC1,
  0xF0, 0x00, 0x07, 0xC0, 0x7E, 0x1F, 0x80, 0x00, 0x3E, 0x03, 0xF0, 0xFC,
  0x00, 0x01, 0xF0, 0x1F, 0x07, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x7E, 0x1F,
  0xF0, 0x7E, 0x07, 0xC3, 0xE1, 0xFF, 0xC3, 0xF0, 0x7E, 0x3F, 0x1F, 0xFF,
  0x0F, 0x83, 0xF1, 0xF0, 0xFF, 0xFC, 0x7E, 0x1F, 0x0F, 0x8F, 0xC7, 0xE1,
  0xFF, 0xF8, 0xFC, 0x7C, 0x1F, 0x8F, 0xFF, 0x87, 0xC3, 0xE0, 0xFC, 0x3F,
  0xFC, 0x7E, 0x3F, 0x03, 0xE0, 0xFF, 0xC3, 0xE1, 0xF8, 0x1F, 0x03, 0xF8,
  0x3F, 0x0F, 0x80, 0xFC, 0x00, 0x01, 0xF8, 0x7C, 0x07, 0xE0, 0x00, 0x0F,
  0x83, 0xE0, 0x3F, 0x00, 0x00, 0xFC, 0x1F, 0x01, 0xF8, 0x00, 0x07, 0xC0,
  0xF8, 0x0F, 0xC0, 0x00, 0x7E, 0x07, 0xC0, 0x7E, 0x00, 0x03, 0xE0, 0x3E,
  0x03, 0xF0, 0x00, 0x1F, 0x01, 0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x0F, 0x80,
  0xFC, 0x00, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x00, 0xFC, 0x03, 0xE0, 0x3F,
  0x00, 0x07, 0xC0, 0x1F, 0x81, 0xF0, 0x00, 0x7E, 0x00, 0x7C, 0x0F, 0x80,
  0x03, 0xE0, 0x03, 0xE0, 0xFC, 0x00, 0x1F, 0x00, 0x1F, 0x87, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x7E, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xFC, 0x7F, 0x80,
  0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x0F, 0xE0,
  0x3F, 0x00, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x7E, 0x00, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x1F,
  0x80, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0xFE, 0x00, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x00, 0xFE, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0x03, 0xFF, 0xF8,
  0x03, 0xF8, 0x3F, 0xCF, 0xE0, 0x1F, 0x83, 0xFC, 0x7F, 0x81, 0xFC, 0x1F,
  0xC1, 0xFE, 0x0F, 0xE1, 0xFE, 0x07, 0xF0, 0x7F, 0x0F, 0xE0, 0x1F, 0xC3,
  0xF0, 0x7F, 0x00, 0xFF, 0x3F, 0x83, 0xF0, 0x03, 0xFD, 0xFC, 0x3F, 0x80,
  0x0F, 0xFF, 0xC1, 0xFC, 0x00, 0x3F, 0xFE, 0x0F, 0xE0, 0x01, 0xFF, 0xE0,
  0x7F, 0x00, 0x07, 0xFF, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x0F, 0xE0, 0x00,
  0xFF, 0x80, 0x7F, 0x00, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x7F, 0xF0, 0x1F,
  0xF0, 0x0F, 0xFF, 0xC0, 0x7F, 0xE3, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x9F, 0xE0, 0x3F, 0xFF, 0xF8, 0x7F, 0x80, 0xFF,
  0xFF, 0x01, 0xFE, 0x01, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFD, 0xFB, 0xF7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF8, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x0F,
  0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x3F,
  0x80, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x3F,
  0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x07,
  0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF8,
  0x03, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0,
  0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xFC, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFC, 0x01, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0xFE, 0x01, 0xF8, 0x03,
  0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x7F, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xE0,
  0x1F, 0xC0, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x78, 0x1F, 0x03, 0x9F, 0xC7, 0xC7, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7E, 0xF8, 0x00, 0x1F, 0xBF, 0x00,
  0x0F, 0xC7, 0xE0, 0x07, 0xF1, 0xFC, 0x03, 0xF8, 0x7F, 0x01, 0xFE, 0x0F,
  0xE0, 0x3F, 0x01, 0xFC, 0x03, 0xC0, 0x78, 0x00, 0x60, 0x18, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x1F, 0xE3, 0xFC, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87,
  0xE1, 0xFC, 0x3F, 0x87, 0xE0, 0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x1F, 0x83,
  0xE0, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x1C, 0x3F, 0xBF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE,
  0x7F, 0x0E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFC, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x03, 0xF8, 0x3F, 0x80, 0x7F,
  0x07, 0xF0, 0x07, 0xF1, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xC7, 0xF0,
  0x01, 0xFC, 0xFC, 0x00, 0x3F, 0xBF, 0x80, 0x07, 0xF7, 0xF0, 0x00, 0xFE,
  0xFE, 0x00, 0x1F, 0xDF, 0xC0, 0x01, 0xFB, 0xF8, 0x00, 0x3F, 0x7F, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF,
  0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7E, 0xFE, 0x00, 0x1F, 0xDF, 0xC0, 0x03,
  0xFB, 0xF8, 0x00, 0x7F, 0x7F, 0x00, 0x0F, 0xE7, 0xF0, 0x01, 0xFC, 0xFE,
  0x00, 0x3F, 0x9F, 0xC0, 0x0F, 0xE3, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x3F,
  0x87, 0xF0, 0x0F, 0xE0, 0xFF, 0x03, 0xFC, 0x0F, 0xF9, 0xFF, 0x00, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0xFF, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x03, 0xF0,
  0x03, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xFC, 0x1F,
  0xFF, 0x0F, 0xFF, 0xC7, 0xFB, 0xF3, 0xFC, 0xFF, 0xFE, 0x3F, 0x7F, 0x0F,
  0xCF, 0x83, 0xF1, 0xC0, 0xFC, 0x20, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xC7, 0xF0, 0x1F, 0xF1, 0xF0, 0x01, 0xFC,
  0x38, 0x00, 0x7F, 0x84, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xC7, 0xE0, 0x0F,
  0xF0, 0xE0, 0x01, 0xFE, 0x30, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x01, 0xFF,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x01,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xEE, 0x00, 0x0F, 0xFB, 0xF8, 0x1F,
  0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0x7E, 0x00, 0x00,
  0xFD, 0xF8, 0x00, 0x03, 0xEF, 0xE0, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x7C,
  0xFE, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x0F, 0x8F, 0xE0, 0x00, 0x7E, 0x3F,
  0x80, 0x01, 0xF0, 0xFE, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x3E, 0x0F, 0xE0,
  0x01, 0xF8, 0x3F, 0x80, 0x0F, 0xC0, 0xFE, 0x00, 0x3F, 0x03, 0xF8, 0x01,
  0xF8, 0x0F, 0xE0, 0x07, 0xE0, 0x3F, 0x80, 0x3F, 0x00, 0xFE, 0x00, 0xF8,
  0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0x00, 0x3F, 0x80, 0xFC, 0x00,
  0xFE, 0x03, 0xE0, 0x03, 0xF8, 0x1F, 0x80, 0x0F, 0xE0, 0x7C, 0x00, 0x3F,
  0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0,
  0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x02, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xB0, 0x00, 0x1F, 0xEF, 0x00, 0x1F, 0xF3, 0xFC, 0x1F, 0xFC,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x3F, 0x80,
  0x7F, 0x1F, 0xFC, 0x0F, 0xE7, 0xFF, 0xC1, 0xFD, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xC7, 0xEF, 0xFF, 0xFC, 0xFF, 0xE0, 0x7F, 0x9F, 0xF0, 0x07, 0xFB,
  0xFE, 0x00, 0x7F, 0x7F, 0x80, 0x0F, 0xEF, 0xE0, 0x01, 0xFD, 0xFC, 0x00,
  0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF,
  0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xF7, 0xE0, 0x00,
  0xFE, 0xFE, 0x00, 0x1F, 0xDF, 0xC0, 0x03, 0xF3, 0xF8, 0x00, 0xFE, 0x3F,
  0x80, 0x1F, 0xC7, 0xF0, 0x07, 0xF0, 0x7F, 0x01, 0xFE, 0x0F, 0xF8, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0x9F, 0xF8, 0x1F, 0xC0,
  0x3F, 0xC3, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xE3, 0xF8, 0x00, 0xFE,
  0x3F, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0xFE, 0x3F, 0x00, 0x0F, 0xE3, 0xF0,
  0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xC3, 0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x1F,
  0xC1, 0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x8F, 0xF0, 0x07,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00,
  0xFF, 0x1F, 0xF0, 0x1F, 0xE0, 0xFF, 0x83, 0xFC, 0x03, 0xFC, 0x3F, 0x80,
  0x1F, 0xE7, 0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x7F,
  0x7E, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x7F, 0x7E, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x7F, 0x7F, 0x00, 0x07,
  0xF7, 0xF0, 0x00, 0xFE, 0x7F, 0x80, 0x1F, 0xE3, 0xFE, 0x03, 0xFC, 0x1F,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0xF0, 0x7F, 0xC3, 0xFC, 0x03, 0xF8, 0x7F,
  0x00, 0x7F, 0x9F, 0xC0, 0x07, 0xF3, 0xF8, 0x00, 0xFE, 0x7F, 0x00, 0x0F,
  0xCF, 0xE0, 0x01, 0xFD, 0xF8, 0x00, 0x3F, 0xBF, 0x00, 0x07, 0xF7, 0xE0,
  0x00, 0xFE, 0xFC, 0x00, 0x1F, 0xDF, 0x80, 0x01, 0xFB, 0xF0, 0x00, 0x7F,
  0x7F, 0x00, 0x0F, 0xEF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80,
  0x0F, 0xF3, 0xF8, 0x03, 0xFE, 0x7F, 0x80, 0xFF, 0xCF, 0xFC, 0x7F, 0xF8,
  0xFF, 0xFF, 0xBF, 0x0F, 0xFF, 0xF7, 0xE0, 0xFF, 0xFC, 0xFC, 0x0F, 0xFF,
  0x1F, 0x80, 0xFF, 0x83, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xF0, 0x18, 0x0F, 0xFC,
  0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x3F, 0xBF,
  0xDF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFE, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xC3, 0xF9, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF,
  0xEF, 0xE7, 0xF0, 0xE0, 0x0F, 0x83, 0xF8, 0xFF, 0x1F, 0xF3, 0xFE, 0x7F,
  0xCF, 0xF0, 0xFE, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x87, 0xF8, 0xFE,
  0x1F, 0xC3, 0xF8, 0x7F, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xC1, 0xF8, 0x3F,
  0x0F, 0xC1, 0xF8, 0x3E, 0x07, 0xC1, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8,
  0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7F,
  0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x00,
  0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x81, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x1F, 0x01, 0xFF, 0x18, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x00, 0x7C, 0x1F, 0x80, 0x3F, 0xFF, 0x07,
  0xE1, 0xF0, 0x07, 0xFF, 0xF0, 0x3E, 0x3F, 0x00, 0xFF, 0xFF, 0x03, 0xE3,
  0xE0, 0x1F, 0xFF, 0xF0, 0x3E, 0x3E, 0x03, 0xF8, 0x3F, 0x03, 0xF7, 0xE0,
  0x3F, 0x03, 0xF0, 0x1F, 0x7E, 0x07, 0xE0, 0x3F, 0x01, 0xF7, 0xC0, 0x7C,
  0x03, 0xF0, 0x1F, 0x7C, 0x07, 0xC0, 0x3F, 0x01, 0xF7, 0xC0, 0xFC, 0x03,
  0xF0, 0x1F, 0xFC, 0x0F, 0xC0, 0x3F, 0x01, 0xFF, 0xC0, 0xF8, 0x03, 0xE0,
  0x1F, 0xFC, 0x0F, 0x80, 0x3E, 0x01, 0xFF, 0xC0, 0xF8, 0x03, 0xE0, 0x1F,
  0xFC, 0x0F, 0x80, 0x3E, 0x01, 0xFF, 0xC0, 0xF8, 0x03, 0xE0, 0x1F, 0xFC,
  0x0F, 0x80, 0x7E, 0x03, 0xFF, 0xC0, 0xF8, 0x07, 0xE0, 0x3E, 0xFC, 0x0F,
  0xC0, 0x7E, 0x03, 0xEF, 0xC0, 0xFC, 0x07, 0xE0, 0x3E, 0x7C, 0x0F, 0xC0,
  0xFF, 0x07, 0xE7, 0xC0, 0x7E, 0x0F, 0xF0, 0x7C, 0x7C, 0x07, 0xF1, 0xEF,
  0x9F, 0xC7, 0xE0, 0x3F, 0xFE, 0xFF, 0xF8, 0x7E, 0x03, 0xFF, 0xC7, 0xFF,
  0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xE0, 0x3F, 0x00, 0x7F, 0x01, 0xFC, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x04, 0x00, 0x03, 0xFC, 0x00, 0x03, 0x80, 0x00, 0x1F, 0xF8, 0x01, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFB,
  0xF8, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00,
  0x3F, 0x9F, 0x80, 0x00, 0x03, 0xF1, 0xFC, 0x00, 0x00, 0x3F, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0xFC, 0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x07, 0xE0,
  0xFE, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x00,
  0xFE, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x01, 0xFC, 0x03, 0xF0,
  0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x1F, 0x80,
  0x3F, 0x80, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x0F,
  0xE0, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x00, 0x3F,
  0x81, 0xFC, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x00, 0x3F, 0x83, 0xF8, 0x00,
  0x03, 0xFC, 0x3F, 0x80, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x01, 0xFC, 0x7F,
  0x80, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x01, 0xFE, 0x7F, 0x00, 0x00, 0x0F,
  0xEF, 0xF0, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xE3, 0xF8, 0x0F, 0xFF, 0x9F,
  0xC0, 0x07, 0xFC, 0xFE, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x7F, 0x3F, 0x80,
  0x03, 0xFD, 0xFC, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x7F, 0x7F, 0x00, 0x03,
  0xFB, 0xF8, 0x00, 0x3F, 0xDF, 0xC0, 0x01, 0xFC, 0xFE, 0x00, 0x0F, 0xE7,
  0xF0, 0x00, 0x7F, 0x3F, 0x80, 0x07, 0xF1, 0xFC, 0x00, 0x7F, 0x8F, 0xE0,
  0x1F, 0xF8, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF1,
  0xFC, 0x00, 0x7F, 0xCF, 0xE0, 0x01, 0xFE, 0x7F, 0x00, 0x07, 0xFB, 0xF8,
  0x00, 0x1F, 0xDF, 0xC0, 0x00, 0xFE, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0xFE, 0xFE,
  0x00, 0x0F, 0xF7, 0xF0, 0x00, 0xFF, 0xBF, 0x80, 0x0F, 0xF9, 0xFF, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xF0, 0x0F, 0x01, 0xFF,
  0x00, 0x0C, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x20, 0x7F, 0xE0,
  0x03, 0x00, 0xFF, 0xF9, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFE, 0x00, 0x7F, 0xE0,
  0xFE, 0x00, 0x1F, 0xF0, 0xFE, 0x00, 0x0F, 0xF8, 0xFE, 0x00, 0x07, 0xF8,
  0xFE, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x01, 0xFC,
  0xFE, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x00, 0xFE,
  0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFE,
  0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFE,
  0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFE,
  0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x01, 0xFC,
  0xFE, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x03, 0xF8,
  0xFE, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x1F, 0xF0,
  0xFE, 0x00, 0x3F, 0xE0, 0xFE, 0x01, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xF7, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFC, 0x01, 0xF8, 0x1F, 0xF8, 0x00, 0x1C, 0x0F,
  0xF0, 0x00, 0x04, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xDF, 0xC0,
  0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x03, 0xF9, 0xFC,
  0x00, 0x01, 0xFC, 0xFF, 0x00, 0x00, 0xFE, 0x7F, 0xC0, 0x00, 0x7F, 0x1F,
  0xE0, 0x00, 0x3F, 0x8F, 0xF8, 0x00, 0x1F, 0xC3, 0xFF, 0x00, 0x0F, 0xE0,
  0xFF, 0xF9, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xF0, 0x7F, 0xE0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x03, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFF,
  0x00, 0xFE, 0x01, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xF8,
  0xFF, 0xF0, 0xFF, 0xC0, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xEF,
  0xE0, 0x00, 0x7F, 0xBF, 0x80, 0x03, 0xFC, 0xFE, 0x00, 0x0F, 0xE3, 0xF8,
  0x00, 0x7F, 0x8F, 0xE0, 0x03, 0xFC, 0x3F, 0x80, 0x0F, 0xE0, 0xFE, 0x00,
  0x7F, 0x83, 0xF8, 0x03, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0x3F, 0x80, 0x7F,
  0x80, 0xFE, 0x03, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x0F, 0xE0, 0x7F, 0x80,
  0x3F, 0x81, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xF8, 0x7F, 0x80, 0x0F,
  0xE1, 0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0xFE, 0x7F, 0x80, 0x03, 0xF9,
  0xFC, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x3F, 0xBF, 0xE0, 0x00, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0xFF, 0xCF, 0xE0, 0x03, 0xFE, 0x3F, 0xC0, 0x0F, 0xF0, 0x7F, 0x00,
  0x3F, 0x81, 0xFE, 0x00, 0xFE, 0x03, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x0F,
  0xE0, 0x1F, 0xE0, 0x3F, 0x80, 0x7F, 0x80, 0xFE, 0x00, 0xFF, 0x03, 0xF8,
  0x03, 0xFC, 0x0F, 0xE0, 0x07, 0xF8, 0x3F, 0x80, 0x0F, 0xE0, 0xFE, 0x00,
  0x3F, 0xC3, 0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xFE, 0x3F, 0x80, 0x03,
  0xF8, 0xFE, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x7F,
  0xBF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xBF, 0x00, 0x00, 0x3F, 0xFF, 0xF7,
  0xE0, 0x00, 0x07, 0xDF, 0xFE, 0xFC, 0x00, 0x01, 0xFB, 0xFF, 0xEF, 0xC0,
  0x00, 0x3F, 0x7F, 0xFD, 0xF8, 0x00, 0x07, 0xCF, 0xFF, 0xBF, 0x00, 0x01,
  0xF9, 0xFF, 0xF3, 0xF0, 0x00, 0x3F, 0x3F, 0xFE, 0x7E, 0x00, 0x07, 0xE7,
  0xFF, 0xCF, 0xC0, 0x01, 0xF8, 0xFF, 0xF9, 0xFC, 0x00, 0x3F, 0x1F, 0xFF,
  0x1F, 0x80, 0x07, 0xE3, 0xFF, 0xE3, 0xF0, 0x01, 0xF8, 0x7F, 0xFC, 0x7E,
  0x00, 0x3F, 0x0F, 0xFF, 0x87, 0xE0, 0x07, 0xE1, 0xFF, 0xF0, 0xFC, 0x00,
  0xF8, 0x3F, 0xFE, 0x1F, 0x80, 0x3F, 0x07, 0xFF, 0xC1, 0xF8, 0x07, 0xE0,
  0xFF, 0xF8, 0x3F, 0x00, 0xF8, 0x1F, 0xFF, 0x07, 0xE0, 0x3F, 0x03, 0xFF,
  0xE0, 0xFE, 0x07, 0xE0, 0x7F, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xFF, 0x81,
  0xF8, 0x3F, 0x01, 0xFF, 0xF0, 0x3F, 0x07, 0xE0, 0x3F, 0xFE, 0x03, 0xF0,
  0xFC, 0x07, 0xFF, 0xC0, 0x7E, 0x3F, 0x00, 0xFF, 0xF8, 0x0F, 0xC7, 0xE0,
  0x1F, 0xFF, 0x00, 0xFC, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0x9F, 0x00, 0x7F,
  0xFC, 0x03, 0xF7, 0xE0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x01, 0xFF, 0xF0,
  0x07, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x1F,
  0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xE0,
  0x03, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xFF, 0x80, 0x0F, 0xE0, 0x01, 0xFF, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0x80, 0x07, 0xE0, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xBF, 0x80, 0x03, 0xFF, 0xCF, 0xE0, 0x01, 0xFF, 0xF7,
  0xF0, 0x00, 0xFF, 0xFB, 0xFC, 0x00, 0x7F, 0xFC, 0xFE, 0x00, 0x3F, 0xFE,
  0x7F, 0x00, 0x1F, 0xFF, 0x1F, 0xC0, 0x0F, 0xFF, 0x8F, 0xE0, 0x07, 0xFF,
  0xC3, 0xF8, 0x03, 0xFF, 0xE1, 0xFC, 0x01, 0xFF, 0xF0, 0x7F, 0x00, 0xFF,
  0xF8, 0x3F, 0x80, 0x7F, 0xFC, 0x0F, 0xE0, 0x3F, 0xFE, 0x07, 0xF0, 0x1F,
  0xFF, 0x01, 0xFC, 0x0F, 0xFF, 0x80, 0xFE, 0x07, 0xFF, 0xC0, 0x3F, 0x83,
  0xFF, 0xE0, 0x1F, 0xC1, 0xFF, 0xF0, 0x07, 0xF0, 0xFF, 0xF8, 0x03, 0xF8,
  0x7F, 0xFC, 0x00, 0xFE, 0x3F, 0xFE, 0x00, 0x7F, 0x1F, 0xFF, 0x00, 0x1F,
  0xCF, 0xFF, 0x80, 0x0F, 0xE7, 0xFF, 0xC0, 0x03, 0xFB, 0xFF, 0xE0, 0x01,
  0xFD, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFE, 0x03, 0xFF, 0x00,
  0xFF, 0x80, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x03,
  0xFC, 0x1F, 0xC0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x01, 0xFC, 0x3F, 0xC0,
  0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x00, 0xFE, 0x7F, 0x80, 0x00, 0x0F, 0xE7,
  0xF8, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x00,
  0x7F, 0x7F, 0x00, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x00, 0x7F, 0x7F, 0x00,
  0x00, 0x07, 0xF7, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x00, 0x7F, 0x7F, 0x00,
  0x00, 0x07, 0xF7, 0xF0, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x07, 0xF7,
  0xF0, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x00,
  0xFF, 0x7F, 0x80, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x00, 0xFE, 0x3F, 0x80,
  0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x3F, 0xC1,
  0xFE, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x0F,
  0xF8, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x17, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0x3F, 0x83, 0xFF,
  0xE7, 0xF0, 0x07, 0xFC, 0xFE, 0x00, 0x3F, 0xDF, 0xC0, 0x07, 0xFB, 0xF8,
  0x00, 0x7F, 0x7F, 0x00, 0x0F, 0xEF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0,
  0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xEF, 0xE0, 0x01, 0xFD,
  0xFC, 0x00, 0x7F, 0xBF, 0x80, 0x1F, 0xE7, 0xF0, 0x07, 0xFC, 0xFE, 0x1F,
  0xFF, 0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x0F,
  0xF0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x00, 0x3F,
  0xC3, 0xFC, 0x00, 0x01, 0xFC, 0x3F, 0xC0, 0x00, 0x1F, 0xE3, 0xF8, 0x00,
  0x00, 0xFE, 0x7F, 0x80, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x00, 0xFE, 0x7F,
  0x00, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x07,
  0xF7, 0xF0, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x07, 0xF7, 0xF0, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07,
  0xF7, 0xF0, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x07, 0xF7, 0xF0, 0x00,
  0x00, 0x7F, 0x7F, 0x00, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x00, 0x7F, 0x7F,
  0x00, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x0F,
  0xE3, 0xF8, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x1F, 0xE3, 0xFC, 0x00,
  0x01, 0xFE, 0x1F, 0xC0, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x03, 0xFC, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x0F, 0xF8, 0x07, 0xFC, 0x01, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8,
  0x3F, 0x80, 0x3F, 0xF0, 0xFE, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0xFF, 0x0F,
  0xE0, 0x01, 0xFE, 0x3F, 0x80, 0x07, 0xF8, 0xFE, 0x00, 0x0F, 0xE3, 0xF8,
  0x00, 0x3F, 0x8F, 0xE0, 0x00, 0xFE, 0x3F, 0x80, 0x03, 0xF8, 0xFE, 0x00,
  0x0F, 0xE3, 0xF8, 0x00, 0x7F, 0x8F, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x07,
  0xF0, 0xFE, 0x00, 0x3F, 0xC3, 0xF8, 0x01, 0xFE, 0x0F, 0xE0, 0x0F, 0xF8,
  0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xF8,
  0x1F, 0xC0, 0x0F, 0xE0, 0x7F, 0x80, 0x3F, 0x80, 0xFE, 0x00, 0xFE, 0x03,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xE0, 0x3F, 0x80, 0x3F,
  0x80, 0xFE, 0x00, 0xFF, 0x03, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xF8,
  0x3F, 0x80, 0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x7F, 0x0F,
  0xE0, 0x01, 0xFE, 0x3F, 0x80, 0x07, 0xF8, 0xFE, 0x00, 0x0F, 0xF3, 0xF8,
  0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x7F, 0xBF, 0x80, 0x01, 0xFE, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF9, 0xFF, 0x81, 0xFC,
  0xFF, 0x00, 0x1C, 0x7F, 0x00, 0x02, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00,
  0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x7F, 0xBE, 0x00, 0x7F, 0xDF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x00,
  0x7C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x3F, 0xBF, 0xC0,
  0x00, 0x7F, 0x3F, 0x80, 0x00, 0xFE, 0x7F, 0x80, 0x03, 0xFC, 0xFF, 0x80,
  0x0F, 0xF0, 0xFF, 0x80, 0x3F, 0xE1, 0xFF, 0xF7, 0xFF, 0x81, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x01, 0xFD, 0xFC, 0x00,
  0x00, 0x7F, 0x7F, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x0F, 0xE3, 0xF8,
  0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x7F, 0x0F,
  0xE0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x01, 0xF8,
  0x1F, 0xC0, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x0F,
  0xE0, 0x3F, 0x80, 0x07, 0xF0, 0x0F, 0xE0, 0x01, 0xFC, 0x01, 0xF8, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x0F,
  0xE0, 0x1F, 0xC0, 0x01, 0xF8, 0x07, 0xF0, 0x00, 0x7F, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x7E, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0xFC, 0x0F, 0xE0,
  0x00, 0x3F, 0x83, 0xF0, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x7F,
  0x00, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0x07, 0xF1,
  0xF8, 0x00, 0x00, 0xFC, 0xFE, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x0F,
  0xCF, 0xC0, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x9F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFE, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF9,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0x0F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xFF,
  0x00, 0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xC3, 0xF8, 0x00,
  0x7F, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x01, 0xFF, 0xE0, 0x03, 0xF8, 0x1F,
  0xC0, 0x07, 0xDF, 0x80, 0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0x7E, 0x00, 0x3F,
  0x81, 0xFC, 0x00, 0xFC, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x03, 0xF3, 0xF0,
  0x07, 0xF0, 0x0F, 0xC0, 0x0F, 0xCF, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F,
  0x3F, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0xF8, 0xFC, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xE3, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x1F, 0x87, 0xE0, 0x3F, 0x80,
  0x1F, 0xC0, 0x7E, 0x1F, 0x80, 0xFE, 0x00, 0x7F, 0x01, 0xF8, 0x7E, 0x03,
  0xF8, 0x01, 0xFC, 0x0F, 0xC1, 0xF8, 0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x00, 0x0F, 0xC0, 0xFC, 0x0F, 0xC1, 0xFC, 0x00, 0x3F, 0x83,
  0xF0, 0x3F, 0x07, 0xF0, 0x00, 0xFE, 0x0F, 0x80, 0xFC, 0x1F, 0xC0, 0x03,
  0xF8, 0x7E, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xE1, 0xF8, 0x07, 0xE1, 0xF8,
  0x00, 0x1F, 0x87, 0xE0, 0x1F, 0x8F, 0xE0, 0x00, 0x7F, 0x1F, 0x80, 0x7E,
  0x3F, 0x80, 0x01, 0xFC, 0xFC, 0x01, 0xF8, 0xFE, 0x00, 0x07, 0xF3, 0xF0,
  0x03, 0xE3, 0xF0, 0x00, 0x0F, 0xCF, 0xC0, 0x0F, 0xCF, 0xC0, 0x00, 0x3F,
  0x3F, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0xFD, 0xFC, 0x00,
  0x03, 0xFB, 0xE0, 0x01, 0xF7, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xDF,
  0x80, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00,
  0xFE, 0x3F, 0x80, 0x00, 0xFE, 0x3F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0, 0x01,
  0xFC, 0x1F, 0xE0, 0x03, 0xFC, 0x0F, 0xE0, 0x03, 0xF8, 0x0F, 0xE0, 0x07,
  0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x0F,
  0xE0, 0x03, 0xF8, 0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x1F,
  0xC0, 0x00, 0xFC, 0x3F, 0x80, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0xFE, 0x7F,
  0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0x7E,
  0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0xFE, 0x3F,
  0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x1F,
  0xC0, 0x03, 0xF8, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x07,
  0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x03,
  0xF8, 0x1F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x01,
  0xFE, 0x3F, 0x80, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00,
  0xFE, 0x7F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x03,
  0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x07,
  0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x0F,
  0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x1F, 0xC0, 0x03, 0xF8, 0x1F,
  0xC0, 0x03, 0xF8, 0x1F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F,
  0x80, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x7E,
  0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7D, 0xF8,
  0x00, 0x01, 0xF9, 0xF8, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x1F, 0x07, 0xE0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xC0,
  0x03, 0xF0, 0x0F, 0x80, 0x07, 0xE0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x01, 0xF8, 0x7E,
  0x00, 0x01, 0xF9, 0xFC, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0,
  0x07, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xF8, 0x3F, 0xE0, 0x70, 0x07,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFC, 0x7F, 0xF0, 0x7F, 0x3F, 0xC0, 0x1F, 0xDF, 0xE0,
  0x07, 0xF7, 0xF0, 0x01, 0xFD, 0xFC, 0x00, 0x7F, 0x7E, 0x00, 0x1F, 0xFF,
  0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0x7E, 0x00, 0x3F,
  0xDF, 0xC0, 0x1F, 0xF7, 0xF0, 0x0F, 0xFD, 0xFE, 0x07, 0xFF, 0x3F, 0xFF,
  0xEF, 0xCF, 0xFF, 0xF3, 0xF1, 0xFF, 0xFC, 0xFC, 0x3F, 0xFC, 0x3F, 0x07,
  0xFE, 0x07, 0xC0, 0x3C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0xFF, 0x80,
  0xFC, 0x7F, 0xF8, 0x1F, 0x9F, 0xFF, 0x83, 0xF7, 0xFF, 0xF8, 0x7E, 0xFF,
  0xFF, 0x8F, 0xFF, 0xBF, 0xF9, 0xFF, 0x80, 0xFF, 0x3F, 0xE0, 0x0F, 0xF7,
  0xF8, 0x00, 0xFE, 0xFF, 0x00, 0x1F, 0xDF, 0xC0, 0x03, 0xFB, 0xF8, 0x00,
  0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01,
  0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F,
  0xFF, 0xC0, 0x03, 0xFB, 0xF8, 0x00, 0x7F, 0x7F, 0x80, 0x0F, 0xEF, 0xF0,
  0x03, 0xFD, 0xFF, 0x00, 0xFF, 0x3F, 0xF8, 0x3F, 0xE7, 0xFF, 0xFF, 0xF8,
  0xFD, 0xFF, 0xFF, 0x1F, 0x9F, 0xFF, 0xC3, 0xE1, 0xFF, 0xF0, 0x7C, 0x1F,
  0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xFF, 0xBF, 0x07, 0xF8,
  0x06, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x01, 0x0F, 0xF8,
  0x1E, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x0F, 0xF0, 0x7F, 0x03, 0xFF, 0xC7, 0xF0, 0x7F, 0xFE, 0x7F, 0x0F, 0xFF,
  0xF7, 0xF1, 0xFF, 0xFF, 0x7F, 0x1F, 0xF9, 0xFF, 0xF3, 0xFC, 0x07, 0xFF,
  0x3F, 0x80, 0x3F, 0xF7, 0xF8, 0x01, 0xFF, 0x7F, 0x00, 0x0F, 0xF7, 0xF0,
  0x00, 0xFF, 0x7F, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0xFF, 0x7F, 0x00,
  0x0F, 0xF7, 0xF0, 0x01, 0xFF, 0x7F, 0x80, 0x1F, 0xF3, 0xFC, 0x03, 0xFF,
  0x3F, 0xE0, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xF7, 0xF0, 0xFF,
  0xFE, 0x3F, 0x07, 0xFF, 0xC3, 0xF0, 0x1F, 0xF8, 0x3F, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x3F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x07, 0xF8, 0x3F, 0xC3, 0xFC, 0x07, 0xF0,
  0xFE, 0x00, 0xFE, 0x3F, 0x00, 0x1F, 0x9F, 0xC0, 0x07, 0xF7, 0xF0, 0x01,
  0xFD, 0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x18, 0x7F, 0xC0, 0x3E, 0x0F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0xC0, 0x3F,
  0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x1F, 0xE0, 0x40,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0xF8, 0x3F,
  0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFF,
  0x03, 0xF0, 0x3F, 0xFC, 0x3F, 0x07, 0xFF, 0xE3, 0xF0, 0xFF, 0xFF, 0x7F,
  0x1F, 0xFF, 0xF7, 0xF1, 0xFF, 0xBF, 0xFF, 0x3F, 0xC0, 0x7F, 0xF3, 0xF8,
  0x03, 0xFF, 0x7F, 0x80, 0x1F, 0xF7, 0xF0, 0x00, 0xFF, 0x7F, 0x00, 0x0F,
  0xF7, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0xFF, 0x7F, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0xFF,
  0x7F, 0x00, 0x1F, 0xF7, 0xF8, 0x01, 0xFF, 0x3F, 0xC0, 0x3F, 0xF3, 0xFE,
  0x0F, 0xFF, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0x7F, 0x0F, 0xFF, 0xE7,
  0xF0, 0x7F, 0xFC, 0x7F, 0x01, 0xFF, 0x87, 0xF0, 0x03, 0x80, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE2,
  0x00, 0x01, 0xFC, 0x3C, 0x00, 0x7F, 0xC3, 0xFF, 0x7F, 0xF8, 0x3F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x7F, 0xC0, 0xFC, 0x7F, 0xFC, 0x3F,
  0x3F, 0xFF, 0x8F, 0xDF, 0xFF, 0xF3, 0xF7, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xBF, 0xF0, 0x1F, 0xEF, 0xF8, 0x03, 0xFB, 0xFC, 0x00, 0xFE, 0xFF, 0x00,
  0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F,
  0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00,
  0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0,
  0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF,
  0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01,
  0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0,
  0x01, 0xFF, 0xF0, 0x00, 0x7F, 0x18, 0x7E, 0x7E, 0xFF, 0xFF, 0xFF, 0x7F,
  0x7E, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x00, 0x60, 0x07, 0xE0,
  0x1F, 0x80, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xC0, 0x7E, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x3F, 0x80, 0xFE, 0x07, 0xFB, 0xFF, 0xEF, 0xFF, 0x3F, 0xFC,
  0xFF, 0xE3, 0xFF, 0x0F, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0xFC, 0x00,
  0x7F, 0xBF, 0x00, 0x1F, 0xCF, 0xC0, 0x0F, 0xE3, 0xF0, 0x07, 0xF8, 0xFC,
  0x01, 0xFC, 0x3F, 0x00, 0xFE, 0x0F, 0xC0, 0x7F, 0x03, 0xF0, 0x3F, 0xC0,
  0xFC, 0x0F, 0xE0, 0x3F, 0x07, 0xF0, 0x0F, 0xC3, 0xF8, 0x03, 0xF0, 0xFE,
  0x00, 0xFC, 0x7F, 0x00, 0x3F, 0x3F, 0x80, 0x0F, 0xCF, 0xE0, 0x03, 0xF7,
  0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0x00, 0xFF, 0x9F, 0xC0, 0x3F, 0xC3, 0xF8, 0x0F, 0xE0, 0xFE,
  0x03, 0xF0, 0x1F, 0xC0, 0xFC, 0x07, 0xF0, 0x3F, 0x00, 0xFE, 0x0F, 0xC0,
  0x3F, 0x83, 0xF0, 0x07, 0xF0, 0xFC, 0x01, 0xFC, 0x3F, 0x00, 0x3F, 0x8F,
  0xC0, 0x0F, 0xE3, 0xF0, 0x01, 0xFC, 0xFC, 0x00, 0x7F, 0xBF, 0x00, 0x0F,
  0xEF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F,
  0xF0, 0x07, 0xFC, 0x1F, 0x0F, 0xFF, 0x03, 0xFF, 0xC3, 0xE3, 0xFF, 0xF0,
  0xFF, 0xFE, 0x7E, 0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xBF, 0xF0, 0x3F, 0xFC, 0x0F, 0xF7,
  0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0xC0,
  0x07, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x1F,
  0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0x00,
  0x0F, 0xFF, 0x80, 0x0F, 0xE0, 0x01, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xE0,
  0x01, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xFF, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0x80, 0x07, 0xF0, 0x00,
  0xFF, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFF,
  0xC0, 0x03, 0xF8, 0x00, 0x7E, 0xF8, 0x1F, 0xF0, 0x3E, 0x1F, 0xFF, 0x0F,
  0x8F, 0xFF, 0xE3, 0xF7, 0xFF, 0xFC, 0xFD, 0xFF, 0xFF, 0x3F, 0xFE, 0xFF,
  0xEF, 0xFC, 0x07, 0xFB, 0xFE, 0x00, 0xFE, 0xFF, 0x00, 0x3F, 0xBF, 0xC0,
  0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F,
  0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00,
  0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC,
  0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F,
  0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00,
  0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0,
  0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF,
  0x80, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x01,
  0xFF, 0x9F, 0xF8, 0x3F, 0xC0, 0x3F, 0xC3, 0xF8, 0x01, 0xFC, 0x7F, 0x80,
  0x0F, 0xE7, 0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x7F,
  0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xF7, 0xF0, 0x00,
  0x7F, 0x7F, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xE3,
  0xF8, 0x01, 0xFC, 0x3F, 0xC0, 0x3F, 0xC1, 0xFF, 0x07, 0xF8, 0x0F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0xF8, 0x1F, 0xF0, 0x1F, 0x0F,
  0xFF, 0x03, 0xE3, 0xFF, 0xF8, 0x7E, 0xFF, 0xFF, 0x0F, 0xDF, 0xFF, 0xF1,
  0xFF, 0xE3, 0xFF, 0x3F, 0xF0, 0x1F, 0xE7, 0xFC, 0x01, 0xFE, 0xFF, 0x00,
  0x1F, 0xDF, 0xE0, 0x03, 0xFB, 0xF8, 0x00, 0x7F, 0x7F, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x03,
  0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8,
  0x00, 0x7F, 0x7F, 0x80, 0x0F, 0xEF, 0xF0, 0x01, 0xFD, 0xFF, 0x00, 0x7F,
  0xBF, 0xE0, 0x1F, 0xE7, 0xFF, 0x07, 0xFC, 0xFD, 0xFF, 0xFF, 0x1F, 0xBF,
  0xFF, 0xE3, 0xF3, 0xFF, 0xF8, 0x7E, 0x3F, 0xFE, 0x0F, 0xC1, 0xFF, 0x01,
  0xF8, 0x0F, 0x80, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x03, 0xF0, 0x3F, 0xFC,
  0x3F, 0x07, 0xFF, 0xE3, 0xF0, 0xFF, 0xFF, 0x7F, 0x1F, 0xFF, 0xF7, 0xF1,
  0xFF, 0x9F, 0xFF, 0x3F, 0xC0, 0x7F, 0xF3, 0xF8, 0x03, 0xFF, 0x7F, 0x80,
  0x1F, 0xF7, 0xF0, 0x00, 0xFF, 0x7F, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0xFF, 0x7F, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0xFF, 0x7F, 0x00, 0x1F, 0xF7,
  0xF8, 0x01, 0xFF, 0x3F, 0xC0, 0x3F, 0xF3, 0xFE, 0x0F, 0xFF, 0x1F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0x7F, 0x0F, 0xFF, 0xE7, 0xF0, 0x7F, 0xFC, 0x7F,
  0x01, 0xFF, 0x87, 0xF0, 0x03, 0x80, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0xF8, 0x1F, 0xFE, 0x0F, 0xFF, 0x87, 0xFF, 0xE3, 0xFF, 0xF9, 0xFF, 0xBF,
  0x7F, 0xEF, 0xFF, 0x9B, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x7F, 0xFF, 0x8F, 0xFF, 0xFE, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0x7F, 0xC1, 0xF3, 0xF8, 0x01, 0x9F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF8, 0x03,
  0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x1F, 0xFF, 0x01, 0xFE,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x03, 0xFF,
  0xF0, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F,
  0xFF, 0xC7, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF,
  0xFF, 0x83, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFC,
  0x00, 0x7F, 0xC3, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0xFF,
  0xF0, 0x0F, 0xFE, 0x00, 0x78, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F,
  0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F,
  0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF,
  0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00,
  0x7F, 0xBF, 0x80, 0x0F, 0xF7, 0xF0, 0x03, 0xFE, 0xFE, 0x00, 0x7F, 0xDF,
  0xE0, 0x1F, 0xF9, 0xFF, 0x0F, 0xFF, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFC,
  0xFC, 0x7F, 0xFF, 0x1F, 0x87, 0xFF, 0xC3, 0xF0, 0x3F, 0xF0, 0x7E, 0x00,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x1F, 0xDF, 0xC0,
  0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x7F, 0x1F, 0xC0, 0x03,
  0xF8, 0xFE, 0x00, 0x1F, 0x87, 0xF0, 0x01, 0xFC, 0x1F, 0x80, 0x0F, 0xE0,
  0xFE, 0x00, 0x7F, 0x07, 0xF0, 0x03, 0xF0, 0x3F, 0x80, 0x3F, 0x80, 0xFC,
  0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0xFE, 0x00, 0xFC, 0x07,
  0xF0, 0x07, 0xE0, 0x3F, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0xFC, 0x1F, 0xC0,
  0x07, 0xE0, 0xFE, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xFC, 0x3F, 0x00, 0x07,
  0xE3, 0xF8, 0x00, 0x3F, 0x1F, 0x80, 0x01, 0xF8, 0xFC, 0x00, 0x07, 0xE7,
  0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x0F, 0xDF, 0x80,
  0x00, 0x3E, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFF,
  0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xBF, 0x80, 0x0F, 0xF0, 0x00, 0xFD, 0xFC,
  0x00, 0x7F, 0xC0, 0x0F, 0xE7, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0x3F, 0x00,
  0x3F, 0xF0, 0x03, 0xF1, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0x8F, 0xE0, 0x0F,
  0xFE, 0x01, 0xFC, 0x3F, 0x00, 0x7F, 0xF0, 0x0F, 0xE1, 0xF8, 0x07, 0xEF,
  0x80, 0x7F, 0x0F, 0xE0, 0x3E, 0x7C, 0x03, 0xF0, 0x7F, 0x01, 0xF3, 0xE0,
  0x1F, 0x83, 0xF8, 0x0F, 0x9F, 0x81, 0xFC, 0x0F, 0xC0, 0xFC, 0xFC, 0x0F,
  0xE0, 0x7E, 0x07, 0xE3, 0xE0, 0x7E, 0x03, 0xF8, 0x3E, 0x1F, 0x03, 0xF0,
  0x1F, 0xC1, 0xF0, 0xFC, 0x3F, 0x80, 0x7E, 0x1F, 0x87, 0xE1, 0xFC, 0x03,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC0, 0x1F, 0xC7, 0xE0, 0xF8, 0x7E, 0x00, 0xFE,
  0x3E, 0x07, 0xC3, 0xF0, 0x03, 0xF1, 0xF0, 0x3F, 0x3F, 0x80, 0x1F, 0x9F,
  0x81, 0xF9, 0xF8, 0x00, 0xFC, 0xFC, 0x0F, 0xCF, 0xC0, 0x07, 0xE7, 0xE0,
  0x3E, 0x7E, 0x00, 0x1F, 0xBE, 0x01, 0xF3, 0xF0, 0x00, 0xFD, 0xF0, 0x0F,
  0xBF, 0x00, 0x07, 0xEF, 0x80, 0x7F, 0xF8, 0x00, 0x3F, 0x7C, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x0F, 0xE7, 0xF0, 0x01, 0xFE, 0x3F, 0x80, 0x1F, 0xC3, 0xF8, 0x03,
  0xFC, 0x1F, 0xC0, 0x3F, 0x81, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x00,
  0xFE, 0x07, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF9,
  0xFC, 0x00, 0x3F, 0x9F, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x03,
  0xFB, 0xF8, 0x00, 0x3F, 0x9F, 0xC0, 0x07, 0xF1, 0xFC, 0x00, 0x7F, 0x0F,
  0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x3F, 0x83, 0xF8, 0x01, 0xFC, 0x7F, 0x00,
  0x1F, 0xC7, 0xF0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x03,
  0xFB, 0xF8, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xE3,
  0xF0, 0x00, 0x7F, 0x1F, 0xC0, 0x03, 0xF8, 0xFE, 0x00, 0x1F, 0x87, 0xF0,
  0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0xFE, 0x00, 0x7F, 0x07, 0xF0, 0x03,
  0xF0, 0x1F, 0x80, 0x3F, 0x80, 0xFE, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xC0,
  0x1F, 0x80, 0xFE, 0x00, 0xFC, 0x07, 0xF0, 0x07, 0xF0, 0x3F, 0x00, 0x1F,
  0x81, 0xF8, 0x00, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x87,
  0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x3F, 0x9F, 0x80,
  0x00, 0xFC, 0xFC, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x3F, 0x7F, 0x00, 0x00,
  0xFB, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x7F,
  0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xE0,
  0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0x80, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF,
  0xE0, 0x0F, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xFF, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xF0,
  0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07,
  0xF0, 0x00, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x0F,
  0xF8, 0x00, 0xFE, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x11, 0xFF,
  0x80, 0x01, 0x3F, 0xFE, 0x00, 0x37, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0xC0,
  0x01, 0xFF, 0xC8, 0x00, 0x01, 0xE0,
};

const GFXglyph NotoSans_Condensed_Medium68pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 9, 50, 17, 4, -49 },
  { 58, 20, 18, 28, 4, -49 },
  { 103, 33, 49, 36, 1, -49 },
  { 306, 27, 56, 33, 3, -52 },
  { 495, 45, 50, 51, 3, -49 },
  { 777, 37, 50, 39, 2, -49 },
  { 1009, 7, 18, 15, 4, -49 },
  { 1025, 16, 60, 21, 3, -49 },
  { 1145, 15, 60, 21, 2, -49 },
  { 1258, 26, 26, 31, 2, -52 },
  { 1343, 28, 32, 33, 2, -40 },
  { 1455, 11, 17, 17, 2, -8 },
  { 1479, 16, 6, 20, 2, -21 },
  { 1491, 9, 10, 17, 4, -9 },
  { 1503, 24, 49, 26, 1, -49 },
  { 1650, 27, 50, 33, 3, -49 },
  { 1819, 18, 49, 33, 4, -49 },
  { 1930, 26, 49, 33, 3, -49 },
  { 2090, 26, 50, 33, 3, -49 },
  { 2253, 30, 49, 33, 1, -49 },
  { 2437, 26, 50, 33, 3, -49 },
  { 2600, 27, 50, 33, 3, -49 },
  { 2769, 28, 49, 33, 2, -49 },
  { 2941, 28, 50, 33, 2, -49 },
  { 3116, 27, 50, 33, 3, -49 },
  { 3285, 9, 38, 17, 4, -37 },
  { 3328, 11, 46, 17, 2, -37 },
  { 3392, 28, 32, 33, 2, -40 },
  { 3504, 28, 20, 33, 2, -34 },
  { 3574, 28, 32, 33, 2, -40 },
  { 3686, 23, 50, 25, 1, -49 },
  { 3830, 44, 55, 50, 3, -49 },
  { 4133, 36, 49, 36, 0, -49 },
  { 4354, 29, 49, 37, 5, -49 },
  { 4532, 30, 50, 35, 3, -49 },
  { 4720, 32, 49, 40, 5, -49 },
  { 4916, 23, 49, 31, 5, -49 },
  { 5057, 23, 49, 30, 5, -49 },
  { 5198, 33, 50, 41, 4, -49 },
  { 5405, 31, 49, 41, 5, -49 },
  { 5595, 17, 49, 21, 2, -49 },
  { 5700, 16, 62, 17, -4, -49 },
  { 5824, 30, 49, 35, 5, -49 },
  { 6008, 23, 49, 29, 5, -49 },
  { 6149, 43, 49, 54, 5, -49 },
  { 6413, 33, 49, 44, 5, -49 },
  { 6616, 36, 50, 43, 3, -49 },
  { 6841, 27, 49, 34, 5, -49 },
  { 7007, 36, 61, 43, 3, -49 },
  { 7282, 30, 49, 36, 5, -49 },
  { 7466, 25, 50, 31, 3, -49 },
  { 7623, 28, 49, 30, 1, -49 },
  { 7795, 31, 50, 41, 5, -49 },
  { 7989, 34, 49, 34, 0, -49 },
  { 8198, 54, 49, 54, 0, -49 },
  { 8529, 32, 49, 33, 0, -49 },
  { 8725, 32, 49, 32, 0, -49 },
  { 8921, 26, 49, 30, 2, -49 },
  { 9081, 15, 60, 22, 5, -49 },
  { 9194, 24, 49, 26, 1, -49 },
  { 9341, 15, 60, 22, 2, -49 },
  { 9454, 31, 29, 34, 1, -49 },
  { 9567, 29, 4, 29, 0, 6 },
  { 9582, 14, 11, 20, 3, -52 },
  { 9602, 26, 38, 32, 2, -37 },
  { 9726, 27, 53, 35, 5, -52 },
  { 9905, 23, 38, 27, 3, -37 },
  { 10015, 28, 53, 35, 3, -52 },
  { 10201, 26, 38, 32, 3, -37 },
  { 10325, 21, 52, 20, 1, -52 },
  { 10462, 28, 53, 35, 3, -37 },
  { 10648, 26, 52, 35, 5, -52 },
  { 10817, 8, 51, 16, 4, -51 },
  { 10868, 14, 67, 16, -2, -51 },
  { 10986, 26, 52, 32, 5, -52 },
  { 11155, 6, 52, 16, 5, -52 },
  { 11194, 43, 37, 53, 5, -37 },
  { 11393, 26, 37, 35, 5, -37 },
  { 11514, 28, 38, 34, 3, -37 },
  { 11647, 27, 53, 35, 5, -37 },
  { 11826, 28, 53, 35, 3, -37 },
  { 12012, 18, 37, 24, 5, -37 },
  { 12096, 21, 38, 27, 3, -37 },
  { 12196, 19, 46, 21, 1, -45 },
  { 12306, 27, 38, 35, 4, -37 },
  { 12435, 29, 37, 29, 0, -37 },
  { 12570, 45, 37, 46, 1, -37 },
  { 12779, 28, 37, 30, 1, -37 },
  { 12909, 29, 53, 29, 0, -37 },
  { 13102, 21, 37, 25, 2, -37 },
  { 13200, 20, 60, 25, 2, -49 },
  { 13350, 5, 68, 31, 13, -52 },
  { 13393, 20, 60, 25, 3, -49 },
  { 13543, 28, 10, 33, 2, -29 },
};

const GFXfont NotoSans_Condensed_Medium68pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Medium68pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Medium68pt7bGlyphs,
  0x20, 0x7E, 93
};

#endif // _NOTOSANS_CONDENSED_MEDIUM68PT7B_H_
