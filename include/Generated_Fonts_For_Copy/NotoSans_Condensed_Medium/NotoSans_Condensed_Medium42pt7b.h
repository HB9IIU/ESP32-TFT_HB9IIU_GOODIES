#ifndef _NOTOSANS_CONDENSED_MEDIUM42PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUM42PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Medium.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Medium42pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF3,
  0x9C, 0xE7, 0x00, 0x00, 0x07, 0xBF, 0xFF, 0xF8, 0xF8, 0xFF, 0xC7, 0xDE,
  0x3E, 0xF1, 0xE7, 0x8F, 0x3C, 0x39, 0xE1, 0xCE, 0x0E, 0x70, 0x73, 0x83,
  0x9C, 0x1C, 0x01, 0xC3, 0x80, 0x1C, 0x38, 0x01, 0xC3, 0x80, 0x3C, 0x38,
  0x03, 0x83, 0x80, 0x38, 0x38, 0x03, 0x87, 0x80, 0x38, 0x70, 0x7F, 0xFF,
  0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x07, 0x07, 0x00, 0x70,
  0xF0, 0x07, 0x0E, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0xF0, 0xE0, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0xE1, 0xC0, 0x0E, 0x1C, 0x00,
  0xE1, 0xC0, 0x1E, 0x1C, 0x01, 0xC1, 0xC0, 0x1C, 0x3C, 0x01, 0xC3, 0x80,
  0x1C, 0x38, 0x01, 0xC3, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x0F, 0xFC, 0x3F, 0xFF, 0x7F, 0xFE, 0x7D, 0x8E, 0xF1, 0x80, 0xF1,
  0x80, 0xF1, 0x80, 0xF1, 0x80, 0xF1, 0x80, 0xFD, 0x80, 0x7F, 0x80, 0x3F,
  0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x01, 0xBF, 0x01, 0x9F, 0x01,
  0x8F, 0x01, 0x8F, 0x01, 0x8F, 0x01, 0x8F, 0xC1, 0x9F, 0xFF, 0xFE, 0xFF,
  0xFC, 0xFF, 0xF8, 0x1F, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x3F, 0x00, 0x3C, 0x07, 0xF8, 0x03, 0x80, 0x7F, 0xC0, 0x70, 0x0F,
  0x1C, 0x07, 0x00, 0xE1, 0xC0, 0xF0, 0x0E, 0x1E, 0x0E, 0x00, 0xE1, 0xE1,
  0xE0, 0x0E, 0x1E, 0x1C, 0x00, 0xE1, 0xE1, 0xC0, 0x0E, 0x1E, 0x3C, 0x00,
  0xE1, 0xE3, 0x80, 0x0E, 0x1E, 0x78, 0x00, 0xE1, 0xE7, 0x1F, 0x8E, 0x1C,
  0xF3, 0xFC, 0xF1, 0xCE, 0x3F, 0xC7, 0xFC, 0xE7, 0x9E, 0x7F, 0x9E, 0x70,
  0xE3, 0xF1, 0xC7, 0x0E, 0x00, 0x3C, 0xF0, 0xE0, 0x03, 0x8F, 0x0F, 0x00,
  0x38, 0xF0, 0xF0, 0x07, 0x8F, 0x0F, 0x00, 0x70, 0xF0, 0xF0, 0x0F, 0x07,
  0x0E, 0x00, 0xE0, 0x70, 0xE0, 0x1E, 0x07, 0x0E, 0x01, 0xC0, 0x79, 0xE0,
  0x1C, 0x03, 0xFC, 0x03, 0xC0, 0x3F, 0xC0, 0x38, 0x01, 0xF8, 0x03, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0xF8, 0xF0, 0x01, 0xE1, 0xE0,
  0x03, 0xC3, 0xC0, 0x07, 0x87, 0x80, 0x0F, 0x0F, 0x00, 0x1E, 0x1E, 0x00,
  0x3C, 0x3C, 0x00, 0x3C, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF8, 0x3E, 0x3E, 0xF8, 0x7C, 0x78,
  0xF0, 0xF1, 0xF1, 0xF1, 0xE3, 0xC1, 0xF7, 0xC7, 0x81, 0xFF, 0x1F, 0x01,
  0xFE, 0x3E, 0x03, 0xF8, 0x7C, 0x03, 0xF0, 0x78, 0x07, 0xE0, 0xF8, 0x1F,
  0xC1, 0xFC, 0xFF, 0xC1, 0xFF, 0xF7, 0xC1, 0xFF, 0xC7, 0xC1, 0xFF, 0x07,
  0xC0, 0xFF, 0xDE, 0xF7, 0xBD, 0xEE, 0x73, 0x9C, 0x07, 0xC1, 0xE0, 0xF0,
  0x38, 0x1E, 0x07, 0x03, 0xC0, 0xF0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF8, 0x1E, 0x07, 0x81, 0xE0, 0x3C, 0x0F, 0x03, 0xC0, 0x78,
  0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0xF0,
  0x1E, 0x07, 0x80, 0xF0, 0x3C, 0x0F, 0x01, 0xE0, 0x78, 0x1E, 0x07, 0x81,
  0xE0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x78,
  0x1E, 0x07, 0x81, 0xE0, 0x78, 0x3C, 0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x3C,
  0x0F, 0x07, 0x81, 0xE0, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x03, 0x8E, 0x39, 0xFF, 0xFC, 0xFF, 0xFE, 0xFF,
  0xFE, 0x81, 0xF0, 0x01, 0xFC, 0x01, 0xEF, 0x01, 0xE7, 0xC0, 0xF1, 0xE0,
  0xF0, 0xF8, 0x08, 0x20, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x7D, 0xF7, 0x9E, 0x79, 0xEF, 0x3C, 0xE3, 0x8E, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x00, 0x00, 0x1E, 0x00, 0x78, 0x00,
  0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0xF0, 0x1F, 0xF8, 0x3F, 0xFC, 0x3E, 0x7C,
  0x7C, 0x3E, 0x78, 0x1E, 0x78, 0x1E, 0xF8, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF8, 0x1F, 0x78, 0x1E, 0x78, 0x1E, 0x7C, 0x3E, 0x3E, 0x7C, 0x3F, 0xFC,
  0x1F, 0xF8, 0x0F, 0xF0, 0x01, 0xE0, 0x7C, 0x1F, 0x87, 0xF3, 0xFE, 0xFB,
  0xFE, 0x7F, 0x8F, 0x61, 0xE4, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x1F, 0xF0,
  0x7F, 0xF8, 0xFF, 0xFC, 0xFC, 0xFE, 0x60, 0x3E, 0x40, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C,
  0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xF0,
  0x7F, 0xF8, 0xFF, 0xFC, 0xF8, 0x7E, 0x60, 0x3E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x01, 0xF8,
  0x1F, 0xF0, 0x1F, 0xE0, 0x1F, 0xF8, 0x01, 0xFC, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F,
  0x80, 0x3E, 0xF0, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0x7F, 0xE0, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x1D, 0xE0, 0x07, 0x78, 0x03, 0x9E, 0x00, 0xE7, 0x80, 0x71, 0xE0, 0x3C,
  0x78, 0x0E, 0x1E, 0x07, 0x87, 0x81, 0xC1, 0xE0, 0xF0, 0x78, 0x38, 0x1E,
  0x1E, 0x07, 0x87, 0x01, 0xE3, 0xC0, 0x78, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC,
  0x7F, 0xFC, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x7B, 0x80, 0x7F, 0xF0, 0x7F, 0xFC, 0x7F, 0xFE,
  0x20, 0x7E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x3E, 0xF8, 0xFE,
  0xFF, 0xFC, 0xFF, 0xF8, 0x7F, 0xE0, 0x01, 0xFE, 0x07, 0xFE, 0x0F, 0xFE,
  0x1F, 0x82, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF1, 0xF0, 0xF7, 0xFC, 0xFF, 0xFE, 0xFF, 0x7E,
  0xFC, 0x1F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x7C, 0x1F, 0x3E, 0x7E,
  0x3F, 0xFC, 0x1F, 0xFC, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0xF0, 0x1F, 0xFE, 0x0F, 0xFF, 0x8F, 0x87, 0xC7, 0x81,
  0xF7, 0xC0, 0x7B, 0xC0, 0x3D, 0xE0, 0x1E, 0xF8, 0x0F, 0x3C, 0x0F, 0x1F,
  0x0F, 0x87, 0xCF, 0x81, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0x80, 0x3F, 0xF0,
  0x3E, 0xFC, 0x3E, 0x1F, 0x3E, 0x07, 0xDE, 0x01, 0xEF, 0x00, 0xF7, 0x80,
  0x7F, 0xC0, 0x3F, 0xE0, 0x1E, 0xF0, 0x0F, 0x7C, 0x0F, 0xBF, 0x0F, 0xCF,
  0xFF, 0xC3, 0xFF, 0xC0, 0x7F, 0x80, 0x0F, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC,
  0x7E, 0x7C, 0xF8, 0x3E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF8, 0x3F,
  0x7E, 0xFF, 0x7F, 0xFF, 0x3F, 0xEF, 0x0F, 0x8F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x41, 0xF8,
  0x7F, 0xF0, 0x7F, 0xE0, 0x7F, 0x80, 0x77, 0xFF, 0xFF, 0xB8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3D, 0xFF, 0xFF, 0xC0, 0x1C, 0x7C, 0xF9,
  0xF3, 0xE3, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xF9, 0xF3, 0xC7, 0x8F, 0x3E, 0x78, 0xF1, 0xC3, 0x8F, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x70, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00,
  0x1F, 0xC0, 0x01, 0xF0, 0x00, 0x1C, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00,
  0x38, 0x00, 0x0F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0x3E, 0x00, 0x0E, 0x00, 0x02, 0x00, 0x00, 0x1F, 0xE1, 0xFF, 0xF1, 0xFF,
  0xE3, 0xE7, 0xE2, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x3C,
  0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x01,
  0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x0F,
  0xFF, 0xF0, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x00, 0xF0, 0x3C, 0x00, 0x0F,
  0x07, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x1E, 0x38, 0x1F, 0xE1, 0xCF, 0x07,
  0xFE, 0x39, 0xC1, 0xFF, 0xC7, 0xB8, 0x78, 0x70, 0x77, 0x0F, 0x0E, 0x0F,
  0xE1, 0xC1, 0xC1, 0xFC, 0x78, 0x38, 0x3F, 0x0F, 0x07, 0x07, 0xE1, 0xE0,
  0xE0, 0xFC, 0x3C, 0x1C, 0x1F, 0x87, 0x83, 0x83, 0xF0, 0xF0, 0xF0, 0xFE,
  0x1E, 0x1E, 0x1D, 0xE1, 0xC3, 0xE3, 0xBC, 0x3F, 0xFF, 0xE3, 0x83, 0xF9,
  0xFC, 0x70, 0x3E, 0x1F, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x30, 0x03, 0xFC, 0x7E,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x1E, 0xE0, 0x00, 0xF3, 0xC0, 0x03, 0xCF, 0x00,
  0x0F, 0x3C, 0x00, 0x7C, 0xF8, 0x01, 0xE1, 0xE0, 0x07, 0x87, 0x80, 0x1E,
  0x1E, 0x00, 0xF8, 0x3C, 0x03, 0xC0, 0xF0, 0x0F, 0x03, 0xC0, 0x3F, 0xFF,
  0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xF8, 0x07, 0xC3,
  0xE0, 0x0F, 0x0F, 0x00, 0x3C, 0x3C, 0x00, 0xF9, 0xF0, 0x03, 0xE7, 0xC0,
  0x07, 0x9E, 0x00, 0x1E, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xF0, 0xFF, 0xF0,
  0x3F, 0xFF, 0x0F, 0xFF, 0xF3, 0xFF, 0xFC, 0xF8, 0x1F, 0xBE, 0x03, 0xEF,
  0x80, 0x7B, 0xE0, 0x1E, 0xF8, 0x07, 0xBE, 0x01, 0xEF, 0x80, 0xFB, 0xE0,
  0x3C, 0xF8, 0x7E, 0x3F, 0xFF, 0x0F, 0xFF, 0x83, 0xFF, 0xF8, 0xF8, 0x3F,
  0x3E, 0x03, 0xEF, 0x80, 0x7B, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xBE, 0x03, 0xEF, 0xFF, 0xFB, 0xFF,
  0xFC, 0xFF, 0xFE, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0x81, 0xFF, 0xF0, 0xFF,
  0xFC, 0x7F, 0x1E, 0x1F, 0x00, 0x8F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0xC0, 0x11, 0xFE, 0x78, 0x3F, 0xFE, 0x07, 0xFF, 0x80,
  0x7F, 0xE0, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0,
  0xF8, 0x1F, 0x8F, 0x80, 0xFC, 0xF8, 0x07, 0xCF, 0x80, 0x3E, 0xF8, 0x03,
  0xEF, 0x80, 0x1E, 0xF8, 0x01, 0xEF, 0x80, 0x1E, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xEF, 0x80, 0x1E, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xCF,
  0x80, 0x7C, 0xF8, 0x0F, 0xCF, 0x81, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0,
  0xFF, 0xFC, 0x0F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xFF,
  0xBF, 0xFE, 0xFF, 0xFB, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x1F, 0xFF, 0xC1, 0xFF, 0xFC, 0x1F,
  0xE7, 0xE1, 0xF8, 0x02, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0x7F, 0xFE, 0x00, 0x1E, 0xF0, 0x00, 0xF7, 0x80, 0x07, 0xBE, 0x00,
  0x3D, 0xF0, 0x01, 0xE7, 0xC0, 0x0F, 0x3E, 0x00, 0x78, 0xF8, 0x03, 0xC7,
  0xF8, 0x7E, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x80, 0xFF, 0xF0, 0xF8, 0x01,
  0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03,
  0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F,
  0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F,
  0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xC0, 0xFF, 0xFF,
  0xFD, 0xFF, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x3F,
  0xEF, 0xFF, 0xFF, 0xC0, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x87, 0xFF, 0xFF, 0xEF, 0xE7, 0xE0, 0xF8,
  0x03, 0xFF, 0x00, 0xFB, 0xE0, 0x3E, 0x7C, 0x07, 0x8F, 0x81, 0xF1, 0xF0,
  0x7C, 0x3E, 0x0F, 0x07, 0xC3, 0xE0, 0xF8, 0xF8, 0x1F, 0x1E, 0x03, 0xE7,
  0xC0, 0x7D, 0xF0, 0x0F, 0xBC, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x07, 0xFF,
  0x00, 0xFF, 0xF0, 0x1F, 0xBE, 0x03, 0xE3, 0xE0, 0x7C, 0x7C, 0x0F, 0x87,
  0xC1, 0xF0, 0x78, 0x3E, 0x0F, 0x87, 0xC0, 0xF0, 0xF8, 0x1F, 0x1F, 0x01,
  0xE3, 0xE0, 0x3E, 0x7C, 0x03, 0xEF, 0x80, 0x7D, 0xF0, 0x07, 0xC0, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F,
  0xFD, 0xC0, 0x07, 0xFF, 0xBC, 0x00, 0xEF, 0xF7, 0x80, 0x3D, 0xFE, 0xF0,
  0x07, 0xBF, 0xCF, 0x00, 0xE7, 0xF9, 0xE0, 0x3C, 0xFF, 0x3C, 0x07, 0x9F,
  0xE3, 0x80, 0xE3, 0xFC, 0x78, 0x3C, 0x7F, 0x8F, 0x07, 0x8F, 0xF0, 0xE0,
  0xE1, 0xFE, 0x1E, 0x3C, 0x3F, 0xC3, 0xC7, 0x87, 0xF8, 0x78, 0xE0, 0xFF,
  0x07, 0x9C, 0x1F, 0xE0, 0xF7, 0x83, 0xFC, 0x1E, 0xF0, 0x7F, 0x81, 0xDC,
  0x0F, 0xF0, 0x3F, 0x81, 0xFE, 0x07, 0xF0, 0x3F, 0xC0, 0x7C, 0x07, 0xF8,
  0x0F, 0x80, 0xFF, 0x01, 0xF0, 0x1F, 0xE0, 0x3C, 0x03, 0xC0, 0xFC, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0x80, 0x3F, 0xFE, 0x01, 0xFE, 0xF0, 0x0F, 0xF7, 0xC0, 0x7F, 0x9E, 0x03,
  0xFC, 0xF8, 0x1F, 0xE3, 0xC0, 0xFF, 0x1F, 0x07, 0xF8, 0x78, 0x3F, 0xC3,
  0xE1, 0xFE, 0x0F, 0x0F, 0xF0, 0x7C, 0x7F, 0x81, 0xE3, 0xFC, 0x0F, 0x1F,
  0xE0, 0x3C, 0xFF, 0x01, 0xE7, 0xF8, 0x07, 0xBF, 0xC0, 0x3D, 0xFE, 0x01,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0xFC, 0x01, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0xFF,
  0xFC, 0x07, 0xFB, 0xF8, 0x3F, 0x01, 0xF0, 0xF8, 0x03, 0xC7, 0xC0, 0x0F,
  0x9F, 0x00, 0x1E, 0x78, 0x00, 0x7D, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x1F,
  0x78, 0x00, 0x7D, 0xE0, 0x01, 0xF7, 0xC0, 0x07, 0x9F, 0x00, 0x3E, 0x3E,
  0x00, 0xF8, 0xFC, 0x07, 0xC1, 0xFE, 0xFE, 0x03, 0xFF, 0xF0, 0x07, 0xFF,
  0x80, 0x07, 0xFC, 0x00, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0xFF, 0x1F, 0xFF,
  0xCF, 0x83, 0xF7, 0xC0, 0xFB, 0xE0, 0x3D, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC,
  0x07, 0xFE, 0x03, 0xFF, 0x01, 0xEF, 0x80, 0xF7, 0xC0, 0xFB, 0xE1, 0xF9,
  0xFF, 0xFC, 0xFF, 0xFC, 0x7F, 0xF8, 0x3F, 0xE0, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0xFF, 0xFE, 0x07, 0xFB, 0xF8, 0x3F, 0x01, 0xF0, 0xF8, 0x03,
  0xE7, 0xC0, 0x0F, 0x9F, 0x00, 0x1E, 0x78, 0x00, 0x7D, 0xE0, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x1F, 0x78, 0x00, 0x7D, 0xE0, 0x01, 0xF7, 0xC0, 0x07, 0x9F,
  0x00, 0x3E, 0x3E, 0x00, 0xF8, 0xFC, 0x07, 0xC1, 0xFE, 0xFE, 0x03, 0xFF,
  0xF8, 0x07, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0xFF, 0xE0, 0x1F, 0xFF, 0x03, 0xFF, 0xF8, 0x7F, 0xFF, 0x0F,
  0x83, 0xF1, 0xF0, 0x3E, 0x3E, 0x03, 0xE7, 0xC0, 0x7C, 0xF8, 0x0F, 0x9F,
  0x01, 0xF3, 0xE0, 0x3E, 0x7C, 0x07, 0x8F, 0x81, 0xF1, 0xF0, 0x7C, 0x3F,
  0xFF, 0x87, 0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xE3, 0xE0, 0x7C,
  0x3C, 0x0F, 0x87, 0xC1, 0xF0, 0x78, 0x3E, 0x0F, 0x87, 0xC0, 0xF0, 0xF8,
  0x1F, 0x1F, 0x01, 0xE3, 0xE0, 0x3E, 0x7C, 0x03, 0xCF, 0x80, 0x7D, 0xF0,
  0x0F, 0xC0, 0x0F, 0xF8, 0x1F, 0xFE, 0x3F, 0xFE, 0x7F, 0xFC, 0xF8, 0x04,
  0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFC,
  0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0xC0, 0x3E, 0xFD, 0xFC, 0xFF, 0xFC, 0xFF, 0xF8,
  0x7F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0x78, 0x03, 0xCF, 0x80, 0xF9,
  0xFE, 0x7F, 0x1F, 0xFF, 0xC1, 0xFF, 0xF0, 0x0F, 0xF8, 0x00, 0xF0, 0x00,
  0x7F, 0xC0, 0x03, 0xDE, 0x00, 0x3E, 0xF0, 0x01, 0xE7, 0x80, 0x0F, 0x1E,
  0x00, 0xF8, 0xF0, 0x07, 0xC7, 0x80, 0x3C, 0x3E, 0x01, 0xE0, 0xF0, 0x1F,
  0x07, 0x80, 0xF0, 0x3C, 0x07, 0x81, 0xF0, 0x3C, 0x07, 0x83, 0xE0, 0x3C,
  0x1E, 0x01, 0xE0, 0xF0, 0x07, 0x87, 0x80, 0x3C, 0x78, 0x01, 0xE3, 0xC0,
  0x0F, 0x1E, 0x00, 0x3C, 0xF0, 0x01, 0xEF, 0x00, 0x0F, 0x78, 0x00, 0x7B,
  0xC0, 0x01, 0xDE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xFC, 0x01, 0xF0,
  0x07, 0xDE, 0x00, 0xF8, 0x03, 0xEF, 0x00, 0x7C, 0x01, 0xE7, 0x80, 0x3F,
  0x00, 0xF3, 0xE0, 0x3F, 0x80, 0x78, 0xF0, 0x1D, 0xC0, 0x7C, 0x78, 0x0E,
  0xE0, 0x3E, 0x3C, 0x07, 0x78, 0x1E, 0x1E, 0x07, 0xBC, 0x0F, 0x0F, 0x83,
  0xDE, 0x07, 0x83, 0xC1, 0xE7, 0x07, 0xC1, 0xE0, 0xE3, 0x83, 0xC0, 0xF0,
  0x71, 0xE1, 0xE0, 0x78, 0x78, 0xF0, 0xF0, 0x1E, 0x3C, 0x78, 0x78, 0x0F,
  0x1E, 0x1C, 0x7C, 0x07, 0x8E, 0x0F, 0x3C, 0x03, 0xCF, 0x07, 0x9E, 0x01,
  0xE7, 0x83, 0xCF, 0x00, 0x7B, 0xC0, 0xE7, 0x80, 0x3D, 0xC0, 0x77, 0x80,
  0x1E, 0xE0, 0x3B, 0xC0, 0x0F, 0x70, 0x1F, 0xE0, 0x03, 0xF8, 0x0F, 0xF0,
  0x01, 0xFC, 0x03, 0xF8, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x01, 0xE3,
  0xC0, 0x3E, 0x3E, 0x03, 0xC1, 0xE0, 0x7C, 0x1E, 0x07, 0x81, 0xF0, 0xF8,
  0x0F, 0x0F, 0x00, 0xF8, 0xF0, 0x07, 0x9E, 0x00, 0x7D, 0xE0, 0x03, 0xFE,
  0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7D, 0xE0, 0x07,
  0x9E, 0x00, 0xF8, 0xF0, 0x0F, 0x0F, 0x01, 0xF0, 0xF8, 0x1E, 0x07, 0x83,
  0xE0, 0x7C, 0x3C, 0x03, 0xC7, 0xC0, 0x3E, 0x78, 0x01, 0xEF, 0x80, 0x1F,
  0xF8, 0x01, 0xF7, 0x80, 0x3E, 0x78, 0x03, 0xE7, 0xC0, 0x3C, 0x3C, 0x07,
  0xC3, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0xF0, 0x0F, 0x0F, 0x00, 0xF1,
  0xF0, 0x0F, 0x9E, 0x00, 0x79, 0xE0, 0x07, 0xBC, 0x00, 0x3F, 0xC0, 0x03,
  0xFC, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00,
  0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07,
  0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E,
  0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0xF0, 0x01, 0xE0,
  0x01, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xE0, 0x01,
  0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E,
  0x00, 0x1C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x01, 0xE0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x80,
  0x07, 0x70, 0x01, 0xEF, 0x00, 0x38, 0xE0, 0x0F, 0x1E, 0x01, 0xC3, 0xC0,
  0x78, 0x3C, 0x0E, 0x07, 0x83, 0xC0, 0x78, 0x70, 0x0F, 0x1E, 0x00, 0xF3,
  0xC0, 0x1E, 0xF0, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x78,
  0x7C, 0x3E, 0x1E, 0x0F, 0x03, 0x0F, 0xF0, 0xFF, 0xF0, 0xFF, 0xF1, 0xE3,
  0xE2, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x07, 0xFC,
  0x7F, 0xFB, 0xFF, 0xF7, 0xC1, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x7F, 0xC0, 0xFF, 0xC3, 0xFF, 0xFF, 0xEF, 0xF9, 0xCF, 0xE3,
  0x80, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0xF8, 0x3D, 0xFF,
  0x1E, 0xFF, 0xCF, 0xFF, 0xE7, 0xE0, 0xFB, 0xE0, 0x3D, 0xF0, 0x1E, 0xF0,
  0x0F, 0xF8, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xBE, 0x03, 0xDF, 0x03,
  0xEF, 0xE3, 0xE7, 0xFF, 0xF3, 0x9F, 0xF1, 0xC7, 0xF0, 0x07, 0xF0, 0x3F,
  0xF1, 0xFF, 0x8F, 0xFE, 0x7C, 0x09, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x1F, 0x86, 0x3F, 0xF8, 0x7F, 0xE0,
  0xFF, 0x80, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x87, 0xE3, 0xC7,
  0xF9, 0xE7, 0xFE, 0xF7, 0xFF, 0xFB, 0xE0, 0xFD, 0xE0, 0x3F, 0xF0, 0x1F,
  0xF0, 0x0F, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xFC, 0x07, 0xDE, 0x03, 0xEF,
  0x83, 0xF7, 0xE3, 0xF9, 0xFF, 0xFC, 0x7F, 0xDE, 0x1F, 0xCF, 0x07, 0xE0,
  0x1F, 0xF8, 0x3F, 0xFC, 0x3E, 0x3E, 0x7C, 0x1E, 0x78, 0x1E, 0xF8, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x01,
  0x3E, 0x06, 0x3F, 0xFE, 0x1F, 0xFE, 0x07, 0xFC, 0x01, 0xFC, 0x1F, 0xE0,
  0xFF, 0x83, 0xF6, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7F, 0xC7, 0xFF, 0x3F, 0xFC, 0xFF, 0xF0, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x0F, 0xC7, 0x8F, 0xF3, 0xCF, 0xFD, 0xEF, 0xFF,
  0xF7, 0xC1, 0xFB, 0xC0, 0x7F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF8, 0x0F, 0xFC, 0x07, 0xDF, 0x07, 0xEF, 0xC7, 0xF3, 0xFF,
  0x78, 0xFF, 0xBC, 0x3F, 0x9E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x03, 0xE0, 0x01, 0xE4, 0x01, 0xF3, 0xF7, 0xF1, 0xFF, 0xF8, 0xFF, 0xF8,
  0x1F, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF1, 0xF0, 0xF7,
  0xFC, 0xFF, 0xFE, 0xFF, 0xFE, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0x60, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0x0F, 0x0F, 0x0F, 0x06, 0x00, 0x00, 0x00, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x1F,
  0xFF, 0xFE, 0xFE, 0xF8, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x1F,
  0xF0, 0x1E, 0xF0, 0x3C, 0xF0, 0x7C, 0xF0, 0xF8, 0xF0, 0xF0, 0xF1, 0xE0,
  0xF3, 0xE0, 0xF3, 0xC0, 0xF7, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xE0,
  0xF9, 0xE0, 0xF9, 0xF0, 0xF0, 0xF0, 0xF0, 0xF8, 0xF0, 0x78, 0xF0, 0x7C,
  0xF0, 0x3E, 0xF0, 0x3E, 0xF0, 0x1F, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE1, 0xF0, 0x3F, 0x1C, 0xFF, 0x9F, 0xF3, 0xFF, 0xF3, 0xFF, 0x7F, 0xFF,
  0xFF, 0xEF, 0xC3, 0xF8, 0x3D, 0xF0, 0x3E, 0x07, 0xFE, 0x07, 0xC0, 0xFF,
  0x80, 0xF8, 0x0F, 0xF0, 0x1F, 0x01, 0xFE, 0x03, 0xC0, 0x3F, 0xC0, 0x78,
  0x07, 0xF8, 0x0F, 0x00, 0xFF, 0x01, 0xE0, 0x1F, 0xE0, 0x3C, 0x03, 0xFC,
  0x07, 0x80, 0x7F, 0x80, 0xF0, 0x0F, 0xF0, 0x1E, 0x01, 0xFE, 0x03, 0xC0,
  0x3F, 0xC0, 0x78, 0x07, 0xF8, 0x0F, 0x00, 0xFF, 0x01, 0xE0, 0x1F, 0xE0,
  0x3C, 0x03, 0xFC, 0x07, 0x80, 0x78, 0xE1, 0xF8, 0xE7, 0xFC, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x87, 0xEF,
  0xC7, 0xC1, 0xF3, 0xC0, 0x7B, 0xE0, 0x3F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF8, 0x07, 0xBC, 0x07, 0x9F, 0x03, 0xC7, 0xC7, 0xE3, 0xFF,
  0xE0, 0xFF, 0xE0, 0x1F, 0xE0, 0xE1, 0xF0, 0x73, 0xFE, 0x3D, 0xFF, 0x9F,
  0xEF, 0xCF, 0xC1, 0xF7, 0xC0, 0x7B, 0xE0, 0x3D, 0xE0, 0x1F, 0xF0, 0x0F,
  0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x3F, 0xE0, 0x1F, 0xF8, 0x0F, 0x7C, 0x07, 0xBE, 0x07, 0xDF, 0xC7, 0xCF,
  0xFF, 0xE7, 0xBF, 0xE3, 0xCF, 0xE1, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0xC7, 0x8F, 0xF3, 0xCF, 0xFD, 0xEF, 0xFF,
  0xF7, 0xC1, 0xFB, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF8, 0x0F, 0xFC, 0x07, 0xDF, 0x07, 0xEF, 0xC7, 0xF3, 0xFF,
  0x78, 0xFF, 0xBC, 0x3F, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0xE1, 0xFC, 0x7F, 0x9F, 0xFF, 0xFF, 0xE1, 0xF8, 0x3E,
  0x07, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x00, 0x1F,
  0xC1, 0xFF, 0xDF, 0xFD, 0xF1, 0xEF, 0x01, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x7F, 0x80, 0xFE, 0x01, 0xF8, 0x03, 0xE0,
  0x1F, 0x00, 0x78, 0x03, 0xE0, 0x3F, 0xC3, 0xEF, 0xFF, 0x7F, 0xF3, 0xFF,
  0x00, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE7, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xF0, 0x3E, 0x23,
  0xFC, 0x7F, 0x87, 0xF0, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0x7F, 0xFF, 0x7F, 0xEF,
  0x1F, 0xCF, 0xF0, 0x03, 0xFE, 0x01, 0xF7, 0x80, 0x79, 0xE0, 0x1E, 0x7C,
  0x07, 0x8F, 0x03, 0xE3, 0xC0, 0xF0, 0xF0, 0x3C, 0x1E, 0x0F, 0x07, 0x87,
  0x81, 0xE1, 0xE0, 0x78, 0x78, 0x0F, 0x3C, 0x03, 0xCF, 0x00, 0xF3, 0xC0,
  0x1C, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0xF7, 0x80, 0xF8,
  0x0F, 0x78, 0x1F, 0x80, 0xF7, 0x81, 0xF8, 0x1E, 0x78, 0x1F, 0xC1, 0xE3,
  0xC1, 0xDC, 0x1E, 0x3C, 0x1D, 0xC1, 0xE3, 0xC3, 0xDC, 0x1E, 0x3C, 0x39,
  0xC3, 0xC1, 0xE3, 0x9E, 0x3C, 0x1E, 0x38, 0xE3, 0xC1, 0xE7, 0x8E, 0x3C,
  0x1E, 0x78, 0xE7, 0x81, 0xE7, 0x0F, 0x78, 0x0F, 0x70, 0xF7, 0x80, 0xF7,
  0x07, 0x78, 0x0F, 0x70, 0x77, 0x00, 0xFF, 0x07, 0x70, 0x07, 0xE0, 0x7F,
  0x00, 0x7E, 0x07, 0xF0, 0x07, 0xE0, 0x3E, 0x00, 0x7E, 0x03, 0xE0, 0x03,
  0xE0, 0x3E, 0x00, 0x78, 0x07, 0xDF, 0x03, 0xE3, 0xC0, 0xF0, 0x78, 0x7C,
  0x1E, 0x1E, 0x03, 0xCF, 0x80, 0xF3, 0xC0, 0x1F, 0xF0, 0x07, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x3E, 0xF0, 0x0F, 0x3C, 0x07, 0xC7, 0x81, 0xE1, 0xE0, 0xF8, 0x3C,
  0x3C, 0x0F, 0x1F, 0x01, 0xEF, 0x80, 0x7C, 0xF8, 0x03, 0xDE, 0x01, 0xF7,
  0x80, 0x79, 0xE0, 0x1E, 0x7C, 0x07, 0x8F, 0x03, 0xE3, 0xC0, 0xF0, 0xF0,
  0x3C, 0x1E, 0x0F, 0x07, 0x87, 0x81, 0xE1, 0xE0, 0x3C, 0x78, 0x0F, 0x3C,
  0x03, 0xCF, 0x00, 0x73, 0xC0, 0x1E, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0,
  0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0xFB,
  0xFF, 0xDF, 0xFE, 0xFF, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x03,
  0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x03, 0xC0,
  0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x78, 0x0F, 0xC0, 0xFE, 0x0F, 0xC0, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x01, 0xE0, 0x3F, 0x07, 0xF0, 0x3E, 0x01, 0xFC, 0x01, 0xF0, 0x07, 0x80,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xC0, 0x3F, 0xC0, 0xFE, 0x03, 0xF0, 0x03,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0x0F, 0xC0, 0xFE, 0x07, 0xE0, 0x1E,
  0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0xE0, 0x3F, 0x01, 0xF0, 0x7F, 0x0F,
  0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x0F, 0xE0, 0xFC, 0x0F, 0x80, 0xC0,
  0x00, 0x1C, 0x00, 0x5F, 0xE0, 0x3F, 0xFF, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xA0, 0x0F, 0xC0,
};

const GFXglyph NotoSans_Condensed_Medium42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 5, 30, 11, 3, -30 },
  { 20, 13, 11, 17, 2, -30 },
  { 38, 20, 30, 22, 1, -30 },
  { 113, 16, 34, 20, 2, -32 },
  { 181, 28, 30, 31, 2, -30 },
  { 286, 23, 30, 24, 1, -30 },
  { 373, 5, 11, 9, 2, -30 },
  { 380, 10, 37, 13, 2, -30 },
  { 427, 10, 37, 13, 1, -30 },
  { 474, 17, 16, 19, 1, -32 },
  { 508, 18, 20, 20, 1, -25 },
  { 553, 6, 11, 10, 2, -5 },
  { 562, 10, 4, 12, 1, -13 },
  { 567, 5, 5, 10, 3, -5 },
  { 571, 15, 30, 16, 1, -30 },
  { 628, 16, 30, 20, 2, -30 },
  { 688, 11, 30, 20, 3, -30 },
  { 730, 16, 30, 20, 2, -30 },
  { 790, 16, 30, 20, 2, -30 },
  { 850, 18, 30, 20, 1, -30 },
  { 918, 16, 30, 20, 2, -30 },
  { 978, 16, 30, 20, 2, -30 },
  { 1038, 18, 30, 20, 1, -30 },
  { 1106, 17, 30, 20, 2, -30 },
  { 1170, 16, 30, 20, 2, -30 },
  { 1230, 5, 23, 10, 3, -23 },
  { 1245, 7, 29, 10, 1, -23 },
  { 1271, 18, 20, 20, 1, -25 },
  { 1316, 17, 12, 20, 2, -21 },
  { 1342, 18, 20, 20, 1, -25 },
  { 1387, 15, 30, 15, 0, -30 },
  { 1444, 27, 34, 31, 2, -30 },
  { 1559, 22, 30, 22, 0, -30 },
  { 1642, 18, 30, 23, 3, -30 },
  { 1710, 18, 30, 21, 2, -30 },
  { 1778, 20, 30, 25, 3, -30 },
  { 1853, 14, 30, 19, 3, -30 },
  { 1906, 14, 30, 18, 3, -30 },
  { 1959, 21, 30, 25, 2, -30 },
  { 2038, 19, 30, 26, 3, -30 },
  { 2110, 11, 30, 13, 1, -30 },
  { 2152, 9, 38, 11, -2, -30 },
  { 2195, 19, 30, 22, 3, -30 },
  { 2267, 14, 30, 18, 3, -30 },
  { 2320, 27, 30, 33, 3, -30 },
  { 2422, 21, 30, 27, 3, -30 },
  { 2501, 22, 30, 26, 2, -30 },
  { 2584, 17, 30, 21, 3, -30 },
  { 2648, 22, 37, 26, 2, -30 },
  { 2750, 19, 30, 22, 3, -30 },
  { 2822, 16, 30, 19, 2, -30 },
  { 2882, 18, 30, 19, 0, -30 },
  { 2950, 19, 30, 25, 3, -30 },
  { 3022, 21, 30, 21, 0, -30 },
  { 3101, 33, 30, 33, 0, -30 },
  { 3225, 20, 30, 20, 0, -30 },
  { 3300, 20, 30, 20, 0, -30 },
  { 3375, 16, 30, 18, 1, -30 },
  { 3435, 9, 37, 13, 3, -30 },
  { 3477, 15, 30, 16, 1, -30 },
  { 3534, 9, 37, 13, 1, -30 },
  { 3576, 19, 17, 21, 1, -30 },
  { 3617, 18, 2, 18, 0, 4 },
  { 3622, 8, 7, 12, 2, -32 },
  { 3629, 15, 23, 20, 2, -23 },
  { 3673, 17, 32, 22, 3, -32 },
  { 3741, 14, 23, 17, 2, -23 },
  { 3782, 17, 32, 22, 2, -32 },
  { 3850, 16, 23, 20, 2, -23 },
  { 3896, 14, 32, 12, 0, -32 },
  { 3952, 17, 33, 22, 2, -23 },
  { 4023, 16, 32, 22, 3, -32 },
  { 4087, 4, 31, 10, 3, -31 },
  { 4103, 8, 41, 10, -1, -31 },
  { 4144, 16, 32, 19, 3, -32 },
  { 4208, 4, 32, 10, 3, -32 },
  { 4224, 27, 23, 33, 3, -23 },
  { 4302, 16, 23, 22, 3, -23 },
  { 4348, 17, 23, 21, 2, -23 },
  { 4397, 17, 33, 22, 3, -23 },
  { 4468, 17, 33, 22, 2, -23 },
  { 4539, 11, 23, 15, 3, -23 },
  { 4571, 13, 23, 16, 2, -23 },
  { 4609, 11, 28, 13, 1, -28 },
  { 4648, 16, 23, 22, 3, -23 },
  { 4694, 18, 23, 18, 0, -23 },
  { 4746, 28, 23, 29, 0, -23 },
  { 4827, 18, 23, 18, 0, -23 },
  { 4879, 18, 33, 18, 0, -23 },
  { 4954, 13, 23, 15, 1, -23 },
  { 4992, 13, 37, 15, 1, -30 },
  { 5053, 3, 42, 19, 8, -32 },
  { 5069, 12, 37, 15, 2, -30 },
  { 5125, 18, 6, 20, 1, -18 },
};

const GFXfont NotoSans_Condensed_Medium42pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Medium42pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Medium42pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _NOTOSANS_CONDENSED_MEDIUM42PT7B_H_
