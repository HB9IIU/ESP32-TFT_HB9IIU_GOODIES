#ifndef _NOTOSANS_CONDENSED_MEDIUM30PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUM30PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Medium.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Medium30pt7bBitmaps[] PROGMEM = {
  0x00, 0xFE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0x66, 0x60, 0x06, 0xFF, 0xE0,
  0xE7, 0xF3, 0xB9, 0xDC, 0x6E, 0x37, 0x1B, 0x8C, 0x06, 0x30, 0x38, 0xC0,
  0xE3, 0x03, 0x1C, 0x0C, 0x60, 0x31, 0x8F, 0xFF, 0xFF, 0xFF, 0x1C, 0x60,
  0x63, 0x81, 0x8E, 0x06, 0x30, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0x8E, 0x30,
  0x31, 0xC0, 0xC7, 0x03, 0x18, 0x0C, 0x60, 0x31, 0x80, 0x06, 0x00, 0x60,
  0x06, 0x01, 0xFF, 0x7F, 0xE7, 0xE6, 0xE6, 0x0E, 0x60, 0xE6, 0x07, 0x60,
  0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x06, 0xF0, 0x67, 0x06, 0x70, 0x67,
  0xC6, 0xFF, 0xFE, 0xFF, 0xC0, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x18,
  0x01, 0x03, 0xE0, 0x60, 0x7E, 0x06, 0x06, 0x70, 0xE0, 0xE3, 0x0C, 0x0E,
  0x31, 0xC0, 0xE3, 0x18, 0x0E, 0x33, 0x80, 0xE3, 0x30, 0x0E, 0x33, 0x3C,
  0x67, 0x77, 0xE7, 0xE6, 0x66, 0x3E, 0xEE, 0x71, 0x8C, 0xE3, 0x00, 0xCE,
  0x30, 0x1C, 0xE3, 0x01, 0x8E, 0x30, 0x38, 0xE3, 0x03, 0x0E, 0x70, 0x70,
  0x67, 0x06, 0x07, 0xE0, 0xE0, 0x3C, 0x07, 0x00, 0x1F, 0xC0, 0x3F, 0xC0,
  0x38, 0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x39, 0xC0, 0x1F, 0xC0,
  0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x0E, 0x7F, 0x8E, 0x73, 0xCE, 0xE1, 0xDE,
  0xE0, 0xFC, 0xE0, 0xFC, 0xE0, 0x78, 0xF0, 0x78, 0x7B, 0xFC, 0x7F, 0xDE,
  0x3F, 0x8F, 0xFF, 0xFF, 0xF8, 0x06, 0x1C, 0x70, 0xE3, 0x87, 0x1C, 0x38,
  0x70, 0xE1, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0x60, 0xE1, 0xC3, 0x87, 0x07,
  0x0E, 0x0C, 0x1C, 0x18, 0x18, 0xC1, 0xC1, 0xC1, 0x83, 0x87, 0x07, 0x0E,
  0x1C, 0x38, 0x30, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x38, 0x70, 0xE1, 0xC7,
  0x0E, 0x18, 0x70, 0xC3, 0x80, 0x0E, 0x00, 0xE0, 0x06, 0x08, 0x62, 0xF7,
  0xEF, 0xFE, 0x0E, 0x11, 0xF0, 0x1B, 0x83, 0x9C, 0x71, 0xC1, 0x10, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x7B, 0x9C,
  0xE6, 0x73, 0x80, 0xFF, 0xFC, 0xEE, 0xFE, 0x00, 0xE0, 0x1C, 0x03, 0x00,
  0xE0, 0x1C, 0x03, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x18, 0x07, 0x00,
  0xE0, 0x18, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x01,
  0xC0, 0x00, 0x06, 0x01, 0xF8, 0x3F, 0xC7, 0x8E, 0x70, 0xE7, 0x07, 0x70,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0x70, 0x77, 0x0E, 0x70, 0xE3, 0xDE, 0x3F, 0xC1, 0xF8, 0x0F,
  0x1F, 0x3F, 0x7F, 0xF7, 0x67, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x0F, 0x03, 0xFC, 0xFF,
  0xE6, 0x1E, 0x40, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01,
  0xC0, 0x3C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x0E, 0x07, 0xFC, 0xFF, 0xE6, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x7C, 0x1F, 0x01, 0xFC, 0x03,
  0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x80, 0xFE, 0x3E, 0xFF,
  0xC7, 0xF8, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x6C, 0x03, 0x60,
  0x3B, 0x01, 0x98, 0x1C, 0xC0, 0xC6, 0x0C, 0x30, 0xE1, 0x86, 0x0C, 0x70,
  0x63, 0x03, 0x1F, 0xFF, 0xFF, 0xF8, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0xFF, 0xDF, 0xFB, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xFF, 0x1F, 0xF1, 0x0F, 0x00, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x01, 0xF0, 0x3B, 0x9F, 0x7F, 0xCF, 0xF0, 0x01, 0xE0, 0xFE, 0x1F, 0xE3,
  0xC0, 0x38, 0x07, 0x00, 0x70, 0x07, 0x00, 0x63, 0x0E, 0xFC, 0xFF, 0xEF,
  0x8F, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0x70, 0x77, 0x07, 0x70, 0xF3,
  0xDE, 0x3F, 0xE0, 0xF8, 0xFF, 0xFF, 0xFF, 0x00, 0x70, 0x07, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x07, 0x00,
  0x70, 0x07, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x00,
  0x0F, 0x03, 0xFC, 0x7F, 0xE7, 0x0E, 0x70, 0x77, 0x07, 0x70, 0x77, 0x0E,
  0x39, 0xE3, 0xFC, 0x1F, 0x81, 0xF8, 0x3B, 0xE7, 0x0E, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x77, 0x8F, 0x7F, 0xE1, 0xFC, 0x06, 0x03, 0xF8,
  0x7F, 0xC7, 0x1E, 0xF0, 0xEE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xF0, 0xF7, 0x9F, 0x3F, 0xF1, 0xF7, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0E,
  0x01, 0xC4, 0x7C, 0x7F, 0x87, 0xE0, 0xEF, 0xF6, 0x00, 0x00, 0x00, 0x00,
  0xEF, 0xFE, 0x73, 0xDE, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3D, 0xCE,
  0x73, 0x39, 0x80, 0x00, 0x10, 0x03, 0x00, 0xF0, 0x3E, 0x0F, 0x83, 0xE0,
  0xF8, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x70, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x80, 0x0E, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0x01, 0xF0, 0x7C, 0x3F, 0x0F, 0xC0, 0xF0, 0x0C, 0x00, 0x0E,
  0x3F, 0xE7, 0xFD, 0x87, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x03, 0xC0, 0xE0,
  0x70, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x70,
  0x1E, 0x07, 0x00, 0x00, 0x60, 0x00, 0x3F, 0xE0, 0x07, 0xDF, 0x00, 0xE0,
  0x38, 0x1C, 0x01, 0xC3, 0x80, 0x0E, 0x30, 0x78, 0x67, 0x1F, 0xC6, 0x61,
  0xCC, 0x76, 0x38, 0xC7, 0x63, 0x0C, 0x7E, 0x30, 0xC7, 0xE3, 0x0C, 0x7E,
  0x30, 0xC7, 0xE3, 0x1C, 0x66, 0x31, 0xC6, 0x63, 0xB6, 0xE6, 0x1F, 0x7C,
  0x70, 0x41, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x20, 0x0F, 0xFE,
  0x00, 0x7F, 0xE0, 0x00, 0x60, 0x00, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xE0,
  0x07, 0xE0, 0x06, 0xE0, 0x0E, 0x60, 0x0E, 0x70, 0x0E, 0x70, 0x0C, 0x70,
  0x1C, 0x38, 0x1C, 0x38, 0x1C, 0x38, 0x3F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFC,
  0x38, 0x1C, 0x78, 0x1E, 0x70, 0x0E, 0x70, 0x0E, 0xF0, 0x0E, 0xE0, 0x0F,
  0xFF, 0xC7, 0xFF, 0x38, 0x3D, 0xC0, 0xEE, 0x07, 0x70, 0x3B, 0x81, 0xDC,
  0x0E, 0xE3, 0xE7, 0xFE, 0x3F, 0xF9, 0xC1, 0xEE, 0x07, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x7F, 0x03, 0xBF, 0xFD, 0xFF, 0xCF, 0xFC, 0x00, 0x03,
  0xC0, 0x7F, 0xCF, 0xFC, 0x78, 0x67, 0x80, 0x78, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x7C, 0xE1, 0xFF, 0x07, 0xF8, 0xFF,
  0xC3, 0xFF, 0x8E, 0x1F, 0x38, 0x1E, 0xE0, 0x3B, 0x80, 0xFE, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x03, 0xF8, 0x0E, 0xE0, 0x7B, 0x83, 0xCF, 0xFF, 0x3F, 0xF8, 0xFF, 0x80,
  0xFF, 0xFF, 0xFE, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x3F,
  0xFF, 0xFF, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x00, 0x01, 0xE0, 0x3F, 0xF1, 0xFF, 0xCF,
  0x02, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xF0, 0x1D,
  0xC0, 0x77, 0x81, 0xCF, 0xCF, 0x1F, 0xFC, 0x3F, 0xE0, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1C, 0xFE, 0xFC,
  0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C,
  0x38, 0x70, 0xE7, 0xFF, 0xE0, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87,
  0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1,
  0xC3, 0x87, 0xFF, 0xFB, 0xE0, 0xE0, 0x7B, 0x81, 0xCE, 0x0E, 0x38, 0x78,
  0xE1, 0xC3, 0x8F, 0x0E, 0x38, 0x39, 0xC0, 0xEF, 0x03, 0xB8, 0x0F, 0xF0,
  0x3F, 0xE0, 0xF3, 0x83, 0x8F, 0x0E, 0x1C, 0x38, 0x78, 0xE0, 0xE3, 0x83,
  0xCE, 0x07, 0x38, 0x1E, 0xE0, 0x3C, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x01, 0xFF,
  0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xBF, 0xC0, 0x3F, 0xD8, 0x0F, 0xFB,
  0x81, 0xFF, 0x70, 0x37, 0xE6, 0x0E, 0xFC, 0xE1, 0xDF, 0x9C, 0x33, 0xF1,
  0x8E, 0x7E, 0x39, 0xCF, 0xC7, 0x31, 0xF8, 0xEE, 0x3F, 0x0D, 0xC7, 0xE1,
  0xF0, 0xFC, 0x3E, 0x1F, 0x83, 0xC3, 0xF0, 0x70, 0x7E, 0x0E, 0x0E, 0xF0,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFD, 0xC1, 0xFB, 0x83,
  0xF3, 0x87, 0xE7, 0x0F, 0xC7, 0x1F, 0x8E, 0x3F, 0x0E, 0x7E, 0x1C, 0xFC,
  0x1D, 0xF8, 0x3B, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0x7F, 0x80, 0xFF, 0x00,
  0xFE, 0x01, 0xE0, 0x03, 0x80, 0x3F, 0xE0, 0xFF, 0xE3, 0xC3, 0xE7, 0x01,
  0xDE, 0x03, 0xB8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x1E, 0xE0,
  0x39, 0xE0, 0xF1, 0xF7, 0xC3, 0xFF, 0x01, 0xFC, 0x00, 0xFF, 0x8F, 0xFE,
  0xE1, 0xEE, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFE, 0x0E,
  0xFF, 0xEF, 0xFC, 0xFE, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x3F, 0xE0, 0xFF, 0xE3, 0xC3,
  0xE7, 0x01, 0xDE, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xF0,
  0x1E, 0xE0, 0x39, 0xE0, 0xF1, 0xF7, 0xC3, 0xFF, 0x01, 0xFC, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0xFF, 0x87, 0xFF, 0x38,
  0xF9, 0xC1, 0xEE, 0x07, 0x70, 0x3B, 0x81, 0xDC, 0x0E, 0xE0, 0xF7, 0x0F,
  0x3F, 0xF1, 0xFF, 0x0E, 0x38, 0x71, 0xE3, 0x87, 0x1C, 0x3C, 0xE0, 0xE7,
  0x07, 0xB8, 0x1D, 0xC0, 0xFE, 0x03, 0x80, 0x0F, 0x03, 0xFE, 0x7F, 0xE7,
  0x86, 0x70, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3F, 0x00,
  0xF8, 0x07, 0xC0, 0x1E, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x0E, 0x80, 0xEF,
  0xFE, 0xFF, 0xC7, 0xF8, 0xFF, 0xFF, 0xFF, 0xC1, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x00, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xF0, 0x39, 0xC0, 0xE7, 0xDF,
  0x8F, 0xFC, 0x1F, 0xE0, 0xE0, 0x0E, 0xE0, 0x1D, 0xC0, 0x73, 0x80, 0xE7,
  0x01, 0xC7, 0x03, 0x8E, 0x0E, 0x1C, 0x1C, 0x38, 0x38, 0x38, 0xE0, 0x71,
  0xC0, 0xE3, 0x80, 0xC7, 0x01, 0xDC, 0x03, 0xB8, 0x07, 0x70, 0x06, 0xE0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x38, 0x00, 0xE0, 0x3C, 0x0F, 0xF0,
  0x3C, 0x0E, 0x70, 0x3C, 0x0E, 0x70, 0x3C, 0x0E, 0x70, 0x7C, 0x0E, 0x70,
  0x7E, 0x1C, 0x38, 0x6E, 0x1C, 0x38, 0x6E, 0x1C, 0x38, 0xE6, 0x1C, 0x38,
  0xE7, 0x3C, 0x38, 0xE7, 0x38, 0x1C, 0xC7, 0x38, 0x1C, 0xC3, 0x38, 0x1D,
  0xC3, 0x38, 0x1D, 0xC3, 0xF0, 0x0D, 0x83, 0xF0, 0x0D, 0x83, 0xF0, 0x0F,
  0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xE0, 0x07, 0x01, 0xE0, 0x70,
  0x3C, 0xE0, 0xE3, 0x87, 0x8F, 0x1C, 0x1C, 0xF0, 0x73, 0x80, 0xEE, 0x03,
  0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xF0, 0x0F, 0xC0, 0x3B, 0x81,
  0xCE, 0x07, 0x3C, 0x38, 0x70, 0xE1, 0xE7, 0x83, 0x9C, 0x0F, 0xF0, 0x1C,
  0xF0, 0x3D, 0xC0, 0xE7, 0x03, 0x8E, 0x1C, 0x38, 0x70, 0xF3, 0xC1, 0xCE,
  0x07, 0x38, 0x0F, 0xC0, 0x3F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0xFF, 0xFF, 0xFC, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x38,
  0x07, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x03, 0xC0, 0x70,
  0x1E, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x0E, 0x1C, 0x38,
  0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E,
  0x1C, 0x38, 0x70, 0xFF, 0xFF, 0xF8, 0xE0, 0x0E, 0x01, 0xC0, 0x18, 0x03,
  0x80, 0x70, 0x06, 0x00, 0xE0, 0x1C, 0x01, 0x80, 0x38, 0x07, 0x00, 0x70,
  0x0E, 0x00, 0xC0, 0x1C, 0x03, 0x80, 0x30, 0x07, 0x00, 0xE0, 0x0E, 0x01,
  0xC0, 0xFF, 0xFF, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0xFF, 0xFF, 0xC0, 0x07, 0x00,
  0x38, 0x03, 0xE0, 0x1B, 0x01, 0xDC, 0x0C, 0xE0, 0xE3, 0x86, 0x1C, 0x70,
  0x73, 0x83, 0xB8, 0x0F, 0xC0, 0x70, 0xFF, 0xFF, 0xFF, 0xC0, 0xF1, 0xC3,
  0x87, 0x0C, 0x7F, 0xC7, 0xF8, 0x87, 0x80, 0x70, 0x0E, 0x01, 0xC3, 0xF9,
  0xFF, 0x78, 0xFE, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xE3, 0xDF, 0xD9, 0xF3,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0xFC,
  0xFF, 0xEF, 0x8E, 0xF0, 0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7F, 0x0F, 0xF9, 0xEF, 0xFE, 0xEF, 0xC0, 0x02,
  0x07, 0xF3, 0xFD, 0xE1, 0x70, 0x1C, 0x07, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0xCC, 0xFF, 0x1F, 0xC0, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x10, 0xE3, 0xE7, 0x3F, 0xBB,
  0xC7, 0xDC, 0x1E, 0xE0, 0xFF, 0x07, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x83, 0xDC, 0x1E, 0xE0, 0xF7, 0x8F, 0x9F, 0xDC, 0x7C, 0xE0, 0x1F,
  0x83, 0xFC, 0x78, 0xE7, 0x06, 0x70, 0x76, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x60, 0x07, 0x00, 0x70, 0x03, 0x86, 0x3F, 0xE0, 0xFE, 0x07,
  0xC7, 0xE1, 0xF8, 0x70, 0x1C, 0x0E, 0x03, 0x81, 0xFC, 0xFF, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0x04, 0x00, 0xF9, 0xCF, 0xEE, 0xF1, 0xF7, 0x07,
  0xB8, 0x3F, 0xC1, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xE0, 0xF7,
  0x07, 0xB8, 0x3D, 0xE3, 0xE7, 0xF7, 0x1F, 0x38, 0x01, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x38, 0xF1, 0xFF, 0x87, 0xF0, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0xFC, 0xFF, 0xEF, 0x8E, 0xF0, 0xEE,
  0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x70, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1C, 0x71, 0xC0, 0x00, 0x01, 0xC7, 0x1C, 0x71, 0xC7,
  0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x7B, 0xFE,
  0xF0, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1E,
  0x0E, 0xE1, 0xCE, 0x3C, 0xE3, 0x8E, 0x70, 0xEE, 0x0E, 0xE0, 0xFE, 0x0F,
  0xF0, 0xF7, 0x0E, 0x38, 0xE3, 0x8E, 0x1C, 0xE1, 0xEE, 0x0E, 0xE0, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x02, 0x02, 0x1D,
  0xF9, 0xFB, 0xFF, 0x7F, 0xF8, 0xFC, 0xFF, 0x0F, 0x0F, 0xC1, 0xC1, 0xF8,
  0x38, 0x3F, 0x07, 0x07, 0xE0, 0xE0, 0xFC, 0x1C, 0x1F, 0x83, 0x83, 0xF0,
  0x70, 0x7E, 0x0E, 0x0F, 0xC1, 0xC1, 0xF8, 0x38, 0x3F, 0x07, 0x07, 0xE0,
  0xE0, 0xE0, 0x02, 0x0E, 0xFC, 0xFF, 0xEF, 0x8E, 0xF0, 0xEE, 0x0F, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x70, 0x02, 0x00, 0xFE, 0x0F, 0xF8, 0xF1, 0xE7, 0x07,
  0x38, 0x3B, 0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0E, 0xE0, 0x77,
  0x07, 0x38, 0x38, 0xE3, 0xC7, 0xFC, 0x0F, 0xC0, 0x02, 0x0E, 0xFC, 0xFF,
  0xEF, 0x8E, 0xF0, 0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7F, 0x0F, 0xF9, 0xEF, 0xFE, 0xEF, 0xCE, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x04, 0x00, 0xF9, 0xCF,
  0xEE, 0xF1, 0xF7, 0x07, 0xB8, 0x3F, 0xC1, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xE0, 0xF7, 0x07, 0xB8, 0x3D, 0xE3, 0xE7, 0xF7, 0x1F, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x02,
  0xCF, 0xFF, 0xFF, 0xF0, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0x04, 0x0F, 0xF7, 0xFB, 0x82, 0xE0, 0x38, 0x0F,
  0x01, 0xF0, 0x3E, 0x07, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x7E, 0x3B, 0xFE,
  0xFF, 0x00, 0x18, 0x0C, 0x06, 0x07, 0x07, 0xFF, 0xFC, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1E, 0x47, 0xE1,
  0xF0, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xE7, 0xDF, 0xD9, 0xF3, 0xE0,
  0x3B, 0x83, 0x9C, 0x1C, 0xE0, 0xE7, 0x07, 0x1C, 0x70, 0xE3, 0x87, 0x1C,
  0x19, 0xC0, 0xEE, 0x07, 0x70, 0x1B, 0x00, 0xD8, 0x07, 0xC0, 0x3E, 0x00,
  0xE0, 0xE0, 0xF0, 0x77, 0x0F, 0x07, 0x70, 0xF0, 0x77, 0x0F, 0x8E, 0x71,
  0xD8, 0xE3, 0x1D, 0x8E, 0x39, 0x98, 0xE3, 0x99, 0xCC, 0x39, 0x9D, 0xC1,
  0xB8, 0xDC, 0x1B, 0x8D, 0xC1, 0xF0, 0xD8, 0x1F, 0x0D, 0x81, 0xF0, 0xF8,
  0x0F, 0x07, 0x80, 0xF0, 0x70, 0x70, 0x7B, 0xC7, 0x8E, 0x38, 0x3B, 0xC1,
  0xDC, 0x07, 0xE0, 0x3E, 0x00, 0xE0, 0x0F, 0x80, 0x7C, 0x07, 0x70, 0x3B,
  0x83, 0x8E, 0x1C, 0x71, 0xC1, 0xDE, 0x0F, 0xE0, 0x3B, 0x83, 0x9C, 0x1C,
  0xE0, 0xE3, 0x87, 0x1C, 0x70, 0xE3, 0x87, 0x1C, 0x1D, 0xC0, 0xEE, 0x07,
  0x70, 0x1B, 0x00, 0xF8, 0x07, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x03, 0x80, 0x1C, 0x0B, 0xE0, 0x3E, 0x01, 0xE0, 0x00, 0xFF, 0xFF, 0xC0,
  0xE0, 0xE0, 0x70, 0x70, 0x38, 0x38, 0x1C, 0x1C, 0x0E, 0x0E, 0x07, 0x07,
  0x03, 0xFF, 0xFF, 0x07, 0x87, 0xC7, 0x83, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x1F, 0x0E, 0x07, 0xC0, 0xF0, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x1F, 0x0F, 0x81, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x7C, 0x0F, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x01, 0xF0, 0x38, 0x7C, 0x78, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x71, 0xF0, 0xF8, 0x70, 0x00, 0x18,
  0x1F, 0xE1, 0xFF, 0xF8, 0x3F, 0x80, 0x00,
};

const GFXglyph NotoSans_Condensed_Medium30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 4, 21, 8, 2, -21 },
  { 12, 9, 7, 12, 2, -21 },
  { 20, 14, 21, 16, 1, -21 },
  { 57, 12, 25, 14, 1, -23 },
  { 95, 20, 22, 22, 1, -22 },
  { 150, 16, 22, 17, 1, -22 },
  { 194, 3, 7, 7, 2, -21 },
  { 197, 7, 27, 9, 1, -22 },
  { 221, 7, 27, 9, 1, -22 },
  { 245, 12, 12, 14, 1, -23 },
  { 263, 12, 15, 14, 1, -18 },
  { 286, 5, 7, 7, 1, -3 },
  { 291, 7, 2, 9, 1, -9 },
  { 293, 4, 4, 7, 2, -4 },
  { 295, 11, 22, 11, 0, -22 },
  { 326, 12, 22, 14, 1, -22 },
  { 359, 8, 21, 14, 2, -21 },
  { 380, 12, 22, 14, 1, -22 },
  { 413, 12, 22, 14, 1, -22 },
  { 446, 13, 22, 14, 1, -22 },
  { 482, 11, 21, 14, 2, -21 },
  { 511, 12, 22, 14, 1, -22 },
  { 544, 12, 21, 14, 1, -21 },
  { 576, 12, 22, 14, 1, -22 },
  { 609, 12, 22, 14, 1, -22 },
  { 642, 4, 16, 7, 2, -16 },
  { 650, 5, 20, 7, 1, -16 },
  { 663, 12, 14, 14, 1, -18 },
  { 684, 12, 9, 14, 1, -15 },
  { 698, 12, 14, 14, 1, -18 },
  { 719, 10, 22, 11, 0, -22 },
  { 747, 20, 25, 22, 1, -22 },
  { 810, 16, 21, 16, 0, -21 },
  { 852, 13, 21, 16, 2, -21 },
  { 887, 13, 22, 15, 2, -22 },
  { 923, 14, 21, 18, 2, -21 },
  { 960, 10, 21, 14, 2, -21 },
  { 987, 10, 21, 13, 2, -21 },
  { 1014, 14, 22, 18, 2, -22 },
  { 1053, 14, 21, 18, 2, -21 },
  { 1090, 7, 21, 9, 1, -21 },
  { 1109, 7, 27, 8, -2, -21 },
  { 1133, 14, 21, 16, 2, -21 },
  { 1170, 10, 21, 13, 2, -21 },
  { 1197, 19, 21, 24, 2, -21 },
  { 1247, 15, 21, 19, 2, -21 },
  { 1287, 15, 22, 19, 2, -22 },
  { 1329, 12, 21, 15, 2, -21 },
  { 1361, 15, 27, 19, 2, -22 },
  { 1412, 13, 21, 16, 2, -21 },
  { 1447, 12, 22, 14, 1, -22 },
  { 1480, 13, 21, 13, 0, -21 },
  { 1515, 14, 21, 18, 2, -21 },
  { 1552, 15, 21, 15, 0, -21 },
  { 1592, 24, 21, 24, 0, -21 },
  { 1655, 14, 21, 14, 0, -21 },
  { 1692, 14, 21, 14, 0, -21 },
  { 1729, 11, 21, 13, 1, -21 },
  { 1758, 7, 27, 10, 2, -22 },
  { 1782, 11, 22, 11, 0, -22 },
  { 1813, 6, 27, 10, 1, -22 },
  { 1834, 13, 12, 15, 1, -21 },
  { 1854, 13, 2, 13, 0, 3 },
  { 1858, 6, 5, 9, 1, -23 },
  { 1862, 11, 16, 14, 1, -16 },
  { 1884, 12, 23, 16, 2, -23 },
  { 1919, 10, 17, 12, 1, -17 },
  { 1941, 13, 23, 16, 1, -23 },
  { 1979, 12, 16, 14, 1, -16 },
  { 2003, 10, 23, 9, 0, -23 },
  { 2032, 13, 24, 16, 1, -17 },
  { 2071, 12, 23, 16, 2, -23 },
  { 2106, 3, 22, 7, 2, -22 },
  { 2115, 6, 29, 7, -1, -22 },
  { 2137, 12, 23, 14, 2, -23 },
  { 2172, 3, 23, 7, 2, -23 },
  { 2181, 19, 17, 23, 2, -17 },
  { 2222, 12, 17, 16, 2, -17 },
  { 2248, 13, 17, 15, 1, -17 },
  { 2276, 12, 24, 16, 2, -17 },
  { 2312, 13, 24, 16, 1, -17 },
  { 2351, 8, 17, 10, 2, -17 },
  { 2368, 10, 17, 12, 1, -17 },
  { 2390, 9, 20, 9, 0, -20 },
  { 2413, 11, 16, 16, 2, -16 },
  { 2435, 13, 16, 13, 0, -16 },
  { 2461, 20, 16, 20, 0, -16 },
  { 2501, 13, 16, 13, 0, -16 },
  { 2527, 13, 23, 13, 0, -16 },
  { 2565, 9, 16, 11, 1, -16 },
  { 2583, 9, 26, 11, 1, -21 },
  { 2613, 2, 30, 14, 6, -23 },
  { 2621, 9, 26, 11, 1, -21 },
  { 2651, 12, 5, 14, 1, -13 },
};

const GFXfont NotoSans_Condensed_Medium30pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Medium30pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Medium30pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _NOTOSANS_CONDENSED_MEDIUM30PT7B_H_
