#ifndef _NOTOSANS_CONDENSED_MEDIUM36PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUM36PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Medium.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Medium36pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFE, 0xF7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x80, 0x00, 0x1B, 0xFF, 0xFB, 0x80, 0xF1, 0xFE, 0x3F, 0xC7, 0x78, 0xEF,
  0x1D, 0xE3, 0x9C, 0x73, 0x0E, 0x61, 0xCC, 0x38, 0x03, 0x8E, 0x01, 0x87,
  0x01, 0xC3, 0x80, 0xE1, 0x80, 0x70, 0xC0, 0x38, 0xE0, 0x1C, 0x70, 0x0C,
  0x38, 0x7F, 0xFF, 0xBF, 0xFF, 0xC3, 0x86, 0x01, 0xC7, 0x00, 0xE3, 0x80,
  0x71, 0xC0, 0x30, 0xE0, 0x18, 0x70, 0xFF, 0xFF, 0x7F, 0xFF, 0x87, 0x1C,
  0x03, 0x8E, 0x01, 0xC7, 0x00, 0xC3, 0x80, 0x61, 0xC0, 0x70, 0xC0, 0x38,
  0x60, 0x1C, 0x70, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x07, 0xFC, 0x7F,
  0xFB, 0xFF, 0xEF, 0x31, 0x38, 0xC0, 0xE3, 0x03, 0x8C, 0x0F, 0x30, 0x3E,
  0xC0, 0x7F, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFC, 0x03, 0x78, 0x0C, 0xF0,
  0x33, 0xC0, 0xCF, 0x03, 0x3F, 0x0D, 0xEF, 0xFF, 0xBF, 0xFC, 0x7F, 0xC0,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x1E, 0x00, 0xE0, 0x3F, 0x00,
  0xE0, 0x7F, 0x81, 0xC0, 0x73, 0x81, 0xC0, 0x71, 0xC3, 0x80, 0x61, 0xC3,
  0x80, 0xE1, 0xC3, 0x80, 0xE1, 0xC7, 0x00, 0xE1, 0xC7, 0x00, 0xE1, 0xCE,
  0x00, 0x61, 0xCE, 0x38, 0x71, 0xCC, 0x7C, 0x73, 0x9C, 0xFE, 0x7F, 0x9D,
  0xC7, 0x3F, 0x39, 0xC7, 0x1E, 0x39, 0xC7, 0x00, 0x71, 0xC7, 0x00, 0x71,
  0xC7, 0x00, 0x71, 0xC7, 0x00, 0xE1, 0xC7, 0x00, 0xE1, 0xC7, 0x01, 0xC1,
  0xC7, 0x01, 0xC1, 0xC7, 0x01, 0x80, 0xEE, 0x03, 0x80, 0xFE, 0x03, 0x80,
  0x7C, 0x07, 0xC0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xC7, 0x80, 0x3C,
  0x38, 0x03, 0xC3, 0x80, 0x3C, 0x38, 0x03, 0xC7, 0x80, 0x1C, 0x70, 0x01,
  0xEF, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xFC, 0x1E,
  0x3D, 0xE1, 0xC7, 0x9E, 0x3C, 0x70, 0xF3, 0xCF, 0x07, 0xB8, 0xF0, 0x3F,
  0x8F, 0x03, 0xF8, 0xF0, 0x1F, 0x0F, 0x01, 0xF0, 0x78, 0x3F, 0x87, 0xFF,
  0xFC, 0x3F, 0xF3, 0xC1, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0x76, 0x66, 0x07,
  0x0E, 0x1E, 0x1C, 0x3C, 0x38, 0x78, 0x70, 0x70, 0xF0, 0xF0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xF0, 0xF0, 0x70, 0x70,
  0x78, 0x38, 0x3C, 0x1C, 0x1E, 0x0E, 0x07, 0xE0, 0x70, 0x78, 0x38, 0x3C,
  0x1C, 0x1E, 0x1E, 0x0E, 0x0E, 0x0F, 0x0F, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x0F, 0x0F, 0x0E, 0x0E, 0x1E, 0x1E, 0x1C, 0x3C, 0x38,
  0x78, 0x70, 0xE0, 0x07, 0x80, 0x0E, 0x00, 0x38, 0x20, 0xC1, 0x73, 0x3F,
  0xFF, 0xFF, 0xFF, 0xC1, 0xE0, 0x0F, 0xC0, 0x7B, 0x81, 0xCF, 0x0F, 0x1E,
  0x18, 0x60, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x3C, 0xE3,
  0x9E, 0x79, 0xC7, 0x1C, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x67, 0xBF, 0xF7,
  0x00, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x03,
  0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x03, 0x80,
  0x1C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x1E,
  0x00, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x3F, 0xE0,
  0x7F, 0xC1, 0xE3, 0xC3, 0x83, 0x8F, 0x07, 0x9E, 0x07, 0x38, 0x0E, 0x70,
  0x1C, 0xE0, 0x3D, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07,
  0xB8, 0x0F, 0x70, 0x1E, 0xE0, 0x3D, 0xC0, 0x73, 0xC0, 0xE7, 0x83, 0xCF,
  0x07, 0x8F, 0x1E, 0x1F, 0xFC, 0x1F, 0xF0, 0x1F, 0xC0, 0x01, 0xC1, 0xF0,
  0xFC, 0x7F, 0x3F, 0xDE, 0xFF, 0x3D, 0x8F, 0x23, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x0F, 0xC0, 0x7F, 0xE3, 0xFF, 0xE3,
  0xC3, 0xC2, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1E,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xC0, 0x7F, 0xE3, 0xFF,
  0xE3, 0x83, 0xC2, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x70, 0x03, 0xE0, 0xFF, 0x01, 0xF8, 0x03, 0xFE, 0x00, 0xFE, 0x00,
  0x3E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07,
  0xB0, 0x1F, 0x7F, 0xFC, 0xFF, 0xF0, 0xFF, 0xC0, 0x00, 0x78, 0x00, 0xF8,
  0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0x78,
  0x06, 0x78, 0x0E, 0x78, 0x1C, 0x78, 0x1C, 0x78, 0x38, 0x78, 0x38, 0x78,
  0x70, 0x78, 0x70, 0x78, 0xE0, 0x78, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x7F, 0xF1, 0xFF, 0xC7, 0xFF, 0x1F, 0xFC, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0xF8, 0x3F, 0xF8, 0xFF, 0xF1, 0x07,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00,
  0x78, 0x01, 0xE8, 0x0F, 0xBF, 0xFC, 0xFF, 0xE1, 0xFE, 0x00, 0x03, 0xF0,
  0x3F, 0xC1, 0xFF, 0x0F, 0x80, 0x7C, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x7E, 0x3B, 0xFC, 0xFF, 0xFB, 0xE1, 0xEF, 0x03,
  0xB8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0x3D, 0xC0,
  0xE7, 0x87, 0x8F, 0xFC, 0x3F, 0xF0, 0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x07, 0xE0, 0x3F,
  0xE0, 0xFF, 0xE3, 0xE1, 0xE7, 0x83, 0xCE, 0x03, 0x9C, 0x07, 0x3C, 0x0E,
  0x78, 0x3C, 0x78, 0xF0, 0x7B, 0xE0, 0xFF, 0x80, 0x7C, 0x03, 0xFE, 0x0F,
  0xBE, 0x3E, 0x3E, 0x78, 0x3C, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01,
  0xEE, 0x03, 0xDE, 0x0F, 0x3F, 0xFE, 0x3F, 0xF8, 0x1F, 0xE0, 0x07, 0xC0,
  0x3F, 0xE0, 0xFF, 0xC3, 0xE3, 0xC7, 0x83, 0xCE, 0x07, 0xBC, 0x07, 0x78,
  0x0E, 0xF0, 0x1D, 0xE0, 0x3F, 0xC0, 0x7B, 0x81, 0xF7, 0x83, 0xEF, 0xDF,
  0xCF, 0xFF, 0x0F, 0xEE, 0x06, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0x80, 0x0F, 0x00, 0x3C, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0x00, 0x67,
  0xBF, 0xF7, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0xF7, 0xFE, 0xE0,
  0x31, 0xE7, 0xDF, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0xE7, 0x9E, 0x79, 0xC7, 0x18, 0xE0, 0x00, 0x06, 0x00, 0x3C, 0x01,
  0xF8, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x00, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0x80,
  0x03, 0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0x01,
  0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x00, 0x3E, 0x01, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0x80,
  0x3C, 0x00, 0x60, 0x00, 0x80, 0x00, 0x1F, 0x8F, 0xFE, 0x7F, 0xF7, 0x0F,
  0x40, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0xC0, 0x78, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x0F, 0x01, 0xF0, 0x1F, 0x00, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x78, 0x07, 0x81, 0xE0, 0x07, 0x87,
  0x80, 0x07, 0x0E, 0x00, 0x07, 0x38, 0x1F, 0xCE, 0x70, 0xFF, 0x0C, 0xC3,
  0xCE, 0x1F, 0x87, 0x1C, 0x3F, 0x1C, 0x38, 0x7E, 0x38, 0x70, 0xFC, 0x70,
  0xE1, 0xF8, 0xE1, 0xC3, 0xF1, 0xC3, 0x87, 0xE3, 0x87, 0x0F, 0xC7, 0x0E,
  0x1B, 0x8E, 0x3C, 0x77, 0x0F, 0xEF, 0xEE, 0x1F, 0x9F, 0x8E, 0x1E, 0x1E,
  0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x01, 0x00,
  0x3F, 0xBE, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x01, 0xFC, 0x00, 0x3B, 0x80, 0x07, 0x70, 0x01,
  0xEE, 0x00, 0x3D, 0xE0, 0x07, 0x1C, 0x00, 0xE3, 0x80, 0x3C, 0x78, 0x07,
  0x8F, 0x00, 0xE0, 0xE0, 0x1C, 0x1C, 0x07, 0x83, 0xC0, 0xFF, 0xF8, 0x1F,
  0xFF, 0x07, 0xFF, 0xF0, 0xFF, 0xFE, 0x1E, 0x03, 0xC3, 0x80, 0x38, 0xF0,
  0x07, 0x9E, 0x00, 0xF3, 0xC0, 0x1E, 0xF0, 0x01, 0xFE, 0x00, 0x3C, 0xFF,
  0x01, 0xFF, 0xE3, 0xFF, 0xE7, 0x0F, 0xEE, 0x03, 0xDC, 0x07, 0xB8, 0x0F,
  0x70, 0x1E, 0xE0, 0x3D, 0xC0, 0x7B, 0x81, 0xE7, 0xFF, 0x8F, 0xFC, 0x1F,
  0xFF, 0x38, 0x1F, 0x70, 0x1E, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0xFE, 0x01, 0xFC, 0x07, 0xB8, 0x1F, 0x7F, 0xFC, 0xFF, 0xF1, 0xFF, 0x80,
  0x03, 0xF8, 0x1F, 0xFC, 0x7F, 0xF9, 0xF8, 0x73, 0xC0, 0x0F, 0x80, 0x1E,
  0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x03,
  0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x81, 0x8F, 0xFF, 0x0F, 0xFE, 0x0F,
  0xF8, 0xFF, 0x00, 0xFF, 0xE0, 0xFF, 0xF8, 0xFF, 0xFC, 0xE0, 0x3C, 0xE0,
  0x1E, 0xE0, 0x1E, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x1E, 0xE0, 0x1E, 0xE0, 0x3C, 0xE0, 0xFC, 0xFF,
  0xF8, 0xFF, 0xF0, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0xFE, 0xFF,
  0xEF, 0xFE, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xFF, 0xEF, 0xFE, 0xFF, 0xEE, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x01,
  0xFE, 0x03, 0xFF, 0xC3, 0xFF, 0xE3, 0xF0, 0xF3, 0xE0, 0x13, 0xE0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xEF, 0x00, 0x77, 0x80, 0x39, 0xE0, 0x1C, 0xF8, 0x0E,
  0x3F, 0xFF, 0x0F, 0xFF, 0x81, 0xFF, 0x80, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xFF,
  0xFF, 0xDF, 0xE3, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0xFE, 0xFF, 0xFF, 0xC0, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x0F, 0x9F, 0xFE,
  0xFE, 0xF8, 0xE0, 0x1E, 0xE0, 0x1E, 0xE0, 0x3C, 0xE0, 0x78, 0xE0, 0x78,
  0xE0, 0xF0, 0xE1, 0xE0, 0xE1, 0xE0, 0xE3, 0xC0, 0xE7, 0x80, 0xE7, 0x80,
  0xEF, 0x00, 0xEF, 0x80, 0xFF, 0x80, 0xFB, 0xC0, 0xF3, 0xC0, 0xE1, 0xE0,
  0xE1, 0xE0, 0xE0, 0xF0, 0xE0, 0xF0, 0xE0, 0x78, 0xE0, 0x78, 0xE0, 0x3C,
  0xE0, 0x3C, 0xE0, 0x1E, 0xE0, 0x1F, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF,
  0xC0, 0x1F, 0xFB, 0x80, 0x3F, 0xF7, 0x00, 0xEF, 0xEE, 0x01, 0xDF, 0xCE,
  0x03, 0xBF, 0x9C, 0x0E, 0x7F, 0x38, 0x1C, 0xFE, 0x78, 0x39, 0xFC, 0x70,
  0xE3, 0xF8, 0xE1, 0xC7, 0xF1, 0xE3, 0x8F, 0xE1, 0xCF, 0x1F, 0xC3, 0x9C,
  0x3F, 0x87, 0x38, 0x7F, 0x07, 0x70, 0xFE, 0x0F, 0xC1, 0xFC, 0x1F, 0x83,
  0xF8, 0x3F, 0x07, 0xF0, 0x3C, 0x0F, 0xE0, 0x78, 0x1F, 0xC0, 0xF0, 0x3C,
  0xF0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xF0,
  0x1F, 0xB8, 0x0F, 0xDE, 0x07, 0xEF, 0x03, 0xF3, 0xC1, 0xF9, 0xE0, 0xFC,
  0x78, 0x7E, 0x3C, 0x3F, 0x0F, 0x1F, 0x87, 0x8F, 0xC1, 0xE7, 0xE0, 0xF3,
  0xF0, 0x3D, 0xF8, 0x1E, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x03, 0xC0, 0x03, 0xF8, 0x01, 0xFF,
  0xC0, 0x7F, 0xFC, 0x1F, 0x8F, 0x87, 0xC0, 0x78, 0xF0, 0x0F, 0x9E, 0x00,
  0xF7, 0x80, 0x1E, 0xF0, 0x01, 0xDE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3B, 0xC0, 0x0F, 0x3C, 0x01, 0xE7, 0x80, 0x3C, 0xF8, 0x0F,
  0x0F, 0x83, 0xE0, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0x00, 0xFE, 0x03,
  0xFF, 0x8F, 0xFF, 0x38, 0xFE, 0xE0, 0x7B, 0x80, 0xFE, 0x03, 0xF8, 0x0F,
  0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x1E, 0xE0, 0xFB, 0xFF, 0xCF, 0xFE,
  0x3F, 0xF0, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x03, 0xF8, 0x01, 0xFF,
  0xC0, 0x7F, 0xFC, 0x1F, 0x8F, 0xC7, 0xC0, 0x78, 0xF0, 0x0F, 0x9E, 0x00,
  0xF7, 0x80, 0x1E, 0xF0, 0x01, 0xDE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3B, 0xC0, 0x0F, 0x3C, 0x01, 0xE7, 0x80, 0x3C, 0xF8, 0x0F,
  0x0F, 0x83, 0xE0, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0xFF, 0x01, 0xFF, 0xC3, 0xFF, 0xC7, 0xFF, 0xCE, 0x07, 0x9C, 0x07, 0xB8,
  0x0F, 0x70, 0x1E, 0xE0, 0x3D, 0xC0, 0x7B, 0x80, 0xE7, 0x03, 0xCF, 0xFF,
  0x1F, 0xFC, 0x3F, 0xF0, 0x71, 0xE0, 0xE1, 0xE1, 0xC3, 0xC3, 0x83, 0xC7,
  0x07, 0x8E, 0x07, 0x9C, 0x0F, 0x38, 0x0F, 0x70, 0x1E, 0xE0, 0x1F, 0xC0,
  0x3C, 0x07, 0xF0, 0x7F, 0xF3, 0xFF, 0x9F, 0x9E, 0x78, 0x09, 0xE0, 0x07,
  0x00, 0x1C, 0x00, 0x78, 0x01, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x3F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3E, 0x00, 0xFE, 0x07, 0xBF, 0xFE, 0xFF, 0xF1, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1E, 0x78,
  0x3E, 0x7F, 0xFC, 0x3F, 0xF8, 0x1F, 0xF0, 0xF0, 0x03, 0xFC, 0x00, 0xF7,
  0x00, 0x3D, 0xE0, 0x0E, 0x78, 0x07, 0x9E, 0x01, 0xE3, 0x80, 0x78, 0xF0,
  0x1C, 0x3C, 0x0F, 0x07, 0x03, 0xC1, 0xC0, 0xE0, 0x78, 0x38, 0x1E, 0x1E,
  0x03, 0x87, 0x80, 0xE1, 0xC0, 0x3C, 0x70, 0x0F, 0x3C, 0x01, 0xCE, 0x00,
  0x73, 0x80, 0x1E, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0xF0, 0x0F, 0x00, 0x7F, 0x00, 0xF0,
  0x0F, 0x70, 0x0F, 0x00, 0xF7, 0x00, 0xF8, 0x0F, 0x78, 0x0F, 0x80, 0xE7,
  0x81, 0xF8, 0x0E, 0x78, 0x1F, 0x81, 0xE3, 0x81, 0xDC, 0x1E, 0x38, 0x1D,
  0xC1, 0xE3, 0xC3, 0xDC, 0x1C, 0x3C, 0x39, 0xC1, 0xC1, 0xC3, 0x9C, 0x3C,
  0x1C, 0x38, 0xE3, 0xC1, 0xE3, 0x8E, 0x3C, 0x1E, 0x70, 0xE3, 0x81, 0xE7,
  0x0E, 0x78, 0x0E, 0x70, 0xF7, 0x80, 0xE7, 0x07, 0x78, 0x0E, 0xF0, 0x77,
  0x00, 0xFE, 0x07, 0x70, 0x07, 0xE0, 0x77, 0x00, 0x7E, 0x03, 0xF0, 0x07,
  0xE0, 0x3F, 0x00, 0x7C, 0x03, 0xE0, 0x07, 0xC0, 0x3E, 0x00, 0x3C, 0x03,
  0xE0, 0x78, 0x07, 0xBC, 0x07, 0x8F, 0x03, 0xC7, 0x83, 0xC1, 0xC1, 0xE0,
  0xF1, 0xE0, 0x38, 0xF0, 0x1E, 0x70, 0x07, 0x78, 0x03, 0xF8, 0x00, 0xFC,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x0F, 0xE0, 0x07,
  0x78, 0x07, 0xBC, 0x03, 0x8F, 0x03, 0xC7, 0x81, 0xE1, 0xC1, 0xE0, 0xF0,
  0xF0, 0x38, 0xF0, 0x1E, 0x78, 0x0F, 0x78, 0x03, 0xC0, 0xF0, 0x07, 0xF8,
  0x07, 0x9E, 0x03, 0xCF, 0x01, 0xC3, 0xC1, 0xE1, 0xE0, 0xF0, 0x70, 0x70,
  0x3C, 0x78, 0x1E, 0x38, 0x07, 0x3C, 0x03, 0xDE, 0x00, 0xEE, 0x00, 0x7F,
  0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x3C,
  0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78,
  0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3,
  0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0xC3, 0x87, 0x0E, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0x80, 0x1E, 0x00,
  0x70, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x03,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0xC0, 0x0E,
  0x00, 0x78, 0x01, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x0E, 0x00, 0x78,
  0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0x80,
  0x03, 0x80, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x0E, 0xE0, 0x0E, 0x70,
  0x1E, 0x70, 0x1C, 0x38, 0x3C, 0x38, 0x38, 0x1C, 0x38, 0x1C, 0x70, 0x0E,
  0x70, 0x0E, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x78, 0x3C, 0x1C,
  0x0E, 0x07, 0x03, 0x80, 0xFF, 0xC3, 0xFF, 0x86, 0x1E, 0x00, 0x38, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x03, 0xFC, 0x7F, 0xF3, 0xFF, 0xDE, 0x0F, 0x70,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x1F, 0x70, 0x7D, 0xFF, 0xF7, 0xF9, 0xCF,
  0xC7, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0xF0, 0xF7, 0xF1, 0xFF, 0xF3, 0xF9, 0xF7, 0xC1, 0xEF,
  0x81, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFE, 0x07, 0x7E, 0x1E, 0xFF, 0xFD,
  0xEF, 0xF3, 0x8F, 0xC0, 0x07, 0xC1, 0xFF, 0x3F, 0xE7, 0xC6, 0x78, 0x0F,
  0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0x78, 0x27, 0xFE, 0x3F, 0xE1, 0xFE, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC3, 0xC7,
  0x3F, 0x9D, 0xFF, 0x77, 0xCF, 0xFC, 0x1F, 0xF0, 0x3F, 0xC0, 0xFE, 0x03,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0xC0,
  0xFF, 0x03, 0xDE, 0x1F, 0x7F, 0xFC, 0xFF, 0x71, 0xF9, 0xC0, 0x07, 0x80,
  0x7F, 0x83, 0xFF, 0x1E, 0x3C, 0x70, 0x7B, 0xC0, 0xEE, 0x03, 0xB8, 0x0E,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00,
  0x3C, 0x00, 0x78, 0x09, 0xFF, 0xE3, 0xFF, 0x83, 0xFC, 0x01, 0x80, 0x7F,
  0x0F, 0xE0, 0xFE, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x07, 0xFC,
  0xFF, 0xC1, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x0F, 0x00, 0xFE, 0x77, 0xFD, 0xDF, 0x3F, 0xF0, 0x7F,
  0xC0, 0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0xFF, 0x03, 0xFC, 0x0F, 0x78, 0x7D, 0xFF, 0xF3, 0xFD,
  0xC7, 0xE7, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x80, 0x79, 0xE7,
  0xE7, 0xFF, 0x1F, 0xF8, 0x07, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x78, 0xF7, 0xF3, 0xFF, 0xEF,
  0xE7, 0xFE, 0x0F, 0xF8, 0x3F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xC0, 0x6F, 0xFF, 0x60, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0C, 0x3C, 0x78, 0xF0,
  0xC0, 0x00, 0x00, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C,
  0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F,
  0xBF, 0xFB, 0xF3, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x3D, 0xE0, 0xF3, 0xC3,
  0xC7, 0x87, 0x0F, 0x1E, 0x1E, 0x78, 0x3D, 0xE0, 0x7B, 0x80, 0xFF, 0x81,
  0xFF, 0x83, 0xFF, 0x07, 0xCF, 0x0F, 0x1E, 0x1E, 0x1E, 0x3C, 0x3C, 0x78,
  0x3C, 0xF0, 0x79, 0xE0, 0x7B, 0xC0, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xE0, 0xF0,
  0xE7, 0xF1, 0xFC, 0xFF, 0xFB, 0xFE, 0xFC, 0xFF, 0x3E, 0xF8, 0x3E, 0x1E,
  0xF8, 0x3C, 0x0E, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F,
  0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F,
  0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F,
  0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0x01, 0xC3, 0x9F,
  0xCF, 0xFF, 0xBF, 0x9F, 0xF8, 0x3F, 0xE0, 0xFF, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0x07, 0x80, 0x3F, 0xC0,
  0xFF, 0xC3, 0xE7, 0xC7, 0x03, 0xDE, 0x07, 0xBC, 0x07, 0x70, 0x0E, 0xE0,
  0x1D, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xDC, 0x03, 0xBC, 0x0F,
  0x78, 0x1E, 0x78, 0x78, 0xFF, 0xF0, 0xFF, 0xC0, 0x7F, 0x00, 0x01, 0xE1,
  0xEF, 0xE3, 0xFF, 0xE7, 0xE3, 0xEF, 0x83, 0xDF, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03,
  0xFC, 0x07, 0xFC, 0x0E, 0xFC, 0x3D, 0xFF, 0xFB, 0xDF, 0xE7, 0x9F, 0x8F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0xFE, 0x77, 0xFD, 0xDF, 0x3F,
  0xF0, 0x7F, 0xC0, 0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x3F, 0x80, 0xFF, 0x03, 0xFC, 0x0F, 0x78, 0x7D, 0xFF,
  0xF3, 0xFD, 0xC7, 0xE7, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x01, 0xF9, 0xFF, 0x7F,
  0xFF, 0xFC, 0x3E, 0x0F, 0x83, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0x0F, 0x83, 0xFF,
  0x7F, 0xE7, 0x86, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x7E, 0x03, 0xF8,
  0x1F, 0xC0, 0x7E, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0xC0, 0xFF, 0xFE,
  0xFF, 0xC7, 0xF8, 0x18, 0x06, 0x03, 0x80, 0xE0, 0x38, 0x3F, 0xEF, 0xF8,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x3C, 0x0F, 0xF3, 0xFC, 0x7F, 0xF0, 0x1F, 0xC0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xF7, 0x03, 0xDE,
  0x1F, 0x7F, 0xFC, 0xFF, 0x71, 0xF9, 0xC0, 0xF0, 0x0E, 0xE0, 0x3D, 0xE0,
  0x7B, 0xC0, 0xE3, 0x83, 0xC7, 0x07, 0x8F, 0x0E, 0x1E, 0x1C, 0x1C, 0x78,
  0x38, 0xF0, 0x79, 0xC0, 0x73, 0x80, 0xEF, 0x01, 0xDC, 0x03, 0xF8, 0x03,
  0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x00, 0xF0, 0x3C, 0x0F, 0x70, 0x3E,
  0x0F, 0x78, 0x3E, 0x0F, 0x78, 0x7E, 0x0E, 0x78, 0x76, 0x0E, 0x38, 0x77,
  0x1E, 0x38, 0x77, 0x1E, 0x3C, 0xE7, 0x1C, 0x3C, 0xE7, 0x1C, 0x1C, 0xE3,
  0x3C, 0x1C, 0xE3, 0xBC, 0x1C, 0xE3, 0xB8, 0x1F, 0xC3, 0xB8, 0x0F, 0xC3,
  0xB8, 0x0F, 0xC1, 0xB8, 0x0F, 0xC1, 0xF0, 0x0F, 0x81, 0xF0, 0x07, 0x81,
  0xF0, 0x07, 0x81, 0xF0, 0x78, 0x1E, 0x78, 0x78, 0xF0, 0xE0, 0xE3, 0xC1,
  0xE7, 0x01, 0xDE, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x80, 0x7F, 0x00, 0xEF, 0x03, 0xCE, 0x07, 0x1E, 0x1E, 0x1C, 0x38, 0x3C,
  0xF0, 0x3B, 0xE0, 0x78, 0xF0, 0x0E, 0xE0, 0x3D, 0xE0, 0x7B, 0xC0, 0xE3,
  0x83, 0xC7, 0x07, 0x8F, 0x0E, 0x0E, 0x1C, 0x1C, 0x78, 0x3C, 0xF0, 0x39,
  0xC0, 0x73, 0x80, 0xEF, 0x01, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x07,
  0x80, 0x5F, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0x80, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x38, 0x0F, 0x01, 0xC0, 0x78,
  0x0E, 0x03, 0xC0, 0x70, 0x1E, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0xE0, 0x7C, 0x1F, 0x87, 0xC0, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x3C, 0x1F, 0x87, 0xC0, 0xF8, 0x0F,
  0xC0, 0x78, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x80, 0xF8, 0x0F, 0xC0, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x1F,
  0x03, 0xF0, 0x1F, 0x01, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1E, 0x01, 0xF0, 0x1F, 0x03, 0xE0, 0xF8, 0x3C,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x0F,
  0x03, 0xE1, 0xF8, 0x3E, 0x07, 0x00, 0x3E, 0x03, 0xFF, 0x8F, 0xFF, 0xFE,
  0x0F, 0xF8, 0x07, 0x00,
};

const GFXglyph NotoSans_Condensed_Medium36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 5, 26, 9, 2, -26 },
  { 18, 11, 10, 15, 2, -26 },
  { 32, 17, 26, 19, 1, -26 },
  { 88, 14, 29, 17, 2, -27 },
  { 139, 24, 26, 27, 1, -26 },
  { 217, 20, 26, 21, 1, -26 },
  { 282, 4, 10, 8, 2, -26 },
  { 287, 8, 32, 11, 2, -26 },
  { 319, 8, 32, 11, 1, -26 },
  { 351, 14, 13, 16, 1, -27 },
  { 374, 15, 17, 17, 1, -21 },
  { 406, 6, 9, 9, 1, -4 },
  { 413, 9, 3, 11, 1, -11 },
  { 417, 5, 5, 9, 2, -5 },
  { 421, 13, 26, 14, 0, -26 },
  { 464, 15, 26, 17, 1, -26 },
  { 513, 10, 26, 17, 2, -26 },
  { 546, 15, 26, 17, 1, -26 },
  { 595, 15, 26, 17, 1, -26 },
  { 644, 16, 26, 17, 1, -26 },
  { 696, 14, 26, 17, 2, -26 },
  { 742, 14, 26, 17, 2, -26 },
  { 788, 15, 26, 17, 1, -26 },
  { 837, 15, 26, 17, 1, -26 },
  { 886, 15, 26, 17, 1, -26 },
  { 935, 5, 20, 9, 2, -20 },
  { 948, 6, 25, 9, 1, -20 },
  { 967, 15, 17, 17, 1, -21 },
  { 999, 15, 10, 17, 1, -18 },
  { 1018, 15, 17, 17, 1, -21 },
  { 1050, 12, 26, 13, 0, -26 },
  { 1089, 23, 29, 27, 2, -26 },
  { 1173, 19, 26, 19, 0, -26 },
  { 1235, 15, 26, 19, 3, -26 },
  { 1284, 15, 26, 18, 2, -26 },
  { 1333, 16, 26, 21, 3, -26 },
  { 1385, 12, 26, 16, 3, -26 },
  { 1424, 12, 26, 16, 3, -26 },
  { 1463, 17, 26, 22, 2, -26 },
  { 1519, 16, 26, 22, 3, -26 },
  { 1571, 9, 26, 11, 1, -26 },
  { 1601, 8, 33, 9, -2, -26 },
  { 1634, 16, 26, 19, 3, -26 },
  { 1686, 12, 26, 15, 3, -26 },
  { 1725, 23, 26, 28, 3, -26 },
  { 1800, 17, 26, 23, 3, -26 },
  { 1856, 19, 26, 23, 2, -26 },
  { 1918, 14, 26, 18, 3, -26 },
  { 1964, 19, 32, 23, 2, -26 },
  { 2040, 15, 26, 19, 3, -26 },
  { 2089, 14, 26, 16, 1, -26 },
  { 2135, 16, 26, 16, 0, -26 },
  { 2187, 16, 26, 21, 3, -26 },
  { 2239, 18, 26, 18, 0, -26 },
  { 2298, 28, 26, 28, 0, -26 },
  { 2389, 17, 26, 17, 0, -26 },
  { 2445, 17, 26, 17, 0, -26 },
  { 2501, 14, 26, 16, 1, -26 },
  { 2547, 7, 32, 11, 3, -26 },
  { 2575, 13, 26, 14, 0, -26 },
  { 2618, 8, 32, 11, 1, -26 },
  { 2650, 16, 15, 18, 1, -26 },
  { 2680, 16, 2, 15, 0, 3 },
  { 2684, 8, 6, 10, 1, -28 },
  { 2690, 14, 20, 17, 1, -20 },
  { 2725, 15, 27, 19, 2, -27 },
  { 2776, 12, 20, 14, 2, -20 },
  { 2806, 14, 27, 19, 2, -27 },
  { 2854, 14, 20, 17, 2, -20 },
  { 2889, 12, 28, 11, 0, -28 },
  { 2931, 14, 29, 19, 2, -20 },
  { 2982, 14, 27, 19, 2, -27 },
  { 3030, 4, 27, 9, 2, -27 },
  { 3044, 7, 36, 8, -1, -27 },
  { 3076, 15, 27, 17, 2, -27 },
  { 3127, 4, 27, 8, 2, -27 },
  { 3141, 24, 20, 28, 2, -20 },
  { 3201, 14, 20, 19, 2, -20 },
  { 3236, 15, 20, 18, 2, -20 },
  { 3274, 15, 29, 19, 2, -20 },
  { 3329, 14, 29, 19, 2, -20 },
  { 3380, 10, 20, 13, 2, -20 },
  { 3405, 12, 20, 14, 1, -20 },
  { 3435, 10, 24, 11, 1, -24 },
  { 3465, 14, 19, 19, 2, -19 },
  { 3499, 15, 19, 16, 0, -19 },
  { 3535, 24, 19, 25, 0, -19 },
  { 3592, 15, 19, 16, 0, -19 },
  { 3628, 15, 28, 16, 0, -19 },
  { 3681, 11, 19, 13, 1, -19 },
  { 3708, 11, 32, 13, 1, -26 },
  { 3752, 3, 36, 16, 7, -27 },
  { 3766, 11, 32, 13, 1, -26 },
  { 3810, 15, 5, 17, 1, -15 },
};

const GFXfont NotoSans_Condensed_Medium36pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Medium36pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Medium36pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _NOTOSANS_CONDENSED_MEDIUM36PT7B_H_
