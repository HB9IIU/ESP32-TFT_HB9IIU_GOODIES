#ifndef _NOTOSANS_CONDENSED_MEDIUM66PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUM66PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Medium.ttf
// Size: 66pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Medium66pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F,
  0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x18, 0x7E, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x7E,
  0x1C, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0,
  0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0x80,
  0xF9, 0xF0, 0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0x7C, 0xF8, 0x0F, 0x9F, 0x01,
  0xF3, 0xE0, 0x3E, 0x7C, 0x07, 0xC0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x1F,
  0x01, 0xF0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x1F,
  0x03, 0xE0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x3E,
  0x03, 0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3E,
  0x03, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x3F, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x7C,
  0x0F, 0x80, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0xF8,
  0x0F, 0x80, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0xF8,
  0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xF0, 0x3E, 0x00, 0x03, 0xE0,
  0x3E, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x03, 0xE0,
  0x3E, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x03, 0xE0,
  0x7C, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x07, 0xC0,
  0x7C, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x07, 0xC0,
  0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xF1, 0xFE, 0x78, 0x7C, 0x7F, 0x1E, 0x02, 0x3F, 0x87, 0x80, 0x0F,
  0xC1, 0xE0, 0x03, 0xF0, 0x78, 0x00, 0xFC, 0x1E, 0x00, 0x3F, 0x07, 0x80,
  0x0F, 0xE1, 0xE0, 0x03, 0xF8, 0x78, 0x00, 0x7F, 0x1E, 0x00, 0x1F, 0xF7,
  0x80, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x01,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFE,
  0x00, 0x07, 0xFF, 0xC0, 0x01, 0xEF, 0xF8, 0x00, 0x78, 0xFE, 0x00, 0x1E,
  0x1F, 0x80, 0x07, 0x87, 0xF0, 0x01, 0xE0, 0xFC, 0x00, 0x78, 0x3F, 0x00,
  0x1E, 0x0F, 0xC0, 0x07, 0x87, 0xF8, 0x01, 0xE1, 0xFB, 0x80, 0x78, 0xFE,
  0xFC, 0x1E, 0x7F, 0xBF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0xF0, 0x00,
  0x3E, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xF0,
  0x00, 0xFC, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x0F, 0xC0, 0x07,
  0xE0, 0xF8, 0x01, 0xF0, 0x00, 0xF8, 0x1F, 0x00, 0x7E, 0x00, 0x1F, 0x03,
  0xF0, 0x0F, 0x80, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x00, 0x7C, 0x07, 0xC0,
  0x7E, 0x00, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x01, 0xF0, 0x1F, 0x03, 0xF0,
  0x00, 0x3E, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0x00,
  0xF8, 0x0F, 0x83, 0xE0, 0x00, 0x1F, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xE0,
  0x3E, 0x1F, 0x80, 0x00, 0x7C, 0x07, 0xC3, 0xE0, 0x7C, 0x0F, 0x81, 0xF8,
  0xFC, 0x3F, 0xE1, 0xF0, 0x3F, 0x1F, 0x0F, 0xFE, 0x3F, 0x07, 0xC3, 0xE3,
  0xFF, 0xE3, 0xE0, 0xF8, 0xF8, 0x7F, 0xFC, 0x7E, 0x3F, 0x1F, 0x1F, 0x8F,
  0xC7, 0xFF, 0xC7, 0xE3, 0xE0, 0xF8, 0xFF, 0xF0, 0xF8, 0x7C, 0x1F, 0x8F,
  0xFE, 0x1F, 0x1F, 0x81, 0xF0, 0xFF, 0x87, 0xC3, 0xE0, 0x3E, 0x07, 0xC0,
  0xF8, 0x7C, 0x07, 0xC0, 0x00, 0x3F, 0x0F, 0x80, 0xF8, 0x00, 0x07, 0xC1,
  0xF0, 0x1F, 0x00, 0x01, 0xF8, 0x3E, 0x03, 0xE0, 0x00, 0x3E, 0x07, 0xC0,
  0x7C, 0x00, 0x07, 0xC0, 0xF8, 0x0F, 0x80, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x00, 0x3E, 0x03, 0xE0, 0x3E, 0x00, 0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0x01,
  0xF0, 0x0F, 0x80, 0xF8, 0x00, 0x7E, 0x01, 0xF8, 0x1F, 0x00, 0x0F, 0x80,
  0x1F, 0x07, 0xE0, 0x01, 0xF0, 0x03, 0xE0, 0xFC, 0x00, 0x7E, 0x00, 0x7C,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC7, 0xE0, 0x03, 0xF0, 0x00, 0xFF, 0xF8,
  0x00, 0x7C, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xC0, 0x03,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x7F, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00,
  0xFC, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x00, 0xFE, 0x07, 0xE0,
  0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0xFC, 0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x01, 0xFC, 0x1F, 0xFF, 0xE0, 0x1F, 0xC1,
  0xFC, 0xFF, 0x01, 0xF8, 0x3F, 0x87, 0xF8, 0x3F, 0x87, 0xF8, 0x3F, 0x83,
  0xF8, 0x7F, 0x01, 0xFC, 0x3F, 0x07, 0xF0, 0x1F, 0xE7, 0xF0, 0xFE, 0x00,
  0xFF, 0x7F, 0x0F, 0xE0, 0x07, 0xF7, 0xE0, 0xFE, 0x00, 0x3F, 0xFE, 0x0F,
  0xE0, 0x03, 0xFF, 0xE0, 0xFE, 0x00, 0x1F, 0xFC, 0x0F, 0xE0, 0x00, 0xFF,
  0x80, 0xFE, 0x00, 0x07, 0xF8, 0x07, 0xF0, 0x00, 0xFF, 0x80, 0x7F, 0x00,
  0x1F, 0xFC, 0x07, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xE1, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x7F, 0x80, 0xFF, 0xFF, 0xC3,
  0xFC, 0x07, 0xFF, 0xF8, 0x1F, 0xE0, 0x1F, 0xFE, 0x01, 0xFF, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFD, 0xF9,
  0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0x00, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F,
  0x80, 0x7F, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8,
  0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF0,
  0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xFC, 0x03, 0xF0, 0x07,
  0xE0, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xE0, 0x01, 0xC0, 0xF8, 0x0E, 0x7E, 0x1E, 0x1F, 0x9F, 0xF7, 0xBF,
  0xE7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0xFC, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x0F, 0xE1, 0xFC,
  0x07, 0xF0, 0x3F, 0x80, 0xFC, 0x0F, 0xC0, 0x0E, 0x01, 0xC0, 0x01, 0x80,
  0x40, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xE3, 0xF8, 0xFE, 0x3F, 0x0F, 0xC3,
  0xF0, 0xF8, 0x7E, 0x1F, 0x87, 0xC1, 0xF0, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x08, 0x7E, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x18, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x3F,
  0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x01,
  0xFE, 0x1F, 0xE0, 0xFF, 0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x1F, 0xC0, 0x1F,
  0xC7, 0xF0, 0x03, 0xF1, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x9F, 0x80,
  0x0F, 0xEF, 0xE0, 0x01, 0xFB, 0xF8, 0x00, 0x7E, 0xFE, 0x00, 0x1F, 0xBF,
  0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F,
  0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00,
  0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC,
  0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F,
  0xFE, 0x00, 0x1F, 0xBF, 0x80, 0x07, 0xEF, 0xE0, 0x01, 0xF9, 0xF8, 0x00,
  0xFE, 0x7E, 0x00, 0x3F, 0x9F, 0xC0, 0x0F, 0xE7, 0xF0, 0x03, 0xF1, 0xFC,
  0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x0F, 0xF0, 0x3F, 0x81, 0xFE, 0x3F, 0xE0,
  0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x0F,
  0xF0, 0x07, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xFC,
  0x3F, 0xFF, 0x1F, 0xFF, 0xCF, 0xF7, 0xFF, 0xF9, 0xFD, 0xFC, 0x7F, 0x3C,
  0x1F, 0xC6, 0x07, 0xF1, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFE, 0x1F, 0xE0, 0x7F, 0xC1, 0xF0, 0x03, 0xFC, 0x1C, 0x00, 0x3F,
  0x81, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x87, 0xE0, 0x1F, 0xE1, 0xE0,
  0x03, 0xFC, 0x30, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x80, 0x00,
  0x7F, 0xB0, 0x00, 0x3F, 0xCF, 0xC0, 0x7F, 0xF3, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x07, 0xCF,
  0xC0, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x07, 0xE3, 0xF0,
  0x00, 0x1F, 0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xE0, 0xFC, 0x00,
  0x1F, 0x83, 0xF0, 0x00, 0x7C, 0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x0F,
  0x80, 0xFC, 0x00, 0x7E, 0x03, 0xF0, 0x01, 0xF0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xF0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x3E, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0xFC, 0x07, 0xC0, 0x03, 0xF0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xE0, 0x7E, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF2, 0x00, 0x03, 0xFC, 0xE0,
  0x01, 0xFF, 0x3F, 0x01, 0xFF, 0x8F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x07,
  0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xC0, 0x20,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xE0, 0xFC, 0x03, 0xF0, 0xFF, 0xC0, 0xFC, 0xFF, 0xFC, 0x3F, 0x3F, 0xFF,
  0x8F, 0xDF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0xFF, 0xC0, 0xFF, 0x3F, 0xE0,
  0x0F, 0xEF, 0xF0, 0x03, 0xFB, 0xF8, 0x00, 0x7E, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F,
  0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0x7E, 0x00,
  0x1F, 0xDF, 0x80, 0x07, 0xF7, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0xFE, 0x3F,
  0x80, 0x3F, 0x8F, 0xF0, 0x1F, 0xC1, 0xFE, 0x1F, 0xF0, 0x3F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0x07, 0xF0, 0x1F, 0xE1, 0xFC, 0x01, 0xFC, 0x3F,
  0x80, 0x1F, 0xC7, 0xE0, 0x03, 0xF8, 0xFC, 0x00, 0x7F, 0x1F, 0x80, 0x07,
  0xE3, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x8F, 0xC0, 0x07, 0xF1, 0xFC,
  0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x83, 0xF8, 0x0F, 0xE0, 0x3F, 0x83, 0xFC,
  0x07, 0xFC, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x7F,
  0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80,
  0x3F, 0xFF, 0xF8, 0x07, 0xF8, 0xFF, 0x81, 0xFC, 0x0F, 0xF8, 0x7F, 0x00,
  0x7F, 0x0F, 0xC0, 0x0F, 0xF3, 0xF8, 0x00, 0xFE, 0x7E, 0x00, 0x0F, 0xEF,
  0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x7F, 0xFC, 0x00, 0x0F, 0xDF, 0x80, 0x03, 0xFB, 0xF0, 0x00, 0x7F, 0x7F,
  0x00, 0x0F, 0xCF, 0xF0, 0x03, 0xF8, 0xFF, 0x01, 0xFF, 0x1F, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFC, 0x07, 0xF8, 0x7F, 0xC1, 0xFE, 0x03, 0xF8, 0x3F, 0x80, 0x3F,
  0x8F, 0xE0, 0x07, 0xF1, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xE7, 0xE0,
  0x01, 0xFC, 0xFC, 0x00, 0x1F, 0xBF, 0x80, 0x03, 0xF7, 0xF0, 0x00, 0x7E,
  0xFE, 0x00, 0x0F, 0xDF, 0xC0, 0x01, 0xFD, 0xF8, 0x00, 0x3F, 0xBF, 0x00,
  0x07, 0xF7, 0xF0, 0x01, 0xFE, 0xFE, 0x00, 0x3F, 0xDF, 0xC0, 0x0F, 0xF9,
  0xFC, 0x01, 0xFF, 0x3F, 0xC0, 0xFF, 0xE7, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xBF, 0x07, 0xFF, 0xF7, 0xE0, 0x7F, 0xFC, 0xFC, 0x07, 0xFF, 0x1F, 0x80,
  0x1F, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x40, 0x3F, 0xF0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3C, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x7E, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7E, 0x18, 0x0F, 0x07, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF,
  0xF3, 0xFC, 0x7F, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xE3,
  0xF8, 0xFE, 0x3F, 0x0F, 0xC3, 0xF1, 0xF8, 0x7E, 0x1F, 0x87, 0xC1, 0xF0,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00,
  0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x08, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00,
  0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0,
  0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x3F, 0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE7, 0xE0, 0xFF, 0x9C, 0x00, 0xFE, 0x20,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFC,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xE0,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x3F, 0x00, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x0F, 0xFF, 0x83,
  0xE1, 0xF8, 0x07, 0xFF, 0xF0, 0x7E, 0x3E, 0x01, 0xFF, 0xFE, 0x07, 0xC7,
  0xC0, 0x7F, 0xFF, 0xC0, 0xF9, 0xF8, 0x0F, 0xC1, 0xF8, 0x1F, 0x3E, 0x03,
  0xF0, 0x3F, 0x03, 0xE7, 0xC0, 0x7C, 0x07, 0xE0, 0x7E, 0xF8, 0x1F, 0x80,
  0xFC, 0x07, 0xDF, 0x03, 0xE0, 0x1F, 0x80, 0xFF, 0xE0, 0x7C, 0x03, 0xF0,
  0x1F, 0xFC, 0x0F, 0x80, 0x7E, 0x03, 0xFF, 0x03, 0xF0, 0x0F, 0x80, 0x7F,
  0xE0, 0x7E, 0x01, 0xF0, 0x0F, 0xFC, 0x0F, 0xC0, 0x3E, 0x01, 0xFF, 0x81,
  0xF8, 0x07, 0xC0, 0x7D, 0xF0, 0x3F, 0x00, 0xF8, 0x0F, 0xBE, 0x07, 0xE0,
  0x1F, 0x01, 0xF7, 0xC0, 0x7C, 0x07, 0xE0, 0x3E, 0xF8, 0x0F, 0x80, 0xFC,
  0x07, 0xDF, 0x81, 0xF0, 0x1F, 0x81, 0xF3, 0xF0, 0x3F, 0x07, 0xF8, 0x3E,
  0x3E, 0x03, 0xF0, 0xEF, 0x0F, 0xC7, 0xC0, 0x7F, 0xFD, 0xFF, 0xF0, 0xF8,
  0x07, 0xFF, 0x1F, 0xFC, 0x1F, 0x80, 0x7F, 0xE1, 0xFF, 0x01, 0xF0, 0x07,
  0xF8, 0x3F, 0xC0, 0x3F, 0x00, 0x18, 0x00, 0x40, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x20, 0x00, 0x1F, 0xE0, 0x00, 0x18, 0x00, 0x01, 0xFF,
  0x80, 0x3F, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x03,
  0xF7, 0xE0, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x1F, 0x9F, 0xC0, 0x00,
  0x03, 0xF1, 0xF8, 0x00, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0x1F, 0xC7, 0xE0,
  0x00, 0x03, 0xF0, 0xFE, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x1F, 0xC1,
  0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x7E, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x7E, 0x01, 0xFC, 0x00,
  0x0F, 0xC0, 0x3F, 0x80, 0x03, 0xF8, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x0F, 0xC0, 0x0F, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x3F, 0x80, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x3F, 0x80, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xC1, 0xFC, 0x00,
  0x01, 0xFC, 0x3F, 0x80, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x07, 0xF1, 0xFC,
  0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x01, 0xFD,
  0xFE, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x07, 0xF8, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0xFE, 0x00, 0x7F, 0xCF, 0xE0, 0x03,
  0xFC, 0xFE, 0x00, 0x1F, 0xCF, 0xE0, 0x01, 0xFE, 0xFE, 0x00, 0x0F, 0xEF,
  0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFE, 0xFE, 0x00,
  0x0F, 0xCF, 0xE0, 0x01, 0xFC, 0xFE, 0x00, 0x1F, 0xCF, 0xE0, 0x03, 0xF8,
  0xFE, 0x00, 0x7F, 0x8F, 0xE0, 0x3F, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0x0F, 0xE0, 0x1F, 0xF8, 0xFE, 0x00, 0x3F, 0xCF, 0xE0, 0x01, 0xFE, 0xFE,
  0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFE, 0xFE, 0x00,
  0x1F, 0xEF, 0xE0, 0x01, 0xFE, 0xFE, 0x00, 0x7F, 0xCF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xFC, 0x0F, 0x80, 0xFF, 0x80, 0x0C, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0xE0, 0x03, 0x01, 0xFF, 0xE0, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xF0, 0x3F, 0x80, 0x3F, 0xF0, 0x7F, 0x00, 0x1F, 0xF0, 0xFE,
  0x00, 0x1F, 0xF1, 0xFC, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x1F, 0xC7, 0xF0,
  0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x7F, 0x3F, 0x80,
  0x00, 0xFF, 0x7F, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x01, 0xFD, 0xFC, 0x00,
  0x03, 0xFB, 0xF8, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x0F, 0xEF, 0xE0, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07,
  0xF7, 0xF0, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x3F,
  0xBF, 0x80, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x03, 0xF9,
  0xFC, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x3F, 0xCF,
  0xE0, 0x00, 0xFF, 0x1F, 0xC0, 0x01, 0xFE, 0x3F, 0x80, 0x07, 0xF8, 0x7F,
  0x00, 0x3F, 0xE0, 0xFE, 0x01, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFB, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFE, 0x03, 0xF8, 0x0F, 0xFC, 0x00, 0x3C,
  0x0F, 0xF8, 0x00, 0x04, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xEF, 0xE0, 0x03, 0xFF, 0xF7, 0xF0,
  0x01, 0xFF, 0xFB, 0xF8, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0xFE, 0xFE,
  0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0x1F, 0xCF,
  0xE0, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x03, 0xF8,
  0xFE, 0x00, 0x01, 0xFC, 0x7F, 0x80, 0x00, 0xFE, 0x3F, 0xE0, 0x00, 0x7F,
  0x0F, 0xF8, 0x00, 0x3F, 0x83, 0xFE, 0x00, 0x1F, 0xC1, 0xFF, 0xE0, 0x7F,
  0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFC, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x3F,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x83, 0xFE, 0xFF, 0xFC, 0xFF,
  0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0x7F, 0x80, 0xFE, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x7F, 0xBF, 0x80, 0x03, 0xF9, 0xFC, 0x00, 0x3F, 0xCF,
  0xE0, 0x03, 0xFC, 0x7F, 0x00, 0x1F, 0xC3, 0xF8, 0x01, 0xFE, 0x1F, 0xC0,
  0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xF0, 0x3F, 0x80, 0x7F,
  0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x80, 0x7F, 0x03, 0xF8, 0x03,
  0xF8, 0x3F, 0x80, 0x1F, 0xC3, 0xFC, 0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xF1,
  0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xFC, 0xFE, 0x00, 0x0F, 0xEF, 0xE0,
  0x00, 0x7F, 0x7F, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xF7, 0xF0, 0x01, 0xFF,
  0x3F, 0xC0, 0x0F, 0xF0, 0xFE, 0x00, 0x7F, 0x03, 0xF8, 0x03, 0xF8, 0x1F,
  0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xE0,
  0x3F, 0x80, 0x7F, 0x81, 0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x0F, 0xF0, 0x7F,
  0x00, 0x3F, 0x83, 0xF8, 0x01, 0xFE, 0x1F, 0xC0, 0x07, 0xF0, 0xFE, 0x00,
  0x3F, 0xC7, 0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x07, 0xF9, 0xFC, 0x00, 0x1F,
  0xCF, 0xE0, 0x00, 0xFF, 0x7F, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xE0,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x7E, 0x00,
  0x00, 0xFB, 0xFF, 0xDF, 0x80, 0x00, 0x7E, 0xFF, 0xF7, 0xE0, 0x00, 0x1F,
  0xBF, 0xFC, 0xF8, 0x00, 0x07, 0xCF, 0xFF, 0x3F, 0x00, 0x03, 0xF3, 0xFF,
  0xCF, 0xC0, 0x00, 0xFC, 0xFF, 0xF3, 0xF0, 0x00, 0x3E, 0x7F, 0xFC, 0x7E,
  0x00, 0x1F, 0x9F, 0xFF, 0x1F, 0x80, 0x07, 0xE7, 0xFF, 0xC7, 0xE0, 0x01,
  0xF1, 0xFF, 0xF0, 0xFC, 0x00, 0xFC, 0x7F, 0xFC, 0x3F, 0x00, 0x3F, 0x1F,
  0xFF, 0x0F, 0xC0, 0x0F, 0xC7, 0xFF, 0xC1, 0xF0, 0x03, 0xE1, 0xFF, 0xF0,
  0x7E, 0x01, 0xF8, 0x7F, 0xFC, 0x1F, 0x80, 0x7E, 0x1F, 0xFF, 0x07, 0xE0,
  0x1F, 0x07, 0xFF, 0xC0, 0xFC, 0x0F, 0xC1, 0xFF, 0xF0, 0x3F, 0x03, 0xF0,
  0x7F, 0xFC, 0x0F, 0xC0, 0xF8, 0x1F, 0xFF, 0x01, 0xF8, 0x7E, 0x07, 0xFF,
  0xC0, 0x7E, 0x1F, 0x81, 0xFF, 0xF0, 0x1F, 0x87, 0xC0, 0x7F, 0xFC, 0x03,
  0xF3, 0xF0, 0x1F, 0xFF, 0x00, 0xFC, 0xFC, 0x07, 0xFF, 0xC0, 0x3F, 0x3F,
  0x01, 0xFF, 0xF0, 0x0F, 0xCF, 0x80, 0x7F, 0xFC, 0x01, 0xFF, 0xE0, 0x1F,
  0xFF, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xF0,
  0x03, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x3F,
  0xE0, 0x07, 0xFF, 0xC0, 0x07, 0xF8, 0x01, 0xFF, 0xF0, 0x01, 0xFE, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xFF,
  0xC0, 0x03, 0xF0, 0x01, 0xFC, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFD, 0xF8, 0x00,
  0x3F, 0xFD, 0xFC, 0x00, 0x3F, 0xFC, 0xFC, 0x00, 0x3F, 0xFC, 0xFE, 0x00,
  0x3F, 0xFC, 0x7E, 0x00, 0x3F, 0xFC, 0x7F, 0x00, 0x3F, 0xFC, 0x3F, 0x00,
  0x3F, 0xFC, 0x3F, 0x80, 0x3F, 0xFC, 0x3F, 0x80, 0x3F, 0xFC, 0x1F, 0xC0,
  0x3F, 0xFC, 0x1F, 0xC0, 0x3F, 0xFC, 0x0F, 0xE0, 0x3F, 0xFC, 0x0F, 0xE0,
  0x3F, 0xFC, 0x07, 0xF0, 0x3F, 0xFC, 0x07, 0xF0, 0x3F, 0xFC, 0x03, 0xF8,
  0x3F, 0xFC, 0x03, 0xF8, 0x3F, 0xFC, 0x01, 0xFC, 0x3F, 0xFC, 0x01, 0xFC,
  0x3F, 0xFC, 0x00, 0xFE, 0x3F, 0xFC, 0x00, 0xFE, 0x3F, 0xFC, 0x00, 0x7F,
  0x3F, 0xFC, 0x00, 0x7F, 0x3F, 0xFC, 0x00, 0x3F, 0xBF, 0xFC, 0x00, 0x3F,
  0xBF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0x83, 0xFF, 0x80, 0x7F, 0xC0, 0x0F, 0xF0,
  0x1F, 0xF0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x01,
  0xFE, 0x1F, 0xE0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x03, 0xFC, 0x7F, 0x00,
  0x00, 0x3F, 0x9F, 0xE0, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x00, 0xFE, 0x7F,
  0x00, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0x3F,
  0xBF, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x1F,
  0xDF, 0xC0, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00,
  0x1F, 0xCF, 0xE0, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x00, 0x7F, 0x1F, 0xC0,
  0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x03, 0xF8, 0x7F, 0x80, 0x00, 0x7F, 0x07,
  0xF0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x03, 0xF8, 0x0F, 0xF0, 0x00, 0xFF,
  0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xFC, 0x3F, 0xF8, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xE8, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xCF, 0xE0, 0x1F, 0xF3, 0xF8,
  0x01, 0xFE, 0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x0F, 0xEF, 0xE0, 0x03, 0xFF,
  0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01,
  0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0,
  0x03, 0xFB, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x7F, 0xBF, 0x80, 0x3F, 0xCF,
  0xE0, 0x1F, 0xF3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0x83, 0xFF, 0x80, 0x7F, 0xC0, 0x0F, 0xF0, 0x1F, 0xF0, 0x00, 0xFF,
  0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00,
  0x1F, 0xC3, 0xF8, 0x00, 0x03, 0xFC, 0x7F, 0x00, 0x00, 0x3F, 0x9F, 0xE0,
  0x00, 0x07, 0xF3, 0xF8, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x1F, 0xEF,
  0xE0, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xF7,
  0xF0, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x03,
  0xFB, 0xF8, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x1F, 0xCF, 0xE0, 0x00,
  0x03, 0xF9, 0xFE, 0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x0F, 0xE3, 0xF8,
  0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x1F, 0xE0,
  0xFF, 0x00, 0x03, 0xF8, 0x0F, 0xF0, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x7F,
  0xC0, 0x1F, 0xFC, 0x3F, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0x83, 0xF8, 0x07, 0xFE, 0x1F, 0xC0, 0x0F, 0xF0, 0xFE, 0x00, 0x3F,
  0x87, 0xF0, 0x01, 0xFE, 0x3F, 0x80, 0x07, 0xF1, 0xFC, 0x00, 0x3F, 0x8F,
  0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x7F, 0x1F, 0xC0,
  0x03, 0xF8, 0xFE, 0x00, 0x1F, 0xC7, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x0F,
  0xE1, 0xFC, 0x00, 0xFF, 0x0F, 0xE0, 0x0F, 0xF0, 0x7F, 0x00, 0xFF, 0x83,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xE0, 0x7E,
  0x00, 0x7F, 0x03, 0xF8, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x00,
  0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x81, 0xFC,
  0x01, 0xFC, 0x0F, 0xE0, 0x0F, 0xF0, 0x7F, 0x00, 0x3F, 0x83, 0xF8, 0x01,
  0xFE, 0x1F, 0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0xC7, 0xF0, 0x00, 0xFE,
  0x3F, 0x80, 0x07, 0xF9, 0xFC, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0xFF, 0x7F,
  0x00, 0x03, 0xFB, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xF1, 0xFF, 0xC7, 0xF8, 0xFF, 0x00, 0x38, 0x7F, 0x00, 0x04, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF,
  0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0xC0, 0x00, 0xFF, 0x78, 0x00, 0xFF, 0x3F, 0xE3, 0xFF, 0x9F, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x1F, 0xBF, 0x80, 0x00, 0xFE, 0xFE, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x0F,
  0xE7, 0xF0, 0x00, 0x7F, 0x9F, 0xE0, 0x01, 0xFC, 0x3F, 0xC0, 0x0F, 0xF0,
  0xFF, 0xE1, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01,
  0xD0, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xDF, 0x80,
  0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x07, 0xF1, 0xF8,
  0x00, 0x03, 0xF8, 0xFE, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0xFC, 0x3F,
  0x80, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x3F, 0x83,
  0xF8, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x0F, 0xE0,
  0x3F, 0x80, 0x07, 0xE0, 0x1F, 0xC0, 0x07, 0xF0, 0x07, 0xE0, 0x03, 0xF8,
  0x03, 0xF0, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0x3F, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x0F, 0xE0, 0x1F,
  0x80, 0x07, 0xF0, 0x1F, 0xC0, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0xFC, 0x07,
  0xE0, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x0F, 0xC1,
  0xFC, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x00, 0xFC,
  0x7F, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x0F,
  0xCF, 0xC0, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x01,
  0xFB, 0xF0, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x7E, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF7,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7E, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xE7, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFE, 0x3F, 0x00, 0x07, 0xFE, 0x00,
  0x0F, 0xE3, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFC, 0x3F, 0x80, 0x07, 0xFE,
  0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x07,
  0xFF, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFC, 0x1F, 0xC0,
  0x0F, 0xDF, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0xF9, 0xF0, 0x03, 0xF8, 0x1F,
  0xC0, 0x0F, 0x9F, 0x80, 0x3F, 0x80, 0xFC, 0x01, 0xF9, 0xF8, 0x03, 0xF8,
  0x0F, 0xC0, 0x1F, 0x9F, 0x80, 0x3F, 0x00, 0xFE, 0x01, 0xF9, 0xF8, 0x03,
  0xF0, 0x0F, 0xE0, 0x1F, 0x0F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xF0, 0xFC,
  0x07, 0xF0, 0x07, 0xE0, 0x3F, 0x0F, 0xC0, 0x7F, 0x00, 0x7E, 0x03, 0xF0,
  0xFC, 0x07, 0xE0, 0x07, 0xF0, 0x3F, 0x07, 0xC0, 0xFE, 0x00, 0x7F, 0x03,
  0xE0, 0x7E, 0x0F, 0xE0, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0xFE, 0x00, 0x3F,
  0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0xFC, 0x00,
  0x3F, 0x87, 0xC0, 0x3E, 0x1F, 0xC0, 0x03, 0xF8, 0xFC, 0x03, 0xF1, 0xFC,
  0x00, 0x1F, 0x8F, 0xC0, 0x3F, 0x1F, 0xC0, 0x01, 0xF8, 0xFC, 0x03, 0xF1,
  0xF8, 0x00, 0x1F, 0x8F, 0xC0, 0x1F, 0x1F, 0x80, 0x01, 0xFC, 0xF8, 0x01,
  0xF3, 0xF8, 0x00, 0x0F, 0xCF, 0x80, 0x1F, 0xBF, 0x80, 0x00, 0xFD, 0xF8,
  0x01, 0xFB, 0xF0, 0x00, 0x0F, 0xDF, 0x80, 0x1F, 0xBF, 0x00, 0x00, 0xFD,
  0xF0, 0x00, 0xFB, 0xF0, 0x00, 0x0F, 0xDF, 0x00, 0x0F, 0xBF, 0x00, 0x00,
  0x7D, 0xF0, 0x00, 0xFB, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x01, 0xFC, 0x7F, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xE0, 0xFE, 0x00,
  0x1F, 0xC0, 0xFE, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0xFE, 0x01, 0xF8, 0x03,
  0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xC0, 0x07, 0xF0, 0x3F,
  0x80, 0x0F, 0xE0, 0x7F, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x1F, 0xC3, 0xF8,
  0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x3F, 0x3F, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0x7F,
  0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xE0,
  0x7E, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x07,
  0xF0, 0x3F, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x1F,
  0xE3, 0xF8, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F,
  0x80, 0xFE, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x07,
  0xF3, 0xFC, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x7E,
  0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xF8, 0x0F, 0xC0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x80, 0xFE, 0x00,
  0x7F, 0x01, 0xFC, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x01,
  0xFC, 0x1F, 0x80, 0x01, 0xFC, 0x7F, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x03,
  0xF1, 0xF8, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x01, 0xF3, 0xF0,
  0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x3F, 0x1F, 0x80, 0x01, 0xF8, 0x3E, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x03,
  0xE0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xFC, 0x03, 0xF0,
  0x01, 0xF8, 0x0F, 0x80, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xC1, 0xF8, 0x00,
  0x3F, 0x0F, 0xC0, 0x00, 0x7E, 0x3F, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x07, 0xF8, 0x1F,
  0xC0, 0x7F, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3E, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x3E, 0x07, 0xF8, 0x18, 0x01, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x1F,
  0xFE, 0x01, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xE7, 0xFC, 0x07, 0xF7, 0xF8, 0x03, 0xFB, 0xF8, 0x01, 0xFD, 0xFC,
  0x00, 0xFE, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF,
  0x80, 0x0F, 0xFF, 0xC0, 0x0F, 0xF7, 0xE0, 0x07, 0xFB, 0xF8, 0x07, 0xFD,
  0xFE, 0x07, 0xFE, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xDF, 0x8F, 0xFF, 0xCF,
  0xC3, 0xFF, 0xC3, 0xE0, 0xFF, 0xC1, 0xF0, 0x0E, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x83, 0xFC,
  0x07, 0xF1, 0xFF, 0xC0, 0xFE, 0x7F, 0xFE, 0x1F, 0xDF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFC, 0xFF, 0xCF, 0xFC, 0x07, 0xF9, 0xFF, 0x00, 0x7F,
  0xBF, 0xE0, 0x07, 0xF7, 0xF8, 0x00, 0xFE, 0xFF, 0x00, 0x0F, 0xFF, 0xE0,
  0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0x00, 0x0F, 0xDF, 0xE0, 0x03, 0xFB, 0xFE, 0x00, 0x7F, 0x7F,
  0xE0, 0x1F, 0xCF, 0xFE, 0x07, 0xF9, 0xFF, 0xFF, 0xFE, 0x3F, 0x3F, 0xFF,
  0xC7, 0xE7, 0xFF, 0xF0, 0xFC, 0x7F, 0xFC, 0x1F, 0x83, 0xFE, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x7F, 0xE7, 0xC3, 0xFC, 0x01, 0x0F, 0xE0,
  0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x23, 0xFE, 0x03, 0x87, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xE0, 0x3F, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x7F, 0x83, 0xF8,
  0x1F, 0xFC, 0x7F, 0x07, 0xFF, 0xCF, 0xE1, 0xFF, 0xFD, 0xFC, 0x7F, 0xFF,
  0xFF, 0x9F, 0xF8, 0xFF, 0xF3, 0xFC, 0x07, 0xFE, 0xFF, 0x00, 0x7F, 0xDF,
  0xC0, 0x07, 0xFB, 0xF8, 0x00, 0xFF, 0x7E, 0x00, 0x1F, 0xFF, 0xC0, 0x01,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F,
  0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFB, 0xF0, 0x00, 0x7F,
  0x7F, 0x00, 0x1F, 0xEF, 0xE0, 0x03, 0xFD, 0xFE, 0x00, 0xFF, 0x9F, 0xC0,
  0x1F, 0xF3, 0xFC, 0x0F, 0xFE, 0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFD, 0xF8,
  0x7F, 0xFF, 0x3F, 0x07, 0xFF, 0xC7, 0xE0, 0x3F, 0xE0, 0xFC, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0x80,
  0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xF8, 0x7F, 0x83, 0xF8, 0x07,
  0xF0, 0xFC, 0x00, 0xFC, 0x7F, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xE7, 0xE0,
  0x01, 0xF9, 0xF8, 0x00, 0x7E, 0xFE, 0x00, 0x1F, 0xBF, 0x80, 0x07, 0xEF,
  0xE0, 0x01, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x41, 0xFE, 0x00, 0xF0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x3F,
  0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0x82, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xFF, 0xC3, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x07, 0xE0,
  0x7F, 0xF0, 0xFC, 0x1F, 0xFF, 0x1F, 0x87, 0xFF, 0xF3, 0xF1, 0xFF, 0xFF,
  0x7E, 0x7F, 0xE7, 0xFF, 0xCF, 0xF0, 0x1F, 0xF9, 0xFC, 0x01, 0xFF, 0x7F,
  0x00, 0x1F, 0xEF, 0xE0, 0x03, 0xFD, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0,
  0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80,
  0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xEF, 0xC0, 0x01, 0xFD,
  0xFC, 0x00, 0x7F, 0xBF, 0x80, 0x0F, 0xF7, 0xF8, 0x03, 0xFE, 0x7F, 0x00,
  0x7F, 0xCF, 0xF8, 0x3F, 0xF8, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xEF, 0xE1,
  0xFF, 0xFD, 0xFC, 0x1F, 0xFF, 0x3F, 0x80, 0xFF, 0x87, 0xF0, 0x03, 0x80,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE3, 0x00, 0x03, 0xF8, 0x78, 0x01, 0xFF, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0xFF, 0x03, 0xF8, 0xFF, 0xF0, 0xFE, 0x7F, 0xFE, 0x3F,
  0xBF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xF7, 0xFE, 0xFF, 0xC0, 0x7F,
  0xBF, 0xE0, 0x0F, 0xEF, 0xF8, 0x01, 0xFB, 0xFC, 0x00, 0x7F, 0xFF, 0x00,
  0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F,
  0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00,
  0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8,
  0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF,
  0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01,
  0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xF0, 0x7C,
  0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x9E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xF0, 0x0F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x81, 0xFC, 0x07, 0xE0, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0,
  0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F,
  0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0xC1, 0xFF, 0xFF, 0xEF, 0xFF, 0x7F, 0xF3, 0xFF,
  0x9F, 0xF0, 0x7E, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0xFF, 0xF8, 0x00, 0xFE, 0xFC, 0x00, 0xFE, 0x7E, 0x00, 0xFE,
  0x3F, 0x00, 0x7F, 0x1F, 0x80, 0x7F, 0x0F, 0xC0, 0x7F, 0x07, 0xE0, 0x3F,
  0x83, 0xF0, 0x3F, 0x81, 0xF8, 0x3F, 0x80, 0xFC, 0x3F, 0x80, 0x7E, 0x1F,
  0xC0, 0x3F, 0x1F, 0xC0, 0x1F, 0x9F, 0xC0, 0x0F, 0xCF, 0xC0, 0x07, 0xEF,
  0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xC0, 0x3F, 0xEF, 0xE0, 0x1F, 0xE3, 0xF8, 0x0F, 0xE1, 0xFC, 0x07,
  0xE0, 0x7F, 0x03, 0xF0, 0x3F, 0x81, 0xF8, 0x0F, 0xE0, 0xFC, 0x07, 0xF0,
  0x7E, 0x01, 0xFC, 0x3F, 0x00, 0xFE, 0x1F, 0x80, 0x3F, 0x8F, 0xC0, 0x1F,
  0xE7, 0xE0, 0x07, 0xF3, 0xF0, 0x03, 0xFD, 0xF8, 0x00, 0xFE, 0xFC, 0x00,
  0x7F, 0xFE, 0x00, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFC, 0x1F, 0xF0, 0x07, 0xF8, 0x1F, 0x87, 0xFF, 0x03, 0xFF, 0xC3,
  0xF1, 0xFF, 0xF0, 0xFF, 0xFC, 0x7E, 0x7F, 0xFF, 0x3F, 0xFF, 0xCF, 0xDF,
  0xFF, 0xF7, 0xFF, 0xF9, 0xFF, 0xF7, 0xFF, 0xF9, 0xFF, 0xBF, 0xF0, 0x3F,
  0xFC, 0x0F, 0xF7, 0xFC, 0x03, 0xFF, 0x00, 0xFE, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xFF, 0xE0, 0x07, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xFF, 0x80, 0x1F, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xE0, 0x03, 0xFF, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xF0,
  0x01, 0xFF, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xC0, 0x07,
  0xFF, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xFF,
  0x80, 0x0F, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xF8, 0x00,
  0xFF, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xE0, 0x03, 0xFF,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xFF, 0xC0,
  0x07, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0xFC, 0x0F, 0xF0, 0x3F, 0x0F, 0xFF, 0x0F, 0xC7, 0xFF,
  0xE3, 0xF3, 0xFF, 0xFC, 0xFD, 0xFF, 0xFF, 0x3F, 0xFE, 0x7F, 0xEF, 0xFC,
  0x07, 0xFB, 0xFE, 0x00, 0xFE, 0xFF, 0x80, 0x1F, 0xBF, 0xC0, 0x07, 0xFF,
  0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07,
  0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F,
  0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00,
  0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xE3, 0xFE, 0x0F, 0xF0, 0x1F, 0xE1,
  0xFC, 0x01, 0xFC, 0x7F, 0x00, 0x1F, 0xCF, 0xE0, 0x03, 0xF9, 0xF8, 0x00,
  0x3F, 0x7F, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC,
  0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F,
  0xEF, 0xC0, 0x01, 0xFD, 0xFC, 0x00, 0x3F, 0x3F, 0x80, 0x0F, 0xE3, 0xF8,
  0x01, 0xFC, 0x7F, 0x00, 0x7F, 0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0xE0, 0x00, 0xFC, 0x0F, 0xF0, 0x1F, 0x87, 0xFF, 0x83,
  0xF1, 0xFF, 0xF8, 0x7E, 0x7F, 0xFF, 0x8F, 0xFF, 0xFF, 0xF1, 0xFF, 0xE1,
  0xFF, 0x3F, 0xF0, 0x0F, 0xE7, 0xFC, 0x01, 0xFE, 0xFF, 0x80, 0x1F, 0xDF,
  0xE0, 0x03, 0xFB, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFE,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0,
  0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F,
  0x7F, 0x80, 0x0F, 0xEF, 0xF8, 0x01, 0xFD, 0xFF, 0x80, 0x7F, 0x3F, 0xF8,
  0x3F, 0xE7, 0xFF, 0xFF, 0xF8, 0xFE, 0xFF, 0xFF, 0x1F, 0xCF, 0xFF, 0xC3,
  0xF8, 0xFF, 0xF0, 0x7F, 0x0F, 0xF8, 0x0F, 0xE0, 0x3C, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x07, 0xE0, 0x7F, 0xF0, 0xFC, 0x1F, 0xFF, 0x1F, 0x87,
  0xFF, 0xF3, 0xF1, 0xFF, 0xFF, 0x7E, 0x7F, 0xE3, 0xFF, 0xCF, 0xF0, 0x1F,
  0xFB, 0xFC, 0x01, 0xFF, 0x7F, 0x00, 0x1F, 0xEF, 0xE0, 0x03, 0xFD, 0xFC,
  0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0,
  0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00,
  0x0F, 0xEF, 0xC0, 0x01, 0xFD, 0xFC, 0x00, 0x7F, 0xBF, 0x80, 0x0F, 0xF7,
  0xF8, 0x03, 0xFE, 0x7F, 0x00, 0x7F, 0xCF, 0xF8, 0x3F, 0xF8, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xEF, 0xE1, 0xFF, 0xFD, 0xFC, 0x1F, 0xFF, 0x3F, 0x80,
  0xFF, 0x87, 0xF0, 0x03, 0x80, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0xFC, 0x0F, 0xFF,
  0x0F, 0xFF, 0xC7, 0xFF, 0xF1, 0xFF, 0xFC, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0x8F, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0xC1,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF1, 0xFE, 0x07, 0xC7, 0xF0,
  0x02, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x0F,
  0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFE,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x80,
  0x01, 0xFB, 0x80, 0x0F, 0xEF, 0x80, 0x7F, 0xBF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x01, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFF, 0x04, 0x1F, 0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F,
  0xFC, 0x03, 0xFF, 0x00, 0x1E, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07,
  0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F,
  0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00,
  0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F,
  0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFD, 0xF8, 0x00,
  0xFF, 0x7F, 0x00, 0x7F, 0xDF, 0xE0, 0x3F, 0xF7, 0xFC, 0x1F, 0xFC, 0xFF,
  0xFF, 0xBF, 0x3F, 0xFF, 0xEF, 0xC7, 0xFF, 0xF3, 0xF0, 0xFF, 0xF8, 0xFC,
  0x1F, 0xF8, 0x3F, 0x00, 0x70, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF7, 0xE0,
  0x00, 0x7F, 0x7E, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x7E, 0x7F, 0x00, 0x0F,
  0xE3, 0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xE3, 0xF8, 0x00, 0xFC, 0x1F,
  0x80, 0x1F, 0xC1, 0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x1F, 0x81, 0xFC, 0x01,
  0xF8, 0x0F, 0xC0, 0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x3F, 0x00,
  0x7E, 0x03, 0xF0, 0x07, 0xE0, 0x7F, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xF0,
  0x7E, 0x00, 0x3F, 0x0F, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0,
  0x01, 0xF8, 0xFC, 0x00, 0x1F, 0x9F, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x0F,
  0x9F, 0x80, 0x00, 0xFD, 0xF8, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0xFF,
  0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xF7, 0xE0,
  0x07, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0x9F, 0x80, 0x3F,
  0xF8, 0x03, 0xF3, 0xF8, 0x07, 0xDF, 0x00, 0xFE, 0x7F, 0x00, 0xFB, 0xE0,
  0x1F, 0x87, 0xE0, 0x1F, 0x7C, 0x03, 0xF0, 0xFC, 0x03, 0xEF, 0x80, 0x7E,
  0x1F, 0xC0, 0xFD, 0xF8, 0x1F, 0xC3, 0xF8, 0x1F, 0x1F, 0x03, 0xF0, 0x3F,
  0x03, 0xE3, 0xE0, 0x7E, 0x07, 0xE0, 0x7C, 0x7C, 0x0F, 0xC0, 0xFC, 0x1F,
  0x8F, 0xC1, 0xF8, 0x1F, 0xC3, 0xF1, 0xF8, 0x7F, 0x01, 0xF8, 0x7C, 0x1F,
  0x0F, 0xC0, 0x3F, 0x0F, 0x83, 0xE1, 0xF8, 0x07, 0xE3, 0xF0, 0x7C, 0x3F,
  0x00, 0xFC, 0x7E, 0x0F, 0xCF, 0xE0, 0x0F, 0xCF, 0x81, 0xF9, 0xF8, 0x01,
  0xF9, 0xF0, 0x1F, 0x3F, 0x00, 0x3F, 0x3E, 0x03, 0xE7, 0xE0, 0x07, 0xE7,
  0xC0, 0x7C, 0xFC, 0x00, 0xFD, 0xF8, 0x0F, 0x9F, 0x00, 0x0F, 0xBE, 0x01,
  0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF,
  0x80, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00,
  0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xE0, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00,
  0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xEF, 0xE0, 0x03, 0xF9, 0xFC, 0x00,
  0xFE, 0x1F, 0xC0, 0x1F, 0xC3, 0xF8, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x03,
  0xF0, 0x3F, 0x80, 0x7F, 0x07, 0xF0, 0x07, 0xE1, 0xFC, 0x00, 0xFE, 0x3F,
  0x80, 0x0F, 0xCF, 0xE0, 0x01, 0xFD, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xDF, 0x80,
  0x03, 0xF3, 0xF8, 0x00, 0xFE, 0x3F, 0x00, 0x1F, 0x87, 0xF0, 0x07, 0xF0,
  0x7E, 0x00, 0xFE, 0x0F, 0xE0, 0x3F, 0x80, 0xFC, 0x07, 0xF0, 0x1F, 0xC1,
  0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x8F, 0xE0, 0x03, 0xF9, 0xFC, 0x00,
  0x7F, 0x7F, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x7F,
  0x7F, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x7E, 0x7F, 0x00, 0x0F, 0xE3, 0xF0,
  0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xE3, 0xF8, 0x00, 0xFC, 0x1F, 0x80, 0x1F,
  0xC1, 0xFC, 0x01, 0xFC, 0x1F, 0xC0, 0x1F, 0x80, 0xFC, 0x01, 0xF8, 0x0F,
  0xC0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0x7E, 0x03,
  0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x00,
  0x3F, 0x0F, 0xE0, 0x03, 0xF8, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xF8,
  0xFC, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x0F, 0xDF, 0x80,
  0x00, 0xFD, 0xF8, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xFC,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xF0, 0x01, 0xFF, 0x00,
  0x3F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0xFF,
  0xE0, 0x0F, 0xFC, 0x00, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xE0, 0x01,
  0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0,
  0x01, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x00, 0x1F,
  0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0x3F, 0xC0, 0x03,
  0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x03,
  0xFF, 0x80, 0x3F, 0xF0, 0x00, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xF8, 0x0F,
  0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x0F, 0xF0,
  0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0xFE, 0x00,
  0x10, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x23, 0xFF, 0x00, 0x05, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x80, 0x00, 0xFF, 0x00,
};

const GFXglyph NotoSans_Condensed_Medium66pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 8, 48, 17, 4, -47 },
  { 49, 19, 17, 27, 4, -47 },
  { 90, 32, 47, 35, 1, -47 },
  { 278, 26, 54, 32, 3, -50 },
  { 454, 43, 49, 49, 3, -48 },
  { 718, 36, 49, 38, 2, -48 },
  { 939, 7, 17, 15, 4, -47 },
  { 954, 15, 57, 20, 3, -47 },
  { 1061, 15, 57, 20, 2, -47 },
  { 1168, 26, 25, 30, 2, -50 },
  { 1250, 27, 31, 32, 2, -39 },
  { 1355, 10, 17, 16, 2, -8 },
  { 1377, 15, 6, 19, 2, -21 },
  { 1389, 8, 10, 16, 4, -9 },
  { 1399, 24, 47, 25, 1, -47 },
  { 1540, 26, 49, 32, 3, -48 },
  { 1700, 18, 47, 32, 4, -47 },
  { 1806, 27, 48, 32, 2, -48 },
  { 1968, 26, 49, 32, 3, -48 },
  { 2128, 30, 47, 32, 1, -47 },
  { 2305, 26, 48, 32, 3, -47 },
  { 2461, 26, 49, 32, 3, -48 },
  { 2621, 27, 47, 32, 2, -47 },
  { 2780, 27, 49, 32, 2, -48 },
  { 2946, 27, 49, 32, 2, -48 },
  { 3112, 8, 37, 16, 4, -36 },
  { 3149, 10, 45, 16, 2, -36 },
  { 3206, 27, 31, 32, 2, -39 },
  { 3311, 27, 19, 32, 2, -33 },
  { 3376, 27, 31, 32, 2, -39 },
  { 3481, 22, 49, 24, 1, -48 },
  { 3616, 43, 54, 49, 3, -48 },
  { 3907, 35, 47, 35, 0, -47 },
  { 4113, 28, 47, 36, 5, -47 },
  { 4278, 29, 49, 34, 3, -48 },
  { 4456, 31, 47, 39, 5, -47 },
  { 4639, 22, 47, 30, 5, -47 },
  { 4769, 22, 47, 29, 5, -47 },
  { 4899, 33, 49, 40, 3, -48 },
  { 5102, 30, 47, 40, 5, -47 },
  { 5279, 16, 47, 21, 2, -47 },
  { 5373, 16, 60, 17, -4, -47 },
  { 5493, 29, 47, 34, 5, -47 },
  { 5664, 22, 47, 28, 5, -47 },
  { 5794, 42, 47, 52, 5, -47 },
  { 6041, 32, 47, 43, 5, -47 },
  { 6229, 35, 49, 42, 3, -48 },
  { 6444, 26, 47, 33, 5, -47 },
  { 6597, 35, 59, 42, 3, -48 },
  { 6856, 29, 47, 35, 5, -47 },
  { 7027, 25, 49, 30, 3, -48 },
  { 7181, 28, 47, 29, 1, -47 },
  { 7346, 30, 48, 39, 5, -47 },
  { 7526, 33, 47, 33, 0, -47 },
  { 7720, 52, 47, 52, 0, -47 },
  { 8026, 31, 47, 32, 0, -47 },
  { 8209, 31, 47, 31, 0, -47 },
  { 8392, 25, 47, 29, 2, -47 },
  { 8539, 14, 58, 21, 5, -47 },
  { 8641, 23, 47, 25, 1, -47 },
  { 8777, 14, 58, 21, 2, -47 },
  { 8879, 30, 27, 33, 1, -47 },
  { 8981, 29, 4, 28, 0, 6 },
  { 8996, 13, 11, 19, 3, -51 },
  { 9014, 25, 37, 31, 2, -36 },
  { 9130, 27, 51, 34, 4, -50 },
  { 9303, 22, 37, 26, 3, -36 },
  { 9405, 27, 51, 34, 3, -50 },
  { 9578, 26, 37, 31, 3, -36 },
  { 9699, 20, 50, 19, 1, -50 },
  { 9824, 27, 52, 34, 3, -36 },
  { 10000, 26, 50, 34, 4, -50 },
  { 10163, 7, 49, 16, 4, -49 },
  { 10206, 13, 65, 16, -2, -49 },
  { 10312, 25, 50, 31, 5, -50 },
  { 10469, 7, 50, 16, 4, -50 },
  { 10513, 43, 36, 51, 4, -36 },
  { 10707, 26, 36, 34, 4, -36 },
  { 10824, 27, 37, 33, 3, -36 },
  { 10949, 27, 52, 34, 4, -36 },
  { 11125, 27, 52, 34, 3, -36 },
  { 11301, 18, 36, 23, 4, -36 },
  { 11382, 22, 37, 26, 2, -36 },
  { 11484, 18, 45, 21, 1, -44 },
  { 11586, 26, 37, 34, 4, -36 },
  { 11707, 28, 36, 29, 0, -36 },
  { 11833, 43, 36, 45, 1, -36 },
  { 12027, 27, 36, 29, 1, -36 },
  { 12149, 28, 52, 29, 0, -36 },
  { 12331, 21, 36, 24, 2, -36 },
  { 12426, 20, 58, 24, 2, -47 },
  { 12571, 6, 66, 30, 12, -50 },
  { 12621, 19, 58, 24, 3, -47 },
  { 12759, 27, 9, 32, 2, -28 },
};

const GFXfont NotoSans_Condensed_Medium66pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Medium66pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Medium66pt7bGlyphs,
  0x20, 0x7E, 90
};

#endif // _NOTOSANS_CONDENSED_MEDIUM66PT7B_H_
