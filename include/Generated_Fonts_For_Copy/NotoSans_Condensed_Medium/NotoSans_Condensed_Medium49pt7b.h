#ifndef _NOTOSANS_CONDENSED_MEDIUM49PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUM49PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Medium.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Medium49pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xE7,
  0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x78, 0x00, 0x00, 0x01, 0xEF,
  0xFF, 0xFF, 0xF7, 0xC4, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8,
  0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xC0, 0xF7, 0x03, 0x9C,
  0x0E, 0x70, 0x38, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0x70, 0x00, 0xF0, 0x70,
  0x00, 0xE0, 0xF0, 0x00, 0xE0, 0xF0, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0xF0,
  0x01, 0xE0, 0xE0, 0x01, 0xE0, 0xE0, 0x01, 0xE0, 0xE0, 0x7F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x03, 0xC1, 0xC0,
  0x03, 0xC1, 0xC0, 0x03, 0xC3, 0xC0, 0x03, 0x83, 0xC0, 0x03, 0x83, 0xC0,
  0x07, 0x83, 0xC0, 0x07, 0x83, 0xC0, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x07, 0x07, 0x80, 0x0F, 0x07, 0x80,
  0x0F, 0x07, 0x80, 0x0F, 0x07, 0x00, 0x0F, 0x07, 0x00, 0x0F, 0x0F, 0x00,
  0x0E, 0x0F, 0x00, 0x0E, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x0F, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x7F, 0xF0,
  0x1F, 0xFF, 0xCF, 0xFF, 0xF1, 0xFF, 0xFE, 0x7E, 0xE1, 0xCF, 0x9C, 0x03,
  0xE3, 0x80, 0x7C, 0x70, 0x0F, 0x8E, 0x01, 0xF1, 0xC0, 0x1F, 0x38, 0x03,
  0xF7, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x3B, 0xF8, 0x07, 0x1F, 0x00, 0xE3, 0xE0,
  0x1C, 0x3C, 0x03, 0x87, 0x80, 0x70, 0xF8, 0x0E, 0x3F, 0xC1, 0xCF, 0xFF,
  0xBF, 0xF7, 0xFF, 0xFC, 0xFF, 0xFF, 0x07, 0xFF, 0x80, 0x07, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x1F,
  0xC0, 0x07, 0x80, 0x1F, 0xF0, 0x03, 0xC0, 0x1F, 0xF8, 0x03, 0xC0, 0x0F,
  0x1E, 0x01, 0xE0, 0x07, 0x8F, 0x00, 0xF0, 0x07, 0x83, 0x80, 0xF0, 0x03,
  0xC1, 0xE0, 0x78, 0x01, 0xE0, 0xF0, 0x78, 0x00, 0xF0, 0x78, 0x3C, 0x00,
  0x78, 0x3C, 0x1C, 0x00, 0x3C, 0x1E, 0x1E, 0x00, 0x1E, 0x0F, 0x0F, 0x00,
  0x0F, 0x07, 0x8F, 0x00, 0x07, 0x83, 0xC7, 0x82, 0x03, 0xC1, 0xE7, 0x87,
  0xE1, 0xE0, 0xE3, 0xC7, 0xF8, 0x78, 0xF1, 0xE7, 0xFE, 0x3C, 0x79, 0xE3,
  0xCF, 0x0F, 0xF8, 0xF3, 0xC3, 0xC7, 0xFC, 0xF1, 0xE1, 0xE1, 0xFC, 0x78,
  0xF0, 0xF0, 0x00, 0x38, 0x70, 0x78, 0x00, 0x3C, 0x38, 0x3C, 0x00, 0x1E,
  0x3C, 0x0E, 0x00, 0x1E, 0x1E, 0x07, 0x80, 0x0F, 0x0F, 0x07, 0x80, 0x0F,
  0x03, 0x83, 0xC0, 0x07, 0x81, 0xC1, 0xE0, 0x03, 0xC0, 0xF0, 0xF0, 0x03,
  0xC0, 0x78, 0x78, 0x01, 0xE0, 0x3C, 0x3C, 0x01, 0xE0, 0x0F, 0x3C, 0x00,
  0xF0, 0x07, 0xFE, 0x00, 0xF0, 0x01, 0xFE, 0x00, 0x78, 0x00, 0x7E, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFC,
  0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x03, 0xE0, 0x78, 0x00, 0xF8,
  0x1E, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0x83, 0xE0, 0x01, 0xF0, 0xF8, 0x00,
  0x7C, 0x7C, 0x00, 0x0F, 0xBF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x23, 0xFF,
  0x81, 0xF0, 0xFB, 0xF0, 0x7C, 0x7E, 0x7E, 0x1F, 0x3F, 0x0F, 0xC7, 0xCF,
  0x81, 0xF3, 0xE3, 0xE0, 0x7E, 0xF8, 0xF8, 0x0F, 0xFE, 0x3E, 0x01, 0xFF,
  0x0F, 0x80, 0x3F, 0xC3, 0xE0, 0x0F, 0xE0, 0xF8, 0x01, 0xF8, 0x3F, 0x00,
  0xFF, 0x0F, 0xE0, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xBF, 0x07,
  0xFF, 0x87, 0xE0, 0xFF, 0xC0, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x9C, 0xE7, 0x00, 0x01, 0xF0, 0x3C, 0x07, 0xC0, 0x78, 0x0F, 0x80, 0xF0,
  0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0xC0,
  0x7C, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x78, 0x07, 0x80, 0x7C, 0x07, 0xC0,
  0x7C, 0x03, 0xC0, 0x3E, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x1F, 0x00, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0xF8, 0x07, 0xC0, 0x3C,
  0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0x80, 0x7C, 0x07,
  0xC0, 0x3C, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x1E, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x7C, 0x07,
  0x80, 0xF8, 0x0F, 0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x3C, 0x07, 0x80, 0xF8,
  0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x30, 0x78, 0x3F, 0xDE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x3F, 0x00, 0x1F, 0xE0, 0x0F, 0xFC, 0x03, 0xCF, 0x01, 0xF3, 0xE0, 0xF8,
  0x7C, 0x3E, 0x1F, 0x03, 0x03, 0x00, 0x40, 0x80, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x3E, 0x7C, 0xF9, 0xF7, 0xCF, 0x9F,
  0x3C, 0x79, 0xF3, 0xC7, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7B,
  0xFF, 0xFF, 0xFD, 0xE1, 0x00, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07,
  0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80,
  0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xFC, 0x01, 0xFF,
  0xC0, 0x7F, 0xFC, 0x0F, 0xFF, 0xC3, 0xF0, 0xF8, 0x7C, 0x0F, 0x9F, 0x01,
  0xF3, 0xE0, 0x3E, 0x7C, 0x03, 0xEF, 0x80, 0x7F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xEF, 0x00, 0x7D, 0xF0, 0x0F,
  0xBE, 0x03, 0xE7, 0xC0, 0x7C, 0x7C, 0x0F, 0x8F, 0xC3, 0xE0, 0xFF, 0xFC,
  0x1F, 0xFF, 0x01, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x00, 0xF8, 0x0F, 0xC0,
  0xFE, 0x0F, 0xF0, 0xFF, 0x8F, 0xFC, 0xFF, 0xEF, 0xDF, 0xFC, 0xFB, 0xC7,
  0xCC, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x0F, 0xFC, 0x07, 0xFF, 0xC1, 0xFF, 0xFC,
  0x7F, 0xFF, 0xC7, 0xC1, 0xFC, 0x60, 0x1F, 0x88, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFC, 0x07, 0xFF, 0xE3, 0xFF, 0xFE,
  0x7F, 0xFF, 0xC7, 0x80, 0xFC, 0x40, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x7F, 0xF0, 0x0F, 0xF8, 0x01, 0xFF, 0xC0,
  0x3F, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x7F, 0x00, 0x1F, 0xB8, 0x07, 0xF7, 0xFF, 0xFC, 0xFF, 0xFF, 0x1F,
  0xFF, 0xC1, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x1D, 0xF0, 0x00, 0xF7, 0xC0, 0x07, 0x9F, 0x00, 0x1E, 0x7C, 0x00,
  0xF1, 0xF0, 0x03, 0xC7, 0xC0, 0x1E, 0x1F, 0x00, 0x78, 0x7C, 0x03, 0xC1,
  0xF0, 0x0F, 0x07, 0xC0, 0x78, 0x1F, 0x01, 0xE0, 0x7C, 0x0F, 0x01, 0xF0,
  0x7C, 0x07, 0xC1, 0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0xFF,
  0xFE, 0x1F, 0xFF, 0xC3, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xFB, 0xE0, 0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x7F, 0xFF, 0x87, 0xDF,
  0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xB8, 0x07, 0xF7, 0xFF, 0xFC, 0xFF, 0xFF,
  0x1F, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x3F, 0xF8, 0x07,
  0xFF, 0x80, 0xFF, 0xF8, 0x1F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x0F, 0x8F, 0xE0, 0xF9, 0xFF, 0x0F, 0xBF, 0xF8, 0xFF, 0xFF,
  0xCF, 0xF0, 0xFC, 0xFE, 0x07, 0xEF, 0xC0, 0x3E, 0xF8, 0x03, 0xEF, 0x80,
  0x3E, 0xF8, 0x01, 0xEF, 0x80, 0x1F, 0xF8, 0x01, 0xF7, 0x80, 0x1E, 0x7C,
  0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xE3, 0xE0, 0x7E, 0x3F, 0x0F, 0xC1,
  0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC,
  0x7E, 0x07, 0xC7, 0xC0, 0x7E, 0x7C, 0x03, 0xE7, 0x80, 0x3E, 0x78, 0x03,
  0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xC7, 0xC0, 0x7C, 0x3E, 0x0F, 0xC3, 0xF1,
  0xF8, 0x1F, 0xFF, 0x00, 0xFF, 0xE0, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x1F,
  0xFF, 0x03, 0xF3, 0xF8, 0x3E, 0x0F, 0xC7, 0xC0, 0x7C, 0xF8, 0x03, 0xEF,
  0x80, 0x3E, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x03, 0xEF, 0x80, 0x3E, 0x7C, 0x07, 0xE7, 0xFF, 0xFC, 0x3F, 0xFF,
  0x81, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x07, 0xF8, 0x01, 0xFF, 0xC0, 0x7F,
  0xFC, 0x1F, 0xFF, 0xC7, 0xE1, 0xF8, 0xF8, 0x1F, 0xBF, 0x01, 0xF7, 0xC0,
  0x3E, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0x7C, 0x07, 0xEF, 0xC1,
  0xFD, 0xFF, 0xF7, 0x9F, 0xFF, 0xF1, 0xFF, 0xBE, 0x1F, 0xC7, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0xC1, 0xFF, 0xF0, 0x3F, 0xFC,
  0x07, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x33, 0xFF, 0xFF, 0xFF, 0xF7, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xEF, 0xFF,
  0xFF, 0xF7, 0x8C, 0x18, 0xFD, 0xFB, 0xF7, 0xEF, 0xCF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xCF, 0x9F,
  0x7E, 0xF9, 0xF3, 0xE7, 0x8F, 0x3E, 0x78, 0xF0, 0x00, 0x00, 0x10, 0x00,
  0x07, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x0F,
  0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0E, 0x00, 0x00, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x00,
  0x07, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03,
  0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0xF8, 0x00, 0x0E, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x1F, 0xF8, 0x3F, 0xFF, 0x3F, 0xFF, 0x8F, 0xFF, 0xE3,
  0x81, 0xF1, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x01,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0xC0, 0x0F,
  0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x20, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFC, 0x0F, 0xE0,
  0x03, 0xE0, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x78,
  0x0F, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x3C, 0x1E, 0x01, 0xF8, 0x1E,
  0x3C, 0x07, 0xFE, 0x1E, 0x3C, 0x1F, 0xFE, 0x1E, 0x78, 0x1F, 0x3E, 0x0E,
  0x78, 0x3E, 0x1E, 0x0F, 0x78, 0x3C, 0x1E, 0x0F, 0x78, 0x78, 0x1E, 0x0F,
  0x70, 0x78, 0x1E, 0x0F, 0x70, 0x78, 0x1E, 0x0F, 0xF0, 0x78, 0x1E, 0x0F,
  0xF0, 0x78, 0x1E, 0x0F, 0xF0, 0x78, 0x1E, 0x0F, 0xF0, 0x78, 0x1E, 0x0F,
  0xF0, 0x78, 0x3E, 0x0E, 0xF0, 0x78, 0x3E, 0x1E, 0x70, 0x78, 0x3E, 0x1E,
  0x78, 0x7C, 0x7E, 0x3C, 0x78, 0x3F, 0xF7, 0xFC, 0x78, 0x1F, 0xE7, 0xF8,
  0x78, 0x0F, 0xC3, 0xF0, 0x3C, 0x02, 0x00, 0x80, 0x3C, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x01, 0x00, 0x07, 0xFC, 0x1F, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0x7C, 0x00, 0x03, 0xDF, 0x00, 0x01, 0xF3,
  0xC0, 0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0x8F, 0x80, 0x03,
  0xE1, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x07, 0xC0,
  0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x7C, 0x0F, 0x80, 0x3E, 0x03,
  0xE0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xC0, 0x0F, 0x83, 0xF0, 0x03, 0xE0,
  0xF8, 0x00, 0xFC, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC7, 0xE0, 0x01,
  0xF9, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0xBF, 0x00, 0x03, 0xEF, 0x80,
  0x00, 0xFC, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC,
  0xF8, 0x1F, 0xEF, 0x80, 0x7E, 0xF8, 0x03, 0xEF, 0x80, 0x3F, 0xF8, 0x03,
  0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80,
  0x7C, 0xF8, 0x3F, 0xCF, 0xFF, 0xF0, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xCF, 0x80, 0xFE, 0xF8, 0x03, 0xEF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x1F, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF,
  0x8F, 0xFF, 0xF0, 0xFF, 0xFC, 0x00, 0x00, 0x02, 0x00, 0x01, 0xFF, 0xC0,
  0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0x80, 0xC1, 0xFC,
  0x01, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x0E, 0x07, 0xFF,
  0xF8, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x3F, 0xFC, 0xFF, 0xF8, 0x03,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xF8, 0x7F, 0xE3, 0xE0,
  0x1F, 0xCF, 0x80, 0x3F, 0x3E, 0x00, 0x7E, 0xF8, 0x01, 0xFB, 0xE0, 0x03,
  0xEF, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xEF, 0x80, 0x1F, 0xBE,
  0x00, 0x7C, 0xF8, 0x03, 0xF3, 0xE0, 0x3F, 0x8F, 0x87, 0xFE, 0x3F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xFE,
  0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xE0, 0x3C, 0x1F, 0x80, 0x04,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x07, 0xFF, 0xF8, 0x07, 0xFF,
  0xF8, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0x7C, 0x00, 0x1F,
  0x7C, 0x00, 0x1F, 0x7E, 0x00, 0x1F, 0x3F, 0x00, 0x1F, 0x3F, 0x80, 0x1F,
  0x1F, 0xE0, 0x3F, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x00, 0xFF, 0xF8, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x80, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFC, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x03, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x3F, 0x03, 0xE0, 0x7E, 0xFF, 0xEF, 0xFC,
  0xFF, 0x8F, 0xF0, 0x38, 0x00, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xBE, 0x00,
  0xFD, 0xF0, 0x0F, 0xCF, 0x80, 0x7C, 0x7C, 0x07, 0xE3, 0xE0, 0x7E, 0x1F,
  0x03, 0xE0, 0xF8, 0x3F, 0x07, 0xC3, 0xF0, 0x3E, 0x1F, 0x01, 0xF1, 0xF8,
  0x0F, 0x8F, 0x80, 0x7C, 0xF8, 0x03, 0xEF, 0xC0, 0x1F, 0x7C, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x01, 0xFD, 0xF0, 0x0F, 0xCF, 0xC0,
  0x7C, 0x3E, 0x03, 0xE1, 0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x3F, 0x07, 0xC0,
  0xF8, 0x3E, 0x07, 0xE1, 0xF0, 0x1F, 0x0F, 0x80, 0xFC, 0x7C, 0x03, 0xF3,
  0xE0, 0x1F, 0x9F, 0x00, 0x7E, 0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0xFE, 0x00,
  0x3E, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFB, 0xC0, 0x01, 0xFF, 0xF7, 0x80, 0x07, 0xBF, 0xEF, 0x80,
  0x0F, 0x7F, 0xCF, 0x00, 0x1E, 0xFF, 0x9E, 0x00, 0x7D, 0xFF, 0x3E, 0x00,
  0xF3, 0xFF, 0x3C, 0x01, 0xE7, 0xFE, 0x78, 0x07, 0xCF, 0xFC, 0xF8, 0x0F,
  0x1F, 0xF9, 0xF0, 0x1E, 0x3F, 0xF1, 0xE0, 0x7C, 0x7F, 0xE3, 0xC0, 0xF0,
  0xFF, 0xC7, 0xC1, 0xE1, 0xFF, 0x87, 0x83, 0xC3, 0xFF, 0x0F, 0x0F, 0x07,
  0xFE, 0x1F, 0x1E, 0x0F, 0xFC, 0x1E, 0x3C, 0x1F, 0xF8, 0x3C, 0xF8, 0x3F,
  0xF0, 0x7D, 0xE0, 0x7F, 0xE0, 0xFB, 0xC0, 0xFF, 0xC0, 0xFF, 0x81, 0xFF,
  0x81, 0xFE, 0x03, 0xFF, 0x03, 0xFC, 0x07, 0xFE, 0x03, 0xF8, 0x0F, 0xFC,
  0x07, 0xE0, 0x1F, 0xF8, 0x0F, 0xC0, 0x3F, 0xF0, 0x0F, 0x80, 0x7F, 0xE0,
  0x1E, 0x00, 0xF8, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F,
  0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x1F,
  0xFF, 0x80, 0x1F, 0xF7, 0xC0, 0x1F, 0xF7, 0xC0, 0x1F, 0xF3, 0xE0, 0x1F,
  0xF3, 0xE0, 0x1F, 0xF1, 0xF0, 0x1F, 0xF1, 0xF0, 0x1F, 0xF8, 0xF8, 0x1F,
  0xF8, 0xF8, 0x1F, 0xF8, 0x7C, 0x1F, 0xF8, 0x7C, 0x1F, 0xF8, 0x3E, 0x1F,
  0xF8, 0x3E, 0x1F, 0xF8, 0x1F, 0x1F, 0xF8, 0x1F, 0x1F, 0xF8, 0x0F, 0x9F,
  0xF8, 0x0F, 0x9F, 0xF8, 0x07, 0xDF, 0xF8, 0x07, 0xDF, 0xF8, 0x03, 0xFF,
  0xF8, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0xFF,
  0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x7F,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF,
  0xF0, 0x1F, 0xE0, 0xFE, 0x07, 0xE0, 0x0F, 0xC3, 0xF0, 0x01, 0xF0, 0xFC,
  0x00, 0x7E, 0x3E, 0x00, 0x0F, 0x9F, 0x80, 0x03, 0xE7, 0xC0, 0x00, 0xFD,
  0xF0, 0x00, 0x1F, 0x7C, 0x00, 0x07, 0xDF, 0x00, 0x01, 0xF7, 0xC0, 0x00,
  0x7D, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xF7, 0xC0,
  0x00, 0x7D, 0xF0, 0x00, 0x1F, 0x7C, 0x00, 0x07, 0xDF, 0x00, 0x01, 0xF7,
  0xC0, 0x00, 0x7D, 0xF0, 0x00, 0x1F, 0x7E, 0x00, 0x0F, 0xDF, 0x80, 0x03,
  0xE3, 0xE0, 0x00, 0xF8, 0xFC, 0x00, 0x7E, 0x1F, 0x00, 0x1F, 0x07, 0xE0,
  0x0F, 0xC0, 0xFE, 0x0F, 0xE0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0xC3, 0xFF,
  0xFC, 0x7F, 0xFF, 0xCF, 0x87, 0xFD, 0xF0, 0x1F, 0xBE, 0x01, 0xF7, 0xC0,
  0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x0F, 0xFE, 0x01, 0xF7, 0xC0, 0x7E, 0xF8, 0x1F, 0xDF, 0xFF,
  0xF3, 0xFF, 0xFC, 0x7F, 0xFF, 0x0F, 0xFF, 0xC1, 0xFF, 0x80, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x1F, 0xE0, 0xFE, 0x07, 0xE0,
  0x0F, 0xC3, 0xF0, 0x01, 0xF0, 0xFC, 0x00, 0x7E, 0x3E, 0x00, 0x0F, 0x9F,
  0x80, 0x03, 0xE7, 0xC0, 0x00, 0xFD, 0xF0, 0x00, 0x1F, 0x7C, 0x00, 0x07,
  0xDF, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x7D, 0xF0, 0x00, 0x1F, 0xFC, 0x00,
  0x07, 0xFF, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x7D, 0xF0, 0x00, 0x1F, 0x7C,
  0x00, 0x07, 0xDF, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x7D, 0xF0, 0x00, 0x1F,
  0x7E, 0x00, 0x0F, 0xDF, 0x80, 0x03, 0xE3, 0xE0, 0x00, 0xF8, 0xFC, 0x00,
  0x7E, 0x1F, 0x00, 0x1F, 0x07, 0xE0, 0x0F, 0xC0, 0xFE, 0x0F, 0xE0, 0x3F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF,
  0x0F, 0x87, 0xFC, 0x7C, 0x07, 0xE3, 0xE0, 0x1F, 0x9F, 0x00, 0xFC, 0xF8,
  0x03, 0xE7, 0xC0, 0x1F, 0x3E, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x3E,
  0x7C, 0x03, 0xF3, 0xE0, 0x1F, 0x1F, 0x01, 0xF8, 0xF8, 0x7F, 0x87, 0xFF,
  0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x7C, 0x3E, 0x03,
  0xE0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x3E, 0x03,
  0xE1, 0xF0, 0x1F, 0x0F, 0x80, 0xFC, 0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x9F,
  0x00, 0x7C, 0xF8, 0x03, 0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0xFF, 0xFC, 0x7F, 0xFF, 0x3F, 0xFF, 0x9F, 0xC1, 0xE7,
  0xC0, 0x0B, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xE0,
  0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xE0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xFC, 0x00, 0xFF, 0xE0, 0x7E, 0xFF, 0xFF,
  0xBF, 0xFF, 0xCF, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80,
  0x0F, 0xBE, 0x00, 0x3E, 0xFC, 0x00, 0xF9, 0xF0, 0x07, 0xE7, 0xF0, 0x3F,
  0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x7F, 0xF0, 0x00,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0x9F, 0x00, 0x07, 0xCF, 0x80, 0x03,
  0xE7, 0xC0, 0x01, 0xF1, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x7C, 0x00,
  0x7C, 0x3E, 0x00, 0x3C, 0x0F, 0x80, 0x3E, 0x07, 0xC0, 0x1F, 0x03, 0xE0,
  0x0F, 0x81, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F,
  0x01, 0xF0, 0x07, 0x81, 0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x7C, 0x00,
  0xF8, 0x3C, 0x00, 0x3C, 0x3E, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x8F, 0x80,
  0x07, 0xC7, 0x80, 0x01, 0xE7, 0xC0, 0x00, 0xFB, 0xE0, 0x00, 0x7D, 0xF0,
  0x00, 0x1E, 0xF0, 0x00, 0x0F, 0x78, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7F, 0xF0, 0x00, 0xF8, 0x00, 0xF9,
  0xF0, 0x03, 0xF0, 0x01, 0xF3, 0xE0, 0x07, 0xE0, 0x03, 0xE7, 0xC0, 0x0F,
  0xE0, 0x07, 0xCF, 0x80, 0x1F, 0xC0, 0x1F, 0x0F, 0x00, 0x3F, 0x80, 0x3E,
  0x1F, 0x00, 0xFF, 0x00, 0x7C, 0x3E, 0x01, 0xEF, 0x00, 0xF8, 0x7C, 0x03,
  0xDE, 0x01, 0xF0, 0xF8, 0x07, 0xBC, 0x07, 0xC0, 0xF8, 0x1F, 0x78, 0x0F,
  0x81, 0xF0, 0x3C, 0xF8, 0x1F, 0x03, 0xE0, 0x79, 0xF0, 0x3E, 0x07, 0xC0,
  0xF1, 0xE0, 0x78, 0x07, 0x81, 0xE3, 0xC1, 0xF0, 0x0F, 0x87, 0xC7, 0x83,
  0xE0, 0x1F, 0x0F, 0x0F, 0x87, 0xC0, 0x3E, 0x1E, 0x0F, 0x0F, 0x80, 0x7C,
  0x3C, 0x1E, 0x3E, 0x00, 0x78, 0xF8, 0x3C, 0x7C, 0x00, 0xF9, 0xE0, 0x7C,
  0xF8, 0x01, 0xF3, 0xC0, 0xF9, 0xF0, 0x03, 0xE7, 0x80, 0xF3, 0xE0, 0x03,
  0xCF, 0x01, 0xE7, 0x80, 0x07, 0xBE, 0x03, 0xDF, 0x00, 0x0F, 0x78, 0x07,
  0xBE, 0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00,
  0x7F, 0x80, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x7E, 0x7C, 0x00, 0xF8, 0xF8,
  0x03, 0xF0, 0xF8, 0x07, 0xC1, 0xF0, 0x1F, 0x81, 0xF0, 0x3E, 0x03, 0xE0,
  0x7C, 0x03, 0xE1, 0xF0, 0x07, 0xC3, 0xE0, 0x07, 0x8F, 0x80, 0x0F, 0x9F,
  0x00, 0x1F, 0x7C, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0xFB, 0xE0, 0x01,
  0xF3, 0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x87, 0xC0, 0x3E, 0x0F, 0x80, 0x7C,
  0x0F, 0x81, 0xF0, 0x1F, 0x03, 0xE0, 0x3F, 0x0F, 0xC0, 0x3E, 0x1F, 0x00,
  0x7E, 0x7E, 0x00, 0x7C, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xF8, 0xF8, 0x00,
  0x7E, 0xF8, 0x00, 0xF9, 0xF0, 0x01, 0xF3, 0xF0, 0x07, 0xC3, 0xE0, 0x0F,
  0x87, 0xC0, 0x3F, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x0F, 0x83, 0xE0,
  0x1F, 0x07, 0xC0, 0x3E, 0x0F, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x00,
  0x7D, 0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xF7, 0x80, 0x01, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF,
  0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0x00,
  0x07, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00,
  0x0F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0xF3, 0xC0, 0x03, 0xCF, 0x80, 0x1E, 0x1E, 0x00, 0x78, 0x7C,
  0x03, 0xC0, 0xF0, 0x0F, 0x03, 0xE0, 0x7C, 0x07, 0x81, 0xE0, 0x1F, 0x0F,
  0x80, 0x3C, 0x3C, 0x00, 0xF9, 0xF0, 0x01, 0xE7, 0x80, 0x07, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFC, 0x3F, 0x07,
  0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0x78, 0x0F, 0x03, 0xF8, 0x07, 0xFF, 0x83,
  0xFF, 0xF0, 0x7F, 0xFE, 0x1C, 0x1F, 0x84, 0x03, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x0F, 0xFF, 0x0F, 0xFF,
  0xCF, 0xFF, 0xF7, 0xF8, 0x7D, 0xF0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0xC1, 0xFF, 0xF9,
  0xEF, 0x7F, 0xFB, 0xCF, 0xFC, 0xF1, 0xFC, 0x3C, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x7C, 0x0F,
  0x9F, 0xF0, 0xFB, 0xFF, 0x8F, 0xBF, 0xFC, 0xFF, 0x8F, 0xCF, 0xE0, 0x7E,
  0xFC, 0x03, 0xEF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC,
  0x03, 0xEF, 0xE0, 0x3E, 0xFF, 0x07, 0xEF, 0xFF, 0xFC, 0xFB, 0xFF, 0xCF,
  0x9F, 0xF8, 0xF0, 0xFE, 0x00, 0x01, 0xFC, 0x07, 0xFF, 0x0F, 0xFF, 0x1F,
  0xFF, 0x3F, 0x8E, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7E,
  0x00, 0x3F, 0x01, 0x3F, 0xFF, 0x1F, 0xFF, 0x0F, 0xFF, 0x03, 0xFE, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x03, 0xE1, 0xF0, 0xFF, 0x9F, 0x1F, 0xFD, 0xF3, 0xFF, 0xFF, 0x3F, 0x8F,
  0xF7, 0xE0, 0x7F, 0x7C, 0x03, 0xF7, 0xC0, 0x3F, 0x7C, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xF7,
  0xC0, 0x1F, 0x7C, 0x03, 0xF7, 0xE0, 0x3F, 0x3E, 0x07, 0xF3, 0xFF, 0xFF,
  0x1F, 0xFE, 0xF0, 0xFF, 0xCF, 0x07, 0xF0, 0xF0, 0x01, 0xF8, 0x00, 0xFF,
  0xC0, 0x3F, 0xFC, 0x0F, 0xFF, 0xC3, 0xF0, 0xF8, 0x7C, 0x0F, 0x9F, 0x00,
  0xF3, 0xE0, 0x1F, 0x78, 0x03, 0xEF, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x0F, 0xC0, 0x30, 0xFF, 0xFE, 0x1F, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFE,
  0x00, 0x03, 0xFE, 0x0F, 0xFC, 0x3F, 0xF0, 0x7F, 0xE0, 0xF8, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x03, 0xFF, 0xCF,
  0xFF, 0x9F, 0xFF, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0xFF, 0x8F, 0x1F, 0xFC, 0xF1, 0xFF, 0xEF, 0x3F, 0x0F, 0xF7,
  0xE0, 0x7F, 0x7C, 0x03, 0xF7, 0xC0, 0x3F, 0x7C, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xF7, 0xC0,
  0x1F, 0x7C, 0x03, 0xF7, 0xE0, 0x3F, 0x3E, 0x07, 0xF3, 0xFF, 0xFF, 0x1F,
  0xFF, 0xF0, 0xFF, 0xDF, 0x07, 0xF1, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE2, 0x00, 0x7E,
  0x3F, 0x3F, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0x83, 0xFF, 0xE0, 0x03, 0xF0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE1, 0xF0, 0x7C, 0xFF, 0x8F, 0xBF, 0xF9, 0xFF, 0xFF, 0xBF, 0xE7,
  0xF7, 0xF0, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x3E, 0x21, 0xEF, 0xBF, 0xF9, 0xE2, 0x00, 0x00,
  0x00, 0x3E, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB,
  0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xF8, 0x02, 0x01, 0xE0,
  0xF8, 0x3F, 0x0F, 0x81, 0xE0, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8,
  0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F,
  0x83, 0xE0, 0xF8, 0x3E, 0xBF, 0xBF, 0xCF, 0xF3, 0xF8, 0x78, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x2F, 0x80, 0x7C, 0xF8, 0x0F, 0xCF, 0x80, 0xF8, 0xF8, 0x1F,
  0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x87, 0xC0, 0xF8, 0xF8, 0x0F, 0x9F,
  0x80, 0xF9, 0xF0, 0x0F, 0xBE, 0x00, 0xFB, 0xF0, 0x0F, 0xFF, 0x00, 0xFF,
  0xF8, 0x0F, 0xEF, 0x80, 0xFC, 0x7C, 0x0F, 0x87, 0xE0, 0xF8, 0x3E, 0x0F,
  0x83, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF8, 0xF8, 0x0F, 0x8F, 0x80, 0xFC,
  0xF8, 0x07, 0xCF, 0x80, 0x7E, 0xF8, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7C, 0x03, 0xE0,
  0xF1, 0xFF, 0x0F, 0xF8, 0xFB, 0xFF, 0x9F, 0xFC, 0xFF, 0xFF, 0xBF, 0xFE,
  0xFF, 0x9F, 0xFC, 0xFE, 0xFE, 0x07, 0xF0, 0x3E, 0xFC, 0x07, 0xF0, 0x3F,
  0xFC, 0x07, 0xE0, 0x1F, 0xFC, 0x03, 0xE0, 0x1F, 0xF8, 0x03, 0xE0, 0x1F,
  0xF8, 0x03, 0xE0, 0x1F, 0xF8, 0x03, 0xE0, 0x1F, 0xF8, 0x03, 0xC0, 0x1F,
  0xF8, 0x03, 0xC0, 0x1F, 0xF8, 0x03, 0xC0, 0x1F, 0xF8, 0x03, 0xC0, 0x1F,
  0xF8, 0x03, 0xC0, 0x1F, 0xF8, 0x03, 0xC0, 0x1F, 0xF8, 0x03, 0xC0, 0x1F,
  0xF8, 0x03, 0xC0, 0x1F, 0xF8, 0x03, 0xC0, 0x1F, 0xF8, 0x03, 0xC0, 0x1F,
  0xF8, 0x03, 0xC0, 0x1F, 0xF8, 0x03, 0xC0, 0x1F, 0xF8, 0x03, 0xC0, 0x1F,
  0xF8, 0x03, 0xC0, 0x1F, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x1E, 0x3F,
  0xE3, 0xEF, 0xFE, 0x7F, 0xFF, 0xEF, 0xF9, 0xFD, 0xFC, 0x0F, 0xFF, 0x00,
  0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0x80, 0x01, 0xF8, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83,
  0xF8, 0xFC, 0x1F, 0x01, 0xF1, 0xF0, 0x0F, 0x8F, 0x80, 0x3E, 0x7C, 0x01,
  0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0x7D, 0xF0, 0x03, 0xEF, 0x80, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1E, 0xF8, 0x01, 0xF7, 0xC0, 0x0F,
  0x9F, 0x00, 0x7C, 0xF8, 0x03, 0xE7, 0xC0, 0x1F, 0x1F, 0x01, 0xF0, 0xFC,
  0x1F, 0x83, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0xFF, 0x80,
  0x00, 0x7C, 0x0F, 0x1F, 0xF0, 0xFB, 0xFF, 0x8F, 0xBF, 0xFC, 0xFF, 0x8F,
  0xCF, 0xE0, 0x7E, 0xFC, 0x03, 0xEF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF,
  0xC0, 0x1F, 0xFC, 0x03, 0xEF, 0xE0, 0x3E, 0xFF, 0x07, 0xEF, 0xFF, 0xFC,
  0xFB, 0xFF, 0xCF, 0x9F, 0xF8, 0xF8, 0xFE, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0xFF, 0x8F, 0x1F, 0xFC, 0xF1, 0xFF, 0xEF,
  0x3F, 0x8F, 0xF7, 0xE0, 0x7F, 0x7C, 0x03, 0xF7, 0xC0, 0x3F, 0x7C, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x03, 0xF7, 0xE0, 0x3F, 0x3F, 0x07, 0xF3,
  0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0xFF, 0xDF, 0x07, 0xF1, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0xC3, 0xEF, 0x1F, 0xBE, 0xFE, 0xFF,
  0xFB, 0xFE, 0x0F, 0xE0, 0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x00, 0x07, 0xF0, 0x3F, 0xF8, 0xFF, 0xFB, 0xFF, 0xFF,
  0xC1, 0xDF, 0x00, 0xBE, 0x00, 0x78, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xF8,
  0x03, 0xFC, 0x03, 0xFE, 0x03, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0xFE,
  0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x07, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFD, 0xFF, 0xF1, 0xFF, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xFF, 0x8F, 0xFC, 0x3F, 0xE0, 0xFF, 0xF8,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0,
  0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0,
  0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xF7, 0xC0,
  0x7E, 0xFC, 0x1F, 0xDF, 0xFF, 0xF9, 0xFF, 0xEF, 0x3F, 0xF9, 0xE1, 0xFE,
  0x3C, 0xF8, 0x00, 0xFB, 0xE0, 0x0F, 0xDF, 0x00, 0x7C, 0xF8, 0x03, 0xE3,
  0xC0, 0x1F, 0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0x87, 0xC0, 0x7C, 0x1E, 0x03,
  0xC0, 0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x1E, 0x0F, 0x80, 0xF8, 0x78, 0x07,
  0xC7, 0xC0, 0x1E, 0x3E, 0x00, 0xF1, 0xE0, 0x07, 0xCF, 0x00, 0x3E, 0xF8,
  0x00, 0xF7, 0x80, 0x07, 0xBC, 0x00, 0x3D, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x03,
  0xF0, 0x0F, 0xBE, 0x01, 0xF8, 0x07, 0x9F, 0x01, 0xFC, 0x07, 0xCF, 0x80,
  0xFE, 0x03, 0xE3, 0xC0, 0x7F, 0x81, 0xF1, 0xF0, 0x3B, 0xC0, 0xF8, 0xF8,
  0x3D, 0xE0, 0x78, 0x7C, 0x1E, 0xF0, 0x7C, 0x1E, 0x0F, 0x38, 0x3E, 0x0F,
  0x07, 0x9E, 0x1F, 0x07, 0xC7, 0x8F, 0x0F, 0x03, 0xE3, 0xC7, 0x8F, 0x81,
  0xF1, 0xE3, 0xC7, 0xC0, 0x78, 0xF0, 0xF3, 0xE0, 0x3E, 0x78, 0x79, 0xE0,
  0x1F, 0x78, 0x3C, 0xF0, 0x0F, 0xBC, 0x1E, 0xF8, 0x03, 0xDE, 0x0F, 0x7C,
  0x01, 0xEF, 0x03, 0xBC, 0x00, 0xF7, 0x81, 0xFE, 0x00, 0x7B, 0x80, 0xFF,
  0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x0F, 0xE0, 0x3F, 0x80, 0x07, 0xF0, 0x0F,
  0xC0, 0x03, 0xF0, 0x07, 0xE0, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0xFC, 0x03,
  0xE7, 0xC0, 0x7C, 0x3E, 0x07, 0xC3, 0xE0, 0xF8, 0x1F, 0x0F, 0x81, 0xF1,
  0xF0, 0x0F, 0x9F, 0x00, 0xFB, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x03,
  0xFC, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00,
  0x7F, 0xC0, 0x07, 0xBE, 0x00, 0xFB, 0xE0, 0x0F, 0x1F, 0x01, 0xF1, 0xF0,
  0x3F, 0x0F, 0x83, 0xE0, 0xF8, 0x7E, 0x07, 0xC7, 0xC0, 0x7C, 0xFC, 0x03,
  0xEF, 0x80, 0x3F, 0xF8, 0x00, 0xFB, 0xE0, 0x0F, 0xDF, 0x00, 0x7C, 0xF8,
  0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0x83, 0xC0, 0x7C,
  0x1F, 0x03, 0xC0, 0xF8, 0x3E, 0x03, 0xC1, 0xF0, 0x1F, 0x0F, 0x80, 0xF8,
  0x78, 0x07, 0xC7, 0xC0, 0x1E, 0x3E, 0x00, 0xF9, 0xE0, 0x07, 0xCF, 0x00,
  0x1E, 0xF8, 0x00, 0xF7, 0x80, 0x07, 0xBC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0x00, 0x07, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F,
  0xFE, 0x7F, 0xFE, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00,
  0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07,
  0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x1E, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x3F, 0x07, 0xFC,
  0x0F, 0xF0, 0x1F, 0x80, 0x3F, 0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x0F, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFC,
  0x00, 0xFF, 0x01, 0xFE, 0x00, 0xFC, 0x00, 0x78, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x03, 0xF8,
  0x0F, 0xF0, 0x3F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xFF, 0x01, 0xFC, 0x01, 0xF0,
  0x1F, 0xC0, 0xFE, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x03, 0xF8, 0x3F, 0xC0, 0xFE, 0x03, 0xF0, 0x0F, 0x00,
  0x00, 0x1C, 0x00, 0x17, 0xFC, 0x01, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE3,
  0xFF, 0xF8, 0x07, 0xFE, 0x80, 0x1F, 0x80,
};

const GFXglyph NotoSans_Condensed_Medium49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 6, 36, 12, 3, -35 },
  { 28, 14, 13, 20, 3, -35 },
  { 51, 24, 35, 26, 1, -35 },
  { 156, 19, 40, 24, 2, -37 },
  { 251, 33, 35, 36, 2, -35 },
  { 396, 26, 35, 28, 2, -35 },
  { 510, 5, 13, 11, 3, -35 },
  { 519, 12, 43, 15, 2, -35 },
  { 584, 12, 43, 15, 1, -35 },
  { 649, 18, 19, 22, 2, -37 },
  { 692, 20, 23, 24, 2, -29 },
  { 750, 7, 12, 12, 2, -6 },
  { 761, 12, 4, 14, 1, -15 },
  { 767, 6, 7, 12, 3, -6 },
  { 773, 17, 35, 19, 1, -35 },
  { 848, 19, 35, 23, 2, -35 },
  { 932, 13, 35, 23, 3, -35 },
  { 989, 19, 35, 23, 2, -35 },
  { 1073, 19, 35, 23, 2, -35 },
  { 1157, 22, 35, 23, 1, -35 },
  { 1254, 19, 35, 23, 2, -35 },
  { 1338, 20, 35, 23, 2, -35 },
  { 1426, 20, 35, 23, 2, -35 },
  { 1514, 20, 35, 23, 2, -35 },
  { 1602, 19, 35, 23, 2, -35 },
  { 1686, 6, 28, 12, 3, -27 },
  { 1707, 7, 33, 12, 2, -27 },
  { 1736, 20, 23, 24, 2, -29 },
  { 1794, 20, 14, 24, 2, -24 },
  { 1829, 20, 23, 24, 2, -29 },
  { 1887, 17, 36, 18, 0, -35 },
  { 1964, 32, 39, 36, 2, -35 },
  { 2120, 26, 35, 26, 0, -35 },
  { 2234, 20, 35, 26, 4, -35 },
  { 2322, 22, 36, 25, 2, -36 },
  { 2421, 22, 35, 29, 4, -35 },
  { 2518, 16, 35, 22, 4, -35 },
  { 2588, 16, 35, 21, 4, -35 },
  { 2658, 24, 35, 30, 3, -35 },
  { 2763, 22, 35, 30, 4, -35 },
  { 2860, 12, 35, 15, 2, -35 },
  { 2913, 12, 45, 12, -3, -35 },
  { 2981, 21, 35, 25, 4, -35 },
  { 3073, 16, 35, 21, 4, -35 },
  { 3143, 31, 35, 39, 4, -35 },
  { 3279, 24, 35, 32, 4, -35 },
  { 3384, 26, 35, 31, 2, -35 },
  { 3498, 19, 35, 25, 4, -35 },
  { 3582, 26, 43, 31, 2, -35 },
  { 3722, 21, 35, 26, 4, -35 },
  { 3814, 18, 36, 22, 2, -36 },
  { 3895, 20, 35, 22, 1, -35 },
  { 3983, 22, 35, 29, 4, -35 },
  { 4080, 25, 35, 25, 0, -35 },
  { 4190, 39, 35, 39, 0, -35 },
  { 4361, 23, 35, 23, 0, -35 },
  { 4462, 23, 35, 23, 0, -35 },
  { 4563, 19, 35, 21, 1, -35 },
  { 4647, 11, 43, 16, 3, -35 },
  { 4707, 17, 35, 19, 1, -35 },
  { 4782, 11, 43, 16, 1, -35 },
  { 4842, 22, 20, 24, 1, -35 },
  { 4897, 21, 3, 21, 0, 4 },
  { 4905, 10, 8, 14, 2, -38 },
  { 4915, 18, 27, 23, 2, -27 },
  { 4976, 20, 37, 25, 3, -37 },
  { 5069, 16, 27, 20, 2, -27 },
  { 5123, 20, 37, 25, 2, -37 },
  { 5216, 19, 27, 23, 2, -27 },
  { 5281, 15, 37, 14, 1, -37 },
  { 5351, 20, 39, 25, 2, -27 },
  { 5449, 19, 37, 25, 3, -37 },
  { 5537, 6, 37, 12, 3, -37 },
  { 5565, 10, 49, 12, -1, -37 },
  { 5627, 20, 37, 23, 3, -37 },
  { 5720, 5, 37, 12, 3, -37 },
  { 5744, 32, 27, 38, 3, -27 },
  { 5852, 19, 27, 25, 3, -27 },
  { 5917, 21, 27, 25, 2, -27 },
  { 5988, 20, 39, 25, 3, -27 },
  { 6086, 20, 39, 25, 2, -27 },
  { 6184, 14, 27, 17, 3, -27 },
  { 6232, 15, 27, 19, 2, -27 },
  { 6283, 13, 32, 15, 1, -32 },
  { 6335, 19, 26, 25, 3, -26 },
  { 6397, 21, 26, 21, 0, -26 },
  { 6466, 33, 26, 33, 0, -26 },
  { 6574, 20, 26, 21, 1, -26 },
  { 6639, 21, 38, 21, 0, -26 },
  { 6739, 16, 26, 18, 1, -26 },
  { 6791, 15, 43, 18, 1, -35 },
  { 6872, 4, 49, 22, 9, -37 },
  { 6897, 14, 43, 18, 2, -35 },
  { 6973, 20, 7, 24, 2, -21 },
};

const GFXfont NotoSans_Condensed_Medium49pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Medium49pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Medium49pt7bGlyphs,
  0x20, 0x7E, 67
};

#endif // _NOTOSANS_CONDENSED_MEDIUM49PT7B_H_
