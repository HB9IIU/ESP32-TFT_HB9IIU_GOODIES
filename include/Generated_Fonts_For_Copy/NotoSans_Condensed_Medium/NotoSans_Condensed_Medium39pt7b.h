#ifndef _NOTOSANS_CONDENSED_MEDIUM39PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUM39PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Medium.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Medium39pt7bBitmaps[] PROGMEM = {
  0x00, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B,
  0x9C, 0xE0, 0x00, 0x0F, 0x7F, 0xFE, 0xF0, 0xF1, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0E, 0x70, 0xE7, 0x0E, 0x70, 0xE7, 0x0E, 0x70, 0xE7, 0x0E, 0x03, 0x87,
  0x00, 0x70, 0xE0, 0x0E, 0x1C, 0x01, 0xC3, 0x80, 0x38, 0x70, 0x07, 0x1C,
  0x01, 0xC3, 0x80, 0x38, 0x70, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF,
  0x83, 0x87, 0x00, 0x71, 0xC0, 0x1C, 0x38, 0x03, 0x87, 0x00, 0x70, 0xE0,
  0x0E, 0x1C, 0x1F, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xE1, 0xC3, 0x80,
  0x38, 0x70, 0x07, 0x0E, 0x00, 0xE1, 0xC0, 0x1C, 0x38, 0x03, 0x8E, 0x00,
  0x61, 0xC0, 0x1C, 0x38, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x01, 0xFF, 0x87, 0xFF, 0xDF, 0xFF, 0x7D, 0x86, 0xF3, 0x01, 0xC6, 0x03,
  0x8C, 0x07, 0x98, 0x0F, 0xB0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF0, 0x07, 0xF8, 0x0D, 0xF0, 0x18, 0xF0, 0x31, 0xE0, 0x63, 0xC0, 0xC7,
  0xC1, 0x8F, 0xF3, 0x7D, 0xFF, 0xF3, 0xFF, 0xC1, 0xFE, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x3E, 0x00, 0x70, 0x3F, 0x80, 0x70, 0x1F,
  0xE0, 0x38, 0x1C, 0x70, 0x38, 0x0E, 0x38, 0x1C, 0x07, 0x0E, 0x1E, 0x03,
  0x87, 0x0E, 0x01, 0xC3, 0x87, 0x00, 0xE1, 0xC7, 0x00, 0x70, 0xE3, 0x80,
  0x38, 0x73, 0xC0, 0x1C, 0x39, 0xC7, 0xCE, 0x38, 0xE7, 0xF7, 0x1C, 0xE7,
  0xF9, 0xFE, 0x73, 0x9E, 0xFE, 0x73, 0xC7, 0x3E, 0x39, 0xC3, 0x80, 0x3C,
  0xE1, 0xC0, 0x1C, 0x70, 0xE0, 0x0E, 0x38, 0x70, 0x0E, 0x1C, 0x38, 0x07,
  0x0E, 0x1C, 0x07, 0x07, 0x0E, 0x03, 0x83, 0xC7, 0x01, 0xC0, 0xE3, 0x81,
  0xC0, 0x7F, 0x80, 0xE0, 0x1F, 0xC0, 0xE0, 0x07, 0xC0, 0x07, 0xF0, 0x00,
  0x7F, 0xC0, 0x07, 0xFF, 0x00, 0x3C, 0x78, 0x01, 0xC3, 0xC0, 0x0E, 0x0E,
  0x00, 0x70, 0x70, 0x03, 0x87, 0x80, 0x1E, 0x3C, 0x00, 0xF3, 0xC0, 0x03,
  0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x83,
  0xC7, 0xFE, 0x1E, 0x7C, 0xF0, 0xF3, 0xC3, 0xC7, 0x1E, 0x1F, 0x79, 0xE0,
  0x7F, 0xCF, 0x01, 0xFC, 0x78, 0x07, 0xE3, 0xE0, 0x3E, 0x0F, 0x01, 0xF8,
  0x7C, 0x3F, 0xE1, 0xFF, 0xEF, 0x0F, 0xFE, 0x7C, 0x1F, 0xE1, 0xF0, 0xFF,
  0xFF, 0x77, 0x77, 0x77, 0x07, 0x87, 0x83, 0x83, 0xC1, 0xC1, 0xE0, 0xE0,
  0xF0, 0x78, 0x38, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0x70, 0x3C, 0x1E, 0x07, 0x03,
  0xC1, 0xE0, 0x78, 0x1C, 0x0F, 0x03, 0xC0, 0xF0, 0x38, 0x0E, 0x07, 0x81,
  0xC0, 0xF0, 0x78, 0x1C, 0x0F, 0x07, 0x81, 0xC0, 0xE0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0E, 0x0F, 0x07,
  0x83, 0xC3, 0xC1, 0xE0, 0xE0, 0xF0, 0x70, 0x78, 0x78, 0x00, 0x03, 0xC0,
  0x07, 0x80, 0x0E, 0x00, 0x1C, 0x04, 0x38, 0x2E, 0x73, 0xDF, 0xFF, 0xFF,
  0xFF, 0x07, 0xC0, 0x0F, 0xC0, 0x3F, 0x80, 0xF3, 0x81, 0xE7, 0x87, 0x87,
  0x83, 0x0C, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x3C, 0xF3, 0xCE, 0x79, 0xE7, 0x1C, 0xF0, 0xFF, 0xFF,
  0xFF, 0xE0, 0x77, 0xFF, 0xF7, 0x80, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80,
  0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0x0F, 0xC0, 0x3F, 0xE0, 0xFF,
  0xE3, 0xE7, 0xC7, 0x83, 0xCF, 0x07, 0xBC, 0x0F, 0x78, 0x0E, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x07,
  0x9C, 0x0F, 0x3C, 0x1E, 0x7C, 0x78, 0x7F, 0xF0, 0x7F, 0xC0, 0x7F, 0x00,
  0x01, 0xE0, 0x7C, 0x1F, 0x87, 0xF1, 0xFE, 0x7B, 0xFE, 0x7B, 0x8F, 0x21,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x0F, 0xE0, 0x3F, 0xF8, 0x7F, 0xFC, 0x7C, 0x7C, 0x30,
  0x3E, 0x20, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F,
  0xF0, 0x3F, 0xF8, 0xFF, 0xFC, 0x78, 0x7E, 0x20, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x0F,
  0xF0, 0x0F, 0xC0, 0x0F, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x80, 0x1E, 0xE0,
  0x7E, 0xFF, 0xFC, 0xFF, 0xF8, 0x7F, 0xF0, 0x00, 0x3C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x0E, 0xF0, 0x07, 0x78,
  0x07, 0x3C, 0x03, 0x9E, 0x03, 0x8F, 0x01, 0xC7, 0x81, 0xC3, 0xC0, 0xE1,
  0xE0, 0xE0, 0xF0, 0xF0, 0x78, 0x70, 0x3C, 0x78, 0x1E, 0x38, 0x0F, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x7F, 0xF8, 0xFF, 0xF1, 0xFF,
  0xE3, 0xFF, 0xC7, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x07, 0xFF, 0x0F, 0xFF, 0x1F, 0xFF, 0x08, 0x3F, 0x00,
  0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x0F, 0x40, 0x3E, 0xE0, 0xFD, 0xFF, 0xF3, 0xFF, 0xC3, 0xFE, 0x00,
  0x03, 0xF8, 0x1F, 0xF0, 0x7F, 0xE0, 0xF8, 0x23, 0xC0, 0x0F, 0x00, 0x1E,
  0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC7, 0x07, 0xBF, 0x8E, 0xFF,
  0x9F, 0xFF, 0xBE, 0x0F, 0x78, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xFE, 0x03, 0xDC, 0x07, 0xBC, 0x1E, 0x7C, 0x7C, 0x7F,
  0xF0, 0x7F, 0xE0, 0x7F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1E,
  0x00, 0x07, 0xF0, 0x1F, 0xFC, 0x3F, 0xFC, 0x3C, 0x3E, 0x78, 0x1E, 0x78,
  0x0E, 0x78, 0x0F, 0x78, 0x0E, 0x78, 0x1E, 0x3C, 0x1E, 0x3E, 0x3C, 0x1F,
  0xFC, 0x0F, 0xF0, 0x07, 0xE0, 0x0F, 0xF8, 0x1F, 0xFC, 0x3C, 0x3E, 0x78,
  0x1E, 0x78, 0x0F, 0x70, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x78,
  0x0F, 0x7C, 0x1E, 0x3F, 0xFE, 0x1F, 0xFC, 0x0F, 0xF0, 0x07, 0xE0, 0x1F,
  0xF8, 0x3F, 0xFC, 0x3E, 0x7C, 0x78, 0x3E, 0x78, 0x1E, 0x78, 0x1E, 0x70,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x78, 0x0F, 0x78, 0x1F, 0x78,
  0x1F, 0x3E, 0x7F, 0x3F, 0xFF, 0x1F, 0xEF, 0x07, 0x8F, 0x00, 0x0E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x3F,
  0xF0, 0x3F, 0xE0, 0x3F, 0xC0, 0x7F, 0xFF, 0xF7, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7B, 0xFF, 0xF7, 0x80, 0x3D, 0xF7, 0xDF, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF3, 0xCF, 0x79, 0xE7,
  0x9C, 0x73, 0xC0, 0x00, 0x01, 0x00, 0x07, 0x00, 0x1F, 0x00, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x00,
  0x07, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0xC0,
  0x00, 0x1F, 0xC3, 0xFF, 0xC7, 0xFF, 0x9E, 0x3E, 0x40, 0x78, 0x00, 0xE0,
  0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x01,
  0xF0, 0x0F, 0x00, 0xF0, 0x01, 0xC0, 0xE0, 0x00, 0x70, 0xF0, 0x00, 0x38,
  0x70, 0x0C, 0x0E, 0x78, 0x3F, 0xC7, 0x38, 0x3F, 0xE3, 0xDC, 0x3C, 0x70,
  0xFE, 0x3C, 0x38, 0x7E, 0x1C, 0x1C, 0x3F, 0x0E, 0x0E, 0x1F, 0x87, 0x07,
  0x0F, 0xC7, 0x83, 0x87, 0xE3, 0xC3, 0xC3, 0xF0, 0xE1, 0xE1, 0xF8, 0x70,
  0xF0, 0xDC, 0x38, 0x78, 0xEE, 0x1E, 0x6C, 0x77, 0x07, 0xF7, 0xF1, 0xC3,
  0xF1, 0xF0, 0xE0, 0x20, 0x20, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xE0, 0x04, 0x00, 0xFE, 0x7E, 0x00, 0x3F, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xEE, 0x00, 0x0F, 0x70, 0x00, 0x73, 0xC0,
  0x07, 0x9E, 0x00, 0x3C, 0xF0, 0x01, 0xE3, 0xC0, 0x0E, 0x1E, 0x00, 0xF0,
  0xF0, 0x07, 0x83, 0x80, 0x3C, 0x1E, 0x01, 0xC0, 0xF0, 0x1F, 0xFF, 0x80,
  0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xC0, 0x3C, 0x1E, 0x00,
  0xF0, 0xF0, 0x07, 0x8F, 0x00, 0x3C, 0x78, 0x01, 0xF3, 0xC0, 0x07, 0xBE,
  0x00, 0x3D, 0xE0, 0x01, 0xF0, 0xFF, 0xE0, 0xFF, 0xF8, 0xFF, 0xFC, 0xFF,
  0xFE, 0xF0, 0x1E, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x1E, 0xF0, 0x1E, 0xF0, 0x7C, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xFC, 0xF0,
  0x3E, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x7E, 0xFF, 0xFE, 0xFF, 0xF8, 0xFF,
  0xF0, 0x01, 0xFE, 0x03, 0xFF, 0xC3, 0xFF, 0xC3, 0xF0, 0xE3, 0xE0, 0x11,
  0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x83, 0x0F, 0xFF, 0x81, 0xFF, 0xC0, 0x7F,
  0xC0, 0xFF, 0xC0, 0x3F, 0xFE, 0x0F, 0xFF, 0xC3, 0xFF, 0xF8, 0xF0, 0x3F,
  0x3C, 0x07, 0xCF, 0x00, 0xFB, 0xC0, 0x1E, 0xF0, 0x07, 0xBC, 0x01, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x1E, 0xF0, 0x07,
  0xBC, 0x03, 0xEF, 0x00, 0xF3, 0xC0, 0xFC, 0xF1, 0xFE, 0x3F, 0xFF, 0x0F,
  0xFF, 0x83, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0xFF, 0x7F, 0xFB, 0xFF, 0xDE, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x7F,
  0xFB, 0xFF, 0xDF, 0xFE, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x00,
  0x00, 0xFF, 0x80, 0xFF, 0xFC, 0x3F, 0xFF, 0x8F, 0xE1, 0xE3, 0xF0, 0x04,
  0x7C, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x3F, 0xFC, 0x07, 0xFF,
  0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xBC, 0x00, 0xF7,
  0x80, 0x1E, 0xF8, 0x03, 0xCF, 0x00, 0x79, 0xF0, 0x0F, 0x1F, 0x81, 0xE1,
  0xFF, 0xFC, 0x1F, 0xFF, 0x81, 0xFF, 0xC0, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0xFF,
  0xF7, 0xF8, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0,
  0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E,
  0x07, 0x81, 0xE0, 0x78, 0x1E, 0x1F, 0xEF, 0xFF, 0xFF, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x1E, 0xFF, 0x7F, 0xBF,
  0x9E, 0x00, 0xF0, 0x0F, 0xF8, 0x07, 0xBC, 0x07, 0x9E, 0x07, 0xCF, 0x03,
  0xC7, 0x83, 0xE3, 0xC1, 0xE1, 0xE1, 0xE0, 0xF1, 0xF0, 0x78, 0xF0, 0x3C,
  0xF0, 0x1E, 0xF8, 0x0F, 0x78, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0xC0,
  0xF9, 0xE0, 0x78, 0xF8, 0x3C, 0x3C, 0x1E, 0x1F, 0x0F, 0x07, 0x87, 0x83,
  0xE3, 0xC0, 0xF1, 0xE0, 0x7C, 0xF0, 0x1E, 0x78, 0x0F, 0xBC, 0x03, 0xDE,
  0x00, 0xF0, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x07,
  0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00,
  0xEF, 0xF7, 0x00, 0x77, 0xFB, 0x80, 0x7B, 0xFD, 0xE0, 0x39, 0xFE, 0x70,
  0x1C, 0xFF, 0x38, 0x1E, 0x7F, 0x9E, 0x0E, 0x3F, 0xCF, 0x07, 0x1F, 0xE3,
  0x87, 0x8F, 0xF1, 0xE3, 0x87, 0xF8, 0xF1, 0xC3, 0xFC, 0x38, 0xE1, 0xFE,
  0x1C, 0xF0, 0xFF, 0x0F, 0x70, 0x7F, 0x83, 0xB8, 0x3F, 0xC1, 0xFC, 0x1F,
  0xE0, 0xFC, 0x0F, 0xF0, 0x7E, 0x07, 0xF8, 0x1F, 0x03, 0xFC, 0x0F, 0x01,
  0xFE, 0x07, 0x80, 0xF0, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xF7,
  0x81, 0xFE, 0xF0, 0x3F, 0xCF, 0x07, 0xF9, 0xE0, 0xFF, 0x1E, 0x1F, 0xE3,
  0xC3, 0xFC, 0x3C, 0x7F, 0x87, 0x8F, 0xF0, 0x79, 0xFE, 0x0F, 0x3F, 0xC0,
  0xF7, 0xF8, 0x1E, 0xFF, 0x01, 0xEF, 0xE0, 0x3D, 0xFC, 0x03, 0xFF, 0x80,
  0x7F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x01, 0xF0, 0x03,
  0xFC, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x3F, 0x1F, 0x83, 0xE0, 0x3C,
  0x3E, 0x00, 0xF1, 0xE0, 0x07, 0x8F, 0x00, 0x1E, 0xF8, 0x00, 0xF7, 0xC0,
  0x07, 0xBC, 0x00, 0x3D, 0xE0, 0x01, 0xEF, 0x00, 0x0F, 0x78, 0x00, 0x7F,
  0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xF7, 0x80, 0x07, 0xBE, 0x00,
  0x3C, 0xF0, 0x01, 0xE7, 0x80, 0x0F, 0x3C, 0x00, 0xF1, 0xF0, 0x07, 0x87,
  0xC0, 0x7C, 0x1F, 0x0F, 0xC0, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x07, 0xFC,
  0x00, 0xFF, 0x81, 0xFF, 0xE3, 0xFF, 0xE7, 0xFF, 0xEF, 0x03, 0xFE, 0x07,
  0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF,
  0x03, 0xFE, 0x0F, 0xBF, 0xFE, 0x7F, 0xFC, 0xFF, 0xE1, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xF8, 0x07,
  0xFF, 0xE0, 0x3F, 0x1F, 0x83, 0xE0, 0x3E, 0x3E, 0x00, 0xF1, 0xE0, 0x07,
  0x8F, 0x00, 0x1E, 0xF8, 0x00, 0xF7, 0xC0, 0x07, 0xBC, 0x00, 0x3D, 0xE0,
  0x01, 0xEF, 0x00, 0x0F, 0x78, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0xF7, 0x80, 0x07, 0xBE, 0x00, 0x3C, 0xF0, 0x01, 0xE7, 0x80,
  0x0F, 0x3C, 0x00, 0xF9, 0xF0, 0x07, 0x87, 0xC0, 0x7C, 0x1F, 0x0F, 0xC0,
  0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFE, 0x1F, 0xFF, 0x8F, 0x03,
  0xE7, 0x80, 0xF3, 0xC0, 0x79, 0xE0, 0x3C, 0xF0, 0x1E, 0x78, 0x0F, 0x3C,
  0x07, 0x9E, 0x07, 0xCF, 0x07, 0xC7, 0xFF, 0xE3, 0xFF, 0xE1, 0xFF, 0xC0,
  0xFF, 0xE0, 0x78, 0x78, 0x3C, 0x3C, 0x1E, 0x0F, 0x0F, 0x07, 0x87, 0x83,
  0xE3, 0xC0, 0xF1, 0xE0, 0x7C, 0xF0, 0x1E, 0x78, 0x0F, 0xBC, 0x03, 0xDE,
  0x01, 0xF0, 0x0F, 0xF0, 0xFF, 0xF7, 0xFF, 0xDF, 0xBE, 0xF8, 0x0B, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x3F,
  0x80, 0x7F, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xE0, 0x1F, 0xF0, 0xFB, 0xFF, 0xEF,
  0xFF, 0x1F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x1E, 0xF0, 0x1F, 0x7E, 0x1F, 0x1F, 0xFF, 0x87, 0xFF,
  0x81, 0xFF, 0x00, 0xF0, 0x00, 0xFF, 0x00, 0x1E, 0x78, 0x01, 0xE7, 0x80,
  0x1E, 0x78, 0x01, 0xE7, 0x80, 0x3C, 0x3C, 0x03, 0xC3, 0xC0, 0x3C, 0x3C,
  0x03, 0x81, 0xC0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x0F, 0x00,
  0xE0, 0xF0, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x1E, 0x00, 0x79, 0xE0,
  0x07, 0x9E, 0x00, 0x79, 0xC0, 0x03, 0xBC, 0x00, 0x3B, 0xC0, 0x03, 0xFC,
  0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0xF0, 0x07, 0x80, 0x1F, 0xE0, 0x0F, 0x80, 0x79, 0xE0, 0x1F, 0x00,
  0xF3, 0xC0, 0x3E, 0x01, 0xE7, 0x80, 0x7C, 0x03, 0xCF, 0x01, 0xF8, 0x07,
  0x9E, 0x03, 0xB8, 0x1E, 0x1E, 0x07, 0x70, 0x3C, 0x3C, 0x0E, 0xE0, 0x78,
  0x78, 0x3D, 0xC0, 0xF0, 0xF0, 0x7B, 0xC1, 0xE0, 0xE0, 0xE7, 0x87, 0x81,
  0xE1, 0xC7, 0x0F, 0x03, 0xC3, 0x8E, 0x1E, 0x07, 0x8F, 0x1E, 0x3C, 0x0F,
  0x1E, 0x3C, 0x70, 0x0E, 0x38, 0x39, 0xE0, 0x1E, 0x70, 0x73, 0xC0, 0x3D,
  0xE0, 0xE7, 0x80, 0x7B, 0xC1, 0xEF, 0x00, 0x77, 0x03, 0xDC, 0x00, 0xEE,
  0x03, 0xF8, 0x01, 0xDC, 0x07, 0xF0, 0x03, 0xF8, 0x0F, 0xE0, 0x07, 0xF0,
  0x1F, 0x80, 0x07, 0xC0, 0x1F, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x1F, 0x00,
  0x7C, 0x00, 0x78, 0x03, 0xDF, 0x01, 0xE3, 0xC0, 0x78, 0xF0, 0x3C, 0x1E,
  0x0F, 0x07, 0x87, 0xC0, 0xF1, 0xE0, 0x3C, 0x78, 0x07, 0xBC, 0x01, 0xEF,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xEF, 0x00, 0x7B, 0xC0, 0x3C, 0xF0, 0x0F,
  0x1E, 0x07, 0x87, 0x81, 0xE0, 0xF0, 0xF0, 0x3C, 0x3C, 0x07, 0x9F, 0x01,
  0xE7, 0x80, 0x7F, 0xE0, 0x0F, 0xF0, 0x03, 0xDE, 0x01, 0xF7, 0x80, 0x79,
  0xF0, 0x1E, 0x3C, 0x0F, 0x0F, 0x03, 0xC1, 0xE0, 0xF0, 0x78, 0x78, 0x1E,
  0x1E, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x1E, 0xE0, 0x07, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00,
  0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0,
  0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07,
  0x80, 0x1E, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0,
  0x01, 0xE0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x80, 0x0E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x1E, 0x00,
  0x38, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x38, 0x00, 0xF0,
  0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xC0, 0x07,
  0xFF, 0xFF, 0xFF, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x07, 0xF0, 0x01, 0xDC, 0x00, 0xF7, 0x80, 0x38, 0xE0, 0x0E, 0x3C, 0x07,
  0x07, 0x01, 0xC1, 0xE0, 0xF0, 0x38, 0x38, 0x0F, 0x1E, 0x01, 0xC7, 0x00,
  0x7B, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xF0, 0xF8,
  0x78, 0x3C, 0x1E, 0x0F, 0x0F, 0xF0, 0x7F, 0xF0, 0x7F, 0xF0, 0xC1, 0xE0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x03, 0xFE, 0x3F, 0xFC, 0xFF,
  0xFB, 0xE0, 0xF7, 0x81, 0xEF, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF8, 0x3E,
  0xF0, 0xFD, 0xFF, 0xF9, 0xFE, 0x71, 0xF8, 0xE0, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xCF, 0xE3, 0xBF, 0xE7, 0x7F, 0xEF, 0xC3, 0xDF, 0x07, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xF0, 0x7F, 0xF0, 0xF7, 0x7F,
  0xEE, 0xFF, 0x9C, 0xFE, 0x00, 0x0F, 0xF8, 0xFF, 0x8F, 0xFC, 0xF8, 0x27,
  0x80, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x8F, 0xFC,
  0x7F, 0xE0, 0xFF, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x1F, 0xCF,
  0x3F, 0xEF, 0x7F, 0xFF, 0x7C, 0x3F, 0x78, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0x78, 0x1F, 0x7C, 0x3F, 0x7F, 0xFF,
  0x3F, 0xEF, 0x1F, 0xCF, 0x0F, 0xE0, 0x3F, 0xE0, 0xFF, 0xE3, 0xC1, 0xE7,
  0x83, 0xDE, 0x03, 0xBC, 0x07, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00,
  0xF8, 0x18, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0x80, 0x01, 0xF0, 0x3F, 0xC3,
  0xFC, 0x1F, 0x61, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xFF,
  0x3F, 0xF9, 0xFF, 0xC1, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x1F, 0xCF, 0x3F,
  0xEF, 0x7F, 0xFF, 0x7C, 0x3F, 0x78, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0x78, 0x1F, 0x7C, 0x3F, 0x7F, 0xEF, 0x3F,
  0xEF, 0x1F, 0xCF, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x60, 0x7C, 0x7F, 0xFC, 0x7F, 0xF8, 0x3F, 0xE0, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xCF, 0xE3, 0xBF, 0xE7, 0x7F, 0xEF, 0xC7, 0xDF, 0x07, 0xBC,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01,
  0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xFE, 0x03, 0xC0, 0x77, 0xFE, 0xF3, 0x00, 0x00, 0x7B,
  0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7,
  0x80, 0x0E, 0x1F, 0x1F, 0x0F, 0x06, 0x00, 0x00, 0x00, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x1E, 0x1E,
  0xFE, 0xFC, 0xF8, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x7F, 0xC1, 0xE7,
  0x83, 0xCF, 0x0F, 0x1E, 0x3C, 0x3C, 0xF8, 0x79, 0xE0, 0xE7, 0x81, 0xDE,
  0x03, 0xBE, 0x07, 0xFC, 0x0F, 0xFC, 0x1F, 0x78, 0x3C, 0x78, 0x78, 0xF8,
  0xF0, 0xF1, 0xE1, 0xF3, 0xC1, 0xE7, 0x83, 0xEF, 0x03, 0xDE, 0x07, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE7, 0xF0, 0xFC, 0x77, 0xFC, 0xFF, 0x3B, 0xFE, 0xFF,
  0xDF, 0x0F, 0xE1, 0xEF, 0x03, 0xE0, 0xF7, 0x81, 0xF0, 0x3F, 0xC0, 0xF0,
  0x1F, 0xE0, 0x78, 0x0F, 0xF0, 0x3C, 0x07, 0xF8, 0x1E, 0x03, 0xFC, 0x0F,
  0x01, 0xFE, 0x07, 0x80, 0xFF, 0x03, 0xC0, 0x7F, 0x81, 0xE0, 0x3F, 0xC0,
  0xF0, 0x1F, 0xE0, 0x78, 0x0F, 0xF0, 0x3C, 0x07, 0xF8, 0x1E, 0x03, 0xFC,
  0x0F, 0x01, 0xFE, 0x07, 0x80, 0xFF, 0x03, 0xC0, 0x78, 0xE7, 0xF1, 0xDF,
  0xF3, 0xBF, 0xF7, 0xC3, 0xEF, 0x83, 0xDE, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01,
  0xE0, 0x0F, 0xF0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7C, 0x3C, 0x78, 0x1E, 0xF0,
  0x1E, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1E, 0x78, 0x1E, 0x7C,
  0x3C, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF0, 0xE7, 0xF1, 0xDF, 0xF3, 0xBF,
  0xF7, 0xC1, 0xEF, 0x83, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xF8, 0x3F, 0xF8, 0xFB, 0xBF, 0xF7, 0x7F, 0xCE, 0x3F, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x00, 0x1F, 0xCF, 0x3F, 0xEF, 0x7F, 0xFF, 0x7C, 0x3F,
  0x78, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F,
  0x78, 0x1F, 0x7C, 0x3F, 0x7F, 0xEF, 0x3F, 0xEF, 0x1F, 0xCF, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0xE3, 0xF9, 0xFE, 0xFF, 0xFD, 0xF8, 0x3E, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x00, 0x1F, 0xF1, 0xFF, 0xDF, 0xFC,
  0xF0, 0x6F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xFC, 0x07,
  0xF8, 0x0F, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x7F, 0x07,
  0xFF, 0xFD, 0xFF, 0xC7, 0xFC, 0x00, 0x1C, 0x07, 0x01, 0xC0, 0xF0, 0x3C,
  0x1F, 0xFF, 0xFF, 0xFF, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xFF,
  0x1F, 0xC3, 0xF0, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F,
  0x00, 0xFE, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xF0,
  0xFF, 0xFF, 0xFB, 0xFE, 0xF3, 0xF9, 0xE0, 0xF0, 0x07, 0xB8, 0x07, 0x9E,
  0x03, 0xCF, 0x01, 0xE7, 0x80, 0xE1, 0xE0, 0xF0, 0xF0, 0x78, 0x78, 0x3C,
  0x1C, 0x3C, 0x0F, 0x1E, 0x07, 0x8F, 0x01, 0xC7, 0x00, 0xE7, 0x80, 0x7B,
  0xC0, 0x3D, 0xC0, 0x0E, 0xE0, 0x07, 0x70, 0x03, 0xF8, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0xF0, 0x1F, 0x03, 0xDE, 0x07, 0xC0, 0xF7, 0x81,
  0xF0, 0x3D, 0xE0, 0xFC, 0x0E, 0x78, 0x3F, 0x07, 0x8E, 0x0E, 0xE1, 0xE3,
  0xC3, 0xB8, 0x78, 0xF1, 0xEE, 0x1C, 0x3C, 0x73, 0x8F, 0x07, 0x1C, 0xF3,
  0xC1, 0xE7, 0x1C, 0xF0, 0x79, 0xC7, 0x38, 0x1E, 0xE1, 0xCE, 0x03, 0xB8,
  0x77, 0x80, 0xEE, 0x1F, 0xE0, 0x3B, 0x83, 0xF0, 0x0E, 0xE0, 0xFC, 0x03,
  0xF0, 0x3F, 0x00, 0x7C, 0x0F, 0xC0, 0x1F, 0x03, 0xF0, 0x07, 0xC0, 0x78,
  0x00, 0x78, 0x0F, 0x1E, 0x0F, 0x0F, 0x07, 0x83, 0xC7, 0x81, 0xE3, 0xC0,
  0x7B, 0xC0, 0x3D, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0xFC, 0x00, 0x7F, 0x00, 0x7B, 0xC0, 0x3D, 0xE0, 0x3C, 0x78, 0x1E,
  0x3C, 0x1E, 0x0F, 0x0F, 0x07, 0x8F, 0x01, 0xEF, 0x80, 0xF8, 0xF0, 0x07,
  0xBC, 0x07, 0x9E, 0x03, 0xCF, 0x01, 0xE3, 0x80, 0xE1, 0xE0, 0xF0, 0xF0,
  0x78, 0x78, 0x3C, 0x1E, 0x3C, 0x0F, 0x1E, 0x07, 0x8F, 0x01, 0xC7, 0x00,
  0xF7, 0x80, 0x7B, 0xC0, 0x1D, 0xC0, 0x0E, 0xE0, 0x07, 0xF0, 0x01, 0xF8,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x03,
  0xE0, 0x00, 0x7F, 0xF7, 0xFF, 0x7F, 0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x03,
  0xC0, 0x3C, 0x07, 0x80, 0x78, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x3C,
  0x03, 0xC0, 0x78, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0,
  0x3F, 0x07, 0xF0, 0x7C, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x07, 0xE0, 0xFC, 0x0F,
  0x80, 0xFE, 0x01, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x7F, 0x03, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x0F, 0xC0,
  0xFE, 0x03, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x80, 0x7E, 0x03, 0xF0, 0x1F,
  0x07, 0xF0, 0x78, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x0F, 0xE0, 0xFC, 0x0F, 0x80,
  0x00, 0x01, 0x7F, 0x01, 0xFF, 0xE3, 0xFF, 0xFF, 0xC1, 0xFF, 0x80, 0x3C,
};

const GFXglyph NotoSans_Condensed_Medium39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 5, 28, 10, 2, -28 },
  { 19, 12, 10, 16, 2, -28 },
  { 34, 19, 28, 20, 1, -28 },
  { 101, 15, 32, 19, 2, -30 },
  { 161, 25, 28, 29, 2, -28 },
  { 249, 21, 28, 22, 1, -28 },
  { 323, 4, 10, 9, 2, -28 },
  { 328, 9, 34, 12, 2, -28 },
  { 367, 9, 34, 12, 1, -28 },
  { 406, 15, 15, 18, 1, -30 },
  { 435, 16, 18, 19, 1, -23 },
  { 471, 6, 9, 10, 1, -4 },
  { 478, 9, 3, 12, 1, -12 },
  { 482, 5, 5, 10, 2, -5 },
  { 486, 14, 28, 15, 1, -28 },
  { 535, 15, 28, 19, 2, -28 },
  { 588, 11, 28, 19, 2, -28 },
  { 627, 16, 28, 19, 1, -28 },
  { 683, 16, 28, 19, 1, -28 },
  { 739, 17, 28, 19, 1, -28 },
  { 799, 15, 28, 19, 2, -28 },
  { 852, 15, 28, 19, 2, -28 },
  { 905, 16, 28, 19, 1, -28 },
  { 961, 16, 28, 19, 1, -28 },
  { 1017, 16, 28, 19, 1, -28 },
  { 1073, 5, 21, 10, 2, -21 },
  { 1087, 6, 26, 10, 1, -21 },
  { 1107, 16, 18, 19, 1, -23 },
  { 1143, 16, 11, 19, 1, -19 },
  { 1165, 16, 18, 19, 1, -23 },
  { 1201, 14, 28, 14, 0, -28 },
  { 1250, 25, 31, 29, 2, -28 },
  { 1347, 21, 28, 21, 0, -28 },
  { 1421, 16, 28, 21, 3, -28 },
  { 1477, 17, 28, 20, 2, -28 },
  { 1537, 18, 28, 23, 3, -28 },
  { 1600, 13, 28, 18, 3, -28 },
  { 1646, 13, 28, 17, 3, -28 },
  { 1692, 19, 28, 24, 2, -28 },
  { 1759, 18, 28, 24, 3, -28 },
  { 1822, 10, 28, 12, 1, -28 },
  { 1857, 9, 36, 10, -2, -28 },
  { 1898, 17, 28, 20, 3, -28 },
  { 1958, 13, 28, 17, 3, -28 },
  { 2004, 25, 28, 31, 3, -28 },
  { 2092, 19, 28, 25, 3, -28 },
  { 2159, 21, 28, 25, 2, -28 },
  { 2233, 15, 28, 20, 3, -28 },
  { 2286, 21, 35, 25, 2, -28 },
  { 2378, 17, 28, 20, 3, -28 },
  { 2438, 14, 28, 18, 2, -28 },
  { 2487, 17, 28, 17, 0, -28 },
  { 2547, 17, 28, 23, 3, -28 },
  { 2607, 20, 28, 20, 0, -28 },
  { 2677, 31, 28, 31, 0, -28 },
  { 2786, 18, 28, 19, 0, -28 },
  { 2849, 18, 28, 18, 0, -28 },
  { 2912, 15, 28, 17, 1, -28 },
  { 2965, 8, 34, 12, 3, -28 },
  { 2999, 14, 28, 15, 0, -28 },
  { 3048, 9, 34, 12, 1, -28 },
  { 3087, 18, 16, 19, 1, -28 },
  { 3123, 17, 3, 17, 0, 3 },
  { 3130, 8, 6, 11, 2, -30 },
  { 3136, 15, 21, 18, 1, -21 },
  { 3176, 15, 30, 20, 3, -30 },
  { 3233, 13, 21, 16, 2, -21 },
  { 3268, 16, 30, 20, 2, -30 },
  { 3328, 15, 21, 18, 2, -21 },
  { 3368, 13, 30, 11, 0, -30 },
  { 3417, 16, 30, 20, 2, -21 },
  { 3477, 15, 30, 20, 3, -30 },
  { 3534, 5, 29, 9, 2, -29 },
  { 3553, 8, 38, 9, -1, -29 },
  { 3591, 15, 30, 18, 3, -30 },
  { 3648, 4, 30, 9, 3, -30 },
  { 3663, 25, 21, 30, 3, -21 },
  { 3729, 15, 21, 20, 3, -21 },
  { 3769, 16, 21, 20, 2, -21 },
  { 3811, 15, 30, 20, 3, -21 },
  { 3868, 16, 30, 20, 2, -21 },
  { 3928, 10, 21, 14, 3, -21 },
  { 3955, 13, 21, 15, 1, -21 },
  { 3990, 10, 26, 12, 1, -26 },
  { 4023, 15, 21, 20, 3, -21 },
  { 4063, 17, 21, 17, 0, -21 },
  { 4108, 26, 21, 27, 0, -21 },
  { 4177, 17, 21, 17, 0, -21 },
  { 4222, 17, 30, 17, 0, -21 },
  { 4286, 12, 21, 14, 1, -21 },
  { 4318, 12, 34, 14, 1, -28 },
  { 4369, 4, 39, 18, 7, -30 },
  { 4389, 12, 34, 14, 1, -28 },
  { 4440, 16, 6, 19, 1, -17 },
};

const GFXfont NotoSans_Condensed_Medium39pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Medium39pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Medium39pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _NOTOSANS_CONDENSED_MEDIUM39PT7B_H_
