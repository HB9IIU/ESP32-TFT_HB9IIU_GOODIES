#ifndef _NOTOSANS_CONDENSED_MEDIUM24PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUM24PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Medium.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Medium24pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x00, 0x6F, 0x60, 0xE7, 0xCD,
  0x9B, 0x36, 0x6C, 0xC0, 0x0C, 0x60, 0xC4, 0x0C, 0xC0, 0xCC, 0x0C, 0xC7,
  0xFF, 0x08, 0xC1, 0x88, 0x19, 0x81, 0x98, 0xFF, 0xFF, 0xFF, 0x11, 0x81,
  0x18, 0x31, 0x03, 0x30, 0x33, 0x00, 0x08, 0x04, 0x0F, 0xEF, 0xFE, 0x8E,
  0x43, 0x21, 0xD0, 0x7C, 0x0F, 0x83, 0xE1, 0x30, 0x98, 0x4F, 0x2F, 0xFE,
  0x3E, 0x04, 0x02, 0x00, 0x78, 0x30, 0xEC, 0x30, 0xCC, 0x60, 0xCC, 0x60,
  0xCC, 0x60, 0xCC, 0xC0, 0xCC, 0xC8, 0xCD, 0x9E, 0x6D, 0xB6, 0x7B, 0x33,
  0x03, 0x23, 0x03, 0x23, 0x06, 0x23, 0x06, 0x33, 0x0C, 0x33, 0x0C, 0x3E,
  0x18, 0x1E, 0x3E, 0x01, 0xF8, 0x1C, 0xC0, 0xC6, 0x07, 0x30, 0x1B, 0x80,
  0xF8, 0x03, 0x80, 0x3C, 0x33, 0xF3, 0xB9, 0xDD, 0x86, 0xCC, 0x3E, 0x60,
  0xE3, 0x8F, 0x8F, 0xEE, 0x3E, 0x78, 0xFD, 0xB6, 0xC0, 0x1C, 0xE3, 0x1C,
  0x61, 0x8E, 0x38, 0xC3, 0x0C, 0x30, 0xE3, 0x86, 0x18, 0x60, 0xC3, 0x06,
  0x1C, 0xC3, 0x18, 0x63, 0x1C, 0xE3, 0x18, 0xC6, 0x31, 0x8C, 0xE6, 0x33,
  0x99, 0xCC, 0x00, 0x1C, 0x0C, 0x22, 0x3F, 0xFF, 0xF8, 0xE0, 0xD8, 0xEE,
  0x22, 0x00, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x3F, 0xF0, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x76, 0x6E, 0xCC, 0xFF, 0xFE, 0x7D, 0x80, 0x03,
  0x81, 0x80, 0xC0, 0xE0, 0x60, 0x30, 0x30, 0x18, 0x1C, 0x0C, 0x06, 0x07,
  0x03, 0x01, 0x81, 0xC0, 0xC0, 0xE0, 0x00, 0x3E, 0x3F, 0x98, 0xFC, 0x3E,
  0x1F, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x7C, 0x3E, 0x1F, 0x1D, 0x8E,
  0xFE, 0x3E, 0x00, 0x1C, 0xF7, 0xFB, 0xCC, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x7E, 0x7F, 0x90, 0xE0, 0x70, 0x18, 0x1C, 0x0E,
  0x06, 0x07, 0x07, 0x03, 0x03, 0x03, 0x83, 0x83, 0x81, 0xFF, 0xFF, 0x80,
  0x7E, 0x7F, 0x90, 0xE0, 0x30, 0x18, 0x1C, 0x1C, 0x7C, 0x3E, 0x03, 0xC0,
  0xE0, 0x30, 0x18, 0x0E, 0x0F, 0xFE, 0xFE, 0x00, 0x03, 0x80, 0x70, 0x1E,
  0x03, 0xC0, 0xD8, 0x1B, 0x06, 0x60, 0xCC, 0x31, 0x8C, 0x31, 0x86, 0x7F,
  0xFF, 0xFE, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x7F, 0x3F, 0x98, 0x0C,
  0x06, 0x03, 0x01, 0xF1, 0xFE, 0x6F, 0x81, 0xC0, 0x60, 0x30, 0x18, 0x0E,
  0x0F, 0xFE, 0xFE, 0x00, 0x1F, 0x8F, 0xE7, 0x01, 0x80, 0x60, 0x38, 0x0C,
  0xE3, 0x7C, 0xF3, 0xB8, 0x6C, 0x1B, 0x07, 0xE1, 0x98, 0x67, 0x39, 0xFC,
  0x3E, 0x00, 0xFF, 0xFF, 0xF0, 0x18, 0x06, 0x03, 0x80, 0xC0, 0x70, 0x18,
  0x06, 0x03, 0x80, 0xC0, 0x30, 0x1C, 0x06, 0x03, 0x80, 0xE0, 0x70, 0x00,
  0x3F, 0x1F, 0xEE, 0x3B, 0x86, 0xE1, 0x98, 0xE7, 0x70, 0xF8, 0x3E, 0x1D,
  0xCE, 0x3B, 0x06, 0xC1, 0xF0, 0x7E, 0x19, 0xFE, 0x3F, 0x00, 0x3E, 0x3F,
  0xB8, 0xF8, 0x3C, 0x1E, 0x0F, 0x07, 0xC3, 0xE7, 0xBF, 0xCE, 0x60, 0x30,
  0x38, 0x18, 0x1C, 0xFC, 0x7C, 0x00, 0x7D, 0x80, 0x00, 0x01, 0xF6, 0x7D,
  0x80, 0x00, 0x01, 0xB7, 0xF6, 0x00, 0xC0, 0xF0, 0xF0, 0xF0, 0xF0, 0x38,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x70, 0x04, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFC, 0x80, 0x38, 0x07, 0x80, 0x78, 0x07, 0x80, 0x70,
  0x78, 0x78, 0x78, 0x38, 0x08, 0x00, 0x7E, 0xFF, 0x43, 0x03, 0x03, 0x03,
  0x07, 0x0E, 0x1C, 0x18, 0x18, 0x18, 0x00, 0x00, 0x38, 0x38, 0x38, 0x07,
  0xF0, 0x1E, 0x78, 0x38, 0x0C, 0x30, 0x0E, 0x61, 0xC6, 0x63, 0xE6, 0x46,
  0x62, 0xC6, 0x63, 0xCC, 0x63, 0xCC, 0x63, 0xCC, 0x62, 0xCC, 0x66, 0xC6,
  0xF6, 0x67, 0xBC, 0x60, 0x00, 0x70, 0x00, 0x38, 0x10, 0x1F, 0xF0, 0x07,
  0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1B, 0x00, 0xD8, 0x0E, 0xC0, 0x67,
  0x03, 0x18, 0x38, 0xC1, 0xC7, 0x0F, 0xF8, 0x7F, 0xC7, 0x06, 0x38, 0x39,
  0x81, 0xDC, 0x06, 0xE0, 0x38, 0xFF, 0x3F, 0xEC, 0x3B, 0x07, 0xC1, 0xF0,
  0x6C, 0x3B, 0xFC, 0xFF, 0x30, 0xEC, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x3B,
  0xFE, 0xFE, 0x00, 0x0F, 0xE7, 0xF8, 0xE1, 0x38, 0x06, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x06, 0x00, 0xE0, 0x0E, 0x11,
  0xFE, 0x0F, 0xC0, 0xFE, 0x1F, 0xF3, 0x0F, 0x60, 0xEC, 0x0D, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0D, 0x83, 0xB0, 0xE7,
  0xF8, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFE, 0xFE,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xFE, 0xFE, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0x0F, 0xE1, 0xFF, 0x38, 0x27, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0E,
  0x00, 0xE1, 0xFE, 0x1F, 0xE0, 0x36, 0x03, 0x60, 0x37, 0x03, 0x38, 0x33,
  0xFF, 0x0F, 0xF0, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xE0, 0xFD, 0xE7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C,
  0x71, 0xC7, 0x3E, 0xFC, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31,
  0x8C, 0x63, 0x18, 0xC7, 0xFF, 0x70, 0xC1, 0xF0, 0x6C, 0x3B, 0x1C, 0xC6,
  0x33, 0x8D, 0xC3, 0x60, 0xFC, 0x3B, 0x0C, 0xE3, 0x1C, 0xC7, 0x30, 0xEC,
  0x3B, 0x07, 0xC1, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xFF, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x81, 0xFD, 0x83, 0x7B, 0x06, 0xF6, 0x0D, 0xEE, 0x33,
  0xCC, 0x67, 0x98, 0xCF, 0x3B, 0x1E, 0x36, 0x3C, 0x6C, 0x78, 0xF8, 0xF0,
  0xE1, 0xE1, 0xC3, 0xC3, 0x86, 0xE0, 0x7F, 0x07, 0xF0, 0x7F, 0x87, 0xD8,
  0x7D, 0xC7, 0xCC, 0x7C, 0xE7, 0xC6, 0x7C, 0x77, 0xC3, 0x7C, 0x3F, 0xC3,
  0xFC, 0x1F, 0xC1, 0xFC, 0x0F, 0xC0, 0xF0, 0x1F, 0xC1, 0xFF, 0x1E, 0x1C,
  0xE0, 0xE6, 0x03, 0x70, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x76, 0x03, 0x38, 0x38, 0xE3, 0x87, 0xFC, 0x0F, 0xC0, 0xFE,
  0x7F, 0xB0, 0xF8, 0x7C, 0x1E, 0x0F, 0x07, 0x87, 0xFF, 0x7F, 0x3C, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x00, 0x1F, 0xC1, 0xFF, 0x1E, 0x1C,
  0xE0, 0xE6, 0x03, 0x70, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x76, 0x03, 0x38, 0x38, 0xE3, 0xC7, 0xFC, 0x1F, 0xC0, 0x0E,
  0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0xFE, 0x3F, 0xCC, 0x3B, 0x06, 0xC1,
  0xB0, 0x6C, 0x3B, 0x0E, 0xFF, 0x3F, 0x8C, 0xE3, 0x1C, 0xC7, 0x30, 0xEC,
  0x3B, 0x07, 0xC1, 0xC0, 0x3F, 0xBF, 0xF8, 0x5C, 0x0E, 0x07, 0x01, 0xC0,
  0xF8, 0x3E, 0x07, 0x80, 0xE0, 0x70, 0x18, 0x1E, 0x0F, 0xFE, 0xFE, 0x00,
  0xFF, 0xFF, 0xF0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x00, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0xC1, 0xB8, 0x73, 0xFC, 0x3F, 0x00, 0xE0, 0x7E,
  0x07, 0x60, 0x66, 0x06, 0x70, 0xE3, 0x0E, 0x30, 0xC3, 0x0C, 0x39, 0xC1,
  0x9C, 0x19, 0x81, 0x98, 0x1F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x00,
  0xE0, 0xE0, 0xFC, 0x1C, 0x1D, 0x83, 0x83, 0x30, 0x50, 0x66, 0x1B, 0x1C,
  0xE3, 0x63, 0x8C, 0x6C, 0x61, 0x8D, 0x8C, 0x33, 0x39, 0x87, 0x63, 0x70,
  0xEC, 0x6E, 0x0D, 0x8D, 0x81, 0xB1, 0xB0, 0x3C, 0x1E, 0x07, 0x83, 0xC0,
  0x70, 0x78, 0x0E, 0x0E, 0x00, 0xE0, 0xEE, 0x18, 0xC7, 0x1C, 0xC1, 0xB8,
  0x3E, 0x03, 0xC0, 0x78, 0x0E, 0x01, 0xE0, 0x7C, 0x0D, 0xC3, 0x98, 0x63,
  0x9C, 0x33, 0x07, 0xE0, 0xE0, 0xE0, 0xEC, 0x1D, 0xC3, 0x18, 0xE3, 0x18,
  0x77, 0x06, 0xC0, 0xF8, 0x0F, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x00, 0xFF, 0xFF, 0xC0, 0xC0, 0xE0, 0x60, 0x70,
  0x30, 0x38, 0x18, 0x1C, 0x0C, 0x0E, 0x06, 0x07, 0x03, 0x81, 0xFF, 0xFF,
  0x80, 0xFF, 0xF1, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6,
  0x31, 0xFF, 0x80, 0xE0, 0x30, 0x1C, 0x06, 0x03, 0x01, 0xC0, 0x60, 0x30,
  0x0C, 0x06, 0x03, 0x00, 0xC0, 0x60, 0x38, 0x0C, 0x06, 0x03, 0x80, 0xFF,
  0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC7, 0xFF,
  0x80, 0x0C, 0x07, 0x01, 0xE0, 0x78, 0x33, 0x0C, 0xC6, 0x19, 0x86, 0xC0,
  0xF0, 0x30, 0xFF, 0xFF, 0xF0, 0xE3, 0x8E, 0x3E, 0x3F, 0x90, 0xE0, 0x70,
  0x38, 0xFD, 0xFF, 0xC7, 0xC3, 0xE1, 0xF0, 0xFF, 0xB7, 0x98, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0xF3, 0xFD, 0xC7, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0xC7, 0xFF, 0x6F, 0x00, 0x1F, 0x7F, 0x70, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x71, 0x7F, 0x3F, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xCF, 0x77, 0xED, 0x8F, 0xE1, 0xF8, 0x7E, 0x1F, 0x07, 0xE1,
  0xF8, 0x7E, 0x1D, 0x87, 0x7E, 0xCF, 0x30, 0x3E, 0x3F, 0x98, 0xFC, 0x3E,
  0x1F, 0xFF, 0xFF, 0x80, 0xE0, 0x70, 0x1C, 0x2F, 0xF3, 0xF8, 0x1F, 0x3E,
  0x38, 0x30, 0x30, 0x7E, 0xFE, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30,
  0x30, 0x30, 0x30, 0x30, 0x3C, 0xDF, 0xB6, 0x3F, 0x87, 0xE1, 0xF8, 0x7C,
  0x1F, 0x87, 0xE1, 0xF8, 0x76, 0x1D, 0xFF, 0x3D, 0xC0, 0x70, 0x1C, 0x06,
  0x63, 0x9F, 0xC3, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0xF3, 0xFD,
  0xC7, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1,
  0xC0, 0x7D, 0x80, 0xDB, 0x6D, 0xB6, 0xDB, 0x6C, 0x19, 0xC6, 0x00, 0x0C,
  0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0xDF, 0xDC, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x1F, 0x1D, 0x9C, 0xCC, 0x6E, 0x3E, 0x1F,
  0x8E, 0xC6, 0x73, 0x19, 0x8E, 0xC3, 0x61, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xDE, 0x7D, 0xFF, 0xFB, 0x8E, 0x3E, 0x1C, 0x3C, 0x38, 0x78, 0x70,
  0xF0, 0xE1, 0xE1, 0xC3, 0xC3, 0x87, 0x87, 0x0F, 0x0E, 0x1E, 0x1C, 0x3C,
  0x38, 0x60, 0xDE, 0x7F, 0xB8, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x38, 0x3F, 0x1F, 0xE6, 0x1B, 0x87, 0xE1, 0xF8,
  0x7C, 0x0F, 0x83, 0xE1, 0xF8, 0x76, 0x19, 0xFE, 0x3F, 0x00, 0xDE, 0x7F,
  0xB8, 0xF8, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF8, 0xFF, 0xED,
  0xE6, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x00, 0x3C, 0xDF, 0xB6, 0x3F,
  0x87, 0xE1, 0xF8, 0x7C, 0x1F, 0x87, 0xE1, 0xF8, 0x76, 0x1D, 0xFF, 0x3D,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0xDF, 0xFF, 0x38, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC0, 0x7E, 0xFE, 0xC2, 0xC0, 0xE0, 0x78,
  0x3C, 0x1E, 0x06, 0x07, 0x86, 0xFE, 0xFC, 0x10, 0x60, 0xC3, 0xFF, 0xE6,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0F, 0x8F, 0xC3, 0xE1, 0xF0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF1, 0xFF, 0xB7, 0xD8,
  0xE0, 0xF8, 0x76, 0x1D, 0x86, 0x71, 0x8C, 0xE3, 0x30, 0xCC, 0x1B, 0x07,
  0xC1, 0xE0, 0x78, 0x0E, 0x00, 0xE1, 0xC3, 0x61, 0xC7, 0x63, 0xC7, 0x63,
  0xC6, 0x73, 0x46, 0x73, 0x66, 0x36, 0x6E, 0x36, 0x6C, 0x36, 0x6C, 0x3E,
  0x2C, 0x1C, 0x3C, 0x1C, 0x38, 0x1C, 0x38, 0xE1, 0xDC, 0x63, 0x38, 0xEC,
  0x1F, 0x07, 0x80, 0xE0, 0x78, 0x1F, 0x0E, 0xC3, 0x39, 0xC6, 0xE1, 0xC0,
  0xE0, 0xD8, 0x76, 0x1D, 0xC6, 0x71, 0x8C, 0xE3, 0x30, 0xEC, 0x1B, 0x07,
  0xC1, 0xE0, 0x38, 0x0E, 0x03, 0x00, 0xC0, 0x70, 0x38, 0x3E, 0x0E, 0x00,
  0xFF, 0xFC, 0x38, 0x61, 0xC3, 0x0E, 0x18, 0x70, 0xC3, 0x87, 0xFF, 0xE0,
  0x0E, 0x3C, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x31, 0xE3, 0x83, 0x83, 0x07,
  0x0E, 0x1C, 0x38, 0x70, 0xE0, 0xF0, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE1, 0xE0, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x38,
  0x3C, 0x38, 0xE3, 0x86, 0x0C, 0x18, 0x30, 0x60, 0xC7, 0x8C, 0x00, 0xF8,
  0x7F, 0xF8, 0xF8,
};

const GFXglyph NotoSans_Condensed_Medium24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 4, 17, 6, 1, -17 },
  { 10, 7, 6, 10, 1, -17 },
  { 16, 12, 17, 13, 0, -17 },
  { 42, 9, 19, 12, 1, -18 },
  { 64, 16, 17, 18, 1, -17 },
  { 98, 13, 17, 14, 1, -17 },
  { 126, 3, 6, 5, 1, -17 },
  { 129, 6, 21, 7, 1, -17 },
  { 145, 5, 21, 7, 1, -17 },
  { 159, 9, 9, 11, 1, -18 },
  { 170, 10, 11, 12, 1, -14 },
  { 184, 4, 6, 6, 1, -3 },
  { 187, 5, 3, 7, 1, -8 },
  { 189, 3, 3, 6, 1, -3 },
  { 191, 9, 17, 9, 0, -17 },
  { 211, 9, 17, 11, 1, -17 },
  { 231, 6, 17, 11, 2, -17 },
  { 244, 9, 17, 11, 1, -17 },
  { 264, 9, 17, 11, 1, -17 },
  { 284, 11, 17, 11, 0, -17 },
  { 308, 9, 17, 11, 1, -17 },
  { 328, 10, 17, 11, 1, -17 },
  { 350, 10, 17, 11, 1, -17 },
  { 372, 10, 17, 11, 1, -17 },
  { 394, 9, 17, 11, 1, -17 },
  { 414, 3, 13, 6, 1, -13 },
  { 419, 3, 16, 6, 1, -13 },
  { 425, 10, 11, 12, 1, -14 },
  { 439, 10, 7, 12, 1, -12 },
  { 448, 10, 11, 12, 1, -14 },
  { 462, 8, 17, 9, 0, -17 },
  { 479, 16, 19, 18, 1, -17 },
  { 517, 13, 17, 13, 0, -17 },
  { 545, 10, 17, 13, 2, -17 },
  { 567, 11, 17, 12, 1, -17 },
  { 591, 11, 17, 14, 2, -17 },
  { 615, 8, 17, 11, 2, -17 },
  { 632, 8, 17, 10, 2, -17 },
  { 649, 12, 17, 14, 1, -17 },
  { 675, 11, 17, 15, 2, -17 },
  { 699, 6, 17, 7, 1, -17 },
  { 712, 5, 22, 6, -1, -17 },
  { 726, 10, 17, 12, 2, -17 },
  { 748, 8, 17, 10, 2, -17 },
  { 765, 15, 17, 19, 2, -17 },
  { 797, 12, 17, 15, 2, -17 },
  { 823, 13, 17, 15, 1, -17 },
  { 851, 9, 17, 12, 2, -17 },
  { 871, 13, 21, 15, 1, -17 },
  { 906, 10, 17, 13, 2, -17 },
  { 928, 9, 17, 11, 1, -17 },
  { 948, 10, 17, 11, 0, -17 },
  { 970, 11, 17, 14, 2, -17 },
  { 994, 12, 17, 12, 0, -17 },
  { 1020, 19, 17, 19, 0, -17 },
  { 1061, 11, 17, 11, 0, -17 },
  { 1085, 11, 17, 11, 0, -17 },
  { 1109, 9, 17, 10, 1, -17 },
  { 1129, 5, 21, 8, 2, -17 },
  { 1143, 9, 17, 9, 0, -17 },
  { 1163, 5, 21, 8, 1, -17 },
  { 1177, 10, 10, 12, 1, -17 },
  { 1190, 10, 2, 10, 0, 2 },
  { 1193, 5, 3, 7, 1, -18 },
  { 1195, 9, 13, 11, 1, -13 },
  { 1210, 9, 18, 12, 2, -18 },
  { 1231, 8, 13, 10, 1, -13 },
  { 1244, 10, 18, 12, 1, -18 },
  { 1267, 9, 13, 11, 1, -13 },
  { 1282, 8, 18, 7, 0, -18 },
  { 1300, 10, 19, 12, 1, -13 },
  { 1324, 9, 18, 12, 2, -18 },
  { 1345, 3, 18, 6, 1, -18 },
  { 1352, 5, 24, 6, -1, -18 },
  { 1367, 9, 18, 11, 2, -18 },
  { 1388, 2, 18, 6, 2, -18 },
  { 1393, 15, 13, 19, 2, -13 },
  { 1418, 9, 13, 12, 2, -13 },
  { 1433, 10, 13, 12, 1, -13 },
  { 1450, 9, 19, 12, 2, -13 },
  { 1472, 10, 19, 12, 1, -13 },
  { 1496, 6, 13, 8, 2, -13 },
  { 1506, 8, 13, 9, 1, -13 },
  { 1519, 7, 16, 7, 0, -16 },
  { 1533, 9, 13, 12, 2, -13 },
  { 1548, 10, 13, 10, 0, -13 },
  { 1565, 16, 13, 16, 0, -13 },
  { 1591, 10, 13, 10, 0, -13 },
  { 1608, 10, 19, 10, 0, -13 },
  { 1632, 7, 13, 9, 1, -13 },
  { 1644, 7, 21, 9, 1, -17 },
  { 1663, 3, 24, 11, 4, -18 },
  { 1672, 7, 21, 9, 1, -17 },
  { 1691, 10, 3, 12, 1, -10 },
};

const GFXfont NotoSans_Condensed_Medium24pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Medium24pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Medium24pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _NOTOSANS_CONDENSED_MEDIUM24PT7B_H_
