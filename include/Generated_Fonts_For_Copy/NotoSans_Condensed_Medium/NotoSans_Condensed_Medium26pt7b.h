#ifndef _NOTOSANS_CONDENSED_MEDIUM26PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUM26PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Medium.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Medium26pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xDB, 0x6D, 0x80, 0xFF, 0x80, 0xE7, 0x67, 0x67,
  0x63, 0x63, 0x63, 0x63, 0x0C, 0xC0, 0xCC, 0x0C, 0xC1, 0x8C, 0x18, 0xC1,
  0x8C, 0xFF, 0xFF, 0xFF, 0x19, 0x81, 0x98, 0x31, 0x83, 0x18, 0xFF, 0xEF,
  0xFE, 0x33, 0x03, 0x30, 0x33, 0x06, 0x30, 0x63, 0x00, 0x04, 0x01, 0x00,
  0xE0, 0xFF, 0x7F, 0xF9, 0x0E, 0x43, 0x90, 0x74, 0x1F, 0x03, 0xF0, 0x1E,
  0x05, 0xC1, 0x30, 0x4E, 0x13, 0xF7, 0xFF, 0xE1, 0xE0, 0x10, 0x04, 0x01,
  0x00, 0x38, 0x1C, 0x3E, 0x0C, 0x3B, 0x06, 0x18, 0xC6, 0x0C, 0x63, 0x06,
  0x33, 0x03, 0x19, 0x81, 0x8C, 0xC0, 0xC6, 0xCF, 0x36, 0x6F, 0xDF, 0x66,
  0x67, 0x37, 0x30, 0x3B, 0x18, 0x19, 0x8C, 0x0C, 0xC6, 0x0C, 0x33, 0x06,
  0x19, 0x86, 0x0F, 0xC3, 0x03, 0xC0, 0x0E, 0x00, 0xFC, 0x03, 0xB8, 0x1C,
  0x60, 0x71, 0x81, 0xCE, 0x03, 0x38, 0x0F, 0xC0, 0x1E, 0x00, 0xF8, 0x07,
  0xE3, 0xB9, 0xCE, 0xE3, 0xB3, 0x87, 0xCE, 0x1F, 0x38, 0x38, 0xF1, 0xF1,
  0xFE, 0xE3, 0xF3, 0xC0, 0xED, 0xB6, 0xD8, 0x0C, 0x63, 0x8C, 0x31, 0xC6,
  0x18, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x18, 0x61, 0xC7, 0x0C, 0x38, 0x61,
  0xC0, 0xC3, 0x86, 0x1C, 0x30, 0xE3, 0x86, 0x18, 0x71, 0xC7, 0x1C, 0x71,
  0x86, 0x18, 0xE3, 0x8C, 0x71, 0x8C, 0x00, 0x0C, 0x03, 0x00, 0xC3, 0x33,
  0xFF, 0xDF, 0xE1, 0xE0, 0xDC, 0x73, 0x88, 0xC0, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC1, 0xFF, 0xFF, 0xF8, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0x77, 0x66, 0xEC, 0xFF, 0xF0, 0xFF, 0x80, 0x01, 0xC0, 0x60, 0x38,
  0x0E, 0x03, 0x01, 0xC0, 0x60, 0x18, 0x0E, 0x03, 0x00, 0xC0, 0x70, 0x18,
  0x0E, 0x03, 0x00, 0xC0, 0x70, 0x18, 0x0E, 0x00, 0x1E, 0x0F, 0xC7, 0xF9,
  0xC6, 0x61, 0xF8, 0x7E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0xF8, 0x7E, 0x1D, 0x87, 0x73, 0x8F, 0xE1, 0xF0, 0x0E, 0x3C, 0xFB, 0xFE,
  0xF9, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C,
  0x38, 0x1E, 0x1F, 0xEF, 0xF9, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x06, 0x03,
  0x80, 0xE0, 0x70, 0x38, 0x1C, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x3F, 0xFF,
  0xFC, 0x1E, 0x1F, 0xEF, 0x79, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x0E, 0x3F,
  0x0F, 0x83, 0xF8, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x83, 0xFF, 0xEF,
  0xF0, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0xFC, 0x0D, 0xC1,
  0xDC, 0x19, 0xC3, 0x1C, 0x31, 0xC6, 0x1C, 0x61, 0xCF, 0xFF, 0xFF, 0xF0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x7F, 0x9F, 0xE7, 0xF9, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x90, 0x7F, 0x1F, 0xE0, 0x1C, 0x07, 0x00, 0xC0, 0x30,
  0x1C, 0x07, 0xC3, 0xBF, 0xE7, 0xF0, 0x07, 0x87, 0xE3, 0xE9, 0xC0, 0x70,
  0x18, 0x0E, 0x03, 0xBC, 0xFF, 0xBE, 0xFE, 0x1F, 0x83, 0xE0, 0xF8, 0x3E,
  0x0D, 0x87, 0x71, 0xCF, 0xE1, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x01,
  0xC0, 0x60, 0x38, 0x0E, 0x03, 0x01, 0xC0, 0x70, 0x38, 0x0E, 0x03, 0x01,
  0xC0, 0x70, 0x18, 0x0E, 0x03, 0x80, 0x1E, 0x0F, 0xE7, 0x3D, 0x87, 0xE1,
  0xF8, 0x76, 0x1D, 0xCE, 0x3F, 0x07, 0x83, 0xF9, 0xCF, 0xE1, 0xF8, 0x3C,
  0x0F, 0x83, 0xE1, 0xDF, 0xE3, 0xF0, 0x1E, 0x0F, 0xC7, 0xFB, 0x87, 0xE1,
  0xF8, 0x7E, 0x0F, 0x83, 0xE1, 0xF8, 0x77, 0xEC, 0xFB, 0x00, 0xC0, 0x70,
  0x18, 0x0E, 0x07, 0x9F, 0xC7, 0xC0, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0,
  0x77, 0x70, 0x00, 0x00, 0x00, 0x07, 0x76, 0xEE, 0xC0, 0x00, 0x60, 0x3C,
  0x1E, 0x0F, 0x07, 0x81, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x80, 0x7C, 0x03,
  0x80, 0x10, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0xF8, 0x7C, 0x3E,
  0x1F, 0x03, 0x80, 0x40, 0x00, 0x3E, 0x7F, 0x9F, 0xE8, 0x70, 0x38, 0x1C,
  0x0E, 0x0E, 0x07, 0x07, 0x07, 0x03, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x18,
  0x1E, 0x06, 0x00, 0x01, 0xE0, 0x03, 0xFC, 0x07, 0x87, 0x03, 0x00, 0xC3,
  0x00, 0x33, 0x87, 0x19, 0x8F, 0xC6, 0xCE, 0x63, 0xE6, 0x31, 0xE3, 0x18,
  0xF1, 0x8C, 0x78, 0xC6, 0x3C, 0x63, 0x1E, 0x33, 0x99, 0x9F, 0x7C, 0xC7,
  0x9C, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x02, 0x03, 0xFF, 0x00, 0x7F, 0x00,
  0x07, 0x00, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0xC0, 0x37, 0x00, 0xCC,
  0x07, 0x30, 0x1C, 0xE0, 0x63, 0x83, 0x86, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF,
  0xC7, 0x03, 0x1C, 0x0E, 0x70, 0x3B, 0x80, 0xEE, 0x01, 0xC0, 0xF8, 0x1F,
  0xF3, 0xFF, 0x70, 0xEE, 0x0F, 0xC1, 0xB8, 0x37, 0x0E, 0xFF, 0x9F, 0xE3,
  0x9F, 0x70, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE1, 0xDF, 0xFB, 0xFC,
  0x00, 0x07, 0xC1, 0xFF, 0x3E, 0xE3, 0x80, 0x70, 0x07, 0x00, 0x60, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x70, 0x07,
  0x80, 0x3C, 0x21, 0xFE, 0x0F, 0xE0, 0xFC, 0x0F, 0xF8, 0xFF, 0xCE, 0x1E,
  0xE0, 0xEE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0xEE, 0x1E, 0xE7, 0xCF, 0xF8, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xFC, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xFF, 0x7F, 0xB8, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFC, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x7F, 0xBF, 0xDC, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x00, 0x03, 0xE0, 0x7F, 0xC7, 0xFC,
  0x70, 0x27, 0x00, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x07, 0xF8,
  0x3F, 0xC0, 0x76, 0x03, 0xB8, 0x1D, 0xC0, 0xEF, 0x07, 0x3C, 0x38, 0xFF,
  0xC3, 0xFE, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x70, 0xFF, 0xF3, 0x8C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x33, 0xFF, 0xC0, 0x0E, 0x1C,
  0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87,
  0x0E, 0x1C, 0x38, 0x70, 0xC3, 0xBF, 0x7C, 0xE0, 0xEE, 0x0E, 0xE1, 0xCE,
  0x38, 0xE3, 0x8E, 0x70, 0xE6, 0x0E, 0xE0, 0xFC, 0x0F, 0xC0, 0xFE, 0x0E,
  0x70, 0xE7, 0x0E, 0x38, 0xE3, 0x8E, 0x1C, 0xE1, 0xCE, 0x0E, 0xE0, 0xF0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x7F, 0xFF, 0xE0, 0xF0, 0x07,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x0F, 0xD8, 0x1F, 0xD8, 0x1B, 0xDC, 0x1B,
  0xEC, 0x1B, 0xEC, 0x3B, 0xEC, 0x33, 0xEE, 0x33, 0xE6, 0x73, 0xE6, 0x63,
  0xE7, 0x63, 0xE3, 0xE3, 0xE3, 0xC3, 0xE3, 0xC3, 0xE1, 0xC3, 0xE1, 0x83,
  0xE0, 0x3F, 0x81, 0xFC, 0x0F, 0xF0, 0x7D, 0x83, 0xEE, 0x1F, 0x70, 0xFD,
  0xC7, 0xEE, 0x3F, 0x39, 0xF9, 0xCF, 0xC7, 0x7E, 0x3B, 0xF0, 0xFF, 0x87,
  0xFC, 0x1F, 0xE0, 0xFF, 0x03, 0xF8, 0x1E, 0x07, 0x80, 0x7F, 0x83, 0xFF,
  0x0E, 0x0E, 0x70, 0x39, 0xC0, 0x76, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0x60, 0x1D, 0xC0, 0x77, 0x03, 0x9C, 0x0E, 0x3C,
  0x70, 0x7F, 0xC0, 0xFC, 0x00, 0xF8, 0x3F, 0xCF, 0xFB, 0x87, 0xE1, 0xF8,
  0x7E, 0x1F, 0x87, 0xE1, 0xF9, 0xEF, 0xFB, 0xF8, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x00, 0x07, 0x80, 0x7F, 0x83, 0xFF, 0x0E, 0x0E,
  0x70, 0x39, 0xC0, 0x76, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xF8, 0x07, 0x60, 0x1D, 0xC0, 0x77, 0x03, 0x9C, 0x0E, 0x3C, 0x70, 0x7F,
  0xC0, 0xFC, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0xF8, 0x1F,
  0xE3, 0xFE, 0x70, 0xEE, 0x1D, 0xC3, 0xB8, 0x77, 0x0E, 0xE3, 0xDF, 0xF3,
  0xFC, 0x73, 0x8E, 0x71, 0xC7, 0x38, 0xE7, 0x0E, 0xE1, 0xDC, 0x1F, 0x83,
  0x80, 0x1F, 0x0F, 0xF7, 0xFB, 0x82, 0xE0, 0x38, 0x0E, 0x01, 0xC0, 0x7C,
  0x0F, 0x80, 0xF8, 0x0E, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0xC3, 0xBF, 0xEF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x00, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x0E, 0x70, 0xE7, 0xFC, 0x3F, 0x80, 0xE0, 0x3F, 0x01,
  0xD8, 0x0E, 0xC0, 0x67, 0x07, 0x38, 0x38, 0xC1, 0xC7, 0x0C, 0x38, 0xE1,
  0xC7, 0x06, 0x30, 0x39, 0x81, 0xDC, 0x06, 0xE0, 0x36, 0x01, 0xB0, 0x0F,
  0x80, 0x38, 0x01, 0xC0, 0xE0, 0x70, 0x3F, 0x03, 0x81, 0x98, 0x1C, 0x1C,
  0xC1, 0xE0, 0xE7, 0x0F, 0x07, 0x38, 0x7C, 0x31, 0xC3, 0x61, 0x86, 0x3B,
  0x1C, 0x31, 0x98, 0xE1, 0xCC, 0xE7, 0x0E, 0x63, 0x30, 0x73, 0x1B, 0x81,
  0xB8, 0xDC, 0x0D, 0x86, 0xE0, 0x7C, 0x3E, 0x03, 0xE0, 0xF0, 0x0F, 0x07,
  0x80, 0x78, 0x3C, 0x03, 0x81, 0xE0, 0x60, 0x77, 0x07, 0x30, 0xE3, 0x8E,
  0x39, 0xC1, 0xDC, 0x1D, 0x80, 0xF8, 0x0F, 0x00, 0x70, 0x0F, 0x00, 0xF8,
  0x1D, 0x81, 0x9C, 0x39, 0xC3, 0x8E, 0x70, 0xE7, 0x07, 0xE0, 0x70, 0xE0,
  0x7E, 0x07, 0x70, 0x67, 0x0E, 0x30, 0xC3, 0x9C, 0x19, 0xC1, 0xD8, 0x1F,
  0x80, 0xF0, 0x0F, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x0E, 0x03, 0x81, 0xC0,
  0x70, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x1C, 0x07, 0x03, 0x80,
  0xE0, 0x3F, 0xFF, 0xFC, 0xFF, 0xFC, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0xFF, 0xC0, 0xE0, 0x18,
  0x07, 0x00, 0xC0, 0x30, 0x0E, 0x01, 0x80, 0x60, 0x1C, 0x03, 0x00, 0xC0,
  0x38, 0x06, 0x01, 0xC0, 0x30, 0x0C, 0x03, 0x80, 0x60, 0x1C, 0xFF, 0xC6,
  0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0xFF,
  0xE0, 0x04, 0x01, 0xC0, 0x38, 0x0F, 0x81, 0xB0, 0x77, 0x0C, 0x63, 0x8E,
  0x60, 0xDC, 0x1F, 0x01, 0x80, 0xFF, 0xFF, 0xFC, 0xE3, 0x8C, 0x30, 0x3F,
  0x1F, 0xE2, 0x18, 0x07, 0x01, 0xC0, 0xF3, 0xFD, 0xC7, 0xE1, 0xF8, 0x7E,
  0x1F, 0x8F, 0xFF, 0xDF, 0x30, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0D, 0xF3, 0x7E, 0xF1, 0xF8, 0x7E, 0x1F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x87, 0xE1, 0xF8, 0x7F, 0xFB, 0x7C, 0x1F, 0x9F, 0x9C, 0x4C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x18, 0x0E, 0x13, 0xF8, 0xF8, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xCF, 0xBB, 0xFF, 0x71, 0xEC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0x60, 0xEE, 0x3D, 0xFF,
  0x9F, 0x30, 0x1F, 0x0F, 0xE7, 0x1D, 0x87, 0xE0, 0xF8, 0x3F, 0xFF, 0xFF,
  0xE0, 0x38, 0x06, 0x01, 0xC1, 0x3F, 0xC7, 0xE0, 0x0F, 0x1F, 0x3D, 0x38,
  0x38, 0x38, 0x7E, 0xFE, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38,
  0x38, 0x38, 0x38, 0x38, 0x3E, 0xEF, 0xFD, 0xC7, 0xB0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1D, 0x83, 0xB8, 0xF7, 0xFE, 0x7D, 0xC0,
  0x38, 0x07, 0x00, 0xC8, 0x39, 0xFE, 0x3F, 0x80, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0D, 0xF3, 0xFE, 0xF3, 0xB8, 0x7E, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xDF, 0x01, 0xB6,
  0xDB, 0x6D, 0xB6, 0xDB, 0x00, 0x18, 0x71, 0x80, 0x00, 0x61, 0x86, 0x18,
  0x61, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x86, 0x18, 0x63, 0xBE, 0xF0,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x1F, 0x0E, 0xC7, 0x33,
  0x8C, 0xC3, 0x70, 0xFC, 0x3F, 0x8E, 0xE3, 0x1C, 0xC7, 0x30, 0xEC, 0x3B,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x3E, 0xFF, 0xFF, 0xE3, 0xC7,
  0xE1, 0xC3, 0xE1, 0xC3, 0xC1, 0x83, 0xC1, 0x83, 0xC1, 0x83, 0xC1, 0x83,
  0xC1, 0x83, 0xC1, 0x83, 0xC1, 0x83, 0xC1, 0x83, 0xC1, 0x83, 0xDF, 0x3F,
  0xEE, 0x3B, 0x87, 0xE1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0x70, 0x1F, 0x07, 0xF1, 0xC7, 0x30, 0x6E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1D, 0x83, 0x38, 0xE3, 0xF8, 0x3E, 0x00,
  0xDF, 0x37, 0xEE, 0x1F, 0x87, 0xE1, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF8,
  0x7E, 0x1F, 0xC7, 0xDF, 0xB7, 0xCC, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0x3E, 0xEF, 0xFD, 0xC7, 0xB0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xB8, 0xF7, 0xFE, 0x7D, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0xCF, 0xBF, 0xE7, 0x0E, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x00, 0x7F, 0xFF, 0xE1, 0xC0, 0xE0, 0xF0,
  0x7C, 0x1E, 0x07, 0x03, 0x03, 0x87, 0xFF, 0xFE, 0x18, 0x38, 0x38, 0x7E,
  0xFE, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x3F,
  0x1F, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x8F, 0xFF, 0xDF, 0x30, 0xE0, 0xEC, 0x1D, 0x83, 0x38,
  0x67, 0x1C, 0x63, 0x8C, 0x61, 0xDC, 0x1B, 0x83, 0x60, 0x6C, 0x0F, 0x80,
  0xE0, 0x1C, 0x00, 0xE1, 0xC1, 0xB0, 0xF0, 0xD8, 0x78, 0xEE, 0x3C, 0x77,
  0x36, 0x31, 0x9B, 0x98, 0xCC, 0xDC, 0x66, 0x6E, 0x3B, 0x36, 0x1F, 0x1B,
  0x07, 0x8D, 0x83, 0xC3, 0xC1, 0xE1, 0xE0, 0xF0, 0xE0, 0x70, 0xEE, 0x38,
  0xE7, 0x1D, 0xC1, 0xF0, 0x3E, 0x03, 0x80, 0x78, 0x1F, 0x03, 0x70, 0xEE,
  0x18, 0xE7, 0x1D, 0xC1, 0xC0, 0xE0, 0xEC, 0x1D, 0x83, 0x38, 0x67, 0x1C,
  0x63, 0x8E, 0x61, 0xDC, 0x1B, 0x83, 0x60, 0x7C, 0x07, 0x80, 0xF0, 0x1C,
  0x03, 0x80, 0x70, 0x0C, 0x03, 0x81, 0xE0, 0x38, 0x00, 0xFF, 0xFF, 0x06,
  0x0E, 0x0C, 0x1C, 0x18, 0x38, 0x30, 0x70, 0x60, 0xE0, 0xFF, 0xFF, 0x01,
  0x0F, 0x1E, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x38, 0x78, 0xE0, 0xF0,
  0x38, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x1C, 0x1F, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0xF0, 0xF8, 0x38, 0x38, 0x38, 0x38,
  0x38, 0x38, 0x18, 0x1C, 0x0F, 0x1F, 0x18, 0x38, 0x38, 0x38, 0x38, 0x38,
  0x38, 0x38, 0xF0, 0xE0, 0x78, 0x3F, 0xFE, 0x3F, 0x40, 0x80,
};

const GFXglyph NotoSans_Condensed_Medium26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 3, 19, 7, 2, -19 },
  { 9, 8, 7, 11, 1, -19 },
  { 16, 12, 19, 14, 1, -19 },
  { 45, 10, 22, 12, 1, -20 },
  { 73, 17, 19, 19, 1, -19 },
  { 114, 14, 19, 15, 1, -19 },
  { 148, 3, 7, 6, 1, -19 },
  { 151, 6, 23, 8, 1, -19 },
  { 169, 6, 23, 8, 1, -19 },
  { 187, 10, 10, 12, 1, -20 },
  { 200, 11, 12, 12, 1, -15 },
  { 217, 4, 6, 6, 1, -3 },
  { 220, 6, 2, 8, 1, -8 },
  { 222, 3, 3, 6, 2, -3 },
  { 224, 10, 19, 10, 0, -19 },
  { 248, 10, 19, 12, 1, -19 },
  { 272, 7, 19, 12, 2, -19 },
  { 289, 10, 19, 12, 1, -19 },
  { 313, 10, 19, 12, 1, -19 },
  { 337, 12, 19, 12, 0, -19 },
  { 366, 10, 19, 12, 1, -19 },
  { 390, 10, 19, 12, 1, -19 },
  { 414, 10, 19, 12, 1, -19 },
  { 438, 10, 19, 12, 1, -19 },
  { 462, 10, 19, 12, 1, -19 },
  { 486, 3, 14, 6, 2, -14 },
  { 492, 4, 17, 6, 1, -14 },
  { 501, 11, 12, 12, 1, -15 },
  { 518, 10, 8, 12, 1, -13 },
  { 528, 11, 12, 12, 1, -15 },
  { 545, 9, 19, 10, 0, -19 },
  { 567, 17, 21, 19, 1, -19 },
  { 612, 14, 19, 14, 0, -19 },
  { 646, 11, 19, 14, 2, -19 },
  { 673, 12, 19, 13, 1, -19 },
  { 702, 12, 19, 15, 2, -19 },
  { 731, 9, 19, 12, 2, -19 },
  { 753, 9, 19, 11, 2, -19 },
  { 775, 13, 19, 16, 1, -19 },
  { 806, 12, 19, 16, 2, -19 },
  { 835, 6, 19, 8, 1, -19 },
  { 850, 7, 24, 7, -2, -19 },
  { 871, 12, 19, 13, 2, -19 },
  { 900, 9, 19, 11, 2, -19 },
  { 922, 16, 19, 21, 2, -19 },
  { 960, 13, 19, 17, 2, -19 },
  { 991, 14, 19, 16, 1, -19 },
  { 1025, 10, 19, 13, 2, -19 },
  { 1049, 14, 23, 16, 1, -19 },
  { 1090, 11, 19, 14, 2, -19 },
  { 1117, 10, 19, 12, 1, -19 },
  { 1141, 11, 19, 12, 0, -19 },
  { 1168, 12, 19, 16, 2, -19 },
  { 1197, 13, 19, 13, 0, -19 },
  { 1228, 21, 19, 21, 0, -19 },
  { 1278, 12, 19, 12, 0, -19 },
  { 1307, 12, 19, 12, 0, -19 },
  { 1336, 10, 19, 11, 1, -19 },
  { 1360, 6, 23, 8, 2, -19 },
  { 1378, 10, 19, 10, 0, -19 },
  { 1402, 5, 23, 8, 1, -19 },
  { 1417, 11, 11, 13, 1, -19 },
  { 1433, 11, 2, 11, 0, 2 },
  { 1436, 5, 4, 7, 1, -20 },
  { 1439, 10, 14, 12, 1, -14 },
  { 1457, 10, 20, 13, 2, -20 },
  { 1482, 9, 14, 10, 1, -14 },
  { 1498, 11, 20, 13, 1, -20 },
  { 1526, 10, 14, 12, 1, -14 },
  { 1544, 8, 20, 8, 0, -20 },
  { 1564, 11, 20, 13, 1, -14 },
  { 1592, 10, 20, 13, 2, -20 },
  { 1617, 3, 19, 6, 2, -19 },
  { 1625, 6, 25, 6, -1, -19 },
  { 1644, 10, 20, 12, 2, -20 },
  { 1669, 2, 20, 6, 2, -20 },
  { 1674, 16, 14, 20, 2, -14 },
  { 1702, 10, 14, 13, 2, -14 },
  { 1720, 11, 14, 13, 1, -14 },
  { 1740, 10, 20, 13, 2, -14 },
  { 1765, 11, 20, 13, 1, -14 },
  { 1793, 7, 14, 9, 2, -14 },
  { 1806, 8, 14, 10, 1, -14 },
  { 1820, 8, 17, 8, 0, -17 },
  { 1837, 10, 14, 13, 2, -14 },
  { 1855, 11, 14, 11, 0, -14 },
  { 1875, 17, 14, 18, 0, -14 },
  { 1905, 11, 14, 11, 0, -14 },
  { 1925, 11, 20, 11, 0, -14 },
  { 1953, 8, 14, 10, 1, -14 },
  { 1967, 8, 23, 9, 1, -19 },
  { 1990, 2, 26, 12, 5, -20 },
  { 1997, 8, 23, 9, 1, -19 },
  { 2020, 11, 4, 12, 1, -11 },
};

const GFXfont NotoSans_Condensed_Medium26pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Medium26pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Medium26pt7bGlyphs,
  0x20, 0x7E, 35
};

#endif // _NOTOSANS_CONDENSED_MEDIUM26PT7B_H_
