#ifndef _NOTOSANS_CONDENSED_MEDIUM20PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUM20PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Medium.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Medium20pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xF4, 0x92, 0x48, 0x2F, 0xC0, 0xCF, 0x3C, 0xF3, 0xCC, 0x09,
  0x82, 0x61, 0x90, 0x64, 0x7F, 0xC4, 0xC1, 0x30, 0x4C, 0xFF, 0xFF, 0xF3,
  0x20, 0xC8, 0x26, 0x09, 0x80, 0x10, 0x18, 0x7E, 0xD2, 0xD0, 0xD0, 0xF0,
  0x78, 0x1E, 0x17, 0x13, 0x93, 0xFE, 0xFC, 0x10, 0x10, 0x70, 0xC6, 0xC4,
  0x26, 0x61, 0x33, 0x09, 0x90, 0x4D, 0xBB, 0x6B, 0xCE, 0xDB, 0x06, 0x98,
  0x24, 0xC3, 0x26, 0x11, 0x31, 0x8D, 0x88, 0x38, 0x7C, 0x19, 0x86, 0x61,
  0x98, 0x6C, 0x0F, 0x03, 0x81, 0xE3, 0xCC, 0xF1, 0xEC, 0x7B, 0x0C, 0xFF,
  0x9F, 0x30, 0xFF, 0xC0, 0x39, 0x18, 0xCC, 0x63, 0x18, 0xC6, 0x31, 0x8C,
  0x31, 0x86, 0x38, 0xC4, 0x66, 0x33, 0x33, 0x33, 0x33, 0x36, 0x64, 0xC0,
  0x18, 0x23, 0x5F, 0xF3, 0x8D, 0x9B, 0x80, 0x18, 0x18, 0x18, 0x18, 0xFF,
  0xFF, 0x18, 0x18, 0x18, 0x18, 0x7B, 0x68, 0xFF, 0x5F, 0x80, 0x06, 0x0C,
  0x10, 0x60, 0xC3, 0x06, 0x0C, 0x30, 0x60, 0x83, 0x06, 0x18, 0x00, 0x7C,
  0x66, 0xC6, 0xC6, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC6, 0xC6, 0x7E,
  0x3C, 0x1C, 0xF6, 0xF3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0x7C, 0xCE, 0x06, 0x06, 0x06, 0x06, 0x0C, 0x0C, 0x18, 0x30, 0x60, 0x60,
  0xFF, 0xFF, 0xFC, 0xCE, 0x06, 0x06, 0x06, 0x0C, 0x78, 0x7E, 0x06, 0x07,
  0x07, 0x06, 0xFE, 0xFC, 0x07, 0x03, 0x83, 0xC1, 0x61, 0xB1, 0x98, 0xCC,
  0xC6, 0x63, 0x7F, 0xFF, 0xE0, 0x60, 0x30, 0x18, 0x7E, 0x7E, 0xC0, 0xC0,
  0xC0, 0xFC, 0xFE, 0x06, 0x07, 0x03, 0x07, 0x06, 0xFE, 0xFC, 0x3E, 0x70,
  0x60, 0xC0, 0xC0, 0xDC, 0xFE, 0xC7, 0xC3, 0xC3, 0xC3, 0xC6, 0x7E, 0x3C,
  0xFF, 0xFF, 0x06, 0x06, 0x06, 0x0C, 0x0C, 0x0C, 0x18, 0x18, 0x30, 0x30,
  0x30, 0x60, 0x7E, 0xE6, 0xC6, 0xC2, 0xE6, 0x7C, 0x38, 0x7E, 0xC6, 0xC3,
  0xC3, 0xC3, 0xEE, 0x7C, 0x7C, 0xEE, 0xC6, 0xC3, 0xC3, 0xC3, 0xC7, 0x7B,
  0x33, 0x06, 0x06, 0x0E, 0xFC, 0xF8, 0xDD, 0x00, 0x00, 0x5F, 0x80, 0xDD,
  0x00, 0x00, 0x0F, 0x6D, 0x00, 0x01, 0x07, 0x1E, 0x78, 0xE0, 0xE0, 0x38,
  0x0E, 0x03, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0xC0, 0x70,
  0x1C, 0x07, 0x0F, 0x3C, 0xF0, 0xC0, 0x80, 0xFC, 0x9C, 0x18, 0x30, 0x61,
  0x86, 0x18, 0x30, 0x60, 0x00, 0x83, 0x06, 0x00, 0x1F, 0xC1, 0xC3, 0x18,
  0x0C, 0xC6, 0x24, 0xF9, 0xE6, 0x4F, 0x22, 0x7B, 0x33, 0xD9, 0x9E, 0x4C,
  0xB3, 0xFD, 0x8C, 0xC6, 0x00, 0x38, 0x20, 0xFF, 0x00, 0xE0, 0x0E, 0x01,
  0xC0, 0x78, 0x0D, 0x81, 0xB0, 0x66, 0x0C, 0xC1, 0x8C, 0x3F, 0x8F, 0xF1,
  0x87, 0x30, 0x6E, 0x0D, 0x81, 0xC0, 0xFC, 0xCE, 0xC7, 0xC3, 0xC6, 0xC6,
  0xF8, 0xCE, 0xC3, 0xC3, 0xC3, 0xC7, 0xFE, 0xFC, 0x04, 0x1F, 0xDC, 0x4C,
  0x0E, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x0C, 0x07, 0x01, 0xF8,
  0x7C, 0xFC, 0x7F, 0x31, 0xD8, 0x6C, 0x3E, 0x0F, 0x07, 0x83, 0xC1, 0xE1,
  0xB0, 0xD8, 0xEF, 0xE7, 0xC0, 0xFF, 0xFC, 0x30, 0xC3, 0x0F, 0xF0, 0xC3,
  0x0C, 0x30, 0xFF, 0xF0, 0xFF, 0xFC, 0x30, 0xC3, 0x0F, 0xFF, 0xC3, 0x0C,
  0x30, 0xC3, 0x00, 0x1F, 0xCE, 0x26, 0x01, 0x80, 0xC0, 0x30, 0x0C, 0x3F,
  0x0F, 0xC0, 0xF0, 0x36, 0x0D, 0xC3, 0x3F, 0xC7, 0xF0, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0xFF, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0C, 0xFB, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC7, 0x7C, 0x18, 0xC6,
  0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0xE6, 0xF7, 0x00, 0xC3, 0xC6,
  0xCC, 0xCC, 0xD8, 0xF0, 0xF0, 0xF8, 0xD8, 0xCC, 0xCE, 0xC6, 0xC7, 0xC3,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xFF, 0xF0, 0xE0,
  0x7E, 0x07, 0xE0, 0x7B, 0x0F, 0xB0, 0xFB, 0x0B, 0x91, 0xB9, 0x9B, 0x99,
  0x38, 0xB3, 0x8F, 0x38, 0xE3, 0x8E, 0x38, 0x63, 0xC1, 0xF0, 0xF8, 0x76,
  0x3B, 0x1C, 0xCE, 0x67, 0x1B, 0x8D, 0xC3, 0xE1, 0xB0, 0x78, 0x3C, 0x0C,
  0x3F, 0x0E, 0x71, 0x83, 0x70, 0x6C, 0x0D, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xD8, 0x19, 0x83, 0x30, 0xE3, 0xF8, 0x3E, 0x00, 0xFD, 0xBF, 0x1E, 0x3C,
  0x78, 0xF3, 0xFE, 0xF1, 0x83, 0x06, 0x0C, 0x18, 0x00, 0x3F, 0x0E, 0x71,
  0x83, 0x70, 0x6C, 0x0D, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xD8, 0x19, 0x83,
  0x30, 0xE3, 0xF8, 0x3E, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0xFC, 0xFE, 0xC6,
  0xC6, 0xC6, 0xC6, 0xFE, 0xF8, 0xD8, 0xCC, 0xCC, 0xC6, 0xC7, 0xC3, 0x00,
  0xFF, 0x9E, 0x0C, 0x18, 0x38, 0x3C, 0x1C, 0x0C, 0x18, 0x38, 0x7F, 0xFF,
  0x00, 0xFF, 0xFF, 0xC6, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F,
  0x87, 0xC3, 0xE1, 0xF0, 0xD8, 0x6C, 0x37, 0xF9, 0xF8, 0xC0, 0xF8, 0x36,
  0x19, 0x86, 0x61, 0x8C, 0x63, 0x30, 0xCC, 0x33, 0x06, 0x81, 0xE0, 0x78,
  0x0E, 0x03, 0x00, 0xC1, 0x83, 0xC1, 0x86, 0x63, 0x86, 0x63, 0xC6, 0x63,
  0xC6, 0x62, 0xCE, 0x36, 0x4C, 0x36, 0x6C, 0x36, 0x6C, 0x36, 0x6C, 0x34,
  0x28, 0x1C, 0x38, 0x1C, 0x38, 0x1C, 0x38, 0xE1, 0xB1, 0x8C, 0xC6, 0xC1,
  0xE0, 0xF0, 0x30, 0x38, 0x1E, 0x1B, 0x0C, 0xCC, 0x66, 0x1E, 0x0C, 0xC1,
  0xB0, 0xD8, 0xC6, 0x63, 0x61, 0xB0, 0x70, 0x38, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0xFF, 0xFC, 0x30, 0x61, 0xC3, 0x0E, 0x18, 0x70, 0xC3,
  0x86, 0x0F, 0xFF, 0xC0, 0xFE, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C,
  0x63, 0x18, 0xF8, 0xC0, 0xC1, 0x81, 0x83, 0x06, 0x06, 0x0C, 0x08, 0x18,
  0x30, 0x20, 0x60, 0xC0, 0xF3, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33,
  0xF0, 0x0C, 0x03, 0x01, 0xE0, 0x48, 0x33, 0x08, 0x46, 0x1B, 0x07, 0xFF,
  0x80, 0xE6, 0x30, 0x7C, 0xFC, 0x18, 0x30, 0xEF, 0xF1, 0xE3, 0xC7, 0xDD,
  0xC8, 0xC0, 0xC0, 0xC0, 0xC0, 0xDE, 0xFF, 0xE3, 0xE3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xE3, 0xF7, 0xDE, 0x3E, 0xFB, 0x86, 0x0C, 0x18, 0x30, 0x60, 0xC0,
  0xF8, 0xF0, 0x03, 0x03, 0x03, 0x03, 0x3B, 0x7F, 0xE7, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0x7F, 0x7B, 0x3C, 0x7E, 0xC6, 0xC3, 0xC3, 0xFF, 0xC0,
  0xC0, 0xC0, 0x76, 0x3E, 0x3E, 0x68, 0xC1, 0x87, 0xDF, 0x8C, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x06, 0x0C, 0x00, 0x3B, 0x7F, 0xE7, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0x7F, 0x7B, 0x03, 0x03, 0x87, 0xFE, 0x78, 0xC0, 0xC0,
  0xC0, 0xC0, 0xDE, 0xFF, 0xE3, 0xE3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xF4, 0xFF, 0xFF, 0xFC, 0x33, 0x10, 0x33, 0x33, 0x33, 0x33, 0x33,
  0x33, 0x33, 0xFE, 0xC0, 0xC0, 0xC0, 0xC0, 0xC3, 0xC6, 0xCC, 0xCC, 0xD8,
  0xF8, 0xEC, 0xCC, 0xC6, 0xC6, 0xC3, 0xFF, 0xFF, 0xFF, 0xFC, 0xDE, 0x77,
  0xF7, 0xF8, 0xC7, 0xC6, 0x3C, 0x31, 0xE1, 0x8F, 0x0C, 0x78, 0x63, 0xC3,
  0x1E, 0x18, 0xF0, 0xC6, 0xDE, 0xFF, 0xE3, 0xE3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0x3C, 0x7E, 0xE3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0x7E, 0x3C, 0xDE, 0xFF, 0xE3, 0xE3, 0xC3, 0xC3, 0xC3, 0xC3, 0xE3, 0xFF,
  0xDE, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x3B, 0x7F, 0xE7, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0x7F, 0x7B, 0x03, 0x03, 0x03, 0x03, 0x03, 0xDF, 0x7E,
  0x38, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x00, 0x7B, 0xFC, 0x30, 0xE1, 0xE1,
  0xC3, 0x0F, 0x7F, 0x80, 0x20, 0x87, 0xFF, 0x61, 0x86, 0x18, 0x61, 0x86,
  0x0D, 0x3C, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x7F,
  0x7B, 0xC3, 0xE1, 0x98, 0xCC, 0x66, 0x61, 0x30, 0xD8, 0x68, 0x3C, 0x0E,
  0x07, 0x00, 0xC3, 0x1E, 0x38, 0xD9, 0xC6, 0xCF, 0x36, 0x59, 0x36, 0xD8,
  0xF2, 0xC7, 0x96, 0x38, 0xE1, 0xC7, 0x06, 0x38, 0xE3, 0x63, 0x36, 0x36,
  0x1C, 0x1C, 0x1C, 0x36, 0x36, 0x63, 0xE3, 0xC3, 0xE1, 0x98, 0xCC, 0x66,
  0x61, 0xB0, 0xD8, 0x68, 0x1C, 0x0E, 0x07, 0x03, 0x01, 0x81, 0xC3, 0xC1,
  0xC0, 0xFF, 0xF1, 0x86, 0x30, 0xC6, 0x18, 0xC3, 0xFF, 0xC0, 0x1C, 0xC3,
  0x0C, 0x30, 0xC3, 0x18, 0xC1, 0x83, 0x0C, 0x30, 0xC3, 0x0E, 0x1C, 0xFF,
  0xFF, 0xF0, 0xE1, 0x83, 0x0C, 0x30, 0xC3, 0x0E, 0x0C, 0xC3, 0x0C, 0x30,
  0xC3, 0x18, 0xE0, 0xF9, 0x9F,
};

const GFXglyph NotoSans_Condensed_Medium20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 3, 14, 5, 1, -14 },
  { 7, 6, 5, 8, 1, -14 },
  { 11, 10, 14, 10, 0, -14 },
  { 29, 8, 16, 10, 1, -15 },
  { 45, 13, 14, 15, 1, -14 },
  { 68, 10, 14, 11, 1, -14 },
  { 86, 2, 5, 4, 1, -14 },
  { 88, 5, 17, 6, 1, -14 },
  { 99, 4, 17, 6, 1, -14 },
  { 108, 7, 7, 9, 1, -15 },
  { 115, 8, 10, 10, 1, -12 },
  { 125, 3, 5, 5, 1, -2 },
  { 127, 4, 2, 6, 1, -6 },
  { 128, 3, 3, 5, 1, -3 },
  { 130, 7, 14, 8, 0, -14 },
  { 143, 8, 14, 10, 1, -14 },
  { 157, 6, 14, 10, 1, -14 },
  { 168, 8, 14, 10, 1, -14 },
  { 182, 8, 14, 10, 1, -14 },
  { 196, 9, 14, 10, 0, -14 },
  { 212, 8, 14, 10, 1, -14 },
  { 226, 8, 14, 10, 1, -14 },
  { 240, 8, 14, 10, 1, -14 },
  { 254, 8, 14, 10, 1, -14 },
  { 268, 8, 14, 10, 1, -14 },
  { 282, 3, 11, 5, 1, -11 },
  { 287, 3, 14, 5, 1, -11 },
  { 293, 8, 10, 10, 1, -12 },
  { 303, 8, 6, 10, 1, -10 },
  { 309, 8, 10, 10, 1, -12 },
  { 319, 7, 14, 7, 0, -14 },
  { 332, 13, 16, 15, 1, -14 },
  { 358, 11, 14, 11, 0, -14 },
  { 378, 8, 14, 11, 2, -14 },
  { 392, 9, 15, 10, 1, -15 },
  { 409, 9, 14, 12, 2, -14 },
  { 425, 6, 14, 9, 2, -14 },
  { 436, 6, 14, 9, 2, -14 },
  { 447, 10, 14, 12, 1, -14 },
  { 465, 9, 14, 12, 2, -14 },
  { 481, 5, 14, 6, 1, -14 },
  { 490, 5, 18, 5, -1, -14 },
  { 502, 8, 14, 10, 2, -14 },
  { 516, 6, 14, 9, 2, -14 },
  { 527, 12, 14, 16, 2, -14 },
  { 548, 9, 14, 13, 2, -14 },
  { 564, 11, 14, 13, 1, -14 },
  { 584, 7, 14, 10, 2, -14 },
  { 597, 11, 17, 13, 1, -14 },
  { 621, 8, 14, 10, 2, -14 },
  { 635, 7, 15, 9, 1, -15 },
  { 649, 9, 14, 9, 0, -14 },
  { 665, 9, 14, 12, 1, -14 },
  { 681, 10, 14, 10, 0, -14 },
  { 699, 16, 14, 16, 0, -14 },
  { 727, 9, 14, 10, 0, -14 },
  { 743, 9, 14, 9, 0, -14 },
  { 759, 7, 14, 9, 1, -14 },
  { 772, 5, 17, 6, 1, -14 },
  { 783, 7, 14, 8, 0, -14 },
  { 796, 4, 17, 6, 1, -14 },
  { 805, 10, 8, 10, 0, -14 },
  { 815, 9, 1, 9, 0, 2 },
  { 817, 4, 3, 6, 1, -15 },
  { 819, 7, 11, 9, 1, -11 },
  { 829, 8, 15, 10, 1, -15 },
  { 844, 7, 11, 8, 1, -11 },
  { 854, 8, 15, 10, 1, -15 },
  { 869, 8, 11, 9, 1, -11 },
  { 880, 7, 15, 6, 0, -15 },
  { 894, 8, 16, 10, 1, -11 },
  { 910, 8, 15, 10, 1, -15 },
  { 925, 2, 15, 5, 1, -15 },
  { 929, 4, 20, 5, -1, -15 },
  { 939, 8, 15, 9, 1, -15 },
  { 954, 2, 15, 5, 1, -15 },
  { 958, 13, 11, 16, 1, -11 },
  { 976, 8, 11, 10, 1, -11 },
  { 987, 8, 11, 10, 1, -11 },
  { 998, 8, 16, 10, 1, -11 },
  { 1014, 8, 16, 10, 1, -11 },
  { 1030, 6, 11, 7, 1, -11 },
  { 1039, 6, 11, 8, 1, -11 },
  { 1048, 6, 13, 6, 0, -13 },
  { 1058, 8, 11, 10, 1, -11 },
  { 1069, 9, 11, 9, 0, -11 },
  { 1082, 13, 11, 14, 0, -11 },
  { 1100, 8, 11, 9, 0, -11 },
  { 1111, 9, 16, 9, 0, -11 },
  { 1129, 6, 11, 7, 1, -11 },
  { 1138, 6, 17, 7, 1, -14 },
  { 1151, 1, 20, 9, 4, -15 },
  { 1154, 6, 17, 7, 1, -14 },
  { 1167, 8, 2, 10, 1, -8 },
};

const GFXfont NotoSans_Condensed_Medium20pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Medium20pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Medium20pt7bGlyphs,
  0x20, 0x7E, 27
};

#endif // _NOTOSANS_CONDENSED_MEDIUM20PT7B_H_
