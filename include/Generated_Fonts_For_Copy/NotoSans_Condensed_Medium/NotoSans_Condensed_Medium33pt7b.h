#ifndef _NOTOSANS_CONDENSED_MEDIUM33PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUM33PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Medium.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Medium33pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x77, 0x77, 0x77, 0x76, 0x60, 0x00, 0xFF,
  0xFF, 0xE3, 0xF8, 0xEE, 0x3B, 0x8E, 0xE3, 0xB8, 0xEE, 0x3B, 0x8E, 0xE1,
  0x80, 0x07, 0x1C, 0x07, 0x18, 0x06, 0x18, 0x06, 0x18, 0x06, 0x38, 0x06,
  0x38, 0x0E, 0x38, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x0C, 0x30, 0x0C,
  0x70, 0x1C, 0x70, 0x1C, 0x70, 0x1C, 0x60, 0xFF, 0xFE, 0xFF, 0xFE, 0x18,
  0x60, 0x18, 0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x38, 0xC0, 0x38, 0xC0, 0x30,
  0xC0, 0x06, 0x00, 0x60, 0x06, 0x03, 0xFE, 0x7F, 0xFF, 0xEE, 0xE6, 0x0E,
  0x60, 0xE6, 0x0E, 0x60, 0xF6, 0x07, 0xE0, 0x3F, 0x01, 0xFC, 0x07, 0xE0,
  0x6F, 0x06, 0x70, 0x67, 0x06, 0x78, 0x67, 0xE7, 0xFF, 0xFE, 0xFF, 0x80,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x1C, 0x01, 0x80, 0xFC, 0x0E, 0x07,
  0x70, 0x38, 0x18, 0xE0, 0xC0, 0xE3, 0x87, 0x03, 0x8E, 0x18, 0x0E, 0x38,
  0xE0, 0x38, 0xE3, 0x80, 0xE3, 0x9C, 0x03, 0x8E, 0x70, 0x06, 0x39, 0x9F,
  0x18, 0xEE, 0x7E, 0x7F, 0x33, 0x9C, 0xFD, 0xCC, 0x71, 0xC7, 0x31, 0xC0,
  0x19, 0xC3, 0x00, 0xE7, 0x0C, 0x03, 0x1C, 0x30, 0x1C, 0x31, 0xC0, 0x70,
  0xC7, 0x03, 0x83, 0x1C, 0x0E, 0x0E, 0x70, 0x30, 0x1F, 0x81, 0xC0, 0x3C,
  0x07, 0x80, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xF3, 0xC0, 0x38, 0x70, 0x0E,
  0x1C, 0x03, 0x87, 0x00, 0xE3, 0x80, 0x1C, 0xE0, 0x07, 0xF0, 0x00, 0xF8,
  0x00, 0x3C, 0x00, 0x3F, 0x83, 0x9E, 0xF1, 0xE7, 0x9C, 0x73, 0xC7, 0x9C,
  0xF0, 0xFF, 0x3C, 0x1F, 0x8F, 0x03, 0xE3, 0xC0, 0xF0, 0xF0, 0x7E, 0x1F,
  0xFF, 0xC3, 0xFE, 0x78, 0x7F, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0E, 0x38,
  0x71, 0xC3, 0x8E, 0x1C, 0x38, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0xC3, 0x87, 0x0E, 0x1E, 0x1C, 0x38, 0x78, 0x70, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE1, 0xC1, 0xC3, 0x83, 0x87, 0x0E, 0x0E, 0x1C, 0x38, 0x70, 0xE1,
  0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE3, 0xC7, 0x0E, 0x3C, 0x71, 0xE3,
  0x8E, 0x00, 0x07, 0x00, 0x38, 0x01, 0xC1, 0x0E, 0x1F, 0x77, 0x7F, 0xFF,
  0xFF, 0xC1, 0xF0, 0x1D, 0xC0, 0xEE, 0x0E, 0x38, 0x71, 0x80, 0x88, 0x00,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x3B, 0xDE, 0xE7, 0x39, 0x9C, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1C, 0x01,
  0xC0, 0x1C, 0x03, 0x80, 0x38, 0x07, 0x80, 0x70, 0x07, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70,
  0x0F, 0x00, 0x07, 0x80, 0xFF, 0x0F, 0xF8, 0x79, 0xE7, 0x87, 0x38, 0x3D,
  0xC0, 0xEE, 0x07, 0x70, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0x70, 0x3B, 0x81, 0xDC, 0x1E, 0xF0, 0xF7, 0x87,
  0x1F, 0xF8, 0x7F, 0x81, 0xF8, 0x03, 0x83, 0xC3, 0xE3, 0xF3, 0xFF, 0xDD,
  0xCE, 0x87, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x0F, 0x81, 0xFF, 0x3F,
  0xFC, 0xE1, 0xE2, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03,
  0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x07, 0x00, 0x70, 0x07, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F,
  0x83, 0xFF, 0x3F, 0xFC, 0xE1, 0xE4, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x70, 0x07, 0x87, 0xF8, 0x3F, 0x01, 0xFE, 0x01, 0xF8, 0x01, 0xE0,
  0x0F, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF8, 0x07, 0xFF, 0xFB, 0xFF,
  0x8F, 0xF8, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x1F,
  0xC0, 0x7F, 0x03, 0xBC, 0x0E, 0xF0, 0x73, 0xC1, 0x8F, 0x0E, 0x3C, 0x30,
  0xF1, 0xC3, 0xC6, 0x0F, 0x38, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x7F, 0xE7, 0xFE, 0x7F,
  0xE7, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0xE0, 0xFF,
  0xCF, 0xFE, 0x41, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x0F, 0x81, 0xEF, 0xFE, 0xFF, 0xCF, 0xF8, 0x01, 0xF0, 0x3F, 0x87,
  0xFC, 0x3C, 0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x9E,
  0x1F, 0xFD, 0xFF, 0xEF, 0x87, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0x70, 0x3B,
  0x81, 0xDC, 0x0E, 0xF0, 0x73, 0x87, 0x9F, 0xF8, 0x7F, 0xC1, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00,
  0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00,
  0x38, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00,
  0x78, 0x01, 0xC0, 0x0F, 0x00, 0x0F, 0x80, 0x7F, 0x83, 0xFF, 0x1E, 0x1E,
  0x70, 0x39, 0xC0, 0xE7, 0x03, 0x9C, 0x1E, 0x78, 0x70, 0xF3, 0xC1, 0xFE,
  0x03, 0xE0, 0x1F, 0xC0, 0xF7, 0xC7, 0x8F, 0x9C, 0x1E, 0xF0, 0x3B, 0x80,
  0xFE, 0x03, 0xFC, 0x0E, 0x70, 0x39, 0xF3, 0xE3, 0xFF, 0x07, 0xF8, 0x0F,
  0x80, 0xFE, 0x0F, 0xF8, 0xF1, 0xE7, 0x07, 0x78, 0x3F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x81, 0xFC, 0x0E, 0xE0, 0xF7, 0xCF, 0x9F, 0xFC, 0x7E, 0xE0,
  0x07, 0x00, 0x38, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x1E, 0x3F, 0xF1, 0xFF,
  0x0F, 0xE0, 0x7F, 0xFF, 0x60, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x3B,
  0xDE, 0xF3, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xEF, 0x7B, 0x9C, 0xE6,
  0x70, 0x00, 0x04, 0x00, 0x30, 0x03, 0xC0, 0x3E, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x3E, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x01, 0xF8,
  0x01, 0xF0, 0x01, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x03, 0x00,
  0x0F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3C, 0x03, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x03, 0xE0, 0x0E, 0x00, 0x20,
  0x00, 0x1F, 0x1F, 0xF9, 0xFF, 0xB0, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x38, 0x0F, 0x03, 0xC0, 0xF0, 0x1C, 0x03, 0x80, 0x60, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x00, 0xF8,
  0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xE0, 0x3C, 0x03, 0x83, 0xC0, 0x0E, 0x1C,
  0x00, 0x31, 0xC0, 0x01, 0xCE, 0x1F, 0xC6, 0xE1, 0xFE, 0x37, 0x1C, 0x71,
  0xF8, 0xC3, 0x8F, 0x8E, 0x1C, 0x7C, 0x70, 0xE3, 0xE3, 0x87, 0x1F, 0x1C,
  0x38, 0xF8, 0xE1, 0xC7, 0xC7, 0x1E, 0x36, 0x1C, 0xF3, 0xB8, 0xFD, 0xF9,
  0xC3, 0xE7, 0x86, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x20, 0x1F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x77, 0x00, 0x3B, 0x80, 0x1D, 0xC0,
  0x0E, 0x70, 0x0F, 0x38, 0x07, 0x1C, 0x03, 0x8F, 0x01, 0xC3, 0x81, 0xE1,
  0xC0, 0xE0, 0xE0, 0x7F, 0xF8, 0x7F, 0xFC, 0x3F, 0xFE, 0x1C, 0x07, 0x8E,
  0x03, 0xCF, 0x00, 0xE7, 0x80, 0x73, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x07,
  0xFC, 0x07, 0xFF, 0x3F, 0xFD, 0xC3, 0xEE, 0x07, 0xF0, 0x3F, 0x81, 0xFC,
  0x0F, 0xE0, 0x7F, 0x07, 0xBF, 0xF9, 0xFF, 0x0F, 0xFE, 0x70, 0x7B, 0x81,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0xFE, 0x07, 0xFF, 0xFB,
  0xFF, 0x9F, 0xF8, 0x03, 0xF0, 0x3F, 0xF1, 0xFF, 0xCF, 0x86, 0x7C, 0x01,
  0xE0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x00,
  0x1E, 0x00, 0x3C, 0x04, 0xFF, 0xE1, 0xFF, 0x81, 0xFE, 0xFC, 0x01, 0xFF,
  0x83, 0xFF, 0xC7, 0x1F, 0x8E, 0x07, 0x9C, 0x07, 0xB8, 0x0F, 0x70, 0x0E,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1D, 0xC0, 0x7B, 0x80, 0xF7, 0x03, 0xCE, 0x0F,
  0x9F, 0xFE, 0x3F, 0xF8, 0x7F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0x01, 0xF8, 0x0F, 0xFF, 0x1F, 0xFE,
  0x3E, 0x0E, 0x3C, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0x07,
  0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0x70, 0x07, 0x78, 0x07, 0x3C, 0x07,
  0x3F, 0xFF, 0x1F, 0xFF, 0x07, 0xFE, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xFF, 0xFF, 0x7F, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0xFF, 0xFF,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x0F,
  0x0F, 0x0F, 0x0F, 0xFE, 0xFE, 0xFC, 0x60, 0xE0, 0x3F, 0x80, 0xEE, 0x07,
  0xB8, 0x3C, 0xE0, 0xE3, 0x87, 0x8E, 0x3C, 0x38, 0xE0, 0xE7, 0x83, 0xBC,
  0x0E, 0xE0, 0x3F, 0x80, 0xFF, 0x03, 0xFE, 0x0F, 0x78, 0x38, 0xF0, 0xE3,
  0xC3, 0x87, 0x8E, 0x1E, 0x38, 0x3C, 0xE0, 0x73, 0x81, 0xEE, 0x03, 0xB8,
  0x0F, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x37, 0xEE, 0x07, 0x7E, 0xE0, 0x77, 0xEE, 0x07, 0x7E, 0x70,
  0xE7, 0xE7, 0x0E, 0x7E, 0x70, 0xE7, 0xE3, 0x9C, 0x7E, 0x39, 0xC7, 0xE3,
  0x9C, 0x7E, 0x3B, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF0, 0x7E,
  0x0F, 0x07, 0xE0, 0xF0, 0x7E, 0x0E, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF8,
  0x07, 0xF8, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFE, 0x07, 0xEE, 0x07, 0xEF,
  0x07, 0xE7, 0x07, 0xE7, 0x87, 0xE3, 0x87, 0xE3, 0xC7, 0xE1, 0xC7, 0xE1,
  0xE7, 0xE0, 0xE7, 0xE0, 0xE7, 0xE0, 0xF7, 0xE0, 0x77, 0xE0, 0x7F, 0xE0,
  0x3F, 0xE0, 0x3F, 0xE0, 0x1F, 0xE0, 0x1F, 0x03, 0xE0, 0x07, 0xFC, 0x0F,
  0xFF, 0x07, 0x87, 0xC7, 0x80, 0xF3, 0x80, 0x7B, 0xC0, 0x1D, 0xE0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0x9C, 0x03, 0xCF,
  0x01, 0xE7, 0xC1, 0xE1, 0xFF, 0xF0, 0x7F, 0xF0, 0x0F, 0xE0, 0xF8, 0x0F,
  0xFC, 0xFF, 0xEE, 0x3F, 0xE0, 0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0xFE, 0x1F, 0xFF, 0xEF, 0xFC, 0xFF, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x03, 0xE0,
  0x07, 0xFC, 0x0F, 0xFF, 0x07, 0x87, 0xC7, 0x80, 0xF3, 0x80, 0x7B, 0xC0,
  0x1D, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0x9C, 0x03, 0xCF, 0x01, 0xE7, 0xC1, 0xE1, 0xFF, 0xF0, 0x7F, 0xF0, 0x0F,
  0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x78, 0xFC, 0x03, 0xFF, 0x0F, 0xFE, 0x39, 0xFC, 0xE0, 0xF3, 0x81,
  0xCE, 0x07, 0x38, 0x1C, 0xE0, 0x73, 0x81, 0xCE, 0x0F, 0x38, 0xF8, 0xFF,
  0xC3, 0xFE, 0x0E, 0x38, 0x38, 0xF0, 0xE1, 0xC3, 0x87, 0x8E, 0x0E, 0x38,
  0x3C, 0xE0, 0xF3, 0x81, 0xEE, 0x07, 0xB8, 0x0F, 0x07, 0xC0, 0xFF, 0xCF,
  0xFC, 0xF8, 0xE7, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0xE0,
  0x0F, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xFC, 0x0F, 0x7F, 0xFB, 0xFF, 0x8F, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x1D, 0xC0, 0x3B, 0x80, 0xF7, 0x81, 0xE7, 0xFF, 0x87, 0xFE,
  0x07, 0xF8, 0xE0, 0x07, 0xF8, 0x03, 0x9C, 0x01, 0xCE, 0x01, 0xE7, 0x00,
  0xF3, 0xC0, 0x70, 0xE0, 0x38, 0x70, 0x3C, 0x38, 0x1E, 0x1E, 0x0E, 0x07,
  0x07, 0x03, 0x87, 0x81, 0xE3, 0x80, 0x71, 0xC0, 0x38, 0xE0, 0x1C, 0xF0,
  0x0F, 0x70, 0x03, 0xB8, 0x01, 0xDC, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0x80, 0xE0, 0x1E, 0x01, 0xFC, 0x07, 0x80, 0xF7,
  0x01, 0xE0, 0x3D, 0xC0, 0x78, 0x0E, 0x70, 0x1F, 0x03, 0x9E, 0x0F, 0xC0,
  0xE7, 0x83, 0xF0, 0x78, 0xE0, 0xFC, 0x1C, 0x38, 0x3B, 0x07, 0x0E, 0x1C,
  0xE1, 0xC3, 0xC7, 0x38, 0x70, 0x71, 0xCE, 0x3C, 0x1C, 0x73, 0x8E, 0x07,
  0x18, 0x73, 0x81, 0xCE, 0x1C, 0xE0, 0x7B, 0x87, 0x78, 0x0E, 0xE1, 0xDE,
  0x03, 0xB8, 0x37, 0x00, 0xEC, 0x0D, 0xC0, 0x3F, 0x03, 0xF0, 0x07, 0xC0,
  0xFC, 0x01, 0xF0, 0x3E, 0x00, 0x78, 0x07, 0x80, 0x1E, 0x01, 0xE0, 0x70,
  0x0E, 0x78, 0x1E, 0x38, 0x1C, 0x3C, 0x3C, 0x1C, 0x38, 0x1C, 0x78, 0x0E,
  0x70, 0x0E, 0x70, 0x0F, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xC0, 0x03,
  0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xF0, 0x0E, 0x70, 0x1E, 0x78, 0x1C,
  0x38, 0x3C, 0x3C, 0x38, 0x3C, 0x78, 0x1C, 0x70, 0x1E, 0xF0, 0x0F, 0xF0,
  0x0F, 0xE0, 0x3D, 0xC0, 0x7B, 0xC0, 0xE3, 0x83, 0xC7, 0x87, 0x0F, 0x0E,
  0x0E, 0x38, 0x1E, 0x70, 0x1D, 0xE0, 0x3B, 0x80, 0x3F, 0x00, 0x7C, 0x00,
  0xF8, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0xFF, 0xF7, 0xFF, 0xBF,
  0xFC, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1C,
  0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x01,
  0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xFF, 0xFF, 0xF0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x1C, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x03, 0x80, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x1E, 0x00, 0xE0,
  0x0E, 0x00, 0x70, 0x07, 0xFF, 0xFF, 0xF8, 0x70, 0xE1, 0xC3, 0x87, 0x0E,
  0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3,
  0x87, 0x0E, 0x1C, 0x3F, 0xFF, 0xE0, 0x03, 0x00, 0x07, 0x00, 0x1E, 0x00,
  0x3E, 0x00, 0xFC, 0x01, 0xDC, 0x07, 0x38, 0x0E, 0x38, 0x38, 0x70, 0x70,
  0x61, 0xC0, 0xE3, 0x80, 0xCE, 0x01, 0xDC, 0x03, 0xC0, 0xFF, 0xFF, 0xFF,
  0xF0, 0xF8, 0xF0, 0xF0, 0xE0, 0xE0, 0x1F, 0xC3, 0xFE, 0x3F, 0xF2, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x7F, 0x3F, 0xF7, 0xE7, 0x70, 0x7F, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0xF7, 0x9F, 0x7F, 0xB3, 0xF3, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x39, 0xF0, 0xEF,
  0xF3, 0xBF, 0xCF, 0x87, 0xBC, 0x0E, 0xF0, 0x3B, 0xC0, 0xEF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xBC, 0x0E, 0xF0, 0x3B, 0xE1, 0xEF,
  0xFF, 0x3B, 0xFC, 0xE7, 0xE0, 0x0F, 0xE3, 0xFC, 0xFF, 0x9C, 0x07, 0x80,
  0xE0, 0x1C, 0x03, 0x80, 0xF0, 0x1E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xF0,
  0x1E, 0x09, 0xF7, 0x1F, 0xE1, 0xFC, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC3, 0xE7, 0x1F, 0xDC, 0xFF, 0xF7,
  0x87, 0xDE, 0x0F, 0x70, 0x3D, 0xC0, 0xFF, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x77, 0x03, 0xDC, 0x0F, 0x70, 0x3D, 0xE1, 0xF3, 0xFF, 0xCF, 0xF7,
  0x1F, 0x9C, 0x0F, 0xC0, 0xFF, 0x0F, 0xFC, 0xF0, 0xE7, 0x03, 0xB8, 0x1D,
  0xC0, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDC, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xE0, 0x27, 0xCF, 0x1F, 0xF8, 0x7F, 0x80, 0x07, 0xE1, 0xF8, 0x7F,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xFC, 0xFF, 0x9F, 0xF0, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x00, 0x0F, 0x9C, 0x7F, 0x73, 0xFF,
  0xDE, 0x1F, 0x78, 0x3D, 0xC0, 0xF7, 0x03, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x01, 0xDC, 0x07, 0x70, 0x3D, 0xC0, 0xF7, 0x83, 0xCF, 0xFF, 0x3F,
  0xDC, 0x7E, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xE6, 0x07, 0x9F,
  0xFC, 0x7F, 0xE0, 0x7E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1C, 0xFC, 0xEF, 0xF7, 0x7F, 0xBE, 0x1F, 0xE0,
  0xFF, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F,
  0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x38, 0x4F, 0xFF,
  0x40, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x08,
  0x3C, 0x78, 0xF0, 0x80, 0x00, 0x0F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7,
  0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1,
  0xC3, 0xBF, 0x7C, 0xF0, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x0F, 0xF0, 0xF7, 0x87, 0x3C, 0x71, 0xE7, 0x8F,
  0x38, 0x73, 0x83, 0xBC, 0x1D, 0xE0, 0xFF, 0x87, 0xDC, 0x3C, 0xF1, 0xE3,
  0x8F, 0x1E, 0x78, 0x73, 0xC3, 0xDE, 0x0E, 0xF0, 0x78, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE7, 0xC3,
  0xE7, 0x7F, 0x3F, 0xBF, 0xFF, 0xFF, 0xF1, 0xF8, 0xFF, 0x07, 0x83, 0xF8,
  0x3C, 0x1F, 0xC1, 0xE0, 0xFE, 0x0E, 0x07, 0xF0, 0x70, 0x3F, 0x83, 0x81,
  0xFC, 0x1C, 0x0F, 0xE0, 0xE0, 0x7F, 0x07, 0x03, 0xF8, 0x38, 0x1F, 0xC1,
  0xC0, 0xFE, 0x0E, 0x07, 0xF0, 0x70, 0x3F, 0x83, 0x81, 0xC0, 0xE7, 0xE7,
  0x7F, 0xBF, 0xFD, 0xF0, 0xFF, 0x07, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0,
  0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x81, 0xC0, 0x0F, 0xC0, 0x7F, 0xC3, 0xFF, 0x9E, 0x1E, 0x78,
  0x3D, 0xC0, 0xF7, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xDC,
  0x07, 0x70, 0x3D, 0xC0, 0xF7, 0x83, 0x8F, 0xBE, 0x1F, 0xF0, 0x3F, 0x80,
  0xE7, 0xC3, 0xBF, 0xCE, 0xFF, 0x3E, 0x1E, 0xF0, 0x3B, 0xC0, 0xEF, 0x03,
  0xBC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0E, 0xF0, 0x3B, 0xC0,
  0xEF, 0x87, 0xBF, 0xFC, 0xEF, 0xF3, 0x9F, 0x8F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x0F, 0x9C,
  0x7F, 0x73, 0xFF, 0xDE, 0x1F, 0x78, 0x3D, 0xC0, 0xF7, 0x03, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xDC, 0x07, 0x70, 0x3D, 0xC0, 0xF7, 0x87,
  0xCF, 0xBF, 0x3F, 0xDC, 0x7E, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0xE7, 0xF7, 0xFB, 0xFF,
  0x8F, 0x87, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x00, 0x1F, 0x8F, 0xFD, 0xFF, 0x78, 0x2E, 0x01,
  0xE0, 0x3E, 0x03, 0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x00, 0xF0, 0x1E, 0x03,
  0xE0, 0x7F, 0xBE, 0xFF, 0xCF, 0xE0, 0x38, 0x1C, 0x0E, 0x07, 0x07, 0xF7,
  0xFB, 0xFC, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x0E, 0x07, 0xB3, 0xF8, 0xFC, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xF8, 0x3F, 0xC3, 0xEF, 0xFF, 0x7F, 0xB9, 0xF9,
  0xC0, 0xF0, 0x1F, 0xC0, 0xF7, 0x03, 0xDC, 0x0E, 0x78, 0x38, 0xE1, 0xE3,
  0x87, 0x0E, 0x1C, 0x1C, 0x70, 0x73, 0x81, 0xCE, 0x07, 0x38, 0x0E, 0xE0,
  0x3F, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x78, 0x1D,
  0xC1, 0xE0, 0x77, 0x07, 0xC3, 0xDC, 0x1F, 0x0E, 0x78, 0xFC, 0x38, 0xE3,
  0xB0, 0xE3, 0x8E, 0xC3, 0x8E, 0x33, 0x9C, 0x38, 0xCE, 0x70, 0xF7, 0x39,
  0xC1, 0xDC, 0x67, 0x07, 0x71, 0xF8, 0x1D, 0x87, 0xE0, 0x76, 0x1F, 0x80,
  0xF8, 0x7E, 0x03, 0xE0, 0xF8, 0x0F, 0x03, 0xC0, 0x3C, 0x0F, 0x00, 0x70,
  0x3D, 0xE0, 0xE3, 0x87, 0x8F, 0x1C, 0x1C, 0xE0, 0x7B, 0x80, 0xFC, 0x03,
  0xF0, 0x07, 0x80, 0x1E, 0x00, 0xFC, 0x03, 0xF8, 0x1E, 0xE0, 0x73, 0xC3,
  0xC7, 0x0E, 0x1E, 0x78, 0x3B, 0xC0, 0xF0, 0xF0, 0x1D, 0xC0, 0xF7, 0x03,
  0xDC, 0x0E, 0x78, 0x38, 0xE1, 0xE3, 0x87, 0x0F, 0x1C, 0x1C, 0x70, 0x73,
  0x81, 0xCE, 0x03, 0xB8, 0x0E, 0xE0, 0x3F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x1F,
  0x80, 0x7C, 0x01, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0x03, 0x81,
  0xE0, 0x70, 0x3C, 0x0E, 0x07, 0x81, 0xC0, 0xF0, 0x38, 0x1E, 0x07, 0x03,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xC1, 0xF0, 0xFC, 0x3C, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x78, 0x1C, 0x3F, 0x0F, 0x03, 0xE0,
  0x3C, 0x07, 0x81, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xF8, 0x3F, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xC0, 0x3E, 0x0F, 0xC0, 0xF0, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x78, 0x0E, 0x03, 0xF0,
  0x3C, 0x1F, 0x0F, 0x03, 0x81, 0xE0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x07, 0xC3, 0xF0, 0xF0, 0x00, 0x3C, 0x07, 0xFC, 0x3F, 0xFF,
  0xE0, 0xFE, 0x80, 0x60,
};

const GFXglyph NotoSans_Condensed_Medium33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 4, 24, 8, 2, -24 },
  { 13, 10, 9, 13, 2, -24 },
  { 25, 16, 24, 17, 1, -24 },
  { 73, 12, 27, 16, 2, -25 },
  { 114, 22, 24, 25, 1, -24 },
  { 180, 18, 24, 19, 1, -24 },
  { 234, 3, 9, 7, 2, -24 },
  { 238, 7, 29, 10, 2, -24 },
  { 264, 7, 29, 10, 1, -24 },
  { 290, 13, 13, 15, 1, -25 },
  { 312, 14, 16, 16, 1, -20 },
  { 340, 5, 8, 8, 1, -4 },
  { 345, 8, 3, 10, 1, -10 },
  { 348, 4, 4, 8, 2, -4 },
  { 350, 12, 24, 13, 0, -24 },
  { 386, 13, 24, 16, 1, -24 },
  { 425, 9, 24, 16, 2, -24 },
  { 452, 13, 24, 16, 1, -24 },
  { 491, 13, 24, 16, 1, -24 },
  { 530, 14, 24, 16, 1, -24 },
  { 572, 12, 24, 16, 2, -24 },
  { 608, 13, 24, 16, 1, -24 },
  { 647, 14, 24, 16, 1, -24 },
  { 689, 14, 24, 16, 1, -24 },
  { 731, 13, 24, 16, 1, -24 },
  { 770, 4, 18, 8, 2, -18 },
  { 779, 5, 22, 8, 1, -18 },
  { 793, 14, 16, 16, 1, -20 },
  { 821, 14, 9, 16, 1, -16 },
  { 837, 14, 16, 16, 1, -20 },
  { 865, 11, 24, 12, 0, -24 },
  { 898, 21, 27, 24, 2, -24 },
  { 969, 17, 24, 17, 0, -24 },
  { 1020, 13, 24, 18, 3, -24 },
  { 1059, 14, 24, 17, 2, -24 },
  { 1101, 15, 24, 19, 3, -24 },
  { 1146, 10, 24, 15, 3, -24 },
  { 1176, 10, 24, 14, 3, -24 },
  { 1206, 16, 24, 20, 2, -24 },
  { 1254, 14, 24, 20, 3, -24 },
  { 1296, 8, 24, 10, 1, -24 },
  { 1320, 8, 31, 8, -2, -24 },
  { 1351, 14, 24, 17, 3, -24 },
  { 1393, 10, 24, 14, 3, -24 },
  { 1423, 20, 24, 26, 3, -24 },
  { 1483, 16, 24, 21, 3, -24 },
  { 1531, 17, 24, 21, 2, -24 },
  { 1582, 12, 24, 17, 3, -24 },
  { 1618, 17, 30, 21, 2, -24 },
  { 1682, 14, 24, 17, 3, -24 },
  { 1724, 13, 24, 15, 1, -24 },
  { 1763, 14, 24, 15, 0, -24 },
  { 1805, 15, 24, 20, 2, -24 },
  { 1850, 17, 24, 17, 0, -24 },
  { 1901, 26, 24, 26, 0, -24 },
  { 1979, 16, 24, 16, 0, -24 },
  { 2027, 15, 24, 15, 0, -24 },
  { 2072, 13, 24, 14, 1, -24 },
  { 2111, 8, 29, 10, 2, -24 },
  { 2140, 12, 24, 13, 0, -24 },
  { 2176, 7, 29, 10, 1, -24 },
  { 2202, 15, 14, 16, 1, -24 },
  { 2229, 14, 2, 14, 0, 3 },
  { 2233, 7, 5, 9, 1, -25 },
  { 2238, 12, 18, 16, 1, -18 },
  { 2265, 14, 25, 17, 2, -25 },
  { 2309, 11, 18, 13, 1, -18 },
  { 2334, 14, 25, 17, 1, -25 },
  { 2378, 13, 18, 16, 1, -18 },
  { 2408, 11, 25, 10, 0, -25 },
  { 2443, 14, 26, 17, 1, -18 },
  { 2489, 13, 25, 17, 2, -25 },
  { 2530, 4, 25, 8, 2, -25 },
  { 2543, 7, 33, 8, -1, -25 },
  { 2572, 13, 25, 15, 2, -25 },
  { 2613, 4, 25, 8, 2, -25 },
  { 2626, 21, 18, 26, 2, -18 },
  { 2674, 13, 18, 17, 2, -18 },
  { 2704, 14, 18, 17, 1, -18 },
  { 2736, 14, 26, 17, 2, -18 },
  { 2782, 14, 26, 17, 1, -18 },
  { 2828, 9, 18, 12, 2, -18 },
  { 2849, 11, 18, 13, 1, -18 },
  { 2874, 9, 22, 10, 1, -22 },
  { 2899, 13, 18, 17, 2, -18 },
  { 2929, 14, 18, 14, 0, -18 },
  { 2961, 22, 18, 22, 0, -18 },
  { 3011, 14, 18, 14, 0, -18 },
  { 3043, 14, 26, 14, 0, -18 },
  { 3089, 10, 18, 12, 1, -18 },
  { 3112, 10, 29, 12, 1, -24 },
  { 3149, 3, 33, 15, 6, -25 },
  { 3162, 10, 29, 12, 1, -24 },
  { 3199, 14, 5, 16, 1, -14 },
};

const GFXfont NotoSans_Condensed_Medium33pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Medium33pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Medium33pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _NOTOSANS_CONDENSED_MEDIUM33PT7B_H_
