#ifndef _NOTOSANS_CONDENSED_MEDIUM31PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUM31PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Medium.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Medium31pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFE, 0xEE, 0xEE, 0x66, 0x66, 0x60, 0x00, 0xEF, 0xFF,
  0xE7, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1B, 0x8D, 0xC6, 0x06, 0x38, 0x0C,
  0x60, 0x38, 0xC0, 0x71, 0x80, 0xE3, 0x01, 0x86, 0x3F, 0xFF, 0xFF, 0xFF,
  0x0C, 0x60, 0x38, 0xC0, 0x71, 0x80, 0xC3, 0x01, 0x8E, 0x1F, 0xFF, 0xBF,
  0xFF, 0x0C, 0x60, 0x38, 0xC0, 0x71, 0x80, 0xC3, 0x01, 0x8E, 0x03, 0x1C,
  0x06, 0x30, 0x00, 0x02, 0x00, 0x10, 0x00, 0x80, 0x1F, 0x83, 0xFF, 0x3F,
  0xF9, 0xC8, 0x5C, 0x40, 0xE2, 0x03, 0x90, 0x1E, 0x80, 0x7C, 0x01, 0xF8,
  0x03, 0xF0, 0x0F, 0xC0, 0x4E, 0x02, 0x30, 0x11, 0xE0, 0x9D, 0xC5, 0xEF,
  0xFE, 0x3F, 0xE0, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x3E, 0x03,
  0x03, 0xF0, 0x38, 0x19, 0xC1, 0x81, 0xC6, 0x1C, 0x0E, 0x30, 0xC0, 0x71,
  0x8E, 0x03, 0x8C, 0x70, 0x1C, 0x63, 0x00, 0xE3, 0x38, 0x87, 0x19, 0x9F,
  0x19, 0xDD, 0xFC, 0xFC, 0xEE, 0x63, 0xE6, 0x63, 0x80, 0x73, 0x1C, 0x03,
  0x18, 0xE0, 0x38, 0xC7, 0x01, 0x86, 0x38, 0x1C, 0x31, 0xC0, 0xE1, 0x8E,
  0x06, 0x0E, 0x60, 0x70, 0x3F, 0x03, 0x01, 0xF0, 0x1F, 0xC0, 0x0F, 0xE0,
  0x0E, 0x38, 0x07, 0x1C, 0x03, 0x8E, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0x7B,
  0x80, 0x1F, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xF0, 0xE7, 0xB8, 0xF3,
  0x8E, 0x73, 0x87, 0xB9, 0xC1, 0xFC, 0xE0, 0x7C, 0x70, 0x1E, 0x3C, 0x1F,
  0x0F, 0xFF, 0xC7, 0xFE, 0xF0, 0xFC, 0x3C, 0xFF, 0xFF, 0xFF, 0x0F, 0x0C,
  0x1C, 0x18, 0x38, 0x38, 0x70, 0x70, 0x70, 0x70, 0x70, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0x70, 0x70, 0x70, 0x70, 0x70, 0x38, 0x38, 0x1C, 0x1C, 0x0E,
  0x07, 0xE0, 0xE1, 0xC1, 0xC3, 0x83, 0x87, 0x0E, 0x1C, 0x1C, 0x38, 0x70,
  0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x70, 0xE1, 0xC3, 0x8E, 0x1C, 0x70, 0xC3,
  0x80, 0x0F, 0x00, 0x60, 0x06, 0x00, 0x60, 0xE6, 0x7F, 0xFF, 0xFF, 0xF0,
  0xF0, 0x1F, 0x83, 0x9C, 0x79, 0xE1, 0x08, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x83, 0xFF, 0xFF, 0xFF, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x7B, 0xDC, 0xE7, 0x33, 0x9C, 0xFF,
  0xFF, 0xF8, 0xEF, 0xFE, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0,
  0x18, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x00,
  0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x0F,
  0x00, 0x1F, 0x81, 0xFE, 0x0F, 0x78, 0xE1, 0xC7, 0x07, 0x38, 0x39, 0xC1,
  0xDE, 0x0E, 0xE0, 0x77, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3B,
  0xC1, 0xCE, 0x0E, 0x70, 0x73, 0x83, 0x9E, 0x38, 0x7B, 0xC3, 0xFC, 0x0F,
  0xC0, 0x07, 0x0F, 0x1F, 0x3F, 0x77, 0xE7, 0x47, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x3F,
  0x87, 0xFE, 0xF9, 0xE6, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00,
  0xE0, 0x0E, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x70, 0x0F, 0x01, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xCF, 0xFE, 0x71,
  0xE4, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0E, 0x01, 0xE1, 0xFC, 0x1F,
  0x01, 0xFC, 0x01, 0xE0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x80,
  0xFF, 0x3E, 0xFF, 0xE7, 0xF8, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0,
  0x6E, 0x03, 0x70, 0x3B, 0x83, 0x9C, 0x18, 0xE1, 0xC7, 0x0C, 0x38, 0xE1,
  0xC6, 0x0E, 0x70, 0x73, 0x03, 0x9F, 0xFF, 0xFF, 0xF8, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x7F, 0xDF, 0xFB, 0xFF, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xFE, 0x1F, 0xF3, 0xFF, 0x00, 0xF0, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1E, 0x07, 0xF3, 0xEF, 0xF9, 0xFE, 0x00,
  0x07, 0xE0, 0xFF, 0x07, 0x84, 0x70, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x67, 0xC7, 0x7F, 0x3F, 0xFD, 0xE0, 0xEF, 0x07, 0x78, 0x3F, 0xC0,
  0xEE, 0x07, 0x70, 0x7B, 0x83, 0x9E, 0x1C, 0x7B, 0xE1, 0xFE, 0x07, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1C,
  0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x1E, 0x00,
  0x1F, 0xC1, 0xFF, 0x1E, 0x3C, 0xE0, 0xE7, 0x07, 0x38, 0x39, 0xC1, 0xCF,
  0x1E, 0x3D, 0xE0, 0xFE, 0x03, 0xE0, 0x7F, 0x87, 0x9E, 0x38, 0x7B, 0xC1,
  0xDC, 0x07, 0xE0, 0x3F, 0x01, 0xFC, 0x1C, 0xF1, 0xE3, 0xFE, 0x0F, 0xE0,
  0x1F, 0x83, 0xFC, 0x79, 0xE7, 0x0F, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7F, 0x07, 0x70, 0xF7, 0xFF, 0x3F, 0xF1, 0xE7, 0x00, 0x70, 0x07,
  0x00, 0xF0, 0x0E, 0x01, 0xE4, 0x7C, 0x7F, 0x87, 0xF0, 0x6F, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0xFF, 0xE0, 0x33, 0xDE, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3D, 0xEE, 0x73, 0x99, 0xCE, 0x00, 0x00, 0x18, 0x03, 0xC0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x03, 0xC0, 0x1F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0x80, 0x0C, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x1F, 0x03, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x0E, 0x00, 0x40, 0x00, 0x7F, 0x9F, 0xF9, 0xCF, 0x20,
  0xF0, 0x0E, 0x01, 0xC0, 0x78, 0x0E, 0x03, 0xC0, 0xF0, 0x1C, 0x07, 0x00,
  0xE0, 0x38, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x0F, 0x01, 0xE0,
  0x38, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0xF8, 0x0F, 0x03, 0xC1, 0xC0, 0x0C,
  0x18, 0x00, 0xE3, 0x80, 0x07, 0x30, 0xFE, 0x77, 0x1F, 0xE3, 0x61, 0x8E,
  0x36, 0x38, 0xE3, 0x63, 0x0E, 0x36, 0x30, 0xE3, 0xE3, 0x0E, 0x3E, 0x30,
  0xE3, 0x63, 0x0E, 0x36, 0x39, 0xE7, 0x63, 0xFF, 0xE7, 0x1F, 0x3C, 0x70,
  0x40, 0x83, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x10, 0x0F, 0xFF, 0x00,
  0x7F, 0xF0, 0x00, 0x60, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0x60, 0x07, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E,
  0x38, 0x1C, 0x38, 0x1C, 0x38, 0x1C, 0x1C, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x38, 0x1E, 0x78, 0x0E, 0x70, 0x0E, 0x70, 0x0F, 0xF0, 0x07, 0xF0,
  0x07, 0xFF, 0xC7, 0xFF, 0xBF, 0xFD, 0xE0, 0xFF, 0x07, 0xF8, 0x1F, 0xC0,
  0xFE, 0x0F, 0xF0, 0x77, 0xFF, 0x3F, 0xF1, 0xFF, 0xEF, 0x07, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x1F, 0xFF, 0xEF, 0xFE, 0x7F,
  0xE0, 0x0F, 0xF0, 0xFF, 0xCF, 0x9C, 0xF0, 0x07, 0x00, 0x78, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1E, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x7F, 0xE1, 0xFF, 0x07,
  0xF8, 0xFF, 0x81, 0xFF, 0xC3, 0xFF, 0xC7, 0x83, 0xCF, 0x03, 0xDE, 0x07,
  0xBC, 0x07, 0x78, 0x0E, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0x78, 0x0E, 0xF0, 0x3D, 0xE0, 0x73, 0xC3,
  0xE7, 0xFF, 0x8F, 0xFE, 0x1F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1F, 0xFB, 0xFF, 0x7F, 0xEF,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x7F, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xFF, 0x7F, 0xEF, 0xFD, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x00, 0x07, 0xFC, 0x3F,
  0xFC, 0xFC, 0xF3, 0xE0, 0x27, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x01, 0xF8,
  0x03, 0xF8, 0x07, 0xF0, 0x0E, 0xE0, 0x1D, 0xE0, 0x39, 0xFB, 0xF1, 0xFF,
  0xE1, 0xFF, 0x80, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x70, 0xFF, 0xFF, 0x38, 0x38, 0x38, 0x38,
  0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38,
  0x38, 0x3C, 0xFF, 0xFF, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0E, 0x0E, 0x0E, 0xFE, 0xFC, 0xF8, 0xF0, 0x3F, 0xC1, 0xEF,
  0x07, 0x3C, 0x3C, 0xF1, 0xE3, 0xC7, 0x0F, 0x3C, 0x3D, 0xE0, 0xF7, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xE0, 0xFB, 0x83, 0xCF, 0x0F, 0x1C, 0x3C, 0x78,
  0xF0, 0xE3, 0xC3, 0xCF, 0x07, 0x3C, 0x1E, 0xF0, 0x3B, 0xC0, 0xF0, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xFC,
  0x01, 0xFF, 0xC0, 0x3F, 0xEC, 0x03, 0xFE, 0xE0, 0x3F, 0xEE, 0x03, 0x7E,
  0xE0, 0x77, 0xE6, 0x07, 0x7E, 0x70, 0x67, 0xE7, 0x0E, 0x7E, 0x30, 0xE7,
  0xE3, 0x8C, 0x7E, 0x39, 0xC7, 0xE3, 0x9C, 0x7E, 0x1D, 0x87, 0xE1, 0xF8,
  0x7E, 0x1F, 0x87, 0xE0, 0xF8, 0x7E, 0x0F, 0x07, 0xE0, 0xF0, 0x7E, 0x07,
  0x07, 0xF8, 0x07, 0xF8, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xEE,
  0x07, 0xEE, 0x07, 0xE7, 0x07, 0xE7, 0x07, 0xE3, 0x87, 0xE3, 0x87, 0xE1,
  0xC7, 0xE1, 0xC7, 0xE0, 0xE7, 0xE0, 0xE7, 0xE0, 0x77, 0xE0, 0x77, 0xE0,
  0x3F, 0xE0, 0x3F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0x0F, 0xF0, 0x3F,
  0xF8, 0x3E, 0x7C, 0x78, 0x1C, 0x70, 0x1E, 0xF0, 0x0E, 0xE0, 0x0E, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0E, 0xF0, 0x0E, 0x70, 0x1E, 0x78, 0x3C, 0x3F,
  0xFC, 0x1F, 0xF8, 0x0F, 0xE0, 0xFF, 0x8F, 0xFE, 0xFF, 0xFF, 0x0F, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF1, 0xFF, 0xFE, 0xFF,
  0xCF, 0xC0, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0x0F, 0xF0, 0x3F, 0xF8, 0x3E, 0x7C, 0x78, 0x1C, 0x70, 0x1E,
  0xF0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0E, 0xF0, 0x0E,
  0x70, 0x1E, 0x78, 0x3C, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0xFF, 0x83, 0xFF, 0x8F,
  0xFF, 0x3C, 0x3C, 0xF0, 0x73, 0xC1, 0xEF, 0x07, 0xBC, 0x1C, 0xF0, 0x73,
  0xC3, 0xCF, 0xFE, 0x3F, 0xF0, 0xFF, 0x83, 0xCF, 0x0F, 0x1C, 0x3C, 0x78,
  0xF0, 0xE3, 0xC3, 0xCF, 0x07, 0x3C, 0x1E, 0xF0, 0x3B, 0xC0, 0xF0, 0x1F,
  0xE3, 0xFF, 0x7D, 0xE7, 0x02, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0x78,
  0x03, 0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x00,
  0x70, 0x07, 0x80, 0xEF, 0xFE, 0xFF, 0xC7, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xF0, 0x1D, 0xC0, 0x77, 0x83, 0xDF, 0xFE, 0x3F, 0xF0, 0x7F, 0x80, 0xE0,
  0x0F, 0xF0, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x1C, 0x38, 0x1C, 0x38,
  0x1C, 0x38, 0x3C, 0x38, 0x38, 0x1C, 0x38, 0x1C, 0x38, 0x1C, 0x78, 0x1C,
  0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0xE0, 0x06, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xE0, 0x1C, 0x07, 0xF0, 0x3C,
  0x07, 0x70, 0x3C, 0x07, 0x70, 0x3E, 0x0F, 0x70, 0x3E, 0x0E, 0x70, 0x7E,
  0x0E, 0x38, 0x76, 0x0E, 0x38, 0x76, 0x0E, 0x38, 0x77, 0x1E, 0x38, 0x67,
  0x1C, 0x38, 0xE7, 0x1C, 0x1C, 0xE3, 0x1C, 0x1C, 0xE3, 0x9C, 0x1C, 0xC3,
  0xB8, 0x1D, 0xC3, 0xB8, 0x0D, 0xC1, 0xB8, 0x0F, 0xC1, 0xB8, 0x0F, 0xC1,
  0xB8, 0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x07, 0x80, 0xF0, 0x07, 0x80,
  0xF0, 0x70, 0x1C, 0xF0, 0x78, 0xE0, 0xE1, 0xE3, 0xC1, 0xC7, 0x03, 0x9E,
  0x03, 0xB8, 0x07, 0x70, 0x07, 0xC0, 0x0F, 0x80, 0x0E, 0x00, 0x3E, 0x00,
  0x7C, 0x01, 0xDC, 0x03, 0xB8, 0x0E, 0x78, 0x1C, 0x70, 0x78, 0xF0, 0xE0,
  0xE3, 0xC1, 0xE7, 0x01, 0xDE, 0x03, 0xC0, 0xF0, 0x1D, 0xC0, 0xF7, 0x03,
  0x8E, 0x0E, 0x38, 0x78, 0xF1, 0xC1, 0xC7, 0x07, 0x38, 0x0E, 0xE0, 0x3F,
  0x00, 0xFC, 0x01, 0xF0, 0x07, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x07, 0x80,
  0x70, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07,
  0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0x0E, 0x1C,
  0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87,
  0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xFF, 0xF8, 0xF0, 0x07, 0x00, 0x70, 0x03,
  0x80, 0x38, 0x01, 0x80, 0x1C, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x0E, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0x80, 0x1C, 0x01, 0xC0,
  0x0E, 0x00, 0xE0, 0x0F, 0xFF, 0xFC, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E,
  0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3,
  0x87, 0x0F, 0xFF, 0xF8, 0x07, 0x00, 0x1C, 0x00, 0xF8, 0x03, 0xE0, 0x0D,
  0xC0, 0x73, 0x01, 0x8E, 0x0E, 0x18, 0x30, 0x71, 0xC1, 0xC6, 0x03, 0xB8,
  0x0E, 0xE0, 0x1C, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0xF0, 0xE0, 0xE0, 0xE0,
  0x1F, 0x83, 0xFC, 0x3F, 0xE2, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x71, 0xFF,
  0x3F, 0xF7, 0x87, 0xF0, 0x7E, 0x0F, 0xE0, 0xFE, 0x0F, 0xF1, 0xF7, 0xF7,
  0x3E, 0x70, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0xF0, 0xEF, 0xE7, 0xFF, 0x3C, 0x3D, 0xE0, 0xEE, 0x07, 0x70,
  0x3F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x03, 0xF8, 0x1D, 0xE0, 0xEF, 0x07,
  0x7E, 0xFB, 0xBF, 0x9C, 0xF8, 0x0F, 0xC3, 0xFC, 0xFF, 0x3C, 0x07, 0x00,
  0xE0, 0x1C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x38, 0x07, 0x00, 0xF0,
  0x0F, 0x31, 0xFE, 0x1F, 0xC0, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE1, 0xE7, 0x3F, 0xB9, 0xFF, 0xDE, 0x1E, 0xE0,
  0xF7, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xDC, 0x0E,
  0xE0, 0xF7, 0x07, 0xBE, 0x7C, 0xFE, 0xE3, 0xE7, 0x0F, 0x81, 0xFC, 0x3D,
  0xE7, 0x07, 0x70, 0x77, 0x07, 0xF0, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xF0,
  0x07, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x73, 0xFF, 0x0F, 0xE0, 0x07, 0x83,
  0xF1, 0xFC, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0xFE, 0xFF, 0xBF, 0xE1, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x0F, 0x39, 0xFD, 0xCF, 0xFE, 0xF0, 0xF7, 0x07,
  0xB8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0E, 0xE0, 0x77,
  0x07, 0xB8, 0x3D, 0xF3, 0xE7, 0xF7, 0x1F, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x07, 0x38, 0x79, 0xFF, 0x8F, 0xF8, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x7C, 0xEF, 0xEF, 0xFE, 0xF0, 0xFF,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xFF, 0xA0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x1C, 0x71, 0xC2, 0x00, 0x01, 0xC7, 0x1C, 0x71,
  0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71,
  0xCF, 0xFF, 0xE0, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x0F, 0xE0, 0xEE, 0x1C, 0xE3, 0xCE, 0x38, 0xE7, 0x0E, 0xE0,
  0xEE, 0x0F, 0xF0, 0xFF, 0x0F, 0x38, 0xE3, 0x8E, 0x1C, 0xE1, 0xCE, 0x0E,
  0xE0, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE7, 0x87, 0xCE, 0xFE, 0xFE, 0xFF, 0xFF, 0xEF, 0x0F, 0x8F, 0xF0, 0xF0,
  0x7E, 0x0F, 0x07, 0xE0, 0x70, 0x7E, 0x07, 0x07, 0xE0, 0x70, 0x7E, 0x07,
  0x07, 0xE0, 0x70, 0x7E, 0x07, 0x07, 0xE0, 0x70, 0x7E, 0x07, 0x07, 0xE0,
  0x70, 0x7E, 0x07, 0x07, 0xE0, 0x70, 0x70, 0xE7, 0xCE, 0xFE, 0xFF, 0xEF,
  0x0F, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x70, 0x0F, 0x80, 0xFF,
  0x0F, 0xFC, 0xF0, 0xE7, 0x07, 0xB8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F,
  0x81, 0xFC, 0x0E, 0xE0, 0x77, 0x03, 0xBC, 0x38, 0xF3, 0xC7, 0xFC, 0x0F,
  0xC0, 0xE7, 0xC7, 0x7F, 0x3F, 0xF9, 0xE1, 0xEF, 0x07, 0x70, 0x3B, 0x81,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x1F, 0xC0, 0xEF, 0x07, 0x78, 0x3B,
  0xE7, 0xDD, 0xFC, 0xE7, 0xC7, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0x0F, 0x39, 0xFD, 0xCF, 0xFE, 0xF0, 0xF7, 0x07,
  0xB8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0E, 0xE0, 0x77,
  0x07, 0xB8, 0x3D, 0xF3, 0xE7, 0xF7, 0x1F, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0xE7, 0xEF, 0xFF, 0xF8, 0xF0,
  0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0x1F, 0x1F, 0xF7, 0xBB, 0x80, 0xE0, 0x38, 0x07, 0x81, 0xF8, 0x3F, 0x03,
  0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x7E, 0x3F, 0xFE, 0x7F, 0x00, 0x18, 0x0C,
  0x06, 0x07, 0xFF, 0xFF, 0xFC, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x3C, 0x1E, 0x47, 0xE1, 0xF0, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0xFF, 0x0F, 0x7B, 0xF7, 0xFF, 0x3F, 0x70, 0xE0,
  0x3F, 0x81, 0xDC, 0x0E, 0xE0, 0xE7, 0x07, 0x1C, 0x38, 0xE3, 0xC7, 0x1C,
  0x18, 0xE0, 0xE7, 0x07, 0x70, 0x3B, 0x80, 0xDC, 0x07, 0xC0, 0x3E, 0x00,
  0xF0, 0x07, 0x80, 0xE0, 0x70, 0x3B, 0x83, 0xC1, 0xDC, 0x3E, 0x1C, 0xE1,
  0xF0, 0xE7, 0x0D, 0x87, 0x38, 0x6C, 0x38, 0xE7, 0x73, 0x87, 0x3B, 0x9C,
  0x39, 0x8C, 0xE1, 0xCC, 0x67, 0x07, 0x63, 0xB0, 0x3F, 0x1F, 0x81, 0xF8,
  0xFC, 0x0F, 0x83, 0xE0, 0x3C, 0x1E, 0x01, 0xE0, 0xF0, 0x0F, 0x07, 0x80,
  0x70, 0x7B, 0xC3, 0x8E, 0x1C, 0x79, 0xC1, 0xCE, 0x0E, 0xE0, 0x3F, 0x01,
  0xF0, 0x07, 0x80, 0x7C, 0x03, 0xF0, 0x3B, 0x81, 0xCE, 0x1C, 0x70, 0xE1,
  0xCE, 0x0E, 0xF0, 0x38, 0xE0, 0x3F, 0x81, 0xDC, 0x0E, 0xE0, 0xE7, 0x07,
  0x1C, 0x38, 0xE3, 0xC7, 0x1C, 0x1C, 0xE0, 0xE7, 0x07, 0x70, 0x1B, 0x80,
  0xFC, 0x07, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x1E,
  0x00, 0xE0, 0x0F, 0x01, 0xF0, 0x0F, 0x00, 0xFF, 0xBF, 0xEF, 0xF8, 0x0E,
  0x07, 0x01, 0xC0, 0xE0, 0x38, 0x1C, 0x07, 0x03, 0x80, 0xE0, 0x70, 0x1C,
  0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x87, 0xC3, 0xC3, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x07, 0x8F, 0x87, 0x03, 0xE0, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x3C, 0x0F, 0x87, 0xC0, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0x7C, 0x0F, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0xC0, 0xF8, 0x1C,
  0x3E, 0x3C, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0xFC,
  0x7C, 0x38, 0x00, 0x7C, 0x0F, 0xF8, 0xFB, 0xFF, 0x07, 0xE0,
};

const GFXglyph NotoSans_Condensed_Medium31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 4, 22, 8, 2, -22 },
  { 12, 9, 8, 13, 2, -22 },
  { 21, 15, 22, 16, 1, -22 },
  { 63, 13, 26, 15, 1, -24 },
  { 106, 21, 22, 23, 1, -22 },
  { 164, 17, 22, 18, 1, -22 },
  { 211, 3, 8, 7, 2, -22 },
  { 214, 8, 27, 9, 1, -22 },
  { 241, 7, 27, 9, 1, -22 },
  { 265, 12, 12, 14, 1, -24 },
  { 283, 13, 14, 15, 1, -18 },
  { 306, 5, 8, 8, 1, -4 },
  { 311, 7, 3, 9, 1, -10 },
  { 314, 4, 4, 8, 2, -4 },
  { 316, 12, 22, 12, 0, -22 },
  { 349, 13, 22, 15, 1, -22 },
  { 385, 8, 22, 15, 2, -22 },
  { 407, 12, 22, 15, 1, -22 },
  { 440, 12, 22, 15, 1, -22 },
  { 473, 13, 22, 15, 1, -22 },
  { 509, 11, 22, 15, 2, -22 },
  { 540, 13, 22, 15, 1, -22 },
  { 576, 13, 22, 15, 1, -22 },
  { 612, 13, 22, 15, 1, -22 },
  { 648, 12, 22, 15, 1, -22 },
  { 681, 4, 17, 8, 2, -17 },
  { 690, 5, 21, 8, 1, -17 },
  { 704, 13, 14, 15, 1, -18 },
  { 727, 13, 8, 15, 1, -15 },
  { 740, 13, 14, 15, 1, -18 },
  { 763, 11, 22, 11, 0, -22 },
  { 794, 20, 25, 23, 1, -22 },
  { 857, 16, 22, 16, 0, -22 },
  { 901, 13, 22, 17, 2, -22 },
  { 937, 13, 22, 16, 2, -22 },
  { 973, 15, 22, 18, 2, -22 },
  { 1015, 11, 22, 14, 2, -22 },
  { 1046, 11, 22, 13, 2, -22 },
  { 1077, 15, 22, 19, 2, -22 },
  { 1119, 14, 22, 19, 2, -22 },
  { 1158, 8, 22, 10, 1, -22 },
  { 1180, 8, 28, 8, -2, -22 },
  { 1208, 14, 22, 16, 2, -22 },
  { 1247, 11, 22, 13, 2, -22 },
  { 1278, 20, 22, 24, 2, -22 },
  { 1333, 16, 22, 20, 2, -22 },
  { 1377, 16, 22, 20, 2, -22 },
  { 1421, 12, 22, 16, 2, -22 },
  { 1454, 16, 27, 20, 2, -22 },
  { 1508, 14, 22, 16, 2, -22 },
  { 1547, 12, 22, 14, 1, -22 },
  { 1580, 13, 22, 14, 0, -22 },
  { 1616, 14, 22, 19, 2, -22 },
  { 1655, 16, 22, 16, 0, -22 },
  { 1699, 24, 22, 25, 0, -22 },
  { 1765, 15, 22, 15, 0, -22 },
  { 1807, 14, 22, 14, 0, -22 },
  { 1846, 12, 22, 13, 1, -22 },
  { 1879, 7, 27, 10, 2, -22 },
  { 1903, 12, 22, 12, 0, -22 },
  { 1936, 7, 27, 10, 1, -22 },
  { 1960, 14, 13, 15, 1, -22 },
  { 1983, 13, 2, 13, 0, 3 },
  { 1987, 7, 5, 9, 1, -24 },
  { 1992, 12, 17, 15, 1, -17 },
  { 2018, 13, 24, 16, 2, -24 },
  { 2057, 11, 17, 12, 1, -17 },
  { 2081, 13, 24, 16, 1, -24 },
  { 2120, 12, 17, 15, 1, -17 },
  { 2146, 10, 24, 9, 0, -24 },
  { 2176, 13, 24, 16, 1, -17 },
  { 2215, 12, 24, 16, 2, -24 },
  { 2251, 3, 23, 7, 2, -23 },
  { 2260, 6, 30, 7, -1, -23 },
  { 2283, 12, 24, 14, 2, -24 },
  { 2319, 3, 24, 7, 2, -24 },
  { 2328, 20, 17, 24, 2, -17 },
  { 2371, 12, 17, 16, 2, -17 },
  { 2397, 13, 17, 16, 1, -17 },
  { 2425, 13, 24, 16, 2, -17 },
  { 2464, 13, 24, 16, 1, -17 },
  { 2503, 8, 17, 11, 2, -17 },
  { 2520, 10, 17, 12, 1, -17 },
  { 2542, 9, 20, 10, 0, -20 },
  { 2565, 12, 17, 16, 2, -17 },
  { 2591, 13, 17, 13, 0, -17 },
  { 2619, 21, 17, 21, 0, -17 },
  { 2664, 13, 17, 13, 0, -17 },
  { 2692, 13, 24, 13, 0, -17 },
  { 2731, 10, 17, 11, 1, -17 },
  { 2753, 9, 27, 11, 1, -22 },
  { 2784, 2, 31, 14, 6, -24 },
  { 2792, 9, 27, 11, 1, -22 },
  { 2823, 13, 4, 15, 1, -13 },
};

const GFXfont NotoSans_Condensed_Medium31pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Medium31pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Medium31pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _NOTOSANS_CONDENSED_MEDIUM31PT7B_H_
