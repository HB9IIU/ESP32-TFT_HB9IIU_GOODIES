#ifndef _NOTOSANS_CONDENSED_MEDIUM47PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUM47PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Medium.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Medium47pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFB, 0xEF, 0xBE, 0xFB, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x00, 0x00, 0x00, 0x7B, 0xFF,
  0xFF, 0xFD, 0xE2, 0x00, 0xF8, 0xFF, 0xC7, 0xFE, 0x1F, 0xF0, 0xFF, 0x87,
  0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1E, 0xE0, 0xF7,
  0x07, 0x80, 0x00, 0xE0, 0xF0, 0x01, 0xC1, 0xE0, 0x03, 0x83, 0x80, 0x0F,
  0x07, 0x00, 0x1E, 0x0E, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x78, 0x00, 0xE0,
  0xF0, 0x01, 0xC1, 0xC0, 0x03, 0x83, 0x81, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xE0, 0x78, 0x78, 0x00, 0xE0, 0xF0, 0x01, 0xC1, 0xC0,
  0x03, 0x83, 0x80, 0x0F, 0x07, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x3C, 0x00,
  0x70, 0x78, 0x1F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x0F,
  0x07, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x70, 0x78, 0x00, 0xE0,
  0xF0, 0x01, 0xC1, 0xC0, 0x03, 0x83, 0x80, 0x0F, 0x07, 0x00, 0x1E, 0x1E,
  0x00, 0x3C, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x03, 0xFC, 0x03, 0xFF, 0xE3, 0xFF, 0xFC, 0xFF, 0xFE, 0x7E, 0xE3,
  0x9E, 0x38, 0x2F, 0x8E, 0x03, 0xE3, 0x80, 0xF8, 0xE0, 0x3E, 0x38, 0x0F,
  0x8E, 0x01, 0xFB, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x0E, 0xFC, 0x03, 0x9F, 0x00, 0xE3,
  0xC0, 0x38, 0xF0, 0x0E, 0x3C, 0x03, 0x8F, 0xC0, 0xE7, 0xFE, 0x3F, 0xEF,
  0xFF, 0xFB, 0xFF, 0xFC, 0x7F, 0xFC, 0x01, 0xF8, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00,
  0x7F, 0x80, 0x1E, 0x00, 0xFF, 0x80, 0x38, 0x03, 0xCF, 0x00, 0xF0, 0x07,
  0x0E, 0x01, 0xE0, 0x1E, 0x1E, 0x07, 0x80, 0x3C, 0x3C, 0x0F, 0x00, 0x78,
  0x78, 0x1C, 0x00, 0xF0, 0x70, 0x78, 0x01, 0xE0, 0xE0, 0xF0, 0x03, 0xC1,
  0xC3, 0xC0, 0x07, 0x83, 0x87, 0x80, 0x0F, 0x0F, 0x1E, 0x00, 0x1E, 0x1E,
  0x3C, 0x18, 0x3C, 0x3C, 0x71, 0xFC, 0x78, 0x79, 0xE3, 0xFC, 0x70, 0xF3,
  0xCF, 0xFC, 0xFB, 0xCF, 0x3C, 0x78, 0xFF, 0x9E, 0x78, 0x71, 0xFE, 0x38,
  0xF0, 0xF0, 0xF8, 0xF1, 0xE1, 0xE0, 0x01, 0xE3, 0x83, 0xC0, 0x07, 0x87,
  0x07, 0x80, 0x0F, 0x0E, 0x0F, 0x00, 0x3C, 0x1C, 0x1E, 0x00, 0x78, 0x38,
  0x3C, 0x00, 0xE0, 0x70, 0x78, 0x03, 0xC0, 0xF0, 0xF0, 0x07, 0x81, 0xE1,
  0xE0, 0x1E, 0x03, 0xC3, 0x80, 0x3C, 0x03, 0xCF, 0x00, 0x70, 0x07, 0xFE,
  0x01, 0xE0, 0x07, 0xF8, 0x07, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x01, 0xF1, 0xF0, 0x01,
  0xF0, 0x78, 0x00, 0xF8, 0x3C, 0x00, 0x7C, 0x1E, 0x00, 0x3E, 0x0F, 0x00,
  0x1F, 0x07, 0x80, 0x07, 0x87, 0xC0, 0x03, 0xE3, 0xC0, 0x01, 0xF3, 0xE0,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xF8, 0x0F, 0x8F, 0xFE, 0x07, 0x8F, 0xDF, 0x87, 0xC7, 0xC7,
  0xC3, 0xE7, 0xC1, 0xF1, 0xF3, 0xE0, 0x7D, 0xF1, 0xF0, 0x3F, 0xF8, 0xF0,
  0x0F, 0xF8, 0x78, 0x03, 0xFC, 0x3E, 0x00, 0xFC, 0x1F, 0x00, 0x7E, 0x0F,
  0x80, 0x7F, 0x87, 0xE0, 0x7F, 0xC1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFE, 0xFC,
  0x3F, 0xFE, 0x3F, 0x07, 0xFC, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFB, 0xDE,
  0xF7, 0xBC, 0xE7, 0x00, 0x01, 0xE0, 0x78, 0x1F, 0x03, 0xC0, 0xF0, 0x1E,
  0x07, 0xC0, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x1E,
  0x03, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF8, 0x1F, 0x01, 0xE0,
  0x3E, 0x07, 0xC0, 0x78, 0x0F, 0x80, 0xF0, 0x1F, 0x01, 0xE0, 0x3E, 0x03,
  0xE0, 0xF0, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x78,
  0x0F, 0x80, 0xF0, 0x1F, 0x03, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xE0, 0x3C, 0x07, 0x81, 0xF0, 0x3E, 0x07, 0x81, 0xF0,
  0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x0F, 0x03, 0xE0, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x20, 0x70, 0x2F,
  0x1C, 0x7B, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xF0, 0x3E, 0x00, 0x1F,
  0xC0, 0x0F, 0x78, 0x07, 0xDF, 0x01, 0xE3, 0xE0, 0xF8, 0xFC, 0x3C, 0x1E,
  0x03, 0x06, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x3E, 0x7D,
  0xF3, 0xE7, 0xCF, 0x1E, 0x7C, 0xF1, 0xE3, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x7B, 0xEF, 0xFF, 0xFD, 0xE2, 0x00, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00,
  0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x01,
  0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07,
  0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1E,
  0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78,
  0x00, 0xF8, 0x00, 0xF0, 0x00, 0x03, 0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xF8,
  0x0F, 0xFF, 0x83, 0xF1, 0xF0, 0x7C, 0x1F, 0x1F, 0x03, 0xE3, 0xE0, 0x3C,
  0x78, 0x07, 0xDF, 0x00, 0xFB, 0xE0, 0x1F, 0x7C, 0x01, 0xEF, 0x80, 0x3D,
  0xF0, 0x07, 0xBE, 0x00, 0xF7, 0xC0, 0x1E, 0xF8, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0x0F, 0xFC, 0x01, 0xEF, 0x80, 0x3D, 0xF0, 0x07, 0xBE, 0x00, 0xF7,
  0xC0, 0x3E, 0xF8, 0x07, 0xCF, 0x00, 0xF9, 0xF0, 0x1F, 0x3E, 0x03, 0xC7,
  0xC0, 0xF8, 0x7C, 0x3F, 0x0F, 0xFF, 0xC0, 0xFF, 0xF0, 0x0F, 0xFC, 0x00,
  0xFF, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0xFE, 0x0F, 0xF0, 0xFF, 0x8F, 0xFC,
  0xFB, 0xEF, 0xDF, 0xF8, 0xFB, 0x87, 0xC8, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x07, 0xF0,
  0x07, 0xFF, 0x07, 0xFF, 0xE3, 0xFF, 0xFC, 0xFC, 0x3F, 0x9C, 0x03, 0xE2,
  0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x07, 0xF0, 0x0F, 0xFF, 0x07, 0xFF, 0xE3, 0xFF, 0xFC,
  0x78, 0x1F, 0x98, 0x03, 0xE4, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x0F,
  0xE0, 0x3F, 0xF0, 0x0F, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0xFE,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x0F, 0xF0, 0x07, 0xEF, 0xFF,
  0xFB, 0xFF, 0xFC, 0xFF, 0xFE, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xDE, 0x00, 0x1F, 0xF0, 0x00, 0xEF, 0x80, 0x0F, 0x7C, 0x00, 0x73,
  0xE0, 0x07, 0x9F, 0x00, 0x38, 0xF8, 0x03, 0xC7, 0xC0, 0x3C, 0x3E, 0x01,
  0xE1, 0xF0, 0x1E, 0x0F, 0x80, 0xF0, 0x7C, 0x0F, 0x03, 0xE0, 0x78, 0x1F,
  0x07, 0x80, 0xF8, 0x3C, 0x07, 0xC3, 0xC0, 0x3E, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x3F, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F,
  0xFF, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0xFC, 0x07, 0xFF, 0xC1,
  0xFF, 0xFC, 0x7F, 0xFF, 0x0C, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x0F, 0xB8, 0x07, 0xEF, 0xFF, 0xF3,
  0xFF, 0xF8, 0xFF, 0xFC, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0xF0,
  0x1F, 0xFE, 0x07, 0xFF, 0xC1, 0xFC, 0x08, 0x3E, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x01, 0xF3, 0xF8, 0x3E, 0xFF, 0xC7, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F,
  0xC1, 0xFB, 0xF0, 0x1F, 0x7C, 0x03, 0xEF, 0x80, 0x3D, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xEF, 0x00, 0x7D, 0xE0, 0x0F, 0x3E,
  0x03, 0xE7, 0xC0, 0x7C, 0x7C, 0x1F, 0x0F, 0xFF, 0xE0, 0xFF, 0xF8, 0x0F,
  0xFE, 0x00, 0x7F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC,
  0x1F, 0xFF, 0xC7, 0xE0, 0xF8, 0xF8, 0x0F, 0x9E, 0x01, 0xF3, 0xC0, 0x3E,
  0x78, 0x07, 0xCF, 0x00, 0xF9, 0xF0, 0x1F, 0x3E, 0x07, 0xC3, 0xE0, 0xF8,
  0x7E, 0x7E, 0x07, 0xFF, 0x80, 0x7F, 0xE0, 0x07, 0xF8, 0x01, 0xFF, 0x80,
  0x7F, 0xF8, 0x1F, 0x9F, 0x87, 0xC0, 0xF8, 0xF0, 0x0F, 0xBE, 0x01, 0xF7,
  0xC0, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x7D, 0xF8, 0x0F, 0x9F, 0xCF, 0xE1, 0xFF, 0xFC, 0x1F, 0xFF, 0x01,
  0xFF, 0x80, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x7E,
  0x1F, 0x1F, 0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0x7C, 0x0F, 0xDF, 0x87, 0xF3, 0xFF, 0xBC, 0xFF, 0xEF, 0x1F,
  0xF3, 0xC1, 0xF0, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x1F, 0x83, 0xFF, 0xE0,
  0xFF, 0xF0, 0x3F, 0xF0, 0x0F, 0xF8, 0x00, 0x33, 0xEF, 0xFF, 0xFF, 0xE7,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7B, 0xEF,
  0xFF, 0xFD, 0xE2, 0x00, 0x18, 0xF9, 0xFB, 0xF7, 0xEF, 0x8E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xDF,
  0x3E, 0x7C, 0xF9, 0xE3, 0xCF, 0x9E, 0x3C, 0x70, 0x00, 0x00, 0x20, 0x00,
  0x1C, 0x00, 0x0F, 0x80, 0x07, 0xF0, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0x7C, 0x00,
  0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xF0, 0x00, 0x1E, 0x00, 0x00,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x80, 0x00, 0x18, 0x00,
  0x03, 0xC0, 0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xF0, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x03, 0xF8, 0x00, 0x7C, 0x00, 0x0E, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x3F, 0xF8, 0xFF, 0xFE, 0x7F, 0xFE, 0x78, 0x3F, 0x20,
  0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x07,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x01, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F,
  0xF3, 0xFC, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x3C, 0x03, 0xE0,
  0x00, 0x3C, 0x0F, 0x80, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x78, 0x78, 0x07,
  0xC0, 0x70, 0xF0, 0x3F, 0xF0, 0xF1, 0xC0, 0xFF, 0xE1, 0xE7, 0x83, 0xE3,
  0xC1, 0xCF, 0x07, 0x87, 0x83, 0x9E, 0x1E, 0x0F, 0x07, 0x38, 0x3C, 0x1E,
  0x0F, 0xF0, 0x70, 0x3C, 0x1F, 0xE1, 0xE0, 0x78, 0x3F, 0xC3, 0xC0, 0xF0,
  0x7F, 0x87, 0x81, 0xE0, 0xEF, 0x0F, 0x03, 0xC1, 0xDE, 0x1E, 0x07, 0x83,
  0xBC, 0x3C, 0x1F, 0x0F, 0x78, 0x38, 0x3E, 0x1E, 0xF0, 0x78, 0x7C, 0x38,
  0xE0, 0xFF, 0xDF, 0xF1, 0xE0, 0xFF, 0x3F, 0xC3, 0xC0, 0xFC, 0x3F, 0x07,
  0x80, 0x70, 0x38, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x04, 0x00, 0x1F,
  0xE0, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xDE,
  0x00, 0x03, 0xEF, 0x00, 0x01, 0xF7, 0x80, 0x00, 0xF3, 0xE0, 0x00, 0x78,
  0xF0, 0x00, 0x7C, 0x78, 0x00, 0x3E, 0x3E, 0x00, 0x1E, 0x1F, 0x00, 0x1F,
  0x07, 0x80, 0x0F, 0x83, 0xC0, 0x07, 0xC1, 0xF0, 0x03, 0xC0, 0xF8, 0x03,
  0xE0, 0x3C, 0x01, 0xF0, 0x1F, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0,
  0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x3E,
  0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE3, 0xE0, 0x01,
  0xF1, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x3E, 0xFC, 0x00, 0x1F, 0x7C, 0x00,
  0x0F, 0xC0, 0xFF, 0x80, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF,
  0x0F, 0xFD, 0xE0, 0x1F, 0xBC, 0x01, 0xF7, 0x80, 0x3F, 0xF0, 0x03, 0xFE,
  0x00, 0x7F, 0xC0, 0x0F, 0x78, 0x03, 0xEF, 0x00, 0x7D, 0xE0, 0x1F, 0x3C,
  0x1F, 0xE7, 0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xFF, 0xE3, 0xC1, 0xFE, 0x78,
  0x07, 0xEF, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0,
  0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xE0,
  0x1F, 0xBF, 0xFF, 0xF7, 0xFF, 0xFC, 0xFF, 0xFE, 0x1F, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x0F, 0xFF, 0x80, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFE, 0x0F,
  0x0F, 0xC0, 0x10, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x18, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x03,
  0xFF, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x3F, 0xFF,
  0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x78, 0x07, 0xE3, 0xC0, 0x1F, 0x9E,
  0x00, 0x7E, 0xF0, 0x01, 0xF7, 0x80, 0x0F, 0xBC, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xF7, 0x80,
  0x0F, 0xBC, 0x00, 0xFD, 0xE0, 0x0F, 0xCF, 0x00, 0xFE, 0x78, 0x1F, 0xE3,
  0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0xFF, 0xFC, 0x07, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3F, 0xFF, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xF7, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xFF, 0xFD, 0xFF,
  0xFB, 0xFF, 0xF7, 0xFF, 0xEF, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x01, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0x03, 0xC1, 0xF8, 0x01,
  0x87, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xE0, 0x3F, 0xF7, 0xC0, 0x01, 0xEF, 0x80, 0x03, 0xDF, 0x00,
  0x07, 0xBE, 0x00, 0x0F, 0x7C, 0x00, 0x1E, 0x7C, 0x00, 0x3C, 0xF8, 0x00,
  0x79, 0xF8, 0x00, 0xF1, 0xF8, 0x01, 0xE1, 0xFC, 0x03, 0xC3, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0xF0, 0x00, 0xFF,
  0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0x80, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xE1, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x0F, 0xE7, 0xFF, 0xFF,
  0xFF, 0xFC, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x81, 0xF0, 0x3E, 0x07, 0xC1, 0xFF, 0xFE, 0xFF, 0xDF, 0xF3,
  0xF8, 0x00, 0xF0, 0x01, 0xFF, 0x00, 0x3E, 0xF0, 0x03, 0xEF, 0x00, 0x7C,
  0xF0, 0x0F, 0x8F, 0x00, 0xF8, 0xF0, 0x1F, 0x0F, 0x03, 0xF0, 0xF0, 0x3E,
  0x0F, 0x07, 0xC0, 0xF0, 0xFC, 0x0F, 0x0F, 0x80, 0xF1, 0xF0, 0x0F, 0x3F,
  0x00, 0xF3, 0xE0, 0x0F, 0x7E, 0x00, 0xF7, 0xE0, 0x0F, 0xFF, 0x00, 0xFF,
  0xF0, 0x0F, 0xDF, 0x80, 0xF8, 0xF8, 0x0F, 0x0F, 0xC0, 0xF0, 0x7C, 0x0F,
  0x03, 0xE0, 0xF0, 0x3E, 0x0F, 0x01, 0xF0, 0xF0, 0x1F, 0x0F, 0x00, 0xF8,
  0xF0, 0x0F, 0xCF, 0x00, 0x7C, 0xF0, 0x07, 0xEF, 0x00, 0x3E, 0xF0, 0x03,
  0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF,
  0xF7, 0x80, 0x0F, 0x7F, 0xBC, 0x00, 0x7B, 0xFD, 0xE0, 0x03, 0xDF, 0xE7,
  0x80, 0x3C, 0xFF, 0x3C, 0x01, 0xE7, 0xF9, 0xE0, 0x0F, 0x3F, 0xCF, 0x80,
  0xF1, 0xFE, 0x3C, 0x07, 0x8F, 0xF1, 0xE0, 0x3C, 0x7F, 0x8F, 0x83, 0xE3,
  0xFC, 0x3C, 0x1E, 0x1F, 0xE1, 0xE0, 0xF0, 0xFF, 0x0F, 0x07, 0x87, 0xF8,
  0x3C, 0x78, 0x3F, 0xC1, 0xE3, 0xC1, 0xFE, 0x0F, 0x1E, 0x0F, 0xF0, 0x7D,
  0xE0, 0x7F, 0x81, 0xEF, 0x03, 0xFC, 0x0F, 0x78, 0x1F, 0xE0, 0x7F, 0x80,
  0xFF, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0x7E, 0x01, 0xFE,
  0x01, 0xF0, 0x0F, 0xF0, 0x0F, 0x80, 0x7F, 0x80, 0x7C, 0x03, 0xC0, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x1F, 0xF7, 0x80,
  0x3F, 0xEF, 0x80, 0x7F, 0xDF, 0x00, 0xFF, 0x9F, 0x01, 0xFF, 0x3E, 0x03,
  0xFE, 0x3E, 0x07, 0xFC, 0x7C, 0x0F, 0xF8, 0x7C, 0x1F, 0xF0, 0xF8, 0x3F,
  0xE0, 0xF8, 0x7F, 0xC1, 0xF0, 0xFF, 0x81, 0xF1, 0xFF, 0x03, 0xE3, 0xFE,
  0x03, 0xE7, 0xFC, 0x07, 0xCF, 0xF8, 0x07, 0xDF, 0xF0, 0x0F, 0xBF, 0xE0,
  0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x00,
  0xFC, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x01, 0xFE, 0x1F, 0xC0, 0xFC, 0x03, 0xF0, 0xFC, 0x00, 0xF8, 0x7C,
  0x00, 0x7E, 0x3E, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0x9F, 0x00, 0x07, 0xCF,
  0x80, 0x01, 0xF7, 0xC0, 0x00, 0xFB, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0xFB, 0xE0, 0x00, 0x7D, 0xF0, 0x00,
  0x3E, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x3F, 0x00, 0x0F, 0x8F, 0x80,
  0x0F, 0xC7, 0xE0, 0x07, 0xC1, 0xF8, 0x07, 0xE0, 0xFE, 0x07, 0xE0, 0x3F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0x00, 0x3F, 0xFE, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0xFF, 0xFF, 0xBC,
  0x07, 0xEF, 0x00, 0xFB, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0xFB, 0xC0, 0x3E,
  0xF0, 0x3F, 0xBF, 0xFF, 0xCF, 0xFF, 0xE3, 0xFF, 0xF0, 0xFF, 0xF0, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xFE, 0x1F, 0xC0, 0xFC, 0x03, 0xF0,
  0xFC, 0x00, 0xF8, 0x7C, 0x00, 0x7E, 0x3E, 0x00, 0x1F, 0x3E, 0x00, 0x0F,
  0x9F, 0x00, 0x07, 0xEF, 0x80, 0x01, 0xF7, 0xC0, 0x00, 0xFB, 0xE0, 0x00,
  0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0xFB, 0xE0,
  0x00, 0x7D, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x1F,
  0x00, 0x0F, 0x8F, 0x80, 0x0F, 0xC7, 0xE0, 0x07, 0xC1, 0xF8, 0x07, 0xE0,
  0xFE, 0x07, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xE0,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0x01, 0xF8, 0xF0, 0x0F, 0xCF, 0x00,
  0x7C, 0xF0, 0x07, 0xCF, 0x00, 0x7C, 0xF0, 0x07, 0xCF, 0x00, 0x7C, 0xF0,
  0x07, 0xCF, 0x00, 0xFC, 0xF0, 0x0F, 0x8F, 0x01, 0xF8, 0xFF, 0xFF, 0x0F,
  0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0xF0, 0xF8, 0x0F, 0x07, 0xC0,
  0xF0, 0x7C, 0x0F, 0x03, 0xE0, 0xF0, 0x3E, 0x0F, 0x01, 0xF0, 0xF0, 0x1F,
  0x0F, 0x00, 0xF8, 0xF0, 0x0F, 0x8F, 0x00, 0x7C, 0xF0, 0x07, 0xCF, 0x00,
  0x3E, 0xF0, 0x03, 0xEF, 0x00, 0x3F, 0x03, 0xFC, 0x03, 0xFF, 0xE1, 0xFF,
  0xF8, 0xFF, 0xFE, 0x7F, 0x1F, 0x1F, 0x00, 0x4F, 0xC0, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x1F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x80, 0x0F, 0xBC,
  0x0F, 0xEF, 0xFF, 0xF3, 0xFF, 0xF8, 0xFF, 0xFC, 0x1F, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0x7D, 0xE0, 0x01, 0xE7, 0xC0, 0x0F, 0x9F, 0x00,
  0x3E, 0x7E, 0x01, 0xF8, 0xFC, 0x0F, 0xC3, 0xFF, 0xFF, 0x07, 0xFF, 0xF8,
  0x0F, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0x78, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3C,
  0x3C, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x78,
  0x1E, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x1F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xE0, 0x07, 0x83, 0xE0,
  0x07, 0xC3, 0xE0, 0x07, 0xC3, 0xE0, 0x03, 0xC3, 0xC0, 0x03, 0xC7, 0xC0,
  0x03, 0xE7, 0xC0, 0x03, 0xE7, 0x80, 0x01, 0xE7, 0x80, 0x01, 0xEF, 0x80,
  0x01, 0xEF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xC0, 0x07, 0xDE, 0x00, 0x3E,
  0x00, 0x3E, 0xF8, 0x01, 0xF8, 0x01, 0xE7, 0xC0, 0x1F, 0xC0, 0x1F, 0x3E,
  0x00, 0xFE, 0x00, 0xF9, 0xF0, 0x07, 0xF0, 0x07, 0xC7, 0x80, 0x3B, 0x80,
  0x3E, 0x3E, 0x01, 0xDE, 0x01, 0xE1, 0xF0, 0x1E, 0xF0, 0x1F, 0x0F, 0x80,
  0xF7, 0x80, 0xF8, 0x3C, 0x07, 0xBC, 0x07, 0xC1, 0xE0, 0x3D, 0xF0, 0x3C,
  0x0F, 0x83, 0xC7, 0x83, 0xE0, 0x7C, 0x1E, 0x3C, 0x1F, 0x03, 0xE0, 0xF1,
  0xE0, 0xF8, 0x0F, 0x07, 0x8F, 0x07, 0xC0, 0x78, 0x7C, 0x3C, 0x3C, 0x03,
  0xE3, 0xC1, 0xE3, 0xE0, 0x1F, 0x1E, 0x0F, 0x1F, 0x00, 0x78, 0xF0, 0x78,
  0xF8, 0x03, 0xC7, 0x83, 0xE7, 0x80, 0x1E, 0x78, 0x0F, 0x3C, 0x00, 0xFB,
  0xC0, 0x7B, 0xE0, 0x07, 0xDE, 0x03, 0xDF, 0x00, 0x1E, 0xF0, 0x1E, 0xF8,
  0x00, 0xF7, 0x80, 0x77, 0x80, 0x07, 0xB8, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x1F, 0xE0, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x07,
  0xE0, 0x00, 0x7C, 0x00, 0x7D, 0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0x80,
  0x7C, 0x1F, 0x01, 0xF0, 0x7C, 0x0F, 0x80, 0xF8, 0x3E, 0x03, 0xE0, 0xF0,
  0x07, 0xC7, 0xC0, 0x1F, 0x1E, 0x00, 0x3C, 0xF8, 0x00, 0xFB, 0xE0, 0x01,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00,
  0x0F, 0xBC, 0x00, 0x3E, 0xF8, 0x01, 0xF1, 0xE0, 0x07, 0xC7, 0xC0, 0x3E,
  0x1F, 0x00, 0xF8, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x01, 0xF0, 0xF8, 0x07,
  0xC3, 0xE0, 0x0F, 0x9F, 0x00, 0x3E, 0x7C, 0x00, 0xFF, 0xF0, 0x01, 0xF0,
  0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xE7, 0xC0, 0x0F, 0x9F, 0x00, 0x3E, 0x3E,
  0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x1E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x3E, 0x1F, 0x00, 0xF8, 0x7C, 0x01, 0xE1, 0xE0, 0x07, 0xCF, 0x80,
  0x1F, 0x3C, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00,
  0xF8, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x3E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F,
  0x78, 0x00, 0x7B, 0xC0, 0x07, 0x8F, 0x00, 0x3C, 0x78, 0x03, 0xE1, 0xE0,
  0x1E, 0x0F, 0x00, 0xF0, 0x3C, 0x0F, 0x01, 0xE0, 0x78, 0x07, 0x87, 0x80,
  0x3C, 0x3C, 0x00, 0xF3, 0xC0, 0x07, 0x9E, 0x00, 0x1F, 0xE0, 0x00, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x1F, 0x07, 0xE0,
  0xF8, 0x1F, 0x03, 0xE0, 0x78, 0x0F, 0x03, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF,
  0x87, 0xFF, 0xE1, 0xC1, 0xF0, 0x80, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0xFF, 0xF1, 0xFF, 0xFB, 0xFF, 0xFD,
  0xF8, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xFC, 0x07, 0xFC, 0x03, 0xFE, 0x01,
  0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xF1, 0xFE, 0xFF, 0xEF, 0x7F, 0xE7, 0x8F,
  0xE1, 0xC0, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE1, 0xE0, 0x7C, 0xFF, 0x0F, 0xBF, 0xF1, 0xFF, 0xFF, 0x3F,
  0xC7, 0xF7, 0xF0, 0x3E, 0xFC, 0x07, 0xDF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF8,
  0x07, 0xFF, 0x01, 0xF7, 0xF0, 0x3E, 0xFF, 0xBF, 0x9E, 0xFF, 0xF3, 0xCF,
  0xFC, 0x78, 0xFF, 0x00, 0x01, 0xF8, 0x07, 0xFF, 0x0F, 0xFE, 0x1F, 0xFE,
  0x3F, 0x0E, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x02,
  0x3F, 0xFE, 0x1F, 0xFE, 0x0F, 0xFE, 0x07, 0xFC, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x07, 0x87, 0xF8,
  0xF1, 0xFF, 0x9E, 0x7F, 0xFB, 0xCF, 0xC7, 0xFB, 0xF0, 0x3F, 0x7C, 0x07,
  0xEF, 0x80, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07,
  0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x3E, 0xF8, 0x07, 0xDF, 0x01, 0xFB, 0xF0, 0x3F,
  0x3F, 0xBF, 0xE7, 0xFF, 0xBC, 0x7F, 0xE7, 0x83, 0xF8, 0xF0, 0x01, 0xF0,
  0x01, 0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0xFC, 0x3E, 0x0F, 0x9F, 0x03, 0xE7,
  0xC0, 0x7D, 0xE0, 0x1F, 0x78, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x23,
  0xFC, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0x80, 0xFF, 0xC0, 0x01, 0xF8, 0x1F,
  0xF0, 0xFF, 0xC3, 0xFE, 0x1F, 0x88, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x1F, 0xFC, 0xFF, 0xF3, 0xFF, 0xC1, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xFE, 0x3C, 0x7F, 0xE7, 0x9F, 0xFE, 0xF3, 0xF1, 0xFE,
  0xFC, 0x0F, 0xDF, 0x01, 0xFB, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F,
  0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xBE, 0x01, 0xF7,
  0xC0, 0x7E, 0xFC, 0x1F, 0xCF, 0xEF, 0xF9, 0xFF, 0xEF, 0x1F, 0xF9, 0xE0,
  0xFE, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xFA, 0x00, 0x3E, 0x70, 0x0F, 0xCF, 0xFF, 0xF1, 0xFF, 0xFE, 0x3F,
  0xFF, 0x01, 0xFF, 0x80, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x87, 0x83, 0xE7, 0xF8, 0xFB, 0xFF, 0x3F, 0xFF, 0xEF,
  0xF1, 0xFF, 0xF8, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03,
  0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0,
  0x0F, 0x77, 0xFF, 0xFF, 0xB8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07,
  0x07, 0xC3, 0xE1, 0xF0, 0xF8, 0x38, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE1,
  0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C,
  0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F,
  0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x8F, 0xFF, 0xDF,
  0xEF, 0xE7, 0xE0, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x07, 0xEF, 0x80, 0xF9, 0xF0, 0x3E,
  0x3E, 0x0F, 0x87, 0xC1, 0xF0, 0xF8, 0x7C, 0x1F, 0x1F, 0x03, 0xE3, 0xC0,
  0x7C, 0xF8, 0x0F, 0xBE, 0x01, 0xF7, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x80,
  0xFE, 0xF8, 0x1F, 0x9F, 0x03, 0xE1, 0xF0, 0x7C, 0x3E, 0x0F, 0x83, 0xE1,
  0xF0, 0x7C, 0x3E, 0x07, 0xC7, 0xC0, 0xF8, 0xF8, 0x0F, 0x9F, 0x01, 0xF3,
  0xE0, 0x1F, 0x7C, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x78, 0x07, 0xC3, 0xC7, 0xF8, 0x7F, 0xCF,
  0x3F, 0xF3, 0xFF, 0xBD, 0xFF, 0xFF, 0xFE, 0xFF, 0x1F, 0xF8, 0xFF, 0xF0,
  0x3F, 0x81, 0xFF, 0xC0, 0xFE, 0x07, 0xFE, 0x01, 0xF0, 0x0F, 0xF8, 0x07,
  0xC0, 0x3F, 0xE0, 0x1F, 0x00, 0xFF, 0x80, 0x7C, 0x03, 0xFE, 0x01, 0xF0,
  0x0F, 0xF8, 0x07, 0xC0, 0x3F, 0xE0, 0x1F, 0x00, 0xFF, 0x80, 0x7C, 0x03,
  0xFE, 0x01, 0xF0, 0x0F, 0xF8, 0x07, 0xC0, 0x3F, 0xE0, 0x1F, 0x00, 0xFF,
  0x80, 0x7C, 0x03, 0xFE, 0x01, 0xF0, 0x0F, 0xF8, 0x07, 0xC0, 0x3F, 0xE0,
  0x1F, 0x00, 0xFF, 0x80, 0x7C, 0x03, 0xFE, 0x01, 0xF0, 0x0F, 0xF8, 0x07,
  0xC0, 0x3F, 0xE0, 0x1F, 0x00, 0xF0, 0x00, 0x7C, 0x3C, 0x7F, 0x8F, 0x3F,
  0xF3, 0xDF, 0xFE, 0xFF, 0x1F, 0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F,
  0xF8, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE,
  0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80,
  0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F,
  0xF8, 0x03, 0xFE, 0x00, 0xF0, 0x01, 0xF8, 0x00, 0x7F, 0xE0, 0x1F, 0xFF,
  0x01, 0xFF, 0xF8, 0x3F, 0x0F, 0xC7, 0xE0, 0x7C, 0x7C, 0x03, 0xE7, 0xC0,
  0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x1E, 0xF8, 0x01, 0xEF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xEF,
  0x80, 0x3E, 0x78, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x07, 0xC3, 0xE0, 0x7C,
  0x3F, 0xBF, 0x81, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x78,
  0x1E, 0x3F, 0xC3, 0xCF, 0xFC, 0x7F, 0xFF, 0xCF, 0xF0, 0xFD, 0xFC, 0x0F,
  0xBF, 0x01, 0xF7, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x1F,
  0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x7D,
  0xFC, 0x1F, 0xBF, 0xFF, 0xE7, 0xFF, 0xFC, 0xFB, 0xFF, 0x1F, 0x3F, 0xC3,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x01, 0xFE, 0x3C, 0x7F, 0xE7, 0x9F, 0xFE, 0xF3,
  0xF1, 0xFE, 0xFC, 0x0F, 0xDF, 0x01, 0xFB, 0xE0, 0x1F, 0xF8, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE,
  0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xBE,
  0x01, 0xF7, 0xC0, 0x7E, 0xFC, 0x1F, 0xCF, 0xEF, 0xF9, 0xFF, 0xEF, 0x1F,
  0xF9, 0xE0, 0xFE, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x7F, 0x8F, 0xFC, 0xFF, 0xEF,
  0xFF, 0x7F, 0x7F, 0x83, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x3F, 0xFD, 0xFF, 0xF3, 0xFF, 0xEF, 0x81, 0x9F, 0x01,
  0x3C, 0x00, 0x78, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xFC, 0x03,
  0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x0F, 0xBF, 0xFF, 0x7F, 0xFC, 0xFF, 0xF8,
  0xFF, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x01,
  0xFF, 0xDF, 0xFE, 0xFF, 0xF1, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x3F, 0xF1,
  0xFF, 0x87, 0xFC, 0x1F, 0xE0, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x3F, 0x7C, 0x1F, 0xDF, 0xFF, 0xF7, 0xFF, 0xBC, 0xFF, 0xCF, 0x1F,
  0xE3, 0xC0, 0xF8, 0x01, 0xF7, 0x80, 0x1F, 0x7C, 0x01, 0xE7, 0xC0, 0x3E,
  0x3C, 0x03, 0xE3, 0xC0, 0x3C, 0x3E, 0x03, 0xC3, 0xE0, 0x7C, 0x1E, 0x07,
  0xC1, 0xF0, 0x78, 0x1F, 0x0F, 0x80, 0xF0, 0xF8, 0x0F, 0x0F, 0x00, 0xF8,
  0xF0, 0x0F, 0x9F, 0x00, 0x79, 0xF0, 0x07, 0x9E, 0x00, 0x7D, 0xE0, 0x03,
  0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x78, 0x07, 0xE0,
  0x1E, 0x7C, 0x07, 0xE0, 0x3E, 0x7C, 0x07, 0xE0, 0x3E, 0x3C, 0x0F, 0xF0,
  0x3C, 0x3C, 0x0F, 0xF0, 0x3C, 0x3E, 0x0F, 0xF0, 0x7C, 0x3E, 0x0E, 0x70,
  0x7C, 0x1E, 0x1E, 0x78, 0x78, 0x1E, 0x1E, 0x78, 0x78, 0x1E, 0x1E, 0x78,
  0x78, 0x1F, 0x1E, 0x78, 0xF8, 0x1F, 0x3C, 0x38, 0xF8, 0x0F, 0x3C, 0x3C,
  0xF0, 0x0F, 0x3C, 0x3C, 0xF0, 0x0F, 0x3C, 0x3C, 0xF0, 0x0F, 0xB8, 0x3D,
  0xF0, 0x07, 0xB8, 0x1D, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x1F,
  0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x03, 0xF0, 0x1F, 0xC0, 0x03, 0xF0, 0x0F,
  0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0xF8, 0x07, 0xEF,
  0x80, 0xF9, 0xF0, 0x3E, 0x1F, 0x07, 0xC3, 0xE1, 0xF0, 0x3E, 0x3C, 0x03,
  0xCF, 0x80, 0x7D, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x0F,
  0xBC, 0x01, 0xE7, 0xC0, 0x7C, 0x78, 0x1F, 0x0F, 0x83, 0xE0, 0xF0, 0xF8,
  0x1F, 0x1F, 0x01, 0xF7, 0xC0, 0x3E, 0xF8, 0x03, 0xE0, 0xF8, 0x01, 0xF7,
  0xC0, 0x1F, 0x7C, 0x01, 0xE7, 0xC0, 0x3E, 0x3C, 0x03, 0xE3, 0xE0, 0x3C,
  0x3E, 0x03, 0xC1, 0xE0, 0x7C, 0x1E, 0x07, 0xC1, 0xF0, 0x78, 0x0F, 0x0F,
  0x80, 0xF0, 0xF8, 0x0F, 0x8F, 0x00, 0xF8, 0xF0, 0x07, 0x9F, 0x00, 0x79,
  0xF0, 0x07, 0xDE, 0x00, 0x3D, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xE0, 0x00, 0x7E, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x00,
  0x07, 0xE0, 0x00, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xF8, 0x01, 0xE0, 0x07,
  0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80,
  0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3C,
  0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x0C, 0x01, 0xF0, 0x1F, 0xC0, 0xFF, 0x03, 0xF0, 0x0F,
  0x80, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x3F,
  0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x00, 0x7C, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x03, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0x3F,
  0x00, 0x3C, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x1E, 0x00,
  0x7C, 0x00, 0xFF, 0x00, 0xFC, 0x07, 0xF0, 0x3F, 0xC1, 0xF0, 0x07, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x01, 0xFC, 0x0F, 0xF0,
  0x3F, 0x80, 0xF8, 0x02, 0x00, 0x00, 0x1E, 0x00, 0x2F, 0xF8, 0x07, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0x00, 0xFF, 0xA0, 0x01, 0x80,
};

const GFXglyph NotoSans_Condensed_Medium47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 6, 35, 12, 3, -34 },
  { 28, 13, 13, 19, 3, -34 },
  { 50, 23, 34, 25, 1, -34 },
  { 148, 18, 39, 23, 2, -36 },
  { 236, 31, 34, 35, 2, -34 },
  { 368, 25, 34, 27, 2, -34 },
  { 475, 5, 13, 10, 3, -34 },
  { 484, 11, 41, 14, 2, -34 },
  { 541, 11, 41, 14, 1, -34 },
  { 598, 18, 18, 21, 2, -36 },
  { 639, 19, 23, 23, 2, -28 },
  { 694, 7, 11, 11, 2, -5 },
  { 704, 11, 5, 14, 1, -15 },
  { 711, 6, 7, 12, 3, -6 },
  { 717, 16, 34, 18, 1, -34 },
  { 785, 19, 34, 22, 2, -34 },
  { 866, 13, 34, 22, 3, -34 },
  { 922, 18, 34, 22, 2, -34 },
  { 999, 18, 34, 22, 2, -34 },
  { 1076, 21, 34, 22, 1, -34 },
  { 1166, 18, 34, 22, 2, -34 },
  { 1243, 19, 34, 22, 2, -34 },
  { 1324, 20, 34, 22, 1, -34 },
  { 1409, 19, 34, 22, 2, -34 },
  { 1490, 18, 34, 22, 2, -34 },
  { 1567, 6, 27, 12, 3, -26 },
  { 1588, 7, 32, 12, 2, -26 },
  { 1616, 19, 22, 23, 2, -28 },
  { 1669, 19, 13, 23, 2, -23 },
  { 1700, 19, 22, 23, 2, -28 },
  { 1753, 16, 35, 17, 0, -34 },
  { 1823, 31, 38, 35, 2, -34 },
  { 1971, 25, 34, 25, 0, -34 },
  { 2078, 19, 34, 25, 4, -34 },
  { 2159, 21, 34, 24, 2, -34 },
  { 2249, 21, 34, 28, 4, -34 },
  { 2339, 15, 34, 21, 4, -34 },
  { 2403, 15, 34, 20, 4, -34 },
  { 2467, 23, 34, 28, 2, -34 },
  { 2565, 21, 34, 29, 4, -34 },
  { 2655, 11, 34, 15, 2, -34 },
  { 2702, 11, 43, 12, -3, -34 },
  { 2762, 20, 34, 24, 4, -34 },
  { 2847, 15, 34, 20, 4, -34 },
  { 2911, 29, 34, 37, 4, -34 },
  { 3035, 23, 34, 30, 4, -34 },
  { 3133, 25, 34, 30, 2, -34 },
  { 3240, 18, 34, 24, 4, -34 },
  { 3317, 25, 42, 30, 2, -34 },
  { 3449, 20, 34, 25, 4, -34 },
  { 3534, 18, 34, 21, 2, -34 },
  { 3611, 19, 34, 21, 1, -34 },
  { 3692, 22, 34, 28, 3, -34 },
  { 3786, 24, 34, 24, 0, -34 },
  { 3888, 37, 34, 37, 0, -34 },
  { 4046, 22, 34, 22, 0, -34 },
  { 4140, 22, 34, 22, 0, -34 },
  { 4234, 18, 34, 20, 1, -34 },
  { 4311, 11, 42, 15, 3, -34 },
  { 4369, 16, 34, 18, 1, -34 },
  { 4437, 11, 42, 15, 1, -34 },
  { 4495, 21, 20, 23, 1, -34 },
  { 4548, 20, 3, 20, 0, 4 },
  { 4556, 10, 8, 13, 2, -36 },
  { 4566, 17, 26, 22, 2, -26 },
  { 4622, 19, 36, 24, 3, -36 },
  { 4708, 16, 26, 19, 2, -26 },
  { 4760, 19, 36, 24, 2, -36 },
  { 4846, 18, 26, 22, 2, -26 },
  { 4905, 14, 36, 14, 1, -36 },
  { 4968, 19, 37, 24, 2, -26 },
  { 5056, 18, 36, 24, 3, -36 },
  { 5137, 5, 35, 11, 3, -35 },
  { 5159, 9, 46, 11, -1, -35 },
  { 5211, 19, 36, 22, 3, -36 },
  { 5297, 5, 36, 11, 3, -36 },
  { 5320, 30, 26, 36, 3, -26 },
  { 5418, 18, 26, 24, 3, -26 },
  { 5477, 20, 26, 24, 2, -26 },
  { 5542, 19, 37, 24, 3, -26 },
  { 5630, 19, 37, 24, 2, -26 },
  { 5718, 13, 26, 16, 3, -26 },
  { 5761, 15, 26, 18, 2, -26 },
  { 5810, 13, 31, 15, 1, -31 },
  { 5861, 18, 25, 24, 3, -25 },
  { 5918, 20, 25, 20, 0, -25 },
  { 5981, 32, 25, 32, 0, -25 },
  { 6081, 19, 25, 20, 1, -25 },
  { 6141, 20, 36, 20, 0, -25 },
  { 6231, 15, 25, 17, 1, -25 },
  { 6278, 14, 42, 17, 1, -34 },
  { 6352, 4, 47, 21, 9, -36 },
  { 6376, 14, 42, 17, 2, -34 },
  { 6450, 19, 7, 23, 2, -20 },
};

const GFXfont NotoSans_Condensed_Medium47pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Medium47pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Medium47pt7bGlyphs,
  0x20, 0x7E, 64
};

#endif // _NOTOSANS_CONDENSED_MEDIUM47PT7B_H_
