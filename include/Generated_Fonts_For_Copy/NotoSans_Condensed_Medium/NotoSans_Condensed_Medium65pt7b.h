#ifndef _NOTOSANS_CONDENSED_MEDIUM65PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUM65PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Medium.ttf
// Size: 65pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Medium65pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x18,
  0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xC0, 0xFD,
  0xF8, 0x1F, 0xBF, 0x03, 0xF7, 0xE0, 0x7E, 0xFC, 0x0F, 0xDF, 0x81, 0xF9,
  0xF0, 0x3F, 0x3E, 0x03, 0xE7, 0xC0, 0x7C, 0xF8, 0x0F, 0x9F, 0x01, 0xF3,
  0xE0, 0x3E, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x1F,
  0x03, 0xE0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x3E,
  0x03, 0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x3E,
  0x07, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3C,
  0x07, 0xC0, 0x00, 0x7C, 0x07, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFF, 0x00, 0x78, 0x0F, 0x80, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0xF8,
  0x0F, 0x80, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0xF8,
  0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0xF0, 0x1F, 0x00, 0x01, 0xF0,
  0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xE0,
  0x3E, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x03, 0xE0,
  0x7C, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x03, 0xC0,
  0x7C, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x07, 0xC0,
  0x78, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x07, 0xC0,
  0xF8, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x07, 0xFF,
  0x00, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0x9F, 0xFF, 0x3F, 0x8F, 0xE3, 0x81, 0xCF, 0xE1, 0xC0, 0x07, 0xE0,
  0xE0, 0x03, 0xF0, 0x70, 0x01, 0xF8, 0x38, 0x00, 0xFC, 0x1C, 0x00, 0x7E,
  0x0E, 0x00, 0x3F, 0x87, 0x00, 0x0F, 0xC3, 0x80, 0x07, 0xF9, 0xC0, 0x03,
  0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0,
  0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF,
  0xE0, 0x00, 0xEF, 0xF8, 0x00, 0x71, 0xFE, 0x00, 0x38, 0x7F, 0x00, 0x1C,
  0x1F, 0x80, 0x0E, 0x0F, 0xC0, 0x07, 0x07, 0xE0, 0x03, 0x83, 0xF0, 0x01,
  0xC1, 0xFC, 0x00, 0xE0, 0xFF, 0x00, 0x70, 0xFF, 0xF0, 0x38, 0xFE, 0xFF,
  0xDF, 0xFF, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x01, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xFE, 0x00, 0x0F,
  0x80, 0x07, 0xFF, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x00,
  0x3F, 0x07, 0xC0, 0x0F, 0x80, 0x07, 0xC0, 0xF8, 0x03, 0xF0, 0x00, 0xF8,
  0x1F, 0x00, 0x7C, 0x00, 0x1F, 0x03, 0xE0, 0x1F, 0x80, 0x03, 0xE0, 0x7E,
  0x03, 0xE0, 0x00, 0x7C, 0x07, 0xC0, 0x7C, 0x00, 0x0F, 0x80, 0xF8, 0x1F,
  0x00, 0x01, 0xF0, 0x1F, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0xE0, 0xFC, 0x00,
  0x07, 0xC0, 0x7C, 0x1F, 0x00, 0x00, 0xF8, 0x0F, 0x83, 0xE0, 0x00, 0x1F,
  0x01, 0xF0, 0xF8, 0x00, 0x03, 0xE0, 0x7E, 0x1F, 0x01, 0x80, 0x7C, 0x0F,
  0x87, 0xE1, 0xFE, 0x0F, 0x81, 0xF0, 0xF8, 0x7F, 0xE1, 0xF0, 0x3E, 0x3F,
  0x1F, 0xFE, 0x1F, 0x07, 0xC7, 0xC7, 0xFF, 0xE3, 0xE1, 0xF0, 0xF8, 0xFC,
  0xFC, 0x7F, 0xFE, 0x3E, 0x1F, 0x0F, 0xC7, 0xFF, 0x87, 0xC7, 0xC0, 0xF8,
  0x7F, 0xF1, 0xF8, 0xF8, 0x1F, 0x07, 0xFC, 0x3E, 0x1F, 0x03, 0xE0, 0x7E,
  0x0F, 0xC3, 0xE0, 0x7C, 0x00, 0x01, 0xF0, 0x7C, 0x0F, 0xC0, 0x00, 0x3E,
  0x0F, 0x81, 0xF8, 0x00, 0x0F, 0x83, 0xF0, 0x3F, 0x00, 0x01, 0xF0, 0x7E,
  0x07, 0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0xFC, 0x00, 0x0F, 0x81, 0xF8, 0x1F,
  0x80, 0x01, 0xF0, 0x1F, 0x03, 0xF0, 0x00, 0x7C, 0x03, 0xE0, 0x7E, 0x00,
  0x0F, 0x80, 0x7C, 0x0F, 0x80, 0x03, 0xF0, 0x0F, 0x81, 0xF0, 0x00, 0x7C,
  0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x80, 0x3E, 0x07, 0xC0, 0x03, 0xE0, 0x03,
  0xE1, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xFF,
  0xC0, 0x03, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x0F, 0xFC, 0x00,
  0x1F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xE3, 0xFC, 0x00,
  0x03, 0xF8, 0x3F, 0x80, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x7E,
  0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x3F, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x03,
  0xF8, 0x3F, 0x80, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x07, 0xF1, 0xFC, 0x00,
  0x00, 0x7E, 0x7F, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x1F, 0x83,
  0xFF, 0xFC, 0x07, 0xF0, 0x7F, 0xBF, 0x80, 0xFE, 0x1F, 0xE3, 0xF8, 0x1F,
  0xC7, 0xF8, 0x7F, 0x83, 0xF0, 0xFE, 0x07, 0xF8, 0x7E, 0x1F, 0xC0, 0x7F,
  0x1F, 0xC7, 0xF0, 0x07, 0xF3, 0xF0, 0xFE, 0x00, 0xFF, 0xFE, 0x1F, 0xC0,
  0x0F, 0xFF, 0xC3, 0xF8, 0x00, 0xFF, 0xF0, 0x7F, 0x00, 0x0F, 0xFE, 0x0F,
  0xE0, 0x01, 0xFF, 0x81, 0xFC, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x03, 0xFC,
  0x03, 0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0x80, 0x3F, 0xFC, 0x07, 0xFC, 0x3F,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x3F, 0x80, 0xFF,
  0xFF, 0xC7, 0xF8, 0x0F, 0xFF, 0xE0, 0x7F, 0x80, 0xFF, 0xF0, 0x07, 0xF8,
  0x00, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xBF, 0x7E, 0xFD,
  0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F,
  0x80, 0x7F, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80,
  0x7F, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7F, 0x00, 0xFE,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7E, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8,
  0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x0F,
  0xE0, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x3F, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x01, 0x00,
  0xF8, 0x02, 0xF0, 0x7C, 0x0E, 0x7F, 0x3E, 0x7F, 0x3F, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xF7, 0xE0, 0x01, 0xF9, 0xF0,
  0x01, 0xF8, 0xFC, 0x01, 0xFC, 0x3F, 0x00, 0xFC, 0x1F, 0xC0, 0xFE, 0x07,
  0xE0, 0x1E, 0x03, 0xC0, 0x03, 0x00, 0xC0, 0x00, 0x80, 0x40, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xC7, 0xF1, 0xFC, 0x7E, 0x1F, 0x8F,
  0xE3, 0xF8, 0xFC, 0x3F, 0x0F, 0xC7, 0xE1, 0xF8, 0x7C, 0x1F, 0x07, 0xC3,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x3C, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFF, 0x07, 0xF0,
  0x7F, 0x01, 0xFC, 0x3F, 0x00, 0x7E, 0x3F, 0x80, 0x3F, 0x9F, 0xC0, 0x1F,
  0xCF, 0xC0, 0x07, 0xE7, 0xE0, 0x03, 0xF7, 0xF0, 0x01, 0xFF, 0xF8, 0x00,
  0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00,
  0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0,
  0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF,
  0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF,
  0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F,
  0xFF, 0x80, 0x0F, 0xEF, 0xC0, 0x07, 0xE7, 0xE0, 0x03, 0xF3, 0xF8, 0x03,
  0xF9, 0xFC, 0x01, 0xFC, 0x7F, 0x01, 0xFC, 0x3F, 0x80, 0xFE, 0x0F, 0xF1,
  0xFE, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x1F,
  0xFF, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x80, 0x1F,
  0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFE, 0x3F,
  0xFF, 0x3F, 0xDF, 0xBF, 0xCF, 0xFF, 0xC7, 0xEF, 0xC3, 0xF3, 0xC1, 0xF8,
  0xC0, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x83, 0xF0, 0x0F, 0xF0, 0xF8, 0x01, 0xFC,
  0x18, 0x00, 0x3F, 0x84, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0xC3, 0xE0, 0x0F, 0xF0, 0xF0, 0x01, 0xFE, 0x10, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0,
  0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF,
  0x80, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xFA, 0x00, 0x01, 0xFE, 0xE0, 0x00, 0xFF, 0xBF, 0x00, 0x7F, 0xCF,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x03, 0xEF, 0xC0, 0x00,
  0x3E, 0x7E, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0xF9,
  0xFC, 0x00, 0x0F, 0x8F, 0xE0, 0x00, 0xFC, 0x7F, 0x00, 0x07, 0xC3, 0xF8,
  0x00, 0x7E, 0x1F, 0xC0, 0x03, 0xE0, 0xFE, 0x00, 0x3F, 0x07, 0xF0, 0x01,
  0xF0, 0x3F, 0x80, 0x1F, 0x81, 0xFC, 0x00, 0xF8, 0x0F, 0xE0, 0x0F, 0xC0,
  0x7F, 0x00, 0x7C, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x7E, 0x00, 0xFE,
  0x03, 0xE0, 0x07, 0xF0, 0x3F, 0x00, 0x3F, 0x81, 0xF0, 0x01, 0xFC, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xC1, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x3F, 0x80, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x20, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFA, 0x00, 0x03, 0xFD,
  0xC0, 0x03, 0xFC, 0xFC, 0x07, 0xFE, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x07,
  0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x81, 0x80, 0x0F,
  0xC3, 0xFE, 0x03, 0xF1, 0xFF, 0xE0, 0xFC, 0xFF, 0xFC, 0x3F, 0x7F, 0xFF,
  0x8F, 0xFF, 0xFF, 0xE3, 0xFF, 0x03, 0xFC, 0xFF, 0x80, 0x7F, 0x3F, 0xC0,
  0x0F, 0xEF, 0xE0, 0x03, 0xFB, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x1F, 0xBF,
  0x00, 0x07, 0xEF, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F,
  0xFF, 0x80, 0x07, 0xEF, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0x7E, 0x7E, 0x00,
  0x1F, 0x9F, 0xC0, 0x0F, 0xE7, 0xF0, 0x03, 0xF8, 0xFE, 0x01, 0xFC, 0x3F,
  0xC0, 0x7F, 0x07, 0xF8, 0x7F, 0x81, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0,
  0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x38,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x3F, 0xE3, 0xFE, 0x0F, 0xF0, 0x1F,
  0xE1, 0xFC, 0x01, 0xFC, 0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF0, 0xFC,
  0x00, 0x7F, 0x1F, 0x80, 0x0F, 0xE3, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x3F,
  0x0F, 0xC0, 0x07, 0xE1, 0xFC, 0x01, 0xFC, 0x1F, 0xC0, 0x7F, 0x03, 0xFC,
  0x1F, 0xE0, 0x3F, 0xC7, 0xF8, 0x03, 0xFD, 0xFE, 0x00, 0x3F, 0xFF, 0x80,
  0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xCF, 0xF8, 0x0F, 0xE0, 0x7F, 0x83,
  0xF8, 0x07, 0xF8, 0x7F, 0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xF3, 0xF0, 0x00,
  0xFE, 0x7E, 0x00, 0x0F, 0xDF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xDF, 0x80, 0x03,
  0xF3, 0xF8, 0x00, 0xFE, 0x7F, 0x80, 0x1F, 0xC7, 0xF8, 0x0F, 0xF0, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x83, 0xFC, 0x0F, 0xE0, 0xFE, 0x01, 0xFC, 0x7F, 0x00, 0x3F,
  0x1F, 0xC0, 0x0F, 0xE7, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0x7E, 0x7E, 0x00,
  0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFE,
  0x00, 0x0F, 0xFF, 0x80, 0x03, 0xF7, 0xE0, 0x01, 0xFD, 0xF8, 0x00, 0x7F,
  0x7F, 0x00, 0x1F, 0xDF, 0xC0, 0x0F, 0xF7, 0xF8, 0x03, 0xFC, 0xFE, 0x01,
  0xFF, 0x3F, 0xE3, 0xFF, 0xC7, 0xFF, 0xFB, 0xF1, 0xFF, 0xFE, 0xFC, 0x3F,
  0xFF, 0x3F, 0x03, 0xFF, 0x8F, 0xC0, 0x7F, 0x83, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x04, 0x03, 0xFE, 0x01,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0,
  0x01, 0xFF, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7E, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x1C, 0x1F, 0x8F, 0xF3, 0xFC, 0xFF,
  0x3F, 0xCF, 0xF3, 0xFC, 0x7E, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC7, 0xF1, 0xFC, 0x7E, 0x3F,
  0x8F, 0xE3, 0xF8, 0xFC, 0x3F, 0x0F, 0xC7, 0xE1, 0xF8, 0x7C, 0x1F, 0x0F,
  0xC3, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x01,
  0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00,
  0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F,
  0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xFC, 0x1F, 0xFF, 0xF1, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xE0, 0x1F, 0xE4, 0x00, 0x7F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0x07, 0xC0, 0x0F, 0xFC, 0x07, 0xC1, 0xF0,
  0x0F, 0xFF, 0xC0, 0xF8, 0xF8, 0x07, 0xFF, 0xF0, 0x3E, 0x3E, 0x03, 0xFF,
  0xFC, 0x0F, 0x8F, 0x80, 0xFC, 0x1F, 0x03, 0xF7, 0xC0, 0x7E, 0x07, 0xC0,
  0x7D, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x7C, 0x0F, 0xC0, 0x7C, 0x07, 0xDF,
  0x03, 0xE0, 0x1F, 0x01, 0xFF, 0xC0, 0xF8, 0x07, 0xC0, 0x7F, 0xE0, 0x7E,
  0x01, 0xF0, 0x1F, 0xF8, 0x1F, 0x80, 0x7C, 0x07, 0xFE, 0x07, 0xC0, 0x1F,
  0x01, 0xFF, 0x81, 0xF0, 0x07, 0xC0, 0x7F, 0xE0, 0x7C, 0x03, 0xF0, 0x1F,
  0xF8, 0x1F, 0x00, 0xFC, 0x07, 0xFE, 0x07, 0xC0, 0x3F, 0x01, 0xFF, 0x81,
  0xF8, 0x0F, 0xC0, 0xFB, 0xE0, 0x7E, 0x03, 0xF0, 0x3E, 0xF8, 0x0F, 0x81,
  0xFC, 0x0F, 0xBF, 0x03, 0xE0, 0x7F, 0x07, 0xC7, 0xC0, 0xFC, 0x3D, 0xE1,
  0xF1, 0xF0, 0x1F, 0xFF, 0x7F, 0xF8, 0x7C, 0x07, 0xFF, 0x9F, 0xFE, 0x1F,
  0x80, 0xFF, 0xC3, 0xFF, 0x07, 0xE0, 0x1F, 0xE0, 0x7F, 0x80, 0xF8, 0x01,
  0xE0, 0x07, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x40, 0x00, 0x3F,
  0xC0, 0x00, 0x70, 0x00, 0x07, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x0F, 0xCF, 0xC0,
  0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x7F, 0x3F,
  0x80, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x01, 0xF8,
  0x7F, 0x00, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0xFC, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x01, 0xFC, 0x07, 0xE0, 0x00,
  0x7E, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x0F, 0xE0, 0x1F, 0xC0,
  0x03, 0xF8, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFC, 0x03, 0xF0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x0F, 0xE0, 0x7F,
  0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x1F, 0xC3,
  0xF8, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x3F,
  0x9F, 0xC0, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xF0, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xF9, 0xFC, 0x07, 0xFF, 0x3F, 0x80, 0x1F, 0xF7, 0xF0, 0x01,
  0xFE, 0xFE, 0x00, 0x1F, 0xDF, 0xC0, 0x03, 0xFB, 0xF8, 0x00, 0x7F, 0x7F,
  0x00, 0x0F, 0xEF, 0xE0, 0x01, 0xFD, 0xFC, 0x00, 0x3F, 0xBF, 0x80, 0x07,
  0xF7, 0xF0, 0x00, 0xFE, 0xFE, 0x00, 0x3F, 0x9F, 0xC0, 0x0F, 0xF3, 0xF8,
  0x03, 0xFC, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x9F, 0xC0,
  0x0F, 0xF3, 0xF8, 0x00, 0xFF, 0x7F, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00,
  0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xF7, 0xF0, 0x03,
  0xFE, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x07, 0xFE, 0x01, 0xE0, 0xFF,
  0x80, 0x04, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x60, 0x7F, 0xF0,
  0x3E, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1E, 0x00, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0x03, 0xF8, 0x3F, 0xFE, 0x0F, 0xE0, 0x0F, 0xFC,
  0x3F, 0x80, 0x0F, 0xF8, 0xFE, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x3F, 0xCF,
  0xE0, 0x00, 0x7F, 0x3F, 0x80, 0x01, 0xFE, 0xFE, 0x00, 0x03, 0xFB, 0xF8,
  0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0xFE, 0xFE, 0x00,
  0x03, 0xFB, 0xF8, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x7F, 0x3F, 0x80, 0x03,
  0xFC, 0xFE, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0xFF, 0x8F, 0xE0, 0x07, 0xFC,
  0x3F, 0x80, 0x7F, 0xE0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFD, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0x00, 0x7C, 0x07, 0xFC, 0x00,
  0x0C, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x7E, 0x00, 0x3F, 0xFF, 0x7F, 0x00, 0x00,
  0x3F, 0x7F, 0x00, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x3F, 0x7F, 0x00, 0x00,
  0x3F, 0x7F, 0x00, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x3F, 0x3F, 0x80, 0x00,
  0x3F, 0x3F, 0x80, 0x00, 0x3F, 0x3F, 0xC0, 0x00, 0x3F, 0x1F, 0xE0, 0x00,
  0x3F, 0x1F, 0xE0, 0x00, 0x3F, 0x0F, 0xF0, 0x00, 0x3F, 0x0F, 0xFC, 0x00,
  0x3F, 0x07, 0xFF, 0x81, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F,
  0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFE,
  0x0F, 0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x3F, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFE, 0x83, 0xFE, 0xFF, 0xFC,
  0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0x3F, 0x00, 0xFE, 0x00,
  0x0F, 0xF7, 0xF0, 0x00, 0x7F, 0x3F, 0x80, 0x07, 0xF1, 0xFC, 0x00, 0x3F,
  0x8F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x3F, 0x83, 0xF8, 0x01, 0xFC, 0x1F,
  0xC0, 0x1F, 0xC0, 0xFE, 0x01, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x80,
  0xFE, 0x01, 0xFC, 0x0F, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0x07, 0xF0,
  0x03, 0xF8, 0x7F, 0x80, 0x1F, 0xC3, 0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x07,
  0xF1, 0xFC, 0x00, 0x3F, 0x9F, 0xC0, 0x01, 0xFD, 0xFC, 0x00, 0x0F, 0xEF,
  0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFE, 0xFE, 0x00, 0x3F, 0xE7, 0xF0, 0x01,
  0xFE, 0x1F, 0xC0, 0x0F, 0xE0, 0xFE, 0x00, 0x7F, 0x03, 0xF8, 0x03, 0xF8,
  0x1F, 0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x0F,
  0xE0, 0x3F, 0x80, 0x7F, 0x81, 0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x0F, 0xF0,
  0x7F, 0x00, 0x3F, 0x83, 0xF8, 0x01, 0xFE, 0x1F, 0xC0, 0x07, 0xF0, 0xFE,
  0x00, 0x3F, 0xC7, 0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x07, 0xF9, 0xFC, 0x00,
  0x1F, 0xCF, 0xE0, 0x00, 0x7F, 0x7F, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xFE, 0xF8, 0x00, 0x03, 0xEF, 0xFF, 0x7E, 0x00, 0x01, 0xF7,
  0xFF, 0xBF, 0x00, 0x01, 0xFB, 0xFF, 0xCF, 0x80, 0x00, 0xFD, 0xFF, 0xE7,
  0xE0, 0x00, 0x7C, 0xFF, 0xF3, 0xF0, 0x00, 0x7E, 0x7F, 0xF9, 0xF8, 0x00,
  0x3F, 0x3F, 0xFC, 0x7E, 0x00, 0x1F, 0x1F, 0xFE, 0x3F, 0x00, 0x1F, 0x8F,
  0xFF, 0x1F, 0x80, 0x0F, 0xC7, 0xFF, 0x87, 0xC0, 0x07, 0xC3, 0xFF, 0xC3,
  0xF0, 0x07, 0xE1, 0xFF, 0xE1, 0xF8, 0x03, 0xF0, 0xFF, 0xF0, 0x7C, 0x01,
  0xF0, 0x7F, 0xF8, 0x3F, 0x00, 0xF8, 0x3F, 0xFC, 0x1F, 0x80, 0xFC, 0x1F,
  0xFE, 0x0F, 0xC0, 0x7E, 0x0F, 0xFF, 0x03, 0xF0, 0x3E, 0x07, 0xFF, 0x81,
  0xF8, 0x3F, 0x03, 0xFF, 0xC0, 0xFC, 0x1F, 0x81, 0xFF, 0xE0, 0x3E, 0x0F,
  0x80, 0xFF, 0xF0, 0x1F, 0x8F, 0xC0, 0x7F, 0xF8, 0x0F, 0xC7, 0xE0, 0x3F,
  0xFC, 0x03, 0xE3, 0xE0, 0x1F, 0xFE, 0x01, 0xFB, 0xF0, 0x0F, 0xFF, 0x00,
  0xFD, 0xF8, 0x07, 0xFF, 0x80, 0x7E, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFC,
  0x01, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x7F,
  0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xFE, 0x00,
  0x7F, 0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xE0,
  0x03, 0xFF, 0xC0, 0x07, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xF0, 0x00, 0xFC,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x3F, 0xFD, 0xF8, 0x00, 0x3F, 0xFD, 0xFC, 0x00, 0x3F,
  0xFC, 0xFC, 0x00, 0x3F, 0xFC, 0xFE, 0x00, 0x3F, 0xFC, 0x7E, 0x00, 0x3F,
  0xFC, 0x7F, 0x00, 0x3F, 0xFC, 0x3F, 0x00, 0x3F, 0xFC, 0x3F, 0x80, 0x3F,
  0xFC, 0x1F, 0x80, 0x3F, 0xFC, 0x1F, 0xC0, 0x3F, 0xFC, 0x1F, 0xC0, 0x3F,
  0xFC, 0x0F, 0xE0, 0x3F, 0xFC, 0x0F, 0xE0, 0x3F, 0xFC, 0x07, 0xF0, 0x3F,
  0xFC, 0x07, 0xF0, 0x3F, 0xFC, 0x03, 0xF8, 0x3F, 0xFC, 0x03, 0xF8, 0x3F,
  0xFC, 0x01, 0xFC, 0x3F, 0xFC, 0x01, 0xFC, 0x3F, 0xFC, 0x00, 0xFE, 0x3F,
  0xFC, 0x00, 0xFE, 0x3F, 0xFC, 0x00, 0x7F, 0x3F, 0xFC, 0x00, 0x7F, 0x3F,
  0xFC, 0x00, 0x3F, 0xBF, 0xFC, 0x00, 0x3F, 0xBF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0xFF, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x03,
  0xF8, 0xFF, 0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x07, 0xF3, 0xF8, 0x00,
  0x00, 0xFE, 0x7F, 0x00, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x03, 0xF9, 0xFC,
  0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x00, 0xFD,
  0xFC, 0x00, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0x7F, 0x00, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x01, 0xFC, 0xFE,
  0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x00, 0xFE,
  0x7F, 0x00, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x00,
  0xFE, 0x1F, 0xC0, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x07, 0xF8, 0x3F, 0x80,
  0x00, 0xFE, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x0F, 0xF0, 0x0F,
  0xF8, 0x03, 0xFE, 0x00, 0xFF, 0xC3, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xE7, 0xF0, 0x7F, 0xFB, 0xF8, 0x07, 0xFD, 0xFC, 0x00, 0xFE, 0xFE,
  0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF,
  0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xE0, 0x0F, 0xF7, 0xF0, 0x0F, 0xFB, 0xF8, 0x3F, 0xF9, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF0, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0x80, 0x0F, 0xF0, 0x1F, 0xE0, 0x00,
  0xFF, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x01, 0xFE, 0x1F, 0xC0,
  0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x03, 0xF8, 0xFF, 0x00, 0x00, 0x7F, 0x1F,
  0xC0, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x1F,
  0xCF, 0xE0, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00,
  0x0F, 0xEF, 0xE0, 0x00, 0x00, 0xFD, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x0F,
  0xE7, 0xE0, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00,
  0x07, 0xF3, 0xF8, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x1F, 0xCF, 0xE0,
  0x00, 0x07, 0xF8, 0xFE, 0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x1F, 0xC3,
  0xFC, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x7F, 0x80, 0x0F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0xC3,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x17, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x0F, 0xE0, 0xFF, 0xF0, 0xFE, 0x00, 0xFF,
  0x0F, 0xE0, 0x07, 0xF8, 0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF8, 0xFE,
  0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xF8, 0xFE, 0x00, 0x1F, 0x8F, 0xE0, 0x01,
  0xF8, 0xFE, 0x00, 0x1F, 0x8F, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x8F,
  0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x7F, 0x8F, 0xE0, 0x07, 0xF0, 0xFE, 0x01,
  0xFF, 0x0F, 0xE0, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xE0,
  0xFE, 0x00, 0xFE, 0x07, 0xE0, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x01, 0xFC, 0x0F, 0xE0, 0x1F, 0xC0, 0xFE,
  0x01, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0xFF, 0x0F, 0xE0, 0x07,
  0xF0, 0xFE, 0x00, 0x7F, 0x8F, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0xCF,
  0xE0, 0x01, 0xFC, 0xFE, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0xFE, 0xFE, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x7F,
  0xC0, 0x7C, 0x7F, 0x80, 0x0C, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x0F,
  0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00,
  0x1F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0xFE, 0xF0, 0x01, 0xFE, 0xFF, 0x0F, 0xFC, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0x3F, 0x80, 0x03, 0xF9, 0xFE,
  0x00, 0x3F, 0xCF, 0xF8, 0x03, 0xFC, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0xBF, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x0F,
  0xE7, 0xF0, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03,
  0xF8, 0x7F, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0xFC, 0x0F, 0xC0, 0x00,
  0x7E, 0x07, 0xF0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0xFC, 0x00,
  0x1F, 0x80, 0x7E, 0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x0F, 0xE0, 0x1F, 0xC0,
  0x07, 0xF0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x7F, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x03, 0xF0, 0x1F, 0x80, 0x01,
  0xF8, 0x0F, 0xC0, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x7F, 0x07, 0xF0, 0x00,
  0x1F, 0x83, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xE1, 0xFC, 0x00,
  0x03, 0xF8, 0xFC, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x7E, 0x3F, 0x00,
  0x00, 0x3F, 0x3F, 0x80, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xEF, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0xBF, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x7F, 0xC0,
  0x00, 0xFC, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0x8F, 0xC0, 0x01, 0xFF,
  0x00, 0x07, 0xF1, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x07,
  0xFE, 0x00, 0x1F, 0x87, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xF0, 0x7E, 0x00,
  0x3E, 0xF8, 0x00, 0xFE, 0x0F, 0xC0, 0x07, 0xDF, 0x00, 0x1F, 0xC1, 0xFC,
  0x00, 0xFB, 0xF0, 0x03, 0xF0, 0x3F, 0x80, 0x3F, 0x7E, 0x00, 0x7E, 0x07,
  0xF0, 0x07, 0xE7, 0xC0, 0x1F, 0xC0, 0x7E, 0x00, 0xFC, 0xF8, 0x03, 0xF8,
  0x0F, 0xC0, 0x1F, 0x1F, 0x80, 0x7F, 0x01, 0xFC, 0x03, 0xE3, 0xF0, 0x0F,
  0xC0, 0x3F, 0x80, 0xFC, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x1F, 0x87, 0xC0,
  0x7F, 0x00, 0x7E, 0x03, 0xF0, 0xF8, 0x0F, 0xE0, 0x0F, 0xC0, 0x7C, 0x1F,
  0x81, 0xF8, 0x01, 0xFC, 0x1F, 0x83, 0xF0, 0x3F, 0x00, 0x3F, 0x83, 0xF0,
  0x7E, 0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x07, 0xC1, 0xFC, 0x00, 0x7E, 0x0F,
  0x80, 0xFC, 0x3F, 0x80, 0x0F, 0xC3, 0xF0, 0x1F, 0x87, 0xE0, 0x01, 0xFC,
  0x7E, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x3E, 0x3F, 0x80, 0x03,
  0xF1, 0xF8, 0x07, 0xC7, 0xF0, 0x00, 0x7E, 0x3E, 0x00, 0xFC, 0xFC, 0x00,
  0x0F, 0xC7, 0xC0, 0x1F, 0x9F, 0x80, 0x01, 0xFD, 0xF8, 0x01, 0xF3, 0xF0,
  0x00, 0x1F, 0xBF, 0x00, 0x3E, 0x7E, 0x00, 0x03, 0xF7, 0xC0, 0x07, 0xDF,
  0xC0, 0x00, 0x7E, 0xF8, 0x00, 0xFB, 0xF0, 0x00, 0x0F, 0xDF, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00,
  0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x01, 0xFC, 0x7F, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xE0,
  0xFE, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x7F, 0x01, 0xFC, 0x01, 0xFC, 0x01,
  0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xE0, 0x03, 0xF0, 0x1F, 0xC0, 0x07,
  0xF0, 0x3F, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x1F,
  0xC7, 0xF0, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x3F,
  0x7F, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x07, 0xEF, 0xE0, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x3F, 0x1F, 0x80,
  0x00, 0xFE, 0x3F, 0x80, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xF0, 0x7F, 0x00,
  0x0F, 0xE0, 0x7E, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x7F, 0x01, 0xFC, 0x01,
  0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x0F, 0xE0, 0x03, 0xF8, 0x1F,
  0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xE1, 0xF8,
  0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x1F, 0xDF, 0xE0, 0x00, 0x3F, 0xC0, 0xFE,
  0x00, 0x01, 0xFD, 0xFC, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x3F, 0x8F, 0xE0,
  0x00, 0xFE, 0x3F, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x1F, 0xC1, 0xFC, 0x00,
  0x7E, 0x07, 0xF0, 0x03, 0xF8, 0x0F, 0xC0, 0x0F, 0xE0, 0x3F, 0x80, 0x3F,
  0x00, 0x7E, 0x01, 0xFC, 0x01, 0xFC, 0x07, 0xE0, 0x07, 0xF0, 0x3F, 0x80,
  0x0F, 0xC0, 0xFE, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x7E, 0x1F, 0xC0, 0x01,
  0xFC, 0x7E, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x3F,
  0xBF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7C,
  0xF8, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x3E, 0x1F,
  0x80, 0x01, 0xF8, 0x7E, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00,
  0xFC, 0x00, 0xFC, 0x03, 0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x07, 0xE0, 0x7E,
  0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x7E, 0x7E, 0x00,
  0x01, 0xF9, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x80,
  0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x1F, 0x00, 0x01, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x0F, 0xF7, 0xFE,
  0x07, 0x00, 0xFF, 0x04, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x7F, 0xFF, 0x03, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0x3F, 0xF0, 0x3F, 0x3F, 0x80, 0x3F, 0x7F, 0x00, 0x3F,
  0x7F, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x7F, 0x00, 0xFF,
  0x7F, 0x01, 0xFF, 0x7F, 0xEF, 0xDF, 0x3F, 0xFF, 0xDF, 0x1F, 0xFF, 0x9F,
  0x1F, 0xFF, 0x1F, 0x07, 0xFC, 0x0F, 0x00, 0xE0, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x0F, 0x00, 0x3F, 0x87, 0xFC, 0x07,
  0xF3, 0xFF, 0xE0, 0xFE, 0xFF, 0xFE, 0x1F, 0xDF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xFC, 0x7F, 0xF0, 0x7F, 0xCF, 0xF8, 0x03, 0xF9, 0xFF, 0x00, 0x7F, 0x3F,
  0xC0, 0x07, 0xF7, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xDF, 0xC0, 0x01,
  0xFB, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F,
  0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xBF, 0x80, 0x03, 0xF7, 0xF8, 0x00, 0xFE,
  0xFF, 0x00, 0x1F, 0xDF, 0xF0, 0x07, 0xF3, 0xFE, 0x00, 0xFE, 0x7F, 0xF0,
  0x3F, 0xCF, 0xFF, 0xFF, 0xF1, 0xFB, 0xFF, 0xFC, 0x3F, 0x3F, 0xFF, 0x87,
  0xE3, 0xFF, 0xE0, 0xFC, 0x1F, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1F,
  0x00, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xC3, 0xFE, 0x07, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x23, 0xFE, 0x03, 0x87,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x7F,
  0xF8, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x1F,
  0x03, 0xF0, 0x3F, 0xF0, 0xFC, 0x1F, 0xFE, 0x3F, 0x0F, 0xFF, 0xCF, 0xC7,
  0xFF, 0xFB, 0xF1, 0xFF, 0xFF, 0xFC, 0xFF, 0x03, 0xFF, 0x3F, 0x80, 0x7F,
  0xDF, 0xC0, 0x0F, 0xF7, 0xF0, 0x01, 0xFD, 0xF8, 0x00, 0x7F, 0xFE, 0x00,
  0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00,
  0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFD, 0xF8,
  0x00, 0x7F, 0x7F, 0x00, 0x1F, 0xDF, 0xC0, 0x0F, 0xF3, 0xF8, 0x07, 0xFC,
  0xFF, 0x03, 0xFF, 0x1F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFB, 0xF0, 0xFF, 0xFC,
  0x7C, 0x1F, 0xFE, 0x1F, 0x03, 0xFF, 0x07, 0xC0, 0x0E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xC0, 0xFF, 0xBF, 0xE0, 0xFF, 0x03, 0xF8, 0x7F, 0x00, 0xFC,
  0x7F, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0x9F, 0x80, 0x0F, 0xCF, 0xC0, 0x03,
  0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x18, 0x7F, 0x80, 0x3C,
  0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x07, 0xFF,
  0x01, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xF0,
  0x20, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0xF8, 0xFF,
  0xFF, 0x8F, 0xFF, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xFF, 0xC1, 0xF0, 0x7F, 0xF8, 0x7C, 0x3F, 0xFF,
  0x3F, 0x1F, 0xFF, 0xEF, 0xC7, 0xFF, 0xFF, 0xF3, 0xFC, 0x0F, 0xFC, 0xFE,
  0x01, 0xFF, 0x7F, 0x00, 0x3F, 0xDF, 0xC0, 0x07, 0xF7, 0xE0, 0x01, 0xFF,
  0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00,
  0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF,
  0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07,
  0xF7, 0xE0, 0x01, 0xFD, 0xFC, 0x00, 0x7F, 0x7F, 0x00, 0x3F, 0xCF, 0xE0,
  0x1F, 0xF3, 0xFC, 0x0F, 0xFC, 0x7F, 0xFF, 0xFF, 0x1F, 0xFF, 0xEF, 0xC3,
  0xFF, 0xF3, 0xF0, 0x7F, 0xF8, 0xFC, 0x0F, 0xFC, 0x3F, 0x00, 0x30, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x30,
  0x00, 0x7F, 0x8F, 0x80, 0x7F, 0xC3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xE0,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x3C, 0x03, 0xF8, 0x7F, 0xE1,
  0xFC, 0xFF, 0xF8, 0xFE, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xBF, 0x7F, 0xFF,
  0xDF, 0xFC, 0x1F, 0xEF, 0xF8, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00,
  0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80,
  0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8,
  0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF,
  0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF,
  0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F,
  0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00,
  0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0x80, 0x7D,
  0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0x1F, 0xC0, 0xFE, 0x07, 0xF0,
  0x3F, 0x81, 0xFC, 0x07, 0xC0, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0,
  0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F,
  0x03, 0xFC, 0x3F, 0xBF, 0xFD, 0xFF, 0xEF, 0xFE, 0x7F, 0xE3, 0xFE, 0x03,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x03, 0xFB, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0xFE, 0x3F, 0x80, 0x3F, 0x8F,
  0xE0, 0x1F, 0xC3, 0xF8, 0x0F, 0xE0, 0xFE, 0x03, 0xF0, 0x3F, 0x81, 0xFC,
  0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x7F, 0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0x8F,
  0xE0, 0x0F, 0xE7, 0xF0, 0x03, 0xF9, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x3F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80,
  0x3F, 0xF7, 0xF0, 0x0F, 0xF9, 0xFC, 0x03, 0xFC, 0x3F, 0x80, 0xFE, 0x0F,
  0xE0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x0F, 0xE0, 0xFE,
  0x01, 0xF8, 0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x0F, 0xE3, 0xF8, 0x03, 0xF8,
  0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xCF, 0xE0, 0x03, 0xFB, 0xF8, 0x00,
  0xFE, 0xFE, 0x00, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x3F, 0x0F, 0xFC, 0x03, 0xFF, 0x0F, 0xC7,
  0xFF, 0x83, 0xFF, 0xE3, 0xF3, 0xFF, 0xF1, 0xFF, 0xFC, 0xFD, 0xFF, 0xFE,
  0x7F, 0xFF, 0x3F, 0x7F, 0xFF, 0xBF, 0xFF, 0xEF, 0xFC, 0x0F, 0xFF, 0x07,
  0xFB, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xFF,
  0xC0, 0x0F, 0xF0, 0x07, 0xFF, 0xF0, 0x03, 0xF8, 0x01, 0xFF, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xFF, 0x80, 0x0F, 0xE0,
  0x03, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFC, 0x00, 0x3F,
  0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xC0, 0x03, 0xFF, 0xE0,
  0x03, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xC0, 0x03, 0xFF, 0xE0, 0x03, 0xF0, 0x00,
  0xFF, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xFF,
  0x80, 0x0F, 0xC0, 0x03, 0xFF, 0xE0, 0x03, 0xF0, 0x00, 0xFF, 0xF8, 0x00,
  0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xC0,
  0x03, 0xFF, 0xE0, 0x03, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0xFC, 0x00, 0x3F,
  0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xC0, 0x03, 0xFF, 0xE0,
  0x03, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0,
  0x7E, 0x0F, 0xFC, 0x3F, 0x1F, 0xFF, 0x1F, 0x9F, 0xFF, 0xCF, 0xDF, 0xFF,
  0xF7, 0xEF, 0xFF, 0xFB, 0xFF, 0x83, 0xFD, 0xFF, 0x00, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0,
  0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE,
  0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF,
  0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F,
  0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03,
  0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00,
  0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0,
  0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x0F, 0xF0,
  0x3F, 0xC1, 0xFC, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF9,
  0xF8, 0x00, 0x7F, 0x7F, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0xFD, 0xFC, 0x00,
  0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF,
  0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE,
  0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xF9, 0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x0F,
  0xE3, 0xF0, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x3F, 0xC0, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xE0,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x1F, 0x83,
  0xFE, 0x03, 0xF1, 0xFF, 0xF0, 0x7E, 0x7F, 0xFF, 0x0F, 0xCF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFE, 0x3F, 0xF8, 0x1F, 0xE7, 0xFC, 0x01, 0xFC, 0xFF, 0x80,
  0x3F, 0x9F, 0xE0, 0x03, 0xFB, 0xFC, 0x00, 0x7F, 0x7F, 0x00, 0x07, 0xEF,
  0xE0, 0x00, 0xFD, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00,
  0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03,
  0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xDF, 0xE0, 0x03, 0xFB, 0xFC,
  0x00, 0x7F, 0x7F, 0x80, 0x0F, 0xEF, 0xF8, 0x03, 0xF9, 0xFF, 0x80, 0x7F,
  0x3F, 0xF8, 0x3F, 0xE7, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x1F, 0xDF,
  0xFF, 0xC3, 0xF9, 0xFF, 0xF0, 0x7F, 0x0F, 0xF8, 0x0F, 0xE0, 0x38, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFF, 0xC1, 0xF0, 0x7F, 0xF8,
  0x7C, 0x3F, 0xFF, 0x3F, 0x1F, 0xFF, 0xEF, 0xC7, 0xFF, 0xFF, 0xF3, 0xFC,
  0x0F, 0xFC, 0xFE, 0x01, 0xFF, 0x7F, 0x00, 0x3F, 0xDF, 0xC0, 0x07, 0xF7,
  0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x03,
  0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF,
  0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F,
  0xFF, 0x80, 0x07, 0xF7, 0xE0, 0x01, 0xFD, 0xFC, 0x00, 0x7F, 0x7F, 0x00,
  0x3F, 0xCF, 0xE0, 0x1F, 0xF3, 0xFC, 0x0F, 0xFC, 0x7F, 0xFF, 0xFF, 0x1F,
  0xFF, 0xEF, 0xC3, 0xFF, 0xF3, 0xF0, 0x7F, 0xF8, 0xFC, 0x0F, 0xFC, 0x3F,
  0x00, 0x30, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xBF, 0x07, 0xFF, 0xC3, 0xFF, 0xF1,
  0xFF, 0xFC, 0xFF, 0xFF, 0x7F, 0xEF, 0xDF, 0xFB, 0xFF, 0x80, 0xFF, 0xC0,
  0x3F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x3F, 0xFE, 0x03, 0xFF, 0xFC, 0x3F, 0xFF, 0xF3,
  0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xFC, 0x03, 0x8F, 0xC0, 0x04, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0xC0, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xF8,
  0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xE0, 0x1F, 0xDF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xE0, 0x7F, 0xFE, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xFC, 0x10, 0xFF, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xC0,
  0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0x60, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F,
  0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00,
  0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00,
  0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0,
  0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF,
  0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF,
  0xF0, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F,
  0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xEF, 0xE0, 0x0F, 0xF7, 0xF0, 0x0F,
  0xFB, 0xFC, 0x0F, 0xFC, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xBF, 0x1F, 0xFF,
  0x8F, 0x87, 0xFF, 0x87, 0xC1, 0xFF, 0x83, 0xE0, 0x0E, 0x00, 0x00, 0xFE,
  0x00, 0x07, 0xF7, 0xE0, 0x00, 0x7F, 0x7F, 0x00, 0x07, 0xE7, 0xF0, 0x00,
  0xFE, 0x3F, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0xFC, 0x3F, 0x80, 0x1F, 0xC3,
  0xF8, 0x01, 0xFC, 0x1F, 0x80, 0x1F, 0x81, 0xF8, 0x01, 0xF8, 0x1F, 0xC0,
  0x3F, 0x80, 0xFC, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xE0, 0x7F, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7E,
  0x07, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC,
  0x00, 0x1F, 0x0F, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x1F, 0x9F, 0x80, 0x01,
  0xF9, 0xF8, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0x80, 0x0F, 0xF0, 0x01,
  0xFB, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x7F, 0x00, 0x3F, 0xE0, 0x07, 0xE7,
  0xE0, 0x07, 0xFC, 0x01, 0xFC, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0x1F, 0x80,
  0x3F, 0xF0, 0x07, 0xE3, 0xF8, 0x07, 0xFE, 0x00, 0xFC, 0x3F, 0x00, 0xFB,
  0xE0, 0x3F, 0x87, 0xE0, 0x3E, 0x7C, 0x07, 0xE0, 0xFC, 0x07, 0xCF, 0x80,
  0xFC, 0x1F, 0xC0, 0xF9, 0xF0, 0x1F, 0x81, 0xF8, 0x1F, 0x3F, 0x03, 0xF0,
  0x3F, 0x07, 0xE3, 0xE0, 0xFC, 0x07, 0xE0, 0xF8, 0x7C, 0x1F, 0x80, 0xFC,
  0x1F, 0x0F, 0x83, 0xF0, 0x1F, 0xC3, 0xE1, 0xF0, 0x7E, 0x01, 0xF8, 0x7C,
  0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x83, 0xE3, 0xF0, 0x07, 0xE3, 0xE0, 0x7C,
  0x7E, 0x00, 0xFC, 0x7C, 0x0F, 0x8F, 0xC0, 0x0F, 0xCF, 0x81, 0xF1, 0xF8,
  0x01, 0xF9, 0xF0, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x03, 0xEF, 0xC0, 0x07,
  0xEF, 0x80, 0x7D, 0xF8, 0x00, 0x7D, 0xF0, 0x0F, 0xBF, 0x00, 0x0F, 0xBE,
  0x01, 0xF7, 0xC0, 0x01, 0xF7, 0xC0, 0x3E, 0xF8, 0x00, 0x3F, 0xF0, 0x03,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x00,
  0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0xFF,
  0x00, 0x1F, 0xCF, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x3F,
  0x81, 0xF8, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x03, 0xF0, 0x3F, 0x80, 0x7F,
  0x0F, 0xE0, 0x07, 0xE1, 0xFC, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xCF, 0xE0,
  0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0x9F, 0x80, 0x07, 0xF3, 0xF8, 0x00,
  0xFC, 0x3F, 0x00, 0x3F, 0x87, 0xF0, 0x07, 0xE0, 0x7F, 0x01, 0xFC, 0x0F,
  0xE0, 0x3F, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0xC1, 0xF8, 0x01, 0xFC, 0x7F,
  0x00, 0x3F, 0x8F, 0xC0, 0x03, 0xFB, 0xF8, 0x00, 0x7F, 0x80, 0xFE, 0x00,
  0x07, 0xF7, 0xE0, 0x00, 0x7F, 0x7F, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0xFE,
  0x3F, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0xFC, 0x3F, 0x80, 0x1F, 0xC1, 0xF8,
  0x01, 0xFC, 0x1F, 0x80, 0x1F, 0x81, 0xFC, 0x01, 0xF8, 0x1F, 0xC0, 0x3F,
  0x80, 0xFC, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xFE, 0x03, 0xF0, 0x07,
  0xE0, 0x7F, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xF0, 0x7E, 0x00, 0x3F, 0x07,
  0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF8, 0xFC, 0x00,
  0x1F, 0x9F, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0xFD,
  0xF8, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF7,
  0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x20, 0x01, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x0F,
  0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0xF0, 0x07, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8,
  0x00, 0xFF, 0x00, 0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x7F, 0xF0,
  0x0F, 0xFE, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x0F,
  0xF8, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x23, 0xFE, 0x00, 0x04,
  0xFF, 0xF0, 0x01, 0xBF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFE, 0x80, 0x01, 0xFF, 0x10,
  0x00, 0x01, 0x00,
};

const GFXglyph NotoSans_Condensed_Medium65pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 8, 47, 16, 4, -46 },
  { 48, 19, 16, 26, 4, -46 },
  { 86, 32, 46, 34, 1, -46 },
  { 270, 25, 53, 31, 3, -49 },
  { 436, 43, 48, 48, 3, -47 },
  { 694, 35, 48, 37, 2, -47 },
  { 904, 7, 16, 14, 4, -46 },
  { 918, 15, 57, 20, 3, -47 },
  { 1025, 15, 57, 20, 2, -47 },
  { 1132, 25, 25, 29, 2, -49 },
  { 1211, 27, 30, 31, 2, -38 },
  { 1313, 10, 16, 16, 2, -7 },
  { 1333, 15, 6, 19, 2, -20 },
  { 1345, 8, 9, 16, 4, -8 },
  { 1354, 23, 47, 25, 1, -47 },
  { 1490, 25, 48, 31, 3, -47 },
  { 1640, 17, 46, 31, 4, -46 },
  { 1738, 26, 47, 31, 2, -47 },
  { 1891, 26, 48, 31, 2, -47 },
  { 2047, 29, 47, 31, 1, -47 },
  { 2218, 25, 47, 31, 3, -46 },
  { 2365, 26, 48, 31, 3, -47 },
  { 2521, 27, 46, 31, 2, -46 },
  { 2677, 27, 48, 31, 2, -47 },
  { 2839, 26, 48, 31, 2, -47 },
  { 2995, 8, 36, 16, 4, -35 },
  { 3031, 10, 44, 16, 2, -35 },
  { 3086, 27, 30, 31, 2, -38 },
  { 3188, 27, 18, 31, 2, -32 },
  { 3249, 27, 30, 31, 2, -38 },
  { 3351, 21, 48, 24, 1, -47 },
  { 3477, 42, 52, 48, 3, -47 },
  { 3750, 34, 46, 34, 0, -46 },
  { 3946, 27, 46, 35, 5, -46 },
  { 4102, 28, 48, 33, 3, -47 },
  { 4270, 30, 46, 38, 5, -46 },
  { 4443, 21, 46, 30, 5, -46 },
  { 4564, 21, 46, 28, 5, -46 },
  { 4685, 32, 48, 39, 3, -47 },
  { 4877, 29, 46, 40, 5, -46 },
  { 5044, 16, 46, 20, 2, -46 },
  { 5136, 16, 59, 17, -4, -46 },
  { 5254, 29, 46, 34, 5, -46 },
  { 5421, 22, 46, 28, 5, -46 },
  { 5548, 41, 46, 51, 5, -46 },
  { 5784, 32, 46, 42, 5, -46 },
  { 5968, 35, 48, 41, 3, -47 },
  { 6178, 25, 46, 33, 5, -46 },
  { 6322, 35, 58, 41, 3, -47 },
  { 6576, 28, 46, 34, 5, -46 },
  { 6737, 24, 48, 30, 3, -47 },
  { 6881, 27, 46, 29, 1, -46 },
  { 7037, 29, 47, 39, 5, -46 },
  { 7208, 33, 46, 33, 0, -46 },
  { 7398, 51, 46, 51, 0, -46 },
  { 7692, 31, 46, 31, 0, -46 },
  { 7871, 30, 46, 30, 0, -46 },
  { 8044, 25, 46, 28, 2, -46 },
  { 8188, 14, 57, 21, 5, -47 },
  { 8288, 23, 47, 25, 1, -47 },
  { 8424, 14, 57, 21, 2, -47 },
  { 8524, 30, 27, 32, 1, -46 },
  { 8626, 28, 4, 28, 0, 6 },
  { 8640, 13, 11, 19, 3, -50 },
  { 8658, 24, 37, 31, 2, -36 },
  { 8769, 27, 50, 34, 4, -49 },
  { 8938, 22, 37, 26, 3, -36 },
  { 9040, 26, 50, 34, 3, -49 },
  { 9203, 25, 37, 31, 3, -36 },
  { 9319, 20, 50, 19, 1, -50 },
  { 9444, 26, 52, 34, 3, -36 },
  { 9613, 25, 49, 34, 4, -49 },
  { 9767, 7, 48, 15, 4, -48 },
  { 9809, 13, 64, 15, -2, -48 },
  { 9913, 26, 49, 30, 4, -49 },
  { 10073, 7, 49, 15, 4, -49 },
  { 10116, 42, 36, 50, 4, -36 },
  { 10305, 25, 36, 34, 4, -36 },
  { 10418, 27, 37, 33, 3, -36 },
  { 10543, 27, 52, 34, 4, -36 },
  { 10719, 26, 52, 34, 3, -36 },
  { 10888, 18, 36, 23, 4, -36 },
  { 10969, 21, 37, 25, 2, -36 },
  { 11067, 18, 44, 20, 1, -43 },
  { 11166, 25, 36, 34, 4, -35 },
  { 11279, 28, 35, 28, 0, -35 },
  { 11402, 43, 35, 44, 1, -35 },
  { 11591, 27, 35, 28, 1, -35 },
  { 11710, 28, 51, 28, 0, -35 },
  { 11889, 20, 35, 24, 2, -35 },
  { 11977, 19, 57, 24, 2, -47 },
  { 12113, 6, 65, 30, 12, -50 },
  { 12162, 20, 57, 24, 2, -47 },
  { 12305, 27, 10, 31, 2, -28 },
};

const GFXfont NotoSans_Condensed_Medium65pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Medium65pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Medium65pt7bGlyphs,
  0x20, 0x7E, 89
};

#endif // _NOTOSANS_CONDENSED_MEDIUM65PT7B_H_
