#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated_Fonts_For_Copy/NotoSans_Condensed_Medium
// Headers: 67

#include "NotoSans_Condensed_Medium6pt7b.h"
#include "NotoSans_Condensed_Medium7pt7b.h"
#include "NotoSans_Condensed_Medium8pt7b.h"
#include "NotoSans_Condensed_Medium9pt7b.h"
#include "NotoSans_Condensed_Medium10pt7b.h"
#include "NotoSans_Condensed_Medium11pt7b.h"
#include "NotoSans_Condensed_Medium12pt7b.h"
#include "NotoSans_Condensed_Medium13pt7b.h"
#include "NotoSans_Condensed_Medium14pt7b.h"
#include "NotoSans_Condensed_Medium15pt7b.h"
#include "NotoSans_Condensed_Medium16pt7b.h"
#include "NotoSans_Condensed_Medium17pt7b.h"
#include "NotoSans_Condensed_Medium18pt7b.h"
#include "NotoSans_Condensed_Medium19pt7b.h"
#include "NotoSans_Condensed_Medium20pt7b.h"
#include "NotoSans_Condensed_Medium21pt7b.h"
#include "NotoSans_Condensed_Medium22pt7b.h"
#include "NotoSans_Condensed_Medium23pt7b.h"
#include "NotoSans_Condensed_Medium24pt7b.h"
#include "NotoSans_Condensed_Medium25pt7b.h"
#include "NotoSans_Condensed_Medium26pt7b.h"
#include "NotoSans_Condensed_Medium27pt7b.h"
#include "NotoSans_Condensed_Medium28pt7b.h"
#include "NotoSans_Condensed_Medium29pt7b.h"
#include "NotoSans_Condensed_Medium30pt7b.h"
#include "NotoSans_Condensed_Medium31pt7b.h"
#include "NotoSans_Condensed_Medium32pt7b.h"
#include "NotoSans_Condensed_Medium33pt7b.h"
#include "NotoSans_Condensed_Medium34pt7b.h"
#include "NotoSans_Condensed_Medium35pt7b.h"
#include "NotoSans_Condensed_Medium36pt7b.h"
#include "NotoSans_Condensed_Medium37pt7b.h"
#include "NotoSans_Condensed_Medium38pt7b.h"
#include "NotoSans_Condensed_Medium39pt7b.h"
#include "NotoSans_Condensed_Medium40pt7b.h"
#include "NotoSans_Condensed_Medium41pt7b.h"
#include "NotoSans_Condensed_Medium42pt7b.h"
#include "NotoSans_Condensed_Medium43pt7b.h"
#include "NotoSans_Condensed_Medium44pt7b.h"
#include "NotoSans_Condensed_Medium45pt7b.h"
#include "NotoSans_Condensed_Medium46pt7b.h"
#include "NotoSans_Condensed_Medium47pt7b.h"
#include "NotoSans_Condensed_Medium48pt7b.h"
#include "NotoSans_Condensed_Medium49pt7b.h"
#include "NotoSans_Condensed_Medium50pt7b.h"
#include "NotoSans_Condensed_Medium51pt7b.h"
#include "NotoSans_Condensed_Medium52pt7b.h"
#include "NotoSans_Condensed_Medium53pt7b.h"
#include "NotoSans_Condensed_Medium54pt7b.h"
#include "NotoSans_Condensed_Medium55pt7b.h"
#include "NotoSans_Condensed_Medium56pt7b.h"
#include "NotoSans_Condensed_Medium57pt7b.h"
#include "NotoSans_Condensed_Medium58pt7b.h"
#include "NotoSans_Condensed_Medium59pt7b.h"
#include "NotoSans_Condensed_Medium60pt7b.h"
#include "NotoSans_Condensed_Medium61pt7b.h"
#include "NotoSans_Condensed_Medium62pt7b.h"
#include "NotoSans_Condensed_Medium63pt7b.h"
#include "NotoSans_Condensed_Medium64pt7b.h"
#include "NotoSans_Condensed_Medium65pt7b.h"
#include "NotoSans_Condensed_Medium66pt7b.h"
#include "NotoSans_Condensed_Medium67pt7b.h"
#include "NotoSans_Condensed_Medium68pt7b.h"
#include "NotoSans_Condensed_Medium69pt7b.h"
#include "NotoSans_Condensed_Medium70pt7b.h"
#include "NotoSans_Condensed_Medium71pt7b.h"
#include "NotoSans_Condensed_Medium72pt7b.h"
