#ifndef _NOTOSANS_CONDENSED_MEDIUM48PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUM48PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Medium.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Medium48pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x00, 0x00, 0x00, 0x7B, 0xFF,
  0xFF, 0xFD, 0xE3, 0x00, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8,
  0x7F, 0xE1, 0xEF, 0x87, 0xBC, 0x1E, 0xF0, 0x7B, 0xC1, 0xE7, 0x07, 0x9C,
  0x1E, 0x00, 0xF0, 0xF0, 0x01, 0xC1, 0xE0, 0x03, 0x83, 0xC0, 0x07, 0x07,
  0x80, 0x1E, 0x0E, 0x00, 0x3C, 0x1C, 0x00, 0x78, 0x38, 0x00, 0xF0, 0xF0,
  0x01, 0xC1, 0xE0, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xE0, 0x78, 0x38, 0x00, 0xF0, 0xF0, 0x01, 0xC1, 0xE0, 0x03,
  0x83, 0xC0, 0x0F, 0x07, 0x80, 0x1E, 0x0E, 0x00, 0x3C, 0x1C, 0x0F, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x0F, 0x07,
  0x00, 0x1E, 0x0E, 0x00, 0x3C, 0x1C, 0x00, 0x78, 0x78, 0x00, 0xE0, 0xF0,
  0x01, 0xC1, 0xE0, 0x03, 0x83, 0xC0, 0x0F, 0x07, 0x00, 0x1E, 0x0E, 0x00,
  0x3C, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x78,
  0x00, 0x7F, 0xF8, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF, 0xFC, 0x7C, 0xE0,
  0x9F, 0x1C, 0x03, 0xE3, 0x80, 0x7C, 0x70, 0x0F, 0x8E, 0x01, 0xF1, 0xC0,
  0x1F, 0x38, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x39, 0xF0, 0x07, 0x1F,
  0x00, 0xE3, 0xE0, 0x1C, 0x3C, 0x03, 0x8F, 0xC0, 0x71, 0xFC, 0x0E, 0x7D,
  0xF9, 0xFF, 0xBF, 0xFF, 0xE7, 0xFF, 0xF8, 0x3F, 0xFC, 0x00, 0x7C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x07, 0x80, 0x3F, 0xE0, 0x0F, 0x00,
  0x7F, 0xE0, 0x0F, 0x00, 0x78, 0xF0, 0x1E, 0x00, 0xF0, 0xF0, 0x1E, 0x00,
  0xF0, 0xF0, 0x1C, 0x00, 0xF0, 0x70, 0x3C, 0x00, 0xF0, 0x78, 0x3C, 0x00,
  0xF0, 0x78, 0x78, 0x00, 0xF0, 0x78, 0x78, 0x00, 0xF0, 0x78, 0x70, 0x00,
  0xF0, 0x78, 0xF0, 0x00, 0xF0, 0x78, 0xF0, 0x00, 0xF0, 0x71, 0xE1, 0xF0,
  0xF0, 0xF1, 0xE7, 0xF8, 0x70, 0xF3, 0xC7, 0xFC, 0x78, 0xF3, 0xCF, 0xBE,
  0x7F, 0xE3, 0x8F, 0x1E, 0x3F, 0xE7, 0x8E, 0x1E, 0x1F, 0xC7, 0x9E, 0x0E,
  0x0F, 0x0F, 0x1E, 0x0F, 0x00, 0x0F, 0x1E, 0x0F, 0x00, 0x1E, 0x1E, 0x0F,
  0x00, 0x1E, 0x1E, 0x0F, 0x00, 0x1E, 0x1E, 0x0F, 0x00, 0x3C, 0x1E, 0x0F,
  0x00, 0x3C, 0x1E, 0x0F, 0x00, 0x78, 0x1E, 0x0F, 0x00, 0x78, 0x1E, 0x1E,
  0x00, 0x70, 0x0F, 0x1E, 0x00, 0xF0, 0x0F, 0x1E, 0x00, 0xF0, 0x07, 0xFC,
  0x01, 0xE0, 0x07, 0xFC, 0x01, 0xE0, 0x03, 0xF8, 0x00, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x01, 0xF1, 0xF0, 0x00,
  0xF0, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x0F, 0x80,
  0x1F, 0x07, 0xC0, 0x07, 0x83, 0xC0, 0x03, 0xE3, 0xE0, 0x01, 0xF3, 0xE0,
  0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xFE, 0x07, 0xC7, 0xFF, 0x03, 0xE7, 0xE7,
  0xC1, 0xF7, 0xE1, 0xF1, 0xF3, 0xE0, 0xFC, 0xF9, 0xF0, 0x3E, 0x7C, 0xF8,
  0x0F, 0xFC, 0x7C, 0x07, 0xFE, 0x3E, 0x01, 0xFE, 0x1F, 0x00, 0x7F, 0x0F,
  0x80, 0x3F, 0x07, 0xE0, 0x3F, 0xC3, 0xF8, 0x3F, 0xF0, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0x3E, 0x1F, 0xFF, 0x0F, 0x83, 0xFE, 0x07, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xF7, 0x9C, 0xE0, 0x03, 0xE0, 0x78, 0x1E, 0x07, 0xC0,
  0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0xC0,
  0xF0, 0x1E, 0x03, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x01, 0xE0, 0x3C, 0x07, 0xC0, 0xF8, 0x1F,
  0x01, 0xE0, 0x3E, 0x07, 0xC0, 0x78, 0x0F, 0x80, 0xF0, 0x1F, 0x01, 0xE0,
  0x1E, 0x03, 0xC0, 0x3C, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x01, 0xF0, 0x1E,
  0x03, 0xC0, 0x7C, 0x07, 0x80, 0xF8, 0x1F, 0x01, 0xE0, 0x3C, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3C, 0x07, 0x81, 0xF0, 0x3E,
  0x07, 0x81, 0xF0, 0x3E, 0x07, 0x81, 0xF0, 0x3C, 0x0F, 0x81, 0xE0, 0x78,
  0x1E, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x0E, 0x1E, 0x3B, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x7F, 0x80, 0x1F, 0xC0, 0x07, 0xF8, 0x03, 0xDF, 0x01, 0xF3, 0xC0,
  0xF8, 0xF8, 0x3E, 0x1F, 0x07, 0x07, 0x00, 0x40, 0x80, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x3E, 0x7C, 0xFB, 0xE7, 0xCF, 0x9F, 0x3C, 0x79, 0xE3, 0xC7,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7B, 0xFF, 0xFF, 0xFD, 0xE2,
  0x00, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0,
  0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03,
  0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0xFF, 0x83,
  0xFB, 0xF0, 0x7C, 0x1F, 0x1F, 0x03, 0xE3, 0xE0, 0x3E, 0x7C, 0x07, 0xCF,
  0x00, 0xFB, 0xE0, 0x0F, 0x7C, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8,
  0x03, 0xFF, 0x00, 0x79, 0xE0, 0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0x7C, 0xFC,
  0x1F, 0x0F, 0x87, 0xE1, 0xFF, 0xF8, 0x1F, 0xFF, 0x01, 0xFF, 0xC0, 0x1F,
  0xF0, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0xFE, 0x0F, 0xF0, 0xFF, 0x9F, 0xFD,
  0xFB, 0xFF, 0x9F, 0x78, 0xF9, 0x87, 0xC8, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x01, 0xE0,
  0x03, 0xFF, 0x80, 0xFF, 0xF8, 0x3F, 0xFF, 0x8F, 0xF7, 0xF8, 0xF0, 0x1F,
  0x08, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xE0,
  0x03, 0xFF, 0x81, 0xFF, 0xFC, 0x7F, 0xFF, 0x8F, 0xE7, 0xF8, 0xE0, 0x1F,
  0x08, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x7F, 0xF0,
  0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7D, 0x00, 0x1F, 0xB0, 0x07, 0xF7,
  0xFF, 0xFC, 0xFF, 0xFF, 0x1F, 0xFF, 0xC1, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xDE, 0x00, 0x1E, 0xF0, 0x00, 0xE7, 0x80, 0x0F, 0x3C,
  0x00, 0x71, 0xE0, 0x07, 0x8F, 0x00, 0x78, 0x78, 0x03, 0xC3, 0xC0, 0x3C,
  0x1E, 0x01, 0xE0, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x3C, 0x0F, 0x01, 0xE0,
  0x78, 0x0F, 0x07, 0x80, 0x78, 0x3C, 0x03, 0xC3, 0xC0, 0x1E, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F,
  0xFF, 0xC3, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFF,
  0xF8, 0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x7F, 0xFF, 0x84, 0x03, 0xF8, 0x00,
  0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE8, 0x00,
  0xFD, 0xC0, 0x3F, 0x3F, 0xFF, 0xE7, 0xFF, 0xF8, 0xFF, 0xFE, 0x07, 0xFF,
  0x00, 0x00, 0x1F, 0x00, 0x3F, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0xFF,
  0x18, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0xF0, 0x3E, 0x7F,
  0x87, 0xDF, 0xF8, 0xFF, 0xFF, 0x9F, 0xE3, 0xFB, 0xF8, 0x1F, 0x7E, 0x03,
  0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0x7D, 0xE0, 0x0F, 0xBE, 0x01, 0xF7, 0xC0, 0x3C, 0x7C, 0x0F,
  0x8F, 0xC3, 0xF0, 0xFF, 0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x0F, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC7,
  0xF1, 0xFC, 0xF8, 0x0F, 0x9F, 0x01, 0xF3, 0xC0, 0x1E, 0x78, 0x03, 0xCF,
  0x00, 0x79, 0xE0, 0x1F, 0x3E, 0x03, 0xE3, 0xE0, 0xF8, 0x7E, 0x3F, 0x07,
  0xEF, 0xC0, 0x7F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xF8, 0x0F,
  0xFF, 0x83, 0xE1, 0xF8, 0xF8, 0x1F, 0xBE, 0x01, 0xF7, 0xC0, 0x1F, 0xF8,
  0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF0,
  0x07, 0xFF, 0x01, 0xF3, 0xFD, 0xFE, 0x3F, 0xFF, 0x83, 0xFF, 0xE0, 0x1F,
  0xF0, 0x00, 0x00, 0xE0, 0x01, 0xFF, 0x80, 0x7F, 0xF8, 0x1F, 0xFF, 0x87,
  0xFF, 0xF0, 0xF8, 0x1F, 0x1F, 0x03, 0xE7, 0xC0, 0x3E, 0xF8, 0x07, 0xDF,
  0x00, 0x7B, 0xE0, 0x0F, 0x7C, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xEF, 0x81, 0xFD, 0xFF, 0xFF, 0x9F,
  0xFF, 0xF1, 0xFF, 0xBE, 0x1F, 0xE7, 0x80, 0x40, 0xF0, 0x00, 0x1E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x1F, 0xC1, 0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0x00, 0xFF,
  0x80, 0x00, 0x7B, 0xFF, 0xFF, 0xFD, 0xE2, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7B, 0xFF, 0xFF, 0xFD, 0xE2, 0x00, 0x3C,
  0xFD, 0xFB, 0xF7, 0xE7, 0x84, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xE7, 0xCF, 0xBE, 0x7C, 0xF9, 0xE3, 0xCF,
  0x9E, 0x3C, 0x78, 0x00, 0x00, 0x20, 0x00, 0x1C, 0x00, 0x0F, 0x80, 0x07,
  0xF0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x1F, 0xE0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F,
  0x80, 0x01, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xE0,
  0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x03, 0xF8, 0x00, 0x7C, 0x00, 0x0E, 0x00, 0x01, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x0F, 0xFC, 0x3F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xF1, 0x80, 0xF8,
  0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0x20, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x3C, 0x1E,
  0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x78, 0xF0, 0x1F, 0xF0, 0xF1, 0xE0,
  0x7F, 0xF0, 0xE3, 0x81, 0xFF, 0xE1, 0xEF, 0x07, 0xC3, 0xC3, 0xDE, 0x0F,
  0x07, 0x87, 0xBC, 0x3C, 0x0E, 0x0F, 0x70, 0x78, 0x1C, 0x0F, 0xE0, 0xF0,
  0x78, 0x1F, 0xC1, 0xC0, 0xF0, 0x3F, 0x87, 0x81, 0xE0, 0xFF, 0x0F, 0x03,
  0xC1, 0xFE, 0x1E, 0x07, 0x83, 0xFC, 0x1C, 0x0F, 0x07, 0xF8, 0x3C, 0x1E,
  0x0F, 0xF0, 0x78, 0x7C, 0x1C, 0xE0, 0xF0, 0xFC, 0x79, 0xE0, 0xFF, 0xBF,
  0xE3, 0xC1, 0xFF, 0x3F, 0xC7, 0x81, 0xFC, 0x7F, 0x07, 0x80, 0xC0, 0x10,
  0x0F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x0C, 0x00, 0x3F, 0xE1, 0xF8, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xBC, 0x00, 0x03, 0xDE, 0x00, 0x03, 0xEF,
  0x80, 0x01, 0xF3, 0xC0, 0x00, 0xF1, 0xE0, 0x00, 0x78, 0xF8, 0x00, 0x7C,
  0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x1E, 0x0F, 0x00, 0x1F, 0x07, 0xC0, 0x0F,
  0x83, 0xE0, 0x07, 0xC0, 0xF0, 0x03, 0xC0, 0x7C, 0x03, 0xE0, 0x3E, 0x01,
  0xF0, 0x1F, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF8, 0x1F, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x0F, 0x80, 0x0F,
  0x87, 0xC0, 0x07, 0xC3, 0xE0, 0x01, 0xF3, 0xE0, 0x00, 0xF9, 0xF0, 0x00,
  0x7C, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xC0, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xF8, 0x0F, 0xCF,
  0x80, 0x7E, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x3E,
  0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x07, 0xCF, 0x80, 0xFC, 0xFF, 0xFF,
  0x8F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0xF8, 0x1F, 0xCF, 0x80,
  0x7E, 0xF8, 0x03, 0xEF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x3E, 0xF8, 0x07, 0xEF,
  0x80, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0x80,
  0x00, 0x1F, 0x00, 0x07, 0xFF, 0x80, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x07, 0xE0, 0x18, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0xC1, 0xFF, 0xFE,
  0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x3F, 0xF8, 0xFF, 0xF8, 0x03, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xF8, 0x1F, 0xE3, 0xE0, 0x1F,
  0x8F, 0x80, 0x3F, 0x3E, 0x00, 0x7C, 0xF8, 0x01, 0xFB, 0xE0, 0x03, 0xEF,
  0x80, 0x0F, 0xBE, 0x00, 0x3E, 0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xEF, 0x80, 0x0F, 0xBE,
  0x00, 0x3E, 0xF8, 0x01, 0xFB, 0xE0, 0x07, 0xCF, 0x80, 0x3F, 0x3E, 0x00,
  0xFC, 0xF8, 0x0F, 0xE3, 0xE0, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0,
  0xFF, 0xFE, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xFF, 0x03,
  0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xE0, 0x0C, 0x1F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0x7C,
  0x03, 0xFF, 0x7C, 0x03, 0xFF, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C,
  0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7E, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x3F,
  0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x80, 0x1F, 0x0F, 0xE0, 0x1F, 0x07,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xF8, 0xF8,
  0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07,
  0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0,
  0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x0F, 0xE7,
  0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0,
  0x3E, 0x07, 0xEF, 0xFE, 0xFF, 0xCF, 0xF8, 0xFF, 0x01, 0x00, 0xF8, 0x01,
  0xFF, 0xC0, 0x1F, 0x3E, 0x01, 0xF9, 0xF0, 0x0F, 0x8F, 0x80, 0xFC, 0x7C,
  0x0F, 0xC3, 0xE0, 0x7C, 0x1F, 0x07, 0xE0, 0xF8, 0x3E, 0x07, 0xC3, 0xE0,
  0x3E, 0x3F, 0x01, 0xF1, 0xF0, 0x0F, 0x9F, 0x00, 0x7D, 0xF8, 0x03, 0xEF,
  0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x01,
  0xF9, 0xF0, 0x0F, 0x8F, 0xC0, 0x7C, 0x3E, 0x03, 0xE1, 0xF8, 0x1F, 0x07,
  0xC0, 0xF8, 0x3F, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xE1, 0xF0, 0x1F, 0x0F,
  0x80, 0x7C, 0x7C, 0x03, 0xF3, 0xE0, 0x0F, 0x9F, 0x00, 0x7E, 0xF8, 0x01,
  0xF7, 0xC0, 0x0F, 0xC0, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x7B, 0xFD, 0xE0, 0x01, 0xEF, 0xF7, 0x80, 0x07, 0xBF, 0xDF, 0x00,
  0x3D, 0xFF, 0x3C, 0x00, 0xF7, 0xFC, 0xF0, 0x03, 0xDF, 0xF3, 0xE0, 0x1E,
  0x7F, 0xCF, 0x80, 0x79, 0xFF, 0x1E, 0x01, 0xE7, 0xFC, 0x78, 0x0F, 0x9F,
  0xF1, 0xF0, 0x3C, 0x7F, 0xC3, 0xC0, 0xF1, 0xFF, 0x0F, 0x07, 0xC7, 0xFC,
  0x3E, 0x1E, 0x1F, 0xF0, 0x78, 0x78, 0x7F, 0xC1, 0xE1, 0xE1, 0xFF, 0x07,
  0xCF, 0x07, 0xFC, 0x1F, 0x3C, 0x1F, 0xF0, 0x3C, 0xF0, 0x7F, 0xC0, 0xF7,
  0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x07, 0xF8, 0x1F, 0xF0, 0x1F, 0xE0,
  0x7F, 0xC0, 0x7F, 0x01, 0xFF, 0x00, 0xFC, 0x07, 0xFC, 0x03, 0xF0, 0x1F,
  0xF0, 0x0F, 0x80, 0x7F, 0xC0, 0x3E, 0x01, 0xF0, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xF7, 0xC0, 0x1F, 0xEF, 0x80,
  0x3F, 0xCF, 0x80, 0x7F, 0x9F, 0x00, 0xFF, 0x1F, 0x01, 0xFE, 0x3E, 0x03,
  0xFC, 0x3E, 0x07, 0xF8, 0x7C, 0x0F, 0xF0, 0x7C, 0x1F, 0xE0, 0xF8, 0x3F,
  0xC0, 0xF8, 0x7F, 0x81, 0xF0, 0xFF, 0x01, 0xF1, 0xFE, 0x03, 0xE3, 0xFC,
  0x03, 0xE7, 0xF8, 0x07, 0xCF, 0xF0, 0x07, 0xDF, 0xE0, 0x0F, 0xBF, 0xC0,
  0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFC, 0x07, 0xF0, 0x1F, 0x81, 0xF0, 0x03, 0xE0, 0xFC, 0x00, 0x7C,
  0x3E, 0x00, 0x1F, 0x1F, 0x80, 0x07, 0xE7, 0xC0, 0x00, 0xF9, 0xF0, 0x00,
  0x3E, 0x7C, 0x00, 0x0F, 0x9F, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xDF, 0x00, 0x03, 0xF7, 0xC0, 0x00,
  0xF9, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0x9F, 0x80, 0x03, 0xE3, 0xE0,
  0x01, 0xF8, 0xF8, 0x00, 0x7C, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x1F, 0x81,
  0xFC, 0x0F, 0xE0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFC,
  0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xF8, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF,
  0xFE, 0xF8, 0x3F, 0xBE, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0xFF, 0xE0, 0x7E, 0xF8, 0x7F, 0xBF, 0xFF, 0xCF, 0xFF, 0xE3, 0xFF,
  0xF0, 0xFF, 0xE0, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFC, 0x07, 0xF0, 0x1F, 0x81, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0x7C, 0x3E,
  0x00, 0x1F, 0x1F, 0x80, 0x07, 0xE7, 0xC0, 0x00, 0xF9, 0xF0, 0x00, 0x3E,
  0x7C, 0x00, 0x0F, 0x9F, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0xFF, 0xF0, 0x00,
  0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0,
  0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xDF, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0xF9,
  0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0x9F, 0x80, 0x03, 0xE3, 0xE0, 0x01,
  0xF8, 0xF8, 0x00, 0x7C, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x1F, 0x81, 0xFC,
  0x0F, 0xE0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF8, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x3F, 0xFF,
  0xC1, 0xFF, 0xFF, 0x0F, 0x83, 0xFC, 0x7C, 0x07, 0xE3, 0xE0, 0x1F, 0x1F,
  0x00, 0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x3F, 0x3E, 0x01, 0xF1, 0xF0, 0x0F,
  0x8F, 0x80, 0x7C, 0x7C, 0x03, 0xE3, 0xE0, 0x3E, 0x1F, 0x07, 0xF0, 0xFF,
  0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0x87, 0xC0,
  0x7C, 0x3E, 0x03, 0xE0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x1F, 0x07, 0xC0,
  0xF8, 0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x80, 0x7C, 0x7C, 0x03, 0xE3,
  0xE0, 0x1F, 0x9F, 0x00, 0x7C, 0xF8, 0x03, 0xF7, 0xC0, 0x0F, 0xC0, 0x01,
  0xF8, 0x01, 0xFF, 0xC1, 0xFF, 0xFC, 0xFF, 0xFE, 0x7F, 0xFF, 0x9F, 0x80,
  0xE7, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x1F,
  0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xE0, 0x03, 0xEF, 0x01, 0xFB, 0xFF, 0xFC, 0xFF,
  0xFF, 0x3F, 0xFF, 0x07, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x1F, 0x7C, 0x00, 0x7D, 0xF0, 0x01, 0xF7, 0xC0, 0x07, 0xDF, 0x00, 0x3F,
  0x7E, 0x00, 0xF8, 0xFC, 0x0F, 0xE3, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x0F,
  0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x7C,
  0x00, 0x1F, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x3C, 0x00, 0x3E, 0x3E,
  0x00, 0x3C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x1E, 0x00, 0x7C, 0x1F,
  0x00, 0x78, 0x1F, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x07, 0x81, 0xF0, 0x07, 0xC1, 0xE0, 0x07,
  0xC3, 0xE0, 0x07, 0xC3, 0xE0, 0x03, 0xC3, 0xE0, 0x03, 0xE3, 0xC0, 0x03,
  0xE7, 0xC0, 0x01, 0xE7, 0xC0, 0x01, 0xE7, 0x80, 0x01, 0xF7, 0x80, 0x01,
  0xF7, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0xF8,
  0x00, 0x78, 0x00, 0x7F, 0xE0, 0x03, 0xF0, 0x01, 0xE7, 0xC0, 0x0F, 0xC0,
  0x0F, 0x9F, 0x00, 0x3F, 0x00, 0x3E, 0x7C, 0x00, 0xFC, 0x00, 0xF9, 0xF0,
  0x07, 0xF8, 0x03, 0xE3, 0xC0, 0x1F, 0xE0, 0x1F, 0x0F, 0x80, 0x7F, 0x80,
  0x7C, 0x3E, 0x01, 0xFE, 0x01, 0xF0, 0xF8, 0x0F, 0xF8, 0x07, 0xC3, 0xE0,
  0x3C, 0xF0, 0x1F, 0x07, 0x80, 0xF3, 0xC0, 0xF8, 0x1F, 0x03, 0xCF, 0x03,
  0xE0, 0x7C, 0x0F, 0x3C, 0x0F, 0x81, 0xF0, 0x7C, 0xF8, 0x3E, 0x03, 0xC1,
  0xE1, 0xE0, 0xF0, 0x0F, 0x87, 0x87, 0x87, 0xC0, 0x3E, 0x1E, 0x1E, 0x1F,
  0x00, 0xF8, 0xF8, 0x78, 0x7C, 0x03, 0xE3, 0xC0, 0xF1, 0xF0, 0x07, 0x8F,
  0x03, 0xC7, 0x80, 0x1F, 0x3C, 0x0F, 0x3E, 0x00, 0x7C, 0xF0, 0x3C, 0xF8,
  0x01, 0xF7, 0xC0, 0xFB, 0xE0, 0x03, 0xDE, 0x01, 0xEF, 0x00, 0x0F, 0x78,
  0x07, 0xBC, 0x00, 0x3D, 0xE0, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x7F, 0xC0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x7C, 0x7C, 0x01, 0xF0, 0xF8,
  0x03, 0xE0, 0xF8, 0x0F, 0x81, 0xF0, 0x1F, 0x01, 0xF0, 0x7C, 0x03, 0xE0,
  0xF8, 0x03, 0xE1, 0xF0, 0x07, 0xC7, 0xC0, 0x07, 0x8F, 0x80, 0x0F, 0xBE,
  0x00, 0x0F, 0x7C, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7D, 0xF0, 0x00, 0xFB, 0xE0, 0x03,
  0xE3, 0xE0, 0x07, 0xC7, 0xC0, 0x1F, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0xF8,
  0x0F, 0x81, 0xF0, 0x1F, 0x07, 0xC0, 0x3F, 0x0F, 0x80, 0x3E, 0x3F, 0x00,
  0x7E, 0x7C, 0x00, 0x7D, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0x7D, 0xF0, 0x01,
  0xF7, 0xC0, 0x0F, 0x8F, 0x80, 0x3E, 0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC1,
  0xF0, 0x1F, 0x07, 0xC0, 0xF8, 0x0F, 0x83, 0xE0, 0x3E, 0x1F, 0x00, 0xF8,
  0x7C, 0x01, 0xF1, 0xE0, 0x07, 0xCF, 0x80, 0x0F, 0xBE, 0x00, 0x3E, 0xF0,
  0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0xFF, 0xCF, 0xFF, 0xF9, 0xFF, 0xFF,
  0x3F, 0xFF, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xE0,
  0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x3D, 0xE0, 0x00, 0xF3, 0xC0, 0x07, 0x8F, 0x00,
  0x1E, 0x1E, 0x00, 0xF8, 0x78, 0x03, 0xC0, 0xF0, 0x1F, 0x03, 0xC0, 0x78,
  0x07, 0x83, 0xE0, 0x1E, 0x0F, 0x00, 0x3C, 0x3C, 0x00, 0xF1, 0xE0, 0x01,
  0xE7, 0x80, 0x07, 0xBC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFC, 0x1F, 0x07, 0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0x78, 0x0F,
  0x0F, 0xFC, 0x0F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x18, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x0F,
  0xFC, 0x3F, 0xFF, 0x3F, 0xFF, 0xDF, 0xF9, 0xF7, 0xE0, 0x7F, 0xE0, 0x1F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE,
  0x07, 0xFF, 0xE7, 0xFD, 0xFF, 0xDF, 0x3F, 0xE3, 0xC7, 0xF0, 0xF0, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0xFE, 0x0F, 0x9F, 0xF0, 0xFB, 0xFF, 0x8F, 0xFF, 0xFC, 0xFE, 0x0F,
  0xCF, 0xC0, 0x7E, 0xFC, 0x03, 0xEF, 0xC0, 0x3E, 0xF8, 0x01, 0xEF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1E, 0xFC, 0x03, 0xEF,
  0xC0, 0x3E, 0xFC, 0x03, 0xEF, 0xE0, 0x7C, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8,
  0xF3, 0xFF, 0x0F, 0x0F, 0xE0, 0x03, 0xFE, 0x0F, 0xFF, 0x1F, 0xFF, 0x3F,
  0xFE, 0x3F, 0x02, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F,
  0x03, 0x3F, 0xFF, 0x1F, 0xFF, 0x0F, 0xFF, 0x07, 0xFE, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x07, 0xF1,
  0xF0, 0xFF, 0x9F, 0x1F, 0xFD, 0xF3, 0xFF, 0xFF, 0x3E, 0x0F, 0xF7, 0xE0,
  0x7F, 0x7C, 0x03, 0xF7, 0xC0, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0x7C, 0x03, 0xF7, 0xC0, 0x3F,
  0x7C, 0x03, 0xF7, 0xE0, 0x7F, 0x3F, 0xFF, 0xF1, 0xFF, 0xDF, 0x1F, 0xF9,
  0xF0, 0x7F, 0x0F, 0x03, 0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xDF,
  0xC3, 0xE0, 0xF8, 0xF8, 0x0F, 0x9F, 0x00, 0xF3, 0xC0, 0x1E, 0x78, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x01, 0x8F, 0xFF, 0xF0, 0xFF, 0xFE,
  0x0F, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0xF0, 0x07, 0xFC, 0x1F, 0xF0, 0x7F,
  0xE0, 0xFC, 0xC3, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x01, 0xFF, 0xCF, 0xFF, 0x9F, 0xFF, 0x3F, 0xFE, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x00, 0x07, 0xF0, 0xF0, 0xFF, 0x9F, 0x1F, 0xFD, 0xF3, 0xFF,
  0xFF, 0x3E, 0x0F, 0xF7, 0xE0, 0x7F, 0x7C, 0x03, 0xF7, 0xC0, 0x3F, 0xF8,
  0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0x78, 0x03, 0xF7, 0xC0, 0x3F, 0x7C, 0x03, 0xF7, 0xE0, 0x7F, 0x3F, 0xFF,
  0xF1, 0xFF, 0xDF, 0x1F, 0xF9, 0xF0, 0x7F, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x30,
  0x07, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0x83, 0xFF, 0xF0, 0x1F, 0xFC, 0x00,
  0x0C, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE3, 0xF8, 0x7D, 0xFF, 0x8F, 0xBF, 0xF9, 0xFF, 0xFF, 0xBF,
  0xC3, 0xF7, 0xE0, 0x3E, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0,
  0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x0F, 0xFC, 0x01, 0xF0, 0x77, 0xFF, 0xFF, 0xBC, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x07, 0x07, 0xC3, 0xE1, 0xF0, 0xF8, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8,
  0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x0F, 0x87, 0xC3, 0xFF, 0xEF, 0xF7, 0xF3, 0xF0, 0x40, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x1F, 0xFC,
  0x07, 0xEF, 0x80, 0xF9, 0xF0, 0x3E, 0x3E, 0x0F, 0x87, 0xC1, 0xF0, 0xF8,
  0x7C, 0x1F, 0x1F, 0x03, 0xE3, 0xC0, 0x7C, 0xF8, 0x0F, 0xBE, 0x01, 0xF7,
  0xC0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFE, 0xF8, 0x1F, 0x8F, 0x83, 0xE1,
  0xF0, 0x7C, 0x1F, 0x0F, 0x83, 0xE1, 0xF0, 0x3E, 0x3E, 0x07, 0xC7, 0xC0,
  0x7C, 0xF8, 0x0F, 0x9F, 0x00, 0xFB, 0xE0, 0x1F, 0x7C, 0x01, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0xFE,
  0x0F, 0xF1, 0xE7, 0xFE, 0x3F, 0xF3, 0xDF, 0xFE, 0xFF, 0xF7, 0xFF, 0xFD,
  0xFF, 0xEF, 0xE0, 0xFF, 0x07, 0xFF, 0x80, 0xFC, 0x07, 0xFF, 0x01, 0xF8,
  0x0F, 0xFE, 0x03, 0xE0, 0x1F, 0xF8, 0x07, 0xC0, 0x3F, 0xF0, 0x0F, 0x80,
  0x7F, 0xE0, 0x1F, 0x00, 0xFF, 0xC0, 0x3E, 0x01, 0xFF, 0x80, 0x7C, 0x03,
  0xFF, 0x00, 0xF8, 0x07, 0xFE, 0x01, 0xF0, 0x0F, 0xFC, 0x03, 0xE0, 0x1F,
  0xF8, 0x07, 0xC0, 0x3F, 0xF0, 0x0F, 0x80, 0x7F, 0xE0, 0x1F, 0x00, 0xFF,
  0xC0, 0x3E, 0x01, 0xFF, 0x80, 0x7C, 0x03, 0xFF, 0x00, 0xF8, 0x07, 0xFE,
  0x01, 0xF0, 0x0F, 0xFC, 0x03, 0xE0, 0x1F, 0xF8, 0x07, 0xC0, 0x3F, 0xF0,
  0x0F, 0x80, 0x7C, 0xF0, 0xFE, 0x1E, 0x7F, 0xE3, 0xCF, 0xFE, 0x7F, 0xFF,
  0xEF, 0xE0, 0xFD, 0xF8, 0x0F, 0xBF, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F,
  0xF8, 0x03, 0xFF, 0x00, 0x7C, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF,
  0x83, 0xFF, 0xFC, 0x3E, 0x07, 0xC7, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0,
  0x1E, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0x7C, 0x01, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xE3, 0xE0, 0x7C,
  0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x3F, 0xC0, 0xF0, 0xFE,
  0x0F, 0x1F, 0xF0, 0xFB, 0xFF, 0x8F, 0xFF, 0xFC, 0xFE, 0x07, 0xCF, 0xC0,
  0x7E, 0xFC, 0x03, 0xEF, 0xC0, 0x3E, 0xF8, 0x01, 0xEF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x3E, 0xFC, 0x03, 0xEF, 0xC0, 0x3E,
  0xFC, 0x07, 0xEF, 0xE0, 0x7C, 0xFF, 0xFF, 0xCF, 0xBF, 0xF8, 0xFB, 0xFF,
  0x0F, 0x8F, 0xE0, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xF0, 0xF0,
  0xFF, 0x9F, 0x1F, 0xFD, 0xF3, 0xFF, 0xFF, 0x3E, 0x0F, 0xF7, 0xC0, 0x7F,
  0x7C, 0x03, 0xF7, 0xC0, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0x7C, 0x03, 0xF7, 0xC0, 0x3F, 0x7C,
  0x03, 0xF7, 0xE0, 0x7F, 0x3F, 0xFF, 0xF1, 0xFF, 0xDF, 0x1F, 0xF9, 0xF0,
  0x7F, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xF0, 0xFF, 0x8F, 0xFC,
  0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0x83, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x00, 0x0F, 0xF8, 0x7F, 0xFD, 0xFF, 0xF7, 0xFF, 0xEF, 0x80,
  0xDE, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x01,
  0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x0F, 0xFF, 0xFF, 0x7F, 0xFE,
  0xFF, 0xF8, 0xFF, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3E, 0x01, 0xFF, 0x8F, 0xFC, 0x3F, 0xE0, 0xFF, 0xF8, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0xFE, 0xF8, 0x3F,
  0xDF, 0xFF, 0xF9, 0xFF, 0xDF, 0x3F, 0xF9, 0xE1, 0xFC, 0x3C, 0xF8, 0x00,
  0xFB, 0xC0, 0x0F, 0x9F, 0x00, 0x7C, 0xF8, 0x03, 0xE7, 0xC0, 0x1E, 0x1E,
  0x01, 0xF0, 0xF8, 0x0F, 0x87, 0xC0, 0x78, 0x1E, 0x07, 0xC0, 0xF8, 0x3E,
  0x07, 0xC1, 0xF0, 0x3E, 0x0F, 0x00, 0xF0, 0xF8, 0x07, 0xC7, 0xC0, 0x3E,
  0x3C, 0x00, 0xF1, 0xE0, 0x07, 0x9F, 0x00, 0x3E, 0xF0, 0x00, 0xF7, 0x80,
  0x07, 0xBC, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x78,
  0x07, 0xE0, 0x1F, 0x7C, 0x07, 0xF0, 0x1F, 0x7C, 0x07, 0xF0, 0x1E, 0x7C,
  0x07, 0xF0, 0x1E, 0x3C, 0x0F, 0x70, 0x3E, 0x3E, 0x0F, 0x70, 0x3E, 0x3E,
  0x0F, 0x78, 0x3E, 0x3E, 0x0F, 0x78, 0x3C, 0x1E, 0x0E, 0x78, 0x7C, 0x1E,
  0x1E, 0x78, 0x7C, 0x1F, 0x1E, 0x3C, 0x7C, 0x1F, 0x1E, 0x3C, 0x78, 0x0F,
  0x1E, 0x3C, 0x78, 0x0F, 0x3C, 0x3C, 0xF8, 0x0F, 0x3C, 0x3C, 0xF8, 0x0F,
  0xBC, 0x1E, 0xF0, 0x0F, 0xBC, 0x1E, 0xF0, 0x07, 0xB8, 0x1E, 0xF0, 0x07,
  0xB8, 0x1F, 0xF0, 0x07, 0xF8, 0x0F, 0xE0, 0x07, 0xF8, 0x0F, 0xE0, 0x03,
  0xF8, 0x0F, 0xE0, 0x03, 0xF0, 0x0F, 0xE0, 0x03, 0xF0, 0x0F, 0xC0, 0x03,
  0xF0, 0x07, 0xC0, 0xF8, 0x03, 0xEF, 0x80, 0xF9, 0xF0, 0x1F, 0x1F, 0x07,
  0xC3, 0xE0, 0xF8, 0x3E, 0x3E, 0x07, 0xC7, 0xC0, 0x7D, 0xF0, 0x0F, 0xBE,
  0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x01, 0xF7, 0xC0, 0x3C, 0xF8,
  0x0F, 0x8F, 0x83, 0xE1, 0xF0, 0x7C, 0x1F, 0x1F, 0x03, 0xE3, 0xE0, 0x3E,
  0xF8, 0x07, 0xFF, 0x00, 0x7C, 0xF8, 0x00, 0xFB, 0xC0, 0x0F, 0x9F, 0x00,
  0x7C, 0xF8, 0x03, 0xE3, 0xC0, 0x1E, 0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0x87,
  0xC0, 0x78, 0x1E, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x1E, 0x0F,
  0x00, 0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x1E, 0x3C, 0x00, 0xF1, 0xE0, 0x07,
  0xDF, 0x00, 0x1E, 0xF8, 0x00, 0xF7, 0x80, 0x07, 0xBC, 0x00, 0x3F, 0xE0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x7F, 0xFE, 0xFF,
  0xFD, 0xFF, 0xFB, 0xFF, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7C,
  0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01,
  0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0,
  0x0F, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7E,
  0x01, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0xFE, 0x07, 0xF8, 0x0F,
  0xC0, 0x1F, 0xE0, 0x3F, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7F, 0x00, 0x7F, 0x80,
  0xFF, 0x00, 0x7E, 0x00, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0,
  0x1F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0x80, 0x1F,
  0x00, 0x7F, 0x00, 0xFF, 0x00, 0x7C, 0x07, 0xF0, 0x3F, 0xC1, 0xF0, 0x07,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0xFC, 0x0F,
  0xF0, 0x3F, 0x80, 0xFC, 0x03, 0x80, 0x00, 0x3F, 0x00, 0x3F, 0xFC, 0x0F,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0x7F, 0x80,
};

const GFXglyph NotoSans_Condensed_Medium48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 6, 35, 12, 3, -34 },
  { 28, 14, 12, 20, 3, -34 },
  { 49, 23, 34, 25, 1, -34 },
  { 147, 19, 39, 23, 2, -36 },
  { 240, 32, 35, 36, 2, -35 },
  { 380, 25, 35, 27, 2, -35 },
  { 490, 5, 12, 11, 3, -34 },
  { 498, 11, 42, 15, 2, -34 },
  { 556, 11, 42, 15, 1, -34 },
  { 614, 18, 19, 22, 2, -37 },
  { 657, 19, 22, 23, 2, -28 },
  { 710, 7, 12, 12, 2, -6 },
  { 721, 12, 4, 14, 1, -15 },
  { 727, 6, 7, 12, 3, -6 },
  { 733, 17, 34, 18, 1, -34 },
  { 806, 19, 35, 23, 2, -35 },
  { 890, 13, 34, 23, 3, -34 },
  { 946, 19, 35, 23, 2, -35 },
  { 1030, 19, 35, 23, 2, -35 },
  { 1114, 21, 34, 23, 1, -34 },
  { 1204, 19, 34, 23, 2, -34 },
  { 1285, 19, 35, 23, 2, -35 },
  { 1369, 20, 34, 23, 1, -34 },
  { 1454, 19, 35, 23, 2, -35 },
  { 1538, 19, 35, 23, 2, -35 },
  { 1622, 6, 27, 12, 3, -26 },
  { 1643, 7, 32, 12, 2, -26 },
  { 1671, 19, 22, 23, 2, -28 },
  { 1724, 19, 14, 23, 2, -24 },
  { 1758, 19, 22, 23, 2, -28 },
  { 1811, 17, 36, 18, 0, -35 },
  { 1888, 31, 39, 36, 2, -35 },
  { 2040, 25, 34, 25, 0, -34 },
  { 2147, 20, 34, 26, 4, -34 },
  { 2232, 21, 35, 24, 2, -35 },
  { 2324, 22, 34, 28, 4, -34 },
  { 2418, 15, 34, 22, 4, -34 },
  { 2482, 15, 34, 21, 4, -34 },
  { 2546, 24, 35, 29, 2, -35 },
  { 2651, 21, 34, 29, 4, -34 },
  { 2741, 11, 34, 15, 2, -34 },
  { 2788, 12, 44, 12, -3, -34 },
  { 2854, 21, 34, 25, 4, -34 },
  { 2944, 16, 34, 21, 4, -34 },
  { 3012, 30, 34, 38, 4, -34 },
  { 3140, 23, 34, 31, 4, -34 },
  { 3238, 26, 35, 30, 2, -35 },
  { 3352, 18, 34, 24, 4, -34 },
  { 3429, 26, 43, 30, 2, -35 },
  { 3569, 21, 34, 25, 4, -34 },
  { 3659, 18, 35, 22, 2, -35 },
  { 3738, 20, 34, 21, 1, -34 },
  { 3823, 22, 34, 29, 3, -34 },
  { 3917, 24, 34, 24, 0, -34 },
  { 4019, 38, 34, 38, 0, -34 },
  { 4181, 23, 34, 23, 0, -34 },
  { 4279, 22, 34, 22, 0, -34 },
  { 4373, 19, 34, 21, 1, -34 },
  { 4454, 11, 42, 15, 3, -34 },
  { 4512, 17, 34, 18, 1, -34 },
  { 4585, 11, 42, 15, 1, -34 },
  { 4643, 22, 20, 24, 1, -34 },
  { 4698, 21, 3, 21, 0, 4 },
  { 4706, 10, 8, 14, 2, -37 },
  { 4716, 18, 26, 23, 2, -26 },
  { 4775, 20, 36, 25, 3, -36 },
  { 4865, 16, 26, 19, 2, -26 },
  { 4917, 20, 36, 25, 2, -36 },
  { 5007, 19, 26, 23, 2, -26 },
  { 5069, 15, 37, 14, 1, -37 },
  { 5139, 20, 38, 25, 2, -26 },
  { 5234, 19, 36, 25, 3, -36 },
  { 5320, 5, 36, 11, 3, -36 },
  { 5343, 9, 48, 11, -1, -36 },
  { 5397, 19, 36, 22, 3, -36 },
  { 5483, 5, 36, 11, 3, -36 },
  { 5506, 31, 26, 37, 3, -26 },
  { 5607, 19, 26, 25, 3, -26 },
  { 5669, 20, 26, 24, 2, -26 },
  { 5734, 20, 38, 25, 3, -26 },
  { 5829, 20, 38, 25, 2, -26 },
  { 5924, 13, 26, 17, 3, -26 },
  { 5967, 15, 26, 19, 2, -26 },
  { 6016, 13, 32, 15, 1, -32 },
  { 6068, 19, 26, 25, 3, -26 },
  { 6130, 21, 26, 21, 0, -26 },
  { 6199, 32, 26, 33, 0, -26 },
  { 6303, 19, 26, 21, 1, -26 },
  { 6365, 21, 38, 21, 0, -26 },
  { 6465, 15, 26, 18, 1, -26 },
  { 6514, 15, 42, 18, 1, -34 },
  { 6593, 4, 48, 22, 9, -37 },
  { 6617, 14, 42, 18, 2, -34 },
  { 6691, 19, 6, 23, 2, -20 },
};

const GFXfont NotoSans_Condensed_Medium48pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Medium48pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Medium48pt7bGlyphs,
  0x20, 0x7E, 65
};

#endif // _NOTOSANS_CONDENSED_MEDIUM48PT7B_H_
