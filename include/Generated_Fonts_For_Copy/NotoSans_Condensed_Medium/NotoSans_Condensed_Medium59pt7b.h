#ifndef _NOTOSANS_CONDENSED_MEDIUM59PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUM59PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Medium.ttf
// Size: 59pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Medium59pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xF7, 0xEF,
  0xDF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9,
  0xF3, 0xE7, 0xCF, 0x80, 0x00, 0x00, 0x00, 0xE3, 0xEF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xF8, 0x40, 0xFE, 0x1F, 0xFF, 0x87, 0xF7, 0xE1, 0xF9, 0xF8, 0x3E,
  0x7C, 0x0F, 0x9F, 0x03, 0xE7, 0xC0, 0xF9, 0xF0, 0x3E, 0x7C, 0x0F, 0x9F,
  0x03, 0xE7, 0xC0, 0xF9, 0xF0, 0x3E, 0x7C, 0x0F, 0x9F, 0x03, 0xE7, 0xC0,
  0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x01, 0xE0, 0x7C, 0x00, 0x0F, 0x03, 0xE0,
  0x00, 0x78, 0x1E, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x3E, 0x07, 0x80, 0x01,
  0xF0, 0x3C, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x78, 0x1F, 0x00, 0x03, 0xC0,
  0xF8, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xF0, 0x3C, 0x03, 0xFF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x00,
  0xF0, 0x3E, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x7C, 0x0F, 0x00, 0x03, 0xE0,
  0x78, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0xF0, 0x3E, 0x00, 0x07, 0x81, 0xF0,
  0x00, 0x3C, 0x0F, 0x80, 0x01, 0xE0, 0x78, 0x07, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xF0, 0x0F, 0x03, 0xC0, 0x00, 0x78, 0x1E, 0x00, 0x07, 0xC0, 0xF0,
  0x00, 0x3E, 0x07, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x03, 0xE0, 0x00,
  0x78, 0x1F, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xF0,
  0x3C, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF1, 0xFC, 0xE1, 0xE7, 0xE1, 0xC0, 0x8F, 0xC3, 0x80, 0x1F,
  0x07, 0x00, 0x3E, 0x0E, 0x00, 0x7C, 0x1C, 0x00, 0xF8, 0x38, 0x01, 0xF8,
  0x70, 0x03, 0xF8, 0xE0, 0x03, 0xF9, 0xC0, 0x07, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0xE0, 0x01, 0xDF, 0xE0, 0x03, 0x9F, 0xC0, 0x07, 0x1F,
  0x80, 0x0E, 0x1F, 0x80, 0x1C, 0x3F, 0x00, 0x38, 0x7E, 0x00, 0x70, 0xFE,
  0x00, 0xE1, 0xF6, 0x01, 0xC7, 0xEF, 0x83, 0x9F, 0xDF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFC, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x3E, 0x00, 0x1F, 0xF8, 0x00, 0x3C, 0x00, 0x3F, 0xFC, 0x00, 0x7C, 0x00,
  0x3F, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x00, 0x7C, 0x3E,
  0x00, 0xF8, 0x00, 0x7C, 0x1E, 0x00, 0xF0, 0x00, 0x78, 0x1F, 0x01, 0xF0,
  0x00, 0xF8, 0x1F, 0x01, 0xE0, 0x00, 0xF8, 0x1F, 0x03, 0xE0, 0x00, 0xF8,
  0x1F, 0x03, 0xE0, 0x00, 0xF8, 0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x1F, 0x07,
  0xC0, 0x00, 0xF8, 0x1F, 0x07, 0x80, 0x00, 0xF8, 0x1F, 0x0F, 0x80, 0x00,
  0xF8, 0x1F, 0x0F, 0x80, 0x00, 0x78, 0x1F, 0x1F, 0x07, 0xC0, 0x78, 0x1F,
  0x1F, 0x1F, 0xF0, 0x7C, 0x1E, 0x3E, 0x3F, 0xF8, 0x7C, 0x3E, 0x3E, 0x3F,
  0xF8, 0x3C, 0x3E, 0x3C, 0x7E, 0xFC, 0x3F, 0xFC, 0x7C, 0x7C, 0x7C, 0x3F,
  0xFC, 0x7C, 0x78, 0x3E, 0x1F, 0xF8, 0xF8, 0xF8, 0x3E, 0x0F, 0xF0, 0xF8,
  0xF8, 0x3E, 0x03, 0xC0, 0xF0, 0xF8, 0x1E, 0x00, 0x01, 0xF0, 0xF8, 0x1E,
  0x00, 0x01, 0xE0, 0xF8, 0x1E, 0x00, 0x03, 0xE0, 0xF8, 0x1F, 0x00, 0x03,
  0xE0, 0xF8, 0x1F, 0x00, 0x07, 0xC0, 0xF8, 0x1F, 0x00, 0x07, 0xC0, 0xF8,
  0x1E, 0x00, 0x07, 0x80, 0xF8, 0x1E, 0x00, 0x0F, 0x80, 0xF8, 0x1E, 0x00,
  0x0F, 0x80, 0xF8, 0x3E, 0x00, 0x1F, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x00,
  0x78, 0x3E, 0x00, 0x1E, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0xFC,
  0x00, 0x3C, 0x00, 0x3F, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0xF0, 0x00, 0x7C,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00,
  0x1F, 0x81, 0xF8, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0x1F, 0x81, 0xF8, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x0F, 0x81, 0xF8, 0x00,
  0x0F, 0xC1, 0xF0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x07, 0xE7, 0xE0, 0x00,
  0x07, 0xEF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0xFC, 0x1F, 0xFF, 0x80, 0xFC, 0x3F, 0x9F, 0x80, 0xFC,
  0x3F, 0x1F, 0xC1, 0xF8, 0x7F, 0x0F, 0xE1, 0xF8, 0x7E, 0x07, 0xF1, 0xF8,
  0xFE, 0x03, 0xF3, 0xF0, 0xFC, 0x03, 0xFB, 0xF0, 0xFC, 0x01, 0xFF, 0xF0,
  0xFC, 0x00, 0xFF, 0xE0, 0xFC, 0x00, 0x7F, 0xE0, 0xFC, 0x00, 0x7F, 0xC0,
  0xFC, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x7F, 0xE0,
  0x7F, 0x81, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFB, 0xF8,
  0x1F, 0xFF, 0xF1, 0xFC, 0x0F, 0xFF, 0xC1, 0xFE, 0x03, 0xFF, 0x80, 0xFF,
  0x00, 0x30, 0x00, 0x00, 0xFF, 0xFD, 0xFB, 0xF7, 0xCF, 0x9F, 0x3E, 0x7C,
  0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0xF8, 0x07,
  0xC0, 0x7C, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x0F, 0xC0,
  0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x3F,
  0x00, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xFC,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x03,
  0xF0, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x0F,
  0xC0, 0x3E, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x01, 0xF0, 0x0F, 0x80, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0x80, 0x7C, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xE0,
  0x3E, 0x03, 0xF0, 0x1F, 0x01, 0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xC0, 0x7E,
  0x03, 0xE0, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x10, 0x1F, 0x01,
  0x3C, 0x3C, 0x1E, 0x7F, 0x79, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xF0, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x01,
  0xF7, 0xC0, 0x07, 0xCF, 0xC0, 0x1F, 0x8F, 0x80, 0x3E, 0x1F, 0x80, 0xFC,
  0x1F, 0x80, 0xF0, 0x3E, 0x00, 0xE0, 0x30, 0x00, 0x40, 0x40, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x1F,
  0x8F, 0xCF, 0xE7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7C, 0x7E, 0x3F, 0x1F, 0x0F,
  0x87, 0x87, 0xC3, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x39, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x30, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x07,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0x81, 0xF8, 0x3F,
  0x80, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x7E,
  0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E,
  0x00, 0x3E, 0x7E, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7E,
  0x00, 0x3F, 0x7E, 0x00, 0x3E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E,
  0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0xFC, 0x3F,
  0x00, 0xFC, 0x3F, 0x81, 0xFC, 0x1F, 0xC1, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0x3E, 0x00, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x7F, 0xE1,
  0xFF, 0xC7, 0xFF, 0x9F, 0xDF, 0x7F, 0x3F, 0xFC, 0x7F, 0xF0, 0xFB, 0xC1,
  0xF3, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x78, 0x00,
  0x07, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF8, 0x3E, 0x03, 0xFC, 0x38, 0x01, 0xFC, 0x10, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x00, 0x0F, 0xFF, 0x00,
  0x7F, 0xFF, 0x83, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x8F, 0xF9, 0xFF, 0x0F,
  0x00, 0x7F, 0x18, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x7F,
  0x80, 0x3F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF8,
  0x03, 0xFF, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xBF, 0xEF, 0xFE, 0x7F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0x0B, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xF0, 0x00, 0x1E, 0xFC, 0x00, 0x0F, 0xBF, 0x00, 0x03, 0xCF,
  0xC0, 0x01, 0xF3, 0xF0, 0x00, 0x78, 0xFC, 0x00, 0x3E, 0x3F, 0x00, 0x1F,
  0x0F, 0xC0, 0x07, 0xC3, 0xF0, 0x03, 0xE0, 0xFC, 0x00, 0xF8, 0x3F, 0x00,
  0x7C, 0x0F, 0xC0, 0x1F, 0x03, 0xF0, 0x0F, 0x80, 0xFC, 0x03, 0xE0, 0x3F,
  0x01, 0xF0, 0x0F, 0xC0, 0x7C, 0x03, 0xF0, 0x3E, 0x00, 0xFC, 0x1F, 0x80,
  0x3F, 0x07, 0xC0, 0x0F, 0xC3, 0xE0, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x02, 0x01, 0xFF, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF4, 0x00,
  0x1F, 0xCE, 0x00, 0x7F, 0x9F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x7F, 0xFF,
  0x01, 0xFF, 0xC6, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x1E, 0x01, 0xF1,
  0xFF, 0x83, 0xE7, 0xFF, 0x87, 0xDF, 0xFF, 0x8F, 0xBF, 0xFF, 0x9F, 0xF8,
  0xFF, 0x3F, 0xC0, 0x7F, 0x7F, 0x00, 0x7E, 0xFC, 0x00, 0xFD, 0xF8, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFD,
  0xF8, 0x03, 0xF3, 0xF0, 0x07, 0xE7, 0xF0, 0x1F, 0xC7, 0xF0, 0x7F, 0x07,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x00, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF8, 0x3F, 0xC3, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x7E,
  0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E,
  0x00, 0x7E, 0x3E, 0x00, 0x7E, 0x3F, 0x00, 0xFC, 0x3F, 0x81, 0xFC, 0x1F,
  0xC3, 0xF8, 0x0F, 0xE7, 0xF0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F,
  0xC7, 0xF8, 0x3F, 0x83, 0xFC, 0x3F, 0x01, 0xFC, 0x7E, 0x00, 0xFE, 0x7E,
  0x00, 0x7E, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x7E,
  0x00, 0x7E, 0x7F, 0x00, 0xFE, 0x3F, 0xC3, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0x00,
  0x38, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF0, 0x3F, 0xEF, 0xF8, 0x3F, 0x81, 0xF8, 0x7F, 0x01, 0xFC, 0x7E,
  0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7C, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC,
  0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3E, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x7E,
  0x00, 0xFF, 0x7F, 0x01, 0xFF, 0x3F, 0xC7, 0xFE, 0x3F, 0xFF, 0xBE, 0x1F,
  0xFF, 0xBE, 0x0F, 0xFF, 0x3E, 0x07, 0xFE, 0x3E, 0x00, 0xF0, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x3C, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x3F,
  0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0x40, 0x00, 0x7D,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x31, 0xFB, 0xFF, 0xFF,
  0xFF, 0xFF, 0xBE, 0x38, 0x1F, 0x1F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFC,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC7, 0xE7, 0xF3,
  0xF1, 0xF8, 0xFC, 0x7E, 0x3E, 0x3F, 0x1F, 0x8F, 0x87, 0xC3, 0xC3, 0xE1,
  0xF0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8,
  0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0xC1, 0xFF, 0xFC, 0x7F,
  0xFF, 0xCF, 0xFF, 0xFC, 0xFE, 0xFF, 0xDC, 0x03, 0xFA, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x00, 0x07,
  0xC1, 0xF0, 0x00, 0x00, 0x1F, 0x0F, 0x80, 0x1F, 0xE0, 0x3C, 0x3E, 0x01,
  0xFF, 0xE0, 0xF8, 0xF0, 0x1F, 0xFF, 0x83, 0xE7, 0xC0, 0x7F, 0xFE, 0x07,
  0x9F, 0x03, 0xF0, 0xF8, 0x1E, 0x78, 0x1F, 0x83, 0xE0, 0x7D, 0xE0, 0x7C,
  0x0F, 0x81, 0xFF, 0x81, 0xE0, 0x3E, 0x07, 0xFE, 0x0F, 0x80, 0xF8, 0x1F,
  0xF8, 0x3E, 0x03, 0xE0, 0x7F, 0xE0, 0xF8, 0x0F, 0x81, 0xFF, 0x83, 0xE0,
  0x3E, 0x07, 0xFC, 0x0F, 0x80, 0xF8, 0x1F, 0xF0, 0x3E, 0x03, 0xE0, 0x7F,
  0xC0, 0xF8, 0x0F, 0x81, 0xFF, 0x03, 0xE0, 0x3E, 0x07, 0xBE, 0x0F, 0x81,
  0xF8, 0x1E, 0xF8, 0x3E, 0x07, 0xE0, 0xFB, 0xE0, 0xF8, 0x1F, 0x83, 0xCF,
  0x81, 0xF0, 0xEE, 0x1F, 0x3E, 0x07, 0xFF, 0xBF, 0xFC, 0x78, 0x0F, 0xFE,
  0x7F, 0xE1, 0xF0, 0x1F, 0xF1, 0xFF, 0x07, 0xC0, 0x3F, 0x83, 0xF8, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xE0, 0x00, 0x3F, 0xE0, 0x1F,
  0x80, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x0F, 0xBE, 0x00,
  0x00, 0x1F, 0x7C, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0xFD, 0xF8, 0x00,
  0x01, 0xF1, 0xF0, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x0F, 0xC7, 0xE0, 0x00,
  0x1F, 0x8F, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0xFC, 0x1F, 0x80, 0x01,
  0xF8, 0x3F, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x1F,
  0x80, 0xFC, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x01, 0xF8,
  0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x07, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x01,
  0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x7F, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x07,
  0xE1, 0xF8, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x3F,
  0x9F, 0x80, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0xFC, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFC, 0x03, 0xFE, 0xFC, 0x00,
  0xFE, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00,
  0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00,
  0x7E, 0xFC, 0x00, 0xFC, 0xFC, 0x01, 0xFC, 0xFC, 0x1F, 0xF8, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFC, 0xFC, 0x01, 0xFE, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0xFE, 0xFC, 0x03, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0x00, 0x70, 0x7F, 0x80, 0x04,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x83, 0xFE,
  0x00, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x0E, 0x00, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xC1, 0xF8, 0x0F, 0xFC, 0x3F, 0x00, 0x7F, 0x87, 0xE0, 0x07, 0xF8,
  0xFC, 0x00, 0x7F, 0x9F, 0x80, 0x07, 0xF3, 0xF0, 0x00, 0x7E, 0x7E, 0x00,
  0x0F, 0xEF, 0xC0, 0x01, 0xFD, 0xF8, 0x00, 0x1F, 0xBF, 0x00, 0x03, 0xF7,
  0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00,
  0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01,
  0xFB, 0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFD, 0xF8,
  0x00, 0x3F, 0xBF, 0x00, 0x07, 0xE7, 0xE0, 0x01, 0xFC, 0xFC, 0x00, 0x3F,
  0x9F, 0x80, 0x0F, 0xE3, 0xF0, 0x03, 0xFC, 0x7E, 0x00, 0xFF, 0x0F, 0xC0,
  0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF,
  0xFF, 0xF7, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0xFF, 0xEF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFE, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xF8, 0x3F, 0xF0, 0x07, 0x81, 0xFE, 0x00, 0x04, 0x1F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x1F,
  0xBF, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x3F, 0x3F,
  0x00, 0x01, 0xF9, 0xFC, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x7E, 0x3F, 0x80,
  0x03, 0xF1, 0xFE, 0x00, 0x1F, 0x87, 0xFC, 0x00, 0xFC, 0x1F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0x0F, 0xE0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0xFE, 0xFF, 0xF3, 0xFF, 0xCF, 0xFE, 0x3F, 0xF0, 0xFF, 0x81, 0xE0,
  0x00, 0xFC, 0x00, 0x3F, 0xBF, 0x00, 0x0F, 0xCF, 0xC0, 0x07, 0xF3, 0xF0,
  0x03, 0xF8, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x7F, 0x0F, 0xC0, 0x3F, 0x83,
  0xF0, 0x0F, 0xC0, 0xFC, 0x07, 0xF0, 0x3F, 0x03, 0xF8, 0x0F, 0xC0, 0xFC,
  0x03, 0xF0, 0x7F, 0x00, 0xFC, 0x3F, 0x80, 0x3F, 0x0F, 0xC0, 0x0F, 0xC7,
  0xF0, 0x03, 0xF1, 0xF8, 0x00, 0xFC, 0xFC, 0x00, 0x3F, 0x7F, 0x00, 0x0F,
  0xDF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80,
  0x0F, 0xFF, 0xE0, 0x03, 0xFD, 0xFC, 0x00, 0xFE, 0x3F, 0x00, 0x3F, 0x0F,
  0xE0, 0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0x7F, 0x00, 0xFC, 0x0F, 0xC0, 0x3F,
  0x03, 0xF8, 0x0F, 0xC0, 0x7F, 0x03, 0xF0, 0x1F, 0xC0, 0xFC, 0x03, 0xF8,
  0x3F, 0x00, 0xFE, 0x0F, 0xC0, 0x1F, 0xC3, 0xF0, 0x07, 0xF0, 0xFC, 0x00,
  0xFE, 0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xF3, 0xF0, 0x00, 0xFC, 0xFC,
  0x00, 0x3F, 0xBF, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xDF, 0x00, 0x01, 0xFF, 0xFE, 0xF8, 0x00, 0x1F,
  0x7F, 0xF7, 0xE0, 0x00, 0xFB, 0xFF, 0x9F, 0x00, 0x07, 0xDF, 0xFC, 0xF8,
  0x00, 0x7C, 0xFF, 0xE7, 0xE0, 0x03, 0xE7, 0xFF, 0x1F, 0x00, 0x1F, 0x3F,
  0xF8, 0xF8, 0x01, 0xF1, 0xFF, 0xC7, 0xC0, 0x0F, 0x8F, 0xFE, 0x3F, 0x00,
  0x7C, 0x7F, 0xF0, 0xF8, 0x07, 0xE3, 0xFF, 0x87, 0xC0, 0x3E, 0x1F, 0xFC,
  0x3F, 0x01, 0xF0, 0xFF, 0xE0, 0xF8, 0x0F, 0x87, 0xFF, 0x07, 0xC0, 0xF8,
  0x3F, 0xF8, 0x3F, 0x07, 0xC1, 0xFF, 0xC0, 0xF8, 0x3E, 0x0F, 0xFE, 0x07,
  0xC3, 0xE0, 0x7F, 0xF0, 0x3E, 0x1F, 0x03, 0xFF, 0x81, 0xF8, 0xF8, 0x1F,
  0xFC, 0x07, 0xCF, 0x80, 0xFF, 0xE0, 0x3E, 0x7C, 0x07, 0xFF, 0x01, 0xFB,
  0xE0, 0x3F, 0xF8, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xC0,
  0x1F, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xF0, 0x07, 0xFF, 0x00,
  0x3F, 0x00, 0x3F, 0xF8, 0x01, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0,
  0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x1F,
  0xFB, 0xF0, 0x01, 0xFF, 0xBF, 0x80, 0x1F, 0xF9, 0xF8, 0x01, 0xFF, 0x9F,
  0x80, 0x1F, 0xF8, 0xFC, 0x01, 0xFF, 0x8F, 0xC0, 0x1F, 0xF8, 0x7E, 0x01,
  0xFF, 0x87, 0xE0, 0x1F, 0xF8, 0x3F, 0x01, 0xFF, 0x83, 0xF0, 0x1F, 0xF8,
  0x1F, 0x81, 0xFF, 0x81, 0xF8, 0x1F, 0xF8, 0x0F, 0xC1, 0xFF, 0x80, 0xFC,
  0x1F, 0xF8, 0x07, 0xE1, 0xFF, 0x80, 0x7E, 0x1F, 0xF8, 0x03, 0xF1, 0xFF,
  0x80, 0x3F, 0x1F, 0xF8, 0x01, 0xF9, 0xFF, 0x80, 0x1F, 0x9F, 0xF8, 0x00,
  0xFD, 0xFF, 0x80, 0x0F, 0xDF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80,
  0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x7F, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFC, 0x07, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x03, 0xF8, 0x3F,
  0x80, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x07, 0xE3, 0xF8,
  0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x1F, 0x9F, 0x80,
  0x00, 0x3F, 0x7F, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x1F,
  0x9F, 0x80, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x7E, 0x7F, 0x00, 0x01, 0xFC,
  0x7E, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0x81,
  0xFE, 0x00, 0x7F, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x2A, 0x00, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x1F, 0x81, 0xFF,
  0x3F, 0x00, 0xFF, 0x7E, 0x00, 0xFE, 0xFC, 0x00, 0xFD, 0xF8, 0x01, 0xFB,
  0xF0, 0x03, 0xF7, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF,
  0x00, 0x3F, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0xFD, 0xF8, 0x03, 0xFB, 0xF0,
  0x07, 0xF7, 0xE0, 0x1F, 0xCF, 0xC1, 0xFF, 0x9F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x01, 0xFF, 0xF8, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x0F,
  0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF0, 0xFC,
  0x00, 0x07, 0xE3, 0xF8, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x0F, 0xCF, 0xC0,
  0x00, 0x1F, 0x9F, 0x80, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x0F,
  0xEF, 0xC0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x7E,
  0x7F, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x0F, 0xE0,
  0xFE, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x7F, 0x01, 0xFE, 0x03, 0xFC, 0x03,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0x87, 0xE0, 0x7F, 0xC3, 0xF0, 0x0F, 0xF1, 0xF8, 0x03, 0xF8, 0xFC,
  0x00, 0xFC, 0x7E, 0x00, 0x7F, 0x3F, 0x00, 0x3F, 0x9F, 0x80, 0x1F, 0xCF,
  0xC0, 0x0F, 0xE7, 0xE0, 0x07, 0xF3, 0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xF8,
  0xFC, 0x00, 0xFC, 0x7E, 0x00, 0xFE, 0x3F, 0x00, 0xFE, 0x1F, 0x81, 0xFF,
  0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x00, 0x7E, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x81,
  0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x81, 0xF8,
  0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x1F,
  0x80, 0x3F, 0x8F, 0xC0, 0x0F, 0xC7, 0xE0, 0x07, 0xF3, 0xF0, 0x01, 0xFD,
  0xF8, 0x00, 0xFE, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x00, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0x0F, 0xE0, 0x1E, 0x3F, 0x80, 0x0C, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F,
  0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF4, 0x00, 0x07, 0xEE, 0x00, 0x1F, 0xDF, 0x80, 0xFF, 0x3F,
  0xFF, 0xFE, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x80, 0x7F,
  0xFC, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF,
  0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00,
  0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F,
  0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xEF, 0xC0, 0x01, 0xF9,
  0xFC, 0x00, 0x3F, 0x1F, 0xC0, 0x0F, 0xE3, 0xFC, 0x07, 0xF8, 0x3F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x30, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x07, 0xE7, 0xE0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x7E, 0x7E, 0x00,
  0x01, 0xF8, 0xFC, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x00,
  0xFC, 0x3F, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x7E,
  0x07, 0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0x3F, 0x00, 0x3F, 0x00,
  0xFC, 0x00, 0xFC, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x1F,
  0x80, 0x7E, 0x00, 0x7E, 0x01, 0xF8, 0x01, 0xF8, 0x07, 0xC0, 0x03, 0xE0,
  0x3F, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0xFC, 0x0F,
  0x80, 0x01, 0xF0, 0x7E, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x1F, 0x87, 0xE0,
  0x00, 0x3E, 0x1F, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x03, 0xF3, 0xF0, 0x00,
  0x0F, 0xCF, 0x80, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF3, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE7, 0xE0, 0x01, 0xFE,
  0x00, 0x1F, 0xCF, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xFC,
  0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0xF0,
  0x01, 0xF8, 0x7E, 0x00, 0x7F, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0xFB, 0xE0,
  0x0F, 0xC0, 0xFC, 0x01, 0xF7, 0xC0, 0x1F, 0x81, 0xF8, 0x03, 0xEF, 0x80,
  0x3F, 0x03, 0xF0, 0x0F, 0x9F, 0x00, 0x7E, 0x07, 0xE0, 0x1F, 0x3E, 0x01,
  0xF8, 0x07, 0xC0, 0x3E, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x7C, 0x7C, 0x07,
  0xE0, 0x1F, 0x80, 0xF8, 0xF8, 0x0F, 0xC0, 0x3F, 0x03, 0xE1, 0xF0, 0x1F,
  0x00, 0x7E, 0x07, 0xC3, 0xF0, 0x7E, 0x00, 0x7C, 0x0F, 0x83, 0xE0, 0xFC,
  0x00, 0xFC, 0x1F, 0x07, 0xC1, 0xF8, 0x01, 0xF8, 0x7E, 0x0F, 0x83, 0xF0,
  0x03, 0xF0, 0xF8, 0x1F, 0x0F, 0xC0, 0x03, 0xE1, 0xF0, 0x1F, 0x1F, 0x80,
  0x07, 0xE3, 0xE0, 0x3E, 0x3F, 0x00, 0x0F, 0xCF, 0xC0, 0x7C, 0x7E, 0x00,
  0x1F, 0x9F, 0x00, 0xF8, 0xF8, 0x00, 0x3F, 0x3E, 0x01, 0xF3, 0xF0, 0x00,
  0x3E, 0x7C, 0x01, 0xF7, 0xE0, 0x00, 0x7C, 0xF8, 0x03, 0xEF, 0xC0, 0x00,
  0xFD, 0xF0, 0x07, 0xDF, 0x80, 0x01, 0xFF, 0xC0, 0x0F, 0xBE, 0x00, 0x01,
  0xFF, 0x80, 0x0F, 0x7C, 0x00, 0x03, 0xFF, 0x00, 0x1E, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0xFE, 0x3F,
  0x80, 0x0F, 0xC1, 0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x1F, 0x80, 0xFC, 0x03,
  0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x00,
  0x3F, 0x07, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xF9,
  0xF8, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0xFD, 0xF8, 0x00, 0x1F, 0x9F, 0x80, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x0F,
  0xC0, 0x03, 0xF0, 0xFE, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00,
  0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xFC, 0x01, 0xF8, 0x1F, 0x80,
  0x1F, 0x83, 0xF8, 0x01, 0xFC, 0x3F, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0xFE,
  0x7E, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xF7, 0xE0,
  0x00, 0x7E, 0x7E, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x1F,
  0xC3, 0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x1F, 0x81, 0xF8, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0x7E, 0x00, 0x7E, 0x07,
  0xE0, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0xF8, 0x00,
  0x3F, 0x1F, 0x80, 0x01, 0xF9, 0xF8, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0xFB,
  0xE0, 0x00, 0x3E, 0x3E, 0x00, 0x07, 0xC7, 0xC0, 0x01, 0xF0, 0x7C, 0x00,
  0x3E, 0x0F, 0x80, 0x0F, 0xC0, 0xF8, 0x01, 0xF0, 0x1F, 0x00, 0x7E, 0x01,
  0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x0F,
  0x80, 0x07, 0xC3, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x9F, 0x00, 0x01,
  0xF7, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x00,
  0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xFF, 0x80, 0x3F,
  0xFF, 0x81, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xC7, 0xF8, 0x30, 0x07,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x07, 0xFF, 0xF0, 0x7F,
  0xFF, 0xC7, 0xFF, 0xFF, 0x3F, 0xFF, 0xFD, 0xFE, 0x03, 0xF7, 0xF0, 0x0F,
  0xDF, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF8, 0x07, 0xF7, 0xE0, 0x3F, 0xDF, 0xC3,
  0xFF, 0x7F, 0xFF, 0x7C, 0xFF, 0xF9, 0xF1, 0xFF, 0xC7, 0xC3, 0xFE, 0x0F,
  0x01, 0x80, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x3F, 0xC0, 0xFC, 0xFF, 0xE0,
  0xFD, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0x81, 0xFC,
  0xFF, 0x00, 0xFE, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFC, 0x00, 0x7E,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFF, 0x00, 0xFE,
  0xFF, 0x81, 0xFC, 0xFF, 0xE3, 0xFC, 0xFB, 0xFF, 0xF8, 0xF9, 0xFF, 0xF0,
  0xF8, 0xFF, 0xE0, 0xF8, 0x7F, 0xC0, 0x00, 0x04, 0x00, 0x01, 0xFF, 0xC0,
  0xFF, 0xFC, 0x3F, 0xFF, 0x8F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0x01, 0x9F,
  0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x01, 0xFE,
  0x01, 0x9F, 0xFB, 0xF1, 0xFF, 0xFE, 0x1F, 0xFF, 0xC1, 0xFF, 0xF8, 0x1F,
  0xFC, 0x00, 0x18, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x03, 0xFC, 0x3F, 0x0F, 0xFE,
  0x3F, 0x1F, 0xFF, 0x3F, 0x1F, 0xFF, 0xBF, 0x3F, 0xFF, 0xFF, 0x7F, 0x81,
  0xFF, 0x7F, 0x00, 0xFF, 0x7E, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x7E, 0x00,
  0xFF, 0x7F, 0x01, 0xFF, 0x3F, 0xC7, 0xFF, 0x3F, 0xFF, 0xBF, 0x1F, 0xFF,
  0xBF, 0x0F, 0xFF, 0x1F, 0x07, 0xFC, 0x1F, 0x00, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0xC7, 0xF0,
  0xFC, 0x07, 0xE7, 0xE0, 0x1F, 0x9F, 0x80, 0x3F, 0x7C, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x01,
  0x8F, 0xF8, 0x3E, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80,
  0x7F, 0xF8, 0x00, 0x1E, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0xF0, 0x3F, 0xFC,
  0x1F, 0xFE, 0x07, 0xFF, 0x81, 0xF8, 0x20, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xFF,
  0xC7, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0xC0, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xFC, 0x1F, 0x0F, 0xFE, 0x3F, 0x1F, 0xFF, 0x3F, 0x1F, 0xFF, 0xBF, 0x3F,
  0xFF, 0xFF, 0x7F, 0x81, 0xFF, 0x7F, 0x00, 0xFF, 0x7E, 0x00, 0xFF, 0xFE,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0x7E,
  0x00, 0x7F, 0x7E, 0x00, 0xFF, 0x7F, 0x01, 0xFF, 0x3F, 0xC7, 0xFF, 0x3F,
  0xFF, 0xBF, 0x1F, 0xFF, 0x3F, 0x0F, 0xFF, 0x3F, 0x07, 0xFC, 0x3F, 0x00,
  0x60, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x60, 0x01, 0xFC, 0x78,
  0x03, 0xFC, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xC0, 0x07, 0xFF, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x87, 0xF8, 0x3F, 0x3F, 0xF8,
  0x7E, 0xFF, 0xF8, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFB, 0xFE, 0x07, 0xF7,
  0xF8, 0x07, 0xEF, 0xE0, 0x0F, 0xDF, 0xC0, 0x1F, 0xBF, 0x80, 0x1F, 0xFE,
  0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0x07, 0xE0, 0x7B, 0xFF, 0xFF, 0xFF, 0xF7, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x01, 0xE0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x7F, 0x07, 0xEF, 0xFE, 0xFF, 0xEF, 0xFC,
  0xFF, 0x8F, 0xF0, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x1F, 0xFF, 0x00, 0x7F, 0x7E, 0x00,
  0xFC, 0xFC, 0x03, 0xF1, 0xF8, 0x0F, 0xC3, 0xF0, 0x3F, 0x87, 0xE0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x1F, 0x87, 0xE0, 0x3F, 0x0F, 0xC0, 0x7E, 0x3F, 0x00,
  0xFC, 0xFC, 0x01, 0xF9, 0xF8, 0x03, 0xF7, 0xE0, 0x07, 0xFF, 0xE0, 0x0F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0x9F, 0x80, 0xFE,
  0x3F, 0x81, 0xF8, 0x3F, 0x03, 0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x0F, 0xC0,
  0xFE, 0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xFC, 0x7E, 0x01, 0xF8, 0xFC, 0x03,
  0xF9, 0xF8, 0x03, 0xF3, 0xF0, 0x07, 0xF7, 0xE0, 0x07, 0xEF, 0xC0, 0x07,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8,
  0x7F, 0xC0, 0x7F, 0xC3, 0xE3, 0xFF, 0x83, 0xFF, 0x8F, 0x9F, 0xFF, 0x1F,
  0xFF, 0x3E, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFE,
  0x0F, 0xFE, 0x0F, 0xEF, 0xF0, 0x1F, 0xF0, 0x1F, 0xBF, 0x80, 0x7F, 0x80,
  0x7F, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0x00, 0x3F, 0xFC, 0x00, 0xFC, 0x00,
  0xFF, 0xF0, 0x03, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xC0, 0x0F, 0xFF, 0x00,
  0x3F, 0x00, 0x3F, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0x00, 0x3F, 0xFC, 0x00,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xC0, 0x0F,
  0xFF, 0x00, 0x3F, 0x00, 0x3F, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0x00, 0x3F,
  0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xF0, 0x03, 0xFF, 0xC0, 0x0F,
  0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0x00, 0x3F, 0xF8, 0x3F, 0xC1, 0xF1, 0xFF,
  0xE3, 0xE7, 0xFF, 0xC7, 0xDF, 0xFF, 0xCF, 0xFF, 0xFF, 0xDF, 0xF0, 0x3F,
  0xBF, 0xC0, 0x3F, 0x7F, 0x00, 0x7E, 0xFE, 0x00, 0xFD, 0xF8, 0x00, 0xFF,
  0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF,
  0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0x3F, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0x81, 0xFC, 0x7F, 0x00, 0xFC,
  0x7E, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7E,
  0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7F, 0x00, 0xFC, 0x3F, 0x01, 0xFC,
  0x3F, 0xE7, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0,
  0x01, 0xFF, 0x80, 0x00, 0x1C, 0x00, 0xF8, 0x3F, 0xC0, 0xF8, 0xFF, 0xE0,
  0xF9, 0xFF, 0xF0, 0xFB, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0x81, 0xFC,
  0xFF, 0x00, 0xFE, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFC, 0x00, 0x7E,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFF, 0x00, 0xFE,
  0xFF, 0x81, 0xFC, 0xFF, 0xF7, 0xFC, 0xFF, 0xFF, 0xF8, 0xFD, 0xFF, 0xF0,
  0xFC, 0xFF, 0xE0, 0xFC, 0x7F, 0xC0, 0xFC, 0x04, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xFC, 0x1F, 0x0F, 0xFE, 0x3F, 0x1F, 0xFF, 0x3F, 0x1F, 0xFF, 0xBF,
  0x3F, 0xFF, 0xFF, 0x7F, 0x81, 0xFF, 0x7F, 0x00, 0xFF, 0x7E, 0x00, 0xFF,
  0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0x7E, 0x00, 0x7F, 0x7E, 0x00, 0xFF, 0x7F, 0x01, 0xFF, 0x3F, 0xCF, 0xFF,
  0x3F, 0xFF, 0xBF, 0x1F, 0xFF, 0x3F, 0x0F, 0xFF, 0x3F, 0x07, 0xFC, 0x3F,
  0x00, 0x60, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0xFF, 0xF8, 0xFF,
  0xF9, 0xFF, 0xFB, 0xFE, 0xFB, 0xF6, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x07, 0xFF,
  0x03, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xF8, 0xFC, 0xFC, 0x03,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xF0,
  0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0xFF,
  0x80, 0x3F, 0xFF, 0x3F, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x3F, 0xFF, 0xC1,
  0xFF, 0xE0, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xF3, 0x0F, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x01, 0xFF, 0x00,
  0x38, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F,
  0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC,
  0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F,
  0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF8, 0x07,
  0xF7, 0xE0, 0x3F, 0xDF, 0xFF, 0xFF, 0x7F, 0xFF, 0x7C, 0xFF, 0xFD, 0xF1,
  0xFF, 0xE3, 0xC3, 0xFE, 0x0F, 0x00, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xBF,
  0x00, 0x0F, 0xDF, 0x80, 0x07, 0xEF, 0xC0, 0x07, 0xE7, 0xE0, 0x03, 0xF1,
  0xF8, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x1F, 0x00, 0x7E,
  0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x0F,
  0xC0, 0x7E, 0x07, 0xC0, 0x3F, 0x07, 0xE0, 0x0F, 0x83, 0xF0, 0x07, 0xC1,
  0xF8, 0x03, 0xF0, 0xF8, 0x00, 0xF8, 0xFC, 0x00, 0x7C, 0x7E, 0x00, 0x3F,
  0x3E, 0x00, 0x1F, 0x9F, 0x00, 0x07, 0xDF, 0x80, 0x03, 0xEF, 0x80, 0x01,
  0xF7, 0xC0, 0x00, 0x7B, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0xF8, 0x00, 0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xFC, 0x00, 0xFB, 0xF0, 0x07,
  0xF8, 0x03, 0xF7, 0xE0, 0x0F, 0xF0, 0x07, 0xE7, 0xC0, 0x1F, 0xE0, 0x0F,
  0xCF, 0xC0, 0x3F, 0xE0, 0x1F, 0x1F, 0x80, 0xFF, 0xC0, 0x7E, 0x3F, 0x01,
  0xFF, 0x80, 0xFC, 0x7E, 0x03, 0xEF, 0x01, 0xF8, 0x7C, 0x07, 0x9E, 0x03,
  0xE0, 0xFC, 0x1F, 0x3E, 0x07, 0xC1, 0xF8, 0x3E, 0x7C, 0x1F, 0x83, 0xF0,
  0x7C, 0xF8, 0x3F, 0x03, 0xE0, 0xF8, 0xF0, 0x7C, 0x07, 0xE1, 0xE1, 0xF0,
  0xF8, 0x0F, 0xC7, 0xC3, 0xE3, 0xF0, 0x1F, 0x8F, 0x87, 0xC7, 0xE0, 0x1F,
  0x1F, 0x0F, 0x8F, 0xC0, 0x3E, 0x3C, 0x0F, 0x1F, 0x00, 0x7C, 0x78, 0x1F,
  0x3E, 0x00, 0xFD, 0xF0, 0x3E, 0xFC, 0x00, 0xFB, 0xE0, 0x7D, 0xF8, 0x01,
  0xF7, 0xC0, 0xFB, 0xE0, 0x03, 0xEF, 0x00, 0xF7, 0xC0, 0x07, 0xDE, 0x01,
  0xEF, 0x80, 0x0F, 0xBC, 0x03, 0xDF, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00,
  0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0xFE, 0x00, 0x7F, 0x7E, 0x00, 0x7E, 0x7F, 0x00, 0xFC, 0x3F, 0x00, 0xFC,
  0x3F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x0F, 0xC3, 0xF0, 0x0F, 0xC3, 0xF0,
  0x07, 0xE7, 0xE0, 0x07, 0xE7, 0xE0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x07, 0xEF, 0xC0, 0x07, 0xE7, 0xE0, 0x0F, 0xC7, 0xE0,
  0x0F, 0xC3, 0xF0, 0x1F, 0x83, 0xF0, 0x1F, 0x81, 0xF8, 0x3F, 0x01, 0xFC,
  0x3F, 0x00, 0xFC, 0x7E, 0x00, 0xFE, 0xFE, 0x00, 0x7E, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xDF, 0x80, 0x07, 0xEF, 0xC0, 0x07,
  0xE3, 0xE0, 0x03, 0xF1, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x7E, 0x00,
  0xFC, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x01, 0xF0,
  0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0x7E, 0x07, 0xC0, 0x1F, 0x07, 0xE0, 0x0F,
  0xC3, 0xF0, 0x07, 0xE1, 0xF8, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0xFC, 0x00,
  0x7E, 0x7E, 0x00, 0x3F, 0x3E, 0x00, 0x0F, 0x9F, 0x00, 0x07, 0xDF, 0x80,
  0x03, 0xEF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F,
  0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xC0,
  0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07,
  0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xE0,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F,
  0x81, 0xFF, 0x80, 0xFF, 0x80, 0x7E, 0x00, 0x3F, 0xC0, 0x1F, 0xF8, 0x01,
  0xFE, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0xC0, 0x07, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x07,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFC, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x07, 0xFF, 0x00, 0x7F, 0xC0, 0x03,
  0xF0, 0x07, 0xFC, 0x03, 0xFF, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x03, 0xFE, 0x03,
  0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xC0, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x01,
  0x3F, 0xF0, 0x01, 0x7F, 0xFC, 0x03, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xC0, 0x1F, 0xFE, 0x80, 0x03, 0xF8,
};

const GFXglyph NotoSans_Condensed_Medium59pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 7, 43, 15, 4, -42 },
  { 39, 18, 15, 24, 3, -42 },
  { 73, 29, 42, 31, 1, -42 },
  { 226, 23, 48, 28, 3, -45 },
  { 364, 40, 44, 44, 2, -43 },
  { 584, 32, 44, 34, 2, -43 },
  { 760, 7, 15, 13, 3, -42 },
  { 774, 13, 51, 18, 3, -42 },
  { 857, 13, 51, 18, 2, -42 },
  { 940, 23, 23, 27, 2, -45 },
  { 1007, 24, 28, 28, 2, -35 },
  { 1091, 9, 15, 14, 2, -7 },
  { 1108, 14, 6, 17, 2, -19 },
  { 1119, 7, 9, 15, 4, -8 },
  { 1127, 21, 42, 23, 1, -42 },
  { 1238, 24, 44, 28, 2, -43 },
  { 1370, 15, 42, 28, 4, -42 },
  { 1449, 24, 43, 28, 2, -43 },
  { 1578, 23, 44, 28, 2, -43 },
  { 1705, 26, 42, 28, 1, -42 },
  { 1842, 23, 43, 28, 3, -42 },
  { 1966, 23, 44, 28, 3, -43 },
  { 2093, 24, 42, 28, 2, -42 },
  { 2219, 24, 44, 28, 2, -43 },
  { 2351, 24, 44, 28, 2, -43 },
  { 2483, 7, 33, 15, 4, -32 },
  { 2512, 9, 40, 15, 2, -32 },
  { 2557, 24, 28, 28, 2, -35 },
  { 2641, 24, 17, 28, 2, -29 },
  { 2692, 24, 28, 28, 2, -35 },
  { 2776, 19, 44, 22, 1, -43 },
  { 2881, 38, 47, 44, 3, -42 },
  { 3105, 31, 42, 31, 0, -42 },
  { 3268, 24, 42, 32, 5, -42 },
  { 3394, 26, 44, 30, 3, -43 },
  { 3537, 27, 42, 35, 5, -42 },
  { 3679, 19, 42, 27, 5, -42 },
  { 3779, 19, 42, 26, 5, -42 },
  { 3879, 29, 44, 36, 3, -43 },
  { 4039, 26, 42, 36, 5, -42 },
  { 4176, 14, 42, 18, 2, -42 },
  { 4250, 14, 54, 15, -3, -42 },
  { 4345, 26, 42, 31, 5, -42 },
  { 4482, 19, 42, 25, 5, -42 },
  { 4582, 37, 42, 47, 5, -42 },
  { 4777, 28, 42, 38, 5, -42 },
  { 4924, 31, 44, 37, 3, -43 },
  { 5095, 23, 42, 30, 5, -42 },
  { 5216, 31, 53, 37, 3, -43 },
  { 5422, 25, 42, 31, 5, -42 },
  { 5554, 23, 44, 27, 2, -43 },
  { 5681, 25, 42, 26, 1, -42 },
  { 5813, 27, 43, 35, 4, -42 },
  { 5959, 30, 42, 30, 0, -42 },
  { 6117, 47, 42, 47, 0, -42 },
  { 6364, 28, 42, 28, 0, -42 },
  { 6511, 28, 42, 28, 0, -42 },
  { 6658, 22, 42, 26, 2, -42 },
  { 6774, 13, 51, 19, 4, -42 },
  { 6857, 21, 42, 23, 1, -42 },
  { 6968, 13, 51, 19, 2, -42 },
  { 7051, 27, 24, 29, 1, -42 },
  { 7132, 25, 4, 25, 0, 5 },
  { 7145, 13, 9, 17, 2, -45 },
  { 7160, 22, 33, 28, 2, -32 },
  { 7251, 24, 46, 31, 4, -45 },
  { 7389, 19, 33, 24, 3, -32 },
  { 7468, 24, 46, 31, 3, -45 },
  { 7606, 22, 33, 28, 3, -32 },
  { 7697, 18, 45, 17, 1, -45 },
  { 7799, 24, 46, 31, 3, -32 },
  { 7937, 23, 45, 31, 4, -45 },
  { 8067, 6, 44, 14, 4, -44 },
  { 8100, 12, 58, 14, -2, -44 },
  { 8187, 23, 45, 27, 4, -45 },
  { 8317, 6, 45, 14, 4, -45 },
  { 8351, 38, 32, 46, 4, -32 },
  { 8503, 23, 32, 31, 4, -32 },
  { 8595, 24, 33, 30, 3, -32 },
  { 8694, 24, 46, 31, 4, -32 },
  { 8832, 24, 46, 31, 3, -32 },
  { 8970, 16, 32, 21, 4, -32 },
  { 9034, 19, 33, 23, 2, -32 },
  { 9113, 16, 40, 18, 1, -39 },
  { 9193, 22, 33, 31, 4, -32 },
  { 9284, 25, 32, 25, 0, -32 },
  { 9384, 39, 32, 40, 1, -32 },
  { 9540, 24, 32, 26, 1, -32 },
  { 9636, 25, 46, 26, 0, -32 },
  { 9780, 18, 32, 22, 2, -32 },
  { 9852, 17, 51, 22, 2, -42 },
  { 9961, 5, 59, 27, 11, -45 },
  { 9998, 18, 51, 22, 2, -42 },
  { 10113, 24, 8, 28, 2, -25 },
};

const GFXfont NotoSans_Condensed_Medium59pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Medium59pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Medium59pt7bGlyphs,
  0x20, 0x7E, 80
};

#endif // _NOTOSANS_CONDENSED_MEDIUM59PT7B_H_
