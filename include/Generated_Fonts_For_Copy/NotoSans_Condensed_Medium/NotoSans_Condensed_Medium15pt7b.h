#ifndef _NOTOSANS_CONDENSED_MEDIUM15PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUM15PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Medium.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Medium15pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFA, 0x3C, 0x99, 0x99, 0x16, 0x14, 0x14, 0x7F, 0x24, 0x24,
  0x24, 0xFE, 0x28, 0x28, 0x48, 0x23, 0xEA, 0xA8, 0xE1, 0xC3, 0x8B, 0xAB,
  0xE2, 0x08, 0x62, 0x28, 0x8B, 0x42, 0xD0, 0xBD, 0x2A, 0xA6, 0xA8, 0x4B,
  0x12, 0xCC, 0xA2, 0x38, 0x70, 0xD8, 0xD8, 0xD8, 0x70, 0x60, 0xF6, 0x9E,
  0x8C, 0xCC, 0xF7, 0xF0, 0x29, 0x69, 0x24, 0x93, 0x26, 0xC6, 0x22, 0x33,
  0x33, 0x33, 0x26, 0xC0, 0x11, 0x5F, 0xCE, 0x6C, 0x20, 0x82, 0x3F, 0x20,
  0x82, 0x00, 0xFA, 0xFF, 0xF0, 0x0C, 0x21, 0x84, 0x10, 0xC2, 0x08, 0x61,
  0x0C, 0x00, 0x73, 0x68, 0xA2, 0x8E, 0x38, 0xE2, 0x8B, 0x67, 0x00, 0x37,
  0xFB, 0x33, 0x33, 0x33, 0x30, 0x73, 0x60, 0x82, 0x18, 0x63, 0x18, 0x42,
  0x0F, 0xC0, 0x76, 0xC2, 0x11, 0xB8, 0x61, 0x0C, 0xFC, 0x0C, 0x18, 0x71,
  0xE2, 0xCD, 0x93, 0x7F, 0xFE, 0x18, 0x30, 0xFB, 0xE8, 0x20, 0xF3, 0xE0,
  0x83, 0x0A, 0x6F, 0x00, 0x39, 0xAC, 0x20, 0xB3, 0x68, 0xA3, 0x8F, 0x27,
  0x80, 0xFF, 0xFC, 0x10, 0x60, 0x81, 0x06, 0x08, 0x30, 0x60, 0x80, 0x73,
  0x68, 0xA2, 0xD9, 0xCD, 0xA3, 0x8E, 0x2F, 0x80, 0x73, 0x68, 0xA2, 0x8F,
  0x7F, 0x82, 0x08, 0x6F, 0x00, 0xF0, 0x0F, 0xF0, 0x0F, 0xA0, 0x04, 0x77,
  0x30, 0xE0, 0xE0, 0xC0, 0xFC, 0x00, 0x3F, 0x83, 0x03, 0x03, 0x3B, 0x88,
  0x00, 0x76, 0xC2, 0x11, 0x98, 0x84, 0x03, 0x18, 0x1C, 0x11, 0x90, 0x7B,
  0xD9, 0x6D, 0xB6, 0x9B, 0x6D, 0x9F, 0xC0, 0x10, 0x07, 0xC0, 0x18, 0x18,
  0x38, 0x3C, 0x24, 0x24, 0x66, 0x7E, 0x42, 0xC2, 0xC3, 0xF3, 0xFC, 0x71,
  0xCF, 0xEC, 0xF1, 0xC7, 0x3F, 0x80, 0x3D, 0xFC, 0x30, 0x82, 0x08, 0x30,
  0xC1, 0x93, 0xC0, 0xF1, 0xFB, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x9B,
  0xE0, 0xFF, 0xF1, 0x8C, 0x7F, 0x18, 0xC6, 0x3E, 0xFF, 0xF1, 0x8C, 0x7F,
  0xF8, 0xC6, 0x30, 0x3C, 0xEF, 0x06, 0x08, 0x11, 0xE3, 0xE1, 0xC2, 0xC4,
  0xF8, 0xC7, 0x8F, 0x1E, 0x3C, 0x7F, 0xF1, 0xE3, 0xC7, 0x8F, 0x18, 0xF2,
  0x22, 0x22, 0x22, 0x22, 0xF0, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0xAE,
  0xC7, 0x9B, 0x26, 0xCF, 0x1E, 0x34, 0x6C, 0xC9, 0x9B, 0x18, 0xC6, 0x31,
  0x8C, 0x63, 0x18, 0xC6, 0x3E, 0xC1, 0xF8, 0x7E, 0x1F, 0x87, 0xF3, 0xF4,
  0xBD, 0x2F, 0x7B, 0xDC, 0xF3, 0x3C, 0xCC, 0xC3, 0xC7, 0x8F, 0x9D, 0x3B,
  0x76, 0xE7, 0xCF, 0x8F, 0x18, 0x38, 0x7E, 0xC6, 0xC2, 0x83, 0x83, 0x83,
  0xC3, 0xC2, 0x66, 0x3C, 0xF3, 0xFC, 0xF3, 0xCF, 0x7F, 0xB0, 0xC3, 0x0C,
  0x00, 0x38, 0x7E, 0xC6, 0xC2, 0x83, 0x83, 0x83, 0xC3, 0xC2, 0x66, 0x3C,
  0x0C, 0x06, 0x06, 0xF1, 0xFB, 0x36, 0x6C, 0xDF, 0x3C, 0x6C, 0xC9, 0x9B,
  0x18, 0x7F, 0xE1, 0x0C, 0x38, 0x61, 0x0C, 0xFC, 0xFF, 0xFC, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1,
  0xE3, 0xC7, 0x89, 0xF0, 0xC3, 0xC2, 0x46, 0x46, 0x64, 0x64, 0x2C, 0x2C,
  0x38, 0x18, 0x18, 0xC6, 0x3C, 0x63, 0x46, 0x24, 0xE2, 0x4F, 0x66, 0x96,
  0x69, 0x42, 0x94, 0x39, 0x43, 0x1C, 0x30, 0xC0, 0xC6, 0x89, 0xB1, 0x43,
  0x83, 0x0E, 0x14, 0x6C, 0x8B, 0x18, 0xC7, 0x89, 0x13, 0x62, 0x87, 0x04,
  0x08, 0x10, 0x20, 0x40, 0xFF, 0xF0, 0xC6, 0x18, 0x43, 0x08, 0x61, 0x0F,
  0xC0, 0xF2, 0x49, 0x24, 0x92, 0x4E, 0xC1, 0x04, 0x18, 0x20, 0xC1, 0x04,
  0x18, 0x20, 0xC0, 0xF3, 0x33, 0x33, 0x33, 0x33, 0x33, 0xF0, 0x10, 0x30,
  0xA1, 0x66, 0x48, 0xF0, 0x80, 0xFC, 0xCC, 0xF8, 0xC2, 0xFC, 0xC6, 0x7D,
  0xC3, 0x0C, 0x2E, 0xCF, 0x3C, 0x71, 0xCF, 0x3B, 0x80, 0x7E, 0x21, 0x08,
  0x43, 0x2F, 0x0C, 0x30, 0xDF, 0xCE, 0x38, 0xE3, 0x8F, 0x37, 0xC0, 0x7E,
  0x63, 0xF8, 0x43, 0x2F, 0x3B, 0x19, 0xE6, 0x31, 0x8C, 0x63, 0x18, 0x7F,
  0x38, 0xE3, 0x8E, 0x3C, 0xDF, 0x0C, 0x3F, 0x98, 0xC3, 0x0C, 0x2E, 0xCF,
  0x3C, 0xF3, 0xCF, 0x3C, 0xC0, 0xE3, 0xFF, 0xFC, 0x68, 0x36, 0xDB, 0x6D,
  0xB5, 0xA0, 0xC3, 0x0C, 0x33, 0xDB, 0xCB, 0x3C, 0xDB, 0x2C, 0xC0, 0xFF,
  0xFF, 0xFC, 0xBB, 0xB3, 0x3C, 0xCF, 0x33, 0xCC, 0xF3, 0x3C, 0xCF, 0x33,
  0xBB, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0x7B, 0x28, 0xE3, 0x8E, 0x3C, 0x9E,
  0xBB, 0x3C, 0xF1, 0xC7, 0x3C, 0xEE, 0xC3, 0x0C, 0x30, 0x7F, 0x38, 0xE3,
  0x8E, 0x3C, 0xDF, 0x0C, 0x30, 0xC3, 0xBC, 0xCC, 0xCC, 0xCC, 0xF8, 0x8E,
  0x31, 0x9F, 0x26, 0xF6, 0x66, 0x66, 0x63, 0x8E, 0x38, 0xE3, 0x8E, 0x3C,
  0xDF, 0xC5, 0x34, 0xDA, 0x68, 0xE3, 0x0C, 0xCC, 0xD3, 0x34, 0xE9, 0x6A,
  0x72, 0x9C, 0xE3, 0x30, 0xCC, 0xCD, 0xA3, 0x8C, 0x30, 0xA6, 0xF3, 0xC5,
  0x34, 0xDA, 0x68, 0xE3, 0x8C, 0x30, 0xCE, 0x30, 0x78, 0xC4, 0x62, 0x31,
  0x1F, 0x19, 0x88, 0x42, 0x13, 0x8C, 0x21, 0x08, 0x63, 0x80, 0xFF, 0xFE,
  0x8C, 0x44, 0x46, 0x36, 0x44, 0x44, 0xC0, 0xFE, 0x60,
};

const GFXglyph NotoSans_Condensed_Medium15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 2, 11, 4, 1, -11 },
  { 4, 4, 4, 6, 1, -11 },
  { 6, 8, 11, 8, 0, -11 },
  { 17, 6, 12, 7, 1, -11 },
  { 26, 10, 11, 11, 1, -11 },
  { 40, 8, 11, 9, 1, -11 },
  { 51, 1, 4, 3, 1, -11 },
  { 52, 3, 13, 5, 1, -11 },
  { 57, 4, 13, 5, 0, -11 },
  { 64, 6, 5, 7, 0, -11 },
  { 68, 6, 7, 7, 1, -9 },
  { 74, 2, 4, 4, 1, -2 },
  { 75, 4, 2, 4, 0, -5 },
  { 76, 2, 2, 4, 1, -2 },
  { 77, 6, 11, 6, 0, -11 },
  { 86, 6, 11, 7, 1, -11 },
  { 95, 4, 11, 7, 1, -11 },
  { 101, 6, 11, 7, 1, -11 },
  { 110, 5, 11, 7, 1, -11 },
  { 117, 7, 11, 7, 0, -11 },
  { 127, 6, 11, 7, 1, -11 },
  { 136, 6, 11, 7, 1, -11 },
  { 145, 7, 11, 7, 0, -11 },
  { 155, 6, 11, 7, 1, -11 },
  { 164, 6, 11, 7, 1, -11 },
  { 173, 2, 8, 4, 1, -8 },
  { 175, 2, 10, 4, 1, -8 },
  { 178, 6, 7, 7, 1, -9 },
  { 184, 6, 4, 7, 1, -7 },
  { 187, 6, 7, 7, 1, -9 },
  { 193, 5, 11, 6, 0, -11 },
  { 200, 9, 12, 11, 1, -11 },
  { 214, 8, 11, 8, 0, -11 },
  { 225, 6, 11, 8, 1, -11 },
  { 234, 6, 11, 8, 1, -11 },
  { 243, 7, 11, 9, 1, -11 },
  { 253, 5, 11, 7, 1, -11 },
  { 260, 5, 11, 7, 1, -11 },
  { 267, 7, 11, 9, 1, -11 },
  { 277, 7, 11, 9, 1, -11 },
  { 287, 4, 11, 5, 0, -11 },
  { 293, 4, 14, 4, -1, -11 },
  { 300, 7, 11, 8, 1, -11 },
  { 310, 5, 11, 6, 1, -11 },
  { 317, 10, 11, 12, 1, -11 },
  { 331, 7, 11, 10, 1, -11 },
  { 341, 8, 11, 9, 1, -11 },
  { 352, 6, 11, 8, 1, -11 },
  { 361, 8, 14, 9, 1, -11 },
  { 375, 7, 11, 8, 1, -11 },
  { 385, 5, 11, 7, 1, -11 },
  { 392, 7, 11, 7, 0, -11 },
  { 402, 7, 11, 9, 1, -11 },
  { 412, 8, 11, 8, 0, -11 },
  { 423, 12, 11, 12, 0, -11 },
  { 440, 7, 11, 7, 0, -11 },
  { 450, 7, 11, 7, 0, -11 },
  { 460, 6, 11, 7, 0, -11 },
  { 469, 3, 13, 5, 1, -11 },
  { 474, 6, 11, 6, 0, -11 },
  { 483, 4, 13, 5, 0, -11 },
  { 490, 7, 7, 7, 0, -11 },
  { 497, 6, 1, 6, 0, 1 },
  { 498, 3, 2, 4, 1, -11 },
  { 499, 5, 8, 7, 1, -8 },
  { 504, 6, 11, 8, 1, -11 },
  { 513, 5, 8, 6, 1, -8 },
  { 518, 6, 11, 8, 1, -11 },
  { 527, 5, 8, 7, 1, -8 },
  { 532, 5, 11, 4, 0, -11 },
  { 539, 6, 12, 8, 1, -8 },
  { 548, 6, 11, 8, 1, -11 },
  { 557, 2, 11, 4, 1, -11 },
  { 560, 3, 15, 4, 0, -11 },
  { 566, 6, 11, 7, 1, -11 },
  { 575, 2, 11, 4, 1, -11 },
  { 578, 10, 8, 12, 1, -8 },
  { 588, 6, 8, 8, 1, -8 },
  { 594, 6, 8, 8, 1, -8 },
  { 600, 6, 12, 8, 1, -8 },
  { 609, 6, 12, 8, 1, -8 },
  { 618, 4, 8, 5, 1, -8 },
  { 622, 4, 8, 6, 1, -8 },
  { 626, 4, 10, 5, 0, -10 },
  { 631, 6, 8, 8, 1, -8 },
  { 637, 6, 8, 6, 0, -8 },
  { 643, 10, 8, 10, 0, -8 },
  { 653, 6, 8, 7, 0, -8 },
  { 659, 6, 12, 7, 0, -8 },
  { 668, 5, 8, 6, 0, -8 },
  { 673, 5, 13, 5, 0, -11 },
  { 682, 1, 15, 7, 3, -11 },
  { 684, 4, 13, 5, 1, -11 },
  { 691, 6, 2, 7, 1, -6 },
};

const GFXfont NotoSans_Condensed_Medium15pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Medium15pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Medium15pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _NOTOSANS_CONDENSED_MEDIUM15PT7B_H_
