#ifndef _NOTOSANS_CONDENSED_MEDIUM70PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUM70PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Medium.ttf
// Size: 70pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Medium70pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0xBF, 0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F, 0xBF,
  0xDF, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE3,
  0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC,
  0x7E, 0x3F, 0x1F, 0x8F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x1F, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x9F, 0x87, 0x00, 0xFF,
  0x07, 0xFF, 0xF8, 0x3F, 0xBF, 0x81, 0xFD, 0xFC, 0x0F, 0xEF, 0xE0, 0x7F,
  0x7F, 0x03, 0xFB, 0xF8, 0x1F, 0xCF, 0xC0, 0xFE, 0x7E, 0x03, 0xF3, 0xF0,
  0x1F, 0x9F, 0x80, 0xFC, 0xFC, 0x07, 0xE7, 0xE0, 0x3F, 0x3F, 0x01, 0xF9,
  0xF8, 0x0F, 0xCF, 0xC0, 0x7C, 0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x00, 0x00,
  0x0F, 0xC0, 0x7C, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x00, 0xF8, 0x0F, 0x80,
  0x00, 0x3E, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x07, 0xE0, 0x3E,
  0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x1F, 0x01,
  0xF8, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x7C,
  0x07, 0xC0, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x7C, 0x03, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xF8, 0x0F, 0x80,
  0x00, 0x7E, 0x03, 0xE0, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x7E,
  0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x1F, 0x01,
  0xF0, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0xF8,
  0x0F, 0xC0, 0x00, 0x3E, 0x03, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xC0, 0x7E, 0x00, 0x01, 0xF0, 0x1F, 0x00,
  0x00, 0x7C, 0x07, 0xC0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x7C,
  0x00, 0x03, 0xF0, 0x1F, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x3E, 0x03,
  0xF0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0xF8,
  0x0F, 0x80, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x07,
  0xC0, 0x7E, 0x00, 0x01, 0xF0, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF,
  0xF7, 0xF8, 0x7F, 0x8F, 0x03, 0x87, 0xF0, 0xF0, 0x08, 0xFE, 0x0F, 0x00,
  0x0F, 0xE0, 0xF0, 0x00, 0xFE, 0x0F, 0x00, 0x0F, 0xE0, 0xF0, 0x00, 0xFE,
  0x0F, 0x00, 0x0F, 0xE0, 0xF0, 0x00, 0x7F, 0x0F, 0x00, 0x07, 0xF8, 0xF0,
  0x00, 0x7F, 0xCF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xFC,
  0x00, 0x0F, 0x7F, 0xC0, 0x00, 0xF1, 0xFE, 0x00, 0x0F, 0x0F, 0xE0, 0x00,
  0xF0, 0x7E, 0x00, 0x0F, 0x07, 0xE0, 0x00, 0xF0, 0x7F, 0x00, 0x0F, 0x07,
  0xE0, 0x00, 0xF0, 0x7E, 0x00, 0x0F, 0x0F, 0xEC, 0x00, 0xF0, 0xFE, 0xF8,
  0x0F, 0x1F, 0xCF, 0xF8, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0xFC, 0x00,
  0x1F, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x00, 0x1F, 0x03, 0xE0, 0x03,
  0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x80, 0x03, 0xF0, 0x3F, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0xFC, 0x01, 0xF0, 0x00, 0x3F, 0x01, 0xF0, 0x0F, 0xC0,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x00,
  0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x00, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0x00,
  0xF8, 0x07, 0xC0, 0xFC, 0x00, 0x03, 0xE0, 0x1F, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x7C, 0x1F, 0x80, 0x00, 0x3E, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0xFC,
  0x07, 0xC3, 0xF0, 0x1E, 0x03, 0xF0, 0x3F, 0x0F, 0xC1, 0xFE, 0x0F, 0xC0,
  0xFC, 0x3E, 0x1F, 0xFC, 0x1F, 0x03, 0xF1, 0xF8, 0xFF, 0xF8, 0x7C, 0x0F,
  0x87, 0xC3, 0xFF, 0xF1, 0xF8, 0x7E, 0x3F, 0x1F, 0xCF, 0xC3, 0xF3, 0xF8,
  0xFC, 0x7E, 0x1F, 0x8F, 0xFF, 0xC7, 0xE1, 0xF0, 0x3E, 0x1F, 0xFE, 0x1F,
  0x8F, 0xC0, 0xF8, 0x3F, 0xF8, 0x7C, 0x3F, 0x03, 0xF0, 0x7F, 0x83, 0xF0,
  0xFC, 0x0F, 0xC0, 0x78, 0x0F, 0x83, 0xE0, 0x3F, 0x00, 0x00, 0x7E, 0x0F,
  0x80, 0xFC, 0x00, 0x01, 0xF8, 0x3E, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0xF8,
  0x07, 0xC0, 0x00, 0x3F, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0xF8, 0x0F, 0x80,
  0x7C, 0x00, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0xF8, 0x07,
  0xC0, 0x00, 0xFC, 0x03, 0xE0, 0x3F, 0x00, 0x03, 0xF0, 0x0F, 0x80, 0xFC,
  0x00, 0x0F, 0x80, 0x3F, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0xFC, 0x0F, 0xC0,
  0x01, 0xF0, 0x03, 0xF0, 0x3E, 0x00, 0x0F, 0xC0, 0x07, 0xC0, 0xF8, 0x00,
  0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0x87, 0xF8, 0x00,
  0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x7E, 0x00, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x07, 0xE0, 0x00,
  0x0F, 0xE0, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x00, 0x7E, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00,
  0x1F, 0xC1, 0xFC, 0x00, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x00, 0xFF, 0x7F,
  0x80, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0x03,
  0xFF, 0xFC, 0x01, 0xFC, 0x1F, 0xF7, 0xF8, 0x07, 0xF0, 0x7F, 0x9F, 0xE0,
  0x3F, 0x83, 0xFC, 0x3F, 0xC0, 0xFE, 0x0F, 0xE0, 0x7F, 0x83, 0xF8, 0x7F,
  0x80, 0xFF, 0x0F, 0xE1, 0xFC, 0x03, 0xFC, 0x7F, 0x07, 0xF0, 0x07, 0xF9,
  0xFC, 0x3F, 0xC0, 0x0F, 0xFF, 0xF0, 0xFF, 0x00, 0x1F, 0xFF, 0x83, 0xFC,
  0x00, 0x7F, 0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0xF0, 0x3F, 0xC0, 0x01, 0xFF,
  0xC0, 0xFF, 0x00, 0x03, 0xFE, 0x01, 0xFC, 0x00, 0x0F, 0xF8, 0x07, 0xF8,
  0x00, 0x7F, 0xE0, 0x1F, 0xE0, 0x03, 0xFF, 0xC0, 0x3F, 0xE0, 0x3F, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xE7, 0xF8, 0x0F, 0xFF, 0xFE, 0x0F, 0xF0, 0x1F, 0xFF, 0xF0, 0x3F,
  0xE0, 0x1F, 0xFF, 0x00, 0x7F, 0xC0, 0x07, 0xC0, 0x00, 0x00, 0xFF, 0xFF,
  0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7C, 0x7C, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x80,
  0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x3F, 0x80,
  0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0,
  0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0xFC,
  0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xFC,
  0x01, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x01, 0x00, 0xF8, 0x02, 0x7C,
  0x1F, 0x03, 0xCF, 0xF3, 0xE7, 0xF9, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xEF, 0xE0,
  0x01, 0xFC, 0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xE1, 0xFC, 0x03, 0xF8,
  0x3F, 0xC0, 0xFF, 0x03, 0xF8, 0x03, 0xC0, 0x7C, 0x00, 0x38, 0x06, 0x00,
  0x01, 0x00, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0x8F, 0xE3,
  0xF9, 0xFC, 0x7F, 0x1F, 0xC7, 0xE1, 0xF8, 0x7E, 0x3F, 0x0F, 0xC3, 0xE0,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x3E, 0x3F, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0x7F,
  0x0E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0x01, 0xFE, 0x07, 0xF0, 0x3F, 0xC0, 0x3F, 0x83, 0xF8,
  0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xC7, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x1F,
  0xC7, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0xFE, 0xFE,
  0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x00,
  0xFE, 0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xEF, 0xE0,
  0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFE, 0x7F, 0x00, 0x0F,
  0xE7, 0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x1F, 0xC7, 0xF0, 0x01, 0xFC, 0x7F,
  0x00, 0x1F, 0xC3, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x83, 0xFC, 0x03,
  0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0xFF,
  0x80, 0x3F, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x3F, 0xFF,
  0x0F, 0xFF, 0xE3, 0xFD, 0xFC, 0xFF, 0x3F, 0xFF, 0xC7, 0xF7, 0xF0, 0xFE,
  0x7C, 0x1F, 0xC7, 0x03, 0xF8, 0x40, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x3F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0xE3, 0xF8, 0x07, 0xFC, 0x3C, 0x00, 0x7F, 0x83, 0x00,
  0x07, 0xF8, 0x40, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0x1F, 0xF9, 0xFF, 0xE3, 0xF0, 0x03, 0xFC,
  0x38, 0x00, 0x3F, 0xC2, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFC,
  0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x40, 0x00,
  0x3F, 0xEF, 0x00, 0x0F, 0xFD, 0xFE, 0x0F, 0xFF, 0x3F, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0x7F, 0x00,
  0x00, 0x7E, 0xFE, 0x00, 0x00, 0xF9, 0xFC, 0x00, 0x03, 0xF3, 0xF8, 0x00,
  0x07, 0xC7, 0xF0, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x3E, 0x1F, 0xC0, 0x00,
  0xFC, 0x3F, 0x80, 0x03, 0xF0, 0x7F, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x1F,
  0x81, 0xFC, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0xFC, 0x07, 0xF0, 0x01, 0xF8,
  0x0F, 0xE0, 0x07, 0xE0, 0x1F, 0xC0, 0x0F, 0xC0, 0x3F, 0x80, 0x3F, 0x00,
  0x7F, 0x00, 0x7C, 0x00, 0xFE, 0x01, 0xF8, 0x01, 0xFC, 0x07, 0xE0, 0x03,
  0xF8, 0x0F, 0xC0, 0x07, 0xF0, 0x3F, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x1F,
  0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0x87, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0x0E, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE8,
  0x00, 0x0F, 0xFB, 0xC0, 0x07, 0xFC, 0xFF, 0x1F, 0xFE, 0x3F, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xF8, 0x07, 0xFF, 0xC7, 0x80, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x7E, 0x00, 0x7E, 0x1F, 0xF8, 0x0F, 0xE7, 0xFF, 0xE0, 0xFE, 0xFF,
  0xFF, 0x0F, 0xEF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0x0F, 0xFC,
  0xFF, 0xC0, 0x3F, 0xCF, 0xF8, 0x01, 0xFE, 0xFF, 0x00, 0x0F, 0xEF, 0xF0,
  0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE,
  0x00, 0x07, 0xF7, 0xE0, 0x00, 0x7F, 0x7F, 0x00, 0x07, 0xF7, 0xF0, 0x00,
  0xFE, 0x7F, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0xE3,
  0xFC, 0x01, 0xFC, 0x1F, 0xE0, 0x3F, 0xC1, 0xFF, 0xDF, 0xF8, 0x0F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFC, 0x03,
  0xFC, 0x7F, 0x80, 0x1F, 0xC7, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xE7,
  0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0xFE, 0x7F, 0x00,
  0x0F, 0xC7, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x1F, 0xC3, 0xF8, 0x03, 0xFC,
  0x3F, 0xC0, 0x3F, 0x81, 0xFE, 0x07, 0xF8, 0x0F, 0xF1, 0xFF, 0x00, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x0F,
  0xF3, 0xFF, 0x01, 0xFE, 0x1F, 0xF8, 0x3F, 0xC0, 0x7F, 0x87, 0xF8, 0x03,
  0xFC, 0x7F, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xEF,
  0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F,
  0xFE, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0xFE, 0x7F, 0x80, 0x1F, 0xE7, 0xFE,
  0x07, 0xFC, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC1, 0xFE,
  0x07, 0xFC, 0x7F, 0x80, 0x7F, 0x8F, 0xE0, 0x07, 0xF3, 0xFC, 0x00, 0x7F,
  0x7F, 0x00, 0x0F, 0xEF, 0xE0, 0x01, 0xFD, 0xFC, 0x00, 0x1F, 0xFF, 0x80,
  0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0x7F, 0x00, 0x3F, 0xEF,
  0xF0, 0x0F, 0xFD, 0xFF, 0x83, 0xFF, 0x9F, 0xFF, 0xFB, 0xF1, 0xFF, 0xFF,
  0x7E, 0x3F, 0xFF, 0xDF, 0xC3, 0xFF, 0xF3, 0xF8, 0x1F, 0xFC, 0x7F, 0x00,
  0xFC, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x70, 0x7F, 0xF8, 0x0F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x00,
  0xFF, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x3F, 0x9F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0x3F, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xF1, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFB, 0xF8, 0x70, 0x0F, 0x83, 0xF8, 0x7F, 0x9F, 0xF3, 0xFE, 0x7F, 0xCF,
  0xF8, 0xFF, 0x0F, 0xC0, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0xFF, 0x1F,
  0xE3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x07,
  0xE1, 0xFC, 0x3F, 0x07, 0xE0, 0xF8, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F,
  0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x3F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0x9F, 0xF7, 0xFF, 0x3E, 0x01, 0xFF, 0x30, 0x01, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x0F, 0xE0, 0x0F,
  0xC1, 0xF8, 0x01, 0xFF, 0xF8, 0x3F, 0x07, 0xC0, 0x1F, 0xFF, 0xE0, 0x7C,
  0x3F, 0x00, 0xFF, 0xFF, 0x81, 0xF8, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xE3,
  0xE0, 0x1F, 0x81, 0xF8, 0x0F, 0x8F, 0x80, 0xFC, 0x07, 0xE0, 0x3E, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xF9, 0xF8, 0x1F, 0x80, 0x7E, 0x03, 0xE7, 0xC0,
  0x7E, 0x01, 0xF8, 0x0F, 0x9F, 0x01, 0xF8, 0x07, 0xE0, 0x3E, 0x7C, 0x07,
  0xC0, 0x1F, 0x80, 0xFD, 0xF0, 0x3F, 0x00, 0x7E, 0x03, 0xFF, 0xC0, 0xFC,
  0x01, 0xF0, 0x0F, 0xBF, 0x03, 0xF0, 0x07, 0xC0, 0x3E, 0xFC, 0x0F, 0xC0,
  0x1F, 0x00, 0xFB, 0xF0, 0x3F, 0x00, 0xFC, 0x03, 0xEF, 0xC0, 0xFC, 0x03,
  0xF0, 0x0F, 0xBF, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0xFC, 0x0F, 0xC0, 0x3F,
  0x01, 0xFB, 0xF0, 0x1F, 0x00, 0xFC, 0x07, 0xC7, 0xC0, 0x7E, 0x07, 0xF0,
  0x1F, 0x1F, 0x01, 0xF8, 0x1F, 0xE0, 0xFC, 0x7C, 0x07, 0xF0, 0xF7, 0x87,
  0xE1, 0xF8, 0x0F, 0xFF, 0xDF, 0xFF, 0x87, 0xE0, 0x3F, 0xFE, 0x3F, 0xFC,
  0x1F, 0x80, 0x7F, 0xF8, 0xFF, 0xE0, 0x3F, 0x00, 0xFF, 0xC1, 0xFF, 0x00,
  0xFC, 0x00, 0xFC, 0x03, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x20, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01,
  0xFB, 0xF0, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x00, 0xFE, 0xFC, 0x00,
  0x00, 0x07, 0xF7, 0xF0, 0x00, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x01, 0xF8,
  0xFC, 0x00, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00,
  0x07, 0xE1, 0xFC, 0x00, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x3F,
  0x80, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x3F, 0x00, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x7F, 0x00, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x7F, 0x80,
  0x00, 0xFF, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x00, 0x1F, 0xC1,
  0xFE, 0x00, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x00,
  0x1F, 0xC3, 0xF8, 0x00, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0x07, 0xF9, 0xFE,
  0x00, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0x07,
  0xF7, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFF, 0x8F, 0xF0, 0x07, 0xFF, 0x3F, 0xC0, 0x07, 0xFC,
  0xFF, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x7F, 0xBF,
  0xC0, 0x01, 0xFE, 0xFF, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x1F, 0xEF, 0xF0,
  0x00, 0x7F, 0xBF, 0xC0, 0x01, 0xFC, 0xFF, 0x00, 0x07, 0xF3, 0xFC, 0x00,
  0x3F, 0xCF, 0xF0, 0x00, 0xFE, 0x3F, 0xC0, 0x07, 0xF8, 0xFF, 0x00, 0x7F,
  0xC3, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F,
  0xC0, 0x0F, 0xF8, 0xFF, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x1F, 0xEF, 0xF0,
  0x00, 0x7F, 0xBF, 0xC0, 0x00, 0xFE, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFE,
  0xFF, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0xFF, 0x3F,
  0xC0, 0x0F, 0xFC, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0x80, 0x3C, 0x0F, 0xF8, 0x00, 0x30,
  0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x02, 0x0F,
  0xFE, 0x00, 0x70, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x03, 0xFC, 0x07, 0xFF, 0xC1, 0xFE, 0x00,
  0x7F, 0xE0, 0xFF, 0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x03, 0xFE, 0x3F, 0xC0,
  0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x7F, 0xCF, 0xF0, 0x00, 0x1F, 0xE7, 0xF8,
  0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x01, 0xFE, 0xFF,
  0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0x1F, 0xDF,
  0xE0, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x01,
  0xFD, 0xFE, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0x7F, 0x7F, 0x80, 0x00,
  0x7F, 0xBF, 0xC0, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x1F, 0xCF, 0xF0, 0x00,
  0x1F, 0xE7, 0xF8, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x0F, 0xF1, 0xFE, 0x00,
  0x07, 0xF8, 0xFF, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x07, 0xFC, 0x3F, 0xC0,
  0x0F, 0xFC, 0x1F, 0xE0, 0x3F, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0x7C, 0x0F, 0xFC, 0x00, 0x06, 0x03, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01,
  0xFD, 0xFC, 0x00, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0x1F, 0xDF, 0xE0, 0x00,
  0x07, 0xF7, 0xF8, 0x00, 0x01, 0xFC, 0xFF, 0x00, 0x00, 0x7F, 0x3F, 0xC0,
  0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x07, 0xF1, 0xFF, 0x00, 0x01, 0xFC, 0x3F,
  0xE0, 0x00, 0x7F, 0x0F, 0xFE, 0x00, 0x1F, 0xC1, 0xFF, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x01, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3,
  0xFF, 0xF0, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x81, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0x3F, 0x00, 0xFE, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0xFF, 0x3F, 0x80, 0x03,
  0xFC, 0xFE, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0xFF, 0x0F, 0xE0, 0x03, 0xFC,
  0x3F, 0x80, 0x1F, 0xE0, 0xFE, 0x00, 0x7F, 0x03, 0xF8, 0x03, 0xFC, 0x0F,
  0xE0, 0x1F, 0xE0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x03, 0xFC, 0x03, 0xF8,
  0x1F, 0xE0, 0x0F, 0xE0, 0x7F, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0xFE, 0x1F,
  0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x3F, 0x8F, 0xE0,
  0x00, 0xFE, 0x7F, 0x80, 0x03, 0xFB, 0xFC, 0x00, 0x0F, 0xEF, 0xF0, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x3F, 0xF7, 0xF0, 0x00, 0xFF, 0x9F, 0xE0, 0x03, 0xFC,
  0x3F, 0x80, 0x0F, 0xE0, 0xFF, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0xFE, 0x07,
  0xF8, 0x03, 0xF8, 0x0F, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0x3F, 0x80, 0x7F,
  0x80, 0xFE, 0x01, 0xFE, 0x03, 0xF8, 0x03, 0xFC, 0x0F, 0xE0, 0x0F, 0xF0,
  0x3F, 0x80, 0x1F, 0xE0, 0xFE, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0xFF, 0x0F,
  0xE0, 0x03, 0xFC, 0x3F, 0x80, 0x07, 0xF8, 0xFE, 0x00, 0x1F, 0xE3, 0xF8,
  0x00, 0x3F, 0xCF, 0xE0, 0x00, 0xFF, 0xBF, 0x80, 0x01, 0xFE, 0xFE, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xFF, 0xDF, 0x80, 0x00, 0x3F, 0x7F, 0xFD, 0xF8, 0x00, 0x03, 0xF7, 0xFF,
  0xDF, 0xC0, 0x00, 0x3F, 0x7F, 0xFC, 0xFC, 0x00, 0x07, 0xE7, 0xFF, 0xCF,
  0xC0, 0x00, 0x7E, 0x7F, 0xFC, 0xFE, 0x00, 0x07, 0xE7, 0xFF, 0xC7, 0xE0,
  0x00, 0xFC, 0x7F, 0xFC, 0x7E, 0x00, 0x0F, 0xC7, 0xFF, 0xC7, 0xE0, 0x00,
  0xFC, 0x7F, 0xFC, 0x7F, 0x00, 0x1F, 0xC7, 0xFF, 0xC3, 0xF0, 0x01, 0xF8,
  0x7F, 0xFC, 0x3F, 0x00, 0x1F, 0x87, 0xFF, 0xC3, 0xF8, 0x01, 0xF8, 0x7F,
  0xFC, 0x1F, 0x80, 0x3F, 0x07, 0xFF, 0xC1, 0xF8, 0x03, 0xF0, 0x7F, 0xFC,
  0x1F, 0xC0, 0x3F, 0x07, 0xFF, 0xC0, 0xFC, 0x07, 0xE0, 0x7F, 0xFC, 0x0F,
  0xC0, 0x7E, 0x07, 0xFF, 0xC0, 0xFC, 0x07, 0xE0, 0x7F, 0xFC, 0x0F, 0xE0,
  0xFC, 0x07, 0xFF, 0xC0, 0x7E, 0x0F, 0xC0, 0x7F, 0xFC, 0x07, 0xE0, 0xFC,
  0x07, 0xFF, 0xC0, 0x7F, 0x1F, 0x80, 0x7F, 0xFC, 0x03, 0xF1, 0xF8, 0x07,
  0xFF, 0xC0, 0x3F, 0x1F, 0x80, 0x7F, 0xFC, 0x03, 0xF9, 0xF8, 0x07, 0xFF,
  0xC0, 0x1F, 0xBF, 0x00, 0x7F, 0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xFF, 0xC0,
  0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0xC0, 0x07, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFD, 0xFC, 0x00, 0x1F, 0xFF, 0x7F, 0x80, 0x07, 0xFF, 0xCF,
  0xE0, 0x01, 0xFF, 0xF3, 0xFC, 0x00, 0x7F, 0xFC, 0x7F, 0x00, 0x1F, 0xFF,
  0x1F, 0xE0, 0x07, 0xFF, 0xC3, 0xF8, 0x01, 0xFF, 0xF0, 0xFF, 0x00, 0x7F,
  0xFC, 0x1F, 0xC0, 0x1F, 0xFF, 0x07, 0xF8, 0x07, 0xFF, 0xC0, 0xFE, 0x01,
  0xFF, 0xF0, 0x3F, 0xC0, 0x7F, 0xFC, 0x07, 0xF0, 0x1F, 0xFF, 0x01, 0xFE,
  0x07, 0xFF, 0xC0, 0x3F, 0x81, 0xFF, 0xF0, 0x0F, 0xF0, 0x7F, 0xFC, 0x01,
  0xFC, 0x1F, 0xFF, 0x00, 0x7F, 0x07, 0xFF, 0xC0, 0x0F, 0xE1, 0xFF, 0xF0,
  0x03, 0xF8, 0x7F, 0xFC, 0x00, 0x7F, 0x1F, 0xFF, 0x00, 0x1F, 0xC7, 0xFF,
  0xC0, 0x03, 0xF9, 0xFF, 0xF0, 0x00, 0xFE, 0x7F, 0xFC, 0x00, 0x3F, 0xDF,
  0xFF, 0x00, 0x07, 0xF7, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x1F, 0xF0, 0x00, 0xFF,
  0x81, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x3F, 0xC3, 0xFC, 0x00,
  0x03, 0xFC, 0x7F, 0x80, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x01, 0xFE, 0x7F,
  0x80, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0x7F, 0x00, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x01, 0xFE, 0x7F,
  0x80, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x01, 0xFC, 0x3F, 0xC0, 0x00, 0x3F,
  0xC3, 0xFE, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x7F, 0x81, 0xFF, 0x00,
  0x0F, 0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0xFF,
  0x03, 0xFF, 0xCF, 0xF0, 0x07, 0xFC, 0xFF, 0x00, 0x3F, 0xEF, 0xF0, 0x01,
  0xFE, 0xFF, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0xFE, 0xFF, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0xFE,
  0xFF, 0x00, 0x1F, 0xEF, 0xF0, 0x01, 0xFE, 0xFF, 0x00, 0x3F, 0xCF, 0xF0,
  0x07, 0xFC, 0xFF, 0x03, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x1F, 0xF0, 0x00,
  0xFF, 0x81, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x3F, 0xC3, 0xFC,
  0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x01, 0xFE,
  0x7F, 0x80, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x01, 0xFE,
  0x7F, 0x80, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00,
  0x3F, 0xC3, 0xFE, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x7F, 0x81, 0xFF,
  0x00, 0x0F, 0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xC0, 0xFF, 0xF0, 0x7F, 0x80, 0x3F, 0xF0,
  0xFF, 0x00, 0x3F, 0xE1, 0xFE, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x3F, 0x87,
  0xF8, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0xFF, 0x1F, 0xE0, 0x01, 0xFE, 0x3F,
  0xC0, 0x03, 0xFC, 0x7F, 0x80, 0x07, 0xF8, 0xFF, 0x00, 0x0F, 0xF1, 0xFE,
  0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0x7F, 0x0F, 0xF0,
  0x01, 0xFE, 0x1F, 0xE0, 0x07, 0xF8, 0x3F, 0xC0, 0x1F, 0xF0, 0x7F, 0x81,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0xFF, 0x01, 0xFC,
  0x01, 0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xF8, 0x07, 0xF8, 0x07, 0xF8,
  0x0F, 0xF0, 0x07, 0xF0, 0x1F, 0xE0, 0x0F, 0xF0, 0x3F, 0xC0, 0x1F, 0xE0,
  0x7F, 0x80, 0x1F, 0xE0, 0xFF, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x3F, 0xC3,
  0xFC, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0xFF, 0x1F,
  0xE0, 0x00, 0xFF, 0x3F, 0xC0, 0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFE, 0xFF,
  0x00, 0x03, 0xFD, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF9, 0xFF, 0x80, 0x7C, 0x7F, 0x80, 0x03,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFE,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01,
  0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFB, 0x80, 0x01, 0xFE, 0xFC, 0x01, 0xFF, 0xBF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0xFE, 0x7F, 0x00,
  0x00, 0xFE, 0x7F, 0x80, 0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFC, 0x3F, 0xC0,
  0x03, 0xFC, 0x3F, 0xF0, 0x0F, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0x3F, 0xBF,
  0x80, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0x3F,
  0x8F, 0xE0, 0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00,
  0x3F, 0x83, 0xF8, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x01, 0xFE, 0x0F, 0xE0,
  0x00, 0x3F, 0x81, 0xFC, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0xFE, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x07, 0xF0, 0x07, 0xE0, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x01, 0xFC, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x7E, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x7E, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x83,
  0xF8, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x0F,
  0xE3, 0xF8, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0x1F, 0x8F, 0xE0, 0x00,
  0x03, 0xF9, 0xF8, 0x00, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0x07, 0xEF, 0xE0,
  0x00, 0x00, 0xFD, 0xFC, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFD, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFB, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xCF,
  0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0x1F, 0xC0, 0x00, 0xFF, 0xC0, 0x01, 0xFE, 0x3F, 0x80, 0x03, 0xFF,
  0x80, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xF0, 0xFF, 0x00,
  0x0F, 0xFE, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0x7E, 0x00, 0x1F, 0xC1,
  0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0xFD, 0xF8, 0x00,
  0xFE, 0x07, 0xF0, 0x01, 0xFB, 0xF0, 0x01, 0xFC, 0x07, 0xF0, 0x03, 0xF3,
  0xE0, 0x03, 0xF8, 0x0F, 0xE0, 0x07, 0xE7, 0xE0, 0x07, 0xF0, 0x1F, 0xC0,
  0x1F, 0x8F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x80,
  0x7F, 0x00, 0x7E, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFC, 0x3F, 0x00,
  0xFE, 0x00, 0xFE, 0x03, 0xF8, 0x7E, 0x03, 0xFC, 0x01, 0xFC, 0x07, 0xE0,
  0xFC, 0x07, 0xF0, 0x03, 0xF8, 0x0F, 0xC1, 0xF8, 0x0F, 0xE0, 0x03, 0xF0,
  0x1F, 0x83, 0xF8, 0x1F, 0xC0, 0x07, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x80,
  0x0F, 0xE0, 0xFC, 0x07, 0xE0, 0xFE, 0x00, 0x1F, 0xC1, 0xF8, 0x0F, 0xC1,
  0xFC, 0x00, 0x3F, 0x83, 0xF0, 0x1F, 0x83, 0xF8, 0x00, 0x3F, 0x07, 0xE0,
  0x1F, 0x87, 0xF0, 0x00, 0x7F, 0x1F, 0xC0, 0x3F, 0x0F, 0xE0, 0x00, 0xFE,
  0x3F, 0x00, 0x7E, 0x3F, 0x80, 0x01, 0xFC, 0x7E, 0x00, 0xFC, 0x7F, 0x00,
  0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFE, 0x00, 0x03, 0xF1, 0xF8, 0x01, 0xF9,
  0xFC, 0x00, 0x07, 0xF3, 0xE0, 0x03, 0xF3, 0xF0, 0x00, 0x0F, 0xEF, 0xC0,
  0x07, 0xEF, 0xE0, 0x00, 0x1F, 0xDF, 0x80, 0x0F, 0xDF, 0xC0, 0x00, 0x1F,
  0xBF, 0x00, 0x0F, 0xBF, 0x80, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0x7F, 0x00,
  0x00, 0x7E, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x1F, 0xE0, 0x00, 0x7F, 0x87, 0xF0, 0x00, 0x3F, 0x83, 0xFC, 0x00,
  0x3F, 0xC0, 0xFE, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x1F, 0xE0, 0x1F, 0xC0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xF0, 0x01, 0xFC,
  0x03, 0xF8, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x1F,
  0xC1, 0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x03, 0xF8, 0xFF, 0x00, 0x00,
  0xFE, 0x7F, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x7F, 0x3F,
  0x80, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x3F, 0x83,
  0xF8, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x0F, 0xE0,
  0x3F, 0xC0, 0x0F, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x07, 0xF8,
  0x01, 0xFC, 0x03, 0xF8, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x3F, 0x81, 0xFC,
  0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x03, 0xFC, 0x7F,
  0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0xFF, 0x00, 0x00, 0x7F, 0xBF, 0x80, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0x3F,
  0xCF, 0xF0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x0F,
  0xE0, 0x7F, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x07, 0xF8, 0x0F, 0xE0, 0x03,
  0xF8, 0x07, 0xF0, 0x03, 0xFC, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x0F, 0xE0,
  0x3F, 0x80, 0x07, 0xF8, 0x3F, 0x80, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0xFE,
  0x1F, 0xC0, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x0F,
  0xE7, 0xF0, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFE,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x03, 0xF3,
  0xF0, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x3F, 0x07,
  0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xF8, 0x0F, 0xC0, 0x07, 0xF0, 0x1F,
  0x80, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0xFC, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0xFC,
  0x1F, 0x80, 0x01, 0xFC, 0x3F, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x03, 0xF9,
  0xF8, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0x80, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xE0, 0x0F, 0xC0, 0x0F, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x7E, 0x0F, 0xF8, 0x38,
  0x01, 0xFE, 0x10, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF7, 0xFE, 0x01, 0xFB, 0xFC, 0x00,
  0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00,
  0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0,
  0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x83, 0xFF, 0xBF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xF3, 0xE7, 0xFF, 0xF1, 0xF1, 0xFF, 0xF0, 0xF8,
  0x7F, 0xE0, 0x7C, 0x07, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE1,
  0xFF, 0x00, 0xFE, 0x3F, 0xFC, 0x0F, 0xE7, 0xFF, 0xE0, 0xFE, 0xFF, 0xFF,
  0x0F, 0xDF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x8F, 0xFC, 0x07, 0xFC, 0xFF,
  0x80, 0x1F, 0xCF, 0xF8, 0x01, 0xFE, 0xFF, 0x00, 0x0F, 0xEF, 0xF0, 0x00,
  0xFE, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F,
  0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x0F,
  0xEF, 0xF0, 0x00, 0xFE, 0xFF, 0x00, 0x1F, 0xEF, 0xF8, 0x01, 0xFC, 0xFF,
  0xC0, 0x3F, 0xCF, 0xFF, 0x0F, 0xFC, 0xFD, 0xFF, 0xFF, 0x8F, 0xDF, 0xFF,
  0xF0, 0xFC, 0xFF, 0xFE, 0x0F, 0xC7, 0xFF, 0xC0, 0xF8, 0x1F, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x02, 0x00, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x0F,
  0xF0, 0x06, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xE0, 0x06, 0x3F, 0xF0, 0x7C, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x20, 0x0F, 0xE0, 0x1F, 0xF0, 0x7F, 0x03, 0xFF, 0xC3, 0xF8,
  0x3F, 0xFF, 0x9F, 0xC3, 0xFF, 0xFC, 0xFE, 0x3F, 0xFF, 0xF7, 0xF1, 0xFF,
  0xFF, 0xFF, 0x9F, 0xF0, 0x1F, 0xFC, 0xFF, 0x00, 0x7F, 0xEF, 0xF0, 0x01,
  0xFF, 0x7F, 0x80, 0x0F, 0xFB, 0xF8, 0x00, 0x3F, 0xDF, 0xC0, 0x01, 0xFE,
  0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0x00, 0x07, 0xFB, 0xF8, 0x00, 0x3F, 0xDF, 0xC0, 0x01, 0xFE, 0xFE, 0x00,
  0x1F, 0xF7, 0xF8, 0x00, 0xFF, 0x9F, 0xC0, 0x0F, 0xFC, 0xFF, 0x00, 0xFF,
  0xE3, 0xFE, 0x0F, 0xFF, 0x1F, 0xFF, 0xFB, 0xF8, 0x7F, 0xFF, 0xDF, 0xC1,
  0xFF, 0xFC, 0xFE, 0x07, 0xFF, 0xC3, 0xF0, 0x1F, 0xF8, 0x1F, 0x80, 0x0F,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x3F, 0xE1, 0xFF, 0x07, 0xF0,
  0x0F, 0xE1, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0xCF, 0xE0, 0x01, 0xF9,
  0xFC, 0x00, 0x3F, 0xBF, 0x80, 0x07, 0xF7, 0xE0, 0x00, 0xFE, 0xFC, 0x00,
  0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x10, 0xFF,
  0x00, 0x0E, 0x1F, 0xF8, 0x0F, 0xC1, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x01, 0x00, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x7F,
  0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xE7, 0x01, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0x80, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x07,
  0xFC, 0x0F, 0xC0, 0xFF, 0xF8, 0xFE, 0x0F, 0xFF, 0xE7, 0xF0, 0xFF, 0xFF,
  0x3F, 0x8F, 0xFF, 0xFD, 0xFC, 0x7F, 0xFF, 0xFF, 0xE7, 0xFC, 0x07, 0xFF,
  0x3F, 0xC0, 0x1F, 0xF9, 0xFC, 0x00, 0x7F, 0xDF, 0xE0, 0x03, 0xFE, 0xFE,
  0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x7F, 0xBF, 0x80, 0x03, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFE, 0xFE, 0x00, 0x0F,
  0xF7, 0xF0, 0x00, 0x7F, 0xBF, 0x80, 0x07, 0xFD, 0xFE, 0x00, 0x3F, 0xE7,
  0xF8, 0x03, 0xFF, 0x3F, 0xC0, 0x3F, 0xF8, 0xFF, 0x87, 0xFF, 0xC7, 0xFF,
  0xFE, 0xFE, 0x1F, 0xFF, 0xF7, 0xF0, 0x7F, 0xFF, 0x3F, 0x81, 0xFF, 0xF1,
  0xFC, 0x07, 0xFE, 0x0F, 0xE0, 0x07, 0x80, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x84, 0x00, 0x03,
  0xFC, 0x38, 0x00, 0x3F, 0xE1, 0xFC, 0x07, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0xFF, 0xC0,
  0xFE, 0x3F, 0xFC, 0x1F, 0xDF, 0xFF, 0xE3, 0xF3, 0xFF, 0xFC, 0x7E, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0xC0, 0xFF, 0xBF, 0xE0, 0x0F, 0xF7,
  0xFC, 0x00, 0xFE, 0xFF, 0x00, 0x1F, 0xDF, 0xE0, 0x03, 0xFB, 0xF8, 0x00,
  0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F,
  0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F,
  0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0xFE, 0x3E, 0x7F, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F,
  0x7E, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F,
  0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F,
  0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F,
  0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x00, 0xF8, 0x07,
  0xF0, 0x1F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xC0, 0x7E, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x03, 0xF8, 0x0F, 0xE8, 0xFF, 0xBF,
  0xFE, 0xFF, 0xF3, 0xFF, 0xCF, 0xFE, 0x3F, 0xF0, 0x3E, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xDF, 0xC0, 0x0F, 0xF3, 0xF8,
  0x01, 0xFC, 0x7F, 0x00, 0x7F, 0x0F, 0xE0, 0x1F, 0xE1, 0xFC, 0x03, 0xF8,
  0x3F, 0x80, 0xFE, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x0F, 0xF0, 0x1F, 0xC1,
  0xFC, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x1F, 0xE0, 0x0F, 0xE3, 0xF8, 0x01,
  0xFC, 0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x07, 0xE7, 0xF8, 0x00, 0xFD, 0xFF,
  0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x0F,
  0xFD, 0xFE, 0x01, 0xFF, 0x1F, 0xC0, 0x3F, 0xC3, 0xFC, 0x07, 0xF0, 0x3F,
  0x80, 0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0x7F, 0x03, 0xF8, 0x0F, 0xF0, 0x7F,
  0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0xE1, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x3F,
  0xC7, 0xF0, 0x03, 0xF8, 0xFE, 0x00, 0x7F, 0x9F, 0xC0, 0x07, 0xF3, 0xF8,
  0x00, 0xFF, 0x7F, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x07, 0xC0, 0xFF, 0x80, 0x1F, 0xF0, 0x3F, 0x1F, 0xFF, 0x03, 0xFF,
  0xE1, 0xF9, 0xFF, 0xFC, 0x3F, 0xFF, 0x8F, 0xDF, 0xFF, 0xF3, 0xFF, 0xFE,
  0x7E, 0xFF, 0xFF, 0xBF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF,
  0xF8, 0x0F, 0xFF, 0x03, 0xFE, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xF7, 0xF8,
  0x01, 0xFF, 0x00, 0x3F, 0xBF, 0xC0, 0x0F, 0xF8, 0x01, 0xFD, 0xFE, 0x00,
  0x7F, 0x80, 0x0F, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x0F,
  0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xFF,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0x80,
  0x07, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xFF, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xF0, 0x00,
  0xFF, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0x00, 0x1F, 0x03, 0xFF, 0x03, 0xF0, 0xFF, 0xF8, 0x7E, 0x7F,
  0xFF, 0x8F, 0xCF, 0xFF, 0xF1, 0xFB, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE7,
  0xFE, 0x03, 0xFE, 0xFF, 0x80, 0x3F, 0xDF, 0xE0, 0x03, 0xFB, 0xFC, 0x00,
  0x7F, 0x7F, 0x80, 0x0F, 0xEF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F,
  0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F,
  0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xF8,
  0x00, 0x02, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xF7,
  0xFF, 0x03, 0xFC, 0x07, 0xFC, 0x3F, 0xC0, 0x1F, 0xE1, 0xFC, 0x00, 0x7F,
  0x1F, 0xE0, 0x01, 0xFC, 0xFE, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x7F, 0x3F,
  0x80, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xDF, 0xC0,
  0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x7F, 0x3F, 0xC0, 0x03,
  0xF8, 0xFE, 0x00, 0x3F, 0xC7, 0xF8, 0x01, 0xFC, 0x1F, 0xE0, 0x1F, 0xE0,
  0xFF, 0x83, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0x00, 0x0F, 0x81, 0xFF, 0x80, 0xFC, 0x3F, 0xFC, 0x0F,
  0xC7, 0xFF, 0xE0, 0xFC, 0xFF, 0xFF, 0x0F, 0xDF, 0xFF, 0xF8, 0xFF, 0xF9,
  0xFF, 0xCF, 0xFC, 0x03, 0xFC, 0xFF, 0x80, 0x1F, 0xCF, 0xF0, 0x01, 0xFE,
  0xFF, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0xFE, 0xFF, 0x00,
  0x1F, 0xEF, 0xF8, 0x01, 0xFC, 0xFF, 0xC0, 0x3F, 0xCF, 0xFF, 0x8F, 0xFC,
  0xFD, 0xFF, 0xFF, 0x8F, 0xCF, 0xFF, 0xF0, 0xFE, 0xFF, 0xFE, 0x0F, 0xE3,
  0xFF, 0xC0, 0xFE, 0x1F, 0xF8, 0x0F, 0xE0, 0x3C, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x07, 0xFC, 0x0F,
  0xC0, 0xFF, 0xF8, 0xFE, 0x0F, 0xFF, 0xE7, 0xF0, 0xFF, 0xFF, 0x3F, 0x8F,
  0xFF, 0xFD, 0xFC, 0x7F, 0xFF, 0xFF, 0xE7, 0xFC, 0x07, 0xFF, 0x3F, 0xC0,
  0x1F, 0xF9, 0xFC, 0x00, 0x7F, 0xDF, 0xE0, 0x03, 0xFE, 0xFE, 0x00, 0x0F,
  0xF7, 0xF0, 0x00, 0x7F, 0xBF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFE, 0xFE, 0x00, 0x0F, 0xF7, 0xF0,
  0x00, 0x7F, 0xBF, 0x80, 0x07, 0xFD, 0xFE, 0x00, 0x3F, 0xE7, 0xF8, 0x03,
  0xFF, 0x3F, 0xC0, 0x3F, 0xF8, 0xFF, 0x87, 0xFF, 0xC7, 0xFF, 0xFE, 0xFE,
  0x1F, 0xFF, 0xF7, 0xF0, 0x7F, 0xFF, 0x3F, 0x81, 0xFF, 0xF1, 0xFC, 0x07,
  0xFE, 0x0F, 0xE0, 0x07, 0x80, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x01, 0x1F, 0x01, 0xFF, 0xE0, 0xFF, 0x7E,
  0x3F, 0xEF, 0xCF, 0xFD, 0xF9, 0xFF, 0xBF, 0x7F, 0xF7, 0xEF, 0xFE, 0xFF,
  0xE0, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x10, 0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xEF, 0xF8, 0x3F, 0x3F, 0x80, 0x1C, 0xFE,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xF0, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x07,
  0xFF, 0x80, 0x07, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xE0, 0x03, 0xFB, 0xF0, 0x3F, 0xEF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x03, 0xFF, 0xF0,
  0x00, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC3, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x07, 0xF8, 0x60, 0xFF, 0xFC, 0x1F, 0xFF, 0x81, 0xFF, 0xF0,
  0x1F, 0xFE, 0x01, 0xFF, 0xC0, 0x07, 0x80, 0xFC, 0x00, 0x1F, 0xFF, 0x00,
  0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF,
  0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F,
  0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00,
  0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC,
  0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F,
  0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00,
  0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8,
  0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFE, 0x03, 0xFF, 0x7F, 0xC7, 0xFF, 0xDF, 0xFF, 0xFB, 0xF3, 0xFF, 0xFE,
  0xFC, 0xFF, 0xFF, 0x3F, 0x1F, 0xFF, 0x87, 0xC1, 0xFF, 0x81, 0xF0, 0x07,
  0x80, 0x00, 0xFE, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x07, 0xF7, 0xF0, 0x00,
  0x3F, 0x9F, 0xC0, 0x00, 0xFE, 0x7F, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x1F,
  0xE3, 0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xF0,
  0x7F, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0xFE, 0x03, 0xF0, 0x03, 0xF8, 0x0F,
  0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xF8,
  0x07, 0xF0, 0x07, 0xF0, 0x1F, 0x80, 0x1F, 0xC0, 0xFE, 0x00, 0x3F, 0x03,
  0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF8, 0x3F, 0x00, 0x0F, 0xE1, 0xFC,
  0x00, 0x1F, 0x87, 0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x01, 0xFC, 0xFE, 0x00,
  0x03, 0xF3, 0xF8, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x3F, 0x3F, 0x00, 0x00,
  0xFE, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFE,
  0x7E, 0x00, 0x3F, 0xF0, 0x03, 0xF9, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xE7,
  0xF0, 0x03, 0xFF, 0x00, 0x3F, 0x9F, 0xC0, 0x1F, 0xFC, 0x00, 0xFC, 0x3F,
  0x00, 0x7D, 0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xF7, 0xE0, 0x1F, 0xC3, 0xF8,
  0x07, 0xCF, 0x80, 0x7F, 0x0F, 0xE0, 0x3F, 0x3E, 0x01, 0xF8, 0x1F, 0x80,
  0xFC, 0xF8, 0x0F, 0xE0, 0x7E, 0x03, 0xF3, 0xF0, 0x3F, 0x81, 0xFC, 0x0F,
  0x8F, 0xC0, 0xFE, 0x07, 0xF0, 0x7E, 0x1F, 0x03, 0xF0, 0x1F, 0xC1, 0xF8,
  0x7C, 0x0F, 0xC0, 0x3F, 0x07, 0xE1, 0xF8, 0x7F, 0x00, 0xFE, 0x1F, 0x87,
  0xE1, 0xFC, 0x03, 0xF8, 0x7C, 0x1F, 0x87, 0xE0, 0x0F, 0xE3, 0xF0, 0x3E,
  0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0xF8, 0xFE, 0x00, 0x7E, 0x3F, 0x03, 0xF3,
  0xF8, 0x01, 0xF8, 0xF8, 0x0F, 0xCF, 0xC0, 0x07, 0xF3, 0xE0, 0x3F, 0x3F,
  0x00, 0x0F, 0xDF, 0x80, 0x7C, 0xFC, 0x00, 0x3F, 0x7E, 0x01, 0xF3, 0xF0,
  0x00, 0xFD, 0xF8, 0x07, 0xDF, 0xC0, 0x03, 0xF7, 0xC0, 0x1F, 0xFE, 0x00,
  0x0F, 0xDF, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x00,
  0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xE0, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x7F, 0x8F,
  0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x3F, 0x81, 0xFC, 0x01, 0xFC, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0xFE, 0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x7F,
  0x00, 0x3F, 0x87, 0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x07, 0xF3, 0xF8, 0x00,
  0x1F, 0xDF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F,
  0xCF, 0xE0, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x7F, 0x0F,
  0xF0, 0x07, 0xF0, 0x3F, 0x80, 0x3F, 0x81, 0xFE, 0x03, 0xF8, 0x07, 0xF0,
  0x1F, 0xC0, 0x3F, 0xC1, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF8, 0xFF,
  0x00, 0x1F, 0xC7, 0xF0, 0x00, 0xFF, 0x7F, 0x80, 0x03, 0xFC, 0xFF, 0x00,
  0x01, 0xFD, 0xFC, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x3F, 0x9F, 0xC0, 0x00,
  0xFE, 0x3F, 0x80, 0x03, 0xF8, 0xFE, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x7F,
  0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x81,
  0xFC, 0x00, 0xFE, 0x03, 0xF8, 0x03, 0xF8, 0x0F, 0xE0, 0x0F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0x7E, 0x01, 0xFC, 0x01, 0xFC, 0x07, 0xF0, 0x07, 0xF0,
  0x1F, 0x80, 0x0F, 0xC0, 0xFE, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFE, 0x0F,
  0xC0, 0x01, 0xF8, 0x7F, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x1F, 0xC7, 0xF0,
  0x00, 0x7F, 0x1F, 0x80, 0x00, 0xFC, 0xFE, 0x00, 0x03, 0xF3, 0xF8, 0x00,
  0x0F, 0xEF, 0xC0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x43, 0xFE,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x80,
  0x3F, 0xF8, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x3F, 0xF0, 0x0F,
  0xFF, 0x00, 0x7F, 0xE0, 0x03, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x00,
  0x07, 0xF0, 0x01, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFC, 0x01, 0xFE, 0x00,
  0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x0F,
  0xF0, 0x00, 0xFC, 0x00, 0x00, 0x01, 0x80, 0x00, 0x08, 0x7F, 0xC0, 0x00,
  0x4F, 0xFF, 0x80, 0x06, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0xC0, 0x01,
  0xFF, 0xE4, 0x00, 0x01, 0xFC, 0x00,
};

const GFXglyph NotoSans_Condensed_Medium70pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 9, 51, 18, 4, -50 },
  { 59, 21, 18, 28, 4, -50 },
  { 107, 34, 50, 37, 1, -50 },
  { 320, 28, 57, 34, 3, -53 },
  { 520, 46, 52, 52, 3, -51 },
  { 819, 38, 52, 40, 2, -51 },
  { 1066, 8, 18, 16, 4, -50 },
  { 1084, 16, 61, 21, 3, -50 },
  { 1206, 16, 61, 21, 2, -50 },
  { 1328, 27, 27, 32, 2, -53 },
  { 1420, 29, 33, 34, 2, -41 },
  { 1540, 10, 17, 17, 3, -8 },
  { 1562, 16, 6, 21, 2, -22 },
  { 1574, 9, 10, 17, 4, -9 },
  { 1586, 25, 50, 27, 1, -50 },
  { 1743, 28, 52, 33, 3, -51 },
  { 1925, 19, 50, 33, 4, -50 },
  { 2044, 27, 51, 33, 3, -51 },
  { 2217, 27, 52, 33, 3, -51 },
  { 2393, 31, 50, 33, 1, -50 },
  { 2587, 26, 51, 33, 4, -50 },
  { 2753, 28, 52, 33, 3, -51 },
  { 2935, 29, 50, 33, 2, -50 },
  { 3117, 28, 52, 33, 3, -51 },
  { 3299, 27, 52, 33, 3, -51 },
  { 3475, 9, 39, 17, 4, -38 },
  { 3519, 11, 47, 17, 2, -38 },
  { 3584, 29, 32, 34, 2, -41 },
  { 3700, 28, 20, 34, 3, -35 },
  { 3770, 29, 32, 34, 2, -41 },
  { 3886, 23, 52, 26, 1, -51 },
  { 4036, 46, 56, 52, 3, -50 },
  { 4358, 37, 50, 37, 0, -50 },
  { 4590, 30, 50, 38, 5, -50 },
  { 4778, 30, 52, 36, 4, -51 },
  { 4973, 33, 50, 41, 5, -50 },
  { 5180, 22, 50, 32, 6, -50 },
  { 5318, 22, 50, 30, 6, -50 },
  { 5456, 34, 52, 42, 4, -51 },
  { 5677, 31, 50, 43, 6, -50 },
  { 5871, 17, 50, 22, 2, -50 },
  { 5978, 16, 64, 18, -4, -50 },
  { 6106, 30, 50, 36, 6, -50 },
  { 6294, 24, 50, 30, 5, -50 },
  { 6444, 44, 50, 55, 6, -50 },
  { 6719, 34, 50, 45, 6, -50 },
  { 6932, 36, 52, 44, 4, -51 },
  { 7166, 28, 50, 35, 5, -50 },
  { 7341, 36, 63, 44, 4, -51 },
  { 7625, 31, 50, 37, 5, -50 },
  { 7819, 26, 52, 32, 3, -51 },
  { 7988, 29, 50, 31, 1, -50 },
  { 8170, 32, 51, 42, 5, -50 },
  { 8374, 35, 50, 35, 0, -50 },
  { 8593, 55, 50, 55, 0, -50 },
  { 8937, 33, 50, 33, 0, -50 },
  { 9144, 33, 50, 33, 0, -50 },
  { 9351, 27, 50, 30, 2, -50 },
  { 9520, 15, 61, 22, 5, -50 },
  { 9635, 25, 50, 27, 1, -50 },
  { 9792, 15, 61, 22, 2, -50 },
  { 9907, 31, 29, 35, 2, -50 },
  { 10020, 30, 5, 30, 0, 6 },
  { 10039, 14, 12, 20, 3, -54 },
  { 10060, 25, 39, 33, 3, -38 },
  { 10182, 28, 54, 36, 5, -53 },
  { 10371, 23, 40, 28, 3, -39 },
  { 10486, 29, 54, 36, 3, -53 },
  { 10682, 27, 39, 33, 3, -38 },
  { 10814, 22, 54, 21, 1, -54 },
  { 10963, 29, 56, 36, 3, -39 },
  { 11166, 27, 53, 36, 5, -53 },
  { 11345, 8, 52, 17, 4, -52 },
  { 11397, 14, 69, 16, -2, -52 },
  { 11518, 27, 53, 32, 5, -53 },
  { 11697, 7, 53, 16, 5, -53 },
  { 11744, 45, 39, 54, 5, -39 },
  { 11964, 27, 39, 36, 5, -39 },
  { 12096, 29, 40, 35, 3, -39 },
  { 12241, 28, 56, 36, 5, -39 },
  { 12437, 29, 56, 36, 3, -39 },
  { 12640, 19, 39, 24, 5, -39 },
  { 12733, 22, 40, 27, 3, -39 },
  { 12843, 19, 47, 22, 1, -46 },
  { 12955, 26, 39, 36, 5, -38 },
  { 13082, 30, 38, 30, 0, -38 },
  { 13225, 46, 38, 48, 1, -38 },
  { 13444, 29, 38, 30, 1, -38 },
  { 13582, 30, 55, 30, 0, -38 },
  { 13789, 22, 38, 26, 2, -38 },
  { 13894, 21, 61, 26, 2, -50 },
  { 14055, 6, 70, 32, 13, -53 },
  { 14108, 20, 61, 26, 3, -50 },
  { 14261, 29, 10, 34, 2, -30 },
};

const GFXfont NotoSans_Condensed_Medium70pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Medium70pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Medium70pt7bGlyphs,
  0x20, 0x7E, 95
};

#endif // _NOTOSANS_CONDENSED_MEDIUM70PT7B_H_
