#ifndef _NOTOSANS_CONDENSED_MEDIUM34PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUM34PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Medium.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Medium34pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0x77, 0x77, 0x77, 0x77, 0x77, 0x70, 0x00, 0xFF,
  0xFF, 0xF3, 0xFC, 0xFE, 0x3F, 0x8F, 0xE1, 0xF8, 0x7E, 0x19, 0x86, 0x61,
  0x80, 0x07, 0x1C, 0x07, 0x1C, 0x07, 0x1C, 0x06, 0x18, 0x06, 0x18, 0x06,
  0x18, 0x0E, 0x38, 0x7F, 0xFF, 0x7F, 0xFF, 0x0E, 0x38, 0x0C, 0x30, 0x0C,
  0x30, 0x0C, 0x30, 0x1C, 0x70, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x18,
  0x60, 0x18, 0x60, 0x18, 0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x38,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x3F, 0xC7, 0xFF, 0x7F, 0xFB, 0xD8,
  0xDC, 0xC0, 0xE6, 0x07, 0x30, 0x39, 0x81, 0xFC, 0x07, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0xFE, 0x06, 0x70, 0x33, 0xC1, 0x8E, 0x0C, 0x78, 0x67, 0x7F,
  0xFB, 0xFF, 0x9F, 0xF8, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x08,
  0x00, 0x00, 0x7E, 0x03, 0x81, 0xFC, 0x06, 0x03, 0x9C, 0x1C, 0x06, 0x38,
  0x30, 0x1C, 0x70, 0xE0, 0x38, 0x61, 0xC0, 0x70, 0xC7, 0x00, 0xE1, 0x8E,
  0x01, 0xC3, 0x18, 0x03, 0x8E, 0x71, 0xC3, 0x1C, 0xEF, 0xC7, 0x3B, 0x9F,
  0xCF, 0xE7, 0x71, 0x8F, 0xCC, 0xE3, 0x86, 0x39, 0xC7, 0x00, 0x63, 0x8E,
  0x01, 0xC7, 0x1C, 0x03, 0x8E, 0x38, 0x0E, 0x1C, 0x70, 0x1C, 0x38, 0xE0,
  0x30, 0x71, 0xC0, 0xE0, 0x77, 0x01, 0xC0, 0xFE, 0x07, 0x00, 0xF8, 0x03,
  0x80, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0xF3, 0xC0, 0x38, 0x70, 0x0E, 0x1C,
  0x03, 0x87, 0x00, 0xF1, 0xC0, 0x1C, 0xF0, 0x07, 0x78, 0x01, 0xFC, 0x00,
  0x3E, 0x00, 0x1F, 0x80, 0x0F, 0xF0, 0xE7, 0xBC, 0x39, 0xC7, 0x9E, 0xF0,
  0xF7, 0xBC, 0x1F, 0xCF, 0x07, 0xF3, 0xC0, 0xF8, 0xF0, 0x1E, 0x1E, 0x1F,
  0xC7, 0xFF, 0xF0, 0xFF, 0xDE, 0x1F, 0xC3, 0xC0, 0xFF, 0xEE, 0xEE, 0xE6,
  0x60, 0x0E, 0x38, 0x71, 0xC3, 0x8E, 0x1C, 0x78, 0xE1, 0xC3, 0x87, 0x0E,
  0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1E, 0x1C, 0x38, 0x78, 0x70,
  0xF0, 0xE0, 0xE0, 0xE0, 0x70, 0x38, 0x38, 0x1C, 0x1C, 0x1C, 0x0E, 0x0E,
  0x0E, 0x0E, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0E, 0x0E, 0x0E,
  0x0E, 0x1E, 0x1C, 0x3C, 0x38, 0x38, 0x70, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x06, 0x73, 0xFF, 0xFF, 0xFF, 0xE0, 0xF0, 0x0F, 0x80, 0xEE,
  0x0F, 0x38, 0x71, 0xE1, 0x84, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x3F, 0xFF, 0xFF, 0xFC, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x39, 0xDE,
  0xF7, 0x39, 0xDC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x03, 0x80,
  0x3C, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0x80, 0x1C,
  0x01, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0x03,
  0x00, 0x3F, 0x81, 0xFE, 0x0F, 0xBC, 0x38, 0x79, 0xE0, 0xE7, 0x03, 0x9C,
  0x0E, 0x70, 0x3D, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0x70, 0x3D, 0xC0, 0xF7, 0x03, 0x9C, 0x0E, 0x78, 0x78,
  0xE1, 0xE3, 0xFF, 0x07, 0xF8, 0x0F, 0xC0, 0x07, 0x87, 0xC7, 0xE7, 0xF7,
  0xBF, 0x9D, 0x8E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x00,
  0xFF, 0x87, 0xFF, 0x3E, 0x7C, 0x60, 0x78, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x00, 0xE0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x06, 0x00, 0xFF, 0x8F, 0xFF, 0x1E,
  0x3E, 0x60, 0x78, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xC0,
  0x0F, 0x07, 0xF0, 0x1F, 0x80, 0x7F, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x38,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3A, 0x01, 0xEF, 0xFF, 0x3F, 0xFC,
  0x7F, 0xC0, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x37, 0x00,
  0xEE, 0x01, 0xDC, 0x07, 0x38, 0x0C, 0x70, 0x38, 0xE0, 0x61, 0xC1, 0xC3,
  0x83, 0x07, 0x0E, 0x0E, 0x38, 0x1C, 0x70, 0x38, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x7F,
  0xE3, 0xFF, 0x1F, 0xF8, 0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00,
  0xE0, 0x07, 0xFC, 0x3F, 0xF9, 0xFF, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x01, 0xE8, 0x0F, 0x7F, 0xF3, 0xFF,
  0x1F, 0xF0, 0x00, 0xE0, 0x1F, 0xE0, 0xFF, 0x87, 0xC2, 0x3C, 0x00, 0xE0,
  0x03, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x7E, 0x1F, 0xFC, 0x7E,
  0xFB, 0xE0, 0xEF, 0x03, 0xFC, 0x0F, 0x70, 0x1D, 0xC0, 0x77, 0x03, 0xDC,
  0x0F, 0x78, 0x38, 0xE1, 0xE3, 0xFF, 0x87, 0xFC, 0x0F, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x1C,
  0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x78,
  0x01, 0xE0, 0x0F, 0x00, 0x03, 0x80, 0x7F, 0x83, 0xFF, 0x1F, 0x1E, 0x78,
  0x39, 0xC0, 0xE7, 0x03, 0x9C, 0x0E, 0x78, 0x38, 0xF1, 0xE3, 0xFF, 0x07,
  0xF8, 0x0F, 0xC0, 0x7F, 0x83, 0xCF, 0x1E, 0x1E, 0x70, 0x3F, 0xC0, 0xFF,
  0x01, 0xFC, 0x07, 0xF0, 0x3D, 0xC0, 0xF7, 0xEF, 0x8F, 0xFC, 0x1F, 0xE0,
  0x03, 0x00, 0x7F, 0x03, 0xFE, 0x1F, 0x3C, 0x78, 0x79, 0xC0, 0xEF, 0x03,
  0xBC, 0x0E, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xDC, 0x0F, 0x78, 0x7D, 0xFF,
  0xF3, 0xFF, 0xC7, 0xEE, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00,
  0x70, 0x07, 0xC3, 0xFE, 0x0F, 0xF0, 0x3F, 0x00, 0x2F, 0xFF, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x13, 0xDE, 0xF3, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x3B, 0xDE, 0xE7, 0x3B, 0x80, 0x00, 0x04, 0x00,
  0x70, 0x07, 0xC0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x3E, 0x00, 0xF8,
  0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x01, 0xF0, 0x01, 0xC0,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x03, 0x80, 0x0F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0x00, 0x7C, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x03, 0xE0, 0x0E, 0x00, 0x20, 0x00, 0x0E,
  0x07, 0xFC, 0xFF, 0xE7, 0xBE, 0x40, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x07, 0x80, 0xF0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0xF0, 0x3C, 0x07, 0x00, 0x38,
  0x38, 0x00, 0x70, 0xE0, 0x00, 0xC7, 0x07, 0xE3, 0x98, 0x3F, 0x8E, 0xE1,
  0xC6, 0x1B, 0x8E, 0x18, 0x6E, 0x38, 0x61, 0xF0, 0xC3, 0x87, 0xC7, 0x0E,
  0x1F, 0x1C, 0x38, 0x6C, 0x70, 0xE1, 0xB1, 0xC3, 0x86, 0xC3, 0x0E, 0x3B,
  0x8E, 0x6C, 0xCE, 0x1F, 0xBF, 0x38, 0x7C, 0x78, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x40, 0x1F, 0xDF, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x07, 0xF0, 0x01, 0xDE, 0x00, 0x73, 0x80, 0x1C, 0xE0, 0x0F, 0x38,
  0x03, 0x8F, 0x00, 0xE1, 0xC0, 0x38, 0x70, 0x1E, 0x1E, 0x07, 0x07, 0x81,
  0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFF, 0x0E, 0x03, 0xC3, 0x80, 0x71, 0xE0,
  0x1E, 0x78, 0x07, 0x9C, 0x00, 0xEF, 0x00, 0x3B, 0xC0, 0x0F, 0xFF, 0xC3,
  0xFF, 0xCF, 0xFF, 0xB8, 0x1E, 0xE0, 0x7B, 0x80, 0xEE, 0x03, 0xB8, 0x0E,
  0xE0, 0x7B, 0x83, 0xCF, 0xFE, 0x3F, 0xF0, 0xFF, 0xF3, 0x81, 0xEE, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x7B, 0xFF,
  0xEF, 0xFF, 0x3F, 0xF0, 0x00, 0xC0, 0x1F, 0xF1, 0xFF, 0xCF, 0xCF, 0x3C,
  0x05, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x1E, 0x00, 0x78, 0x00, 0xF8, 0x13, 0xFF, 0xC7, 0xFF, 0x07, 0xF8,
  0xFF, 0xC1, 0xFF, 0xE3, 0xFF, 0xE7, 0x03, 0xCE, 0x03, 0xDC, 0x07, 0xB8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3B, 0x80, 0xF7,
  0x03, 0xEE, 0x0F, 0x9F, 0xFE, 0x3F, 0xF8, 0x7F, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0xFF,
  0x7F, 0xEF, 0xFD, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x7F, 0xEF, 0xFD,
  0xFF, 0xB8, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0x00, 0x60, 0x07, 0xFE, 0x0F, 0xFF, 0x1F, 0x9F, 0x3E,
  0x02, 0x7C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xE0, 0x00, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0x70, 0x07, 0x78, 0x07, 0x78, 0x07, 0x3E, 0x07, 0x1F,
  0xFF, 0x0F, 0xFF, 0x07, 0xFE, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xFF, 0xFF, 0x3C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C,
  0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x3E,
  0xFF, 0xFF, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x0F, 0x0F, 0x9E, 0xFE, 0xFC, 0xF0, 0xE0, 0x3D, 0xC0,
  0xF3, 0x81, 0xE7, 0x07, 0x8E, 0x0E, 0x1C, 0x3C, 0x38, 0xF0, 0x71, 0xC0,
  0xE7, 0x81, 0xDE, 0x03, 0xB8, 0x07, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x3C,
  0xF0, 0x71, 0xE0, 0xE1, 0xE1, 0xC3, 0xC3, 0x83, 0xC7, 0x07, 0x8E, 0x07,
  0x9C, 0x0F, 0x38, 0x0F, 0x70, 0x1F, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xF8,
  0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xDF, 0xB8, 0x0E, 0xFD, 0xC0, 0x77,
  0xEE, 0x03, 0xBF, 0x70, 0x39, 0xF9, 0xC1, 0xCF, 0xCE, 0x0E, 0x7E, 0x70,
  0xE3, 0xF1, 0xC7, 0x1F, 0x8E, 0x38, 0xFC, 0x73, 0x87, 0xE1, 0xDC, 0x3F,
  0x0E, 0xE1, 0xF8, 0x76, 0x0F, 0xC3, 0xF0, 0x7E, 0x0F, 0x83, 0xF0, 0x7C,
  0x1F, 0x83, 0xC0, 0xFC, 0x0E, 0x07, 0xF0, 0x07, 0xF8, 0x07, 0xF8, 0x07,
  0xFC, 0x07, 0xFC, 0x07, 0xFE, 0x07, 0xEE, 0x07, 0xEF, 0x07, 0xE7, 0x07,
  0xE7, 0x87, 0xE3, 0x87, 0xE3, 0xC7, 0xE1, 0xC7, 0xE1, 0xE7, 0xE1, 0xE7,
  0xE0, 0xF7, 0xE0, 0xF7, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0x3F, 0xE0, 0x3F,
  0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0x00, 0xC0, 0x03, 0xFE, 0x01, 0xFF,
  0xC0, 0xFD, 0xF8, 0x7C, 0x0F, 0x1E, 0x01, 0xC7, 0x00, 0x7B, 0xC0, 0x1E,
  0xF0, 0x03, 0xBC, 0x00, 0xEE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x03, 0xBC, 0x00, 0xEF, 0x00,
  0x79, 0xE0, 0x1E, 0x78, 0x0F, 0x0F, 0x07, 0xC3, 0xFF, 0xE0, 0x7F, 0xF0,
  0x07, 0xF8, 0x00, 0xFF, 0x87, 0xFF, 0x3F, 0xFD, 0xC1, 0xEE, 0x07, 0xF0,
  0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x3D, 0xC7, 0xEF, 0xFE,
  0x7F, 0xE3, 0xF8, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x00, 0xC0, 0x03, 0xFE, 0x01, 0xFF,
  0xC0, 0xFD, 0xF8, 0x7C, 0x0F, 0x1E, 0x01, 0xC7, 0x00, 0x7B, 0xC0, 0x1E,
  0xF0, 0x03, 0xBC, 0x00, 0xEE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x03, 0xBC, 0x00, 0xEF, 0x00,
  0x79, 0xE0, 0x1E, 0x78, 0x0F, 0x0F, 0x07, 0xC3, 0xFF, 0xE0, 0x7F, 0xF0,
  0x07, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0xF8, 0xFF, 0xC3, 0xFF, 0x8F, 0xFF, 0x38, 0x3C, 0xE0,
  0x7B, 0x81, 0xEE, 0x07, 0xB8, 0x1E, 0xE0, 0x7B, 0x81, 0xEE, 0x0F, 0x3F,
  0xF8, 0xFF, 0xC3, 0xFE, 0x0E, 0x3C, 0x38, 0x70, 0xE1, 0xE3, 0x87, 0x8E,
  0x0F, 0x38, 0x3C, 0xE0, 0x7B, 0x81, 0xEE, 0x03, 0xF8, 0x0F, 0x03, 0x00,
  0xFF, 0x8F, 0xFE, 0xFF, 0xE7, 0x81, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0xC0, 0x1F, 0x00, 0x7E, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x78, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0xE0, 0x7F, 0xFF, 0xDF,
  0xFC, 0x7F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x70, 0x0F,
  0x70, 0x0F, 0x78, 0x0E, 0x7C, 0x1E, 0x3F, 0xFC, 0x1F, 0xFC, 0x0F, 0xF0,
  0xF0, 0x07, 0xF8, 0x03, 0xDC, 0x01, 0xCE, 0x00, 0xE7, 0x80, 0xF1, 0xC0,
  0x78, 0xE0, 0x38, 0x78, 0x1C, 0x3C, 0x1E, 0x0E, 0x0F, 0x07, 0x07, 0x03,
  0xC3, 0x81, 0xE3, 0xC0, 0x71, 0xC0, 0x38, 0xE0, 0x1E, 0x70, 0x07, 0x78,
  0x03, 0xB8, 0x01, 0xDC, 0x00, 0xEE, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x03, 0xC0, 0xF0, 0x0E, 0x01, 0xFE, 0x03, 0xC0, 0x39, 0xC0, 0x7C,
  0x07, 0x38, 0x0F, 0x80, 0xE7, 0x81, 0xF0, 0x3C, 0xF0, 0x36, 0x07, 0x8E,
  0x0E, 0xE0, 0xE1, 0xC1, 0xDC, 0x1C, 0x38, 0x3B, 0x87, 0x87, 0x87, 0x70,
  0xF0, 0xF1, 0xC6, 0x1C, 0x0E, 0x38, 0xE3, 0x81, 0xC7, 0x1C, 0x70, 0x38,
  0xE3, 0x9E, 0x07, 0xB8, 0x73, 0xC0, 0x77, 0x07, 0x70, 0x0E, 0xE0, 0xEE,
  0x01, 0xDC, 0x1D, 0xC0, 0x3B, 0x83, 0xF8, 0x07, 0x60, 0x3E, 0x00, 0x7C,
  0x07, 0xC0, 0x0F, 0x80, 0xF8, 0x01, 0xF0, 0x1F, 0x00, 0x3C, 0x03, 0xE0,
  0x78, 0x0F, 0x38, 0x1E, 0x3C, 0x1C, 0x3C, 0x3C, 0x1C, 0x38, 0x1E, 0x78,
  0x0E, 0x78, 0x0F, 0x70, 0x07, 0xF0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xC0,
  0x03, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x0F, 0x70, 0x0E, 0x78, 0x1E, 0x38,
  0x1C, 0x3C, 0x3C, 0x3C, 0x38, 0x1C, 0x78, 0x1E, 0x78, 0x0E, 0xF0, 0x0F,
  0xF0, 0x0F, 0x70, 0x0E, 0x78, 0x1E, 0x38, 0x1C, 0x3C, 0x3C, 0x3C, 0x38,
  0x1C, 0x38, 0x1E, 0x78, 0x0E, 0x70, 0x0E, 0xF0, 0x0F, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80,
  0x38, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x78,
  0x03, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xFF, 0xFF, 0xF0, 0x03, 0x80, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x70,
  0x03, 0xC0, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x01, 0xC0,
  0x0E, 0x00, 0x78, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0xFF,
  0xFC, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3,
  0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x3F, 0xFF,
  0xE0, 0x03, 0x80, 0x07, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0xEE, 0x01, 0xDC,
  0x07, 0x1C, 0x0E, 0x38, 0x38, 0x38, 0x70, 0x71, 0xC0, 0x73, 0x80, 0xEE,
  0x00, 0xFC, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8, 0xF0, 0xF0, 0xE0,
  0xE0, 0x03, 0x01, 0xFF, 0x0F, 0xFC, 0x61, 0xE0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x0F, 0xF9, 0xFF, 0xDF, 0x1E, 0xE0, 0xFF, 0x07, 0xF8, 0x3F,
  0xC1, 0xFE, 0x1F, 0x79, 0xFB, 0xFD, 0xCF, 0xCE, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x70, 0xF7, 0xE3,
  0xFF, 0xCF, 0xCF, 0xBE, 0x0E, 0xF0, 0x3F, 0xC0, 0xFF, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x87,
  0xBF, 0xFE, 0xEF, 0xF3, 0x9F, 0x80, 0x07, 0x03, 0xFC, 0xFF, 0x3C, 0x6F,
  0x01, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x3C, 0x07, 0x81, 0x7F, 0xE7, 0xFC, 0x7F, 0x00, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC1, 0xC7, 0x1F,
  0xDC, 0xFF, 0xF3, 0xC7, 0xDE, 0x0F, 0x78, 0x3D, 0xC0, 0x77, 0x01, 0xDC,
  0x07, 0xF0, 0x1F, 0xC0, 0x77, 0x01, 0xDC, 0x07, 0x70, 0x1D, 0xE0, 0xF7,
  0x83, 0xCF, 0xFF, 0x3F, 0xDC, 0x3E, 0x70, 0x07, 0x00, 0xFE, 0x0F, 0xF8,
  0xF1, 0xEF, 0x07, 0x70, 0x3B, 0x81, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x02, 0x7E, 0xF1, 0xFF,
  0x87, 0xF8, 0x07, 0xE1, 0xFC, 0x7F, 0x0F, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x7F, 0xDF, 0xF8, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x07, 0x00, 0x7F, 0x73, 0xFF, 0xCF, 0x1F, 0x78, 0x3D, 0xE0,
  0xF7, 0x01, 0xDC, 0x07, 0x70, 0x1F, 0xC0, 0x7F, 0x01, 0xDC, 0x07, 0x70,
  0x1D, 0xC0, 0x77, 0x83, 0xDE, 0x0F, 0x3F, 0xFC, 0xFF, 0x70, 0xF9, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC8, 0x1E, 0x3F, 0xF8, 0xFF, 0xC1,
  0xFC, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x38, 0xF7, 0xF7, 0xFF, 0xBF, 0x3F, 0xF0, 0xFF, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xC0, 0xFF, 0xF6, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1E, 0x3C,
  0x78, 0x60, 0x00, 0x00, 0x0F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F,
  0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3,
  0xFF, 0x7E, 0xF8, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x7B, 0xC3, 0xCF, 0x0E, 0x3C, 0x78,
  0xF3, 0xC3, 0xCE, 0x0F, 0x70, 0x3F, 0xC0, 0xFF, 0x83, 0xFE, 0x0F, 0xBC,
  0x3C, 0x70, 0xF1, 0xE3, 0xC3, 0x8F, 0x0F, 0x3C, 0x1C, 0xF0, 0x7B, 0xC0,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x01, 0xC0, 0xC3, 0x9F, 0x8F, 0xEE, 0xFF, 0x7F, 0xBF, 0x3F,
  0x9F, 0xF8, 0x7C, 0x3F, 0xC1, 0xE0, 0x7F, 0x03, 0x81, 0xFC, 0x0E, 0x07,
  0xF0, 0x38, 0x1F, 0xC0, 0xE0, 0x7F, 0x03, 0x81, 0xFC, 0x0E, 0x07, 0xF0,
  0x38, 0x1F, 0xC0, 0xE0, 0x7F, 0x03, 0x81, 0xFC, 0x0E, 0x07, 0xF0, 0x38,
  0x1F, 0xC0, 0xE0, 0x7F, 0x03, 0x81, 0xC0, 0x01, 0x87, 0x3F, 0xBB, 0xFD,
  0xF8, 0xFF, 0x87, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC,
  0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81,
  0xFC, 0x0E, 0x03, 0x80, 0x1F, 0xC0, 0xFF, 0xE1, 0xE3, 0xC7, 0x83, 0xCE,
  0x03, 0x9C, 0x07, 0x38, 0x0F, 0x70, 0x1F, 0xE0, 0x3F, 0xC0, 0x7B, 0x80,
  0xF7, 0x01, 0xCE, 0x03, 0x9E, 0x0F, 0x1C, 0x1E, 0x3E, 0xF8, 0x3F, 0xE0,
  0x3F, 0x80, 0x01, 0xC3, 0x9F, 0x8E, 0xFF, 0x3F, 0x3E, 0xF8, 0x3B, 0xC0,
  0xFF, 0x03, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFE, 0x1E, 0xFF, 0xFB, 0xFF, 0xCF, 0x7E, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x00, 0x07, 0x00, 0x7F, 0x73, 0xFF, 0xCF, 0x1F, 0x78, 0x3D, 0xE0,
  0xF7, 0x01, 0xDC, 0x07, 0x70, 0x1F, 0xC0, 0x7F, 0x01, 0xDC, 0x07, 0x70,
  0x1D, 0xC0, 0x77, 0x83, 0xDE, 0x0F, 0x3F, 0xFC, 0xFF, 0x70, 0xF9, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x01, 0xF3, 0xFB, 0xFD, 0xFF, 0x87, 0xC3, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x00,
  0x07, 0x07, 0xFD, 0xFF, 0xB8, 0x6F, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x7E,
  0x07, 0xF0, 0x3F, 0x01, 0xF0, 0x1E, 0x01, 0xC0, 0x3C, 0x0F, 0xFF, 0xFF,
  0xF9, 0xFE, 0x00, 0x38, 0x1C, 0x0E, 0x07, 0x0F, 0xFF, 0xFC, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0xF3, 0xF8, 0xFC, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F,
  0x03, 0xF8, 0x3D, 0xC1, 0xEF, 0xFF, 0x7F, 0xB9, 0xF9, 0xC0, 0xF0, 0x1E,
  0xE0, 0x39, 0xC0, 0xF3, 0xC1, 0xE3, 0x83, 0x87, 0x07, 0x0E, 0x1E, 0x1E,
  0x38, 0x1C, 0x70, 0x39, 0xE0, 0x73, 0x80, 0x77, 0x00, 0xEE, 0x01, 0xDC,
  0x03, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0xF0, 0x3C, 0x1E, 0xE0,
  0xF8, 0x39, 0xC1, 0xF0, 0x73, 0xC3, 0x60, 0xE7, 0x86, 0xE3, 0xC7, 0x1D,
  0xC7, 0x0E, 0x3B, 0x8E, 0x1C, 0x77, 0x1C, 0x3C, 0xC6, 0x38, 0x3B, 0x8E,
  0xF0, 0x77, 0x1D, 0xC0, 0xEE, 0x3B, 0x81, 0xDC, 0x77, 0x01, 0xB0, 0x6E,
  0x03, 0xE0, 0xF8, 0x07, 0xC1, 0xF0, 0x0F, 0x83, 0xE0, 0x1F, 0x03, 0xC0,
  0x78, 0x3C, 0xE0, 0xE3, 0xC7, 0x87, 0x1C, 0x1E, 0xF0, 0x3B, 0x80, 0xFE,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xB8, 0x1E, 0xE0, 0x71,
  0xC3, 0xC7, 0x8E, 0x0E, 0x78, 0x3F, 0xC0, 0xF0, 0xF0, 0x1E, 0xE0, 0x39,
  0xC0, 0xF3, 0xC1, 0xE3, 0x83, 0x87, 0x07, 0x0F, 0x1E, 0x0E, 0x38, 0x1C,
  0x70, 0x39, 0xE0, 0x7B, 0x80, 0x77, 0x00, 0xEE, 0x01, 0xDC, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x00,
  0xE0, 0x03, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xF0, 0x00, 0xFF, 0xDF, 0xF8,
  0x07, 0x01, 0xE0, 0x38, 0x0F, 0x01, 0xC0, 0x78, 0x0E, 0x03, 0xC0, 0x70,
  0x1E, 0x03, 0x80, 0xF0, 0x1C, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xC1,
  0xF0, 0xF8, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x78, 0x1C, 0x3F, 0x0F, 0x03, 0xF0, 0x1C, 0x07, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xF8, 0x1F, 0x03, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xF8, 0x3F, 0x07, 0xC0, 0x78, 0x1E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0F, 0x01, 0xF0, 0x1C, 0x1F, 0x0F, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x1E, 0x07, 0x83, 0xC3, 0xF0, 0xF8,
  0x00, 0x7E, 0x07, 0xFF, 0x7E, 0xFF, 0xE0, 0x7E,
};

const GFXglyph NotoSans_Condensed_Medium34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 4, 24, 9, 2, -24 },
  { 13, 10, 9, 14, 2, -24 },
  { 25, 16, 24, 18, 1, -24 },
  { 73, 13, 28, 16, 2, -26 },
  { 119, 23, 25, 25, 1, -25 },
  { 191, 18, 25, 19, 1, -25 },
  { 248, 4, 9, 8, 2, -24 },
  { 253, 7, 29, 10, 2, -24 },
  { 279, 8, 29, 10, 1, -24 },
  { 308, 13, 13, 15, 1, -26 },
  { 330, 14, 16, 16, 1, -20 },
  { 358, 5, 8, 8, 1, -4 },
  { 363, 8, 3, 10, 1, -11 },
  { 366, 4, 4, 8, 2, -4 },
  { 368, 13, 24, 13, 0, -24 },
  { 407, 14, 25, 16, 1, -25 },
  { 451, 9, 24, 16, 2, -24 },
  { 478, 14, 25, 16, 1, -25 },
  { 522, 14, 25, 16, 1, -25 },
  { 566, 15, 24, 16, 1, -24 },
  { 611, 13, 24, 16, 2, -24 },
  { 650, 14, 25, 16, 1, -25 },
  { 694, 14, 24, 16, 1, -24 },
  { 736, 14, 25, 16, 1, -25 },
  { 780, 14, 25, 16, 1, -25 },
  { 824, 4, 19, 8, 2, -19 },
  { 834, 5, 23, 8, 1, -19 },
  { 849, 14, 16, 16, 1, -20 },
  { 877, 14, 10, 16, 1, -17 },
  { 895, 14, 16, 16, 1, -20 },
  { 923, 12, 25, 12, 0, -25 },
  { 961, 22, 27, 25, 2, -24 },
  { 1036, 18, 24, 18, 0, -24 },
  { 1090, 14, 24, 18, 3, -24 },
  { 1132, 14, 25, 17, 2, -25 },
  { 1176, 15, 24, 20, 3, -24 },
  { 1221, 11, 24, 15, 3, -24 },
  { 1254, 11, 24, 15, 3, -24 },
  { 1287, 16, 25, 21, 2, -25 },
  { 1337, 15, 24, 21, 3, -24 },
  { 1382, 8, 24, 11, 1, -24 },
  { 1406, 8, 31, 9, -2, -24 },
  { 1437, 15, 24, 18, 3, -24 },
  { 1482, 11, 24, 15, 3, -24 },
  { 1515, 21, 24, 27, 3, -24 },
  { 1578, 16, 24, 22, 3, -24 },
  { 1626, 18, 25, 21, 2, -25 },
  { 1683, 13, 24, 17, 3, -24 },
  { 1722, 18, 31, 21, 2, -25 },
  { 1792, 14, 24, 18, 3, -24 },
  { 1834, 13, 25, 16, 1, -25 },
  { 1875, 15, 24, 15, 0, -24 },
  { 1920, 16, 24, 20, 2, -24 },
  { 1968, 17, 24, 17, 0, -24 },
  { 2019, 27, 24, 27, 0, -24 },
  { 2100, 16, 24, 16, 0, -24 },
  { 2148, 16, 24, 16, 0, -24 },
  { 2196, 13, 24, 15, 1, -24 },
  { 2235, 8, 29, 11, 2, -24 },
  { 2264, 13, 24, 13, 0, -24 },
  { 2303, 7, 29, 11, 1, -24 },
  { 2329, 15, 14, 17, 1, -24 },
  { 2356, 15, 2, 15, 0, 3 },
  { 2360, 7, 5, 10, 1, -26 },
  { 2365, 13, 19, 16, 1, -19 },
  { 2396, 14, 26, 18, 2, -26 },
  { 2442, 11, 19, 14, 2, -19 },
  { 2469, 14, 26, 18, 1, -26 },
  { 2515, 13, 19, 16, 2, -19 },
  { 2546, 11, 26, 10, 0, -26 },
  { 2582, 14, 27, 18, 1, -19 },
  { 2630, 13, 26, 18, 2, -26 },
  { 2673, 4, 25, 8, 2, -25 },
  { 2686, 7, 33, 8, -1, -25 },
  { 2715, 14, 26, 16, 2, -26 },
  { 2761, 4, 26, 8, 2, -26 },
  { 2774, 22, 19, 26, 2, -19 },
  { 2827, 13, 19, 18, 2, -19 },
  { 2858, 15, 19, 17, 1, -19 },
  { 2894, 14, 27, 18, 2, -19 },
  { 2942, 14, 27, 18, 1, -19 },
  { 2990, 9, 19, 12, 2, -19 },
  { 3012, 11, 19, 13, 1, -19 },
  { 3039, 9, 22, 11, 1, -22 },
  { 3064, 13, 18, 18, 2, -18 },
  { 3094, 15, 18, 15, 0, -18 },
  { 3128, 23, 18, 23, 0, -18 },
  { 3180, 14, 18, 15, 0, -18 },
  { 3212, 15, 26, 15, 0, -18 },
  { 3261, 11, 18, 12, 1, -18 },
  { 3286, 10, 29, 12, 1, -24 },
  { 3323, 3, 34, 16, 6, -26 },
  { 3336, 10, 29, 12, 1, -24 },
  { 3373, 14, 4, 16, 1, -14 },
};

const GFXfont NotoSans_Condensed_Medium34pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Medium34pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Medium34pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _NOTOSANS_CONDENSED_MEDIUM34PT7B_H_
