#ifndef _NOTOSANS_CONDENSED_MEDIUM40PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUM40PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Medium.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Medium40pt7bBitmaps[] PROGMEM = {
  0x00, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x79, 0xE7, 0x9E, 0x38, 0x00, 0x00, 0x79, 0xEF, 0xDE, 0x78, 0xF8,
  0xFF, 0x8F, 0xF8, 0xF7, 0x0F, 0x70, 0xF7, 0x0F, 0x70, 0xF7, 0x0F, 0x70,
  0xE7, 0x0E, 0x70, 0xE0, 0x01, 0xC3, 0x80, 0x70, 0xE0, 0x0E, 0x1C, 0x01,
  0xC3, 0x80, 0x38, 0x70, 0x07, 0x0E, 0x00, 0xE1, 0xC0, 0x1C, 0x38, 0x07,
  0x0E, 0x0F, 0xFF, 0xFD, 0xFF, 0xFF, 0x83, 0x87, 0x00, 0x70, 0xE0, 0x0E,
  0x1C, 0x01, 0xC3, 0x80, 0x70, 0xE0, 0x0E, 0x1C, 0x01, 0xC3, 0x83, 0xFF,
  0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC, 0x38, 0x78, 0x07, 0x0E, 0x00, 0xE1,
  0xC0, 0x1C, 0x38, 0x03, 0x87, 0x00, 0x70, 0xE0, 0x0E, 0x1C, 0x03, 0x87,
  0x00, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x7F, 0xC3, 0xFF, 0xEF, 0xFF,
  0xDF, 0x67, 0x78, 0xC2, 0xF1, 0x81, 0xE3, 0x03, 0xC6, 0x07, 0x8C, 0x0F,
  0x98, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x06,
  0xF8, 0x0C, 0xF0, 0x18, 0xE0, 0x31, 0xC0, 0x63, 0xC0, 0xCF, 0xF1, 0xFF,
  0xFF, 0xFB, 0xFF, 0xE1, 0xFE, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x1E, 0x00, 0x70, 0x0F, 0xC0, 0x1C, 0x07, 0xF8, 0x0F, 0x03, 0xCE,
  0x03, 0x80, 0xE3, 0xC1, 0xE0, 0x38, 0x70, 0x70, 0x0E, 0x1C, 0x1C, 0x03,
  0x87, 0x0E, 0x00, 0xE1, 0xC3, 0x80, 0x38, 0x71, 0xE0, 0x0E, 0x1C, 0x70,
  0x03, 0x87, 0x1C, 0x20, 0xE1, 0xCE, 0x3F, 0x38, 0xF3, 0x9F, 0xEF, 0x39,
  0xEF, 0x79, 0xFE, 0x73, 0x8E, 0x3F, 0x3C, 0xE1, 0xC7, 0x8E, 0x38, 0x70,
  0x03, 0x8E, 0x1C, 0x01, 0xC3, 0x87, 0x00, 0x70, 0xE1, 0xC0, 0x3C, 0x38,
  0x70, 0x0E, 0x0E, 0x1C, 0x03, 0x83, 0x87, 0x01, 0xC0, 0xE1, 0xC0, 0x70,
  0x38, 0xE0, 0x38, 0x07, 0xF8, 0x0E, 0x01, 0xFC, 0x07, 0x80, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x07, 0xCF, 0x00, 0x1E,
  0x1C, 0x00, 0x70, 0x78, 0x01, 0xC1, 0xE0, 0x07, 0x07, 0x00, 0x1E, 0x3C,
  0x00, 0x78, 0xF0, 0x01, 0xF7, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x1E, 0x3E, 0xF0, 0xF1, 0xF3,
  0xE3, 0xC7, 0x87, 0xCF, 0x1E, 0x0F, 0x7C, 0xF0, 0x1F, 0xE3, 0xC0, 0x7F,
  0x8F, 0x80, 0xFC, 0x3E, 0x01, 0xF0, 0x78, 0x0F, 0xC1, 0xF8, 0xFF, 0x83,
  0xFF, 0xFF, 0x0F, 0xFF, 0x3E, 0x0F, 0xF0, 0x7C, 0xFF, 0xFE, 0xE7, 0x39,
  0xCE, 0x73, 0x9C, 0x07, 0x83, 0x83, 0xC3, 0xC1, 0xE1, 0xE0, 0xF0, 0x70,
  0x78, 0x3C, 0x1E, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0x70, 0x3C, 0x1E, 0x0F, 0x03, 0xC1,
  0xE0, 0x70, 0x3C, 0x0E, 0x07, 0x81, 0xE0, 0xF0, 0x38, 0x1E, 0x07, 0x83,
  0xC0, 0xF0, 0x78, 0x1C, 0x0F, 0x07, 0x81, 0xC0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x87,
  0x83, 0xC1, 0xE0, 0xE0, 0xF0, 0x78, 0x78, 0x38, 0x3C, 0x3C, 0x00, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x61, 0x86, 0x7F, 0xFE, 0x7F,
  0xFF, 0xFF, 0xFF, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0x70, 0x1E, 0x78, 0x3E,
  0x3C, 0x1C, 0x38, 0x04, 0x20, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x3E, 0x78,
  0xF1, 0xE3, 0xCF, 0x1E, 0x3C, 0x71, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7B, 0xFF, 0xF7, 0x80, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x70, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x01,
  0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x07, 0xC0, 0x3F, 0xE0, 0xFF,
  0xE1, 0xFF, 0xC7, 0xC3, 0xCF, 0x07, 0xBE, 0x07, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03,
  0xFC, 0x07, 0xBC, 0x1E, 0x78, 0x3C, 0xF8, 0xF8, 0xFF, 0xE0, 0xFF, 0x80,
  0xFE, 0x00, 0x01, 0xC0, 0xF0, 0x7C, 0x7F, 0x3F, 0xDF, 0xFF, 0xBF, 0xCF,
  0x63, 0xD0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0x07, 0xE0, 0x1F, 0xF8, 0x7F, 0xFC, 0x7F, 0xFE, 0x30,
  0x3E, 0x20, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x00,
  0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x0F, 0xC0, 0xFF, 0xE3, 0xFF, 0xE7, 0xFF, 0xE6, 0x03, 0xC8, 0x07,
  0x80, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0,
  0x3F, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x80, 0x3F,
  0xC1, 0xFB, 0xFF, 0xE7, 0xFF, 0x8F, 0xFE, 0x00, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x0E, 0xF0, 0x03, 0xBC, 0x01, 0xCF, 0x00, 0x73, 0xC0, 0x38, 0xF0, 0x0E,
  0x3C, 0x07, 0x0F, 0x03, 0xC3, 0xC0, 0xE0, 0xF0, 0x78, 0x3C, 0x1C, 0x0F,
  0x0F, 0x03, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x7F, 0xFC, 0xFF, 0xF9, 0xFF, 0xF3, 0xFF, 0xE7, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0xBE,
  0x07, 0xFF, 0x1F, 0xFF, 0x1F, 0xFF, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x80,
  0x3D, 0xC1, 0xFB, 0xFF, 0xE7, 0xFF, 0x87, 0xFE, 0x00, 0x01, 0xFC, 0x07,
  0xFC, 0x0F, 0xFC, 0x1F, 0xFC, 0x3E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF3, 0xF0, 0xF7, 0xF8, 0xFF,
  0xFC, 0xFC, 0x7E, 0xF8, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x1E, 0xF0, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x7C,
  0x7C, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x07,
  0xFC, 0x07, 0xFF, 0x87, 0xC7, 0xC3, 0xC1, 0xF3, 0xC0, 0x79, 0xE0, 0x3C,
  0xF0, 0x1E, 0x78, 0x0F, 0x1E, 0x0F, 0x0F, 0x07, 0x83, 0xE7, 0x80, 0xFF,
  0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x3F, 0xF0, 0x3E, 0x7E, 0x1E, 0x1F, 0x1E,
  0x07, 0xCF, 0x01, 0xE7, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1E, 0xF0, 0x0F,
  0x78, 0x0F, 0x3E, 0x0F, 0x8F, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0x80, 0x03,
  0xE0, 0x0F, 0xF8, 0x1F, 0xFC, 0x3F, 0xFC, 0x7C, 0x3E, 0x78, 0x1E, 0x78,
  0x0F, 0x78, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x78, 0x0F, 0x78,
  0x0F, 0x78, 0x1F, 0x7C, 0x3F, 0x3F, 0xFF, 0x3F, 0xFF, 0x1F, 0xEF, 0x03,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x3F, 0xF8, 0x3F, 0xF0, 0x3F, 0xC0, 0x33, 0xFF, 0xF7,
  0x98, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xDF, 0xF7, 0xBC, 0x18,
  0xF7, 0xDF, 0x3C, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xF3, 0xCF, 0x3C, 0xF7, 0x9E, 0x79, 0xCF, 0x00, 0x00, 0x00, 0x80, 0x01,
  0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0x80, 0x01, 0xC0, 0x00,
  0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x70, 0x00, 0x3E, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xC0, 0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0xFF, 0x01, 0xFE,
  0x00, 0xFC, 0x00, 0x78, 0x00, 0x30, 0x00, 0x00, 0x0F, 0xC1, 0xFF, 0xCF,
  0xFF, 0x9F, 0xFE, 0x60, 0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x01, 0xF0, 0x07, 0x80, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x3C, 0x01, 0xE0,
  0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0x01, 0xF0,
  0x0F, 0x00, 0x1E, 0x07, 0x80, 0x03, 0x81, 0xC0, 0x00, 0xF0, 0xE0, 0x00,
  0x1C, 0x38, 0x1F, 0xC3, 0x9C, 0x1F, 0xF8, 0xE7, 0x0F, 0xFE, 0x39, 0xC3,
  0x87, 0x0E, 0xF1, 0xE1, 0xC1, 0xF8, 0x70, 0x70, 0x7E, 0x1C, 0x1C, 0x1F,
  0x87, 0x07, 0x07, 0xE1, 0xC1, 0xC1, 0xF8, 0x70, 0x70, 0xFE, 0x1C, 0x1C,
  0x3B, 0x87, 0x0F, 0x0E, 0xE1, 0xC3, 0xC3, 0xB8, 0x79, 0xF9, 0xCF, 0x0F,
  0xE7, 0xF1, 0xC1, 0xF9, 0xF8, 0x70, 0x10, 0x10, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x20, 0x03, 0xFC, 0xF8,
  0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x1D, 0xC0, 0x00, 0xEE, 0x00, 0x0F,
  0x78, 0x00, 0x7B, 0xC0, 0x03, 0xDE, 0x00, 0x3C, 0x70, 0x01, 0xE3, 0xC0,
  0x0F, 0x1E, 0x00, 0x78, 0xF0, 0x07, 0x83, 0xC0, 0x3C, 0x1E, 0x01, 0xE0,
  0xF0, 0x0F, 0x07, 0x80, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x83,
  0xFF, 0xFE, 0x1E, 0x00, 0xF0, 0xF0, 0x07, 0x87, 0x80, 0x3E, 0x7C, 0x01,
  0xF3, 0xC0, 0x07, 0x9E, 0x00, 0x3D, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0x80,
  0xFF, 0x00, 0x7F, 0xFC, 0x3F, 0xFF, 0x1F, 0xFF, 0xCF, 0x03, 0xF7, 0x80,
  0xFB, 0xC0, 0x3D, 0xE0, 0x1E, 0xF0, 0x0F, 0x78, 0x07, 0xBC, 0x03, 0xDE,
  0x03, 0xCF, 0xFF, 0xC7, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xFC, 0xF0, 0x1F,
  0x78, 0x07, 0xBC, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0x78, 0x7F, 0xBF, 0xFF, 0x9F, 0xFF, 0x8F,
  0xFF, 0x00, 0x00, 0xFE, 0x01, 0xFF, 0xC3, 0xFF, 0xE3, 0xFF, 0xF1, 0xF0,
  0x11, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC1, 0x83, 0xFF, 0xC0,
  0xFF, 0xE0, 0x3F, 0xF0, 0xFF, 0x80, 0x1F, 0xFE, 0x03, 0xFF, 0xF0, 0x7F,
  0xFF, 0x0F, 0x03, 0xF1, 0xE0, 0x3F, 0x3C, 0x03, 0xE7, 0x80, 0x3E, 0xF0,
  0x07, 0xDE, 0x00, 0x7B, 0xC0, 0x0F, 0x78, 0x01, 0xEF, 0x00, 0x3D, 0xE0,
  0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xDE, 0x00, 0x7B, 0xC0,
  0x0F, 0x78, 0x01, 0xEF, 0x00, 0x7D, 0xE0, 0x0F, 0xBC, 0x01, 0xE7, 0x80,
  0x7C, 0xF0, 0x3F, 0x1F, 0xFF, 0xC3, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F,
  0x80, 0xC3, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0x78, 0x00, 0xF7, 0x80, 0x0F, 0x7C, 0x00, 0xF3, 0xE0,
  0x0F, 0x3F, 0x00, 0xF1, 0xFC, 0x1F, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x01,
  0xFF, 0xC0, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC,
  0x7C, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E,
  0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81,
  0xE0, 0x78, 0x1E, 0x07, 0x87, 0xFB, 0xFF, 0xFF, 0xC0, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x0F, 0xFF, 0xBF,
  0xDF, 0xCF, 0x80, 0xF0, 0x07, 0xFC, 0x03, 0xEF, 0x00, 0xF3, 0xC0, 0x7C,
  0xF0, 0x3E, 0x3C, 0x0F, 0x0F, 0x07, 0xC3, 0xC3, 0xE0, 0xF0, 0xF0, 0x3C,
  0x7C, 0x0F, 0x1E, 0x03, 0xCF, 0x00, 0xF7, 0xC0, 0x3D, 0xF0, 0x0F, 0xFC,
  0x03, 0xFF, 0x80, 0xFD, 0xE0, 0x3E, 0x7C, 0x0F, 0x0F, 0x03, 0xC3, 0xE0,
  0xF0, 0x78, 0x3C, 0x1F, 0x0F, 0x03, 0xC3, 0xC0, 0xF8, 0xF0, 0x1E, 0x3C,
  0x07, 0xCF, 0x00, 0xF3, 0xC0, 0x3E, 0xF0, 0x07, 0xC0, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFC, 0x00, 0x0F,
  0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x03,
  0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0xEF, 0xFE, 0x00, 0x77, 0xF7, 0x00,
  0x7B, 0xFB, 0xC0, 0x39, 0xFD, 0xE0, 0x1C, 0xFE, 0x70, 0x1E, 0x7F, 0x3C,
  0x0E, 0x3F, 0x9E, 0x07, 0x1F, 0xC7, 0x07, 0x8F, 0xE3, 0x83, 0xC7, 0xF1,
  0xE1, 0xC3, 0xF8, 0xF1, 0xE1, 0xFC, 0x38, 0xF0, 0xFE, 0x1E, 0x70, 0x7F,
  0x0F, 0x38, 0x3F, 0x83, 0xBC, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFE, 0x07,
  0xF0, 0x3F, 0x03, 0xF8, 0x1F, 0x01, 0xFC, 0x0F, 0x80, 0xFE, 0x07, 0xC0,
  0x7F, 0x01, 0xE0, 0x38, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF,
  0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F,
  0xF7, 0x80, 0xFF, 0x78, 0x0F, 0xF3, 0xC0, 0xFF, 0x3C, 0x0F, 0xF1, 0xE0,
  0xFF, 0x1E, 0x0F, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0xF0, 0x78, 0xFF, 0x07,
  0x8F, 0xF0, 0x3C, 0xFF, 0x03, 0xCF, 0xF0, 0x1E, 0xFF, 0x01, 0xEF, 0xF0,
  0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFF,
  0x00, 0x3F, 0xF0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF,
  0xE0, 0x3F, 0xFF, 0x83, 0xF0, 0x3E, 0x1F, 0x00, 0xF1, 0xF0, 0x07, 0xCF,
  0x00, 0x1E, 0x78, 0x00, 0xF7, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xF7, 0x80, 0x0F,
  0xBC, 0x00, 0x79, 0xF0, 0x07, 0xC7, 0x80, 0x3E, 0x3E, 0x03, 0xE0, 0xFC,
  0x7E, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00,
  0xFF, 0xF0, 0xFF, 0xF8, 0xFF, 0xFC, 0xF0, 0x7E, 0xF0, 0x1E, 0xF0, 0x1E,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1E, 0xF0, 0x1E,
  0xF0, 0x3E, 0xF0, 0xFC, 0xFF, 0xFC, 0xFF, 0xF0, 0xFF, 0xE0, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x3F,
  0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xF0, 0x3E, 0x1F, 0x00, 0xF1,
  0xF0, 0x07, 0xCF, 0x00, 0x1E, 0x78, 0x00, 0xF7, 0xC0, 0x07, 0xFE, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x01,
  0xF7, 0x80, 0x0F, 0xBC, 0x00, 0x79, 0xF0, 0x07, 0xC7, 0x80, 0x3E, 0x3E,
  0x03, 0xE0, 0xFC, 0x7F, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0xFE, 0x00, 0x3F, 0xFC, 0x0F,
  0xFF, 0xC3, 0xFF, 0xF0, 0xF0, 0x7E, 0x3C, 0x07, 0x8F, 0x01, 0xF3, 0xC0,
  0x7C, 0xF0, 0x0F, 0x3C, 0x03, 0xCF, 0x01, 0xF3, 0xC0, 0x78, 0xF0, 0x3E,
  0x3C, 0x1F, 0x0F, 0xFF, 0xC3, 0xFF, 0xC0, 0xFF, 0xE0, 0x3C, 0x3C, 0x0F,
  0x0F, 0x03, 0xC3, 0xE0, 0xF0, 0x78, 0x3C, 0x1F, 0x0F, 0x03, 0xC3, 0xC0,
  0xF8, 0xF0, 0x1E, 0x3C, 0x07, 0xCF, 0x00, 0xF3, 0xC0, 0x3E, 0xF0, 0x07,
  0xC0, 0x07, 0xE0, 0x3F, 0xF8, 0xFF, 0xF3, 0xFF, 0xEF, 0x81, 0x9E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07,
  0xF0, 0x07, 0xF8, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x00,
  0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x80, 0x3D,
  0xE1, 0xFB, 0xFF, 0xE7, 0xFF, 0x87, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x7F, 0xE0, 0x1E, 0x78, 0x0F, 0x9F, 0x87, 0xE3, 0xFF, 0xF0, 0x7F,
  0xF8, 0x0F, 0xFC, 0x00, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0x78, 0x00, 0xF7,
  0x80, 0x1E, 0x78, 0x01, 0xE7, 0x80, 0x1E, 0x3C, 0x01, 0xE3, 0xC0, 0x3C,
  0x3C, 0x03, 0xC3, 0xC0, 0x3C, 0x1E, 0x07, 0xC1, 0xE0, 0x78, 0x1E, 0x07,
  0x80, 0xF0, 0x78, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0x78,
  0xF0, 0x07, 0x9E, 0x00, 0x79, 0xE0, 0x03, 0x9E, 0x00, 0x3D, 0xC0, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x00, 0xF8, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0xF0, 0x03, 0xC0,
  0x1E, 0x78, 0x07, 0xC0, 0x1E, 0x78, 0x07, 0xC0, 0x1E, 0x78, 0x07, 0xE0,
  0x1E, 0x78, 0x07, 0xE0, 0x3C, 0x78, 0x07, 0xE0, 0x3C, 0x3C, 0x0F, 0xE0,
  0x3C, 0x3C, 0x0E, 0xF0, 0x3C, 0x3C, 0x0E, 0xF0, 0x3C, 0x3C, 0x0E, 0x70,
  0x78, 0x1E, 0x1E, 0x70, 0x78, 0x1E, 0x1E, 0x70, 0x78, 0x1E, 0x1C, 0x78,
  0x78, 0x1E, 0x1C, 0x78, 0xF0, 0x1E, 0x3C, 0x38, 0xF0, 0x0F, 0x3C, 0x38,
  0xF0, 0x0F, 0x3C, 0x3C, 0xF0, 0x0F, 0x38, 0x3C, 0xF0, 0x0F, 0x38, 0x1D,
  0xE0, 0x07, 0x78, 0x1D, 0xE0, 0x07, 0x78, 0x1D, 0xE0, 0x07, 0xF0, 0x1D,
  0xE0, 0x07, 0xF0, 0x1F, 0xE0, 0x07, 0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x0F,
  0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xE0, 0x0F, 0xC0, 0x03, 0xE0, 0x07,
  0x80, 0x78, 0x03, 0xCF, 0x80, 0x78, 0xF0, 0x1F, 0x1E, 0x03, 0xC1, 0xE0,
  0xF8, 0x3C, 0x1E, 0x03, 0xC7, 0xC0, 0x78, 0xF0, 0x07, 0x9E, 0x00, 0xF7,
  0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x1E, 0xF0, 0x03, 0xDE,
  0x00, 0xF1, 0xE0, 0x1E, 0x3C, 0x07, 0x83, 0xC0, 0xF0, 0x78, 0x3E, 0x07,
  0x87, 0x80, 0xF1, 0xF0, 0x1F, 0x3C, 0x01, 0xEF, 0x80, 0x3E, 0xF0, 0x03,
  0xFF, 0x00, 0x79, 0xE0, 0x0F, 0x3E, 0x03, 0xC3, 0xC0, 0x78, 0x78, 0x1F,
  0x07, 0x83, 0xC0, 0xF0, 0x78, 0x1E, 0x1E, 0x01, 0xE3, 0xC0, 0x3C, 0xF0,
  0x03, 0xDE, 0x00, 0x7B, 0xC0, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8,
  0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x03,
  0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80,
  0x0F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1C,
  0x00, 0x78, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x01,
  0xE0, 0x03, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x07, 0x80,
  0x0F, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x07, 0x80, 0x0E, 0x00, 0x3C,
  0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0xFF, 0xFF, 0xFF,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xF0,
  0x01, 0xFC, 0x00, 0x77, 0x80, 0x3C, 0xE0, 0x0E, 0x3C, 0x07, 0x87, 0x01,
  0xC1, 0xE0, 0xF0, 0x38, 0x3C, 0x0F, 0x0E, 0x01, 0xC7, 0x80, 0x79, 0xC0,
  0x0E, 0xF0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xF0,
  0xF8, 0x78, 0x3C, 0x1E, 0x0E, 0x07, 0x07, 0xF0, 0x7F, 0xF0, 0x7F, 0xF0,
  0xE1, 0xF1, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x0F,
  0xFC, 0x7F, 0xF9, 0xFF, 0xF7, 0xC1, 0xEF, 0x03, 0xDE, 0x07, 0xFC, 0x0F,
  0xF8, 0x1E, 0xF0, 0x7D, 0xE1, 0xFB, 0xFF, 0x73, 0xFC, 0xE3, 0xF1, 0xC0,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF1, 0xE0, 0xF7, 0xF8, 0xFF, 0xFC, 0xFF, 0xFC,
  0xF8, 0x3E, 0xF8, 0x1E, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F,
  0xF0, 0x1E, 0xF8, 0x1E, 0xFC, 0x3E, 0xEF, 0xFC, 0xE7, 0xF8, 0xE3, 0xF0,
  0x07, 0xE0, 0xFF, 0xCF, 0xFE, 0x7E, 0xE7, 0xC0, 0x3C, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x06, 0x7F, 0xF1, 0xFF, 0x87, 0xF8,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x0F, 0x8F, 0x1F, 0xEF, 0x3F, 0xFF, 0x7E, 0xFF,
  0x78, 0x1F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF8, 0x1F, 0x78, 0x1F, 0x7C, 0x3F, 0x3F, 0xFF, 0x3F, 0xE7, 0x1F, 0xC7,
  0x07, 0xC0, 0x3F, 0xE0, 0xFF, 0xE1, 0xE3, 0xE7, 0x83, 0xCF, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x31,
  0xFF, 0xE1, 0xFF, 0xC1, 0xFF, 0x00, 0x00, 0xE0, 0x3F, 0xC1, 0xFE, 0x1F,
  0xE0, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xFF, 0x1F, 0xF9,
  0xFF, 0xCF, 0xFE, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x00, 0x0F, 0x87, 0x1F,
  0xE7, 0x3F, 0xFF, 0x7E, 0xFF, 0x78, 0x3F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0x78, 0x1F, 0x7C, 0x3F, 0x3F,
  0xFF, 0x3F, 0xEF, 0x1F, 0xCF, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x1E, 0x60, 0x3E, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xF0, 0x03,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF1, 0xF1, 0xEF, 0xF3, 0xFF, 0xF7, 0xFF, 0xEF,
  0x83, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xC0, 0x33, 0xFE,
  0xF7, 0x00, 0x00, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD,
  0xEF, 0x7B, 0xDE, 0xF7, 0xBC, 0x06, 0x0F, 0x1F, 0x0F, 0x0E, 0x00, 0x00,
  0x00, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x1E, 0xFE, 0xFE, 0xFC, 0x70, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x1F, 0xE0, 0x7B, 0xC1, 0xF7, 0x83, 0xCF, 0x0F, 0x1E, 0x3C, 0x3C,
  0xF8, 0x79, 0xE0, 0xF7, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFE, 0x0F, 0xBC,
  0x1F, 0x3C, 0x3C, 0x78, 0x78, 0x78, 0xF0, 0xF9, 0xE0, 0xF3, 0xC1, 0xF7,
  0x81, 0xEF, 0x03, 0xFE, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xE0, 0x7C,
  0x73, 0xFC, 0xFF, 0xBB, 0xFE, 0x7F, 0xDF, 0xDF, 0xFB, 0xFF, 0x83, 0xF0,
  0x7F, 0x81, 0xF0, 0x3F, 0xC0, 0xF8, 0x1F, 0xE0, 0x3C, 0x0F, 0xF0, 0x1E,
  0x07, 0xF8, 0x0F, 0x03, 0xFC, 0x07, 0x81, 0xFE, 0x03, 0xC0, 0xFF, 0x01,
  0xE0, 0x7F, 0x80, 0xF0, 0x3F, 0xC0, 0x78, 0x1F, 0xE0, 0x3C, 0x0F, 0xF0,
  0x1E, 0x07, 0xF8, 0x0F, 0x03, 0xFC, 0x07, 0x81, 0xFE, 0x03, 0xC0, 0xFF,
  0x01, 0xE0, 0x7F, 0x80, 0xF0, 0x3C, 0xE3, 0xF1, 0xCF, 0xF3, 0xBF, 0xF7,
  0xFF, 0xEF, 0x83, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xC0,
  0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0x7E, 0x78, 0x1E, 0x78, 0x1F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x78, 0x0F, 0x78, 0x1E,
  0x7C, 0x3E, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF0, 0xE3, 0xE0, 0xE7, 0xF8,
  0xEF, 0xFC, 0xFE, 0x7C, 0xF8, 0x3E, 0xF0, 0x1E, 0xF0, 0x1F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x1E, 0xF8, 0x1E, 0xFC, 0x3E, 0xFF, 0xFC,
  0xF7, 0xF8, 0xF3, 0xF0, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0x0F, 0x87, 0x1F, 0xE7, 0x3F, 0xFF, 0x7E, 0xFF, 0x78, 0x1F, 0xF8, 0x1F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0x78, 0x1F,
  0x7C, 0x3F, 0x3F, 0xFF, 0x3F, 0xEF, 0x1F, 0xCF, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0xE1, 0xFC, 0xFB, 0xBF, 0x77, 0xEF, 0xC1, 0xF0,
  0x3E, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x00, 0x0F,
  0xE1, 0xFF, 0xDF, 0xFE, 0xF8, 0xE7, 0x81, 0x78, 0x01, 0xC0, 0x0F, 0x00,
  0x7C, 0x01, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x00, 0xFC, 0x01, 0xE0,
  0x0F, 0x00, 0x7C, 0x03, 0xF8, 0x3F, 0xFF, 0xEF, 0xFF, 0x3F, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x1E, 0x03, 0xFD, 0xFF, 0xBF, 0xF7, 0xFE, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x81, 0xFF, 0x1F, 0xE1, 0xFC, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0x7F, 0xE1, 0xFB, 0xFF,
  0xF7, 0xFC, 0xE7, 0xF1, 0xC0, 0xF0, 0x07, 0xF8, 0x03, 0xDE, 0x01, 0xEF,
  0x01, 0xE7, 0x80, 0xF1, 0xE0, 0x78, 0xF0, 0x78, 0x78, 0x3C, 0x3C, 0x1E,
  0x0F, 0x0F, 0x07, 0x8F, 0x03, 0xC7, 0x80, 0xE3, 0xC0, 0x79, 0xC0, 0x3D,
  0xE0, 0x0E, 0xF0, 0x07, 0x70, 0x03, 0xB8, 0x01, 0xFC, 0x00, 0x7E, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0xF0, 0x1F, 0x01, 0xEF, 0x03, 0xE0, 0x3D, 0xE0,
  0x7C, 0x07, 0x3C, 0x0F, 0xC1, 0xE7, 0x83, 0xF8, 0x3C, 0x70, 0x77, 0x07,
  0x8F, 0x0E, 0xE0, 0xE1, 0xE1, 0xDC, 0x3C, 0x3C, 0x3B, 0xC7, 0x87, 0x8F,
  0x38, 0xF0, 0x79, 0xC7, 0x1C, 0x0F, 0x38, 0xE3, 0x81, 0xE7, 0x1E, 0xF0,
  0x3C, 0xE3, 0xDE, 0x03, 0xBC, 0x3B, 0xC0, 0x77, 0x07, 0x70, 0x0F, 0xE0,
  0xEE, 0x01, 0xFC, 0x1F, 0xC0, 0x1F, 0x83, 0xF8, 0x03, 0xE0, 0x3E, 0x00,
  0x7C, 0x07, 0xC0, 0x0F, 0x80, 0xF8, 0x00, 0x78, 0x0F, 0xBE, 0x07, 0x8F,
  0x07, 0xC7, 0xC3, 0xC1, 0xE3, 0xE0, 0xF9, 0xE0, 0x3D, 0xE0, 0x0F, 0xF0,
  0x07, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x3D, 0xE0, 0x1E, 0xF0, 0x1E, 0x3C, 0x0F, 0x1F, 0x0F, 0x07, 0x87,
  0x83, 0xE7, 0x80, 0xF7, 0xC0, 0x7C, 0xF0, 0x07, 0xFC, 0x03, 0xDE, 0x01,
  0xEF, 0x01, 0xE7, 0x80, 0xF1, 0xE0, 0x78, 0xF0, 0x78, 0x78, 0x3C, 0x1E,
  0x1E, 0x0F, 0x0F, 0x07, 0x8F, 0x01, 0xC7, 0x80, 0xF3, 0xC0, 0x79, 0xC0,
  0x3D, 0xE0, 0x0E, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00,
  0x70, 0x00, 0x7F, 0xF3, 0xFF, 0x9F, 0xFC, 0xFF, 0xE0, 0x0F, 0x00, 0xF0,
  0x07, 0x80, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x0F,
  0x00, 0x78, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x30, 0x1F, 0x03, 0xF0, 0x7F, 0x07, 0x80, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x0F,
  0x01, 0xF0, 0xFE, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x80, 0x78, 0x07, 0xF0, 0x3F, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x80, 0x1F, 0x03, 0xF0, 0x7F, 0x03, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0x78, 0x0F, 0xE0, 0x7C, 0x0F, 0x87, 0xF0, 0xF0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x81, 0xF0, 0xFC,
  0x1F, 0x83, 0xC0, 0x00, 0x1E, 0x00, 0xBF, 0xC0, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFC, 0x0F, 0xF4, 0x00, 0x60,
};

const GFXglyph NotoSans_Condensed_Medium40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 6, 29, 10, 2, -29 },
  { 23, 12, 11, 16, 2, -29 },
  { 40, 19, 29, 21, 1, -29 },
  { 109, 15, 32, 19, 2, -30 },
  { 169, 26, 29, 30, 2, -29 },
  { 264, 22, 29, 23, 1, -29 },
  { 344, 5, 11, 9, 2, -29 },
  { 351, 9, 35, 12, 2, -29 },
  { 391, 9, 35, 12, 1, -29 },
  { 431, 16, 15, 18, 1, -30 },
  { 461, 17, 19, 19, 1, -24 },
  { 502, 7, 10, 10, 1, -5 },
  { 511, 10, 4, 12, 1, -13 },
  { 516, 5, 5, 10, 2, -5 },
  { 520, 14, 29, 15, 1, -29 },
  { 571, 15, 29, 19, 2, -29 },
  { 626, 10, 29, 19, 3, -29 },
  { 663, 16, 29, 19, 1, -29 },
  { 721, 15, 29, 19, 2, -29 },
  { 776, 18, 29, 19, 1, -29 },
  { 842, 15, 29, 19, 2, -29 },
  { 897, 16, 29, 19, 2, -29 },
  { 955, 17, 29, 19, 1, -29 },
  { 1017, 17, 29, 19, 1, -29 },
  { 1079, 16, 29, 19, 1, -29 },
  { 1137, 5, 22, 10, 2, -22 },
  { 1151, 6, 27, 10, 1, -22 },
  { 1172, 17, 19, 19, 1, -24 },
  { 1213, 17, 12, 19, 1, -20 },
  { 1239, 17, 19, 19, 1, -24 },
  { 1280, 14, 29, 15, 0, -29 },
  { 1331, 26, 32, 30, 2, -29 },
  { 1435, 21, 29, 21, 0, -29 },
  { 1512, 17, 29, 22, 3, -29 },
  { 1574, 17, 29, 20, 2, -29 },
  { 1636, 19, 29, 24, 3, -29 },
  { 1705, 13, 29, 18, 3, -29 },
  { 1753, 13, 29, 17, 3, -29 },
  { 1801, 20, 29, 24, 2, -29 },
  { 1874, 18, 29, 24, 3, -29 },
  { 1940, 10, 29, 12, 1, -29 },
  { 1977, 9, 37, 10, -2, -29 },
  { 2019, 18, 29, 21, 3, -29 },
  { 2085, 13, 29, 17, 3, -29 },
  { 2133, 25, 29, 32, 3, -29 },
  { 2224, 20, 29, 26, 3, -29 },
  { 2297, 21, 29, 25, 2, -29 },
  { 2374, 16, 29, 20, 3, -29 },
  { 2432, 21, 36, 25, 2, -29 },
  { 2527, 18, 29, 21, 3, -29 },
  { 2593, 15, 29, 18, 2, -29 },
  { 2648, 17, 29, 18, 0, -29 },
  { 2710, 18, 29, 24, 3, -29 },
  { 2776, 20, 29, 20, 0, -29 },
  { 2849, 32, 29, 32, 0, -29 },
  { 2965, 19, 29, 19, 0, -29 },
  { 3034, 19, 29, 19, 0, -29 },
  { 3103, 15, 29, 17, 1, -29 },
  { 3158, 9, 35, 13, 3, -29 },
  { 3198, 14, 29, 15, 1, -29 },
  { 3249, 9, 35, 13, 1, -29 },
  { 3289, 18, 17, 20, 1, -29 },
  { 3328, 17, 3, 17, 0, 3 },
  { 3335, 8, 7, 11, 2, -31 },
  { 3342, 15, 22, 19, 1, -22 },
  { 3384, 16, 30, 21, 3, -30 },
  { 3444, 13, 22, 16, 2, -22 },
  { 3480, 16, 30, 21, 2, -30 },
  { 3540, 15, 22, 19, 2, -22 },
  { 3582, 13, 31, 12, 0, -31 },
  { 3633, 16, 32, 21, 2, -22 },
  { 3697, 15, 30, 21, 3, -30 },
  { 3754, 5, 30, 9, 2, -30 },
  { 3773, 8, 40, 9, -1, -30 },
  { 3813, 15, 30, 19, 3, -30 },
  { 3870, 4, 30, 9, 3, -30 },
  { 3885, 25, 22, 31, 3, -22 },
  { 3954, 15, 22, 21, 3, -22 },
  { 3996, 16, 22, 20, 2, -22 },
  { 4040, 16, 32, 21, 3, -22 },
  { 4104, 16, 32, 21, 2, -22 },
  { 4168, 11, 22, 14, 3, -22 },
  { 4199, 13, 22, 16, 1, -22 },
  { 4235, 11, 26, 12, 1, -26 },
  { 4271, 15, 22, 21, 3, -22 },
  { 4313, 17, 22, 17, 0, -22 },
  { 4360, 27, 22, 27, 0, -22 },
  { 4435, 17, 22, 17, 0, -22 },
  { 4482, 17, 32, 17, 0, -22 },
  { 4550, 13, 22, 15, 1, -22 },
  { 4586, 12, 35, 15, 1, -29 },
  { 4639, 4, 39, 18, 7, -30 },
  { 4659, 11, 35, 15, 2, -29 },
  { 4708, 17, 6, 19, 1, -17 },
};

const GFXfont NotoSans_Condensed_Medium40pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Medium40pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Medium40pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _NOTOSANS_CONDENSED_MEDIUM40PT7B_H_
