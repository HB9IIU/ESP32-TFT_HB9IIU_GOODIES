#ifndef _NOTOSANS_CONDENSED_MEDIUM51PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUM51PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Medium.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Medium51pt7bBitmaps[] PROGMEM = {
  0x00, 0xFD, 0xFB, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x1E, 0x3C, 0x78, 0x00,
  0x00, 0x00, 0x02, 0x1F, 0x7E, 0xFF, 0xFF, 0xF3, 0xE1, 0x00, 0xF8, 0x7F,
  0xF0, 0xFF, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xBE, 0x0F, 0x7C,
  0x1E, 0x78, 0x3C, 0xF0, 0x79, 0xE0, 0xF3, 0xC1, 0xE7, 0x83, 0xC0, 0x00,
  0xF8, 0x38, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x0F, 0x00,
  0x0F, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x03, 0x81, 0xC0, 0x03, 0xC0, 0xE0,
  0x01, 0xE0, 0xF0, 0x00, 0xF0, 0x78, 0x1F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFC, 0x0F, 0x07, 0x80, 0x07, 0x83,
  0xC0, 0x03, 0xC1, 0xE0, 0x01, 0xE0, 0xF0, 0x00, 0xF0, 0x78, 0x00, 0x78,
  0x3C, 0x00, 0x38, 0x1C, 0x07, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x03, 0xC1, 0xE0, 0x01, 0xE0, 0xF0, 0x00,
  0xE0, 0x70, 0x00, 0xF0, 0x78, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x1E, 0x00,
  0x1E, 0x0F, 0x00, 0x0F, 0x07, 0x80, 0x07, 0x83, 0x80, 0x03, 0x83, 0xC0,
  0x03, 0xC1, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x78, 0x00, 0x7F, 0xFC, 0x1F, 0xFF, 0xF3, 0xFF, 0xFE,
  0x3F, 0xFF, 0xE7, 0xE7, 0x0C, 0x7C, 0x70, 0x0F, 0x87, 0x00, 0xF8, 0x70,
  0x0F, 0x87, 0x00, 0xF8, 0x70, 0x07, 0xC7, 0x00, 0x7E, 0x70, 0x03, 0xFF,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x73, 0xF0, 0x07, 0x1F, 0x00, 0x71, 0xF0,
  0x07, 0x0F, 0x00, 0x70, 0xF0, 0x07, 0x1F, 0x80, 0x71, 0xFF, 0x07, 0x7E,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x83, 0xFF, 0xE0, 0x00, 0xF0,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x0F, 0x80, 0x00, 0x20, 0x07, 0xF8, 0x00, 0xF0, 0x03, 0xFE, 0x00,
  0x3C, 0x01, 0xFF, 0xC0, 0x1E, 0x00, 0x78, 0xF0, 0x07, 0x80, 0x1E, 0x1E,
  0x03, 0xE0, 0x0F, 0x07, 0x80, 0xF0, 0x03, 0xC1, 0xE0, 0x3C, 0x00, 0xF0,
  0x78, 0x1E, 0x00, 0x3C, 0x1E, 0x07, 0x80, 0x0F, 0x07, 0xC3, 0xC0, 0x03,
  0xC1, 0xF0, 0xF0, 0x00, 0xF0, 0x7C, 0x7C, 0x00, 0x3C, 0x1E, 0x1E, 0x00,
  0x0F, 0x07, 0x87, 0x80, 0x03, 0xC1, 0xE3, 0xC3, 0xF0, 0xF0, 0x78, 0xF1,
  0xFE, 0x1E, 0x1E, 0x78, 0xFF, 0xC7, 0x8F, 0x9E, 0x3C, 0xF8, 0xFF, 0xC7,
  0x9E, 0x1E, 0x3F, 0xE3, 0xC7, 0x87, 0x87, 0xF8, 0xF1, 0xE1, 0xF0, 0xF8,
  0x78, 0x78, 0x3C, 0x00, 0x1E, 0x3C, 0x0F, 0x00, 0x0F, 0x8F, 0x03, 0xC0,
  0x03, 0xC3, 0xC0, 0xF0, 0x00, 0xF0, 0xF0, 0x3C, 0x00, 0x78, 0x3C, 0x0F,
  0x00, 0x1E, 0x0F, 0x03, 0xC0, 0x0F, 0x01, 0xE0, 0xF0, 0x03, 0xC0, 0x78,
  0x7C, 0x00, 0xF0, 0x1E, 0x1E, 0x00, 0x78, 0x07, 0x87, 0x80, 0x1E, 0x00,
  0xF3, 0xE0, 0x0F, 0x00, 0x3F, 0xF0, 0x03, 0xC0, 0x07, 0xF8, 0x01, 0xF0,
  0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x07, 0xFF, 0xC0, 0x01, 0xF8, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x07,
  0xC1, 0xF0, 0x00, 0xF0, 0x3E, 0x00, 0x1E, 0x07, 0xC0, 0x03, 0xC0, 0xF8,
  0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x1F,
  0x3E, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFE, 0x07, 0xE3, 0xF7,
  0xC0, 0xF8, 0xFC, 0xFC, 0x1F, 0x1F, 0x0F, 0xC3, 0xE7, 0xE0, 0xFC, 0x7C,
  0xF8, 0x0F, 0x9F, 0x1F, 0x01, 0xFB, 0xE3, 0xE0, 0x1F, 0xFC, 0x7C, 0x01,
  0xFF, 0x0F, 0x80, 0x1F, 0xE1, 0xF0, 0x03, 0xF8, 0x3F, 0x00, 0x7F, 0x07,
  0xE0, 0x1F, 0xF0, 0x7F, 0x0F, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFE,
  0x7E, 0x0F, 0xFF, 0x87, 0xE0, 0xFF, 0xC0, 0x7E, 0x00, 0x80, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7B, 0xDE, 0xF7, 0x80, 0x00, 0xF0, 0x1E,
  0x03, 0xE0, 0x3C, 0x07, 0xC0, 0xF8, 0x0F, 0x81, 0xF0, 0x1F, 0x01, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0,
  0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x07, 0x80, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x7C,
  0x03, 0xC0, 0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x1E,
  0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0x80, 0x7C, 0x07, 0xC0, 0x3C, 0x03,
  0xE0, 0x3E, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x07,
  0xC0, 0xF8, 0x0F, 0x81, 0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x01, 0xC0, 0x38, 0x38, 0x3F, 0xF7, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0x78, 0x03, 0xEF,
  0x80, 0xF8, 0xF8, 0x1F, 0x1F, 0x87, 0xC1, 0xF0, 0x38, 0x38, 0x02, 0x02,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x3F, 0x3E, 0x3E, 0x3E, 0x7E, 0x7C, 0x7C, 0x7C,
  0x78, 0x78, 0xF8, 0xF0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x11, 0xFF, 0xFF, 0xFF, 0xF7, 0xCC, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0xE0, 0x0F,
  0xFF, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0xF0, 0xFC, 0x3E, 0x07, 0xE7,
  0xE0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x01, 0xF7, 0xC0, 0x1F,
  0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0x7C,
  0x01, 0xF7, 0xC0, 0x3F, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x7E, 0x03, 0xE3,
  0xE0, 0x7C, 0x3F, 0x0F, 0xC1, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xF0,
  0x03, 0xFC, 0x00, 0x02, 0x00, 0x00, 0xFC, 0x07, 0xF0, 0x3F, 0xC1, 0xFF,
  0x0F, 0xFC, 0x7F, 0xF3, 0xF7, 0xDF, 0x9F, 0xFC, 0x7C, 0xE1, 0xF3, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x03, 0xF8, 0x00, 0xFF,
  0xE0, 0x3F, 0xFF, 0x07, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xC0, 0xFC, 0x30,
  0x07, 0xE2, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xF8, 0x01, 0xFF, 0xE0, 0x7F, 0xFF,
  0x8F, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0x80, 0xFE, 0x20, 0x07, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x0F, 0xFF, 0x00,
  0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE8, 0x00,
  0x7E, 0xF0, 0x1F, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0x7F,
  0xFC, 0x00, 0x08, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x3D, 0xF0, 0x00, 0x7B, 0xE0, 0x01, 0xE7, 0xC0, 0x03, 0xCF, 0x80,
  0x0F, 0x3F, 0x00, 0x1E, 0x7E, 0x00, 0x78, 0xFC, 0x00, 0xF1, 0xF8, 0x03,
  0xC3, 0xF0, 0x07, 0x87, 0xE0, 0x1E, 0x0F, 0xC0, 0x7C, 0x1F, 0x80, 0xF0,
  0x3F, 0x03, 0xE0, 0x7E, 0x07, 0x80, 0xFC, 0x1F, 0x01, 0xF8, 0x3C, 0x03,
  0xF0, 0xF8, 0x07, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x7F, 0xFF, 0x8F, 0xFF, 0xF1, 0xFF, 0xFE, 0x3F, 0xFF,
  0xC7, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF3, 0x80,
  0x3F, 0xFF, 0x07, 0xFF, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0x80, 0x7F,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x1F, 0xA0, 0x03, 0xF7, 0x01, 0xFC, 0xFF, 0xFF, 0x9F, 0xFF, 0xE3,
  0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0x10, 0x00, 0x00, 0x1F, 0xC0, 0x0F, 0xFC,
  0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xFD, 0xC0, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x7E, 0x0F, 0x9F, 0xF8, 0xFB,
  0xFF, 0xCF, 0xBF, 0xFE, 0xFF, 0x8F, 0xEF, 0xE0, 0x3E, 0xFC, 0x03, 0xFF,
  0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0x7C, 0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x1F, 0x3E, 0x03,
  0xF3, 0xE0, 0x3E, 0x3F, 0x87, 0xE1, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x7F,
  0xF8, 0x03, 0xFE, 0x00, 0x02, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xF0,
  0xFE, 0x3F, 0x03, 0xF1, 0xF0, 0x0F, 0x8F, 0x80, 0x7E, 0x7C, 0x01, 0xF3,
  0xE0, 0x0F, 0x9F, 0x00, 0xF8, 0xF8, 0x07, 0xC3, 0xE0, 0x3E, 0x1F, 0x83,
  0xE0, 0x7E, 0x3F, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x80, 0x1F, 0xFE, 0x01, 0xFB, 0xF8, 0x1F, 0x87, 0xE1, 0xF8, 0x1F,
  0x8F, 0x80, 0x7E, 0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0x7D, 0xF0,
  0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFB, 0xE0, 0x07, 0xDF, 0x80, 0x7E,
  0x7E, 0x07, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0x7F,
  0xE0, 0x00, 0x30, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0x03,
  0xFF, 0xF8, 0x3F, 0xFF, 0xC7, 0xE0, 0xFC, 0x7C, 0x07, 0xEF, 0xC0, 0x3E,
  0xF8, 0x03, 0xEF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x03, 0xF7, 0xC0,
  0x3F, 0x7E, 0x07, 0xF7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF1, 0xFF, 0xDF, 0x0F,
  0xF9, 0xF0, 0x3C, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x7F, 0x03, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xF0,
  0x00, 0x20, 0x00, 0x38, 0xFB, 0xF7, 0xFF, 0xDF, 0x9F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x1F, 0x7E,
  0xFF, 0xFF, 0xF3, 0xE3, 0x00, 0x1C, 0x3E, 0x7E, 0x7F, 0x7E, 0x7E, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x3E, 0x3E, 0x3E, 0x7E, 0x7C, 0x7C, 0x7C, 0x78,
  0xF8, 0xF8, 0xF0, 0xF0, 0x00, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x7E,
  0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x01, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0x80,
  0x00, 0x7C, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x3E, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFE, 0x00,
  0x0F, 0xC0, 0x00, 0x78, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0F,
  0xE0, 0x1F, 0xFC, 0x3F, 0xFF, 0x1F, 0xFF, 0xCF, 0xFF, 0xF3, 0x01, 0xF9,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03,
  0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x10, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x1F, 0x00, 0x01,
  0xF0, 0x1F, 0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x1E, 0x0F, 0x80, 0x00,
  0x0F, 0x87, 0x80, 0x7F, 0x03, 0xC7, 0xC0, 0xFF, 0xE1, 0xE3, 0xC0, 0xFF,
  0xF0, 0x79, 0xE0, 0xFE, 0xF8, 0x3D, 0xE0, 0x78, 0x3C, 0x1E, 0xF0, 0x7C,
  0x1E, 0x0F, 0x78, 0x3C, 0x0F, 0x07, 0xBC, 0x1E, 0x07, 0x83, 0xDE, 0x1E,
  0x03, 0xC1, 0xEF, 0x0F, 0x01, 0xE0, 0xFF, 0x07, 0x80, 0xF0, 0x7F, 0x83,
  0xC0, 0x78, 0x3F, 0xC1, 0xE0, 0x7C, 0x1F, 0xE0, 0xF0, 0x3E, 0x0F, 0xF8,
  0x78, 0x1F, 0x07, 0xBC, 0x3E, 0x0F, 0x83, 0x9E, 0x0F, 0x0F, 0xC3, 0xCF,
  0x07, 0xCF, 0xF3, 0xE7, 0x81, 0xFF, 0x3F, 0xE3, 0xC0, 0xFF, 0x9F, 0xE0,
  0xF0, 0x1F, 0x07, 0xE0, 0x78, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x18, 0x00, 0x1F, 0xE0, 0x7C, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x3E, 0xF0, 0x00, 0x07, 0xDF,
  0x00, 0x00, 0xFB, 0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x07, 0xC7, 0xC0, 0x00,
  0xF8, 0xF8, 0x00, 0x1F, 0x1F, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0xF8, 0x3E,
  0x00, 0x1F, 0x07, 0xC0, 0x07, 0xE0, 0xF8, 0x00, 0xF8, 0x0F, 0x80, 0x1F,
  0x01, 0xF0, 0x03, 0xE0, 0x3E, 0x00, 0xFC, 0x07, 0xC0, 0x1F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x03, 0xE0,
  0x07, 0xE0, 0x7C, 0x00, 0x7C, 0x1F, 0x80, 0x0F, 0x83, 0xF0, 0x01, 0xF8,
  0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE3, 0xF0, 0x00, 0x7E, 0x7E, 0x00,
  0x0F, 0xCF, 0x80, 0x00, 0xFB, 0xF0, 0x00, 0x1F, 0x7E, 0x00, 0x03, 0xF0,
  0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0x80,
  0xFF, 0x7C, 0x01, 0xFB, 0xE0, 0x07, 0xDF, 0x00, 0x3E, 0xF8, 0x01, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0x7D, 0xF0, 0x03, 0xEF, 0x80, 0x3F, 0x7C, 0x01,
  0xF3, 0xE0, 0x3F, 0x9F, 0xFF, 0xF8, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x3F,
  0xFF, 0xF1, 0xF0, 0x1F, 0xEF, 0x80, 0x3F, 0x7C, 0x00, 0xFF, 0xE0, 0x07,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xDF, 0x03, 0xFE,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF, 0xE1, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF8, 0x7F, 0x00, 0xC3, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xE0, 0x02, 0x1F, 0xE0, 0x78, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80,
  0xFF, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x10, 0x00, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0x80, 0xFF, 0x1F, 0x00,
  0x7F, 0x3E, 0x00, 0x7E, 0x7C, 0x00, 0x7E, 0xF8, 0x00, 0xFD, 0xF0, 0x00,
  0xFB, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFB, 0xE0,
  0x03, 0xF7, 0xC0, 0x07, 0xEF, 0x80, 0x1F, 0x9F, 0x00, 0x7F, 0x3E, 0x01,
  0xFC, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0xFC,
  0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF,
  0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF7, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0x00, 0x70, 0x7F, 0x00, 0x08,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x01, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0,
  0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xDF,
  0x00, 0x07, 0xEF, 0xC0, 0x03, 0xF7, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0xFC,
  0xFC, 0x00, 0x7E, 0x3F, 0x80, 0x3F, 0x1F, 0xF0, 0x3F, 0x87, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x00, 0x20,
  0x00, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF1, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8,
  0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8,
  0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8,
  0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x7F, 0xCF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x3F, 0x03, 0xEF, 0xFE, 0xFF, 0xEF, 0xFC, 0xFF, 0x8F, 0xE0,
  0xF8, 0x00, 0xFD, 0xF0, 0x03, 0xF3, 0xE0, 0x07, 0xC7, 0xC0, 0x1F, 0x8F,
  0x80, 0x7E, 0x1F, 0x00, 0xF8, 0x3E, 0x03, 0xF0, 0x7C, 0x0F, 0xC0, 0xF8,
  0x1F, 0x01, 0xF0, 0x7E, 0x03, 0xE1, 0xF8, 0x07, 0xC3, 0xE0, 0x0F, 0x8F,
  0xC0, 0x1F, 0x3F, 0x00, 0x3E, 0x7C, 0x00, 0x7D, 0xF8, 0x00, 0xFB, 0xF0,
  0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x0F, 0xE7, 0xC0,
  0x1F, 0x8F, 0xC0, 0x3E, 0x0F, 0x80, 0x7C, 0x1F, 0x80, 0xF8, 0x1F, 0x01,
  0xF0, 0x3F, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x7E, 0x0F, 0x80, 0x7E, 0x1F,
  0x00, 0xFC, 0x3E, 0x00, 0xFC, 0x7C, 0x01, 0xF8, 0xF8, 0x01, 0xF9, 0xF0,
  0x03, 0xF3, 0xE0, 0x03, 0xF7, 0xC0, 0x07, 0xF0, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x01, 0xEF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFB, 0xC0, 0x03, 0xDF, 0xFB, 0xE0, 0x03, 0xDF, 0xFB, 0xE0, 0x07,
  0xDF, 0xF9, 0xE0, 0x07, 0x9F, 0xF9, 0xF0, 0x07, 0x9F, 0xF9, 0xF0, 0x0F,
  0x9F, 0xF8, 0xF0, 0x0F, 0x1F, 0xF8, 0xF0, 0x0F, 0x1F, 0xF8, 0xF8, 0x1F,
  0x1F, 0xF8, 0xF8, 0x1F, 0x1F, 0xF8, 0x78, 0x1E, 0x1F, 0xF8, 0x7C, 0x1E,
  0x1F, 0xF8, 0x7C, 0x3E, 0x1F, 0xF8, 0x3C, 0x3C, 0x1F, 0xF8, 0x3E, 0x3C,
  0x1F, 0xF8, 0x3E, 0x7C, 0x1F, 0xF8, 0x1E, 0x78, 0x1F, 0xF8, 0x1E, 0x78,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF8, 0x0F, 0xF0,
  0x1F, 0xF8, 0x0F, 0xF0, 0x1F, 0xF8, 0x0F, 0xF0, 0x1F, 0xF8, 0x07, 0xE0,
  0x1F, 0xF8, 0x07, 0xE0, 0x1F, 0xF8, 0x07, 0xE0, 0x1F, 0xF8, 0x03, 0xC0,
  0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0,
  0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF,
  0x80, 0x1F, 0xFF, 0xE0, 0x0F, 0xFD, 0xF0, 0x07, 0xFE, 0xFC, 0x03, 0xFF,
  0x3E, 0x01, 0xFF, 0x9F, 0x80, 0xFF, 0xC7, 0xC0, 0x7F, 0xE3, 0xF0, 0x3F,
  0xF0, 0xF8, 0x1F, 0xF8, 0x7E, 0x0F, 0xFC, 0x1F, 0x07, 0xFE, 0x0F, 0x83,
  0xFF, 0x03, 0xE1, 0xFF, 0x81, 0xF0, 0xFF, 0xC0, 0x7C, 0x7F, 0xE0, 0x3E,
  0x3F, 0xF0, 0x0F, 0x9F, 0xF8, 0x07, 0xCF, 0xFC, 0x01, 0xF7, 0xFE, 0x00,
  0xFB, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0,
  0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE,
  0x00, 0x0F, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xF8,
  0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x07, 0xF0,
  0x3F, 0x83, 0xF0, 0x03, 0xF1, 0xF8, 0x00, 0x7C, 0x7E, 0x00, 0x1F, 0x9F,
  0x00, 0x03, 0xEF, 0xC0, 0x00, 0xFB, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFD, 0xF0, 0x00,
  0x3E, 0x7E, 0x00, 0x1F, 0x9F, 0x80, 0x07, 0xE3, 0xF0, 0x03, 0xF0, 0xFE,
  0x01, 0xFC, 0x1F, 0xE1, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80,
  0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0x00, 0x00, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xF8, 0x1F, 0xEF, 0x80,
  0x7E, 0xF8, 0x03, 0xEF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8,
  0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xEF,
  0x80, 0x7E, 0xF8, 0x0F, 0xEF, 0x83, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0,
  0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x7F,
  0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x07, 0xF0, 0x3F, 0x83,
  0xF0, 0x03, 0xF1, 0xF8, 0x00, 0x7E, 0x7E, 0x00, 0x1F, 0x9F, 0x00, 0x03,
  0xEF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFD, 0xF0, 0x00, 0x3E, 0x7E,
  0x00, 0x1F, 0x9F, 0x80, 0x07, 0xE3, 0xF0, 0x03, 0xF0, 0xFE, 0x01, 0xFC,
  0x1F, 0xE1, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF,
  0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x02, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0xFF, 0xFC,
  0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xF8, 0x1F, 0xE3,
  0xE0, 0x1F, 0x8F, 0x80, 0x3F, 0x3E, 0x00, 0xFC, 0xF8, 0x03, 0xF3, 0xE0,
  0x0F, 0xCF, 0x80, 0x1F, 0x3E, 0x00, 0xFC, 0xF8, 0x03, 0xF3, 0xE0, 0x0F,
  0x8F, 0x80, 0x7E, 0x3E, 0x01, 0xF8, 0xF8, 0x1F, 0xC3, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xE1, 0xF8, 0x0F, 0x83,
  0xE0, 0x3E, 0x0F, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7E, 0x0F, 0x80, 0xF8,
  0x3E, 0x03, 0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x8F, 0x80, 0x3E, 0x3E,
  0x00, 0xFC, 0xF8, 0x01, 0xF3, 0xE0, 0x07, 0xEF, 0x80, 0x0F, 0xBE, 0x00,
  0x3F, 0x01, 0xFC, 0x00, 0xFF, 0xF8, 0x7F, 0xFF, 0x9F, 0xFF, 0xE3, 0xFF,
  0xFC, 0xFE, 0x07, 0x9F, 0x80, 0x13, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0,
  0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xE0, 0x01, 0xFE, 0x00, 0x7E, 0xFC, 0x1F, 0xDF, 0xFF, 0xF3, 0xFF, 0xFC,
  0x7F, 0xFF, 0x03, 0xFF, 0xC0, 0x01, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01,
  0xFF, 0xC0, 0x03, 0xEF, 0xC0, 0x07, 0xDF, 0x80, 0x1F, 0x9F, 0x80, 0x3F,
  0x3F, 0xC1, 0xFC, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80,
  0x1F, 0xFC, 0x00, 0x01, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xDF, 0x00, 0x03,
  0xE7, 0xC0, 0x00, 0xF9, 0xF0, 0x00, 0x3E, 0x7E, 0x00, 0x1F, 0x8F, 0x80,
  0x07, 0xC3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x3E, 0x07,
  0xC0, 0x0F, 0x81, 0xF0, 0x03, 0xE0, 0x7C, 0x01, 0xF8, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x07, 0xC0,
  0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x03,
  0xE1, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0x8F, 0x80,
  0x01, 0xF3, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x3C, 0x00, 0x03, 0xDF,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x7C, 0x00, 0x7E, 0x00,
  0x1F, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x7C,
  0x00, 0x7F, 0x00, 0x3E, 0x7E, 0x00, 0xFF, 0x00, 0x3E, 0x3E, 0x00, 0xFF,
  0x00, 0x3E, 0x3E, 0x00, 0xFF, 0x00, 0x7E, 0x3E, 0x00, 0xFF, 0x80, 0x7C,
  0x3E, 0x01, 0xF7, 0x80, 0x7C, 0x1F, 0x01, 0xF7, 0x80, 0x7C, 0x1F, 0x01,
  0xE7, 0x80, 0xFC, 0x1F, 0x01, 0xE7, 0xC0, 0xF8, 0x1F, 0x01, 0xE7, 0xC0,
  0xF8, 0x1F, 0x03, 0xE7, 0xC0, 0xF8, 0x0F, 0x83, 0xE3, 0xC0, 0xF8, 0x0F,
  0x83, 0xC3, 0xC1, 0xF8, 0x0F, 0x83, 0xC3, 0xE1, 0xF0, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0x07, 0x87, 0xC1, 0xE1, 0xF0, 0x07, 0xC7, 0x81, 0xE1, 0xF0,
  0x07, 0xC7, 0x81, 0xF3, 0xE0, 0x07, 0xC7, 0x81, 0xF3, 0xE0, 0x07, 0xCF,
  0x80, 0xF3, 0xE0, 0x03, 0xCF, 0x80, 0xF3, 0xE0, 0x03, 0xEF, 0x00, 0xF3,
  0xE0, 0x03, 0xEF, 0x00, 0xF7, 0xC0, 0x03, 0xEF, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x7E, 0x00, 0x3F, 0x3E, 0x00, 0x7E, 0x3F, 0x00, 0x7C,
  0x1F, 0x00, 0xFC, 0x1F, 0x80, 0xF8, 0x0F, 0x81, 0xF8, 0x0F, 0xC1, 0xF0,
  0x07, 0xC1, 0xF0, 0x07, 0xC3, 0xE0, 0x03, 0xE3, 0xE0, 0x03, 0xE7, 0xC0,
  0x01, 0xF7, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xF7, 0xC0,
  0x03, 0xE7, 0xC0, 0x03, 0xE3, 0xE0, 0x07, 0xE3, 0xE0, 0x07, 0xC3, 0xF0,
  0x0F, 0xC1, 0xF0, 0x0F, 0x81, 0xF8, 0x1F, 0x80, 0xF8, 0x1F, 0x00, 0xFC,
  0x3F, 0x00, 0x7C, 0x3E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7C, 0x00, 0x3E,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x7C, 0x00, 0x3E, 0x7E, 0x00, 0x7E,
  0x3E, 0x00, 0x7C, 0x3E, 0x00, 0xFC, 0x3F, 0x00, 0xF8, 0x1F, 0x00, 0xF8,
  0x1F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x07, 0xC3, 0xE0,
  0x07, 0xC3, 0xE0, 0x07, 0xE7, 0xC0, 0x03, 0xE7, 0xC0, 0x03, 0xE7, 0xC0,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF,
  0xFF, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF0,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x00,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03,
  0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x38, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x7B, 0xC0, 0x01, 0xF7, 0xC0, 0x03, 0xC7, 0x80, 0x0F, 0x8F, 0x80,
  0x1E, 0x0F, 0x00, 0x7C, 0x1F, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x3E, 0x07,
  0xC0, 0x3C, 0x0F, 0x00, 0x7C, 0x3E, 0x00, 0x78, 0x78, 0x00, 0xF9, 0xF0,
  0x00, 0xF3, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xC0, 0xF8, 0x0F,
  0x81, 0xF8, 0x1F, 0x01, 0xF0, 0x0F, 0x03, 0xFC, 0x03, 0xFF, 0xE0, 0xFF,
  0xFE, 0x0F, 0xFF, 0xC1, 0xE0, 0xFC, 0x20, 0x0F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x3F, 0xF0, 0x7F,
  0xFE, 0x3F, 0xFF, 0xCF, 0xFF, 0xFB, 0xF8, 0x1F, 0xFC, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x03,
  0xFF, 0xE0, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0x7C, 0xFF, 0xC7, 0x8F, 0xF0,
  0xF0, 0x30, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0xFC, 0x0F, 0x8F,
  0xF8, 0x7C, 0xFF, 0xE3, 0xEF, 0xFF, 0x9F, 0xF9, 0xFC, 0xFF, 0x03, 0xF7,
  0xF0, 0x0F, 0xBF, 0x00, 0x7D, 0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00,
  0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF,
  0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03,
  0xFF, 0x80, 0x3F, 0xFE, 0x01, 0xF7, 0xF0, 0x1F, 0xBF, 0xC1, 0xFD, 0xFF,
  0xFF, 0xCF, 0xBF, 0xFC, 0x7C, 0xFF, 0xC3, 0xE3, 0xFC, 0x00, 0x03, 0x00,
  0x01, 0xFE, 0x03, 0xFF, 0xC3, 0xFF, 0xE3, 0xFF, 0xE1, 0xFC, 0xF1, 0xF8,
  0x08, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8,
  0x00, 0x7F, 0x03, 0x1F, 0xFF, 0x8F, 0xFF, 0xC3, 0xFF, 0xE0, 0x7F, 0xE0,
  0x03, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x07, 0xE1, 0xF0, 0x7F, 0xCF,
  0x8F, 0xFF, 0x7C, 0x7F, 0xFF, 0xE7, 0xF1, 0xFF, 0x3F, 0x03, 0xFB, 0xF0,
  0x0F, 0xDF, 0x00, 0x7E, 0xF8, 0x03, 0xF7, 0xC0, 0x0F, 0xFE, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7D, 0xF0, 0x03, 0xEF,
  0x80, 0x3F, 0x7E, 0x01, 0xFB, 0xF0, 0x1F, 0xCF, 0xC1, 0xFE, 0x7F, 0xFF,
  0xF1, 0xFF, 0xEF, 0x87, 0xFE, 0x3C, 0x1F, 0xE1, 0xE0, 0x08, 0x00, 0x01,
  0xFC, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x81, 0xFF, 0xFC, 0x3F, 0x0F, 0xC3,
  0xE0, 0x3E, 0x7E, 0x03, 0xE7, 0xC0, 0x1E, 0x7C, 0x01, 0xF7, 0xC0, 0x1F,
  0x78, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x23, 0xF8, 0x06, 0x1F,
  0xFF, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x10, 0x00,
  0x00, 0xFC, 0x03, 0xFF, 0x07, 0xFE, 0x0F, 0xFE, 0x0F, 0xC4, 0x0F, 0x80,
  0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0xF8,
  0x7F, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x78, 0x3F, 0xE3, 0xC7,
  0xFF, 0xBE, 0x3F, 0xFF, 0xF3, 0xF8, 0xFF, 0x9F, 0x81, 0xFD, 0xF8, 0x07,
  0xEF, 0x80, 0x3F, 0x7C, 0x01, 0xFB, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8,
  0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3E, 0xF8, 0x01, 0xF7, 0xC0,
  0x1F, 0xBE, 0x00, 0xFD, 0xF8, 0x0F, 0xE7, 0xE0, 0xFF, 0x3F, 0xFF, 0xF8,
  0xFF, 0xF7, 0xC3, 0xFF, 0x3E, 0x0F, 0xF1, 0xF0, 0x04, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x88,
  0x00, 0xFC, 0x78, 0x1F, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0xFF, 0xFE,
  0x01, 0xFF, 0x80, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x87, 0xE0, 0xF8, 0xFF, 0x8F,
  0xBF, 0xFC, 0xFB, 0xFF, 0xEF, 0xFC, 0xFE, 0xFF, 0x03, 0xFF, 0xE0, 0x3F,
  0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01,
  0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0,
  0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC,
  0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF,
  0xC0, 0x1F, 0xFC, 0x01, 0xF0, 0x7B, 0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x83,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC1, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3E, 0x0F, 0xA7, 0xEF, 0xFB, 0xFC, 0xFE, 0x3F,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x7E, 0xF8, 0x07, 0xCF, 0x80, 0xFC,
  0xF8, 0x1F, 0x8F, 0x81, 0xF0, 0xF8, 0x3E, 0x0F, 0x87, 0xE0, 0xF8, 0xFC,
  0x0F, 0x8F, 0x80, 0xF9, 0xF0, 0x0F, 0x3F, 0x00, 0xF3, 0xE0, 0x0F, 0x7E,
  0x00, 0xF7, 0xF0, 0x0F, 0xFF, 0x00, 0xFE, 0xF8, 0x0F, 0xCF, 0x80, 0xF8,
  0x7C, 0x0F, 0x87, 0xC0, 0xF8, 0x3E, 0x0F, 0x83, 0xF0, 0xF8, 0x1F, 0x0F,
  0x81, 0xF8, 0xF8, 0x0F, 0x8F, 0x80, 0xFC, 0xF8, 0x07, 0xCF, 0x80, 0x7E,
  0xF8, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x7E, 0x01,
  0xF8, 0x7C, 0xFF, 0xC3, 0xFE, 0x3E, 0xFF, 0xF3, 0xFF, 0x9F, 0x7F, 0xFB,
  0xFF, 0xEF, 0xFC, 0xFF, 0xE7, 0xF7, 0xF0, 0x3F, 0xC0, 0xFF, 0xF8, 0x0F,
  0xE0, 0x3F, 0xF8, 0x07, 0xE0, 0x1F, 0xFC, 0x03, 0xF0, 0x0F, 0xFE, 0x01,
  0xF8, 0x07, 0xFF, 0x00, 0xF8, 0x03, 0xFF, 0x80, 0x7C, 0x01, 0xFF, 0xC0,
  0x3E, 0x00, 0xFF, 0xE0, 0x1F, 0x00, 0x7F, 0xF0, 0x0F, 0x80, 0x3F, 0xF8,
  0x07, 0xC0, 0x1F, 0xFC, 0x03, 0xE0, 0x0F, 0xFE, 0x01, 0xF0, 0x07, 0xFF,
  0x00, 0xF8, 0x03, 0xFF, 0x80, 0x7C, 0x01, 0xFF, 0xC0, 0x3E, 0x00, 0xFF,
  0xE0, 0x1F, 0x00, 0x7F, 0xF0, 0x0F, 0x80, 0x3F, 0xF8, 0x07, 0xC0, 0x1F,
  0xFC, 0x03, 0xE0, 0x0F, 0xFE, 0x01, 0xF0, 0x07, 0xFF, 0x00, 0xF8, 0x03,
  0xFF, 0x80, 0x7C, 0x01, 0xF0, 0xF8, 0x7E, 0x0F, 0x8F, 0xF8, 0xFB, 0xFF,
  0xCF, 0xBF, 0xFE, 0xFF, 0xCF, 0xEF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xC0,
  0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC,
  0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF,
  0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F,
  0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01,
  0xFF, 0xC0, 0x1F, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xF0, 0x3F,
  0xFF, 0x83, 0xF8, 0xFE, 0x1F, 0x81, 0xF9, 0xF8, 0x07, 0xCF, 0x80, 0x3F,
  0x7C, 0x00, 0xFB, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF,
  0xE0, 0x07, 0xDF, 0x00, 0x3E, 0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0xBF, 0x00,
  0xF8, 0xF8, 0x07, 0xC7, 0xE0, 0x7C, 0x1F, 0xFF, 0xE0, 0x7F, 0xFE, 0x01,
  0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x02, 0x00, 0x00, 0xF8, 0x7E, 0x07, 0xC7,
  0xFC, 0x3E, 0x7F, 0xF1, 0xF7, 0xFF, 0xCF, 0xF8, 0xFE, 0x7F, 0x81, 0xFB,
  0xF8, 0x07, 0xDF, 0x80, 0x3E, 0xFC, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00,
  0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF,
  0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x03,
  0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0xFB, 0xF8, 0x0F, 0xDF, 0xE0, 0xFC, 0xFB,
  0xFF, 0xE7, 0xDF, 0xFE, 0x3E, 0x7F, 0xE1, 0xF1, 0xFE, 0x0F, 0xC0, 0x80,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x78, 0x3F, 0xE3, 0xC7, 0xFF,
  0xBE, 0x3F, 0xFF, 0xF3, 0xF8, 0xFF, 0x9F, 0x81, 0xFD, 0xF8, 0x07, 0xEF,
  0x80, 0x3F, 0x7C, 0x01, 0xFB, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3E, 0xF8, 0x01, 0xF7, 0xC0, 0x1F,
  0xBF, 0x00, 0xFD, 0xF8, 0x0F, 0xE7, 0xE0, 0xFF, 0x3F, 0xFF, 0xF8, 0xFF,
  0xF7, 0xC3, 0xFF, 0x3E, 0x0F, 0xF1, 0xF0, 0x04, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0xF0, 0x7F, 0xE3, 0xFF, 0x9F, 0xFE, 0xFF, 0xFB, 0xFF, 0xFE,
  0x0F, 0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0x07, 0xF8, 0x1F, 0xFE, 0x3F, 0xFF, 0x7F, 0xFE, 0xFC,
  0x1E, 0xF8, 0x02, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x80,
  0x1F, 0xE0, 0x3F, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0x7F, 0xF0, 0x01,
  0x00, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7E, 0x01, 0xFF, 0xC3, 0xFF, 0x0F, 0xFC, 0x1F,
  0xF0, 0x0C, 0x00, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xF7, 0xC0, 0x3F, 0x7C, 0x07,
  0xF7, 0xE0, 0xFF, 0x7F, 0xFF, 0xF3, 0xFF, 0xDF, 0x1F, 0xF8, 0xF0, 0xFF,
  0x0F, 0x01, 0x80, 0x00, 0xF8, 0x00, 0x7F, 0xF0, 0x03, 0xF7, 0xC0, 0x0F,
  0x9F, 0x00, 0x3E, 0x7C, 0x00, 0xF8, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x0F,
  0x80, 0x7C, 0x1E, 0x01, 0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x0F, 0x87, 0xC0, 0x3E, 0x1F, 0x00, 0xF8, 0x7C, 0x01, 0xE1, 0xE0,
  0x07, 0xCF, 0x80, 0x1F, 0x3E, 0x00, 0x7C, 0xF8, 0x00, 0xF3, 0xC0, 0x03,
  0xDF, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0xF8, 0x01, 0xF0,
  0x07, 0xDF, 0x00, 0xFC, 0x01, 0xF7, 0xC0, 0x3F, 0x80, 0x7D, 0xF0, 0x0F,
  0xE0, 0x1F, 0x7C, 0x03, 0xF8, 0x0F, 0x8F, 0x81, 0xFE, 0x03, 0xE3, 0xE0,
  0x7B, 0xC0, 0xF8, 0xF8, 0x1E, 0xF0, 0x3E, 0x3E, 0x07, 0xBC, 0x0F, 0x07,
  0x83, 0xEF, 0x07, 0xC1, 0xF0, 0xF3, 0xC1, 0xF0, 0x7C, 0x3C, 0x78, 0x7C,
  0x1F, 0x0F, 0x1E, 0x1E, 0x07, 0xC3, 0xC7, 0x8F, 0x80, 0xF9, 0xF1, 0xE3,
  0xE0, 0x3E, 0x78, 0x7C, 0xF8, 0x0F, 0x9E, 0x0F, 0x3C, 0x03, 0xE7, 0x83,
  0xCF, 0x00, 0x79, 0xE0, 0xF7, 0xC0, 0x1E, 0xF0, 0x3D, 0xF0, 0x07, 0xFC,
  0x0F, 0x78, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x0F,
  0xF0, 0x1F, 0xE0, 0x03, 0xF8, 0x07, 0xF8, 0x00, 0xFE, 0x01, 0xFC, 0x00,
  0x1F, 0x80, 0x3F, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0xFC, 0x01, 0xF3, 0xE0,
  0x1F, 0x9F, 0x00, 0xF8, 0x7C, 0x0F, 0xC3, 0xE0, 0x7C, 0x0F, 0x87, 0xE0,
  0x7C, 0x3E, 0x01, 0xF3, 0xF0, 0x0F, 0x9F, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0x80, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x1F, 0x3E,
  0x00, 0xF9, 0xF8, 0x0F, 0x87, 0xC0, 0xFC, 0x3F, 0x07, 0xC0, 0xF8, 0x7E,
  0x07, 0xE3, 0xE0, 0x1F, 0x3F, 0x00, 0xFD, 0xF0, 0x03, 0xF0, 0xF8, 0x00,
  0x7F, 0xF0, 0x03, 0xF7, 0xC0, 0x0F, 0x9F, 0x00, 0x3E, 0x7E, 0x00, 0xF8,
  0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x1F, 0x01, 0xF0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x03, 0xC0, 0xF8, 0x0F, 0x87, 0xC0, 0x3E, 0x1F,
  0x00, 0x78, 0x7C, 0x01, 0xF1, 0xF0, 0x07, 0xCF, 0x80, 0x1F, 0x3E, 0x00,
  0x3C, 0xF8, 0x00, 0xFB, 0xC0, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x11, 0xF8,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0,
  0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0x00, 0x3F,
  0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0,
  0x1F, 0xC0, 0xFF, 0x80, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x0F, 0xC0,
  0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x7F,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x80, 0x01,
  0xF8, 0x03, 0xF8, 0x07, 0xF8, 0x0F, 0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0xC0, 0x1F, 0x80, 0x7F, 0x03, 0xFE, 0x07, 0xE0, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07,
  0xC0, 0x1F, 0x81, 0xFF, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0x80, 0x00, 0x04,
  0x00, 0x09, 0xFE, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFA, 0x00, 0x7F, 0x90, 0x00, 0x60,
};

const GFXglyph NotoSans_Condensed_Medium51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 7, 37, 13, 3, -36 },
  { 34, 15, 13, 21, 3, -36 },
  { 59, 25, 36, 27, 1, -36 },
  { 172, 20, 42, 24, 2, -39 },
  { 277, 34, 37, 38, 2, -37 },
  { 435, 27, 38, 29, 2, -37 },
  { 564, 5, 13, 11, 3, -36 },
  { 573, 12, 45, 15, 2, -37 },
  { 641, 12, 45, 15, 1, -37 },
  { 709, 19, 20, 23, 2, -39 },
  { 757, 21, 24, 24, 2, -30 },
  { 820, 8, 13, 12, 2, -6 },
  { 833, 11, 5, 15, 2, -16 },
  { 840, 6, 8, 13, 3, -7 },
  { 846, 18, 37, 19, 1, -37 },
  { 930, 20, 38, 24, 2, -37 },
  { 1025, 14, 36, 24, 3, -36 },
  { 1088, 20, 37, 24, 2, -37 },
  { 1181, 20, 38, 24, 2, -37 },
  { 1276, 23, 37, 24, 1, -37 },
  { 1383, 19, 37, 24, 3, -36 },
  { 1471, 20, 38, 24, 2, -37 },
  { 1566, 20, 36, 24, 2, -36 },
  { 1656, 21, 38, 24, 2, -37 },
  { 1756, 20, 38, 24, 2, -37 },
  { 1851, 7, 29, 13, 3, -28 },
  { 1877, 8, 35, 13, 2, -28 },
  { 1912, 21, 24, 24, 2, -30 },
  { 1975, 21, 14, 24, 2, -25 },
  { 2012, 21, 24, 24, 2, -30 },
  { 2075, 17, 38, 19, 1, -37 },
  { 2156, 33, 41, 38, 2, -37 },
  { 2326, 27, 36, 27, 0, -36 },
  { 2448, 21, 36, 28, 4, -36 },
  { 2543, 22, 38, 26, 3, -37 },
  { 2648, 23, 36, 30, 4, -36 },
  { 2752, 17, 36, 23, 4, -36 },
  { 2829, 17, 36, 22, 4, -36 },
  { 2906, 25, 38, 31, 3, -37 },
  { 3025, 23, 36, 31, 4, -36 },
  { 3129, 12, 36, 16, 2, -36 },
  { 3183, 12, 46, 13, -3, -36 },
  { 3252, 23, 36, 26, 4, -36 },
  { 3356, 17, 36, 22, 4, -36 },
  { 3433, 32, 36, 40, 4, -36 },
  { 3577, 25, 36, 33, 4, -36 },
  { 3690, 26, 38, 32, 3, -37 },
  { 3814, 20, 36, 26, 4, -36 },
  { 3904, 26, 46, 32, 3, -37 },
  { 4054, 22, 36, 27, 4, -36 },
  { 4153, 19, 38, 23, 2, -37 },
  { 4244, 21, 36, 23, 1, -36 },
  { 4339, 23, 37, 30, 4, -36 },
  { 4446, 26, 36, 26, 0, -36 },
  { 4563, 40, 36, 40, 0, -36 },
  { 4743, 24, 36, 24, 0, -36 },
  { 4851, 24, 36, 24, 0, -36 },
  { 4959, 20, 36, 22, 1, -36 },
  { 5049, 11, 45, 16, 4, -37 },
  { 5111, 18, 37, 19, 1, -37 },
  { 5195, 12, 45, 16, 1, -37 },
  { 5263, 23, 21, 25, 1, -36 },
  { 5324, 22, 4, 22, 0, 4 },
  { 5335, 11, 8, 15, 2, -39 },
  { 5346, 19, 29, 24, 2, -28 },
  { 5415, 21, 40, 26, 3, -39 },
  { 5520, 17, 29, 20, 2, -28 },
  { 5582, 21, 40, 26, 2, -39 },
  { 5687, 20, 29, 24, 2, -28 },
  { 5760, 16, 39, 15, 1, -39 },
  { 5838, 21, 40, 26, 2, -28 },
  { 5943, 20, 39, 26, 3, -39 },
  { 6041, 6, 38, 12, 3, -38 },
  { 6070, 10, 50, 12, -1, -38 },
  { 6133, 20, 39, 24, 4, -39 },
  { 6231, 6, 39, 12, 3, -39 },
  { 6261, 33, 28, 40, 3, -28 },
  { 6377, 20, 28, 26, 3, -28 },
  { 6447, 21, 29, 26, 2, -28 },
  { 6524, 21, 40, 26, 3, -28 },
  { 6629, 21, 40, 26, 2, -28 },
  { 6734, 14, 28, 18, 3, -28 },
  { 6783, 16, 29, 20, 2, -28 },
  { 6841, 14, 35, 16, 1, -34 },
  { 6903, 20, 29, 26, 3, -28 },
  { 6976, 22, 28, 22, 0, -28 },
  { 7053, 34, 28, 35, 0, -28 },
  { 7172, 21, 28, 22, 1, -28 },
  { 7246, 22, 40, 22, 0, -28 },
  { 7356, 16, 28, 19, 1, -28 },
  { 7412, 16, 45, 19, 1, -37 },
  { 7502, 5, 51, 23, 9, -39 },
  { 7534, 15, 45, 19, 2, -37 },
  { 7619, 21, 8, 24, 2, -22 },
};

const GFXfont NotoSans_Condensed_Medium51pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Medium51pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Medium51pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _NOTOSANS_CONDENSED_MEDIUM51PT7B_H_
