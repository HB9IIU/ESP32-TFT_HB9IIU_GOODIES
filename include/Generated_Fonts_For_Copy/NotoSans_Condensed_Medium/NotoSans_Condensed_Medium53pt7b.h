#ifndef _NOTOSANS_CONDENSED_MEDIUM53PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUM53PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Medium.ttf
// Size: 53pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Medium53pt7bBitmaps[] PROGMEM = {
  0x00, 0xFE, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBE, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x1E, 0x3C, 0x78,
  0xF0, 0x00, 0x00, 0x00, 0x1C, 0x7D, 0xFF, 0xFF, 0xF7, 0xEF, 0x86, 0x00,
  0xFC, 0x3F, 0xFC, 0x3E, 0xFC, 0x3E, 0xFC, 0x3E, 0xFC, 0x3E, 0xF8, 0x3E,
  0xF8, 0x3E, 0x78, 0x3E, 0x78, 0x3E, 0x78, 0x3E, 0x78, 0x1E, 0x78, 0x1E,
  0x78, 0x1E, 0x78, 0x1E, 0x00, 0x78, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x07,
  0x83, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0xF0, 0x3C, 0x00, 0x3C, 0x0F, 0x00,
  0x0F, 0x07, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x1E,
  0x00, 0x0F, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0x07, 0x83, 0xC0, 0x01, 0xE0, 0xF0, 0x00,
  0xF0, 0x3C, 0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x07, 0xC0, 0x03, 0xC1, 0xE0,
  0x00, 0xF0, 0x78, 0x00, 0x3C, 0x1E, 0x03, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF0, 0x1E, 0x0F, 0x00, 0x07,
  0x83, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x0F, 0x00,
  0x0F, 0x03, 0xC0, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x1E,
  0x00, 0x0F, 0x07, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xF0,
  0x7F, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xF3, 0xF3, 0x83, 0x1F, 0x1C,
  0x00, 0xF0, 0xE0, 0x0F, 0x87, 0x00, 0x7C, 0x38, 0x01, 0xF1, 0xC0, 0x0F,
  0x8E, 0x00, 0x7E, 0x70, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xF8,
  0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0x73, 0xF0, 0x03, 0x8F, 0xC0, 0x1C, 0x3E, 0x00, 0xE1, 0xF0, 0x07, 0x0F,
  0x80, 0x38, 0x7C, 0x01, 0xC3, 0xF8, 0x0E, 0x3F, 0xF8, 0x77, 0xF7, 0xFF,
  0xFF, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x01, 0xFF, 0xE0, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x03, 0xFC, 0x00, 0x3C, 0x00, 0xFF, 0xC0,
  0x0F, 0x80, 0x3E, 0x7C, 0x01, 0xE0, 0x07, 0x87, 0x80, 0x3C, 0x00, 0xF0,
  0xF0, 0x0F, 0x00, 0x3E, 0x0F, 0x01, 0xE0, 0x07, 0xC1, 0xE0, 0x7C, 0x00,
  0xF0, 0x3C, 0x0F, 0x00, 0x1E, 0x07, 0x81, 0xE0, 0x03, 0xC0, 0xF0, 0x78,
  0x00, 0x78, 0x1E, 0x0F, 0x00, 0x0F, 0x03, 0xC3, 0xE0, 0x01, 0xE0, 0x78,
  0x78, 0x00, 0x3C, 0x0F, 0x1F, 0x00, 0x07, 0xC1, 0xE3, 0xC3, 0xF0, 0x78,
  0x3C, 0x78, 0xFF, 0x0F, 0x0F, 0x1E, 0x3F, 0xF1, 0xE1, 0xE3, 0xC7, 0xFF,
  0x3F, 0x7C, 0xF9, 0xF1, 0xE3, 0xFF, 0x1E, 0x3C, 0x3E, 0x3F, 0xC7, 0xC7,
  0x83, 0xC3, 0xF0, 0xF1, 0xF0, 0x78, 0x00, 0x1E, 0x3E, 0x0F, 0x00, 0x07,
  0xC7, 0xC1, 0xE0, 0x00, 0xF0, 0xF0, 0x3C, 0x00, 0x3E, 0x1E, 0x07, 0x80,
  0x07, 0x83, 0xC0, 0xF0, 0x00, 0xF0, 0x78, 0x1E, 0x00, 0x3C, 0x0F, 0x83,
  0xC0, 0x07, 0x81, 0xF0, 0x78, 0x01, 0xF0, 0x1E, 0x0F, 0x00, 0x3C, 0x03,
  0xC3, 0xE0, 0x0F, 0x80, 0x78, 0x78, 0x01, 0xE0, 0x07, 0x9F, 0x00, 0x3C,
  0x00, 0xFF, 0xC0, 0x0F, 0x00, 0x0F, 0xF8, 0x01, 0xE0, 0x00, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF,
  0xFC, 0x00, 0x1F, 0x87, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x03, 0xE0,
  0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x03, 0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x1F,
  0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0xF9, 0xF8,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x7E, 0x3F, 0xFE,
  0x07, 0xE3, 0xF3, 0xE0, 0x7C, 0x7E, 0x3F, 0x07, 0xC7, 0xC1, 0xF8, 0x7C,
  0xFC, 0x0F, 0xCF, 0xCF, 0x80, 0x7C, 0xF8, 0xF8, 0x07, 0xFF, 0x8F, 0x80,
  0x3F, 0xF0, 0xF8, 0x01, 0xFF, 0x0F, 0x80, 0x1F, 0xE0, 0xFC, 0x00, 0xFE,
  0x0F, 0xC0, 0x0F, 0xE0, 0xFE, 0x03, 0xFF, 0x07, 0xF8, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFC, 0xFC, 0x1F, 0xFF, 0x87, 0xE0, 0x7F, 0xE0,
  0x3F, 0x00, 0x40, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0x9E, 0x79,
  0xE7, 0x9E, 0x79, 0xE0, 0x00, 0xF8, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x7C,
  0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E,
  0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xFC, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3C, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x03,
  0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF0,
  0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xC0, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x08, 0x0F,
  0x02, 0x78, 0xF1, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0x80, 0x1F, 0x80, 0x03, 0xFC, 0x00, 0x7F, 0xE0, 0x0F, 0x9F, 0x00,
  0xF9, 0xF0, 0x1F, 0x0F, 0x83, 0xF0, 0xFC, 0x0E, 0x07, 0x00, 0x20, 0x40,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x3F, 0x3F, 0x3E, 0x3E, 0x3E, 0x7E,
  0x7C, 0x7C, 0x7C, 0x78, 0xF8, 0xF8, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x38, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0x08, 0x00, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xF8, 0x03, 0xFF,
  0xE0, 0x3F, 0xFF, 0x81, 0xFD, 0xFE, 0x1F, 0x83, 0xF0, 0xF8, 0x0F, 0x8F,
  0xC0, 0x7E, 0x7E, 0x01, 0xF3, 0xE0, 0x0F, 0x9F, 0x00, 0x7C, 0xF8, 0x03,
  0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC,
  0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0,
  0x0F, 0xDF, 0x00, 0x7E, 0xF8, 0x03, 0xF7, 0xC0, 0x1F, 0x3E, 0x00, 0xF9,
  0xF8, 0x0F, 0xC7, 0xC0, 0x7E, 0x3F, 0x07, 0xE0, 0xFC, 0x7F, 0x07, 0xFF,
  0xF0, 0x1F, 0xFF, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x3C, 0x01, 0xF0, 0x1F, 0xC0, 0xFF, 0x07, 0xFC, 0x3F, 0xF1, 0xFF,
  0xCF, 0xDF, 0x7E, 0x7F, 0xF1, 0xF3, 0x87, 0xC4, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xF8,
  0x0F, 0xFF, 0xE1, 0xFF, 0xFF, 0x87, 0xF1, 0xFE, 0x3C, 0x03, 0xF0, 0xC0,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07,
  0xFE, 0x01, 0xFF, 0xFC, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC7, 0xE1, 0xFE,
  0x3C, 0x03, 0xF8, 0x80, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x03, 0xF8, 0x07, 0xFF, 0x80, 0x3F, 0xF0, 0x01, 0xFF,
  0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0xC0,
  0x07, 0xF7, 0xC0, 0x7F, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0,
  0x1F, 0xFF, 0x00, 0x02, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7B, 0xE0, 0x00, 0x7B, 0xE0,
  0x00, 0xF3, 0xE0, 0x00, 0xF3, 0xE0, 0x01, 0xE3, 0xE0, 0x03, 0xE3, 0xE0,
  0x03, 0xC3, 0xE0, 0x07, 0xC3, 0xE0, 0x07, 0x83, 0xE0, 0x0F, 0x83, 0xE0,
  0x0F, 0x03, 0xE0, 0x1F, 0x03, 0xE0, 0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3C, 0x03, 0xE0, 0x7C, 0x03, 0xE0, 0x78, 0x03, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0xFF,
  0xC7, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8,
  0x60, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3,
  0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x80, 0x0F, 0xEF, 0x03,
  0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFE, 0x07, 0xFF, 0x80, 0x01,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0x00, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0xFF, 0x82, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF1, 0xFC, 0x0F, 0x9F, 0xF0, 0x79, 0xFF, 0xC7, 0xDF,
  0xFF, 0x3F, 0xF3, 0xFD, 0xFE, 0x07, 0xEF, 0xE0, 0x1F, 0xFE, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xDF, 0x00,
  0x3E, 0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0x7D, 0xF8, 0x07, 0xE7,
  0xC0, 0x3E, 0x3F, 0x03, 0xF0, 0xFC, 0x3F, 0x87, 0xFF, 0xF8, 0x1F, 0xFF,
  0x80, 0x7F, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x40, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3,
  0xF0, 0x7F, 0x3F, 0x01, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x01,
  0xF3, 0xE0, 0x0F, 0x9F, 0x00, 0x7C, 0xF8, 0x03, 0xE3, 0xE0, 0x3F, 0x1F,
  0x81, 0xF0, 0x7E, 0x3F, 0x83, 0xFB, 0xF8, 0x0F, 0xFF, 0x80, 0x3F, 0xF0,
  0x00, 0xFF, 0x80, 0x0F, 0xFE, 0x01, 0xFF, 0xFC, 0x1F, 0xC7, 0xF0, 0xFC,
  0x1F, 0xCF, 0xC0, 0x7E, 0x7C, 0x01, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80,
  0x1F, 0x7C, 0x01, 0xFB, 0xF8, 0x1F, 0x8F, 0xFF, 0xFC, 0x7F, 0xFF, 0xC0,
  0xFF, 0xFC, 0x03, 0xFF, 0x80, 0x01, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x7F,
  0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xF8, 0xFE, 0x3F, 0x03, 0xF1,
  0xF0, 0x0F, 0x8F, 0x80, 0x7E, 0xFC, 0x01, 0xF7, 0xC0, 0x0F, 0xBE, 0x00,
  0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xFF,
  0x80, 0x3F, 0xFC, 0x01, 0xFB, 0xE0, 0x1F, 0xDF, 0x80, 0xFE, 0xFF, 0x1F,
  0xF3, 0xFF, 0xEF, 0x8F, 0xFF, 0x7C, 0x3F, 0xF3, 0xE0, 0xFE, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC1, 0x03,
  0xFC, 0x0F, 0xFF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xF8, 0x00,
  0x0C, 0x00, 0x00, 0x38, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0x08, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x3E,
  0xFF, 0xFF, 0xFF, 0xF7, 0xC2, 0x00, 0x1C, 0x3E, 0x7F, 0x7F, 0x7F, 0x7F,
  0x3E, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x3F, 0x3E, 0x3E, 0x3E, 0x7E, 0x7C,
  0x7C, 0x7C, 0x78, 0xF8, 0xF0, 0xF0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x07,
  0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1F, 0xF8,
  0x3F, 0xFE, 0x3F, 0xFF, 0x9F, 0xFF, 0xE7, 0xC7, 0xFB, 0x00, 0xFC, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF8,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x04, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFE,
  0xFF, 0xC0, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x3C, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x1E, 0x0F,
  0x80, 0x00, 0x03, 0xC3, 0xC0, 0x1F, 0xC0, 0xF1, 0xF0, 0x1F, 0xFC, 0x3E,
  0x78, 0x0F, 0xFF, 0x07, 0x9E, 0x07, 0xFF, 0xC1, 0xE7, 0x83, 0xE0, 0xF0,
  0x7B, 0xE0, 0xF0, 0x3C, 0x1F, 0xF0, 0x7C, 0x0F, 0x03, 0xFC, 0x1E, 0x03,
  0xC0, 0xFF, 0x07, 0x80, 0xF0, 0x3F, 0xC1, 0xE0, 0x3C, 0x0F, 0xF0, 0x78,
  0x1F, 0x03, 0xFC, 0x1E, 0x07, 0xC0, 0xFF, 0x07, 0x81, 0xF0, 0x7B, 0xC1,
  0xE0, 0x7C, 0x1E, 0xF0, 0x78, 0x1F, 0x07, 0xBC, 0x1E, 0x07, 0xC1, 0xEF,
  0x07, 0x83, 0xF0, 0x7B, 0xC1, 0xF0, 0xFC, 0x3C, 0xF0, 0x3F, 0xF7, 0xFF,
  0x3E, 0x0F, 0xFC, 0xFF, 0x8F, 0x81, 0xFE, 0x3F, 0xC1, 0xE0, 0x1F, 0x03,
  0xE0, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x60, 0x00, 0x7F, 0x80, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xBE, 0x00,
  0x00, 0xF9, 0xE0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x1F,
  0x9F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0, 0xF8,
  0x00, 0x3F, 0x0F, 0x80, 0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x07,
  0xE0, 0x7C, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xC0, 0x3E, 0x00, 0x7C, 0x03,
  0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x81, 0xF8, 0x01, 0xF8, 0x1F, 0x00,
  0x0F, 0x83, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFC,
  0x3E, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xE7, 0xC0,
  0x00, 0x7E, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xF0,
  0x0F, 0xEF, 0xC0, 0x1F, 0xBF, 0x00, 0x7E, 0xFC, 0x00, 0xFB, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0xBF, 0x00, 0x3E, 0xFC, 0x00, 0xFB, 0xF0, 0x07, 0xEF,
  0xC0, 0x1F, 0x3F, 0x01, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF3, 0xF0, 0x0F, 0xEF, 0xC0, 0x1F,
  0xBF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF,
  0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x7F, 0xFC, 0x03, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xC3, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0xFF, 0x8F, 0xC3, 0xF8, 0x03, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x04, 0x1F, 0xF0, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x01, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x07, 0xE0, 0x3F, 0xC3, 0xF0, 0x07, 0xF1, 0xF8, 0x01, 0xF8,
  0xFC, 0x00, 0x7E, 0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xDF, 0x80, 0x07,
  0xEF, 0xC0, 0x03, 0xF7, 0xE0, 0x01, 0xFB, 0xF0, 0x00, 0x7D, 0xF8, 0x00,
  0x3E, 0xFC, 0x00, 0x1F, 0x7E, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFB, 0xF0, 0x00, 0x7D, 0xF8,
  0x00, 0x3E, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xDF,
  0x80, 0x07, 0xCF, 0xC0, 0x07, 0xE7, 0xE0, 0x07, 0xF3, 0xF0, 0x03, 0xF1,
  0xF8, 0x03, 0xF8, 0xFC, 0x07, 0xF8, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0xFE, 0x3F, 0x07, 0xF8, 0x01, 0xC1,
  0xFC, 0x00, 0x10, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x3F, 0x7E,
  0x00, 0x0F, 0xDF, 0xC0, 0x03, 0xF3, 0xF0, 0x00, 0xFC, 0xFE, 0x00, 0x3F,
  0x1F, 0xC0, 0x0F, 0xC3, 0xFE, 0x0F, 0xF0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x00, 0x20, 0x00, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xE1,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x1F, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x3F, 0x03, 0xF8,
  0xFF, 0xFF, 0xEF, 0xFC, 0xFF, 0xCF, 0xF0, 0x10, 0x00, 0xFC, 0x00, 0x7E,
  0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x01, 0xF8, 0xFC, 0x03, 0xF0,
  0xFC, 0x03, 0xF0, 0xFC, 0x07, 0xE0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x7E, 0x00,
  0xFC, 0x7C, 0x00, 0xFC, 0xFC, 0x00, 0xFD, 0xF8, 0x00, 0xFD, 0xF8, 0x00,
  0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00,
  0xFF, 0x7E, 0x00, 0xFE, 0x7E, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00,
  0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x01, 0xF8,
  0xFC, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0x7E,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x03, 0xDF, 0xFB, 0xC0, 0x00, 0xF7, 0xFE, 0xF8, 0x00, 0x7D, 0xFF,
  0xBE, 0x00, 0x1F, 0x7F, 0xEF, 0x80, 0x07, 0x9F, 0xF9, 0xF0, 0x03, 0xE7,
  0xFE, 0x7C, 0x00, 0xFB, 0xFF, 0x9F, 0x00, 0x3C, 0xFF, 0xE3, 0xC0, 0x1F,
  0x3F, 0xF8, 0xF8, 0x07, 0xCF, 0xFE, 0x3E, 0x01, 0xE3, 0xFF, 0x87, 0x80,
  0xF8, 0xFF, 0xE1, 0xF0, 0x3E, 0x3F, 0xF8, 0x7C, 0x0F, 0x0F, 0xFE, 0x1F,
  0x03, 0xC3, 0xFF, 0x83, 0xE1, 0xF0, 0xFF, 0xE0, 0xF8, 0x78, 0x3F, 0xF8,
  0x3E, 0x1E, 0x0F, 0xFE, 0x07, 0x8F, 0x83, 0xFF, 0x81, 0xF3, 0xE0, 0xFF,
  0xE0, 0x7C, 0xF0, 0x3F, 0xF8, 0x0F, 0x7C, 0x0F, 0xFE, 0x03, 0xFF, 0x03,
  0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xE0, 0x3F, 0xF8, 0x07, 0xF8,
  0x0F, 0xFE, 0x01, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0x00, 0xFF, 0xE0, 0x0F,
  0xC0, 0x3F, 0xF8, 0x03, 0xE0, 0x0F, 0xFE, 0x00, 0xF8, 0x03, 0xF0, 0xFE,
  0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F,
  0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00,
  0x1F, 0xFF, 0xE0, 0x07, 0xFE, 0xF8, 0x01, 0xFF, 0xBF, 0x00, 0x7F, 0xE7,
  0xC0, 0x1F, 0xF9, 0xF8, 0x07, 0xFE, 0x3E, 0x01, 0xFF, 0x8F, 0xC0, 0x7F,
  0xE1, 0xF0, 0x1F, 0xF8, 0x7E, 0x07, 0xFE, 0x0F, 0x81, 0xFF, 0x83, 0xF0,
  0x7F, 0xE0, 0x7C, 0x1F, 0xF8, 0x1F, 0x87, 0xFE, 0x03, 0xE1, 0xFF, 0x80,
  0xFC, 0x7F, 0xE0, 0x3F, 0x1F, 0xF8, 0x07, 0xE7, 0xFE, 0x01, 0xF9, 0xFF,
  0x80, 0x3F, 0x7F, 0xE0, 0x0F, 0xDF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00,
  0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xF9, 0xFF, 0x01, 0xFC, 0x03, 0xF8,
  0x3F, 0x80, 0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x0F, 0xC7, 0xE0,
  0x00, 0x7C, 0x7C, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x07,
  0xEF, 0xC0, 0x00, 0x3E, 0xFC, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x3E, 0xF8,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xEF,
  0xC0, 0x00, 0x3E, 0xFC, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x7E, 0xFC, 0x00,
  0x07, 0xE7, 0xC0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0xFC,
  0x3F, 0x00, 0x0F, 0xC3, 0xF8, 0x01, 0xF8, 0x1F, 0xC0, 0x3F, 0x81, 0xFF,
  0x1F, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x04, 0x00, 0x00, 0xFF, 0xF8, 0x07, 0xFF,
  0xF8, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x7E, 0x07, 0xFB,
  0xF0, 0x0F, 0xDF, 0x80, 0x7E, 0xFC, 0x01, 0xF7, 0xE0, 0x0F, 0xFF, 0x00,
  0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xDF,
  0x80, 0x3E, 0xFC, 0x03, 0xF7, 0xE0, 0x3F, 0xBF, 0x07, 0xF9, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFC, 0x7F, 0xFF, 0x83, 0xFF, 0xF8, 0x1F, 0xF8, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xE0, 0x1F, 0xF9, 0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x1F,
  0x83, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x7C, 0x7C,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0x3E, 0xFC, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3E,
  0xFC, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xE7, 0xC0,
  0x00, 0x7E, 0x7E, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x0F,
  0xC3, 0xF8, 0x01, 0xF8, 0x1F, 0xC0, 0x3F, 0x81, 0xFF, 0x1F, 0xF0, 0x0F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0xFF, 0xF8, 0x01,
  0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F,
  0x81, 0xFE, 0x3F, 0x00, 0xFC, 0x7E, 0x01, 0xF8, 0xFC, 0x01, 0xF9, 0xF8,
  0x03, 0xF3, 0xF0, 0x07, 0xE7, 0xE0, 0x0F, 0xCF, 0xC0, 0x1F, 0x9F, 0x80,
  0x3F, 0x3F, 0x00, 0x7C, 0x7E, 0x01, 0xF8, 0xFC, 0x07, 0xF1, 0xF8, 0x1F,
  0xC3, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0,
  0x3F, 0xFF, 0x80, 0x7E, 0x1F, 0x80, 0xFC, 0x1F, 0x01, 0xF8, 0x3F, 0x03,
  0xF0, 0x3E, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0x7C, 0x1F, 0x80, 0xFC, 0x3F,
  0x00, 0xF8, 0x7E, 0x01, 0xF8, 0xFC, 0x01, 0xF1, 0xF8, 0x03, 0xF3, 0xF0,
  0x07, 0xE7, 0xE0, 0x07, 0xEF, 0xC0, 0x0F, 0xDF, 0x80, 0x0F, 0xC0, 0x03,
  0xFF, 0x80, 0xFF, 0xFE, 0x1F, 0xFF, 0xF3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE7,
  0xF0, 0x0C, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xE0, 0x07, 0xEF, 0xE3, 0xFE,
  0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x03, 0xFF, 0xC0, 0x00, 0x80,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3E, 0x7E, 0x00, 0x7E, 0x7F, 0x00,
  0xFC, 0x3F, 0xC3, 0xFC, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x30, 0x00, 0xFC, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0xFD, 0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0xFC,
  0xFC, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0xFC, 0x3F, 0x00,
  0x1F, 0x83, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x81,
  0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x03,
  0xF0, 0x0F, 0xC0, 0x7C, 0x00, 0xF8, 0x0F, 0x80, 0x1F, 0x01, 0xF0, 0x03,
  0xE0, 0x7E, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x3E,
  0x00, 0x1F, 0x8F, 0x80, 0x01, 0xF1, 0xF0, 0x00, 0x3E, 0x3E, 0x00, 0x07,
  0xC7, 0xC0, 0x00, 0x79, 0xF0, 0x00, 0x0F, 0xBE, 0x00, 0x01, 0xF7, 0xC0,
  0x00, 0x3E, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0x00, 0x0F,
  0xC0, 0x03, 0xF7, 0xC0, 0x03, 0xF0, 0x00, 0xF9, 0xF0, 0x00, 0xFC, 0x00,
  0x3E, 0x7C, 0x00, 0x7F, 0x00, 0x1F, 0x9F, 0x80, 0x1F, 0xE0, 0x07, 0xE3,
  0xE0, 0x07, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xFE, 0x00, 0x7C, 0x3E, 0x00,
  0x7F, 0x80, 0x1F, 0x0F, 0xC0, 0x3F, 0xF0, 0x0F, 0xC3, 0xF0, 0x0F, 0x7C,
  0x03, 0xF0, 0x7C, 0x03, 0xCF, 0x00, 0xF8, 0x1F, 0x00, 0xF3, 0xC0, 0x3E,
  0x07, 0xC0, 0x7C, 0xF0, 0x0F, 0x81, 0xF8, 0x1F, 0x3E, 0x07, 0xE0, 0x3E,
  0x07, 0xCF, 0x81, 0xF0, 0x0F, 0x81, 0xE1, 0xE0, 0x7C, 0x03, 0xE0, 0xF8,
  0x78, 0x1F, 0x00, 0xF8, 0x3E, 0x1F, 0x0F, 0xC0, 0x3F, 0x0F, 0x87, 0xC3,
  0xF0, 0x07, 0xC3, 0xC1, 0xF0, 0xF8, 0x01, 0xF0, 0xF0, 0x3C, 0x3E, 0x00,
  0x7C, 0x7C, 0x0F, 0x8F, 0x80, 0x1F, 0x1F, 0x03, 0xE7, 0xE0, 0x07, 0xE7,
  0xC0, 0xF9, 0xF0, 0x00, 0xF9, 0xE0, 0x1E, 0x7C, 0x00, 0x3E, 0x78, 0x07,
  0x9F, 0x00, 0x0F, 0xBE, 0x01, 0xE7, 0xC0, 0x03, 0xEF, 0x80, 0x7D, 0xF0,
  0x00, 0x7B, 0xC0, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0,
  0x0F, 0xF8, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0x7E, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x8F, 0xC0, 0x0F, 0x83, 0xE0, 0x0F,
  0xC1, 0xF8, 0x07, 0xC0, 0x7C, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x0F, 0x81,
  0xF0, 0x07, 0xC1, 0xF8, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0xFC, 0x00, 0x7E,
  0x7C, 0x00, 0x1F, 0x7E, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00,
  0x03, 0xFF, 0x80, 0x01, 0xF7, 0xE0, 0x01, 0xF9, 0xF0, 0x00, 0xF8, 0xFC,
  0x00, 0xFC, 0x3E, 0x00, 0x7C, 0x1F, 0x80, 0x7E, 0x07, 0xC0, 0x3E, 0x03,
  0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x0F, 0xC0,
  0x0F, 0x8F, 0xC0, 0x07, 0xE7, 0xE0, 0x01, 0xF7, 0xE0, 0x00, 0xFC, 0xFC,
  0x00, 0x1F, 0xBE, 0x00, 0x0F, 0x9F, 0x80, 0x0F, 0xCF, 0xC0, 0x07, 0xC3,
  0xE0, 0x07, 0xE1, 0xF8, 0x03, 0xE0, 0x7C, 0x01, 0xF0, 0x3F, 0x01, 0xF8,
  0x1F, 0x80, 0xF8, 0x07, 0xC0, 0xFC, 0x03, 0xF0, 0x7C, 0x00, 0xF8, 0x3E,
  0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0xEF,
  0x80, 0x01, 0xF7, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0xFF,
  0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xF7, 0x80, 0x01, 0xE7,
  0xC0, 0x03, 0xE7, 0xC0, 0x03, 0xC3, 0xE0, 0x07, 0xC3, 0xE0, 0x07, 0x81,
  0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x1E, 0x00,
  0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFC, 0x0F, 0xC1, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xE0, 0x03, 0xFE, 0x00, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC,
  0x1F, 0x0F, 0xE0, 0x80, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x03, 0xFF, 0xF0, 0xFF,
  0xFF, 0x3F, 0xFF, 0xF7, 0xFC, 0x3F, 0x7E, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x07, 0xFF,
  0xC0, 0x7F, 0xFE, 0x0F, 0xF7, 0xFF, 0xDF, 0x7F, 0xFD, 0xF3, 0xFF, 0x9F,
  0x1F, 0xE0, 0xF0, 0x10, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0xFC,
  0x0F, 0x9F, 0xF8, 0x7D, 0xFF, 0xE3, 0xFF, 0xFF, 0x9F, 0xFB, 0xFC, 0xFE,
  0x07, 0xF7, 0xE0, 0x1F, 0xBF, 0x00, 0x7D, 0xF0, 0x03, 0xFF, 0x80, 0x1F,
  0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xF7, 0xE0, 0x1F, 0xBF, 0x80,
  0xFD, 0xFE, 0x0F, 0xCF, 0xFF, 0xFE, 0x79, 0xFF, 0xE3, 0xCF, 0xFE, 0x1E,
  0x1F, 0xE0, 0x00, 0x10, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0xF0, 0xFF, 0xFC,
  0x7F, 0xFE, 0x1F, 0xEF, 0x8F, 0xC0, 0x23, 0xF0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x01, 0x3F,
  0x81, 0xC7, 0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0xFE, 0x1F, 0x07, 0xFC,
  0x7C, 0x3F, 0xF9, 0xF1, 0xFF, 0xF7, 0xCF, 0xF3, 0xFF, 0x3F, 0x03, 0xFD,
  0xF8, 0x07, 0xF7, 0xE0, 0x0F, 0xDF, 0x00, 0x3F, 0x7C, 0x00, 0xFD, 0xF0,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xF7,
  0xC0, 0x0F, 0xDF, 0x00, 0x3F, 0x7E, 0x00, 0xFD, 0xF8, 0x07, 0xF3, 0xF0,
  0x1F, 0xCF, 0xE0, 0xFF, 0x1F, 0xFF, 0xFC, 0x7F, 0xFD, 0xF0, 0xFF, 0xE7,
  0xC0, 0xFF, 0x0F, 0x00, 0x40, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x03,
  0xFF, 0xE0, 0x3F, 0xFF, 0x81, 0xF8, 0x7E, 0x1F, 0x81, 0xF0, 0xF8, 0x07,
  0xCF, 0x80, 0x3E, 0x7C, 0x01, 0xF3, 0xE0, 0x07, 0xDF, 0x00, 0x3E, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x02, 0x1F, 0x80, 0x70,
  0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x08,
  0x00, 0x00, 0x10, 0x01, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x0F, 0xFE, 0x0F,
  0xC2, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0xFC, 0x7F, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x03,
  0xF8, 0x7C, 0x1F, 0xF1, 0xF0, 0xFF, 0xE7, 0xC7, 0xFF, 0xDF, 0x3F, 0xCF,
  0xFC, 0xFC, 0x0F, 0xF7, 0xE0, 0x1F, 0xDF, 0x80, 0x3F, 0x7C, 0x00, 0xFD,
  0xF0, 0x03, 0xF7, 0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0,
  0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0xC0, 0x0F, 0xDF, 0x00, 0x3F, 0x7C, 0x00, 0xFD, 0xF8, 0x03, 0xF7,
  0xE0, 0x1F, 0xCF, 0xC0, 0x7F, 0x3F, 0x83, 0xFC, 0x7F, 0xFD, 0xF1, 0xFF,
  0xF7, 0xC3, 0xFF, 0x9F, 0x03, 0xFC, 0x7C, 0x01, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x88,
  0x00, 0x7E, 0x38, 0x07, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF0, 0x1F, 0xFF, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x87,
  0xE0, 0xF9, 0xFF, 0x8F, 0xBF, 0xFC, 0xFF, 0xFF, 0xEF, 0xFD, 0xFE, 0xFE,
  0x07, 0xEF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0x7F,
  0xFF, 0xFF, 0x7D, 0xE0, 0x00, 0x00, 0x07, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D,
  0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D,
  0xF7, 0xDF, 0x7D, 0xF7, 0xC0, 0x03, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x3E,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x7E, 0x0F, 0xC1, 0xF7, 0xFE, 0xFF,
  0xDF, 0xF3, 0xFC, 0x1E, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x3F, 0xF8,
  0x07, 0xEF, 0x80, 0x7C, 0xF8, 0x0F, 0xCF, 0x81, 0xF8, 0xF8, 0x1F, 0x0F,
  0x83, 0xE0, 0xF8, 0x7E, 0x0F, 0x8F, 0xC0, 0xF8, 0xF8, 0x0F, 0x9F, 0x00,
  0xFB, 0xF0, 0x0F, 0xBF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0xFF, 0xF8,
  0x0F, 0xEF, 0xC0, 0xFC, 0x7C, 0x0F, 0x87, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF8, 0xF8, 0x0F, 0xCF, 0x80, 0xFC, 0xF8,
  0x07, 0xEF, 0x80, 0x7E, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE,
  0x01, 0xF8, 0x3C, 0x7F, 0xE1, 0xFF, 0x8F, 0x3F, 0xF8, 0xFF, 0xF3, 0xDF,
  0xFF, 0x7F, 0xFC, 0xFF, 0x9F, 0xFF, 0x7F, 0xBF, 0x81, 0xFE, 0x07, 0xEF,
  0xC0, 0x7F, 0x80, 0xFB, 0xF0, 0x0F, 0xC0, 0x3E, 0xF8, 0x03, 0xF0, 0x0F,
  0xFE, 0x00, 0xFC, 0x03, 0xFF, 0x80, 0x3E, 0x00, 0xFF, 0xE0, 0x0F, 0x80,
  0x3F, 0xF8, 0x03, 0xE0, 0x0F, 0xFE, 0x00, 0xF8, 0x03, 0xFF, 0x80, 0x3E,
  0x00, 0xFF, 0xE0, 0x0F, 0x80, 0x3F, 0xF8, 0x03, 0xE0, 0x0F, 0xFE, 0x00,
  0xF8, 0x03, 0xFF, 0x80, 0x3E, 0x00, 0xFF, 0xE0, 0x0F, 0x80, 0x3F, 0xF8,
  0x03, 0xE0, 0x0F, 0xFE, 0x00, 0xF8, 0x03, 0xFF, 0x80, 0x3E, 0x00, 0xFF,
  0xE0, 0x0F, 0x80, 0x3F, 0xF8, 0x03, 0xE0, 0x0F, 0xFE, 0x00, 0xF8, 0x03,
  0xFF, 0x80, 0x3E, 0x00, 0xFF, 0xE0, 0x0F, 0x80, 0x3F, 0xF8, 0x03, 0xE0,
  0x0F, 0xC0, 0xF0, 0x7E, 0x0F, 0x1F, 0xF8, 0xF3, 0xFF, 0xCF, 0x7F, 0xFE,
  0xFF, 0xDF, 0xEF, 0xE0, 0x7E, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x03,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07,
  0xFF, 0xF8, 0x1F, 0xC7, 0xF0, 0xFC, 0x07, 0xE3, 0xE0, 0x1F, 0x9F, 0x80,
  0x3E, 0x7C, 0x00, 0xFD, 0xF0, 0x01, 0xF7, 0xC0, 0x07, 0xFF, 0x00, 0x1F,
  0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC,
  0x00, 0x7F, 0xF0, 0x01, 0xF7, 0xC0, 0x07, 0xDF, 0x00, 0x1F, 0x7C, 0x00,
  0xFD, 0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0xC0, 0x7E, 0x1F, 0x83, 0xF0,
  0x7F, 0xFF, 0xC0, 0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0x00, 0x00,
  0x40, 0x00, 0xF0, 0x7E, 0x07, 0x8F, 0xFC, 0x3C, 0xFF, 0xF1, 0xEF, 0xFF,
  0xCF, 0xF8, 0xFE, 0x7F, 0x03, 0xFB, 0xF0, 0x0F, 0xDF, 0x80, 0x3E, 0xF8,
  0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xFB,
  0xF0, 0x0F, 0xDF, 0xC0, 0x7E, 0xFF, 0x07, 0xE7, 0xFF, 0xFF, 0x3E, 0xFF,
  0xF1, 0xF3, 0xFF, 0x0F, 0x8F, 0xF0, 0x7C, 0x08, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x7C, 0x1F, 0xF1, 0xF0, 0xFF,
  0xE7, 0xC7, 0xFF, 0xDF, 0x3F, 0xCF, 0xFC, 0xFC, 0x0F, 0xF7, 0xE0, 0x1F,
  0xDF, 0x80, 0x3F, 0x7C, 0x00, 0xFD, 0xF0, 0x03, 0xF7, 0xC0, 0x0F, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00,
  0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xDF, 0x00, 0x3F,
  0x7C, 0x00, 0xFD, 0xF8, 0x03, 0xF7, 0xE0, 0x1F, 0xCF, 0xC0, 0x7F, 0x3F,
  0x83, 0xFC, 0x7F, 0xFD, 0xF1, 0xFF, 0xF7, 0xC3, 0xFF, 0x9F, 0x03, 0xFC,
  0x7C, 0x03, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0xF0, 0x7F, 0xC7, 0xFF, 0x3F, 0xFC, 0xFF, 0xF7, 0xFB, 0xFE, 0x1F,
  0xF0, 0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x00, 0x07, 0xF8, 0x0F, 0xFF, 0xCF, 0xFF, 0xCF, 0xFF,
  0xE7, 0xE1, 0xF7, 0xE0, 0x13, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7E,
  0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0,
  0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x3F, 0xF0, 0x3F, 0x7F, 0xFF, 0xBF,
  0xFF, 0x9F, 0xFF, 0x87, 0xFF, 0x80, 0x08, 0x00, 0x07, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC7, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7E,
  0x01, 0xF8, 0x43, 0xFF, 0x0F, 0xFC, 0x1F, 0xF0, 0x3F, 0xC0, 0x18, 0xFC,
  0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0,
  0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xBE, 0x00, 0xFD, 0xF0, 0x0F, 0xEF,
  0xC0, 0x7F, 0x7F, 0x0F, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xBE, 0x3F, 0xF9,
  0xF0, 0xFF, 0x87, 0x80, 0xE0, 0x00, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xF9,
  0xF0, 0x01, 0xF3, 0xE0, 0x07, 0xE7, 0xE0, 0x0F, 0xC7, 0xC0, 0x1F, 0x0F,
  0x80, 0x3E, 0x1F, 0x00, 0xFC, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x7C,
  0x07, 0xC0, 0xF8, 0x1F, 0x80, 0xF8, 0x3E, 0x01, 0xF0, 0x7C, 0x03, 0xE0,
  0xF8, 0x03, 0xE3, 0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0x1E,
  0x00, 0x1F, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x7D, 0xF0, 0x00, 0x7B, 0xC0,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF7, 0xC0,
  0x1F, 0x80, 0x3E, 0x7C, 0x01, 0xF8, 0x03, 0xE7, 0xC0, 0x3F, 0xC0, 0x3E,
  0x7E, 0x03, 0xFC, 0x03, 0xE3, 0xE0, 0x3F, 0xC0, 0x7C, 0x3E, 0x03, 0xFC,
  0x07, 0xC3, 0xE0, 0x7F, 0xE0, 0x7C, 0x3F, 0x07, 0x9E, 0x07, 0xC1, 0xF0,
  0x79, 0xE0, 0xF8, 0x1F, 0x07, 0x9E, 0x0F, 0x81, 0xF0, 0x79, 0xE0, 0xF8,
  0x1F, 0x0F, 0x9F, 0x0F, 0x80, 0xF8, 0xF0, 0xF0, 0xF0, 0x0F, 0x8F, 0x0F,
  0x1F, 0x00, 0xF8, 0xF0, 0xF1, 0xF0, 0x0F, 0x9F, 0x0F, 0x9F, 0x00, 0xF9,
  0xF0, 0xF9, 0xF0, 0x07, 0xDE, 0x07, 0x9E, 0x00, 0x7D, 0xE0, 0x7B, 0xE0,
  0x07, 0xDE, 0x07, 0xBE, 0x00, 0x7D, 0xE0, 0x7B, 0xE0, 0x03, 0xDE, 0x07,
  0xFC, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x3F, 0xC0, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x3F, 0x80,
  0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x01, 0xFB, 0xE0, 0x0F, 0xDF, 0x80,
  0xFC, 0x7C, 0x07, 0xC3, 0xF0, 0x7E, 0x0F, 0x83, 0xE0, 0x7E, 0x3F, 0x01,
  0xF1, 0xF0, 0x0F, 0xDF, 0x80, 0x3E, 0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03,
  0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0xF8, 0xF8,
  0x07, 0xC7, 0xC0, 0x7C, 0x1F, 0x03, 0xE0, 0xFC, 0x3E, 0x03, 0xE3, 0xF0,
  0x1F, 0x9F, 0x00, 0x7D, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0x80, 0xFC, 0x00,
  0x7E, 0xF8, 0x00, 0xF9, 0xF0, 0x01, 0xF3, 0xE0, 0x07, 0xE7, 0xE0, 0x0F,
  0xC7, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x1F, 0x80, 0xFC, 0x1F, 0x01, 0xF0,
  0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x1F, 0x80, 0xF8, 0x3E, 0x01,
  0xF0, 0x7C, 0x01, 0xF0, 0xF8, 0x03, 0xE3, 0xE0, 0x07, 0xC7, 0xC0, 0x0F,
  0x8F, 0x80, 0x0F, 0x9E, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x3D,
  0xF0, 0x00, 0x7B, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x78, 0x00, 0x00, 0x7F,
  0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xF8, 0x00, 0xF8,
  0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F,
  0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x07,
  0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x1E, 0x01, 0xFC, 0x07, 0xF8, 0x1F, 0xF0, 0x3F, 0x80, 0x7C,
  0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x7E, 0x01, 0xF8, 0x1F, 0xF0, 0x3F, 0x80, 0x7E, 0x00, 0xFF, 0x00,
  0x7F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xF8, 0x0F, 0xF0,
  0x0F, 0xE0, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x00, 0xFE, 0x00, 0xFF,
  0x00, 0xFF, 0x80, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0x01, 0xFF, 0x03, 0xFC, 0x03,
  0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0xFF, 0x80, 0xFF, 0x80, 0xFF,
  0x00, 0xFC, 0x00, 0x3F, 0xC0, 0x05, 0xFF, 0xC0, 0x7F, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFA, 0x00, 0xFF, 0xC8, 0x00, 0x7E, 0x00,
};

const GFXglyph NotoSans_Condensed_Medium53pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 7, 39, 13, 3, -38 },
  { 36, 16, 14, 22, 3, -38 },
  { 64, 26, 38, 28, 1, -38 },
  { 188, 21, 43, 25, 2, -40 },
  { 301, 35, 38, 39, 2, -38 },
  { 468, 28, 39, 30, 2, -38 },
  { 605, 6, 14, 12, 3, -38 },
  { 616, 13, 46, 16, 2, -38 },
  { 691, 13, 46, 16, 1, -38 },
  { 766, 20, 20, 24, 2, -40 },
  { 816, 21, 25, 25, 2, -31 },
  { 882, 8, 13, 13, 2, -6 },
  { 895, 12, 5, 16, 2, -17 },
  { 903, 7, 8, 13, 3, -7 },
  { 910, 19, 38, 20, 1, -38 },
  { 1001, 21, 39, 25, 2, -38 },
  { 1104, 14, 38, 25, 3, -38 },
  { 1171, 21, 38, 25, 2, -38 },
  { 1271, 21, 39, 25, 2, -38 },
  { 1374, 24, 38, 25, 1, -38 },
  { 1488, 20, 39, 25, 3, -38 },
  { 1586, 21, 39, 25, 2, -38 },
  { 1689, 21, 38, 25, 2, -38 },
  { 1789, 21, 39, 25, 2, -38 },
  { 1892, 21, 39, 25, 2, -38 },
  { 1995, 7, 30, 13, 3, -29 },
  { 2022, 8, 36, 13, 2, -29 },
  { 2058, 22, 24, 25, 2, -31 },
  { 2124, 21, 15, 25, 2, -26 },
  { 2164, 22, 24, 25, 2, -31 },
  { 2230, 17, 39, 19, 1, -38 },
  { 2313, 34, 42, 39, 3, -38 },
  { 2492, 28, 38, 28, 0, -38 },
  { 2625, 22, 38, 29, 4, -38 },
  { 2730, 23, 39, 27, 3, -38 },
  { 2843, 25, 38, 31, 4, -38 },
  { 2962, 17, 38, 24, 4, -38 },
  { 3043, 17, 38, 23, 4, -38 },
  { 3124, 26, 39, 32, 3, -38 },
  { 3251, 24, 38, 32, 4, -38 },
  { 3365, 13, 38, 16, 2, -38 },
  { 3427, 12, 49, 13, -3, -38 },
  { 3501, 24, 38, 27, 4, -38 },
  { 3615, 18, 38, 23, 4, -38 },
  { 3701, 34, 38, 42, 4, -38 },
  { 3863, 26, 38, 34, 4, -38 },
  { 3987, 28, 39, 33, 3, -38 },
  { 4124, 21, 38, 27, 4, -38 },
  { 4224, 28, 47, 33, 3, -38 },
  { 4389, 23, 38, 28, 4, -38 },
  { 4499, 20, 39, 24, 2, -38 },
  { 4597, 22, 38, 24, 1, -38 },
  { 4702, 24, 39, 32, 4, -38 },
  { 4819, 27, 38, 27, 0, -38 },
  { 4948, 42, 38, 42, 0, -38 },
  { 5148, 25, 38, 25, 0, -38 },
  { 5267, 25, 38, 25, 0, -38 },
  { 5386, 21, 38, 23, 1, -38 },
  { 5486, 11, 46, 17, 4, -38 },
  { 5550, 19, 38, 20, 1, -38 },
  { 5641, 12, 46, 17, 1, -38 },
  { 5710, 24, 22, 26, 1, -38 },
  { 5776, 23, 3, 23, 0, 5 },
  { 5785, 11, 9, 15, 2, -41 },
  { 5798, 20, 30, 25, 2, -29 },
  { 5873, 21, 41, 27, 4, -40 },
  { 5981, 18, 30, 21, 2, -29 },
  { 6049, 22, 41, 27, 2, -40 },
  { 6162, 21, 30, 25, 2, -29 },
  { 6241, 16, 41, 16, 1, -41 },
  { 6323, 22, 42, 27, 2, -29 },
  { 6439, 20, 40, 27, 4, -40 },
  { 6539, 6, 39, 13, 3, -39 },
  { 6569, 11, 52, 12, -2, -39 },
  { 6641, 20, 40, 25, 4, -40 },
  { 6741, 5, 40, 12, 4, -40 },
  { 6766, 34, 29, 41, 4, -29 },
  { 6890, 20, 29, 27, 4, -29 },
  { 6963, 22, 30, 27, 2, -29 },
  { 7046, 21, 42, 27, 4, -29 },
  { 7157, 22, 42, 27, 2, -29 },
  { 7273, 14, 29, 19, 4, -29 },
  { 7324, 17, 30, 21, 2, -29 },
  { 7388, 14, 36, 16, 1, -35 },
  { 7451, 21, 30, 27, 3, -29 },
  { 7530, 23, 29, 23, 0, -29 },
  { 7614, 36, 29, 36, 0, -29 },
  { 7745, 21, 29, 23, 1, -29 },
  { 7822, 23, 42, 23, 0, -29 },
  { 7943, 17, 29, 19, 1, -29 },
  { 8005, 15, 46, 19, 2, -38 },
  { 8092, 4, 53, 24, 10, -40 },
  { 8119, 16, 46, 19, 2, -38 },
  { 8211, 22, 7, 25, 2, -22 },
};

const GFXfont NotoSans_Condensed_Medium53pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Medium53pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Medium53pt7bGlyphs,
  0x20, 0x7E, 72
};

#endif // _NOTOSANS_CONDENSED_MEDIUM53PT7B_H_
