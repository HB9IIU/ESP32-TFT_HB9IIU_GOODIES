#ifndef _NOTOSANS_CONDENSED_MEDIUM12PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUM12PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Medium.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Medium12pt7bBitmaps[] PROGMEM = {
  0x00, 0xFD, 0x80, 0xB6, 0xD0, 0x28, 0xA2, 0x9F, 0x29, 0x2F, 0x54, 0x50,
  0x4F, 0xCC, 0xE5, 0x5F, 0x44, 0x62, 0x64, 0x94, 0x98, 0x6B, 0x6D, 0x15,
  0x15, 0x23, 0x30, 0xB1, 0x23, 0x82, 0x2A, 0xB3, 0x66, 0x76, 0xF0, 0x5A,
  0xAA, 0xB4, 0x89, 0x92, 0x49, 0x6B, 0x00, 0x23, 0xE8, 0xB0, 0x21, 0x3E,
  0x42, 0x10, 0x58, 0xE0, 0xC0, 0x11, 0x12, 0x26, 0x44, 0x80, 0x32, 0xD2,
  0x9C, 0xA5, 0x29, 0x70, 0x2E, 0x92, 0x49, 0x20, 0x36, 0xC2, 0x11, 0x18,
  0x88, 0xF8, 0x36, 0xC2, 0x17, 0x0C, 0x21, 0xF0, 0x18, 0x63, 0x8E, 0x59,
  0x6F, 0xC6, 0x18, 0xFF, 0x88, 0xF1, 0x11, 0xE0, 0x3C, 0x88, 0xF9, 0x99,
  0xF0, 0xFF, 0xC2, 0x31, 0x08, 0x84, 0x60, 0x32, 0x52, 0xB3, 0x2F, 0x29,
  0x78, 0x32, 0xF3, 0x94, 0xBC, 0x23, 0x70, 0xC6, 0x50, 0x05, 0x80, 0x09,
  0xB0, 0xC1, 0x84, 0xF8, 0x3E, 0xC1, 0x82, 0x7C, 0x40, 0x69, 0x11, 0x24,
  0x04, 0x60, 0x38, 0x8A, 0x0D, 0xDA, 0xB5, 0x6A, 0xDA, 0xC0, 0xF0, 0x30,
  0xC3, 0x0A, 0x49, 0xE7, 0xF1, 0x84, 0xE5, 0xE3, 0x3E, 0x4E, 0x33, 0xF0,
  0x36, 0x61, 0x08, 0x42, 0x18, 0x78, 0xE7, 0xE3, 0x18, 0xC6, 0x33, 0xF0,
  0xFF, 0x88, 0xF8, 0x88, 0xF0, 0xFF, 0x88, 0xF8, 0x88, 0x80, 0x3B, 0x61,
  0x09, 0xC6, 0x39, 0x78, 0x8C, 0x63, 0x1F, 0xC6, 0x31, 0x88, 0xE9, 0x24,
  0x92, 0xE0, 0x24, 0x92, 0x49, 0x27, 0x80, 0x8C, 0xAD, 0x4E, 0x52, 0x52,
  0x88, 0x88, 0x88, 0x88, 0x88, 0xF0, 0xC3, 0xC7, 0xC7, 0xA7, 0xA7, 0xAB,
  0xAB, 0x9B, 0x93, 0x87, 0x1C, 0x69, 0xA6, 0x59, 0x63, 0x8C, 0x33, 0x68,
  0xE1, 0x86, 0x18, 0xF2, 0x78, 0xE5, 0xA7, 0x39, 0x72, 0x10, 0x80, 0x33,
  0x68, 0xE1, 0x86, 0x18, 0xF2, 0x78, 0x60, 0xC0, 0xE7, 0xA7, 0x3F, 0x72,
  0x52, 0x88, 0x32, 0x50, 0x87, 0x0C, 0x31, 0xF0, 0xFF, 0xC8, 0x42, 0x10,
  0x84, 0x20, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x70, 0x87, 0x14, 0xD2, 0x49,
  0xA3, 0x0C, 0x30, 0x88, 0xC6, 0x73, 0x2B, 0x95, 0x5A, 0xA9, 0x4C, 0x66,
  0x23, 0x00, 0xCD, 0x25, 0x8C, 0x30, 0xC5, 0x12, 0xCC, 0x8F, 0x24, 0x94,
  0x30, 0x82, 0x08, 0x20, 0xFF, 0xC4, 0x22, 0x11, 0x08, 0xF8, 0xEA, 0xAA,
  0xAC, 0x84, 0x44, 0x22, 0x31, 0x10, 0xE4, 0x92, 0x49, 0x27, 0x80, 0x20,
  0xC3, 0x12, 0xCC, 0xF8, 0xC4, 0x32, 0xC2, 0xF4, 0xE5, 0xE0, 0x84, 0x29,
  0xA9, 0xCE, 0x72, 0xF0, 0x7E, 0x88, 0x88, 0xE0, 0x11, 0x5F, 0x99, 0x99,
  0xF0, 0x6B, 0x9F, 0x88, 0xF0, 0x74, 0x4E, 0x44, 0x44, 0x40, 0x4F, 0x99,
  0x99, 0xF1, 0x9E, 0x88, 0xAD, 0x99, 0x99, 0x90, 0xDF, 0x80, 0x51, 0x55,
  0x57, 0x84, 0x21, 0x6A, 0x72, 0x96, 0x98, 0xFF, 0x80, 0x24, 0xDA, 0x93,
  0x93, 0x93, 0x93, 0x93, 0x2D, 0x99, 0x99, 0x90, 0x66, 0xA5, 0x39, 0x4B,
  0xC0, 0x26, 0xA7, 0x39, 0xCB, 0xD0, 0x84, 0x00, 0x4F, 0x99, 0x99, 0xF1,
  0x11, 0x3E, 0x49, 0x20, 0x25, 0xC6, 0x11, 0xF0, 0x44, 0xE4, 0x44, 0x47,
  0x99, 0x99, 0x9F, 0xCA, 0xD4, 0xA7, 0x10, 0xD9, 0x5B, 0x5A, 0x56, 0x66,
  0x26, 0xDA, 0x88, 0xE5, 0x64, 0xCA, 0xD4, 0xA3, 0x10, 0x8C, 0xC0, 0xF2,
  0x24, 0x4F, 0x12, 0x22, 0x2C, 0x62, 0x22, 0x30, 0xFF, 0xF0, 0x86, 0x22,
  0x23, 0x22, 0x26, 0xC0, 0xFC, 0xC0,
};

const GFXglyph NotoSans_Condensed_Medium12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 9, 3, 1, -9 },
  { 3, 3, 4, 5, 1, -9 },
  { 5, 6, 9, 6, 0, -9 },
  { 12, 4, 10, 6, 1, -9 },
  { 17, 8, 9, 9, 0, -9 },
  { 26, 7, 9, 7, 0, -9 },
  { 34, 1, 4, 3, 1, -9 },
  { 35, 2, 11, 4, 1, -9 },
  { 38, 3, 11, 4, 0, -9 },
  { 43, 5, 4, 5, 0, -9 },
  { 46, 5, 6, 6, 0, -7 },
  { 50, 2, 3, 3, 0, -1 },
  { 51, 3, 1, 4, 0, -4 },
  { 52, 1, 2, 3, 1, -2 },
  { 53, 4, 9, 5, 0, -9 },
  { 58, 5, 9, 6, 0, -9 },
  { 64, 3, 9, 6, 1, -9 },
  { 68, 5, 9, 6, 0, -9 },
  { 74, 5, 9, 6, 0, -9 },
  { 80, 6, 9, 6, 0, -9 },
  { 87, 4, 9, 6, 1, -9 },
  { 92, 4, 9, 6, 1, -9 },
  { 97, 5, 9, 6, 0, -9 },
  { 103, 5, 9, 6, 0, -9 },
  { 109, 5, 9, 6, 0, -9 },
  { 115, 1, 7, 3, 1, -7 },
  { 116, 2, 9, 3, 0, -7 },
  { 119, 5, 6, 6, 0, -7 },
  { 123, 5, 3, 6, 0, -6 },
  { 125, 5, 6, 6, 0, -7 },
  { 129, 4, 9, 4, 0, -9 },
  { 134, 7, 10, 9, 1, -9 },
  { 143, 6, 9, 6, 0, -9 },
  { 150, 5, 9, 6, 1, -9 },
  { 156, 5, 9, 6, 1, -9 },
  { 162, 5, 9, 7, 1, -9 },
  { 168, 4, 9, 5, 1, -9 },
  { 173, 4, 9, 5, 1, -9 },
  { 178, 5, 9, 7, 1, -9 },
  { 184, 5, 9, 7, 1, -9 },
  { 190, 3, 9, 4, 0, -9 },
  { 194, 3, 11, 3, -1, -9 },
  { 199, 5, 9, 6, 1, -9 },
  { 205, 4, 9, 5, 1, -9 },
  { 210, 8, 9, 9, 1, -9 },
  { 219, 6, 9, 8, 1, -9 },
  { 226, 6, 9, 8, 1, -9 },
  { 233, 5, 9, 6, 1, -9 },
  { 239, 6, 11, 8, 1, -9 },
  { 248, 5, 9, 6, 1, -9 },
  { 254, 5, 9, 5, 0, -9 },
  { 260, 5, 9, 5, 0, -9 },
  { 266, 5, 9, 7, 1, -9 },
  { 272, 6, 9, 6, 0, -9 },
  { 279, 9, 9, 9, 0, -9 },
  { 290, 6, 9, 6, 0, -9 },
  { 297, 6, 9, 6, 0, -9 },
  { 304, 5, 9, 5, 0, -9 },
  { 310, 2, 11, 4, 1, -9 },
  { 313, 4, 9, 5, 0, -9 },
  { 318, 3, 11, 4, 0, -9 },
  { 323, 6, 5, 6, 0, -9 },
  { 327, 5, 1, 5, 0, 1 },
  { 328, 3, 2, 3, 0, -9 },
  { 329, 5, 7, 6, 0, -7 },
  { 334, 5, 9, 6, 1, -9 },
  { 340, 4, 7, 5, 1, -7 },
  { 344, 4, 9, 6, 1, -9 },
  { 349, 4, 7, 6, 1, -7 },
  { 353, 4, 9, 4, 0, -9 },
  { 358, 4, 10, 6, 1, -7 },
  { 363, 4, 9, 6, 1, -9 },
  { 368, 1, 9, 3, 1, -9 },
  { 370, 2, 12, 3, 0, -9 },
  { 373, 5, 9, 6, 1, -9 },
  { 379, 1, 9, 3, 1, -9 },
  { 381, 8, 7, 9, 1, -7 },
  { 388, 4, 7, 6, 1, -7 },
  { 392, 5, 7, 6, 1, -7 },
  { 397, 5, 10, 6, 1, -7 },
  { 404, 4, 10, 6, 1, -7 },
  { 409, 3, 7, 4, 1, -7 },
  { 412, 4, 7, 5, 0, -7 },
  { 416, 4, 8, 4, 0, -8 },
  { 420, 4, 6, 6, 1, -6 },
  { 423, 5, 6, 5, 0, -6 },
  { 427, 8, 6, 8, 0, -6 },
  { 433, 5, 6, 5, 0, -6 },
  { 437, 5, 9, 5, 0, -6 },
  { 443, 4, 6, 4, 0, -6 },
  { 446, 4, 11, 4, 0, -9 },
  { 452, 1, 12, 5, 2, -9 },
  { 454, 4, 11, 4, 0, -9 },
  { 460, 5, 2, 6, 0, -5 },
};

const GFXfont NotoSans_Condensed_Medium12pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Medium12pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Medium12pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _NOTOSANS_CONDENSED_MEDIUM12PT7B_H_
