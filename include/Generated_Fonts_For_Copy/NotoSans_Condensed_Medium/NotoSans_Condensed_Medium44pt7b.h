#ifndef _NOTOSANS_CONDENSED_MEDIUM44PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUM44PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Medium.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Medium44pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBD, 0xCE, 0x73,
  0x9C, 0xE7, 0x38, 0x00, 0x03, 0xBF, 0xFF, 0xFF, 0xE0, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xF0, 0x01, 0xE1, 0xC0, 0x0E, 0x0E, 0x00, 0x70, 0x70, 0x03, 0x83,
  0x80, 0x1C, 0x3C, 0x01, 0xE1, 0xC0, 0x0F, 0x0E, 0x00, 0x70, 0x70, 0x7F,
  0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF0, 0x78, 0x70,
  0x03, 0xC3, 0x80, 0x1C, 0x1C, 0x00, 0xE0, 0xE0, 0x07, 0x07, 0x00, 0x38,
  0x78, 0x3F, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xF8,
  0x38, 0x38, 0x01, 0xC1, 0xC0, 0x0E, 0x1E, 0x00, 0x70, 0xF0, 0x07, 0x87,
  0x00, 0x3C, 0x38, 0x01, 0xC1, 0xC0, 0x0E, 0x0E, 0x00, 0x70, 0xF0, 0x00,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x7F, 0x01, 0xFF, 0xF9, 0xFF,
  0xF9, 0xFF, 0xFC, 0xFB, 0x8E, 0xF9, 0xC0, 0x78, 0xE0, 0x3C, 0x70, 0x1E,
  0x38, 0x0F, 0x9C, 0x03, 0xEE, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xF0,
  0x03, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x1C, 0xF8, 0x0E, 0x3C, 0x07,
  0x1E, 0x03, 0x8F, 0x01, 0xC7, 0xC0, 0xE3, 0xF8, 0x77, 0xDF, 0xFF, 0xEF,
  0xFF, 0xE3, 0xFF, 0xC0, 0x3F, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x02, 0x01, 0xFC, 0x00, 0xE0,
  0x1F, 0xF0, 0x0F, 0x00, 0xF7, 0x80, 0x70, 0x0F, 0x1E, 0x07, 0x80, 0x78,
  0xF0, 0x3C, 0x03, 0x83, 0x81, 0xC0, 0x1C, 0x1C, 0x1E, 0x00, 0xE0, 0xE0,
  0xE0, 0x07, 0x07, 0x0F, 0x00, 0x38, 0x38, 0x70, 0x01, 0xC1, 0xC3, 0x80,
  0x0E, 0x0E, 0x3C, 0x00, 0x70, 0x71, 0xC7, 0xE3, 0xC7, 0x9E, 0x7F, 0x9E,
  0x3C, 0xE3, 0xFE, 0x7B, 0xCF, 0x3C, 0xF3, 0xFE, 0x79, 0xC3, 0x8F, 0xE3,
  0x8E, 0x1E, 0x1C, 0x3C, 0xF0, 0xF0, 0x01, 0xC7, 0x87, 0x80, 0x1E, 0x3C,
  0x3C, 0x00, 0xE1, 0xE1, 0xE0, 0x07, 0x0F, 0x0F, 0x00, 0x78, 0x78, 0x78,
  0x03, 0x83, 0xC3, 0xC0, 0x3C, 0x0E, 0x1E, 0x01, 0xC0, 0x70, 0xE0, 0x1E,
  0x03, 0xCF, 0x00, 0xF0, 0x0F, 0xF8, 0x07, 0x00, 0x7F, 0x80, 0x78, 0x01,
  0xF8, 0x01, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF,
  0x00, 0x1F, 0x1F, 0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x0F,
  0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x1F, 0x1E, 0x00, 0x0F, 0x3E,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xF0, 0x3E, 0x1F, 0xF8, 0x3E, 0x3E, 0x7C, 0x3C, 0x7C, 0x7C,
  0x3C, 0x7C, 0x3E, 0x7C, 0x78, 0x1F, 0x7C, 0x78, 0x0F, 0xF8, 0xF8, 0x0F,
  0xF8, 0xF8, 0x07, 0xF0, 0x78, 0x03, 0xF0, 0x7C, 0x03, 0xF0, 0x7C, 0x0F,
  0xF8, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0x7C, 0x1F, 0xFE, 0x3E, 0x0F, 0xF8,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0xE0, 0x78, 0x3C,
  0x0F, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0x78, 0x1E,
  0x0F, 0x83, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF8, 0x3E, 0x07, 0x81, 0xE0, 0x78, 0x1F, 0x03, 0xC0, 0xF0, 0x3E,
  0x07, 0x81, 0xF0, 0x3C, 0x07, 0x81, 0xE0, 0x3C, 0xF0, 0x1E, 0x07, 0x80,
  0xF0, 0x1E, 0x07, 0x81, 0xF0, 0x3C, 0x0F, 0x01, 0xE0, 0x78, 0x1E, 0x07,
  0x81, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x7C, 0x1E, 0x07, 0x81, 0xE0, 0xF8, 0x3C,
  0x0F, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x1E, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x04, 0x1E, 0x0B, 0xEE, 0x7D, 0xFF, 0xFE,
  0xFF, 0xFF, 0x9F, 0xFE, 0x01, 0xF8, 0x01, 0xFE, 0x01, 0xEF, 0x00, 0xF3,
  0xC0, 0xF1, 0xF0, 0xF8, 0x7C, 0x18, 0x30, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x7D, 0xF7, 0xDF, 0x79, 0xEF, 0xBC, 0xF3, 0x8E,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x77, 0xFF, 0xFF, 0xFC, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1E,
  0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00,
  0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x00,
  0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x03,
  0xE0, 0x07, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0xC3, 0xE3, 0xE3, 0xE0, 0xF9,
  0xE0, 0x3C, 0xF0, 0x1E, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xE0, 0x3F,
  0xF0, 0x1F, 0xF8, 0x0F, 0x3C, 0x07, 0x9F, 0x07, 0xCF, 0x83, 0xC3, 0xF7,
  0xE1, 0xFF, 0xE0, 0x7F, 0xF0, 0x0F, 0xE0, 0x01, 0xF0, 0x3F, 0x07, 0xF0,
  0xFF, 0x3F, 0xF7, 0xFF, 0xFD, 0xFF, 0x9F, 0x61, 0xF2, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xFC, 0x1F, 0xFF,
  0x1F, 0xFF, 0xCF, 0x83, 0xF3, 0x00, 0xF8, 0x80, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0,
  0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x07, 0xE0, 0x1F, 0xFC, 0x3F, 0xFF, 0x1F, 0xFF, 0xC7, 0x03,
  0xF3, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x7F, 0xE0, 0x3F, 0xC0,
  0x1F, 0xF8, 0x0F, 0xFF, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xF0,
  0x03, 0xEF, 0x8F, 0xF7, 0xFF, 0xF3, 0xFF, 0xF0, 0xFF, 0xE0, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x3B, 0xC0, 0x0F, 0x78, 0x01, 0xCF, 0x00, 0x79, 0xE0, 0x0E, 0x7C,
  0x03, 0xCF, 0x80, 0x71, 0xF0, 0x1E, 0x3E, 0x03, 0x87, 0xC0, 0xF0, 0xF8,
  0x1C, 0x1F, 0x07, 0x83, 0xE0, 0xE0, 0x7C, 0x3C, 0x0F, 0x8F, 0x01, 0xF1,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x3F, 0xFE, 0x1F, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x10, 0x07, 0xFF, 0x83, 0xFF, 0xE1, 0xFF, 0xF8, 0x61, 0xFE,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xB0, 0x0F, 0xDF,
  0x1F, 0xCF, 0xFF, 0xC7, 0xFF, 0xC1, 0xFF, 0xC0, 0x00, 0x7E, 0x01, 0xFF,
  0x01, 0xFF, 0x81, 0xFF, 0xC1, 0xF8, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x1F, 0x87,
  0x9F, 0xE3, 0xDF, 0xF9, 0xFF, 0xFE, 0xFC, 0x1F, 0x7C, 0x07, 0xFE, 0x03,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x07, 0xBC, 0x07, 0xDF, 0x03, 0xEF, 0x83, 0xE3, 0xF7, 0xF0, 0xFF, 0xF0,
  0x3F, 0xF0, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x07, 0xFE, 0x0F, 0xFF, 0x87, 0xFF, 0xE7, 0xC1,
  0xF3, 0xC0, 0x7B, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xBC, 0x07, 0x9E,
  0x03, 0xCF, 0x83, 0xE3, 0xE3, 0xE0, 0xFF, 0xE0, 0x3F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xF8, 0x1F, 0xFE, 0x0F, 0x8F, 0x8F, 0x83, 0xEF, 0x80, 0xFF, 0x80,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFF,
  0x01, 0xF7, 0xC1, 0xF3, 0xFF, 0xF8, 0xFF, 0xF8, 0x1F, 0xF0, 0x03, 0xE0,
  0x07, 0xFC, 0x0F, 0xFF, 0x07, 0xFF, 0xC7, 0xC3, 0xE7, 0xC0, 0xFB, 0xE0,
  0x3D, 0xE0, 0x1E, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF0, 0x3F, 0x7C, 0x3F, 0xBF, 0xFB,
  0xCF, 0xFD, 0xE3, 0xFC, 0xF0, 0x70, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x0F, 0x86, 0x1F, 0xC3,
  0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0x80, 0x77, 0xFF, 0xFF, 0xB8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1D, 0xFF, 0xFF, 0xFF, 0x1C, 0x7C, 0xF9,
  0xF3, 0xE3, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xF3, 0xE7, 0xCF, 0x1E, 0x3C, 0xF9, 0xE3, 0xC7, 0x1E, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x03,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x70,
  0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x00, 0x38, 0x00, 0x0F, 0x80,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7C, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x0F, 0x00,
  0x03, 0x00, 0x00, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x7F, 0xF3, 0xFF, 0xF3,
  0xFF, 0xE7, 0x87, 0xE4, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF8, 0x03, 0xE0, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xC7, 0xF0, 0x07, 0xC0, 0x0F, 0x80,
  0xF8, 0x00, 0x78, 0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1E, 0x3C, 0x00,
  0x01, 0xE3, 0xC0, 0xFF, 0x0E, 0x38, 0x1F, 0xF8, 0xF7, 0x83, 0xFF, 0x87,
  0x70, 0x78, 0x78, 0x77, 0x0F, 0x07, 0x07, 0xF0, 0xF0, 0x70, 0x7F, 0x0E,
  0x07, 0x07, 0xF0, 0xE0, 0x70, 0x7F, 0x0E, 0x07, 0x07, 0xF0, 0xE0, 0x70,
  0x7F, 0x0E, 0x0F, 0x07, 0xF0, 0xE0, 0xF0, 0x7F, 0x0E, 0x0F, 0x0F, 0xF0,
  0xF0, 0xF0, 0xFF, 0x0F, 0x1F, 0x9E, 0x70, 0x7F, 0xBF, 0xE7, 0x03, 0xF9,
  0xFC, 0x78, 0x1E, 0x0F, 0x87, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0xC0, 0x07, 0xF8,
  0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x1E, 0xF0, 0x00, 0x3D, 0xE0, 0x00, 0x7B, 0xC0, 0x00, 0xF7, 0x80, 0x03,
  0xE7, 0x80, 0x07, 0x8F, 0x00, 0x0F, 0x1E, 0x00, 0x3E, 0x3E, 0x00, 0x7C,
  0x3C, 0x00, 0xF0, 0x78, 0x01, 0xE0, 0xF0, 0x07, 0xC1, 0xF0, 0x0F, 0x81,
  0xE0, 0x1E, 0x03, 0xC0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0x03, 0xFF, 0xFE, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0x78,
  0x78, 0x00, 0xF9, 0xF0, 0x01, 0xF3, 0xE0, 0x03, 0xE7, 0x80, 0x03, 0xDF,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0x80, 0xFF, 0xFC, 0x1F, 0xFF, 0xE3, 0xFF,
  0xFE, 0x7C, 0x3F, 0xCF, 0x80, 0xFD, 0xF0, 0x0F, 0xBE, 0x01, 0xF7, 0xC0,
  0x1E, 0xF8, 0x07, 0xDF, 0x00, 0xFB, 0xE0, 0x1F, 0x7C, 0x07, 0xCF, 0x81,
  0xF1, 0xFF, 0xFC, 0x3F, 0xFE, 0x07, 0xFF, 0xF8, 0xF8, 0x7F, 0x9F, 0x01,
  0xFB, 0xE0, 0x1F, 0x7C, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0xFB, 0xE0, 0x3F, 0x7F, 0xFF,
  0xCF, 0xFF, 0xF1, 0xFF, 0xFC, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x3F,
  0xFC, 0x1F, 0xFF, 0x87, 0xFF, 0xF1, 0xFC, 0x1C, 0x3F, 0x00, 0x8F, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x20, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFE,
  0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0x80,
  0xFC, 0x7C, 0x03, 0xF3, 0xE0, 0x0F, 0x9F, 0x00, 0x3E, 0xF8, 0x01, 0xF7,
  0xC0, 0x0F, 0xBE, 0x00, 0x3D, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x3F, 0xF0, 0x01, 0xEF, 0x80, 0x1F, 0x7C, 0x00, 0xFB, 0xE0, 0x07,
  0xDF, 0x00, 0x7C, 0xF8, 0x03, 0xE7, 0xC0, 0x3E, 0x3E, 0x07, 0xF1, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0xFF,
  0xBF, 0xFF, 0x7F, 0xFE, 0xFF, 0xFD, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3F,
  0xFF, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xFB, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x03,
  0xFF, 0xC0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xE0, 0x78, 0x7E, 0x00,
  0x43, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF,
  0xFE, 0x00, 0x1F, 0x78, 0x00, 0x7D, 0xE0, 0x01, 0xF7, 0xC0, 0x07, 0xDF,
  0x00, 0x1F, 0x3E, 0x00, 0x7C, 0xF8, 0x01, 0xF3, 0xF0, 0x07, 0xC7, 0xE0,
  0x1F, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFC,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xF0, 0xFF, 0xFF, 0xFC, 0xFF, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x8F, 0xFF, 0xFF, 0xFF,
  0xF8, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x47, 0xEF, 0xFD, 0xFF, 0x3F, 0xC1, 0xE0, 0xF8, 0x03, 0xFF, 0x80,
  0x7C, 0xF8, 0x07, 0xCF, 0x80, 0xF8, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xF8,
  0x3E, 0x0F, 0x87, 0xC0, 0xF8, 0x7C, 0x0F, 0x8F, 0x80, 0xF8, 0xF0, 0x0F,
  0x9F, 0x00, 0xFB, 0xE0, 0x0F, 0xBE, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0xFF, 0xF0, 0x0F, 0xEF, 0x80, 0xFC, 0xF8, 0x0F, 0x87, 0xC0, 0xF8, 0x7C,
  0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x80,
  0xF8, 0xF8, 0x0F, 0x8F, 0x80, 0x7C, 0xF8, 0x07, 0xEF, 0x80, 0x3E, 0xF8,
  0x01, 0xF0, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0x78, 0x00, 0xFF, 0xF7, 0x80,
  0x0F, 0xFF, 0x78, 0x00, 0xEF, 0xFB, 0x80, 0x1E, 0xFF, 0xBC, 0x01, 0xEF,
  0xFB, 0xC0, 0x1C, 0xFF, 0xBC, 0x03, 0xCF, 0xF9, 0xE0, 0x3C, 0xFF, 0x9E,
  0x03, 0xCF, 0xF9, 0xE0, 0x78, 0xFF, 0x8F, 0x07, 0x8F, 0xF8, 0xF0, 0x78,
  0xFF, 0x8F, 0x0F, 0x0F, 0xF8, 0x70, 0xF0, 0xFF, 0x87, 0x8F, 0x0F, 0xF8,
  0x78, 0xE0, 0xFF, 0x87, 0x9E, 0x0F, 0xF8, 0x3D, 0xE0, 0xFF, 0x83, 0xDC,
  0x0F, 0xF8, 0x3F, 0xC0, 0xFF, 0x81, 0xFC, 0x0F, 0xF8, 0x1F, 0x80, 0xFF,
  0x81, 0xF8, 0x0F, 0xF8, 0x0F, 0x80, 0xFF, 0x80, 0xF8, 0x0F, 0xF8, 0x0F,
  0x00, 0xF0, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0x78, 0x03, 0xFD, 0xF0, 0x0F,
  0xF3, 0xC0, 0x3F, 0xEF, 0x80, 0xFF, 0x9E, 0x03, 0xFE, 0x7C, 0x0F, 0xF8,
  0xF0, 0x3F, 0xE3, 0xE0, 0xFF, 0x87, 0x83, 0xFE, 0x1F, 0x0F, 0xF8, 0x7C,
  0x3F, 0xE0, 0xF8, 0xFF, 0x83, 0xE3, 0xFE, 0x07, 0xCF, 0xF8, 0x1F, 0x3F,
  0xE0, 0x3E, 0xFF, 0x80, 0xFB, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0x80, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF,
  0x80, 0x7F, 0xFF, 0x81, 0xFC, 0x3F, 0x87, 0xE0, 0x1F, 0x0F, 0x80, 0x1F,
  0x1E, 0x00, 0x3E, 0x7C, 0x00, 0x3C, 0xF8, 0x00, 0x7D, 0xE0, 0x00, 0xFB,
  0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x80, 0x03, 0xEF, 0x00, 0x07, 0xDF, 0x00, 0x0F, 0xBE, 0x00,
  0x1F, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xFC, 0x03, 0xE0, 0xFC, 0x0F,
  0xC1, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xC0,
  0xFF, 0xF8, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3, 0xE3, 0xFC, 0xF8, 0x1F, 0xBE,
  0x03, 0xEF, 0x80, 0x7B, 0xE0, 0x1E, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7B, 0xE0, 0x1E, 0xF8, 0x0F, 0xBE, 0x03, 0xEF, 0x83, 0xF3, 0xFF, 0xFC,
  0xFF, 0xFE, 0x3F, 0xFF, 0x0F, 0xFF, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x81, 0xFC, 0x3F,
  0x87, 0xE0, 0x1F, 0x0F, 0x80, 0x1F, 0x1E, 0x00, 0x3E, 0x7C, 0x00, 0x3C,
  0xF8, 0x00, 0x7D, 0xE0, 0x00, 0xFB, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xF7, 0x80, 0x03, 0xEF, 0x00,
  0x07, 0xDF, 0x00, 0x0F, 0xBE, 0x00, 0x1F, 0x7C, 0x00, 0x7C, 0x7C, 0x00,
  0xF8, 0xFC, 0x03, 0xE0, 0xFC, 0x0F, 0xC1, 0xFF, 0xFF, 0x01, 0xFF, 0xFC,
  0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x3F, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF0, 0xF8, 0x1F, 0x8F, 0x80, 0xF8, 0xF8, 0x07, 0x8F, 0x80, 0x7C, 0xF8,
  0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x07, 0xCF, 0x80, 0x78, 0xF8, 0x0F, 0x8F,
  0x81, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xFF, 0x80,
  0xF8, 0x78, 0x0F, 0x87, 0xC0, 0xF8, 0x3C, 0x0F, 0x83, 0xE0, 0xF8, 0x1E,
  0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x80, 0xF8, 0xF8, 0x0F, 0x8F, 0x80,
  0x7C, 0xF8, 0x07, 0xCF, 0x80, 0x3E, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x0F,
  0xFE, 0x3F, 0xFF, 0x3F, 0xFF, 0x7E, 0x1E, 0xFC, 0x02, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x7F,
  0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xFE, 0x00,
  0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x80, 0x1F, 0xC0, 0x3F, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0x7F,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0x78,
  0x01, 0xF7, 0xC0, 0x3E, 0x7E, 0x03, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0,
  0xFF, 0xF8, 0x07, 0xFE, 0x00, 0xF8, 0x00, 0x7D, 0xE0, 0x01, 0xF7, 0x80,
  0x07, 0xDF, 0x00, 0x1E, 0x7C, 0x00, 0xF8, 0xF0, 0x03, 0xE3, 0xC0, 0x0F,
  0x0F, 0x80, 0x3C, 0x3E, 0x01, 0xF0, 0x78, 0x07, 0xC1, 0xE0, 0x1E, 0x07,
  0xC0, 0x78, 0x0F, 0x03, 0xE0, 0x3C, 0x0F, 0x00, 0xF0, 0x3C, 0x03, 0xE0,
  0xF0, 0x07, 0x87, 0xC0, 0x1E, 0x1E, 0x00, 0x78, 0x78, 0x01, 0xF1, 0xE0,
  0x03, 0xCF, 0x80, 0x0F, 0x3C, 0x00, 0x3C, 0xF0, 0x00, 0x7B, 0xC0, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xEF,
  0x00, 0x3E, 0x00, 0x79, 0xE0, 0x07, 0xC0, 0x0F, 0x3C, 0x01, 0xF8, 0x03,
  0xE7, 0xC0, 0x3F, 0x80, 0x7C, 0xF8, 0x07, 0xF0, 0x0F, 0x0F, 0x00, 0xFE,
  0x01, 0xE1, 0xE0, 0x3D, 0xC0, 0x7C, 0x3C, 0x07, 0xB8, 0x0F, 0x87, 0xC0,
  0xF7, 0x81, 0xF0, 0x78, 0x1E, 0xF0, 0x3C, 0x0F, 0x03, 0x9E, 0x07, 0x81,
  0xE0, 0xF1, 0xC1, 0xF0, 0x3E, 0x1E, 0x3C, 0x3E, 0x07, 0xC3, 0xC7, 0x87,
  0x80, 0x78, 0x78, 0xF0, 0xF0, 0x0F, 0x1E, 0x1E, 0x1E, 0x01, 0xE3, 0xC1,
  0xE7, 0xC0, 0x3E, 0x78, 0x3C, 0xF8, 0x07, 0xCF, 0x07, 0x9E, 0x00, 0x79,
  0xC0, 0xF3, 0xC0, 0x0F, 0x78, 0x0E, 0x78, 0x01, 0xEF, 0x01, 0xDF, 0x00,
  0x3D, 0xE0, 0x3F, 0xC0, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0xFF,
  0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x3F, 0x00, 0x03, 0xE0, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x01, 0xF1, 0xF0, 0x0F, 0x0F, 0x80, 0xF8, 0x3C, 0x07, 0xC1, 0xF0, 0x7C,
  0x07, 0x83, 0xE0, 0x3E, 0x1E, 0x00, 0xF1, 0xF0, 0x07, 0xCF, 0x00, 0x1E,
  0xF8, 0x00, 0xF7, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF,
  0x80, 0x07, 0xBC, 0x00, 0x7D, 0xF0, 0x03, 0xC7, 0x80, 0x3E, 0x3E, 0x01,
  0xE0, 0xF0, 0x1F, 0x07, 0xC0, 0xF0, 0x1E, 0x0F, 0x80, 0xF8, 0x7C, 0x07,
  0xC7, 0xC0, 0x1F, 0x3E, 0x00, 0xFB, 0xE0, 0x03, 0xE0, 0xF8, 0x01, 0xFB,
  0xC0, 0x0F, 0x9F, 0x00, 0x78, 0x78, 0x07, 0xC3, 0xE0, 0x3C, 0x1F, 0x01,
  0xE0, 0x78, 0x1F, 0x03, 0xE0, 0xF0, 0x0F, 0x0F, 0x80, 0x7C, 0x78, 0x01,
  0xE3, 0xC0, 0x0F, 0x3E, 0x00, 0x7D, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01,
  0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00,
  0x3E, 0x00, 0x1E, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFC, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x07,
  0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x07, 0x9C, 0x00, 0x79, 0xE0, 0x0F,
  0x0E, 0x00, 0xF0, 0xF0, 0x1E, 0x07, 0x01, 0xE0, 0x78, 0x3C, 0x03, 0x83,
  0xC0, 0x3C, 0x38, 0x03, 0xC7, 0x80, 0x1E, 0x78, 0x01, 0xEF, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0x7C, 0x1F, 0x07,
  0xC1, 0xE0, 0x78, 0x1E, 0x0F, 0xF0, 0x3F, 0xFC, 0x3F, 0xFE, 0x3E, 0x7E,
  0x10, 0x1E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x0F, 0xFF, 0x3F, 0xFF, 0x7F, 0xEF, 0xFC, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x3F, 0xF8, 0x7F, 0x7F, 0xEF,
  0x7F, 0xCF, 0x3F, 0x87, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x7E, 0x0F, 0x3F, 0xE3, 0xDF, 0xF8, 0xFF, 0xFF, 0x3F, 0x07, 0xEF,
  0x80, 0xFB, 0xE0, 0x1E, 0xF8, 0x07, 0xBE, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x7B, 0xE0, 0x3E, 0xFC, 0x0F, 0xBF, 0xCF, 0xCF,
  0x7F, 0xF3, 0xDF, 0xF8, 0xF1, 0xFC, 0x00, 0x03, 0xF8, 0x1F, 0xFC, 0x7F,
  0xF1, 0xFF, 0xE7, 0xE0, 0x4F, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x13, 0xF1, 0xC7, 0xFF,
  0x87, 0xFF, 0x03, 0xFC, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC1, 0xF9, 0xF1, 0xFF, 0x3C, 0xFF, 0xEF, 0x3F, 0xFF, 0xDF, 0x07, 0xF7,
  0xC0, 0xFD, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xC0,
  0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x7D, 0xE0, 0x1F, 0x7C, 0x0F, 0xDF, 0x8F, 0xF3,
  0xFF, 0xBC, 0x7F, 0xCF, 0x0F, 0xE3, 0xC0, 0x07, 0xF0, 0x07, 0xFE, 0x07,
  0xFF, 0x87, 0xE7, 0xC7, 0xC1, 0xF3, 0xC0, 0x79, 0xE0, 0x3F, 0xF0, 0x0F,
  0xF8, 0x07, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x23, 0xF0, 0x70, 0xFF, 0xF8, 0x3F, 0xFC, 0x0F, 0xFC, 0x00, 0x70,
  0x0F, 0xF0, 0x7F, 0xC3, 0xFF, 0x0F, 0x84, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x01, 0xFF, 0x1F, 0xFC, 0xFF, 0xF3, 0xFF, 0xC0, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x07, 0xE3,
  0xC7, 0xFC, 0xF3, 0xFF, 0xBC, 0xFF, 0xFF, 0x7C, 0x1F, 0xDF, 0x03, 0xF7,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x07,
  0xFE, 0x01, 0xF7, 0x80, 0x7D, 0xF0, 0x3F, 0x7F, 0x3F, 0xCF, 0xFE, 0xF1,
  0xFF, 0x7C, 0x3F, 0x9F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1E, 0x00, 0x07, 0x90, 0x03, 0xE7, 0x83, 0xF1, 0xFF, 0xFC, 0x7F, 0xFE,
  0x0F, 0xFE, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0xFC, 0x3C, 0xFF, 0x9E, 0xFF, 0xEF, 0xFF, 0xF7, 0xE0, 0xFB, 0xF0,
  0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07,
  0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0,
  0x1F, 0xF0, 0x0F, 0x80, 0x67, 0xBF, 0xFF, 0x30, 0x00, 0x07, 0xBD, 0xEF,
  0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE,
  0xF0, 0x06, 0x07, 0x83, 0xE1, 0xF0, 0xF0, 0x30, 0x00, 0x00, 0x00, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3D, 0x3E, 0xFF, 0x7F,
  0x3F, 0x04, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x07,
  0xFC, 0x07, 0xDE, 0x07, 0xCF, 0x03, 0xC7, 0x83, 0xE3, 0xC3, 0xE1, 0xE1,
  0xE0, 0xF1, 0xF0, 0x79, 0xF0, 0x3C, 0xF0, 0x1E, 0xF8, 0x0F, 0xFE, 0x07,
  0xFF, 0x03, 0xF7, 0xC1, 0xF1, 0xE0, 0xF8, 0xF8, 0x78, 0x3C, 0x3C, 0x1F,
  0x1E, 0x07, 0x8F, 0x03, 0xE7, 0x80, 0xF3, 0xC0, 0x7D, 0xE0, 0x1F, 0xF0,
  0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF1, 0xF8, 0x1F, 0x8F, 0x3F,
  0xC7, 0xFC, 0xF7, 0xFE, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFC, 0x1F, 0xC1,
  0xFF, 0x81, 0xF8, 0x1F, 0xF8, 0x0F, 0x80, 0xFF, 0x80, 0xF8, 0x0F, 0xF8,
  0x0F, 0x00, 0xFF, 0x00, 0xF0, 0x0F, 0xF0, 0x0F, 0x00, 0xFF, 0x00, 0xF0,
  0x0F, 0xF0, 0x0F, 0x00, 0xFF, 0x00, 0xF0, 0x0F, 0xF0, 0x0F, 0x00, 0xFF,
  0x00, 0xF0, 0x0F, 0xF0, 0x0F, 0x00, 0xFF, 0x00, 0xF0, 0x0F, 0xF0, 0x0F,
  0x00, 0xFF, 0x00, 0xF0, 0x0F, 0xF0, 0x0F, 0x00, 0xFF, 0x00, 0xF0, 0x0F,
  0xF0, 0x0F, 0x00, 0xFF, 0x00, 0xF0, 0x0F, 0xF1, 0xF8, 0x79, 0xFF, 0x3D,
  0xFF, 0xDF, 0xFF, 0xEF, 0xC1, 0xF7, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0x07, 0xF8,
  0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x7C, 0x0F, 0x9F, 0x01, 0xE7,
  0x80, 0x7B, 0xE0, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x07,
  0xDE, 0x01, 0xF7, 0xC0, 0x79, 0xF0, 0x3E, 0x3F, 0x1F, 0x07, 0xFF, 0xC0,
  0xFF, 0xE0, 0x1F, 0xE0, 0xF1, 0xF8, 0x3C, 0xFF, 0x8F, 0x7F, 0xF3, 0xFF,
  0xFC, 0xFC, 0x1F, 0xBE, 0x03, 0xEF, 0x80, 0x7B, 0xE0, 0x1E, 0xF8, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF,
  0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xEF, 0x80, 0xFB, 0xF0,
  0x3E, 0xFF, 0x3F, 0x3D, 0xFF, 0xCF, 0x3F, 0xE3, 0xC7, 0xF0, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0xE3, 0xC7, 0xFC, 0xF3, 0xFF, 0xBC, 0xFF, 0xFF, 0x7C, 0x1F, 0xDF, 0x03,
  0xF7, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x7F,
  0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFE, 0x01, 0xF7, 0x80, 0xFD, 0xF0, 0x3F, 0x7F, 0x3F, 0xCF, 0xFE,
  0xF1, 0xFF, 0x7C, 0x3F, 0x9F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0xE1, 0xFF, 0x3F, 0xF7, 0xFF, 0x7E,
  0xFF, 0x1F, 0xC0, 0xFC, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x1F, 0xE0, 0xFF, 0xE7, 0xFF, 0xBF,
  0x3E, 0xF0, 0x13, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0xF8, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xE0, 0x1E, 0xF1, 0xFB, 0xFF, 0xEF, 0xFF, 0x1F, 0xF0,
  0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF3, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x01, 0xF1, 0x1F, 0xF1, 0xFF, 0x0F, 0xF0, 0xF0, 0x0F, 0xF8, 0x07,
  0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0,
  0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFE, 0x07,
  0xFF, 0x03, 0xF7, 0xE7, 0xFB, 0xFF, 0xBC, 0xFF, 0x9E, 0x3F, 0x8F, 0xF8,
  0x03, 0xEF, 0x00, 0x7D, 0xE0, 0x0F, 0x3C, 0x01, 0xE7, 0xC0, 0x7C, 0x78,
  0x0F, 0x0F, 0x01, 0xE1, 0xF0, 0x7C, 0x1E, 0x0F, 0x03, 0xC1, 0xE0, 0x78,
  0x3C, 0x0F, 0x8F, 0x80, 0xF1, 0xE0, 0x1E, 0x3C, 0x03, 0xC7, 0x80, 0x3D,
  0xE0, 0x07, 0xBC, 0x00, 0xF7, 0x80, 0x1E, 0xF0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0xF8, 0x07, 0x80, 0x7D,
  0xE0, 0x3F, 0x01, 0xE7, 0x80, 0xFC, 0x07, 0x9E, 0x03, 0xF0, 0x1E, 0x7C,
  0x0F, 0xC0, 0xF8, 0xF0, 0x7F, 0x83, 0xC3, 0xC1, 0xFE, 0x0F, 0x0F, 0x07,
  0x38, 0x3C, 0x3E, 0x1C, 0xE1, 0xF0, 0x78, 0xF3, 0x87, 0x81, 0xE3, 0xCF,
  0x1E, 0x07, 0x8F, 0x3C, 0x78, 0x1E, 0x38, 0x71, 0xE0, 0x7C, 0xE1, 0xCF,
  0x00, 0xF7, 0x87, 0xBC, 0x03, 0xDE, 0x1E, 0xF0, 0x0F, 0x78, 0x7B, 0xC0,
  0x3D, 0xC0, 0xEE, 0x00, 0x77, 0x03, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x07,
  0xF0, 0x3F, 0x80, 0x1F, 0x80, 0xFE, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0xF8,
  0x07, 0xC0, 0xF8, 0x0F, 0x9E, 0x03, 0xE7, 0xC0, 0xF0, 0xF0, 0x7C, 0x3E,
  0x1E, 0x07, 0x8F, 0x81, 0xF3, 0xC0, 0x3D, 0xF0, 0x0F, 0xF8, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x80,
  0x3D, 0xE0, 0x1F, 0x7C, 0x07, 0x8F, 0x03, 0xE3, 0xE0, 0xF0, 0x78, 0x7C,
  0x1F, 0x1E, 0x03, 0xCF, 0x80, 0xFB, 0xC0, 0x1F, 0xF8, 0x03, 0xEF, 0x00,
  0x7D, 0xE0, 0x0F, 0x3E, 0x01, 0xE7, 0xC0, 0x7C, 0x78, 0x0F, 0x0F, 0x01,
  0xE1, 0xF0, 0x7C, 0x1E, 0x0F, 0x83, 0xC1, 0xE0, 0x7C, 0x3C, 0x07, 0x8F,
  0x80, 0xF1, 0xE0, 0x1E, 0x3C, 0x01, 0xE7, 0x80, 0x3D, 0xE0, 0x07, 0xBC,
  0x00, 0x77, 0x80, 0x0E, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x23, 0xF0, 0x03, 0xFC, 0x00,
  0x7F, 0x00, 0x0F, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x7F, 0xFD, 0xFF, 0xF7,
  0xFF, 0xDF, 0xFF, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xE0,
  0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0xC0,
  0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x08, 0x07, 0xC0, 0x7E, 0x07, 0xF0, 0x7E, 0x03, 0xE0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0xF8, 0x3F, 0xC1, 0xF8, 0x0F, 0xE0,
  0x7F, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xF0, 0x07,
  0xF0, 0x3F, 0x80, 0xFC, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xC0, 0x3F, 0x01, 0xFC, 0x03, 0xF0,
  0x0F, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xFE, 0x03,
  0xF0, 0x3F, 0x83, 0xFC, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07,
  0xC1, 0xFC, 0x0F, 0xE0, 0x7E, 0x03, 0xC0, 0x00, 0x04, 0x00, 0x27, 0xF8,
  0x05, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x1F, 0xFD, 0x80, 0x7F, 0x20, 0x01,
  0x00,
};

const GFXglyph NotoSans_Condensed_Medium44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 5, 31, 11, 3, -31 },
  { 21, 12, 11, 18, 3, -31 },
  { 38, 21, 31, 23, 1, -31 },
  { 120, 17, 36, 21, 2, -33 },
  { 197, 29, 32, 33, 2, -32 },
  { 313, 24, 32, 25, 1, -32 },
  { 409, 4, 11, 10, 3, -31 },
  { 415, 10, 39, 13, 2, -32 },
  { 464, 10, 39, 13, 1, -32 },
  { 513, 17, 16, 20, 1, -33 },
  { 547, 17, 21, 21, 2, -26 },
  { 592, 6, 11, 11, 2, -5 },
  { 601, 11, 4, 13, 1, -14 },
  { 607, 5, 6, 11, 3, -6 },
  { 611, 15, 32, 17, 1, -32 },
  { 671, 17, 32, 21, 2, -32 },
  { 739, 12, 31, 21, 3, -31 },
  { 786, 17, 32, 21, 2, -32 },
  { 854, 17, 32, 21, 2, -32 },
  { 922, 19, 32, 21, 1, -32 },
  { 998, 17, 31, 21, 2, -31 },
  { 1064, 17, 32, 21, 2, -32 },
  { 1132, 18, 31, 21, 1, -31 },
  { 1202, 17, 32, 21, 2, -32 },
  { 1270, 17, 32, 21, 2, -32 },
  { 1338, 5, 24, 11, 3, -24 },
  { 1353, 7, 30, 11, 1, -24 },
  { 1380, 19, 21, 21, 1, -26 },
  { 1430, 17, 13, 21, 2, -22 },
  { 1458, 18, 21, 21, 2, -26 },
  { 1506, 15, 32, 16, 0, -32 },
  { 1566, 28, 36, 33, 2, -32 },
  { 1692, 23, 31, 23, 0, -31 },
  { 1782, 19, 31, 24, 3, -31 },
  { 1856, 19, 32, 22, 2, -32 },
  { 1932, 21, 31, 26, 3, -31 },
  { 2014, 15, 31, 20, 3, -31 },
  { 2073, 15, 31, 19, 3, -31 },
  { 2132, 22, 32, 27, 2, -32 },
  { 2220, 20, 31, 27, 3, -31 },
  { 2298, 11, 31, 14, 1, -31 },
  { 2341, 11, 40, 11, -3, -31 },
  { 2396, 20, 31, 23, 3, -31 },
  { 2474, 15, 31, 19, 3, -31 },
  { 2533, 28, 31, 35, 3, -31 },
  { 2642, 22, 31, 28, 3, -31 },
  { 2728, 23, 32, 28, 2, -32 },
  { 2820, 18, 31, 22, 3, -31 },
  { 2890, 23, 39, 28, 2, -32 },
  { 3003, 20, 31, 23, 3, -31 },
  { 3081, 16, 32, 20, 2, -32 },
  { 3145, 18, 31, 20, 1, -31 },
  { 3215, 20, 31, 26, 3, -31 },
  { 3293, 22, 31, 22, 0, -31 },
  { 3379, 35, 31, 35, 0, -31 },
  { 3515, 21, 31, 21, 0, -31 },
  { 3597, 21, 31, 21, 0, -31 },
  { 3679, 17, 31, 19, 1, -31 },
  { 3745, 10, 39, 14, 3, -32 },
  { 3794, 15, 32, 17, 1, -32 },
  { 3854, 10, 39, 14, 1, -32 },
  { 3903, 20, 18, 22, 1, -31 },
  { 3948, 19, 3, 19, 0, 4 },
  { 3956, 9, 7, 13, 2, -34 },
  { 3964, 16, 24, 21, 2, -24 },
  { 4012, 18, 33, 23, 3, -33 },
  { 4087, 15, 24, 18, 2, -24 },
  { 4132, 18, 33, 23, 2, -33 },
  { 4207, 17, 24, 21, 2, -24 },
  { 4258, 14, 34, 13, 0, -34 },
  { 4318, 18, 35, 23, 2, -24 },
  { 4397, 17, 33, 23, 3, -33 },
  { 4468, 5, 33, 10, 3, -33 },
  { 4489, 9, 44, 10, -1, -33 },
  { 4539, 17, 33, 20, 3, -33 },
  { 4610, 4, 33, 10, 3, -33 },
  { 4627, 28, 24, 34, 3, -24 },
  { 4711, 17, 24, 23, 3, -24 },
  { 4762, 18, 24, 22, 2, -24 },
  { 4816, 18, 35, 23, 3, -24 },
  { 4895, 18, 35, 23, 2, -24 },
  { 4974, 12, 24, 15, 3, -24 },
  { 5010, 14, 24, 17, 2, -24 },
  { 5052, 12, 29, 14, 1, -29 },
  { 5096, 17, 24, 23, 3, -24 },
  { 5147, 19, 24, 19, 0, -24 },
  { 5204, 30, 24, 30, 0, -24 },
  { 5294, 18, 24, 19, 1, -24 },
  { 5348, 19, 35, 19, 0, -24 },
  { 5432, 14, 24, 16, 1, -24 },
  { 5474, 13, 39, 16, 1, -32 },
  { 5538, 4, 44, 20, 8, -34 },
  { 5560, 13, 39, 16, 2, -32 },
  { 5624, 19, 7, 21, 1, -19 },
};

const GFXfont NotoSans_Condensed_Medium44pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Medium44pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Medium44pt7bGlyphs,
  0x20, 0x7E, 60
};

#endif // _NOTOSANS_CONDENSED_MEDIUM44PT7B_H_
