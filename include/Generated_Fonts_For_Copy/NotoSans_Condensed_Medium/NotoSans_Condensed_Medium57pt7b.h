#ifndef _NOTOSANS_CONDENSED_MEDIUM57PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUM57PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Medium.ttf
// Size: 57pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Medium57pt7bBitmaps[] PROGMEM = {
  0x00, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF,
  0xDF, 0xBF, 0x7E, 0xFC, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x78, 0xF1,
  0xE3, 0xC7, 0x80, 0x00, 0x00, 0x00, 0x01, 0xF7, 0xEF, 0xFF, 0xFF, 0xFE,
  0xFC, 0x60, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xF7, 0xC1,
  0xFB, 0xE0, 0xFD, 0xF0, 0x7E, 0xF8, 0x3E, 0x7C, 0x1F, 0x3E, 0x0F, 0x9F,
  0x03, 0xCF, 0x81, 0xE7, 0xC0, 0xF3, 0xE0, 0x79, 0xE0, 0x3C, 0x00, 0x3C,
  0x0F, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x7C, 0x0F, 0x00, 0x07, 0xC1, 0xF0,
  0x00, 0x78, 0x1E, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0xF8, 0x3E,
  0x00, 0x0F, 0x03, 0xC0, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x07,
  0xC0, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00,
  0x1E, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xC0,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3C, 0x0F, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x78,
  0x1F, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0x78, 0x1E, 0x00, 0x07, 0x83, 0xE0, 0x00, 0xF8, 0x3E, 0x00, 0x0F,
  0x83, 0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x7E, 0x00,
  0x1F, 0xFF, 0x81, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF1, 0xFD,
  0xC7, 0xCF, 0xC7, 0x03, 0x3E, 0x1C, 0x00, 0xF8, 0x70, 0x03, 0xE1, 0xC0,
  0x0F, 0x87, 0x00, 0x3E, 0x1C, 0x00, 0xFC, 0x70, 0x03, 0xF9, 0xC0, 0x07,
  0xF7, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x7F,
  0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0x3F,
  0x80, 0x1C, 0x7E, 0x00, 0x70, 0xFC, 0x01, 0xC1, 0xF0, 0x07, 0x07, 0xC0,
  0x1C, 0x1F, 0x00, 0x70, 0xFE, 0x01, 0xC3, 0xEE, 0x07, 0x3F, 0xBF, 0xDF,
  0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x03, 0xFF, 0x80,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x7F, 0xC0,
  0x01, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0x80, 0x0F, 0xFF, 0x00, 0x3E, 0x00,
  0x7C, 0x7C, 0x00, 0xF0, 0x01, 0xF0, 0xF0, 0x07, 0xC0, 0x07, 0x83, 0xE0,
  0x1E, 0x00, 0x1E, 0x0F, 0x80, 0xF8, 0x00, 0xF8, 0x1E, 0x03, 0xE0, 0x03,
  0xE0, 0x78, 0x1F, 0x00, 0x0F, 0x81, 0xE0, 0x7C, 0x00, 0x3E, 0x07, 0x81,
  0xE0, 0x00, 0xF8, 0x1E, 0x0F, 0x80, 0x03, 0xE0, 0x78, 0x3C, 0x00, 0x0F,
  0x81, 0xE1, 0xF0, 0x00, 0x3E, 0x07, 0x87, 0xC0, 0x00, 0xF8, 0x1E, 0x1E,
  0x0F, 0x81, 0xE0, 0xF8, 0xF8, 0xFF, 0x87, 0x83, 0xE3, 0xC7, 0xFF, 0x1F,
  0x0F, 0x1F, 0x1F, 0xFC, 0x7C, 0x7C, 0x78, 0xF8, 0xF8, 0xFF, 0xF3, 0xE3,
  0xC3, 0xE1, 0xFF, 0x8F, 0x8F, 0x07, 0x87, 0xFC, 0x3C, 0x7C, 0x1F, 0x07,
  0xE1, 0xF1, 0xF0, 0x7C, 0x00, 0x07, 0x87, 0xC1, 0xF0, 0x00, 0x3E, 0x1F,
  0x07, 0xC0, 0x00, 0xF8, 0x7C, 0x1F, 0x00, 0x03, 0xC1, 0xF0, 0x3C, 0x00,
  0x1F, 0x07, 0xC1, 0xF0, 0x00, 0x78, 0x1F, 0x07, 0xC0, 0x03, 0xE0, 0x7C,
  0x1F, 0x00, 0x0F, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x07, 0xC1, 0xF0, 0x01,
  0xF0, 0x0F, 0x07, 0xC0, 0x07, 0x80, 0x3C, 0x1E, 0x00, 0x3E, 0x00, 0xF8,
  0xF8, 0x00, 0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xC0, 0x07, 0xFF, 0x00, 0x1F,
  0x00, 0x0F, 0xF8, 0x00, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x03, 0xF0, 0x7E, 0x00,
  0x07, 0xE0, 0x7C, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x1F, 0x01, 0xF0, 0x00,
  0x3F, 0x03, 0xE0, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0xFC, 0x1F, 0x80, 0x00,
  0xF8, 0x3F, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x03,
  0xF7, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xE0, 0x3F, 0x07, 0xFF, 0xC0, 0x7E, 0x1F, 0xCF, 0xC0, 0xF8, 0x7F, 0x1F,
  0xC3, 0xF0, 0xFC, 0x1F, 0xC7, 0xE3, 0xF0, 0x1F, 0x8F, 0xC7, 0xE0, 0x1F,
  0xBF, 0x0F, 0xC0, 0x3F, 0xFE, 0x1F, 0x80, 0x3F, 0xF8, 0x3F, 0x00, 0x3F,
  0xF0, 0x7E, 0x00, 0x3F, 0xC0, 0xFC, 0x00, 0x7F, 0x81, 0xF8, 0x00, 0xFF,
  0x03, 0xF8, 0x03, 0xFE, 0x03, 0xF8, 0x0F, 0xFE, 0x07, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFE, 0xFE, 0x07, 0xFF, 0xF8, 0xFE, 0x07, 0xFF, 0xE0, 0xFC,
  0x07, 0xFF, 0x01, 0xFE, 0x00, 0x60, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x7D,
  0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0x80, 0x00, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x1F, 0x01, 0xF8,
  0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xFC, 0x07, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xF8, 0x07,
  0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x1F,
  0x80, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7E, 0x01, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F,
  0x80, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x07, 0x07, 0x83, 0x9F, 0x9E, 0x7E, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x3D, 0xF0, 0x01, 0xF3, 0xE0, 0x0F, 0x8F, 0xC0, 0x7E, 0x1F, 0x03,
  0xF8, 0x7E, 0x03, 0xC0, 0xF0, 0x07, 0x03, 0x00, 0x04, 0x08, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x1F, 0xCF, 0xC7, 0xE3, 0xF1, 0xF8,
  0xF8, 0x7C, 0x7E, 0x3E, 0x1F, 0x0F, 0x8F, 0x87, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7E, 0x7E, 0xFF, 0xFF, 0xFF, 0x7E,
  0x7E, 0x18, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0x03,
  0xF0, 0x7E, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x3E, 0x00, 0xF8, 0xFC,
  0x01, 0xF9, 0xF8, 0x03, 0xF3, 0xF0, 0x03, 0xE7, 0xE0, 0x07, 0xCF, 0x80,
  0x0F, 0x9F, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFD,
  0xF0, 0x01, 0xFB, 0xE0, 0x03, 0xF7, 0xC0, 0x07, 0xCF, 0xC0, 0x0F, 0x9F,
  0x80, 0x3F, 0x3F, 0x00, 0x7E, 0x3E, 0x00, 0xFC, 0x7E, 0x03, 0xF0, 0xFC,
  0x07, 0xE0, 0xFC, 0x1F, 0xC1, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x03, 0xFF,
  0xF8, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0x20, 0x00, 0x00, 0x3E,
  0x00, 0xFC, 0x03, 0xF8, 0x1F, 0xF0, 0x7F, 0xE1, 0xFF, 0xC7, 0xFF, 0x9F,
  0xFF, 0x7F, 0x7F, 0xFC, 0xFF, 0xF1, 0xFB, 0xC3, 0xF3, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x03, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x0F, 0xC0, 0xFF, 0x0E, 0x00, 0x7E, 0x08,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0x0F, 0x80, 0x7F, 0x0C, 0x00, 0x7E, 0x10, 0x00, 0xFE,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xFA, 0x00, 0x07, 0xF7, 0x00, 0x1F, 0xCF, 0xE1, 0xFF, 0x9F,
  0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1E, 0xFC, 0x00, 0x1F, 0x7E,
  0x00, 0x0F, 0x3F, 0x00, 0x0F, 0x9F, 0x80, 0x07, 0x8F, 0xC0, 0x07, 0xC7,
  0xE0, 0x03, 0xC3, 0xF0, 0x03, 0xE1, 0xF8, 0x01, 0xE0, 0xFC, 0x01, 0xF0,
  0x7E, 0x01, 0xF0, 0x3F, 0x00, 0xF8, 0x1F, 0x80, 0xF8, 0x0F, 0xC0, 0x7C,
  0x07, 0xE0, 0x7C, 0x03, 0xF0, 0x3E, 0x01, 0xF8, 0x3E, 0x00, 0xFC, 0x1F,
  0x00, 0x7E, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x3F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xE1, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xFE,
  0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE8, 0x00, 0x3F, 0x38,
  0x03, 0xFC, 0xFE, 0x7F, 0xE3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xC0, 0x3F, 0xFC, 0x00, 0x02, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x81, 0xFE, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x0F, 0x80, 0x7C, 0x7F, 0xC0, 0xF9, 0xFF, 0xE1, 0xF7,
  0xFF, 0xC3, 0xFF, 0xFF, 0xCF, 0xFC, 0x3F, 0xDF, 0xE0, 0x1F, 0xBF, 0x80,
  0x3F, 0x7F, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFD, 0xF0, 0x01,
  0xFB, 0xE0, 0x03, 0xF7, 0xC0, 0x07, 0xEF, 0x80, 0x0F, 0xDF, 0x80, 0x1F,
  0xBF, 0x00, 0x3F, 0x3E, 0x00, 0x7E, 0x7E, 0x01, 0xF8, 0xFC, 0x03, 0xF0,
  0xFC, 0x0F, 0xE1, 0xFE, 0x7F, 0x81, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x01,
  0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x18, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x80,
  0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFE, 0xFF, 0x87, 0xE0, 0x3F, 0x1F,
  0x80, 0x3F, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0x7C, 0xFC, 0x00, 0xF9, 0xF8,
  0x01, 0xF3, 0xF0, 0x07, 0xE3, 0xE0, 0x0F, 0xC7, 0xE0, 0x1F, 0x0F, 0xC0,
  0x7E, 0x0F, 0xE1, 0xF8, 0x0F, 0xEF, 0xF0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xF8,
  0x0F, 0xC3, 0xF8, 0x3F, 0x03, 0xF8, 0xFC, 0x03, 0xF9, 0xF8, 0x03, 0xF7,
  0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE,
  0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFD, 0xF8, 0x01, 0xFB, 0xF0,
  0x07, 0xE7, 0xF8, 0x3F, 0xC7, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x07, 0xFF,
  0xF0, 0x03, 0xFF, 0x80, 0x00, 0x20, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFF,
  0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xF0, 0x7E,
  0x1F, 0xC0, 0x7E, 0x3F, 0x00, 0xFC, 0x7C, 0x00, 0xFD, 0xF8, 0x01, 0xFB,
  0xF0, 0x03, 0xF7, 0xE0, 0x03, 0xEF, 0xC0, 0x07, 0xDF, 0x80, 0x0F, 0xFF,
  0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xFD, 0xF8,
  0x03, 0xFB, 0xF0, 0x0F, 0xF7, 0xF0, 0x3F, 0xE7, 0xFF, 0xFF, 0xCF, 0xFF,
  0xDF, 0x8F, 0xFF, 0xBE, 0x0F, 0xFE, 0x7C, 0x07, 0xF0, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7F, 0x03, 0x07, 0xFC, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x1F,
  0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x06, 0x00, 0x00, 0x3C, 0x7E, 0x7F, 0xFF,
  0xFF, 0x7E, 0x7E, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x7E, 0x7F, 0xFF,
  0x7F, 0x7E, 0x7E, 0x18, 0x1E, 0x1F, 0x8F, 0xEF, 0xF7, 0xF9, 0xF8, 0xFC,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x1F, 0xCF, 0xC7, 0xE3,
  0xF1, 0xF8, 0xF8, 0xFC, 0x7E, 0x3E, 0x1F, 0x0F, 0x8F, 0x87, 0xC0, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x78, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x03,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x0F,
  0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0xFF, 0xFC, 0xF0, 0x3F, 0x90,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x30,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xE0, 0x1F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x00, 0x3E, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x7C, 0x01, 0xFE, 0x07, 0xC3, 0xE0, 0x3F, 0xFC,
  0x1E, 0x3E, 0x03, 0xFF, 0xE0, 0xF9, 0xF0, 0x3F, 0xFF, 0x07, 0xCF, 0x03,
  0xF0, 0x78, 0x1E, 0x78, 0x1F, 0x03, 0xC0, 0xF7, 0xC1, 0xF0, 0x3E, 0x07,
  0xBE, 0x0F, 0x81, 0xF0, 0x3D, 0xF0, 0x78, 0x0F, 0x81, 0xEF, 0x03, 0xC0,
  0x7C, 0x0F, 0xF8, 0x1E, 0x03, 0xE0, 0x7B, 0xC1, 0xF0, 0x1F, 0x03, 0xDE,
  0x0F, 0x80, 0xF8, 0x1E, 0xF0, 0x7C, 0x07, 0xC0, 0xF7, 0x83, 0xE0, 0x3E,
  0x07, 0xBC, 0x0F, 0x01, 0xF0, 0x3D, 0xE0, 0x78, 0x1F, 0x83, 0xEF, 0x03,
  0xE0, 0xFC, 0x1E, 0x7C, 0x1F, 0x07, 0xE1, 0xF3, 0xE0, 0x7E, 0xF7, 0x9F,
  0x1F, 0x03, 0xFF, 0xBF, 0xF8, 0x78, 0x0F, 0xF8, 0xFF, 0x83, 0xE0, 0x3F,
  0x83, 0xF8, 0x1F, 0x00, 0x20, 0x03, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x70, 0x00, 0x1F,
  0xE0, 0x1F, 0x80, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x01, 0xF3, 0xE0, 0x00,
  0x07, 0xCF, 0x80, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x03,
  0xE1, 0xF0, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x01, 0xF0,
  0x7E, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0xFC, 0x0F,
  0xC0, 0x03, 0xE0, 0x1F, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x7E, 0x01, 0xF8,
  0x01, 0xF8, 0x07, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7E,
  0x00, 0x1F, 0x81, 0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x01, 0xF8, 0x3F, 0x80,
  0x03, 0xF0, 0xFC, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x00,
  0xFC, 0x7E, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x1F,
  0xBF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFC, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFC,
  0x07, 0xFC, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC,
  0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC,
  0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0xFC, 0xFC, 0x01, 0xFC, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xF8, 0xFC, 0x03, 0xFC, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0x7E, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0xFE, 0xFC, 0x01, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF0, 0x7F, 0x80, 0x70, 0x7F, 0x80, 0x08, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0x80, 0x00, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xC1, 0xF8, 0x3F, 0xFC, 0x3F, 0x00, 0x7F, 0x87, 0xE0,
  0x03, 0xF8, 0xFC, 0x00, 0x3F, 0x1F, 0x80, 0x07, 0xF3, 0xF0, 0x00, 0x7E,
  0x7E, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x1F, 0xBF, 0x00,
  0x03, 0xF7, 0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF,
  0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00,
  0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xDF,
  0x80, 0x01, 0xFB, 0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0xFD, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x07, 0xE7, 0xE0, 0x01, 0xFC, 0xFC,
  0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xE3, 0xF0, 0x07, 0xF8, 0x7E, 0x03, 0xFE,
  0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xFF,
  0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xBF, 0xFF, 0xF7, 0xFF, 0xFE, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xC0, 0x3C, 0x0F, 0xF0, 0x00, 0xC1, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F,
  0x7E, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F, 0x7F, 0x00, 0x03, 0xF3, 0xF0,
  0x00, 0x3F, 0x3F, 0x80, 0x03, 0xF1, 0xFC, 0x00, 0x3F, 0x1F, 0xE0, 0x03,
  0xF0, 0xFF, 0x00, 0x3F, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x18,
  0x00, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xE0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0xC1, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x81, 0xFC, 0x1F, 0xDF, 0xFE, 0xFF, 0xE7, 0xFF,
  0x3F, 0xF1, 0xFE, 0x00, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xCF, 0xC0,
  0x07, 0xF3, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0xFE, 0x3F, 0x00, 0x7F, 0x0F,
  0xC0, 0x1F, 0x83, 0xF0, 0x0F, 0xE0, 0xFC, 0x03, 0xF0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0xFE, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x0F,
  0xE0, 0x0F, 0xC3, 0xF0, 0x03, 0xF1, 0xF8, 0x00, 0xFC, 0xFE, 0x00, 0x3F,
  0x3F, 0x00, 0x0F, 0xDF, 0xC0, 0x03, 0xF7, 0xF0, 0x00, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x03, 0xFE, 0xFC, 0x00, 0xFF, 0x3F,
  0x80, 0x3F, 0x87, 0xE0, 0x0F, 0xC1, 0xFC, 0x03, 0xF0, 0x3F, 0x00, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xFC, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x0F, 0xE0,
  0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x7F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03,
  0xF8, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0xCF, 0xC0, 0x03, 0xF3, 0xF0,
  0x00, 0xFE, 0xFC, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x01, 0xEF, 0xFF, 0x7C, 0x00, 0x1F, 0x7F, 0xFB,
  0xE0, 0x00, 0xFB, 0xFF, 0xDF, 0x00, 0x07, 0xDF, 0xFE, 0x7C, 0x00, 0x7C,
  0xFF, 0xF3, 0xE0, 0x03, 0xE7, 0xFF, 0x9F, 0x00, 0x1F, 0x3F, 0xFC, 0xFC,
  0x01, 0xF1, 0xFF, 0xE3, 0xE0, 0x0F, 0x8F, 0xFF, 0x1F, 0x00, 0x7C, 0x7F,
  0xF8, 0xF8, 0x07, 0xC3, 0xFF, 0xC3, 0xE0, 0x3E, 0x1F, 0xFE, 0x1F, 0x01,
  0xF0, 0xFF, 0xF0, 0xF8, 0x0F, 0x07, 0xFF, 0x83, 0xE0, 0xF8, 0x3F, 0xFC,
  0x1F, 0x07, 0xC1, 0xFF, 0xE0, 0xF8, 0x3E, 0x0F, 0xFF, 0x07, 0xE3, 0xE0,
  0x7F, 0xF8, 0x1F, 0x1F, 0x03, 0xFF, 0xC0, 0xF8, 0xF8, 0x1F, 0xFE, 0x07,
  0xCF, 0x80, 0xFF, 0xF0, 0x1F, 0x7C, 0x07, 0xFF, 0x80, 0xFB, 0xE0, 0x3F,
  0xFC, 0x07, 0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xF0, 0x0F, 0xFF, 0x00, 0xFF,
  0x80, 0x7F, 0xF8, 0x07, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xC0, 0x1F, 0xFE,
  0x00, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0x00,
  0x3F, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFD, 0xF0, 0x01, 0xFF, 0xDF, 0x80, 0x1F,
  0xFC, 0xF8, 0x01, 0xFF, 0xCF, 0xC0, 0x1F, 0xFC, 0xFC, 0x01, 0xFF, 0xC7,
  0xE0, 0x1F, 0xFC, 0x7E, 0x01, 0xFF, 0xC3, 0xF0, 0x1F, 0xFC, 0x3F, 0x01,
  0xFF, 0xC1, 0xF8, 0x1F, 0xFC, 0x1F, 0x81, 0xFF, 0xC0, 0xFC, 0x1F, 0xFC,
  0x0F, 0xC1, 0xFF, 0xC0, 0x7E, 0x1F, 0xFC, 0x07, 0xE1, 0xFF, 0xC0, 0x3F,
  0x1F, 0xFC, 0x03, 0xF1, 0xFF, 0xC0, 0x1F, 0x9F, 0xFC, 0x01, 0xF9, 0xFF,
  0xC0, 0x0F, 0xDF, 0xFC, 0x00, 0xFD, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xC0, 0xFF, 0x01, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xF8,
  0x3F, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x3F, 0x9F,
  0x80, 0x00, 0x7E, 0x7E, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0x1F, 0xBF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x7E, 0x7E, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x3F, 0x8F, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF0, 0xFE, 0x00,
  0x1F, 0xC1, 0xFC, 0x00, 0xFE, 0x07, 0xF8, 0x07, 0xF0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x1F, 0x83,
  0xFF, 0x3F, 0x00, 0xFF, 0x7E, 0x00, 0xFE, 0xFC, 0x00, 0xFD, 0xF8, 0x01,
  0xFB, 0xF0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x7E, 0xFC, 0x00, 0xFD, 0xF8, 0x01, 0xFB,
  0xF0, 0x07, 0xF7, 0xE0, 0x1F, 0xCF, 0xC7, 0xFF, 0x9F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x01, 0xFF, 0x80, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xC0, 0xFF, 0x01, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xFC,
  0x3F, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x3F, 0x9F,
  0x80, 0x00, 0x7E, 0x7E, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x7E, 0x7E, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x3F, 0x9F, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF0, 0xFE, 0x00,
  0x1F, 0xC1, 0xFC, 0x00, 0xFE, 0x07, 0xF8, 0x07, 0xF8, 0x0F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0,
  0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x87, 0xE0, 0xFF,
  0xC3, 0xF0, 0x0F, 0xF1, 0xF8, 0x03, 0xF8, 0xFC, 0x00, 0xFC, 0x7E, 0x00,
  0x7F, 0x3F, 0x00, 0x1F, 0x9F, 0x80, 0x0F, 0xCF, 0xC0, 0x07, 0xE7, 0xE0,
  0x03, 0xF3, 0xF0, 0x01, 0xF9, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x7E,
  0x00, 0xFE, 0x3F, 0x00, 0xFE, 0x1F, 0x87, 0xFE, 0x0F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0xFC, 0x1F, 0x80,
  0x7E, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0x7E,
  0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0xFC, 0x01,
  0xF8, 0x7E, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x1F, 0x8F, 0xC0,
  0x07, 0xE7, 0xE0, 0x03, 0xF3, 0xF0, 0x00, 0xFD, 0xF8, 0x00, 0x7E, 0xFC,
  0x00, 0x3F, 0x80, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x87,
  0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xFE, 0x07, 0xC7, 0xF0, 0x03, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF,
  0x80, 0x07, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07,
  0xEC, 0x00, 0x3F, 0xBE, 0x01, 0xFE, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x01, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0x7E, 0x00,
  0x1F, 0x9F, 0x80, 0x07, 0xE7, 0xF0, 0x03, 0xF8, 0xFE, 0x01, 0xFC, 0x3F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0,
  0x01, 0xFF, 0xE0, 0x00, 0x03, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x0F, 0xDF, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x07, 0xE7, 0xE0, 0x00,
  0x3F, 0x3F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0xFC,
  0x3F, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x3E, 0x07, 0xE0, 0x03, 0xF0, 0x3F,
  0x00, 0x1F, 0x81, 0xF8, 0x00, 0xFC, 0x07, 0xC0, 0x07, 0xC0, 0x3F, 0x00,
  0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x01, 0xF8,
  0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0x7E, 0x00, 0x3E, 0x03, 0xE0, 0x01,
  0xF0, 0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x0F, 0x80, 0x01, 0xF0,
  0x7C, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x7E, 0x3F, 0x00, 0x03, 0xF1, 0xF0,
  0x00, 0x0F, 0x8F, 0x80, 0x00, 0x7C, 0xFC, 0x00, 0x03, 0xF7, 0xE0, 0x00,
  0x0F, 0xBE, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xDF,
  0x00, 0x07, 0xF0, 0x00, 0x7C, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE7, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF9, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0xC7, 0xC0, 0x07, 0xFC, 0x00, 0x7C, 0x3F, 0x00, 0x3D,
  0xE0, 0x07, 0xE1, 0xF8, 0x01, 0xEF, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0x7C,
  0x01, 0xF8, 0x3E, 0x00, 0xFB, 0xE0, 0x0F, 0xC1, 0xF8, 0x07, 0xDF, 0x00,
  0x7C, 0x0F, 0xC0, 0x3E, 0xF8, 0x07, 0xE0, 0x7E, 0x01, 0xF7, 0xC0, 0x3F,
  0x03, 0xF0, 0x1F, 0x1F, 0x01, 0xF8, 0x0F, 0x80, 0xF8, 0xF8, 0x0F, 0x80,
  0x7E, 0x07, 0xC7, 0xC0, 0xFC, 0x03, 0xF0, 0x3E, 0x3E, 0x07, 0xE0, 0x1F,
  0x83, 0xE0, 0xF8, 0x3F, 0x00, 0x7C, 0x1F, 0x07, 0xC1, 0xF8, 0x03, 0xE0,
  0xF8, 0x3E, 0x0F, 0x80, 0x1F, 0x87, 0xC1, 0xF0, 0xFC, 0x00, 0xFC, 0x3E,
  0x0F, 0x87, 0xE0, 0x07, 0xE3, 0xE0, 0x3E, 0x3F, 0x00, 0x1F, 0x1F, 0x01,
  0xF1, 0xF0, 0x00, 0xF8, 0xF8, 0x0F, 0x8F, 0x80, 0x07, 0xE7, 0xC0, 0x7C,
  0xFC, 0x00, 0x3F, 0x3C, 0x01, 0xE7, 0xE0, 0x00, 0xFB, 0xE0, 0x0F, 0xBF,
  0x00, 0x07, 0xDF, 0x00, 0x7D, 0xF0, 0x00, 0x3E, 0xF8, 0x03, 0xEF, 0x80,
  0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC7, 0xE0, 0x01, 0xF8, 0xFC, 0x00,
  0x7E, 0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0x3E, 0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0x7C, 0x1F,
  0x80, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x1F, 0x9F, 0x80, 0x03,
  0xF7, 0xE0, 0x00, 0x3E, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x1F, 0x7E, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFC,
  0xFC, 0x00, 0x3F, 0x1F, 0x80, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x3F, 0x00,
  0x3F, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x00,
  0xFC, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x1F,
  0xC0, 0x03, 0xF3, 0xF0, 0x00, 0x7E, 0xFE, 0x00, 0x0F, 0xE0, 0xFC, 0x00,
  0x0F, 0xEF, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xC3,
  0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xC0, 0xFC, 0x01,
  0xF8, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x01, 0xF0, 0x03,
  0xE0, 0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x7E,
  0x00, 0x1F, 0x8F, 0x80, 0x01, 0xF3, 0xF0, 0x00, 0x3F, 0x7C, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xF3, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x1E, 0x1F, 0x00, 0x0F,
  0x87, 0xC0, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x7C, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x03,
  0xF0, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x9F, 0x80, 0x03, 0xE7, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x07, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x03, 0xFF, 0x00, 0x7F,
  0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xF8, 0x7F, 0x06, 0x01, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x03, 0xFF, 0x81, 0xFF, 0xFC, 0x3F, 0xFF, 0xE3,
  0xFF, 0xFF, 0x3F, 0xC0, 0xFB, 0xF8, 0x07, 0xDF, 0x80, 0x3F, 0xF8, 0x01,
  0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC,
  0x03, 0xFF, 0xF0, 0x3F, 0xDF, 0xC3, 0xFE, 0xFF, 0xFD, 0xF3, 0xFF, 0xEF,
  0x8F, 0xFE, 0x3C, 0x3F, 0xC1, 0xE0, 0x70, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x87, 0xF8, 0x1F, 0x1F, 0xF8,
  0x3E, 0x7F, 0xF8, 0x7D, 0xFF, 0xF8, 0xFF, 0xFF, 0xF9, 0xFE, 0x07, 0xF3,
  0xF8, 0x07, 0xF7, 0xF0, 0x07, 0xEF, 0xC0, 0x0F, 0xDF, 0x80, 0x0F, 0xBF,
  0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x03,
  0xF7, 0xF0, 0x07, 0xEF, 0xE0, 0x0F, 0xDF, 0xE0, 0x3F, 0x3F, 0xF1, 0xFE,
  0x7D, 0xFF, 0xF8, 0xFB, 0xFF, 0xF1, 0xF3, 0xFF, 0xC3, 0xC1, 0xFE, 0x00,
  0x00, 0x40, 0x00, 0x01, 0xFF, 0x81, 0xFF, 0xF0, 0xFF, 0xFC, 0x7F, 0xFF,
  0x3F, 0xFF, 0x8F, 0xE0, 0x27, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0xC0, 0x13, 0xFC, 0x7C, 0xFF, 0xFF, 0x1F, 0xFF, 0xC3, 0xFF, 0xF0, 0x3F,
  0xF8, 0x00, 0x40, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x3F, 0x87, 0xE1, 0xFF, 0xCF, 0xC7, 0xFF, 0xDF, 0x9F, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFE, 0xFE, 0x07, 0xFD, 0xF8, 0x07, 0xFF, 0xF0, 0x07,
  0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F,
  0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF,
  0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xF7, 0xE0,
  0x1F, 0xEF, 0xE0, 0x3F, 0xCF, 0xE1, 0xFF, 0x9F, 0xFF, 0xFF, 0x1F, 0xFF,
  0x3E, 0x1F, 0xFC, 0x7C, 0x1F, 0xF0, 0xF8, 0x02, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0x87, 0xE0,
  0xFC, 0x0F, 0xC7, 0xE0, 0x1F, 0x1F, 0x00, 0x7E, 0xFC, 0x00, 0xFB, 0xF0,
  0x03, 0xEF, 0x80, 0x0F, 0xBE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x43, 0xFC, 0x0F,
  0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFC, 0x00,
  0x06, 0x00, 0x00, 0x38, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFE, 0x07,
  0xFF, 0x83, 0xF8, 0x40, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xFF, 0x87, 0xFF, 0xE3,
  0xFF, 0xF8, 0xFF, 0xFE, 0x3F, 0xFF, 0x80, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x03, 0xF8, 0x3E, 0x1F, 0xFC, 0x7C, 0x7F,
  0xFC, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xEF, 0xE0, 0x7F, 0xDF, 0x80,
  0x7F, 0xBF, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x01,
  0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F,
  0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF,
  0xC0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x3F, 0xFE,
  0x00, 0x7F, 0x7E, 0x01, 0xFE, 0xFE, 0x03, 0xFC, 0xFE, 0x1F, 0xF9, 0xFF,
  0xFF, 0xF1, 0xFF, 0xF7, 0xE1, 0xFF, 0xCF, 0xC1, 0xFF, 0x1F, 0x80, 0x20,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x98, 0x00, 0x7E, 0x3F, 0x07, 0xFC,
  0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0x00,
  0x0F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xF8, 0x7F, 0x83, 0xE3, 0xFF, 0x8F, 0x9F, 0xFF, 0x3E, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFB, 0xFC, 0x0F, 0xEF, 0xE0, 0x1F, 0xBF, 0x80, 0x3E, 0xFC, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xC0, 0xFB, 0xFF, 0xFF, 0xFF, 0xE2, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xE0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0x03, 0xE0,
  0x7E, 0x8F, 0xEF, 0xFE, 0xFF, 0xCF, 0xF8, 0xFF, 0x03, 0x80, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x01, 0xFF, 0xF0, 0x07,
  0xEF, 0xC0, 0x3F, 0x3F, 0x01, 0xF8, 0xFC, 0x07, 0xE3, 0xF0, 0x3F, 0x0F,
  0xC1, 0xF8, 0x3F, 0x0F, 0xC0, 0xFC, 0x3F, 0x03, 0xF1, 0xF8, 0x0F, 0xCF,
  0xC0, 0x3E, 0x3E, 0x00, 0xF9, 0xF8, 0x03, 0xEF, 0xE0, 0x0F, 0xBF, 0x80,
  0x3F, 0xFF, 0x00, 0xFF, 0xFE, 0x03, 0xFD, 0xF8, 0x0F, 0xE3, 0xF0, 0x3F,
  0x0F, 0xC0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC0, 0xFC, 0x3F, 0x03,
  0xF0, 0xFC, 0x07, 0xE3, 0xF0, 0x1F, 0x8F, 0xC0, 0x3F, 0x3F, 0x00, 0xFC,
  0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xFF, 0xC0, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x7F, 0x80, 0xFF, 0x0F, 0x9F,
  0xFC, 0x1F, 0xFC, 0xFB, 0xFF, 0xE3, 0xFF, 0xCF, 0xBF, 0xFF, 0x7F, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xE0, 0x7F, 0xFE, 0x03, 0xFE,
  0x03, 0xFF, 0xE0, 0x1F, 0xC0, 0x3F, 0xFC, 0x01, 0xFC, 0x01, 0xFF, 0xC0,
  0x1F, 0x80, 0x1F, 0xFC, 0x01, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0x80, 0x1F,
  0xFC, 0x01, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0x80, 0x1F, 0xFC, 0x01, 0xF8,
  0x01, 0xFF, 0xC0, 0x1F, 0x80, 0x1F, 0xFC, 0x01, 0xF8, 0x01, 0xFF, 0xC0,
  0x1F, 0x80, 0x1F, 0xFC, 0x01, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0x80, 0x1F,
  0xFC, 0x01, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0x80, 0x1F, 0xFC, 0x01, 0xF8,
  0x01, 0xFF, 0xC0, 0x1F, 0x80, 0x1F, 0xFC, 0x01, 0xF8, 0x01, 0xFF, 0xC0,
  0x1F, 0x80, 0x1F, 0xFC, 0x01, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0x80, 0x1F,
  0xFC, 0x01, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0x80, 0x1F, 0xFC, 0x01, 0xF8,
  0x01, 0xF0, 0xF0, 0x7F, 0x83, 0xE3, 0xFF, 0x8F, 0x9F, 0xFF, 0x3E, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFB, 0xFC, 0x0F, 0xEF, 0xE0, 0x1F, 0xBF, 0x80, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF,
  0x80, 0xFF, 0xFF, 0x83, 0xFE, 0xFF, 0x8F, 0xE0, 0x3F, 0x1F, 0x80, 0x3F,
  0x3F, 0x00, 0x7E, 0xFC, 0x00, 0x7D, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0x3F, 0x00,
  0x7E, 0x7E, 0x00, 0xFC, 0xFE, 0x03, 0xF0, 0xFE, 0x1F, 0xE0, 0xFF, 0xFF,
  0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x08, 0x00,
  0xF0, 0x7F, 0x81, 0xF1, 0xFF, 0x83, 0xE7, 0xFF, 0x87, 0xDF, 0xFF, 0x8F,
  0xFE, 0xFF, 0x9F, 0xE0, 0x3F, 0x3F, 0x80, 0x7F, 0x7F, 0x00, 0x7E, 0xFC,
  0x00, 0xFD, 0xF8, 0x00, 0xFB, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07,
  0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x3F, 0x7F, 0x00, 0x7E, 0xFE, 0x01, 0xFD,
  0xFE, 0x03, 0xF3, 0xFF, 0x1F, 0xE7, 0xDF, 0xFF, 0x8F, 0x9F, 0xFF, 0x1F,
  0x3F, 0xFC, 0x3E, 0x1F, 0xE0, 0x7E, 0x06, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF8,
  0x3E, 0x1F, 0xFC, 0x7C, 0x7F, 0xFC, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xEF, 0xE0, 0x7F, 0xDF, 0x80, 0x7F, 0xBF, 0x00, 0x7F, 0xFC, 0x00, 0xFF,
  0xF8, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0,
  0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80,
  0x0F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0x7E, 0x01, 0xFE, 0xFE, 0x03,
  0xFC, 0xFE, 0x1F, 0xF9, 0xFF, 0xFF, 0xF1, 0xFF, 0xF7, 0xE1, 0xFF, 0xCF,
  0xC1, 0xFF, 0x1F, 0x80, 0x30, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0xF0, 0x7F, 0xE1, 0xFF,
  0xE7, 0xFF, 0xDF, 0xFF, 0xBF, 0xFF, 0xFC, 0x7F, 0xE0, 0x7F, 0x80, 0xFE,
  0x01, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x07, 0xFE, 0x07, 0xFF, 0xE3,
  0xFF, 0xFD, 0xFF, 0xFE, 0x7F, 0x0F, 0xBF, 0x00, 0x4F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0xC0,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xE0,
  0x07, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x80, 0x0F, 0xF0, 0x03, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0x3F, 0xFF, 0x83, 0xFF, 0xC0, 0x02, 0x00, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0xFE, 0x7F,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE3, 0x0F, 0xFF, 0x0F, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x00,
  0x20, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F,
  0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8,
  0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0,
  0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF8, 0x1F,
  0xF7, 0xF9, 0xFF, 0xDF, 0xFF, 0xFF, 0x3F, 0xFE, 0x7C, 0x7F, 0xF1, 0xF0,
  0xFF, 0x87, 0xC0, 0x20, 0x00, 0xFC, 0x00, 0x1F, 0xBE, 0x00, 0x1F, 0x9F,
  0x80, 0x0F, 0xCF, 0xC0, 0x07, 0xE7, 0xE0, 0x07, 0xE1, 0xF0, 0x03, 0xF0,
  0xFC, 0x01, 0xF8, 0x7E, 0x00, 0xF8, 0x1F, 0x00, 0xFC, 0x0F, 0x80, 0x7E,
  0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x1F, 0x80, 0x7C, 0x0F,
  0xC0, 0x3F, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xC3, 0xF0, 0x03, 0xF1,
  0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x7E, 0x00, 0x1F,
  0x3E, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xEF, 0x80, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0xC0,
  0x0F, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0xF8, 0x03, 0xF8, 0x03,
  0xF7, 0xC0, 0x3F, 0xE0, 0x1F, 0x3E, 0x01, 0xFF, 0x00, 0xF9, 0xF8, 0x0F,
  0x78, 0x0F, 0xCF, 0xC0, 0x7B, 0xC0, 0x7E, 0x7E, 0x07, 0xDE, 0x03, 0xE1,
  0xF0, 0x3E, 0xF8, 0x1F, 0x0F, 0x81, 0xE7, 0xC1, 0xF8, 0x7E, 0x0F, 0x1E,
  0x0F, 0xC3, 0xF0, 0xF8, 0xF0, 0x7C, 0x0F, 0x87, 0xC7, 0xC3, 0xE0, 0x7C,
  0x3E, 0x3E, 0x1F, 0x03, 0xF1, 0xE1, 0xF1, 0xF8, 0x1F, 0x8F, 0x07, 0x8F,
  0x80, 0x7C, 0xF8, 0x3C, 0x7C, 0x03, 0xE7, 0xC1, 0xF3, 0xE0, 0x1F, 0x3E,
  0x0F, 0x9F, 0x00, 0xF9, 0xE0, 0x7D, 0xF0, 0x07, 0xEF, 0x01, 0xEF, 0x80,
  0x1F, 0x78, 0x0F, 0x7C, 0x00, 0xFF, 0xC0, 0x7B, 0xE0, 0x07, 0xFC, 0x03,
  0xDF, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x07, 0xE0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0xFC, 0x01, 0xF9,
  0xF8, 0x03, 0xF1, 0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0x83, 0xF0, 0x7E, 0x07,
  0xE0, 0xF8, 0x07, 0xE3, 0xF0, 0x0F, 0xC7, 0xC0, 0x0F, 0xDF, 0x80, 0x0F,
  0xBE, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0xF9, 0xF8, 0x03, 0xF1, 0xF8,
  0x07, 0xC3, 0xF0, 0x1F, 0x83, 0xF0, 0x3E, 0x07, 0xE0, 0xFC, 0x07, 0xE1,
  0xF0, 0x0F, 0xC7, 0xE0, 0x0F, 0xDF, 0x80, 0x1F, 0xBF, 0x00, 0x1F, 0x80,
  0xFC, 0x00, 0x1F, 0xBE, 0x00, 0x1F, 0x9F, 0x80, 0x0F, 0xCF, 0xC0, 0x07,
  0xE7, 0xE0, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x7E, 0x00,
  0xF8, 0x1F, 0x00, 0xFC, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x3F, 0x01, 0xF0,
  0x1F, 0x00, 0xF8, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x1F, 0x07, 0xC0, 0x0F,
  0x83, 0xE0, 0x07, 0xE3, 0xF0, 0x01, 0xF1, 0xF0, 0x00, 0xF8, 0xF8, 0x00,
  0x7C, 0x7C, 0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xDF, 0x00,
  0x03, 0xEF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x8F, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xBF,
  0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0x80, 0x07, 0xC0, 0x03,
  0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0x80, 0x1F, 0xC0,
  0x3F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x7F, 0x01, 0xFF, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x00, 0x7F, 0x80, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xFC, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x01,
  0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x3F, 0xE0, 0x3F, 0xC0, 0x3F, 0x80,
  0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x03, 0xFE, 0x03,
  0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x02,
  0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xE0, 0x03, 0xFF, 0x40, 0x00, 0xF0,
};

const GFXglyph NotoSans_Condensed_Medium57pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 7, 42, 14, 4, -41 },
  { 38, 17, 15, 23, 3, -41 },
  { 70, 28, 41, 30, 1, -41 },
  { 214, 22, 46, 27, 3, -43 },
  { 341, 38, 42, 42, 2, -41 },
  { 541, 31, 42, 33, 2, -41 },
  { 704, 6, 15, 13, 3, -41 },
  { 716, 13, 50, 17, 3, -41 },
  { 798, 14, 50, 17, 1, -41 },
  { 886, 22, 22, 26, 2, -43 },
  { 947, 23, 27, 27, 2, -34 },
  { 1025, 9, 14, 14, 2, -7 },
  { 1041, 13, 5, 17, 2, -18 },
  { 1050, 8, 8, 14, 3, -7 },
  { 1058, 20, 41, 22, 1, -41 },
  { 1161, 23, 42, 27, 2, -41 },
  { 1282, 15, 41, 27, 4, -41 },
  { 1359, 23, 41, 27, 2, -41 },
  { 1477, 23, 42, 27, 2, -41 },
  { 1598, 25, 41, 27, 1, -41 },
  { 1727, 22, 42, 27, 3, -41 },
  { 1843, 23, 42, 27, 2, -41 },
  { 1964, 23, 41, 27, 2, -41 },
  { 2082, 23, 42, 27, 2, -41 },
  { 2203, 23, 42, 27, 2, -41 },
  { 2324, 8, 32, 14, 3, -31 },
  { 2356, 9, 38, 14, 2, -31 },
  { 2399, 23, 27, 27, 2, -34 },
  { 2477, 23, 16, 27, 2, -28 },
  { 2523, 23, 27, 27, 2, -34 },
  { 2601, 19, 42, 21, 1, -41 },
  { 2701, 37, 46, 42, 3, -41 },
  { 2914, 30, 41, 30, 0, -41 },
  { 3068, 24, 41, 31, 4, -41 },
  { 3191, 25, 42, 29, 3, -41 },
  { 3323, 27, 41, 34, 4, -41 },
  { 3462, 19, 41, 26, 4, -41 },
  { 3560, 19, 41, 25, 4, -41 },
  { 3658, 28, 42, 34, 3, -41 },
  { 3805, 26, 41, 35, 4, -41 },
  { 3939, 14, 41, 18, 2, -41 },
  { 4011, 13, 52, 14, -3, -41 },
  { 4096, 26, 41, 29, 4, -41 },
  { 4230, 19, 41, 24, 4, -41 },
  { 4328, 37, 41, 45, 4, -41 },
  { 4518, 28, 41, 37, 4, -41 },
  { 4662, 30, 42, 36, 3, -41 },
  { 4820, 23, 41, 29, 4, -41 },
  { 4938, 30, 51, 36, 3, -41 },
  { 5130, 25, 41, 30, 4, -41 },
  { 5259, 22, 42, 26, 2, -41 },
  { 5375, 24, 41, 25, 1, -41 },
  { 5498, 26, 42, 34, 4, -41 },
  { 5635, 29, 41, 29, 0, -41 },
  { 5784, 45, 41, 45, 0, -41 },
  { 6015, 27, 41, 27, 0, -41 },
  { 6154, 27, 41, 27, 0, -41 },
  { 6293, 22, 41, 25, 1, -41 },
  { 6406, 12, 50, 18, 4, -41 },
  { 6481, 20, 41, 22, 1, -41 },
  { 6584, 12, 50, 18, 2, -41 },
  { 6659, 26, 24, 28, 1, -41 },
  { 6737, 25, 4, 25, 0, 5 },
  { 6750, 12, 9, 16, 2, -44 },
  { 6764, 21, 32, 27, 2, -31 },
  { 6848, 23, 44, 29, 4, -43 },
  { 6975, 18, 32, 23, 3, -31 },
  { 7047, 23, 44, 29, 3, -43 },
  { 7174, 22, 32, 27, 3, -31 },
  { 7262, 18, 44, 17, 1, -44 },
  { 7361, 23, 45, 29, 3, -31 },
  { 7491, 22, 43, 29, 4, -43 },
  { 7610, 6, 42, 13, 4, -42 },
  { 7642, 12, 56, 13, -2, -42 },
  { 7726, 22, 43, 26, 4, -43 },
  { 7845, 6, 43, 13, 4, -43 },
  { 7878, 36, 31, 44, 4, -31 },
  { 8018, 22, 31, 29, 4, -31 },
  { 8104, 23, 32, 29, 3, -31 },
  { 8196, 23, 45, 29, 4, -31 },
  { 8326, 23, 45, 29, 3, -31 },
  { 8456, 15, 31, 20, 4, -31 },
  { 8515, 18, 32, 22, 2, -31 },
  { 8587, 16, 39, 18, 1, -38 },
  { 8665, 22, 32, 29, 4, -31 },
  { 8753, 25, 31, 25, 0, -31 },
  { 8850, 37, 31, 39, 1, -31 },
  { 8994, 23, 31, 25, 1, -31 },
  { 9084, 25, 45, 25, 0, -31 },
  { 9225, 18, 31, 21, 2, -31 },
  { 9295, 17, 50, 21, 2, -41 },
  { 9402, 4, 56, 26, 11, -43 },
  { 9430, 17, 50, 21, 2, -41 },
  { 9537, 23, 8, 27, 2, -24 },
};

const GFXfont NotoSans_Condensed_Medium57pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Medium57pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Medium57pt7bGlyphs,
  0x20, 0x7E, 78
};

#endif // _NOTOSANS_CONDENSED_MEDIUM57PT7B_H_
