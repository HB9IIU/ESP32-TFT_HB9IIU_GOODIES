#ifndef _NOTOSANS_CONDENSED_MEDIUM8PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUM8PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Medium.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Medium8pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0x30, 0xB4, 0x55, 0xF6, 0xF6, 0x5F, 0x17, 0x80, 0x4A, 0xCB,
  0x9D, 0x35, 0x20, 0x63, 0x18, 0xEB, 0x3C, 0xC0, 0x5A, 0xA4, 0x95, 0x5C,
  0x5D, 0x80, 0x44, 0xF4, 0x60, 0xC0, 0x80, 0x25, 0x25, 0x00, 0x6A, 0x99,
  0xA6, 0x75, 0x50, 0xE4, 0x95, 0xC0, 0xE4, 0xB3, 0xC0, 0x22, 0x6A, 0xF2,
  0x73, 0x13, 0xC0, 0x64, 0xE9, 0x96, 0xF2, 0x22, 0x44, 0x6A, 0x66, 0x96,
  0x76, 0xB2, 0xC0, 0xC3, 0xC3, 0x80, 0x16, 0xC3, 0xFF, 0x86, 0x3C, 0xC4,
  0xA0, 0x80, 0x31, 0x2B, 0x6D, 0xB9, 0x03, 0x00, 0x26, 0x67, 0x99, 0xD6,
  0xFB, 0xC0, 0x34, 0x88, 0x47, 0xD6, 0xDB, 0x80, 0xEB, 0xB0, 0xEB, 0xA0,
  0x34, 0x89, 0x57, 0xB6, 0xFB, 0x40, 0xD5, 0x70, 0xFF, 0xBB, 0x6D, 0x40,
  0xAA, 0xB0, 0x9C, 0xE7, 0xDE, 0xD4, 0x99, 0xDD, 0xBB, 0x72, 0xA3, 0x14,
  0xB8, 0xD6, 0xE9, 0x00, 0x72, 0xA3, 0x14, 0xB8, 0x40, 0xD6, 0xED, 0x40,
  0x71, 0x13, 0xC0, 0xE9, 0x24, 0x80, 0xB6, 0xDB, 0xC0, 0x99, 0x96, 0x66,
  0x96, 0x5B, 0x5D, 0x69, 0x20, 0x96, 0x66, 0x69, 0x9A, 0x64, 0x44, 0xE4,
  0xA5, 0xC0, 0xFE, 0x91, 0x22, 0x40, 0xD5, 0x5C, 0x46, 0x69, 0xE0, 0xC0,
  0xEE, 0xF0, 0x9A, 0xDB, 0x80, 0x72, 0x30, 0x11, 0x79, 0x97, 0x7E, 0x30,
  0x6B, 0x24, 0x80, 0x79, 0x97, 0x16, 0x9A, 0xDB, 0x40, 0xBC, 0xBF, 0x97,
  0x4D, 0xC0, 0xFC, 0xFD, 0x6B, 0x50, 0xF6, 0xD0, 0x69, 0x96, 0xF6, 0xE9,
  0x00, 0x79, 0x97, 0x11, 0xEA, 0xE8, 0xF0, 0x6A, 0x40, 0xB6, 0xF0, 0xB5,
  0xA0, 0xAD, 0xD6, 0xA0, 0xA9, 0xD0, 0xB5, 0xA5, 0x80, 0xE9, 0x70, 0x29,
  0x64, 0x98, 0xFF, 0x89, 0x34, 0xB0, 0xF0,
};

const GFXglyph NotoSans_Condensed_Medium8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 6, 2, 0, -6 },
  { 3, 3, 2, 3, 0, -6 },
  { 4, 4, 6, 4, 0, -6 },
  { 7, 3, 6, 4, 0, -6 },
  { 10, 6, 6, 6, 0, -6 },
  { 15, 5, 6, 5, 0, -6 },
  { 19, 1, 2, 2, 0, -6 },
  { 20, 2, 7, 2, 0, -6 },
  { 22, 2, 7, 2, 0, -6 },
  { 24, 3, 3, 4, 0, -6 },
  { 26, 4, 4, 4, 0, -5 },
  { 28, 2, 2, 2, 0, -1 },
  { 29, 2, 1, 2, 0, -3 },
  { 30, 1, 1, 2, 0, -1 },
  { 31, 3, 6, 3, 0, -6 },
  { 34, 4, 6, 4, 0, -6 },
  { 37, 2, 6, 4, 1, -6 },
  { 39, 3, 6, 4, 0, -6 },
  { 42, 3, 6, 4, 0, -6 },
  { 45, 4, 6, 4, 0, -6 },
  { 48, 3, 6, 4, 0, -6 },
  { 51, 4, 6, 4, 0, -6 },
  { 54, 4, 6, 4, 0, -6 },
  { 57, 4, 6, 4, 0, -6 },
  { 60, 3, 6, 4, 0, -6 },
  { 63, 2, 4, 2, 0, -4 },
  { 64, 2, 5, 2, 0, -4 },
  { 66, 4, 4, 4, 0, -5 },
  { 68, 4, 2, 4, 0, -4 },
  { 69, 4, 4, 4, 0, -5 },
  { 71, 3, 6, 3, 0, -6 },
  { 74, 6, 7, 6, 0, -6 },
  { 80, 4, 6, 4, 0, -6 },
  { 83, 3, 6, 4, 1, -6 },
  { 86, 4, 6, 4, 0, -6 },
  { 89, 3, 6, 5, 1, -6 },
  { 92, 2, 6, 4, 1, -6 },
  { 94, 2, 6, 3, 1, -6 },
  { 96, 4, 6, 5, 0, -6 },
  { 99, 3, 6, 5, 1, -6 },
  { 102, 2, 6, 2, 0, -6 },
  { 104, 1, 8, 2, 0, -6 },
  { 105, 3, 6, 4, 1, -6 },
  { 108, 2, 6, 3, 1, -6 },
  { 110, 5, 6, 6, 1, -6 },
  { 114, 4, 6, 5, 1, -6 },
  { 117, 5, 6, 5, 0, -6 },
  { 121, 3, 6, 4, 1, -6 },
  { 124, 5, 7, 5, 0, -6 },
  { 129, 3, 6, 4, 1, -6 },
  { 132, 3, 6, 4, 0, -6 },
  { 135, 3, 6, 4, 0, -6 },
  { 138, 3, 6, 5, 1, -6 },
  { 141, 4, 6, 4, 0, -6 },
  { 144, 6, 6, 6, 0, -6 },
  { 149, 4, 6, 4, 0, -6 },
  { 152, 4, 6, 4, 0, -6 },
  { 155, 3, 6, 3, 0, -6 },
  { 158, 1, 7, 3, 1, -6 },
  { 159, 3, 6, 3, 0, -6 },
  { 162, 2, 7, 3, 0, -6 },
  { 164, 4, 4, 4, 0, -6 },
  { 166, 3, 1, 3, 0, 0 },
  { 167, 2, 1, 2, 0, -6 },
  { 168, 3, 4, 4, 0, -4 },
  { 170, 3, 6, 4, 1, -6 },
  { 173, 3, 4, 3, 0, -4 },
  { 175, 4, 6, 4, 0, -6 },
  { 178, 3, 4, 4, 0, -4 },
  { 180, 3, 6, 2, 0, -6 },
  { 183, 4, 6, 4, 0, -4 },
  { 186, 3, 6, 4, 1, -6 },
  { 189, 1, 6, 2, 0, -6 },
  { 190, 1, 8, 2, 0, -6 },
  { 191, 3, 6, 4, 1, -6 },
  { 194, 1, 6, 2, 0, -6 },
  { 195, 5, 4, 6, 1, -4 },
  { 198, 3, 4, 4, 1, -4 },
  { 200, 4, 4, 4, 0, -4 },
  { 202, 3, 6, 4, 1, -4 },
  { 205, 4, 6, 4, 0, -4 },
  { 208, 2, 4, 3, 1, -4 },
  { 209, 3, 4, 3, 0, -4 },
  { 211, 2, 5, 2, 0, -5 },
  { 213, 3, 4, 4, 1, -4 },
  { 215, 3, 4, 3, 0, -4 },
  { 217, 5, 4, 5, 0, -4 },
  { 220, 3, 4, 3, 0, -4 },
  { 222, 3, 6, 3, 0, -4 },
  { 225, 3, 4, 3, 0, -4 },
  { 227, 3, 7, 3, 0, -6 },
  { 230, 1, 8, 4, 1, -6 },
  { 231, 3, 7, 3, 0, -6 },
  { 234, 4, 1, 4, 0, -3 },
};

const GFXfont NotoSans_Condensed_Medium8pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Medium8pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Medium8pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _NOTOSANS_CONDENSED_MEDIUM8PT7B_H_
