#ifndef _NOTOSANS_CONDENSED_MEDIUM38PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUM38PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Medium.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Medium38pt7bBitmaps[] PROGMEM = {
  0x00, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0x39, 0xCE, 0x73,
  0x9C, 0x00, 0x01, 0xCF, 0xFF, 0xDE, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xF7,
  0x0E, 0xE1, 0xDC, 0x3B, 0x87, 0x70, 0xEE, 0x1C, 0x03, 0x87, 0x00, 0xE1,
  0x80, 0x38, 0x60, 0x0E, 0x38, 0x07, 0x0E, 0x01, 0xC3, 0x80, 0x70, 0xE0,
  0x1C, 0x38, 0x7F, 0xFF, 0xDF, 0xFF, 0xF0, 0x71, 0xC0, 0x38, 0x70, 0x0E,
  0x1C, 0x03, 0x87, 0x00, 0xE1, 0xC0, 0x38, 0x60, 0xFF, 0xFF, 0xBF, 0xFF,
  0xEF, 0xFF, 0xF8, 0x70, 0xE0, 0x1C, 0x38, 0x07, 0x0E, 0x01, 0xC3, 0x00,
  0x71, 0xC0, 0x18, 0x70, 0x0E, 0x1C, 0x03, 0x87, 0x00, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x3E, 0x03, 0xFF, 0xCF, 0xFF, 0x9F, 0xDE, 0x79, 0x84,
  0xE3, 0x01, 0xC6, 0x03, 0x8C, 0x07, 0x98, 0x0F, 0xB0, 0x0F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x07, 0xF8, 0x0C, 0xF0, 0x18, 0xE0, 0x31,
  0xE0, 0x63, 0xA0, 0xC7, 0x71, 0xBE, 0xFF, 0xF9, 0xFF, 0xE0, 0xFF, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x07,
  0xC0, 0x1C, 0x03, 0xF8, 0x07, 0x01, 0xEF, 0x03, 0x80, 0x71, 0xC0, 0xE0,
  0x1C, 0x70, 0x70, 0x07, 0x1C, 0x1C, 0x01, 0xC7, 0x8F, 0x00, 0xF0, 0xE3,
  0x80, 0x3C, 0x38, 0xE0, 0x07, 0x1E, 0x70, 0x01, 0xC7, 0x1C, 0x70, 0x71,
  0xCE, 0x3F, 0x1C, 0x73, 0x9F, 0xC7, 0xBC, 0xEF, 0x38, 0xFE, 0x73, 0x8E,
  0x1F, 0x1C, 0xE3, 0x81, 0x0E, 0x38, 0x70, 0x03, 0x8E, 0x1C, 0x01, 0xC3,
  0x87, 0x00, 0x70, 0xE1, 0xC0, 0x1C, 0x38, 0x70, 0x0E, 0x0E, 0x1C, 0x03,
  0x83, 0x8E, 0x01, 0xC0, 0xE3, 0x80, 0x70, 0x1D, 0xE0, 0x3C, 0x07, 0xF0,
  0x0E, 0x00, 0xF8, 0x00, 0x80, 0x00, 0x3F, 0x80, 0x03, 0xFE, 0x00, 0x3F,
  0xF0, 0x01, 0xC3, 0xC0, 0x1E, 0x1E, 0x00, 0xF0, 0xF0, 0x07, 0x87, 0x80,
  0x1C, 0x3C, 0x00, 0xF3, 0xC0, 0x07, 0x9E, 0x00, 0x1F, 0xE0, 0x00, 0xFE,
  0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x47, 0xFC, 0x1C, 0x7C, 0xF1, 0xE3,
  0xC7, 0xCF, 0x1E, 0x1E, 0x79, 0xE0, 0x7F, 0x8F, 0x03, 0xFC, 0x78, 0x0F,
  0xC3, 0xC0, 0x3E, 0x0F, 0x03, 0xF0, 0x7C, 0x3F, 0xC3, 0xFF, 0xFF, 0x0F,
  0xFE, 0x7C, 0x1F, 0xC1, 0xF0, 0xFF, 0xFF, 0x77, 0x77, 0x77, 0x07, 0x0E,
  0x1E, 0x1C, 0x3C, 0x38, 0x78, 0x78, 0x70, 0x70, 0xF0, 0xF0, 0xF0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xF0, 0xF0, 0xF0, 0xF0, 0x70, 0x70, 0x78,
  0x78, 0x3C, 0x3C, 0x1C, 0x1E, 0x0E, 0x07, 0xF0, 0x3C, 0x0E, 0x07, 0x81,
  0xC0, 0xF0, 0x78, 0x1C, 0x0F, 0x07, 0x81, 0xC0, 0xE0, 0x70, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x70, 0x38, 0x3C, 0x1E, 0x0F, 0x07,
  0x07, 0x83, 0xC1, 0xC1, 0xE0, 0xE0, 0xE0, 0xF0, 0x00, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x04, 0x38, 0x4F, 0x77, 0xBF, 0xFF, 0xFF, 0xFF,
  0x07, 0xC0, 0x1F, 0xC0, 0x3B, 0x80, 0xF3, 0x83, 0xC7, 0x83, 0x86, 0x02,
  0x08, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x3C, 0xF3, 0xDE, 0x79, 0xE7, 0x1C, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x77, 0xFF, 0xF7, 0x80, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x01,
  0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xE0,
  0x0F, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x00, 0x78, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x80,
  0x38, 0x00, 0x01, 0x00, 0x3F, 0xC0, 0xFF, 0xC1, 0xFF, 0x87, 0x87, 0x8F,
  0x0F, 0x3C, 0x0F, 0x78, 0x1E, 0xF0, 0x3D, 0xE0, 0x7B, 0xC0, 0x77, 0x00,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0xC0, 0x77, 0x81, 0xEF, 0x03, 0xDE, 0x07, 0xBC, 0x0F, 0x3C, 0x3C, 0x7C,
  0x78, 0x7F, 0xE0, 0xFF, 0xC0, 0x7E, 0x00, 0x01, 0xE0, 0x7C, 0x3F, 0x8F,
  0xF3, 0xFE, 0xFB, 0xFE, 0x79, 0x8F, 0x21, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0x01, 0x00, 0x3F,
  0xE0, 0xFF, 0xE3, 0xFF, 0xE7, 0x83, 0xC4, 0x07, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00,
  0x3E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x01, 0x00, 0x3F, 0xE1, 0xFF, 0xE7, 0xFF, 0xE7, 0x03, 0xC4,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x03,
  0xC0, 0xFF, 0x01, 0xFC, 0x03, 0xFC, 0x07, 0xFE, 0x00, 0x7C, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0xE0,
  0x7D, 0xFF, 0xFB, 0xFF, 0xE3, 0xFF, 0x00, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0D, 0xE0, 0x0E, 0xF0, 0x0E, 0x78,
  0x07, 0x3C, 0x07, 0x1E, 0x03, 0x8F, 0x03, 0x87, 0x81, 0xC3, 0xC1, 0xC1,
  0xE0, 0xE0, 0xF0, 0xE0, 0x78, 0x70, 0x3C, 0x70, 0x1E, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x7F, 0xF9, 0xFF, 0xE7, 0xFF, 0x9C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0xFC,
  0x3F, 0xFC, 0xFF, 0xF9, 0xCF, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF8, 0x07, 0xF0, 0x3E, 0xFF,
  0xFB, 0xFF, 0xC7, 0xFC, 0x00, 0x07, 0xF8, 0x1F, 0xF0, 0x7F, 0xE1, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0x9F, 0x87, 0x7F, 0xCE, 0xFF, 0x9F, 0x0F, 0xBC, 0x0F, 0x78, 0x0E, 0xF0,
  0x1F, 0xC0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x07, 0x9E, 0x0F,
  0x3E, 0x3E, 0x3F, 0xF8, 0x3F, 0xE0, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x00, 0x80, 0x0F, 0xF0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7C, 0x3E,
  0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x38, 0x1E, 0x3C, 0x3C,
  0x1E, 0x7C, 0x1F, 0xF8, 0x07, 0xE0, 0x0F, 0xF0, 0x1F, 0xF8, 0x3C, 0x7C,
  0x78, 0x3E, 0x78, 0x1E, 0x70, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0x78, 0x0E, 0x78, 0x1E, 0x3F, 0xFC, 0x3F, 0xFC, 0x0F, 0xF0, 0x0F, 0xE0,
  0x3F, 0xF0, 0xFF, 0xE3, 0xE1, 0xE7, 0x83, 0xCF, 0x03, 0xDC, 0x07, 0xF8,
  0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x7B, 0xC0, 0xF7, 0x81, 0xEF, 0x8F,
  0xCF, 0xFB, 0x8F, 0xF7, 0x0F, 0x8E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x7C, 0x3F, 0xF0, 0x7F, 0xC0, 0xFE,
  0x00, 0x33, 0xFF, 0xF7, 0x90, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x77,
  0xFF, 0xF7, 0x80, 0x18, 0xF7, 0xDF, 0x3C, 0x40, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xF3, 0xCF, 0x79, 0xE7, 0x9C, 0x73, 0x80, 0x00,
  0x01, 0x00, 0x03, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0xFE, 0x03, 0xF8, 0x0F,
  0xE0, 0x3F, 0x80, 0xFE, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xC0,
  0x00, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0xC0, 0x00, 0x02, 0x01, 0xFF,
  0x3F, 0xFC, 0xFF, 0xE6, 0x0F, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x0F,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x0F, 0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFF,
  0xE0, 0x07, 0xE1, 0xF0, 0x0F, 0x00, 0x78, 0x1E, 0x00, 0x3C, 0x3C, 0x00,
  0x1E, 0x38, 0x00, 0x0E, 0x78, 0x3F, 0x8E, 0x70, 0x7F, 0xC7, 0x70, 0xF3,
  0x87, 0xE1, 0xE3, 0x87, 0xE1, 0xC3, 0x87, 0xE1, 0xC3, 0x87, 0xE3, 0x83,
  0x87, 0xE3, 0x83, 0x87, 0xE3, 0x83, 0x87, 0xE3, 0x83, 0x87, 0xE3, 0x83,
  0x87, 0xE1, 0xC7, 0x87, 0xE1, 0xC7, 0xCE, 0xE1, 0xFE, 0xFE, 0xF0, 0xFC,
  0xFC, 0x70, 0x38, 0x70, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x40, 0x0F, 0xE7, 0xC0, 0x07, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0x03, 0x9C, 0x00, 0x79, 0xC0, 0x07, 0x9E, 0x00,
  0x79, 0xE0, 0x07, 0x0E, 0x00, 0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0xF0, 0xF0,
  0x0E, 0x07, 0x01, 0xE0, 0x78, 0x1F, 0xFF, 0x81, 0xFF, 0xF8, 0x3F, 0xFF,
  0xC3, 0xC0, 0x3C, 0x3C, 0x03, 0xC3, 0xC0, 0x3C, 0x78, 0x01, 0xE7, 0x80,
  0x1E, 0x78, 0x01, 0xEF, 0x80, 0x1F, 0xF0, 0x00, 0xF0, 0xFF, 0xE0, 0xFF,
  0xF8, 0xFF, 0xFC, 0xF0, 0x7E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0,
  0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x3C, 0xFF, 0xF8, 0xFF, 0xE0, 0xFF,
  0xF8, 0xF0, 0xFC, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x1E, 0xF0, 0x7E, 0xFF, 0xFC, 0xFF,
  0xF8, 0xFF, 0xE0, 0x00, 0x30, 0x03, 0xFE, 0x0F, 0xFF, 0x1F, 0xFF, 0x1F,
  0x02, 0x3E, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x3F, 0x03, 0x1F, 0xFF, 0x0F, 0xFF, 0x03, 0xFE, 0xFF,
  0xE0, 0x7F, 0xFC, 0x3F, 0xFF, 0x1E, 0x1F, 0xCF, 0x03, 0xF7, 0x80, 0xFB,
  0xC0, 0x3D, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0xF7, 0x80, 0xFB, 0xC0, 0xF9,
  0xE3, 0xFC, 0xFF, 0xFC, 0x7F, 0xF8, 0x3F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0x10, 0x00, 0x3F, 0xF0,
  0x1F, 0xFF, 0x07, 0xFF, 0xE1, 0xF8, 0x18, 0x7C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0xF7, 0x80, 0x1E, 0xF0, 0x03, 0xDF,
  0x00, 0x79, 0xF0, 0x0F, 0x1F, 0x01, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0x81,
  0xFF, 0xC0, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xE0,
  0xFF, 0xFF, 0xF3, 0xF0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07,
  0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0,
  0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x7F, 0xBF, 0xFF, 0xFC, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x7C, 0x3D, 0xFE, 0xFE, 0x7E,
  0x18, 0x00, 0xF0, 0x0F, 0xF8, 0x0F, 0x3C, 0x07, 0x9E, 0x07, 0x8F, 0x07,
  0x87, 0x83, 0xC3, 0xC3, 0xC1, 0xE3, 0xE0, 0xF1, 0xE0, 0x79, 0xE0, 0x3D,
  0xF0, 0x1E, 0xF0, 0x0F, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xF7, 0xC0,
  0xF1, 0xE0, 0x78, 0xF8, 0x3C, 0x3C, 0x1E, 0x1F, 0x0F, 0x07, 0x87, 0x83,
  0xE3, 0xC0, 0xF1, 0xE0, 0x3C, 0xF0, 0x1E, 0x78, 0x07, 0xBC, 0x03, 0xC0,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xEE,
  0x00, 0x7F, 0xEE, 0x00, 0x7F, 0xEF, 0x00, 0xFF, 0xF7, 0x00, 0xEF, 0xF7,
  0x00, 0xEF, 0xF7, 0x81, 0xEF, 0xF3, 0x81, 0xCF, 0xF3, 0x81, 0xCF, 0xF3,
  0xC3, 0xCF, 0xF3, 0xC3, 0x8F, 0xF1, 0xC3, 0x8F, 0xF1, 0xC7, 0x8F, 0xF1,
  0xE7, 0x0F, 0xF0, 0xE7, 0x0F, 0xF0, 0xE7, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0x7E, 0x0F, 0xF0, 0x7E, 0x0F, 0xF0, 0x7E, 0x0F, 0xF0, 0x7C, 0x0F, 0xF0,
  0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x1F,
  0xF0, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7E, 0xF0, 0x1F, 0xBC, 0x07, 0xE7,
  0x81, 0xFD, 0xE0, 0x7F, 0x3C, 0x1F, 0xCF, 0x07, 0xF1, 0xE1, 0xFC, 0x78,
  0x7F, 0x0F, 0x1F, 0xC3, 0xC7, 0xF0, 0x79, 0xFC, 0x1E, 0x7F, 0x03, 0xDF,
  0xC0, 0xF7, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0,
  0x07, 0xFC, 0x01, 0xFF, 0x00, 0x3C, 0x00, 0x20, 0x00, 0x7F, 0xC0, 0x0F,
  0xFF, 0x01, 0xFF, 0xF8, 0x3F, 0x0F, 0xC3, 0xC0, 0x3C, 0x7C, 0x03, 0xE7,
  0x80, 0x1E, 0x78, 0x01, 0xEF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x1E, 0x78, 0x01, 0xE7, 0x80,
  0x1E, 0x7C, 0x03, 0xE3, 0xC0, 0x7C, 0x3F, 0x0F, 0xC1, 0xFF, 0xF8, 0x0F,
  0xFF, 0x00, 0x3F, 0xC0, 0xFF, 0xC1, 0xFF, 0xE3, 0xFF, 0xE7, 0x87, 0xEF,
  0x03, 0xDE, 0x07, 0xBC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0xFF, 0x81, 0xEF, 0x07, 0xDF, 0xFF, 0x3F, 0xFC, 0x7F, 0xF0, 0xFF, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x7F, 0xE0,
  0x0F, 0xFF, 0x01, 0xFF, 0xF8, 0x3F, 0x0F, 0xC3, 0xC0, 0x3C, 0x7C, 0x03,
  0xE7, 0x80, 0x1E, 0x78, 0x01, 0xEF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x1F, 0x78, 0x01, 0xE7,
  0x80, 0x1E, 0x7C, 0x03, 0xE3, 0xC0, 0x7C, 0x3F, 0x0F, 0xC1, 0xFF, 0xF8,
  0x0F, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0xFF, 0xC0, 0x7F, 0xF8,
  0x3F, 0xFE, 0x1E, 0x3F, 0x8F, 0x03, 0xC7, 0x81, 0xF3, 0xC0, 0x79, 0xE0,
  0x3C, 0xF0, 0x1E, 0x78, 0x0F, 0x3C, 0x0F, 0x1E, 0x07, 0x8F, 0x0F, 0x87,
  0xFF, 0xC3, 0xFF, 0x81, 0xFF, 0xC0, 0xF1, 0xE0, 0x78, 0x78, 0x3C, 0x3C,
  0x1E, 0x0F, 0x0F, 0x07, 0x87, 0x81, 0xE3, 0xC0, 0xF1, 0xE0, 0x7C, 0xF0,
  0x1E, 0x78, 0x0F, 0xBC, 0x03, 0xE0, 0x01, 0x00, 0x7F, 0xC3, 0xFF, 0xDF,
  0xFE, 0xF8, 0x3B, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x7F, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x01, 0xF8,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xE0, 0x1E,
  0xE0, 0xFB, 0xFF, 0xCF, 0xFE, 0x3F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x7F,
  0xE0, 0x3C, 0xF8, 0x3E, 0x7F, 0xFE, 0x1F, 0xFE, 0x03, 0xFE, 0x00, 0xF0,
  0x01, 0xFE, 0x00, 0x3D, 0xE0, 0x07, 0xBC, 0x01, 0xE7, 0x80, 0x3C, 0x70,
  0x07, 0x8F, 0x00, 0xE1, 0xE0, 0x3C, 0x3C, 0x07, 0x83, 0x80, 0xF0, 0x78,
  0x1C, 0x0F, 0x07, 0x81, 0xE0, 0xF0, 0x1C, 0x1C, 0x03, 0xC7, 0x80, 0x78,
  0xF0, 0x07, 0x1E, 0x00, 0xE3, 0x80, 0x1E, 0xF0, 0x03, 0xDE, 0x00, 0x3B,
  0xC0, 0x07, 0x70, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF0, 0x07, 0x80, 0x3F, 0xC0, 0x1E, 0x00, 0xF7,
  0x80, 0x78, 0x07, 0x9E, 0x03, 0xF0, 0x1E, 0x78, 0x0F, 0xC0, 0x79, 0xE0,
  0x3F, 0x01, 0xE3, 0x80, 0xFC, 0x07, 0x8F, 0x07, 0xF8, 0x3C, 0x3C, 0x1E,
  0xE0, 0xF0, 0xF0, 0x73, 0x83, 0xC3, 0xC1, 0xCE, 0x0F, 0x07, 0x07, 0x38,
  0x38, 0x1E, 0x3C, 0xF1, 0xE0, 0x78, 0xE1, 0xC7, 0x81, 0xE3, 0x87, 0x1E,
  0x03, 0x8E, 0x1C, 0x78, 0x0E, 0x78, 0x79, 0xC0, 0x3D, 0xE1, 0xEF, 0x00,
  0xF7, 0x03, 0xBC, 0x03, 0xDC, 0x0E, 0xF0, 0x07, 0x70, 0x3B, 0x80, 0x1D,
  0xC0, 0xEE, 0x00, 0x7E, 0x01, 0xF8, 0x01, 0xF8, 0x07, 0xE0, 0x03, 0xE0,
  0x1F, 0x80, 0x0F, 0x80, 0x7C, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x78, 0x07,
  0xCF, 0x01, 0xE3, 0xC0, 0xF0, 0x70, 0x3C, 0x1E, 0x1E, 0x07, 0x87, 0x80,
  0xF1, 0xC0, 0x3C, 0xF0, 0x07, 0xBC, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x07, 0xF8,
  0x01, 0xEF, 0x00, 0xF3, 0xC0, 0x3C, 0x70, 0x1E, 0x1E, 0x07, 0x87, 0x83,
  0xC0, 0xF0, 0xF0, 0x3C, 0x78, 0x07, 0x9E, 0x01, 0xEF, 0x80, 0x3C, 0xF0,
  0x07, 0xDE, 0x01, 0xE7, 0x80, 0x78, 0xF0, 0x3C, 0x3C, 0x0F, 0x0F, 0x07,
  0x81, 0xE1, 0xE0, 0x78, 0x78, 0x0E, 0x3C, 0x03, 0xCF, 0x00, 0xF3, 0x80,
  0x1F, 0xE0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00,
  0x1E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C,
  0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x01,
  0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xFF,
  0xF0, 0x01, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x38, 0x00,
  0xF0, 0x01, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xC0,
  0xFF, 0xFF, 0xFF, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x3B, 0x80, 0x39, 0xE0,
  0x1C, 0x70, 0x1C, 0x3C, 0x0E, 0x0E, 0x0F, 0x07, 0x87, 0x01, 0xC7, 0x80,
  0xF3, 0x80, 0x3B, 0xC0, 0x1F, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF1, 0xF1, 0xE1, 0xE1, 0xE1, 0xC0, 0x07, 0xE0, 0x7F, 0xE3, 0xFF,
  0x87, 0x1F, 0x10, 0x3C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x3F,
  0xF3, 0xFF, 0xDF, 0x87, 0x78, 0x1D, 0xC0, 0x7F, 0x01, 0xFC, 0x0F, 0xF0,
  0x3D, 0xE1, 0xF7, 0xFF, 0xCF, 0xF7, 0x1F, 0x8C, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE3,
  0xE1, 0xCF, 0xE3, 0xBF, 0xE7, 0xF7, 0xEF, 0x83, 0xDE, 0x07, 0xBC, 0x07,
  0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x3D, 0xF0, 0xFB, 0xFF, 0xE7, 0x7F,
  0xCE, 0x7E, 0x00, 0x07, 0xE1, 0xFF, 0x3F, 0xF7, 0xE6, 0x78, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF8, 0x07, 0xC1, 0x7F, 0xF3, 0xFF, 0x0F, 0xE0, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x0F, 0x1E, 0x3F, 0xBC, 0xFF, 0xFB, 0xF7, 0xF7, 0x83, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF8, 0x3E, 0xF0, 0x7D,
  0xFF, 0xB9, 0xFF, 0x71, 0xF8, 0xE0, 0x07, 0xC0, 0x7F, 0x83, 0xFF, 0x1F,
  0x1E, 0x78, 0x3F, 0xC0, 0xFF, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x01,
  0xF0, 0x33, 0xFF, 0xC7, 0xFF, 0x0F, 0xF8, 0x03, 0xF0, 0x7F, 0x0F, 0xF0,
  0xF1, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1F, 0xE7, 0xFE, 0xFF, 0xEF,
  0xFE, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x1E, 0x00, 0x0F, 0x8E, 0x3F, 0x9C, 0xFF, 0xBB, 0xE7, 0xF7, 0x83,
  0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF8, 0x3E, 0xF0,
  0x7D, 0xFF, 0xF9, 0xFF, 0xF1, 0xF9, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1F, 0x00, 0x79, 0xC1, 0xF3, 0xFF, 0xC7, 0xFF, 0x07, 0xFC, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE3, 0xE3, 0x9F, 0xCE, 0xFF, 0xBF, 0xBF, 0xF8, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x3C, 0x77, 0xFE, 0xE0, 0x00, 0x0E, 0x73, 0x9C, 0xE7, 0x39,
  0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE0, 0x0E, 0x1F, 0x1F,
  0x0E, 0x00, 0x00, 0x00, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E,
  0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E,
  0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x1E, 0x1E, 0xFE, 0xFC, 0xF8, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x3D, 0xC0, 0xF3, 0x81, 0xE7, 0x07, 0x8E, 0x1E, 0x1C, 0x78,
  0x38, 0xF0, 0x73, 0xC0, 0xEF, 0x01, 0xDE, 0x03, 0xFE, 0x07, 0xFC, 0x0F,
  0xBC, 0x1E, 0x3C, 0x38, 0x78, 0x70, 0x78, 0xE0, 0xF1, 0xC0, 0xF3, 0x81,
  0xE7, 0x01, 0xEE, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xE3, 0xE0, 0xF8, 0xEF, 0xF1, 0xFC, 0xEF, 0xFB,
  0xFE, 0xFC, 0xFF, 0xBE, 0xF8, 0x7E, 0x1F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C,
  0x0F, 0xF0, 0x3C, 0x0F, 0xE0, 0x3C, 0x0F, 0xE0, 0x3C, 0x0F, 0xE0, 0x3C,
  0x0F, 0xE0, 0x3C, 0x0F, 0xE0, 0x3C, 0x0F, 0xE0, 0x3C, 0x0F, 0xE0, 0x3C,
  0x0F, 0xE0, 0x3C, 0x0F, 0xE0, 0x3C, 0x0F, 0xE0, 0x3C, 0x0F, 0xE0, 0x3C,
  0x0F, 0xE0, 0x3C, 0x0F, 0xE0, 0x3C, 0x0F, 0xE3, 0xE3, 0x9F, 0xCE, 0xFF,
  0xBF, 0xBF, 0xF8, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x80,
  0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3C, 0x07, 0xC0, 0x3F, 0xE0,
  0xFF, 0xE3, 0xF3, 0xE7, 0x83, 0xDE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x03, 0xFC, 0x07,
  0xF8, 0x0F, 0x78, 0x1E, 0xF0, 0x78, 0xFF, 0xE0, 0xFF, 0xC0, 0xFE, 0x00,
  0xE3, 0xE1, 0xCF, 0xE3, 0xBF, 0xE7, 0xE7, 0xEF, 0x83, 0xDE, 0x07, 0xBC,
  0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01,
  0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x0E, 0xF0, 0x3D, 0xF0, 0xFB, 0xFF, 0xE7,
  0x7F, 0xCE, 0x7E, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x8E, 0x3F,
  0x9C, 0xFF, 0xBB, 0xF7, 0xF7, 0x83, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xF8, 0x3E, 0xF0, 0x7D, 0xFF, 0xF9, 0xFE, 0xF1, 0xF9,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0xE3, 0xF9, 0xFE, 0xFF, 0xFE, 0xFC,
  0x3E, 0x0F, 0x03, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x00, 0x0F, 0xC1, 0xFF,
  0x9F, 0xFC, 0xF0, 0xEF, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x7E, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00,
  0x76, 0x07, 0xBF, 0xFD, 0xFF, 0xC7, 0xFC, 0x00, 0x1C, 0x07, 0x01, 0xC0,
  0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xFC, 0x7F, 0x0F, 0xC0, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xB8, 0x0F, 0x78, 0x3E,
  0xF0, 0xFD, 0xFF, 0xB9, 0xFF, 0x71, 0xF8, 0xE0, 0xF0, 0x0F, 0xF0, 0x0F,
  0x78, 0x0F, 0x78, 0x0E, 0x78, 0x1E, 0x38, 0x1E, 0x3C, 0x1E, 0x3C, 0x1C,
  0x3C, 0x3C, 0x1C, 0x3C, 0x1E, 0x38, 0x1E, 0x78, 0x0E, 0x78, 0x0E, 0x78,
  0x0F, 0x70, 0x07, 0x70, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0,
  0x03, 0xC0, 0xF0, 0x1E, 0x03, 0xDC, 0x07, 0x80, 0xE7, 0x83, 0xE0, 0x79,
  0xE0, 0xFC, 0x1E, 0x78, 0x3F, 0x07, 0x8E, 0x0F, 0xC1, 0xC3, 0x87, 0x70,
  0xF0, 0xF1, 0xCE, 0x3C, 0x3C, 0x73, 0x8F, 0x0F, 0x1C, 0xE3, 0x81, 0xC7,
  0x38, 0xE0, 0x7B, 0x8F, 0x78, 0x1E, 0xE1, 0xDE, 0x07, 0xB8, 0x77, 0x00,
  0xEE, 0x1D, 0xC0, 0x3B, 0x87, 0x70, 0x0E, 0xC1, 0xDC, 0x03, 0xF0, 0x3E,
  0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x07, 0xC0, 0xF8, 0x00, 0x78,
  0x0F, 0x78, 0x1E, 0x3C, 0x1E, 0x3C, 0x3C, 0x1E, 0x3C, 0x1E, 0x78, 0x0F,
  0x78, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07,
  0xF0, 0x0F, 0xF0, 0x0F, 0x78, 0x1E, 0x78, 0x1E, 0x3C, 0x3C, 0x3C, 0x3C,
  0x1E, 0x78, 0x1E, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x78, 0x0F, 0x78,
  0x0E, 0x78, 0x1E, 0x38, 0x1E, 0x3C, 0x1E, 0x3C, 0x1C, 0x1C, 0x3C, 0x1E,
  0x3C, 0x1E, 0x38, 0x0E, 0x78, 0x0E, 0x78, 0x0F, 0x78, 0x0F, 0x70, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x7F,
  0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01,
  0xE0, 0x1E, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x0F, 0x00, 0xF0, 0x1E,
  0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x01, 0xE0, 0x7C, 0x1F, 0x87, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0x87, 0xE0, 0xF0,
  0x1F, 0x80, 0x78, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x0F, 0x01, 0xF8, 0x1F, 0x01, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xF8, 0x0F, 0xC0, 0xFE, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x07,
  0x80, 0x3F, 0x00, 0xF0, 0x7F, 0x07, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xE0, 0xFE,
  0x0F, 0xC0, 0xF0, 0x00, 0x3E, 0x01, 0x7F, 0x83, 0xFF, 0xFF, 0xE3, 0xFF,
  0x80, 0x7E,
};

const GFXglyph NotoSans_Condensed_Medium38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 5, 27, 10, 2, -27 },
  { 18, 11, 10, 15, 2, -27 },
  { 32, 18, 27, 20, 1, -27 },
  { 93, 15, 31, 18, 2, -29 },
  { 152, 26, 28, 28, 1, -28 },
  { 243, 21, 28, 22, 1, -28 },
  { 317, 4, 10, 8, 2, -27 },
  { 322, 8, 33, 11, 2, -27 },
  { 355, 9, 33, 11, 1, -27 },
  { 393, 15, 15, 17, 1, -29 },
  { 422, 16, 18, 18, 1, -22 },
  { 458, 6, 9, 9, 1, -4 },
  { 465, 9, 4, 11, 1, -12 },
  { 470, 5, 5, 9, 2, -5 },
  { 474, 13, 27, 15, 1, -27 },
  { 518, 15, 28, 18, 2, -28 },
  { 571, 11, 27, 18, 2, -27 },
  { 609, 15, 28, 18, 1, -28 },
  { 662, 15, 28, 18, 1, -28 },
  { 715, 17, 27, 18, 1, -27 },
  { 773, 14, 27, 18, 2, -27 },
  { 821, 15, 27, 18, 2, -27 },
  { 872, 16, 27, 18, 1, -27 },
  { 926, 16, 28, 18, 1, -28 },
  { 982, 15, 27, 18, 1, -27 },
  { 1033, 5, 21, 9, 2, -21 },
  { 1047, 6, 26, 9, 1, -21 },
  { 1067, 16, 18, 18, 1, -23 },
  { 1103, 16, 11, 18, 1, -19 },
  { 1125, 16, 18, 18, 1, -23 },
  { 1161, 13, 28, 14, 0, -28 },
  { 1207, 24, 30, 28, 2, -27 },
  { 1297, 20, 27, 20, 0, -27 },
  { 1365, 16, 27, 21, 3, -27 },
  { 1419, 16, 28, 19, 2, -28 },
  { 1475, 17, 27, 22, 3, -27 },
  { 1533, 12, 27, 17, 3, -27 },
  { 1574, 12, 27, 17, 3, -27 },
  { 1615, 19, 28, 23, 2, -28 },
  { 1682, 17, 27, 23, 3, -27 },
  { 1740, 10, 27, 12, 1, -27 },
  { 1774, 9, 35, 10, -2, -27 },
  { 1814, 17, 27, 20, 3, -27 },
  { 1872, 13, 27, 16, 3, -27 },
  { 1916, 24, 27, 30, 3, -27 },
  { 1997, 18, 27, 24, 3, -27 },
  { 2058, 20, 28, 24, 2, -28 },
  { 2128, 15, 27, 19, 3, -27 },
  { 2179, 20, 34, 24, 2, -28 },
  { 2264, 17, 27, 20, 3, -27 },
  { 2322, 14, 28, 17, 2, -28 },
  { 2371, 16, 27, 17, 0, -27 },
  { 2425, 17, 27, 23, 3, -27 },
  { 2483, 19, 27, 19, 0, -27 },
  { 2548, 30, 27, 30, 0, -27 },
  { 2650, 18, 27, 18, 0, -27 },
  { 2711, 18, 27, 18, 0, -27 },
  { 2772, 15, 27, 17, 1, -27 },
  { 2823, 8, 33, 12, 3, -27 },
  { 2856, 14, 27, 15, 0, -27 },
  { 2904, 8, 33, 12, 1, -27 },
  { 2937, 17, 16, 19, 1, -27 },
  { 2971, 16, 3, 16, 0, 3 },
  { 2977, 7, 6, 11, 2, -29 },
  { 2983, 14, 21, 18, 1, -21 },
  { 3020, 15, 29, 20, 3, -29 },
  { 3075, 12, 21, 15, 2, -21 },
  { 3107, 15, 29, 20, 2, -29 },
  { 3162, 14, 21, 18, 2, -21 },
  { 3199, 12, 29, 11, 0, -29 },
  { 3243, 15, 30, 20, 2, -21 },
  { 3300, 14, 29, 20, 3, -29 },
  { 3351, 5, 28, 9, 2, -28 },
  { 3369, 8, 37, 9, -1, -28 },
  { 3406, 15, 29, 18, 3, -29 },
  { 3461, 3, 29, 9, 3, -29 },
  { 3472, 24, 21, 29, 3, -21 },
  { 3535, 14, 21, 20, 3, -21 },
  { 3572, 15, 21, 19, 2, -21 },
  { 3612, 15, 30, 20, 3, -21 },
  { 3669, 15, 30, 20, 2, -21 },
  { 3726, 10, 21, 13, 3, -21 },
  { 3753, 13, 21, 15, 1, -21 },
  { 3788, 10, 25, 12, 1, -25 },
  { 3820, 15, 21, 20, 2, -21 },
  { 3860, 16, 21, 16, 0, -21 },
  { 3902, 26, 21, 26, 0, -21 },
  { 3971, 16, 21, 16, 0, -21 },
  { 4013, 16, 30, 16, 0, -21 },
  { 4073, 12, 21, 14, 1, -21 },
  { 4105, 11, 33, 14, 1, -27 },
  { 4151, 3, 38, 17, 7, -29 },
  { 4166, 12, 33, 14, 1, -27 },
  { 4216, 16, 5, 18, 1, -16 },
};

const GFXfont NotoSans_Condensed_Medium38pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Medium38pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Medium38pt7bGlyphs,
  0x20, 0x7E, 52
};

#endif // _NOTOSANS_CONDENSED_MEDIUM38PT7B_H_
