#ifndef _NOTOSANS_CONDENSED_MEDIUM37PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUM37PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Medium.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Medium37pt7bBitmaps[] PROGMEM = {
  0x00, 0xFB, 0xDE, 0xF7, 0xBD, 0xEF, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x80, 0x00, 0x39, 0xFF, 0xFB, 0xC0, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF,
  0x1E, 0xE3, 0xDC, 0x7B, 0x86, 0x70, 0xC0, 0x03, 0x8E, 0x00, 0xE3, 0x80,
  0x30, 0xE0, 0x1C, 0x38, 0x07, 0x0E, 0x01, 0xC3, 0x00, 0x70, 0xC1, 0xFF,
  0xFF, 0x7F, 0xFF, 0xDF, 0xFF, 0xF0, 0xE1, 0xC0, 0x38, 0x70, 0x0E, 0x18,
  0x03, 0x8E, 0x00, 0xE3, 0x83, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xE1,
  0xC3, 0x80, 0x70, 0xC0, 0x1C, 0x70, 0x07, 0x1C, 0x01, 0x87, 0x00, 0x61,
  0xC0, 0x38, 0x70, 0x0E, 0x18, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x03,
  0xFC, 0x3F, 0xFD, 0xFF, 0xEF, 0xB1, 0xB8, 0xC0, 0xE3, 0x03, 0x8C, 0x0E,
  0x30, 0x3C, 0xC0, 0x7F, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x03, 0xF8,
  0x0D, 0xF0, 0x33, 0xC0, 0xC7, 0x03, 0x1E, 0x0C, 0xFC, 0x37, 0xFF, 0xFE,
  0xFF, 0xF0, 0xFF, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x0E,
  0x00, 0x10, 0x1F, 0x80, 0x70, 0x0F, 0xE0, 0x38, 0x0E, 0x78, 0x1C, 0x07,
  0x1C, 0x1C, 0x03, 0x8E, 0x0E, 0x03, 0x87, 0x0E, 0x01, 0xC3, 0x87, 0x00,
  0xE1, 0xC7, 0x00, 0x70, 0xE3, 0x80, 0x18, 0x71, 0xC0, 0x0E, 0x39, 0xC7,
  0xC7, 0x1C, 0xE7, 0xE3, 0x9E, 0xE7, 0xF8, 0xFE, 0x73, 0x9C, 0x7E, 0x73,
  0x87, 0x0E, 0x39, 0xC3, 0x80, 0x1C, 0xE1, 0xC0, 0x1C, 0x70, 0xE0, 0x0E,
  0x38, 0x70, 0x0E, 0x1C, 0x38, 0x07, 0x0E, 0x1C, 0x03, 0x83, 0x0E, 0x03,
  0x81, 0xCE, 0x01, 0xC0, 0xF7, 0x01, 0xC0, 0x3F, 0x80, 0xE0, 0x0F, 0x80,
  0x03, 0xC0, 0x00, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xE7, 0x80, 0x3C, 0x38,
  0x03, 0xC3, 0x80, 0x3C, 0x38, 0x03, 0xC3, 0x80, 0x1C, 0x78, 0x01, 0xE7,
  0x80, 0x1E, 0xF0, 0x00, 0xFE, 0x00, 0x07, 0xC0, 0x01, 0xFC, 0x00, 0x3F,
  0xC1, 0xE3, 0xDE, 0x1E, 0x78, 0xF1, 0xE7, 0x87, 0xBC, 0xF0, 0x7F, 0xCF,
  0x03, 0xF8, 0xF0, 0x1F, 0x8F, 0x00, 0xF0, 0x78, 0x1F, 0x87, 0xC3, 0xF8,
  0x7F, 0xFF, 0xC3, 0xFF, 0x9E, 0x1F, 0xE1, 0xF0, 0xFF, 0xFF, 0xF7, 0x77,
  0x70, 0x07, 0x0F, 0x0E, 0x1C, 0x3C, 0x38, 0x38, 0x78, 0x70, 0x70, 0xF0,
  0xF0, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xF0, 0xF0,
  0xF0, 0x70, 0x78, 0x78, 0x38, 0x3C, 0x1C, 0x1E, 0x0E, 0x07, 0xE0, 0x70,
  0x78, 0x38, 0x3C, 0x1C, 0x1E, 0x1E, 0x0E, 0x0F, 0x0F, 0x0F, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x0F, 0x0F, 0x0E, 0x0E,
  0x1E, 0x1C, 0x3C, 0x38, 0x78, 0x70, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x63, 0x9D, 0xFF, 0xFF, 0xFF, 0xC7, 0xF8, 0x07, 0xC0, 0x3B,
  0x81, 0xEF, 0x0F, 0x1C, 0x3C, 0x78, 0x20, 0x80, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x3C, 0xF3, 0x9E, 0x79, 0xC7, 0x1C,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x77, 0xFF, 0xF7, 0x00, 0x00, 0x78,
  0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x03,
  0xC0, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xC0,
  0x1E, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0E,
  0x00, 0xF0, 0x07, 0x80, 0x38, 0x00, 0x07, 0x80, 0x7F, 0x83, 0xFF, 0x1F,
  0xFC, 0x78, 0x7B, 0xC1, 0xEF, 0x03, 0xBC, 0x0F, 0xF0, 0x3F, 0x80, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xE7, 0x07, 0x9E, 0x3E,
  0x3F, 0xF0, 0xFF, 0x81, 0xFC, 0x00, 0x03, 0xC1, 0xF0, 0xFC, 0x7F, 0x3D,
  0xFE, 0x77, 0x1C, 0x87, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x07, 0xC0, 0x3F, 0xE1, 0xFF, 0xE7, 0xFF, 0xE3, 0x03,
  0xC4, 0x07, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0x80, 0x7F, 0xE3, 0xFF, 0xE3,
  0xE7, 0xE2, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x78, 0x01, 0xE0, 0x0F, 0x80, 0xFE, 0x01, 0xFC, 0x03, 0xFE, 0x00, 0x3E,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x0F, 0xE0, 0x3E, 0xFF, 0xF9, 0xFF, 0xF1, 0xFF, 0x80, 0x00, 0x78, 0x00,
  0x78, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xB8, 0x03, 0xB8, 0x03,
  0xB8, 0x07, 0x38, 0x0E, 0x38, 0x0E, 0x38, 0x1C, 0x38, 0x1C, 0x38, 0x38,
  0x38, 0x38, 0x38, 0x70, 0x38, 0x70, 0x38, 0xE0, 0x38, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x38, 0x7F, 0xF1, 0xFF, 0xC7, 0xFF, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0xFE, 0x3F, 0xFC,
  0x7F, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xEC, 0x0F, 0xBF, 0xFC, 0xFF, 0xE1, 0xFF,
  0x00, 0x01, 0xF0, 0x1F, 0xE1, 0xFF, 0x8F, 0xE6, 0x3C, 0x01, 0xE0, 0x07,
  0x80, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x3C, 0x3B, 0xFC, 0xEF, 0xFB,
  0xF3, 0xEF, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xF0, 0x3F, 0xC0, 0xF7, 0x83, 0xDE, 0x1E, 0x3F, 0xF8, 0xFF, 0xC0, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0E,
  0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x3F, 0xE0, 0xFF, 0xE1, 0xE3, 0xE7, 0x83, 0xCF,
  0x03, 0xDE, 0x07, 0xBC, 0x0F, 0x78, 0x1C, 0x78, 0x78, 0xF9, 0xE0, 0xFF,
  0xC0, 0xFE, 0x01, 0xFC, 0x07, 0xFC, 0x1F, 0x7C, 0x78, 0x3C, 0xF0, 0x3D,
  0xC0, 0x7F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xDC, 0x07, 0xBC, 0x1F, 0x7F,
  0xFC, 0x7F, 0xF0, 0x3F, 0xC0, 0x03, 0x80, 0x3F, 0xE0, 0xFF, 0xE1, 0xF7,
  0xC7, 0x83, 0xCF, 0x07, 0x9C, 0x07, 0x78, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7B, 0x80, 0xF7, 0x81, 0xEF, 0x07, 0xCF, 0xFF, 0x9F, 0xFF, 0x1F,
  0xDE, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x3F, 0xF0, 0x7F, 0xC0, 0xFE, 0x00, 0x77, 0xFF, 0xF7, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0xFF, 0xFE, 0xF0, 0x39, 0xF7, 0xDF,
  0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0xF3, 0x9E,
  0x79, 0xC7, 0x1C, 0xE0, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x78, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0x00, 0x06,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0xE0, 0x00, 0xF8,
  0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x00, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x00, 0xF0, 0x00, 0xC0, 0x00, 0x07, 0x03, 0xFF, 0x3F, 0xFC, 0xFF, 0xE4,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xE0, 0x1E, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x03,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x0F, 0x80,
  0xF0, 0x1E, 0x00, 0x78, 0x1C, 0x00, 0x3C, 0x38, 0x00, 0x1C, 0x38, 0x08,
  0x0E, 0x70, 0x7F, 0x8E, 0x70, 0xFF, 0x8E, 0xE1, 0xE3, 0x86, 0xE1, 0xC3,
  0x87, 0xE3, 0xC3, 0x87, 0xE3, 0x83, 0x87, 0xE3, 0x83, 0x87, 0xE3, 0x83,
  0x87, 0xE3, 0x83, 0x86, 0xE3, 0x87, 0x8E, 0xE3, 0x87, 0x8E, 0xE1, 0xC7,
  0x8E, 0xE1, 0xFD, 0xFC, 0xE0, 0xFC, 0xF8, 0x70, 0x70, 0x70, 0x70, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x40, 0x0F, 0xEF,
  0xC0, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xB8, 0x00, 0x3B, 0xC0, 0x07, 0xBC,
  0x00, 0x79, 0xC0, 0x07, 0x9C, 0x00, 0x71, 0xE0, 0x0F, 0x1E, 0x00, 0xF0,
  0xE0, 0x0E, 0x0F, 0x00, 0xE0, 0xF0, 0x1E, 0x0F, 0x01, 0xFF, 0xF0, 0x1F,
  0xFF, 0x83, 0xFF, 0xF8, 0x3C, 0x07, 0x83, 0xC0, 0x3C, 0x3C, 0x03, 0xC7,
  0x80, 0x3C, 0x78, 0x01, 0xE7, 0x80, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x1F,
  0xFF, 0xF1, 0xFF, 0xF3, 0xFF, 0xF7, 0x81, 0xEF, 0x03, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x1D, 0xE0, 0x7B, 0xC3, 0xE7, 0xFF, 0x8F, 0xFF,
  0x1F, 0xFF, 0xBC, 0x0F, 0x78, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x1F, 0x7F, 0xFE, 0xFF, 0xF9, 0xFF,
  0xC0, 0x01, 0xF8, 0x07, 0xFF, 0x0F, 0xFF, 0x1F, 0xFE, 0x3E, 0x02, 0x3C,
  0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3F,
  0x02, 0x1F, 0xFE, 0x0F, 0xFE, 0x03, 0xFE, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F,
  0xFF, 0x1E, 0x0F, 0xCF, 0x01, 0xE7, 0x80, 0xFB, 0xC0, 0x3D, 0xE0, 0x1E,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xBC, 0x03, 0xDE,
  0x01, 0xEF, 0x01, 0xE7, 0x81, 0xF3, 0xC3, 0xF1, 0xFF, 0xF0, 0xFF, 0xF0,
  0x7F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0xFE, 0xFF, 0xEF, 0xFE,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0xFC, 0x00,
  0xFF, 0xE0, 0xFF, 0xFC, 0x7F, 0xFE, 0x3F, 0x01, 0x8F, 0x00, 0x07, 0xC0,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3D, 0xE0, 0x0F, 0x78, 0x03, 0xDF, 0x00, 0xF3, 0xC0,
  0x3C, 0xFC, 0x0F, 0x1F, 0xFF, 0xC3, 0xFF, 0xF0, 0x3F, 0xF8, 0xF0, 0x07,
  0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xC0, 0xFF, 0xFF, 0xC7, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0xFE, 0xFF, 0xFF, 0xC0,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xE0, 0xF0, 0x7B, 0xFD, 0xFC,
  0xFC, 0x00, 0xF0, 0x1F, 0xF0, 0x1E, 0xF0, 0x3C, 0xF0, 0x78, 0xF0, 0x78,
  0xF0, 0xF0, 0xF1, 0xE0, 0xF1, 0xE0, 0xF3, 0xC0, 0xF7, 0xC0, 0xF7, 0x80,
  0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xC0, 0xFB, 0xC0, 0xF3, 0xE0, 0xF1, 0xE0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0x3C, 0xF0, 0x3C,
  0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x0F, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F,
  0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x0F, 0xFD,
  0xC0, 0x1D, 0xFB, 0x80, 0x3B, 0xF7, 0x80, 0x77, 0xE7, 0x01, 0xCF, 0xCE,
  0x03, 0x9F, 0x9E, 0x07, 0x3F, 0x3C, 0x1E, 0x7E, 0x38, 0x38, 0xFC, 0x70,
  0x71, 0xF8, 0xF1, 0xE3, 0xF0, 0xE3, 0x87, 0xE1, 0xC7, 0x0F, 0xC3, 0xDE,
  0x1F, 0x83, 0xB8, 0x3F, 0x07, 0x70, 0x7E, 0x0F, 0xE0, 0xFC, 0x1F, 0x81,
  0xF8, 0x1F, 0x03, 0xF0, 0x3E, 0x07, 0xE0, 0x7C, 0x0F, 0xC0, 0x70, 0x1C,
  0xF8, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFE, 0x03, 0xFF,
  0x80, 0xFE, 0xF0, 0x3F, 0xBC, 0x0F, 0xE7, 0x83, 0xF9, 0xE0, 0xFE, 0x3C,
  0x3F, 0x8F, 0x0F, 0xE1, 0xE3, 0xF8, 0x78, 0xFE, 0x0F, 0x3F, 0x83, 0xCF,
  0xE0, 0x7B, 0xF8, 0x1E, 0xFE, 0x03, 0xDF, 0x80, 0xF7, 0xE0, 0x1F, 0xF8,
  0x07, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xF8, 0x01, 0xF0, 0x00,
  0xF0, 0x00, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC3, 0xE0, 0x78, 0xF8,
  0x07, 0x9E, 0x00, 0xF3, 0xC0, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xBC, 0x00, 0xF7, 0x80,
  0x3C, 0xF0, 0x07, 0x8F, 0x01, 0xF1, 0xF0, 0x7C, 0x1F, 0xFF, 0x01, 0xFF,
  0xC0, 0x1F, 0xF0, 0x00, 0xFF, 0xE3, 0xFF, 0xCF, 0xFF, 0xBC, 0x1F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x1F, 0xF1, 0xFB, 0xFF, 0xCF, 0xFE, 0x3F, 0xE0, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC3,
  0xE0, 0x78, 0xF8, 0x07, 0x9E, 0x00, 0xF3, 0xC0, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xBC,
  0x00, 0xF7, 0x80, 0x3C, 0xF0, 0x07, 0x8F, 0x01, 0xF1, 0xF0, 0x7C, 0x1F,
  0xFF, 0x01, 0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xE0, 0xFF, 0xE0, 0xFF,
  0xF0, 0xFF, 0xF8, 0xF0, 0x7C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0,
  0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x78, 0xFF, 0xF0, 0xFF,
  0xE0, 0xFF, 0xC0, 0xF1, 0xE0, 0xF1, 0xE0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0x78, 0xF0, 0x78, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0,
  0x1F, 0x03, 0xC0, 0x7F, 0xF3, 0xFF, 0xCF, 0xFF, 0x7C, 0x09, 0xE0, 0x07,
  0x80, 0x1C, 0x00, 0x78, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x80, 0x7F, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0xF8, 0x03, 0xFC, 0x1F, 0xFF, 0xFB, 0xFF, 0xC7, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8,
  0x0F, 0x7C, 0x3E, 0x7F, 0xFE, 0x3F, 0xFC, 0x0F, 0xF0, 0xF0, 0x01, 0xEE,
  0x00, 0x79, 0xE0, 0x0F, 0x3C, 0x01, 0xE7, 0x80, 0x38, 0x70, 0x0F, 0x0F,
  0x01, 0xE1, 0xE0, 0x3C, 0x3C, 0x07, 0x03, 0x81, 0xE0, 0x78, 0x3C, 0x0F,
  0x07, 0x00, 0xE0, 0xE0, 0x1C, 0x3C, 0x03, 0xC7, 0x80, 0x78, 0xE0, 0x07,
  0x3C, 0x00, 0xE7, 0x80, 0x1E, 0xF0, 0x03, 0xDC, 0x00, 0x3B, 0x80, 0x07,
  0xF0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0xF0,
  0x07, 0x80, 0x7F, 0x80, 0x7C, 0x03, 0xDE, 0x03, 0xE0, 0x1E, 0xF0, 0x1F,
  0x00, 0xE7, 0x80, 0xFC, 0x0F, 0x3C, 0x06, 0xE0, 0x78, 0xE0, 0x77, 0x03,
  0xC7, 0x83, 0xB8, 0x1C, 0x3C, 0x1D, 0xC1, 0xE1, 0xE0, 0xEF, 0x0F, 0x0F,
  0x0F, 0x38, 0x78, 0x38, 0x71, 0xC3, 0xC1, 0xE3, 0x8E, 0x1C, 0x0F, 0x1C,
  0x79, 0xE0, 0x79, 0xE1, 0xCF, 0x01, 0xCF, 0x0E, 0x78, 0x0E, 0x70, 0x73,
  0x80, 0x7B, 0x83, 0x9C, 0x03, 0xDC, 0x1F, 0xE0, 0x1E, 0xE0, 0x7F, 0x00,
  0x7E, 0x03, 0xF8, 0x03, 0xF0, 0x1F, 0x80, 0x1F, 0x80, 0xFC, 0x00, 0xFC,
  0x03, 0xE0, 0x03, 0xE0, 0x1F, 0x00, 0x1E, 0x00, 0xF8, 0x00, 0x78, 0x07,
  0x8F, 0x03, 0xC3, 0xC0, 0xF0, 0x70, 0x78, 0x1E, 0x1E, 0x03, 0x87, 0x00,
  0xF3, 0xC0, 0x3C, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x01, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xE0, 0x07, 0xF8,
  0x03, 0xCE, 0x00, 0xF3, 0xC0, 0x78, 0x70, 0x1E, 0x1E, 0x0F, 0x07, 0x83,
  0xC0, 0xF1, 0xE0, 0x3C, 0x78, 0x07, 0xBC, 0x01, 0xF0, 0xF0, 0x07, 0xBC,
  0x03, 0x9E, 0x03, 0xC7, 0x81, 0xE3, 0xC1, 0xE1, 0xE0, 0xF0, 0x78, 0x70,
  0x3C, 0x78, 0x0E, 0x3C, 0x07, 0xBC, 0x01, 0xDE, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1E,
  0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x3C,
  0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78,
  0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xFF,
  0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0,
  0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x1E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0,
  0xFF, 0xFF, 0xFF, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xC0, 0x01,
  0xE0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x73, 0x80, 0x39, 0xE0,
  0x3C, 0x70, 0x1C, 0x3C, 0x1E, 0x0E, 0x0E, 0x07, 0x0F, 0x01, 0xC7, 0x00,
  0xE7, 0x80, 0x3B, 0x80, 0x1E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x3C, 0x1C, 0x1E, 0x0F, 0x03, 0x0F, 0xF0, 0xFF, 0xE1, 0xFF, 0x84, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x0F, 0xFC, 0xFF, 0xF7, 0xF3,
  0xDE, 0x0F, 0x70, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0x78, 0x7D, 0xFF,
  0xF7, 0xFD, 0xC7, 0xE7, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE7, 0xE1, 0xDF, 0xE3, 0xFF,
  0xE7, 0xC3, 0xCF, 0x03, 0xDE, 0x07, 0xB8, 0x0F, 0x70, 0x0E, 0xE0, 0x1D,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xEE, 0x01, 0xDC, 0x07, 0xBC, 0x0F, 0x78,
  0x1E, 0xF8, 0x79, 0xFF, 0xF3, 0xBF, 0xC7, 0x3F, 0x00, 0x0F, 0xF3, 0xFF,
  0x3F, 0xE7, 0x82, 0x78, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x17, 0xFF,
  0x3F, 0xF1, 0xFE, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x1F, 0x9E, 0x7F, 0xBD, 0xFF, 0xFB,
  0xC3, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x1F,
  0x78, 0x7E, 0xFF, 0xFC, 0xFF, 0x78, 0xFC, 0x70, 0x0F, 0xC0, 0xFF, 0xC7,
  0xFF, 0x1E, 0x1E, 0xF0, 0x3B, 0xC0, 0xFF, 0x03, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1C, 0x00,
  0x78, 0x08, 0xFF, 0xE3, 0xFF, 0x83, 0xFC, 0x07, 0xF0, 0xFF, 0x0F, 0xE1,
  0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3F, 0xCF, 0xFC, 0xFF, 0xC1,
  0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x1F, 0x9E, 0x7F, 0xBD, 0xFF, 0xFB, 0xC3, 0xFF, 0x03, 0xFE, 0x07,
  0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x1F, 0x78, 0x7E, 0xFF, 0xFC, 0xFF,
  0x78, 0xFC, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x80, 0x3C,
  0xE1, 0xF1, 0xFF, 0xE3, 0xFF, 0x81, 0xFC, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE7, 0xE3,
  0xBF, 0xCF, 0xFF, 0xBE, 0x1E, 0xF0, 0x3F, 0xC0, 0xFE, 0x03, 0xF8, 0x0F,
  0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0x27, 0xFF, 0x70,
  0x00, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x04,
  0x1C, 0x78, 0xF0, 0xE0, 0x00, 0x00, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3,
  0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0xC3, 0x8F, 0x1F, 0x7F, 0xF7, 0xEF, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x7F,
  0x81, 0xEE, 0x0F, 0x38, 0x78, 0xE3, 0xC3, 0x8F, 0x0E, 0x78, 0x3B, 0xC0,
  0xEF, 0x03, 0xFC, 0x0F, 0xF8, 0x3E, 0xF0, 0xF3, 0xC3, 0x87, 0x8E, 0x1E,
  0x38, 0x3C, 0xE0, 0xF3, 0x81, 0xEE, 0x07, 0xB8, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE7, 0xE1, 0xF9, 0xDF,
  0xE7, 0xFB, 0xFF, 0xDF, 0xFF, 0xC3, 0xF0, 0xFF, 0x07, 0xC1, 0xFE, 0x0F,
  0x83, 0xF8, 0x0E, 0x03, 0xF0, 0x1C, 0x07, 0xE0, 0x38, 0x0F, 0xC0, 0x70,
  0x1F, 0x80, 0xE0, 0x3F, 0x01, 0xC0, 0x7E, 0x03, 0x80, 0xFC, 0x07, 0x01,
  0xF8, 0x0E, 0x03, 0xF0, 0x1C, 0x07, 0xE0, 0x38, 0x0F, 0xC0, 0x70, 0x1F,
  0x80, 0xE0, 0x3F, 0x01, 0xC0, 0x70, 0xE7, 0xE3, 0xBF, 0xCF, 0xFF, 0xBE,
  0x1E, 0xF0, 0x3F, 0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0xFE, 0x03, 0xF8, 0x0F, 0x0F, 0xE0, 0x7F, 0xE1, 0xFF, 0xE3, 0xC3,
  0xEF, 0x03, 0xDE, 0x03, 0xBC, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0x38, 0x1E, 0x78,
  0x3C, 0x7F, 0xF0, 0xFF, 0xC0, 0x7F, 0x00, 0xE7, 0xE1, 0xDF, 0xE3, 0xFF,
  0xE7, 0xC3, 0xCF, 0x03, 0xDE, 0x07, 0xB8, 0x0F, 0x70, 0x0E, 0xE0, 0x1D,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xEE, 0x01, 0xDC, 0x07, 0xBC, 0x0F, 0x78,
  0x1E, 0xF8, 0x79, 0xFF, 0xF3, 0xBF, 0xC7, 0x3F, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x00, 0x1F, 0x9E, 0x7F, 0xBD, 0xFF, 0xFB, 0xC3, 0xFF, 0x03, 0xFE,
  0x07, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x1F, 0x78, 0x7E, 0xFF, 0xFC,
  0xFF, 0x78, 0xFC, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0xC7, 0xFB, 0xEE,
  0xFB, 0xFA, 0xF8, 0x3C, 0x0F, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0x1F, 0xE3,
  0xFF, 0x7F, 0xE7, 0x02, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x7F, 0x03,
  0xF8, 0x0F, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x70, 0x0F, 0xC0, 0xFF,
  0xFE, 0xFF, 0xE7, 0xFC, 0x18, 0x06, 0x03, 0x80, 0xE0, 0x7F, 0xFF, 0xFF,
  0xFC, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xF0, 0x3C, 0x0F, 0xF1, 0xFC, 0x7F, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03,
  0xFC, 0x0F, 0xBC, 0x1F, 0x78, 0x7E, 0xFF, 0xFC, 0xFF, 0x78, 0xFC, 0x70,
  0xF0, 0x0F, 0x70, 0x0E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x38, 0x1C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x1C, 0x38, 0x1C, 0x38, 0x1E, 0x78, 0x1E, 0x78,
  0x0E, 0x70, 0x0E, 0x70, 0x0F, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x3E, 0x07, 0xB8, 0x1F, 0x03, 0xDE, 0x0F,
  0x81, 0xCF, 0x07, 0xC1, 0xE7, 0x83, 0x70, 0xF1, 0xC3, 0xB8, 0x78, 0xE1,
  0xDC, 0x38, 0x78, 0xEE, 0x1C, 0x3C, 0x73, 0x9E, 0x0E, 0x71, 0xCF, 0x07,
  0x38, 0xE7, 0x03, 0x9C, 0x73, 0x81, 0xEE, 0x39, 0xC0, 0xF7, 0x0F, 0xE0,
  0x3F, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0xFC,
  0x01, 0xE0, 0x3C, 0x00, 0xF0, 0x1E, 0x00, 0x78, 0x1E, 0x38, 0x1E, 0x3C,
  0x3C, 0x1C, 0x3C, 0x1E, 0x78, 0x0E, 0x78, 0x0F, 0xF0, 0x07, 0xE0, 0x07,
  0xE0, 0x03, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1E,
  0x78, 0x1E, 0x78, 0x3C, 0x3C, 0x3C, 0x3C, 0x78, 0x1E, 0xF8, 0x1F, 0xF0,
  0x0F, 0x70, 0x0E, 0x78, 0x1E, 0x78, 0x1E, 0x38, 0x1E, 0x38, 0x1C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x1C, 0x38, 0x1E, 0x38, 0x1E, 0x78, 0x0E, 0x78, 0x0E,
  0x70, 0x0F, 0x70, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x9F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x78, 0x00, 0xFF, 0xEF, 0xFE,
  0xFF, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x00, 0xF0,
  0x0E, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x70, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x03, 0xE0, 0xFC, 0x1F, 0x87, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x3C, 0x3F, 0x07,
  0xC0, 0xFC, 0x07, 0xC0, 0x38, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF8, 0x0F, 0xC0, 0xF8, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xF8, 0x1F, 0x81, 0xF8, 0x0F, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xF0, 0x1E, 0x01, 0xF8, 0x0F, 0x03,
  0xE0, 0xF0, 0x3C, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x01, 0xE1, 0xFC, 0x3F, 0x07, 0x80, 0x18, 0x01, 0x7F,
  0x03, 0xFF, 0xFF, 0xE7, 0xFF, 0x80, 0xFE, 0x80, 0x00,
};

const GFXglyph NotoSans_Condensed_Medium37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 5, 26, 9, 2, -26 },
  { 18, 11, 9, 15, 2, -26 },
  { 31, 18, 26, 19, 1, -26 },
  { 90, 14, 30, 18, 2, -28 },
  { 143, 25, 27, 27, 1, -27 },
  { 228, 20, 27, 21, 1, -27 },
  { 296, 4, 9, 8, 2, -26 },
  { 301, 8, 33, 11, 2, -27 },
  { 334, 8, 33, 11, 1, -27 },
  { 367, 14, 14, 17, 1, -28 },
  { 392, 15, 18, 18, 1, -22 },
  { 426, 6, 9, 9, 1, -4 },
  { 433, 9, 4, 11, 1, -12 },
  { 438, 5, 5, 9, 2, -5 },
  { 442, 13, 27, 14, 1, -27 },
  { 486, 14, 27, 18, 2, -27 },
  { 534, 10, 26, 18, 2, -26 },
  { 567, 15, 27, 18, 1, -27 },
  { 618, 15, 27, 18, 1, -27 },
  { 669, 16, 27, 18, 1, -27 },
  { 723, 14, 26, 18, 2, -26 },
  { 769, 14, 27, 18, 2, -27 },
  { 817, 15, 26, 18, 1, -26 },
  { 866, 15, 27, 18, 1, -27 },
  { 917, 15, 27, 18, 1, -27 },
  { 968, 5, 20, 9, 2, -20 },
  { 981, 6, 25, 9, 1, -20 },
  { 1000, 15, 17, 18, 1, -22 },
  { 1032, 15, 10, 18, 1, -18 },
  { 1051, 16, 17, 18, 1, -22 },
  { 1085, 13, 27, 14, 0, -27 },
  { 1129, 24, 30, 27, 2, -27 },
  { 1219, 20, 26, 20, 0, -26 },
  { 1284, 15, 26, 20, 3, -26 },
  { 1333, 16, 27, 19, 2, -27 },
  { 1387, 17, 26, 22, 3, -26 },
  { 1443, 12, 26, 17, 3, -26 },
  { 1482, 12, 26, 16, 3, -26 },
  { 1521, 18, 27, 22, 2, -27 },
  { 1582, 17, 26, 23, 3, -26 },
  { 1638, 9, 26, 12, 1, -26 },
  { 1668, 9, 33, 9, -2, -26 },
  { 1706, 16, 26, 19, 3, -26 },
  { 1758, 12, 26, 16, 3, -26 },
  { 1797, 23, 26, 29, 3, -26 },
  { 1872, 18, 26, 24, 3, -26 },
  { 1931, 19, 27, 23, 2, -27 },
  { 1996, 14, 26, 19, 3, -26 },
  { 2042, 19, 33, 23, 2, -27 },
  { 2121, 16, 26, 19, 3, -26 },
  { 2173, 14, 27, 17, 1, -27 },
  { 2221, 16, 26, 16, 0, -26 },
  { 2273, 16, 26, 22, 3, -26 },
  { 2325, 19, 26, 19, 0, -26 },
  { 2387, 29, 26, 29, 0, -26 },
  { 2482, 18, 26, 18, 0, -26 },
  { 2541, 17, 26, 17, 0, -26 },
  { 2597, 14, 26, 16, 1, -26 },
  { 2643, 8, 33, 12, 3, -27 },
  { 2676, 14, 27, 14, 0, -27 },
  { 2724, 8, 33, 12, 1, -27 },
  { 2757, 17, 15, 18, 1, -26 },
  { 2789, 16, 3, 16, 0, 3 },
  { 2795, 8, 6, 11, 1, -28 },
  { 2801, 14, 20, 18, 1, -20 },
  { 2836, 15, 28, 19, 3, -28 },
  { 2889, 12, 20, 15, 2, -20 },
  { 2919, 15, 28, 19, 2, -28 },
  { 2972, 14, 20, 18, 2, -20 },
  { 3007, 12, 28, 11, 0, -28 },
  { 3049, 15, 29, 19, 2, -20 },
  { 3104, 14, 28, 19, 3, -28 },
  { 3153, 4, 28, 9, 2, -28 },
  { 3167, 7, 37, 9, -1, -28 },
  { 3200, 14, 28, 17, 3, -28 },
  { 3249, 3, 28, 9, 3, -28 },
  { 3260, 23, 20, 29, 3, -20 },
  { 3318, 14, 20, 19, 3, -20 },
  { 3353, 15, 20, 19, 2, -20 },
  { 3391, 15, 29, 19, 3, -20 },
  { 3446, 15, 29, 19, 2, -20 },
  { 3501, 10, 20, 13, 3, -20 },
  { 3526, 12, 20, 14, 1, -20 },
  { 3556, 10, 24, 12, 1, -24 },
  { 3586, 15, 20, 19, 2, -20 },
  { 3624, 16, 20, 16, 0, -20 },
  { 3664, 25, 20, 25, 0, -20 },
  { 3727, 16, 20, 16, 0, -20 },
  { 3767, 16, 29, 16, 0, -20 },
  { 3825, 12, 20, 14, 1, -20 },
  { 3855, 11, 32, 14, 1, -26 },
  { 3899, 3, 37, 17, 7, -28 },
  { 3913, 11, 32, 14, 1, -26 },
  { 3957, 16, 6, 18, 1, -16 },
};

const GFXfont NotoSans_Condensed_Medium37pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Medium37pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Medium37pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _NOTOSANS_CONDENSED_MEDIUM37PT7B_H_
