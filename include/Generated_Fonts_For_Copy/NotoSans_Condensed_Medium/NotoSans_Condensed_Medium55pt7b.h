#ifndef _NOTOSANS_CONDENSED_MEDIUM55PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUM55PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Medium.ttf
// Size: 55pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Medium55pt7bBitmaps[] PROGMEM = {
  0x00, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7,
  0xEF, 0xDF, 0xBE, 0x7C, 0xF9, 0xF3, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x3C, 0xFD, 0xFF, 0xFF, 0xEF, 0xDF, 0x8C,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0x7C, 0x1F,
  0x7C, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0x78, 0x1F, 0x78, 0x1F, 0x78, 0x1E,
  0x78, 0x1E, 0x78, 0x1E, 0x00, 0x7C, 0x1E, 0x00, 0x0F, 0x03, 0xC0, 0x01,
  0xE0, 0x78, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0x83, 0xE0, 0x00, 0xF0, 0x78,
  0x00, 0x3E, 0x0F, 0x00, 0x07, 0x81, 0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x1E,
  0x07, 0x80, 0x03, 0xC0, 0xF0, 0x1F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF8, 0x0F, 0x03, 0xC0, 0x01, 0xE0,
  0x78, 0x00, 0x3C, 0x1F, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF0, 0x78, 0x00,
  0x3C, 0x0F, 0x00, 0x07, 0x81, 0xE0, 0x00, 0xF0, 0x3C, 0x07, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x03,
  0xC0, 0xF0, 0x00, 0x78, 0x1E, 0x00, 0x0F, 0x03, 0xC0, 0x01, 0xE0, 0x78,
  0x00, 0x3C, 0x1F, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x3C,
  0x0F, 0x00, 0x07, 0x81, 0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x1E, 0x07, 0x80,
  0x03, 0xC1, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x03, 0xFF, 0xC0, 0x7F, 0xFF, 0xC7, 0xFF,
  0xFE, 0x7F, 0xFF, 0xF3, 0xFB, 0xBF, 0x3F, 0x1C, 0x19, 0xF0, 0xE0, 0x0F,
  0x87, 0x00, 0x7C, 0x38, 0x03, 0xE1, 0xC0, 0x1F, 0x0E, 0x00, 0xF8, 0x70,
  0x07, 0xE3, 0x80, 0x1F, 0xDC, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x07,
  0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0x80, 0x1C, 0xFC, 0x00, 0xE3, 0xF0, 0x07, 0x0F, 0x80, 0x38, 0x7C, 0x01,
  0xC3, 0xE0, 0x0E, 0x1F, 0x80, 0x71, 0xFE, 0x03, 0x9F, 0xBF, 0x1F, 0xFD,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x7F, 0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xC0,
  0x07, 0xFC, 0x00, 0x3C, 0x00, 0x7F, 0xF0, 0x03, 0xE0, 0x07, 0xC7, 0x80,
  0x1E, 0x00, 0x3C, 0x3E, 0x01, 0xF0, 0x01, 0xE0, 0xF0, 0x0F, 0x00, 0x0F,
  0x07, 0x80, 0x78, 0x00, 0xF8, 0x3E, 0x07, 0xC0, 0x07, 0xC1, 0xF0, 0x3C,
  0x00, 0x3E, 0x0F, 0x83, 0xE0, 0x01, 0xF0, 0x7C, 0x1E, 0x00, 0x0F, 0x83,
  0xE1, 0xF0, 0x00, 0x7C, 0x1F, 0x0F, 0x00, 0x03, 0xE0, 0xF8, 0x78, 0x00,
  0x1F, 0x07, 0xC7, 0xC0, 0x00, 0xF8, 0x3E, 0x3C, 0x1F, 0x03, 0xC1, 0xE3,
  0xE3, 0xFE, 0x1E, 0x0F, 0x1E, 0x3F, 0xF0, 0xF0, 0xF8, 0xF1, 0xFF, 0xC7,
  0xC7, 0x8F, 0x9F, 0x1E, 0x1F, 0xFC, 0x78, 0xF0, 0xF8, 0x7F, 0xC7, 0xC7,
  0x83, 0xC1, 0xFC, 0x3C, 0x7C, 0x1E, 0x07, 0x83, 0xE3, 0xE0, 0xF0, 0x00,
  0x1E, 0x1F, 0x07, 0xC0, 0x00, 0xF0, 0xF8, 0x3E, 0x00, 0x0F, 0x87, 0x81,
  0xF0, 0x00, 0x78, 0x3C, 0x0F, 0x80, 0x07, 0xC1, 0xE0, 0x7C, 0x00, 0x3C,
  0x0F, 0x83, 0xE0, 0x03, 0xE0, 0x7C, 0x1F, 0x00, 0x1F, 0x03, 0xE0, 0xF0,
  0x00, 0xF0, 0x0F, 0x07, 0x80, 0x0F, 0x80, 0x78, 0x3C, 0x00, 0x78, 0x03,
  0xE3, 0xE0, 0x07, 0xC0, 0x0F, 0xBE, 0x00, 0x3C, 0x00, 0x7F, 0xF0, 0x01,
  0xE0, 0x01, 0xFF, 0x00, 0x1F, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x7E,
  0x0F, 0x80, 0x03, 0xE0, 0x7C, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0xF8, 0x1F,
  0x00, 0x07, 0xC0, 0xF8, 0x00, 0x3F, 0x07, 0xC0, 0x01, 0xF8, 0x7E, 0x00,
  0x07, 0xC3, 0xE0, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0xC0, 0x3F, 0x0F, 0xFF, 0x01, 0xF8, 0xFE, 0xFC, 0x0F,
  0xCF, 0xE7, 0xF0, 0x7C, 0x7E, 0x1F, 0x87, 0xE7, 0xE0, 0x7E, 0x3F, 0x3F,
  0x01, 0xF9, 0xF1, 0xF8, 0x0F, 0xFF, 0x8F, 0xC0, 0x3F, 0xFC, 0x7C, 0x00,
  0xFF, 0xC3, 0xF0, 0x03, 0xFE, 0x1F, 0x80, 0x1F, 0xE0, 0xFC, 0x00, 0x7F,
  0x07, 0xF0, 0x07, 0xF8, 0x1F, 0x80, 0x7F, 0xE0, 0xFF, 0x9F, 0xFF, 0x83,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xF3, 0xF0, 0x7F, 0xFE, 0x0F, 0xC0, 0xFF,
  0xC0, 0x7F, 0x00, 0x30, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFD, 0xF7, 0xDF,
  0x7D, 0xE7, 0x9E, 0x79, 0xE0, 0x01, 0xF0, 0x3E, 0x07, 0xC0, 0x7C, 0x0F,
  0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x7C,
  0x07, 0xC0, 0xFC, 0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7E,
  0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x07,
  0xC0, 0x3E, 0x01, 0xE0, 0x1F, 0xFC, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x01,
  0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x07,
  0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0xFC, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0,
  0x7C, 0x07, 0xE0, 0x3E, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x01, 0x03, 0xC0, 0xCF, 0x8E, 0x3E, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0x00,
  0x1F, 0x7C, 0x00, 0xFB, 0xE0, 0x0F, 0x8F, 0x80, 0xFC, 0x7E, 0x0F, 0xC1,
  0xF8, 0x1E, 0x0F, 0x00, 0x60, 0x20, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3F, 0x3F,
  0x3F, 0x3F, 0x3E, 0x3E, 0x7E, 0x7C, 0x7C, 0x7C, 0x78, 0xF8, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3C, 0xFF, 0xFF, 0xFF,
  0xEF, 0xDF, 0x08, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01,
  0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xF0, 0x1F,
  0xFF, 0xE0, 0x7E, 0x1F, 0x83, 0xF0, 0x3F, 0x0F, 0xC0, 0x7C, 0x3E, 0x01,
  0xF9, 0xF8, 0x07, 0xE7, 0xE0, 0x0F, 0x9F, 0x00, 0x3E, 0x7C, 0x00, 0xF9,
  0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x0F, 0xDF, 0x00, 0x3F, 0x7C, 0x00, 0xF9, 0xF0, 0x03, 0xE7, 0xE0,
  0x0F, 0x9F, 0x80, 0x7E, 0x3E, 0x01, 0xF8, 0xFC, 0x07, 0xC3, 0xF0, 0x3F,
  0x07, 0xF3, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x7F, 0xF8, 0x00,
  0x7F, 0xC0, 0x00, 0x20, 0x00, 0x00, 0x7C, 0x03, 0xF0, 0x3F, 0xC1, 0xFF,
  0x0F, 0xFC, 0x7F, 0xF3, 0xFF, 0xDF, 0xDF, 0xFE, 0x7F, 0xF1, 0xF7, 0x07,
  0xC8, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xE1, 0xF8, 0x3F, 0xC3, 0x80, 0x3F, 0x0C, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFC, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF1, 0xF0, 0x1F, 0xC3, 0x00, 0x3F, 0x08,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xE0, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x00, 0x07,
  0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xEC, 0x00, 0x3F, 0xBF, 0x07, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x00, 0x40, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3D, 0xF0, 0x00, 0x3D, 0xF0,
  0x00, 0x79, 0xF0, 0x00, 0xF9, 0xF0, 0x00, 0xF1, 0xF0, 0x01, 0xF1, 0xF0,
  0x01, 0xE1, 0xF0, 0x03, 0xE1, 0xF0, 0x03, 0xC1, 0xF0, 0x07, 0xC1, 0xF0,
  0x07, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x3E, 0x01, 0xF0, 0x3E, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x7C, 0x01, 0xF0,
  0xF8, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x3F, 0xFF, 0xE3, 0xFF, 0xFF, 0x1F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x78, 0xFF, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x80, 0x07, 0xF6, 0x00, 0x7F, 0x3E,
  0x0F, 0xF9, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x7F, 0xFF, 0x81, 0xFF, 0xF0,
  0x00, 0x18, 0x00, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0x00,
  0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0xC0, 0x40, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x0F, 0xC0, 0x7C,
  0xFF, 0xC1, 0xF7, 0xFF, 0x87, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0x83,
  0xFB, 0xFC, 0x07, 0xEF, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xDF, 0x00, 0x1F, 0x7C, 0x00, 0x7D, 0xF0,
  0x03, 0xF7, 0xC0, 0x0F, 0xDF, 0x80, 0x3F, 0x3E, 0x00, 0xF8, 0xFC, 0x07,
  0xE3, 0xF8, 0x1F, 0x87, 0xF1, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80,
  0x7F, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x10, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x0F,
  0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFC, 0x0F,
  0xE7, 0xE0, 0x1F, 0x9F, 0x80, 0x3E, 0x7C, 0x00, 0xF9, 0xF0, 0x03, 0xE7,
  0xC0, 0x0F, 0x9F, 0x80, 0x3E, 0x7E, 0x01, 0xF8, 0xF8, 0x07, 0xE3, 0xF0,
  0x3F, 0x07, 0xE1, 0xF8, 0x0F, 0xEF, 0xE0, 0x3F, 0xFF, 0x00, 0x7F, 0xF0,
  0x00, 0x7F, 0x80, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFC, 0xFE, 0x0F,
  0xE1, 0xFC, 0x7E, 0x03, 0xF9, 0xF8, 0x07, 0xE7, 0xC0, 0x0F, 0xFF, 0x00,
  0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F,
  0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xF7, 0xE0, 0x1F, 0x9F, 0xC0, 0xFE, 0x3F,
  0xFF, 0xF0, 0x7F, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x10,
  0x00, 0x00, 0x78, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xF0,
  0x3F, 0xFF, 0xE0, 0xFE, 0x1F, 0x87, 0xE0, 0x3F, 0x1F, 0x80, 0x7C, 0x7C,
  0x01, 0xFB, 0xF0, 0x07, 0xEF, 0xC0, 0x0F, 0xBF, 0x00, 0x3E, 0xFC, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xF0, 0x03, 0xF7, 0xC0, 0x1F, 0xDF, 0x80, 0xFF, 0x7F, 0x07, 0xFC, 0xFF,
  0xFD, 0xF1, 0xFF, 0xFF, 0xC7, 0xFF, 0xBF, 0x07, 0xFC, 0xF8, 0x07, 0xC3,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x01,
  0xFC, 0x08, 0x1F, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xFC, 0x03, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0x02, 0x00, 0x00, 0x3C, 0xFF, 0xFF, 0xFF, 0xEF, 0xDF,
  0x9C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x7F, 0xFF, 0xFF, 0xF7, 0xEF, 0x84, 0x00, 0x1E, 0x3F,
  0x7F, 0x7F, 0x7F, 0x3F, 0x3F, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x3F,
  0x3F, 0x3F, 0x3E, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0xF8, 0xF8, 0xF0, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0x00, 0x03,
  0xFC, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x10, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x7C,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x0F, 0xFF,
  0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0xFF, 0xFF, 0x9E, 0x0F, 0xE6, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x1F, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F,
  0xE0, 0x7F, 0x80, 0x07, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x0F, 0x80,
  0x7E, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x78, 0x00, 0x00, 0x1E, 0x1F, 0x00, 0xFF, 0x03, 0xE3, 0xC0, 0x7F,
  0xF8, 0x3C, 0xF8, 0x1F, 0xFF, 0x07, 0x9E, 0x07, 0xFF, 0xE0, 0xFB, 0xC0,
  0xF8, 0x3C, 0x1F, 0xF8, 0x3E, 0x07, 0x81, 0xFF, 0x07, 0x80, 0xF0, 0x3F,
  0xC0, 0xF0, 0x1E, 0x07, 0xF8, 0x3E, 0x07, 0xC0, 0xFF, 0x07, 0xC0, 0xF8,
  0x1F, 0xE0, 0xF0, 0x1F, 0x03, 0xFC, 0x1E, 0x03, 0xE0, 0x7F, 0x83, 0xC0,
  0x7C, 0x0F, 0xF0, 0x78, 0x0F, 0x81, 0xFE, 0x0F, 0x01, 0xF0, 0x7F, 0xC1,
  0xF0, 0x3E, 0x0F, 0x78, 0x3E, 0x0F, 0xC1, 0xEF, 0x03, 0xC1, 0xF8, 0x7D,
  0xE0, 0x7C, 0x7F, 0x8F, 0x3E, 0x0F, 0xFE, 0xFF, 0xE7, 0xC0, 0xFF, 0xCF,
  0xF8, 0x78, 0x0F, 0xF0, 0xFE, 0x0F, 0x80, 0x78, 0x0F, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x06, 0x00,
  0x07, 0xFC, 0x07, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x01, 0xF7, 0xC0, 0x00,
  0x0F, 0xBE, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x3E,
  0x3E, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0xFC, 0x7E,
  0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xF0, 0x7E, 0x00,
  0x1F, 0x03, 0xF0, 0x00, 0xF8, 0x0F, 0x80, 0x0F, 0xC0, 0x7C, 0x00, 0x7E,
  0x03, 0xF0, 0x03, 0xE0, 0x1F, 0x80, 0x1F, 0x00, 0x7C, 0x01, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0x81, 0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0xFC,
  0x00, 0x1F, 0x87, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x07, 0xE1, 0xF8, 0x00,
  0x3F, 0x1F, 0x80, 0x00, 0xFC, 0xFC, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x3F,
  0x7E, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xE0, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xCF, 0xC1, 0xFF, 0x9F, 0x80,
  0x3F, 0xBF, 0x00, 0x3F, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0x7D, 0xF8, 0x00,
  0xFB, 0xF0, 0x01, 0xF7, 0xE0, 0x03, 0xEF, 0xC0, 0x0F, 0xDF, 0x80, 0x1F,
  0xBF, 0x00, 0x7E, 0x7E, 0x01, 0xFC, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0x83,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x9F, 0x80, 0x7F, 0xBF,
  0x00, 0x3F, 0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xFB, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xFF, 0x03, 0xFF,
  0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xF8, 0x3C, 0x1F, 0xE0, 0x04, 0x1F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x04, 0x0F, 0xFE,
  0xFC, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x7F,
  0xF8, 0x00, 0x02, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x3F, 0x00, 0xFF, 0x0F,
  0xC0, 0x0F, 0xE3, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x7F, 0x3F, 0x00, 0x0F,
  0xCF, 0xC0, 0x03, 0xFB, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0xBF, 0x00,
  0x07, 0xEF, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0x3E, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFB, 0xF0, 0x00, 0x7E, 0xFC, 0x00,
  0x1F, 0xBF, 0x00, 0x07, 0xEF, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0x7E, 0xFC,
  0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xCF, 0xC0, 0x07, 0xE3, 0xF0, 0x03, 0xF8,
  0xFC, 0x01, 0xFC, 0x3F, 0x01, 0xFF, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC,
  0x1F, 0xF8, 0x1F, 0x03, 0xF8, 0x00, 0x60, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0,
  0x00, 0x1F, 0xBE, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x0F,
  0xDF, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x3F, 0x3F, 0x80, 0x07, 0xE3, 0xF8,
  0x00, 0xFC, 0x7F, 0x80, 0x1F, 0x87, 0xFE, 0x3F, 0xF0, 0x7F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0x01,
  0x00, 0x00, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF,
  0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F,
  0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00,
  0x3F, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xF0,
  0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF,
  0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07,
  0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00,
  0x7F, 0xF0, 0x00, 0x3E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xC0, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xE8, 0x7F, 0x7F, 0xFB, 0xFF,
  0x9F, 0xF8, 0xFF, 0x83, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x3F,
  0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0x1F, 0x87, 0xE0, 0x1F,
  0x83, 0xF0, 0x0F, 0xC1, 0xF8, 0x0F, 0xC0, 0xFC, 0x0F, 0xE0, 0x7E, 0x07,
  0xE0, 0x3F, 0x07, 0xE0, 0x1F, 0x87, 0xF0, 0x0F, 0xC3, 0xF0, 0x07, 0xE3,
  0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xF9, 0xF8, 0x00, 0xFD, 0xF8, 0x00, 0x7E,
  0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x07,
  0xFF, 0xF0, 0x03, 0xFC, 0xFC, 0x01, 0xFC, 0x7E, 0x00, 0xFC, 0x1F, 0x80,
  0x7E, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0x7E,
  0x07, 0xE0, 0x3F, 0x83, 0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xF0, 0xFC, 0x01,
  0xF8, 0x7E, 0x00, 0xFE, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x1F, 0xCF, 0xC0,
  0x07, 0xE7, 0xE0, 0x03, 0xFB, 0xF0, 0x00, 0xFE, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xDF, 0x00, 0x03, 0xFF, 0xFB,
  0xE0, 0x00, 0x7B, 0xFF, 0x7C, 0x00, 0x1F, 0x7F, 0xE7, 0x80, 0x03, 0xEF,
  0xFC, 0xF8, 0x00, 0x79, 0xFF, 0x9F, 0x00, 0x1F, 0x3F, 0xFB, 0xE0, 0x03,
  0xE7, 0xFF, 0x3E, 0x00, 0x78, 0xFF, 0xE7, 0xC0, 0x1F, 0x1F, 0xFC, 0xF8,
  0x03, 0xE3, 0xFF, 0x8F, 0x80, 0x7C, 0x7F, 0xF1, 0xF0, 0x1F, 0x0F, 0xFE,
  0x3E, 0x03, 0xE1, 0xFF, 0xC3, 0xC0, 0x7C, 0x3F, 0xF8, 0x7C, 0x0F, 0x07,
  0xFF, 0x0F, 0x83, 0xE0, 0xFF, 0xE1, 0xF0, 0x7C, 0x1F, 0xFC, 0x1F, 0x0F,
  0x03, 0xFF, 0x83, 0xE3, 0xE0, 0x7F, 0xF0, 0x7C, 0x7C, 0x0F, 0xFE, 0x07,
  0xCF, 0x01, 0xFF, 0xC0, 0xFB, 0xE0, 0x3F, 0xF8, 0x1F, 0x7C, 0x07, 0xFF,
  0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xE0, 0x1F, 0xFC, 0x07, 0xFC, 0x03,
  0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xE0, 0x0F, 0xFE, 0x01, 0xFC,
  0x01, 0xFF, 0xC0, 0x3F, 0x80, 0x3F, 0xF8, 0x03, 0xE0, 0x07, 0xFF, 0x00,
  0x7C, 0x00, 0xF8, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00,
  0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFB, 0xE0, 0x03, 0xFF, 0x7E, 0x00,
  0x7F, 0xE7, 0xC0, 0x0F, 0xFC, 0xFC, 0x01, 0xFF, 0x8F, 0x80, 0x3F, 0xF1,
  0xF8, 0x07, 0xFF, 0x1F, 0x00, 0xFF, 0xE3, 0xF0, 0x1F, 0xFC, 0x3E, 0x03,
  0xFF, 0x87, 0xE0, 0x7F, 0xF0, 0xFC, 0x0F, 0xFE, 0x0F, 0xC1, 0xFF, 0xC1,
  0xF8, 0x3F, 0xF8, 0x1F, 0x87, 0xFF, 0x03, 0xF0, 0xFF, 0xE0, 0x3F, 0x1F,
  0xFC, 0x07, 0xE3, 0xFF, 0x80, 0x7E, 0x7F, 0xF0, 0x0F, 0xCF, 0xFE, 0x00,
  0xFD, 0xFF, 0xC0, 0x1F, 0xBF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xF8, 0x3F,
  0xC0, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xE3,
  0xF8, 0x00, 0x3F, 0x1F, 0x80, 0x01, 0xF8, 0xFC, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0x3F, 0x7E, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x0F, 0xDF, 0x80, 0x00,
  0x3E, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x0F, 0xBF, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x3F,
  0x3F, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0xFC, 0x3F,
  0x00, 0x0F, 0xE1, 0xFC, 0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xF0, 0x1F, 0xFB,
  0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x02, 0x00, 0x00, 0xFF, 0xFE, 0x03, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF3, 0xF0, 0x1F,
  0xEF, 0xC0, 0x3F, 0xBF, 0x00, 0x7E, 0xFC, 0x00, 0xFB, 0xF0, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xBF, 0x00, 0x7E, 0xFC, 0x01, 0xFB, 0xF0, 0x0F, 0xEF, 0xC0, 0x7F,
  0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x3F,
  0xFF, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF0, 0x0F, 0xF8, 0x3F, 0xC0, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x01,
  0xF8, 0x3F, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x3F, 0x1F, 0x80, 0x01, 0xFC,
  0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x3F, 0x7E, 0x00, 0x01, 0xFB, 0xF0,
  0x00, 0x0F, 0xDF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0xFD, 0xF8, 0x00,
  0x07, 0xE7, 0xE0, 0x00, 0x3F, 0x3F, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x1F,
  0x87, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0xFE, 0x07,
  0xF0, 0x0F, 0xF0, 0x1F, 0xFB, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFC, 0x07, 0xF8,
  0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC,
  0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC,
  0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x03, 0xF8, 0xFC, 0x07, 0xF0,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x00, 0xFC, 0x1F, 0x00, 0xFC, 0x1F, 0x80, 0xFC, 0x0F, 0x80,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0xFC, 0x07, 0xE0,
  0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8,
  0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E,
  0xFC, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0x03, 0xFF, 0xFE, 0x3F,
  0xFF, 0xE3, 0xFF, 0xFF, 0x1F, 0xE1, 0xF1, 0xFC, 0x01, 0x8F, 0xC0, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x80, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xBC, 0x01, 0xFD, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xE3, 0xFF, 0xFE, 0x07, 0xFF, 0xC0,
  0x01, 0x40, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF,
  0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F,
  0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01,
  0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00,
  0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC,
  0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7C, 0xFC, 0x00, 0x7E,
  0x7E, 0x00, 0x3F, 0x3F, 0x80, 0x3F, 0x0F, 0xF9, 0xFF, 0x83, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x00, 0x10,
  0x00, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x07, 0xE7,
  0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x7C, 0x3E, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0xF8,
  0x1F, 0x00, 0x1F, 0x81, 0xF8, 0x01, 0xF8, 0x0F, 0x80, 0x1F, 0x00, 0xF8,
  0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x3E,
  0x00, 0x7C, 0x03, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xC0, 0x03,
  0xE0, 0x7C, 0x00, 0x3E, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x0F,
  0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x1F, 0x80, 0x01, 0xF9, 0xF0, 0x00,
  0x0F, 0x9F, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0xFB,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xFF,
  0x80, 0x03, 0xF0, 0x00, 0xFD, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xBF, 0x00,
  0x1F, 0xC0, 0x03, 0xF7, 0xE0, 0x03, 0xF8, 0x00, 0x7C, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0x8F, 0x80, 0x0F, 0xF0, 0x03, 0xF1, 0xF0, 0x03, 0xFE, 0x00,
  0x7E, 0x3F, 0x00, 0x7F, 0xC0, 0x0F, 0x87, 0xE0, 0x0F, 0x7C, 0x01, 0xF0,
  0xFC, 0x01, 0xEF, 0x80, 0x7E, 0x0F, 0x80, 0x7D, 0xF0, 0x0F, 0xC1, 0xF0,
  0x0F, 0xBE, 0x01, 0xF8, 0x3F, 0x01, 0xF3, 0xC0, 0x3E, 0x07, 0xE0, 0x3E,
  0x7C, 0x07, 0xC0, 0x7C, 0x07, 0x8F, 0x81, 0xF8, 0x0F, 0x81, 0xF1, 0xF0,
  0x3F, 0x01, 0xF0, 0x3E, 0x1E, 0x07, 0xE0, 0x3F, 0x07, 0xC3, 0xE0, 0xF8,
  0x07, 0xE0, 0xF0, 0x7C, 0x1F, 0x00, 0x7C, 0x3E, 0x0F, 0x87, 0xE0, 0x0F,
  0x87, 0xC1, 0xF0, 0xFC, 0x01, 0xF8, 0xF8, 0x1E, 0x1F, 0x00, 0x3F, 0x1F,
  0x03, 0xE3, 0xE0, 0x03, 0xE3, 0xC0, 0x7C, 0x7C, 0x00, 0x7C, 0xF8, 0x0F,
  0x9F, 0x80, 0x0F, 0x9F, 0x00, 0xF3, 0xF0, 0x01, 0xF3, 0xE0, 0x1E, 0x7C,
  0x00, 0x3F, 0x78, 0x03, 0xEF, 0x80, 0x03, 0xEF, 0x00, 0x7D, 0xF0, 0x00,
  0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xE3, 0xF0, 0x03, 0xF0, 0x7E, 0x00,
  0xFC, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0x1F,
  0x03, 0xF0, 0x07, 0xE0, 0xF8, 0x00, 0xF8, 0x7E, 0x00, 0x3F, 0x1F, 0x00,
  0x07, 0xCF, 0xC0, 0x01, 0xFB, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFB, 0xE0, 0x00, 0x7C, 0xFC,
  0x00, 0x3F, 0x1F, 0x00, 0x0F, 0x87, 0xE0, 0x07, 0xE1, 0xF8, 0x01, 0xF8,
  0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x1F, 0x80, 0x7E, 0x07,
  0xE0, 0x0F, 0x83, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x1F,
  0x9F, 0x80, 0x07, 0xEF, 0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0xDF, 0x80,
  0x07, 0xE7, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x0F,
  0xC0, 0x0F, 0x81, 0xF8, 0x07, 0xE0, 0x7E, 0x01, 0xF0, 0x0F, 0x80, 0xFC,
  0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x0F, 0x80, 0x1F, 0x07, 0xE0, 0x07, 0xE1,
  0xF0, 0x00, 0xF8, 0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x07, 0xCF, 0x80, 0x01,
  0xF7, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x1C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xDE, 0x00, 0x03, 0xEF, 0x80,
  0x01, 0xF3, 0xC0, 0x01, 0xF1, 0xF0, 0x00, 0xF8, 0x78, 0x00, 0xF8, 0x3E,
  0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1E, 0x00,
  0xF8, 0x1F, 0x00, 0x7C, 0x0F, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x87, 0xC0,
  0x03, 0xE7, 0xC0, 0x01, 0xF3, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x3E, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x03, 0xFF,
  0x00, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x1F, 0x0F, 0xE0, 0x80,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0xFF, 0xF0, 0x7F, 0xFF, 0x1F, 0xFF, 0xF3,
  0xFF, 0xFF, 0x7F, 0x01, 0xF7, 0xE0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F,
  0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x07,
  0xF7, 0xE0, 0xFF, 0x7F, 0xFE, 0xF3, 0xFF, 0xCF, 0x3F, 0xF8, 0xF0, 0xFF,
  0x0F, 0x01, 0x80, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x7F, 0x03, 0xE7, 0xFF, 0x0F, 0xBF, 0xFE, 0x3E, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF3, 0xFC, 0x0F, 0xCF, 0xE0, 0x1F, 0xBF, 0x00, 0x7E, 0xFC,
  0x00, 0xFB, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0,
  0x03, 0xEF, 0xC0, 0x1F, 0xBF, 0x80, 0x7E, 0xFE, 0x03, 0xFB, 0xFE, 0x1F,
  0xCF, 0xFF, 0xFF, 0x3E, 0xFF, 0xF8, 0xF1, 0xFF, 0xC3, 0xC3, 0xFE, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0xFC, 0x1F, 0xFF, 0x07, 0xFF,
  0xE1, 0xFF, 0xFC, 0x7F, 0x01, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x3F, 0x80, 0x43, 0xF8, 0x38, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0xFC,
  0x03, 0xFF, 0x00, 0x04, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x87, 0xE0, 0xFF, 0xCF, 0xC3, 0xFF, 0xDF,
  0x8F, 0xFF, 0xFF, 0x1F, 0xEF, 0xFE, 0x7F, 0x03, 0xFC, 0xFC, 0x03, 0xFB,
  0xF0, 0x07, 0xF7, 0xE0, 0x07, 0xEF, 0xC0, 0x0F, 0xDF, 0x00, 0x1F, 0xBE,
  0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xDF, 0x00, 0x1F, 0xBE, 0x00,
  0x3F, 0x7C, 0x00, 0x7E, 0xFC, 0x00, 0xFD, 0xF8, 0x03, 0xFB, 0xF0, 0x07,
  0xF3, 0xF0, 0x1F, 0xE7, 0xF0, 0x7F, 0xC7, 0xFF, 0xEF, 0x87, 0xFF, 0x9F,
  0x0F, 0xFF, 0x3E, 0x07, 0xF8, 0x7C, 0x00, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x0F, 0xFE, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x1F, 0xC7, 0xF0, 0xFC,
  0x07, 0xC3, 0xE0, 0x1F, 0x8F, 0x80, 0x3E, 0x7E, 0x00, 0xF9, 0xF0, 0x03,
  0xE7, 0xC0, 0x0F, 0xDF, 0x00, 0x1F, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x18, 0x7F, 0x01, 0xE1, 0xFF, 0xFF, 0x83,
  0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x00, 0x80, 0x00, 0x00,
  0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xF0, 0x7E, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x01, 0xFF, 0xE3, 0xFF, 0xF3, 0xFF, 0xF9, 0xFF, 0xFC, 0xFF, 0xFE, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x00, 0x01, 0xFC, 0x3E, 0x0F, 0xFC, 0x7C, 0x3F,
  0xFC, 0xF8, 0xFF, 0xFD, 0xF1, 0xFE, 0xFF, 0xE7, 0xF0, 0x3F, 0xCF, 0xC0,
  0x3F, 0xBF, 0x00, 0x7F, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0xFD, 0xF0, 0x01,
  0xFB, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFD, 0xF0, 0x01, 0xFB,
  0xE0, 0x03, 0xF7, 0xC0, 0x07, 0xEF, 0xC0, 0x0F, 0xDF, 0x80, 0x3F, 0xBF,
  0x00, 0x7F, 0x3F, 0x01, 0xFE, 0x7F, 0x87, 0xFC, 0x7F, 0xFF, 0xF8, 0x7F,
  0xFB, 0xF0, 0xFF, 0xE7, 0xE0, 0x7F, 0x8F, 0xC0, 0x10, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xE2, 0x00, 0x0F, 0xC7, 0x00, 0x3F, 0x0F, 0xF7, 0xFE, 0x1F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x87, 0xF0, 0x7C, 0xFF, 0xE3, 0xEF, 0xFF,
  0x9F, 0x7F, 0xFC, 0xFF, 0xFF, 0xF7, 0xF8, 0x1F, 0xBF, 0x80, 0x7D, 0xF8,
  0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F,
  0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80,
  0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00,
  0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xC0,
  0x38, 0xFB, 0xF7, 0xFF, 0xCF, 0x8E, 0x00, 0x00, 0x00, 0x03, 0xE7, 0xCF,
  0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3,
  0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C,
  0x01, 0xC0, 0x3E, 0x07, 0xE0, 0x7F, 0x07, 0xE0, 0x3E, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7E,
  0x07, 0xEF, 0xFE, 0xFF, 0xCF, 0xFC, 0xFF, 0x8F, 0xE0, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x1F, 0xFC, 0x01, 0xFB, 0xE0, 0x1F,
  0x9F, 0x00, 0xF8, 0xF8, 0x0F, 0xC7, 0xC0, 0xFC, 0x3E, 0x0F, 0xC1, 0xF0,
  0x7E, 0x0F, 0x87, 0xE0, 0x7C, 0x7E, 0x03, 0xE3, 0xE0, 0x1F, 0x3F, 0x00,
  0xFB, 0xF0, 0x07, 0xDF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0x7F, 0x3F, 0x03, 0xF1, 0xF8, 0x1F, 0x07, 0xE0, 0xF8, 0x3F, 0x07,
  0xC0, 0xFC, 0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x8F, 0x80, 0x7C, 0x7C, 0x03,
  0xF3, 0xE0, 0x0F, 0xDF, 0x00, 0x7E, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xF0, 0x7F, 0x01, 0xFE, 0x1E, 0x3F, 0xF0, 0x7F, 0xE3,
  0xCF, 0xFF, 0x1F, 0xFE, 0x7F, 0xFF, 0xF7, 0xFF, 0xEF, 0xFD, 0xFF, 0xFF,
  0xFD, 0xFE, 0x0F, 0xF8, 0x1F, 0xBF, 0x80, 0xFF, 0x01, 0xFF, 0xE0, 0x1F,
  0xC0, 0x3F, 0xFC, 0x03, 0xF8, 0x07, 0xFF, 0x80, 0x3E, 0x00, 0x7F, 0xE0,
  0x07, 0xC0, 0x0F, 0xFC, 0x00, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0x00, 0x3F,
  0xF0, 0x03, 0xE0, 0x07, 0xFE, 0x00, 0x7C, 0x00, 0xFF, 0xC0, 0x0F, 0x80,
  0x1F, 0xF8, 0x01, 0xF0, 0x03, 0xFF, 0x00, 0x3E, 0x00, 0x7F, 0xE0, 0x07,
  0xC0, 0x0F, 0xFC, 0x00, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0x00, 0x3F, 0xF0,
  0x03, 0xE0, 0x07, 0xFE, 0x00, 0x7C, 0x00, 0xFF, 0xC0, 0x0F, 0x80, 0x1F,
  0xF8, 0x01, 0xF0, 0x03, 0xFF, 0x00, 0x3E, 0x00, 0x7F, 0xE0, 0x07, 0xC0,
  0x0F, 0xFC, 0x00, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0x00, 0x3F, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0xF0, 0x7F, 0x07, 0x8F, 0xFE, 0x3C, 0xFF, 0xF9, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0x7F, 0x81, 0xFB, 0xF8, 0x0F, 0xDF, 0x80, 0x3F,
  0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80,
  0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00,
  0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFC, 0x00, 0xFF,
  0x00, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x81, 0xFE, 0x7F,
  0x87, 0xF0, 0x3F, 0x0F, 0xC0, 0x3F, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0x7E,
  0xFC, 0x00, 0xFD, 0xF0, 0x01, 0xFB, 0xE0, 0x01, 0xF7, 0xC0, 0x03, 0xFF,
  0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8,
  0x00, 0x7D, 0xF0, 0x00, 0xFB, 0xE0, 0x03, 0xF7, 0xC0, 0x07, 0xEF, 0xC0,
  0x0F, 0xDF, 0x80, 0x1F, 0x1F, 0x80, 0x7E, 0x3F, 0x01, 0xF8, 0x3F, 0x87,
  0xF0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xF0,
  0x00, 0x0C, 0x00, 0x00, 0xF0, 0x7F, 0x03, 0xC7, 0xFF, 0x0F, 0xBF, 0xFE,
  0x3E, 0xFF, 0xF8, 0xFF, 0xCF, 0xF3, 0xFC, 0x0F, 0xCF, 0xE0, 0x1F, 0xBF,
  0x00, 0x7E, 0xFC, 0x00, 0xFB, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F,
  0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xEF, 0xC0, 0x1F, 0xBF, 0x80, 0x7E, 0xFE, 0x03,
  0xFB, 0xFE, 0x1F, 0xCF, 0xFF, 0xFF, 0x3E, 0xFF, 0xF8, 0xF9, 0xFF, 0xC3,
  0xE3, 0xFE, 0x0F, 0x81, 0xC0, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x01, 0xFC, 0x3E, 0x0F, 0xFC, 0x7C, 0x3F, 0xFC, 0xF8,
  0xFF, 0xFD, 0xF1, 0xFE, 0xFF, 0xE7, 0xE0, 0x3F, 0xCF, 0xC0, 0x3F, 0xBF,
  0x00, 0x7F, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0xFD, 0xF0, 0x01, 0xFB, 0xE0,
  0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFD, 0xF0, 0x01, 0xFB, 0xE0, 0x03,
  0xF7, 0xC0, 0x07, 0xEF, 0xC0, 0x0F, 0xDF, 0x80, 0x3F, 0xBF, 0x00, 0x7F,
  0x3F, 0x01, 0xFE, 0x7F, 0x87, 0xFC, 0x7F, 0xFF, 0xF8, 0x7F, 0xFB, 0xF0,
  0x7F, 0xE7, 0xE0, 0x7F, 0x8F, 0xC0, 0x10, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0xF0, 0x7F, 0xE1, 0xFB, 0xC7,
  0xF7, 0x9F, 0xEF, 0xFF, 0xDF, 0xF8, 0xBF, 0xC0, 0x7F, 0x00, 0xFE, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x00, 0x07, 0xFC, 0x07, 0xFF, 0xE3, 0xFF, 0xF9, 0xFF,
  0xFE, 0x7F, 0x0F, 0x3F, 0x00, 0xCF, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x01,
  0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xF8, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0xC0, 0x1F,
  0xBC, 0x0F, 0xEF, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFE, 0x0F, 0xFE, 0x00,
  0x10, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x07, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xE1, 0x0F, 0xFE, 0x1F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF0, 0x02, 0x00,
  0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80,
  0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00,
  0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x0F,
  0xFF, 0x80, 0x7F, 0xFC, 0x07, 0xFF, 0xF8, 0xFF, 0xDF, 0xFF, 0xBE, 0xFF,
  0xFD, 0xF3, 0xFF, 0xCF, 0x87, 0xF8, 0x7C, 0x04, 0x00, 0x00, 0xFC, 0x00,
  0x3F, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00,
  0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x1F, 0x00,
  0xF8, 0x1F, 0x00, 0xF8, 0x1F, 0x01, 0xF8, 0x1F, 0x81, 0xF0, 0x0F, 0x81,
  0xF0, 0x0F, 0x83, 0xF0, 0x0F, 0x83, 0xE0, 0x07, 0xC3, 0xE0, 0x07, 0xC3,
  0xE0, 0x07, 0xC7, 0xE0, 0x03, 0xE7, 0xC0, 0x03, 0xE7, 0xC0, 0x03, 0xE7,
  0xC0, 0x03, 0xEF, 0x80, 0x01, 0xEF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFB, 0xE0, 0x0F, 0xE0,
  0x0F, 0xDF, 0x00, 0x7F, 0x00, 0x7C, 0xFC, 0x03, 0xF8, 0x03, 0xE7, 0xE0,
  0x1F, 0xE0, 0x1F, 0x1F, 0x00, 0xFF, 0x01, 0xF8, 0xF8, 0x0F, 0xF8, 0x0F,
  0x87, 0xE0, 0x7B, 0xC0, 0x7C, 0x3F, 0x03, 0xDF, 0x03, 0xE0, 0xF8, 0x1E,
  0xF8, 0x1F, 0x07, 0xC1, 0xF3, 0xC1, 0xF8, 0x3E, 0x0F, 0x9E, 0x0F, 0x81,
  0xF8, 0x78, 0xF8, 0x7C, 0x07, 0xC3, 0xC7, 0xC3, 0xE0, 0x3E, 0x3E, 0x3E,
  0x3F, 0x01, 0xF1, 0xF0, 0xF1, 0xF0, 0x0F, 0x8F, 0x87, 0x8F, 0x80, 0x3E,
  0x78, 0x3E, 0x7C, 0x01, 0xF3, 0xC1, 0xF3, 0xE0, 0x0F, 0xBE, 0x0F, 0xBE,
  0x00, 0x7D, 0xF0, 0x3D, 0xF0, 0x03, 0xEF, 0x01, 0xEF, 0x80, 0x0F, 0x78,
  0x0F, 0x7C, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x03, 0xFE, 0x01, 0xFE, 0x00,
  0x1F, 0xF0, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0xFC,
  0x00, 0xFD, 0xF8, 0x07, 0xE7, 0xE0, 0x1F, 0x8F, 0xC0, 0xFC, 0x3F, 0x03,
  0xF0, 0x7C, 0x1F, 0x81, 0xF8, 0x7E, 0x03, 0xE3, 0xF0, 0x0F, 0xCF, 0xC0,
  0x1F, 0x3E, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xCF, 0x80, 0x3F, 0x3F, 0x00,
  0xF8, 0x7C, 0x07, 0xE1, 0xF8, 0x1F, 0x03, 0xE0, 0xFC, 0x0F, 0xC7, 0xE0,
  0x1F, 0x1F, 0x80, 0x7E, 0xFC, 0x00, 0xFB, 0xF0, 0x03, 0xF0, 0xFC, 0x00,
  0x3F, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00,
  0x7C, 0x3E, 0x00, 0x7C, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x1F, 0x00,
  0xF8, 0x1F, 0x00, 0xF8, 0x1F, 0x81, 0xF8, 0x0F, 0x81, 0xF0, 0x0F, 0x81,
  0xF0, 0x0F, 0xC3, 0xF0, 0x07, 0xC3, 0xE0, 0x07, 0xC3, 0xE0, 0x07, 0xC3,
  0xE0, 0x03, 0xE7, 0xE0, 0x03, 0xE7, 0xC0, 0x03, 0xE7, 0xC0, 0x03, 0xE7,
  0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xFF, 0x9F, 0xFF, 0xE7,
  0xFF, 0xF9, 0xFF, 0xFE, 0x7F, 0xFF, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00,
  0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x03,
  0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0xFF, 0x80, 0xFF,
  0x00, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x1F, 0xC0, 0x07, 0xC0, 0x07,
  0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x00,
  0x7F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xC0,
  0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xFF, 0x00, 0xFF,
  0x00, 0x3F, 0x00, 0x7F, 0x01, 0xFF, 0x03, 0xF8, 0x03, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x0F, 0xC0, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x00, 0xFE, 0x00,
  0xF0, 0x00, 0x1F, 0xC0, 0x02, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xA0, 0x03, 0xFC, 0x00,
};

const GFXglyph NotoSans_Condensed_Medium55pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 7, 40, 14, 3, -39 },
  { 36, 16, 14, 22, 3, -39 },
  { 64, 27, 39, 29, 1, -39 },
  { 196, 21, 45, 26, 3, -42 },
  { 315, 37, 41, 41, 2, -40 },
  { 505, 29, 41, 31, 2, -40 },
  { 654, 6, 14, 12, 3, -39 },
  { 665, 12, 48, 17, 3, -39 },
  { 737, 13, 48, 17, 1, -39 },
  { 815, 21, 21, 25, 2, -42 },
  { 871, 22, 27, 26, 2, -33 },
  { 946, 8, 13, 13, 2, -6 },
  { 959, 13, 5, 16, 2, -17 },
  { 968, 7, 8, 14, 3, -7 },
  { 975, 19, 39, 21, 1, -39 },
  { 1068, 22, 41, 26, 2, -40 },
  { 1181, 14, 39, 26, 4, -39 },
  { 1250, 22, 40, 26, 2, -40 },
  { 1360, 22, 41, 26, 2, -40 },
  { 1473, 24, 39, 26, 1, -39 },
  { 1590, 21, 40, 26, 3, -39 },
  { 1695, 22, 41, 26, 2, -40 },
  { 1808, 22, 39, 26, 2, -39 },
  { 1916, 22, 41, 26, 2, -40 },
  { 2029, 22, 41, 26, 2, -40 },
  { 2142, 7, 31, 14, 3, -30 },
  { 2170, 8, 37, 14, 2, -30 },
  { 2207, 22, 26, 26, 2, -33 },
  { 2279, 22, 15, 26, 2, -27 },
  { 2321, 23, 26, 26, 2, -33 },
  { 2396, 18, 41, 20, 1, -40 },
  { 2489, 35, 45, 41, 3, -40 },
  { 2686, 29, 39, 29, 0, -39 },
  { 2828, 23, 39, 30, 4, -39 },
  { 2941, 24, 41, 28, 3, -40 },
  { 3064, 26, 39, 32, 4, -39 },
  { 3191, 18, 39, 25, 4, -39 },
  { 3279, 18, 39, 24, 4, -39 },
  { 3367, 27, 41, 33, 3, -40 },
  { 3506, 25, 39, 34, 4, -39 },
  { 3628, 13, 39, 17, 2, -39 },
  { 3692, 13, 50, 14, -3, -39 },
  { 3774, 25, 39, 28, 4, -39 },
  { 3896, 18, 39, 23, 4, -39 },
  { 3984, 35, 39, 43, 4, -39 },
  { 4155, 27, 39, 35, 4, -39 },
  { 4287, 29, 41, 35, 3, -40 },
  { 4436, 22, 39, 28, 4, -39 },
  { 4544, 29, 49, 35, 3, -40 },
  { 4722, 24, 39, 29, 4, -39 },
  { 4839, 21, 41, 25, 2, -40 },
  { 4947, 23, 39, 24, 1, -39 },
  { 5060, 25, 40, 33, 4, -39 },
  { 5185, 28, 39, 28, 0, -39 },
  { 5322, 43, 39, 44, 0, -39 },
  { 5532, 26, 39, 26, 0, -39 },
  { 5659, 26, 39, 26, 0, -39 },
  { 5786, 22, 39, 24, 1, -39 },
  { 5894, 12, 48, 17, 4, -39 },
  { 5966, 19, 39, 21, 1, -39 },
  { 6059, 12, 48, 17, 2, -39 },
  { 6131, 25, 23, 27, 1, -39 },
  { 6203, 24, 3, 24, 0, 5 },
  { 6212, 12, 9, 16, 2, -42 },
  { 6226, 20, 31, 26, 2, -30 },
  { 6304, 22, 43, 28, 4, -42 },
  { 6423, 19, 31, 22, 2, -30 },
  { 6497, 23, 43, 28, 2, -42 },
  { 6621, 22, 31, 26, 2, -30 },
  { 6707, 17, 42, 16, 1, -42 },
  { 6797, 23, 43, 28, 2, -30 },
  { 6921, 21, 42, 28, 4, -42 },
  { 7032, 7, 41, 13, 3, -41 },
  { 7068, 12, 54, 13, -2, -41 },
  { 7149, 21, 42, 26, 4, -42 },
  { 7260, 5, 42, 13, 4, -42 },
  { 7287, 35, 30, 43, 4, -30 },
  { 7419, 21, 30, 28, 4, -30 },
  { 7498, 23, 31, 28, 2, -30 },
  { 7588, 22, 43, 28, 4, -30 },
  { 7707, 23, 43, 28, 2, -30 },
  { 7831, 15, 30, 19, 4, -30 },
  { 7888, 18, 31, 21, 2, -30 },
  { 7958, 15, 37, 17, 1, -36 },
  { 8028, 21, 31, 28, 4, -30 },
  { 8110, 24, 30, 24, 0, -30 },
  { 8200, 37, 30, 37, 0, -30 },
  { 8339, 22, 30, 24, 1, -30 },
  { 8422, 24, 43, 24, 0, -30 },
  { 8551, 18, 30, 20, 1, -30 },
  { 8619, 16, 48, 20, 2, -39 },
  { 8715, 5, 55, 25, 10, -42 },
  { 8750, 16, 48, 20, 2, -39 },
  { 8846, 23, 7, 26, 2, -23 },
};

const GFXfont NotoSans_Condensed_Medium55pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Medium55pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Medium55pt7bGlyphs,
  0x20, 0x7E, 75
};

#endif // _NOTOSANS_CONDENSED_MEDIUM55PT7B_H_
