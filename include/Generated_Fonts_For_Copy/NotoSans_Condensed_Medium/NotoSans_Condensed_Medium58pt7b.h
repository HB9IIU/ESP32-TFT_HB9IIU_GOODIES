#ifndef _NOTOSANS_CONDENSED_MEDIUM58PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUM58PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Medium.ttf
// Size: 58pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Medium58pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF,
  0xDF, 0xBF, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9,
  0xF3, 0xE7, 0x80, 0x00, 0x00, 0x00, 0x21, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7C, 0x60, 0xFE, 0x1F, 0xFF, 0x0F, 0xDF, 0x07, 0xEF, 0x83, 0xF7, 0xC1,
  0xFB, 0xE0, 0xFD, 0xF0, 0x3E, 0xF8, 0x1F, 0x7C, 0x0F, 0xBE, 0x07, 0xDF,
  0x03, 0xEF, 0x81, 0xF7, 0xC0, 0xF3, 0xE0, 0x79, 0xF0, 0x3C, 0x00, 0x3C,
  0x0F, 0x80, 0x03, 0xC0, 0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0xC0, 0xF0,
  0x00, 0x7C, 0x0F, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x78, 0x1F, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x07, 0x81, 0xE0, 0x00, 0xF8, 0x1E,
  0x03, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0x3C, 0x00, 0x1F, 0x03,
  0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x1E, 0x07, 0xC0, 0x01, 0xE0, 0x78, 0x00,
  0x1E, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x3E, 0x07, 0x80, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3C, 0x0F, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x7C,
  0x1F, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x78, 0x1F, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0x78, 0x1E, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x0F,
  0x83, 0xE0, 0x00, 0xF8, 0x3E, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x0F, 0xFF, 0x00, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xF9, 0xFF,
  0xFF, 0xEF, 0xE7, 0x03, 0x3F, 0x1C, 0x00, 0xF8, 0x70, 0x03, 0xE1, 0xC0,
  0x0F, 0x87, 0x00, 0x3E, 0x1C, 0x00, 0xF8, 0x70, 0x03, 0xF1, 0xC0, 0x0F,
  0xE7, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0xFF,
  0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x07, 0x7F,
  0x80, 0x1C, 0x7F, 0x00, 0x70, 0xFC, 0x01, 0xC1, 0xF0, 0x07, 0x07, 0xC0,
  0x1C, 0x1F, 0x00, 0x70, 0x7C, 0x01, 0xC1, 0xF8, 0x07, 0x0F, 0xFC, 0x1C,
  0x7E, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0,
  0x0F, 0xFC, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xF0, 0x01, 0xFF,
  0xE0, 0x03, 0xC0, 0x03, 0xE7, 0xC0, 0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x1E,
  0x00, 0x1F, 0x0F, 0x80, 0x7C, 0x00, 0x3C, 0x0F, 0x00, 0xF8, 0x00, 0x78,
  0x1E, 0x01, 0xE0, 0x01, 0xF0, 0x3C, 0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x0F,
  0x00, 0x07, 0xC0, 0xF8, 0x3E, 0x00, 0x0F, 0x81, 0xF0, 0x7C, 0x00, 0x1F,
  0x03, 0xE1, 0xF0, 0x00, 0x3E, 0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x0F, 0x87,
  0x80, 0x00, 0xF8, 0x1F, 0x1F, 0x00, 0x00, 0xF0, 0x3C, 0x3C, 0x1F, 0xC1,
  0xE0, 0x78, 0xF8, 0xFF, 0xC3, 0xE1, 0xF1, 0xF1, 0xFF, 0xC7, 0xC3, 0xE7,
  0xC7, 0xFF, 0x87, 0xCF, 0x8F, 0x8F, 0x0F, 0x8F, 0xFF, 0x1E, 0x3E, 0x1F,
  0x0F, 0xFC, 0x7C, 0x7C, 0x1E, 0x0F, 0xF0, 0xF0, 0xF0, 0x3C, 0x0F, 0x83,
  0xE1, 0xE0, 0x7C, 0x00, 0x07, 0xC3, 0xC0, 0xF8, 0x00, 0x0F, 0x0F, 0x81,
  0xF0, 0x00, 0x3E, 0x1F, 0x03, 0xE0, 0x00, 0x78, 0x3E, 0x07, 0xC0, 0x01,
  0xF0, 0x7C, 0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x1F, 0x00, 0x0F, 0x80, 0xF0,
  0x3E, 0x00, 0x1F, 0x01, 0xE0, 0x7C, 0x00, 0x3C, 0x03, 0xC0, 0xF0, 0x00,
  0xF8, 0x07, 0xC1, 0xE0, 0x01, 0xE0, 0x0F, 0x87, 0xC0, 0x07, 0xC0, 0x0F,
  0x0F, 0x80, 0x0F, 0x80, 0x1F, 0xFE, 0x00, 0x1E, 0x00, 0x1F, 0xFC, 0x00,
  0x7C, 0x00, 0x3F, 0xF0, 0x00, 0xF0, 0x00, 0x1F, 0xC0, 0x02, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xF8, 0x7E,
  0x00, 0x07, 0xE0, 0x7C, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x1F, 0x81, 0xF8,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0x80,
  0x00, 0xF8, 0x1F, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x03, 0xF1, 0xF8, 0x00,
  0x03, 0xF7, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0xFF, 0xC0, 0x1F, 0x87, 0xFF, 0xC0, 0x7E, 0x1F, 0xDF, 0xC0, 0xFC, 0x3F,
  0x1F, 0xC1, 0xF8, 0xFE, 0x1F, 0x83, 0xF1, 0xF8, 0x1F, 0x87, 0xC7, 0xE0,
  0x3F, 0x9F, 0x8F, 0xC0, 0x3F, 0xBF, 0x1F, 0x80, 0x3F, 0xFC, 0x3F, 0x00,
  0x7F, 0xF8, 0x7E, 0x00, 0x7F, 0xE0, 0xFC, 0x00, 0x7F, 0xC1, 0xF8, 0x00,
  0x7F, 0x03, 0xF8, 0x00, 0xFE, 0x03, 0xF0, 0x07, 0xFE, 0x07, 0xF0, 0x1F,
  0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0xFC, 0x0F, 0xFF, 0xF9,
  0xFC, 0x0F, 0xFF, 0xC1, 0xFC, 0x0F, 0xFE, 0x01, 0xFC, 0x00, 0xC0, 0x00,
  0x00, 0xFF, 0xFD, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xC0, 0x7E, 0x03,
  0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x00,
  0xF8, 0x07, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x01, 0xF8, 0x07,
  0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x0F,
  0x80, 0x7E, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80,
  0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x0F, 0xC0, 0x7E, 0x01,
  0xF0, 0x0F, 0x80, 0x7E, 0x03, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x07, 0xC0, 0x3E, 0x03, 0xF0,
  0x1F, 0x01, 0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x3E,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x06, 0x07, 0x80, 0x9F, 0x1E, 0x3F, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xF0, 0x01, 0xF3, 0xE0, 0x07, 0xCF, 0xC0,
  0x3E, 0x1F, 0x01, 0xF8, 0x7E, 0x0F, 0xC0, 0xFC, 0x0F, 0x03, 0xC0, 0x0C,
  0x04, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x1F,
  0x8F, 0xCF, 0xE7, 0xE3, 0xF1, 0xF8, 0xF8, 0x7C, 0x7E, 0x3E, 0x1F, 0x0F,
  0x87, 0x87, 0xC3, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x08, 0x7E, 0x7E, 0x7F, 0xFF, 0x7F, 0x7E, 0x7E, 0x18, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF,
  0x00, 0xFF, 0xFF, 0x03, 0xF8, 0xFF, 0x07, 0xE0, 0x7E, 0x1F, 0x80, 0xFC,
  0x3F, 0x00, 0xFC, 0x7C, 0x01, 0xF9, 0xF8, 0x01, 0xF3, 0xF0, 0x03, 0xE7,
  0xE0, 0x07, 0xEF, 0xC0, 0x0F, 0xDF, 0x80, 0x1F, 0xBE, 0x00, 0x3F, 0x7C,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xF8, 0x00, 0xFD, 0xF0, 0x01, 0xFB, 0xE0, 0x03, 0xF7, 0xE0, 0x07,
  0xEF, 0xC0, 0x0F, 0xDF, 0x80, 0x1F, 0xBF, 0x00, 0x3E, 0x7E, 0x00, 0xFC,
  0x7E, 0x01, 0xF8, 0xFC, 0x03, 0xF1, 0xF8, 0x0F, 0xC1, 0xF8, 0x3F, 0x83,
  0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x03,
  0xFF, 0x00, 0x00, 0x40, 0x00, 0x00, 0x7E, 0x01, 0xFC, 0x07, 0xF8, 0x1F,
  0xF0, 0x7F, 0xE1, 0xFF, 0xC7, 0xEF, 0x9F, 0xDF, 0x7F, 0x7F, 0xF8, 0xFD,
  0xE1, 0xF9, 0x83, 0xF2, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x01, 0xFE,
  0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0x0F, 0xE0, 0xFF, 0x0F, 0x00, 0x7E, 0x0C, 0x00, 0xFE, 0x10, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01,
  0xFE, 0x00, 0x1F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0x8F, 0xC0, 0xFF, 0x0E, 0x00, 0x7F, 0x08, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0xC0, 0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF4, 0x00, 0x0F, 0xEE, 0x00, 0x3F, 0xDF, 0xE3, 0xFF,
  0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0x7F, 0xFE, 0x00,
  0x05, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1E, 0xF8, 0x00, 0x0F, 0xBE, 0x00,
  0x03, 0xCF, 0x80, 0x01, 0xF3, 0xE0, 0x00, 0x78, 0xF8, 0x00, 0x3E, 0x7E,
  0x00, 0x0F, 0x1F, 0x80, 0x07, 0xC7, 0xE0, 0x03, 0xE1, 0xF8, 0x00, 0xF8,
  0x7E, 0x00, 0x7C, 0x1F, 0x80, 0x1F, 0x07, 0xE0, 0x0F, 0x81, 0xF8, 0x03,
  0xE0, 0x7E, 0x01, 0xF0, 0x1F, 0x80, 0x7C, 0x07, 0xE0, 0x3E, 0x01, 0xF8,
  0x0F, 0x80, 0x7E, 0x07, 0xC0, 0x1F, 0x81, 0xE0, 0x07, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x3E, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0x07, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFC, 0x3C, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE8, 0x00, 0x3F, 0xB8, 0x01, 0xFC, 0xFF,
  0x7F, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0x3F, 0xFE,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0xFF, 0x01, 0x03, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x3F, 0xC0, 0xF9, 0xFF, 0xC1, 0xF7, 0xFF, 0xC3, 0xEF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xCF, 0xF0, 0x3F, 0xBF, 0xC0, 0x3F, 0xFF, 0x00,
  0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFD, 0xF0, 0x00, 0xFB, 0xE0, 0x01,
  0xF7, 0xC0, 0x03, 0xEF, 0x80, 0x07, 0xDF, 0x80, 0x0F, 0xBF, 0x00, 0x1F,
  0x7E, 0x00, 0x7E, 0x7C, 0x00, 0xFC, 0xFC, 0x01, 0xF9, 0xFC, 0x07, 0xE1,
  0xF8, 0x1F, 0xC3, 0xFE, 0xFF, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x03,
  0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0x20, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF8, 0x3F, 0x81, 0xFC, 0x3F, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E,
  0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7C, 0x7E,
  0x00, 0x7C, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x1F, 0x81, 0xF8, 0x1F,
  0xC7, 0xF0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xEF, 0xF0, 0x3F,
  0x83, 0xF8, 0x3F, 0x01, 0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0xFC,
  0x00, 0x7E, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7F,
  0x00, 0xFE, 0x3F, 0xC3, 0xFC, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x18, 0x00, 0x00, 0xFE, 0x00, 0x07,
  0xFF, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x07, 0xF8,
  0xFF, 0x0F, 0xC0, 0x7E, 0x3F, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0xF8, 0x01,
  0xFB, 0xF0, 0x01, 0xF7, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFD,
  0xF8, 0x03, 0xFB, 0xF0, 0x07, 0xF7, 0xF0, 0x1F, 0xE7, 0xF0, 0x7F, 0xCF,
  0xFF, 0xEF, 0x8F, 0xFF, 0xDF, 0x0F, 0xFF, 0x7E, 0x0F, 0xFC, 0xFC, 0x07,
  0xE1, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x07, 0x1F, 0xFC, 0x0F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x0C, 0x00, 0x00,
  0x31, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0x3E, 0x10, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x11, 0xFB, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x30, 0x0C, 0x1F, 0x8F, 0xE7, 0xF3, 0xF9, 0xFC,
  0xFC, 0x3E, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xCF, 0xE7,
  0xF3, 0xF1, 0xF8, 0xFC, 0x7C, 0x3E, 0x3F, 0x1F, 0x0F, 0x87, 0xC7, 0xC3,
  0xE1, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0xFE,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x07,
  0xF8, 0x07, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0xFF, 0xFC, 0xF8,
  0x3F, 0x98, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x00, 0x07, 0xC0,
  0x7C, 0x00, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x20,
  0x03, 0xE3, 0xE0, 0x1F, 0xFC, 0x1F, 0x1E, 0x01, 0xFF, 0xF0, 0x79, 0xF0,
  0x1F, 0xFF, 0x83, 0xCF, 0x81, 0xF8, 0x7C, 0x1F, 0x78, 0x1F, 0x83, 0xE0,
  0xFB, 0xC0, 0xF8, 0x1F, 0x03, 0xFE, 0x0F, 0x80, 0xF8, 0x1F, 0xF0, 0x7C,
  0x07, 0xC0, 0xFF, 0x83, 0xE0, 0x3C, 0x07, 0xF8, 0x1F, 0x01, 0xE0, 0x3F,
  0xC0, 0xF0, 0x0F, 0x01, 0xFE, 0x07, 0x80, 0x78, 0x0F, 0xF0, 0x3C, 0x07,
  0xC0, 0x7F, 0x81, 0xE0, 0x3E, 0x07, 0xFC, 0x0F, 0x01, 0xF0, 0x3F, 0xE0,
  0x78, 0x0F, 0x81, 0xEF, 0x03, 0xE0, 0x7C, 0x0F, 0x7C, 0x1F, 0x07, 0xE0,
  0xFB, 0xE0, 0xFC, 0x3F, 0x87, 0x9F, 0x03, 0xFF, 0xDF, 0xFC, 0xF8, 0x1F,
  0xFC, 0xFF, 0xC3, 0xE0, 0x7F, 0xC3, 0xFC, 0x1F, 0x01, 0xFC, 0x0F, 0xC0,
  0xF8, 0x01, 0x80, 0x10, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x01, 0x80, 0x00, 0xFF, 0x80, 0xFC,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00,
  0x3F, 0x7C, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x01,
  0xF3, 0xF0, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x1F,
  0x0F, 0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x00, 0x01, 0xF8,
  0x3F, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x1F, 0x80,
  0xF8, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0xFC, 0x03, 0xF0, 0x01, 0xF8, 0x07,
  0xE0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE,
  0x03, 0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x01, 0xFC, 0x0F, 0xC0, 0x01, 0xF8,
  0x3F, 0x80, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0xE1,
  0xF8, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x3F, 0x9F,
  0x80, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFE, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xE7, 0xE0, 0x0F, 0xF3, 0xF0, 0x01, 0xFD, 0xF8, 0x00, 0xFE,
  0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xDF, 0x80, 0x07,
  0xEF, 0xC0, 0x03, 0xF7, 0xE0, 0x03, 0xF3, 0xF0, 0x01, 0xF9, 0xF8, 0x01,
  0xFC, 0xFC, 0x03, 0xFC, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE3, 0xF0, 0x07, 0xF9, 0xF8,
  0x00, 0xFE, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F,
  0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xBF, 0x00, 0x1F,
  0xDF, 0x80, 0x3F, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0,
  0x7F, 0xE0, 0xF8, 0x3F, 0xC0, 0x08, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x70, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xD0, 0x00, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xE1, 0xF8, 0x03, 0xFE, 0x3F, 0x00, 0x3F, 0xC7, 0xE0,
  0x01, 0xFC, 0xFC, 0x00, 0x3F, 0x9F, 0x80, 0x03, 0xFB, 0xF0, 0x00, 0x7F,
  0x7E, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF,
  0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00,
  0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0xFD, 0xF8, 0x00, 0x1F, 0xBF, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0xFC, 0xFC,
  0x00, 0x3F, 0x9F, 0x80, 0x0F, 0xE3, 0xF0, 0x03, 0xFC, 0x7E, 0x03, 0xFF,
  0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xE0, 0x7E, 0x0F, 0xF0, 0x00,
  0xE1, 0xFE, 0x00, 0x02, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x1F, 0x7E, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x1F, 0x7F, 0x00, 0x01,
  0xF7, 0xF0, 0x00, 0x1F, 0x3F, 0x00, 0x01, 0xF3, 0xF8, 0x00, 0x1F, 0x1F,
  0xC0, 0x01, 0xF1, 0xFE, 0x00, 0x1F, 0x0F, 0xF8, 0x01, 0xF0, 0x7F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0xFE, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F,
  0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00,
  0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00,
  0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0,
  0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF,
  0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFC, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x1F, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x81, 0xFC,
  0x0F, 0xFF, 0xFE, 0xFF, 0xF7, 0xFF, 0x3F, 0xF1, 0xFE, 0x00, 0xF8, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xBE, 0x00, 0x3F, 0x9F, 0x00, 0x1F, 0x8F, 0x80,
  0x1F, 0xC7, 0xC0, 0x1F, 0xC3, 0xE0, 0x0F, 0xC1, 0xF0, 0x0F, 0xE0, 0xF8,
  0x0F, 0xE0, 0x7C, 0x07, 0xE0, 0x3E, 0x07, 0xF0, 0x1F, 0x03, 0xF0, 0x0F,
  0x83, 0xF0, 0x07, 0xC3, 0xF8, 0x03, 0xE1, 0xF8, 0x01, 0xF1, 0xF8, 0x00,
  0xF9, 0xFC, 0x00, 0x7C, 0xFC, 0x00, 0x3E, 0xFE, 0x00, 0x1F, 0x7F, 0x80,
  0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFE, 0xFE,
  0x00, 0xFE, 0x3F, 0x00, 0x7E, 0x1F, 0xC0, 0x3E, 0x07, 0xE0, 0x1F, 0x03,
  0xF8, 0x0F, 0x80, 0xFE, 0x07, 0xC0, 0x7F, 0x03, 0xE0, 0x1F, 0xC1, 0xF0,
  0x0F, 0xE0, 0xF8, 0x03, 0xF8, 0x7C, 0x00, 0xFC, 0x3E, 0x00, 0x7F, 0x1F,
  0x00, 0x1F, 0x8F, 0x80, 0x0F, 0xE7, 0xC0, 0x03, 0xF3, 0xE0, 0x01, 0xFD,
  0xF0, 0x00, 0x7E, 0xF8, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7D, 0xFF, 0xBE, 0x00, 0x07, 0xDF, 0xFB,
  0xE0, 0x00, 0x7D, 0xFF, 0xBE, 0x00, 0x0F, 0x9F, 0xF9, 0xF0, 0x00, 0xF9,
  0xFF, 0x9F, 0x00, 0x0F, 0x9F, 0xF9, 0xF0, 0x01, 0xF1, 0xFF, 0x9F, 0x80,
  0x1F, 0x1F, 0xF8, 0xF8, 0x01, 0xF1, 0xFF, 0x8F, 0x80, 0x3E, 0x1F, 0xF8,
  0xFC, 0x03, 0xE1, 0xFF, 0x87, 0xC0, 0x3E, 0x1F, 0xF8, 0x7C, 0x07, 0xE1,
  0xFF, 0x87, 0xC0, 0x7C, 0x1F, 0xF8, 0x3E, 0x07, 0xC1, 0xFF, 0x83, 0xE0,
  0x7C, 0x1F, 0xF8, 0x3E, 0x0F, 0x81, 0xFF, 0x83, 0xF0, 0xF8, 0x1F, 0xF8,
  0x1F, 0x0F, 0x81, 0xFF, 0x81, 0xF1, 0xF0, 0x1F, 0xF8, 0x1F, 0x9F, 0x01,
  0xFF, 0x80, 0xF9, 0xF0, 0x1F, 0xF8, 0x0F, 0xBE, 0x01, 0xFF, 0x80, 0xFF,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xF8,
  0x07, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xF8, 0x03, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0x80, 0x1F, 0xF8, 0x03, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0x80, 0x1F, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0xFE, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x03,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xE0, 0x03, 0xFF, 0xBE, 0x00, 0x3F, 0xFB, 0xF0, 0x03, 0xFF, 0xBF, 0x00,
  0x3F, 0xF9, 0xF8, 0x03, 0xFF, 0x9F, 0x80, 0x3F, 0xF8, 0xFC, 0x03, 0xFF,
  0x8F, 0xC0, 0x3F, 0xF8, 0x7E, 0x03, 0xFF, 0x87, 0xE0, 0x3F, 0xF8, 0x3F,
  0x03, 0xFF, 0x83, 0xF0, 0x3F, 0xF8, 0x1F, 0x83, 0xFF, 0x81, 0xF8, 0x3F,
  0xF8, 0x0F, 0xC3, 0xFF, 0x80, 0xFC, 0x3F, 0xF8, 0x07, 0xE3, 0xFF, 0x80,
  0x7E, 0x3F, 0xF8, 0x03, 0xF3, 0xFF, 0x80, 0x3F, 0x3F, 0xF8, 0x01, 0xFB,
  0xFF, 0x80, 0x1F, 0xBF, 0xF8, 0x00, 0xFD, 0xFF, 0x80, 0x0F, 0xDF, 0xF8,
  0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x03,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFC, 0x01, 0xFF, 0x8F, 0xFC, 0x07, 0xF8, 0x03, 0xF8, 0x0F, 0xE0,
  0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xF1, 0xFC, 0x00,
  0x07, 0xE3, 0xF0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x1F, 0xCF, 0xC0, 0x00,
  0x1F, 0xBF, 0x80, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00,
  0xFD, 0xF8, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x07,
  0xEF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x01, 0xFB,
  0xF0, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x0F, 0xCF,
  0xC0, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0xFC, 0x3F,
  0x00, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x1F, 0xC0, 0xFE,
  0x00, 0x7F, 0x00, 0xFF, 0x01, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x14, 0x00, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x9F, 0x80, 0x7F, 0xBF,
  0x00, 0x7F, 0x7E, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFB, 0xF0, 0x07,
  0xF7, 0xE0, 0x3F, 0xCF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xE0, 0xFF, 0xFE, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x01,
  0xFF, 0x8F, 0xFC, 0x07, 0xF8, 0x03, 0xF8, 0x0F, 0xE0, 0x03, 0xF8, 0x3F,
  0x80, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x07, 0xE3, 0xF0,
  0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x1F, 0xBF, 0x80,
  0x00, 0x3F, 0x7F, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFD, 0xF8, 0x00,
  0x01, 0xFB, 0xF0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x7E, 0xFC, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x03,
  0xF7, 0xF0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x3F,
  0x9F, 0x80, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF8,
  0x7F, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x7F, 0x80,
  0xFF, 0x01, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x3F, 0x00, 0xFF, 0x0F, 0xC0, 0x1F,
  0xC3, 0xF0, 0x03, 0xF8, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x8F, 0xC0,
  0x07, 0xE3, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x8F,
  0xC0, 0x07, 0xE3, 0xF0, 0x03, 0xF8, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x7F,
  0x0F, 0xC0, 0x3F, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFC, 0x1F, 0x80, 0x3F,
  0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x07, 0xE0, 0xFC, 0x01,
  0xF8, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xF8, 0xFC,
  0x00, 0x7E, 0x3F, 0x00, 0x1F, 0xCF, 0xC0, 0x03, 0xF3, 0xF0, 0x00, 0xFE,
  0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0xFF, 0x8F, 0xE7, 0xF8, 0x03, 0x1F,
  0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x07,
  0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x7E, 0xF8, 0x07, 0xFB, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0x80, 0x7F, 0xFC, 0x00,
  0x06, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFD, 0xF8,
  0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xDF, 0x80, 0x07, 0xF7, 0xF0, 0x03, 0xF8,
  0xFF, 0x01, 0xFE, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xFB, 0xE0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x7E, 0xFC, 0x00,
  0x07, 0xE7, 0xE0, 0x00, 0x3F, 0x1F, 0x80, 0x01, 0xF8, 0xFC, 0x00, 0x0F,
  0xC7, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x07,
  0xE0, 0x01, 0xF0, 0x3F, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0xFC, 0x07, 0xE0,
  0x07, 0xE0, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0x7E, 0x00,
  0x3E, 0x03, 0xF0, 0x01, 0xF8, 0x1F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3E,
  0x0F, 0xC0, 0x01, 0xF0, 0x7E, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x7E, 0x3F,
  0x00, 0x01, 0xF1, 0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x7E, 0x7C, 0x00,
  0x03, 0xF7, 0xE0, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x03,
  0xEF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFD, 0xF0, 0x00,
  0x3F, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x9F, 0x80, 0x07,
  0xF8, 0x00, 0x7E, 0x7E, 0x00, 0x1F, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0x7F,
  0x80, 0x07, 0xC3, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xF8,
  0x00, 0xFC, 0x3F, 0x00, 0x3F, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xFF, 0xC0,
  0x0F, 0xC1, 0xF0, 0x03, 0xDF, 0x00, 0x7E, 0x07, 0xE0, 0x1F, 0x7C, 0x01,
  0xF8, 0x1F, 0x80, 0x7C, 0xF8, 0x07, 0xE0, 0x7E, 0x01, 0xF3, 0xE0, 0x1F,
  0x81, 0xF8, 0x07, 0xCF, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x3E, 0x03, 0xF0,
  0x0F, 0xC0, 0xF8, 0xF8, 0x0F, 0xC0, 0x3F, 0x03, 0xE1, 0xF0, 0x3F, 0x00,
  0xFC, 0x0F, 0x87, 0xC0, 0xFC, 0x01, 0xF0, 0x3E, 0x1F, 0x03, 0xE0, 0x07,
  0xC1, 0xF8, 0x7C, 0x1F, 0x80, 0x1F, 0x87, 0xC0, 0xF8, 0x7E, 0x00, 0x7E,
  0x1F, 0x03, 0xE1, 0xF8, 0x01, 0xF8, 0x7C, 0x0F, 0x87, 0xE0, 0x03, 0xE1,
  0xF0, 0x3E, 0x1F, 0x00, 0x0F, 0x8F, 0x80, 0xF8, 0xFC, 0x00, 0x3F, 0x3E,
  0x01, 0xF3, 0xF0, 0x00, 0xFC, 0xF8, 0x07, 0xCF, 0xC0, 0x01, 0xF3, 0xE0,
  0x1F, 0x3E, 0x00, 0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x00, 0x1F, 0x7C, 0x00,
  0xF7, 0xE0, 0x00, 0x7D, 0xF0, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xE7, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x0F, 0xC0,
  0x0F, 0xC0, 0xFC, 0x03, 0xF8, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC3,
  0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0x9F, 0x80, 0x01, 0xFF, 0xE0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x1F, 0xFE, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0xFC, 0xFC, 0x00, 0x3F,
  0x0F, 0xC0, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x3F, 0x80, 0x3F, 0x03, 0xF0,
  0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x0F, 0xC0,
  0x0F, 0xC3, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x9F, 0xC0, 0x03, 0xF3,
  0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x0F, 0xEF, 0xC0,
  0x01, 0xF9, 0xF8, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x01, 0xF8,
  0x7F, 0x00, 0x3F, 0x07, 0xE0, 0x0F, 0xC0, 0xFC, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x1F, 0x01, 0xF8, 0x03, 0xF0, 0x7E, 0x00,
  0x7E, 0x0F, 0xC0, 0x07, 0xE3, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x0F, 0x8F,
  0x80, 0x01, 0xFB, 0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x7F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xDF, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x3E, 0x3E, 0x00,
  0x0F, 0x87, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x80,
  0xF8, 0x01, 0xF0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x03,
  0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0xC3, 0xE0, 0x00,
  0xF8, 0xF8, 0x00, 0x1F, 0x9F, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF0, 0x38, 0x0F, 0xE0, 0x80, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0xC7, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFC, 0xFF, 0x03, 0xF7, 0xF0, 0x0F, 0xDF, 0x80, 0x3F, 0xFC, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0,
  0x07, 0xFF, 0xE0, 0x3F, 0xDF, 0xC3, 0xFF, 0x7F, 0xFF, 0x7C, 0xFF, 0xF9,
  0xF1, 0xFF, 0xC7, 0xC3, 0xFE, 0x1F, 0x03, 0xC0, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC1, 0xF0, 0x1F, 0x8F,
  0xF8, 0x3F, 0x7F, 0xF8, 0x7E, 0xFF, 0xF8, 0xFB, 0xFF, 0xF9, 0xFF, 0x87,
  0xF3, 0xFC, 0x07, 0xF7, 0xF0, 0x07, 0xEF, 0xE0, 0x0F, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0xDF, 0xC0, 0x1F, 0xBF, 0xC0,
  0x7F, 0x7F, 0xE1, 0xFC, 0xFB, 0xFF, 0xF9, 0xF3, 0xFF, 0xE3, 0xE3, 0xFF,
  0x87, 0xC3, 0xFE, 0x00, 0x00, 0x40, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0xF8,
  0x3F, 0xFF, 0x8F, 0xFF, 0xE1, 0xFF, 0xFC, 0x7F, 0x83, 0x9F, 0xC0, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x01, 0x1F,
  0xF3, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x81, 0xFF, 0xF0, 0x1F, 0xFC, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x1F, 0x07, 0xE0, 0xFF, 0x8F, 0xC3, 0xFF, 0xDF, 0x8F, 0xFF, 0xDF,
  0x3F, 0xFF, 0xBE, 0x7F, 0x07, 0xFD, 0xFC, 0x07, 0xFB, 0xF0, 0x07, 0xFF,
  0xE0, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80,
  0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x0F,
  0xEF, 0xC0, 0x1F, 0xDF, 0xC0, 0x7F, 0x9F, 0xE3, 0xFF, 0x3F, 0xFF, 0xBE,
  0x3F, 0xFE, 0x7C, 0x3F, 0xF8, 0xF8, 0x3F, 0xE1, 0xF0, 0x06, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF0, 0xFC, 0x0F, 0xC7, 0xE0, 0x1F, 0x9F, 0x80, 0x7E, 0x7C, 0x00,
  0xFB, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x01, 0x8F, 0xF8, 0x3E, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x7F,
  0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x38, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0xF0,
  0x3F, 0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0x83, 0xF8, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x0F, 0xFF, 0x8F, 0xFF, 0xE3, 0xFF, 0xF8, 0xFF, 0xFE, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0xFC, 0x7C, 0x3F, 0xFC, 0xF8, 0xFF, 0xFD, 0xF3, 0xFF, 0xFB,
  0xE7, 0xF0, 0xFF, 0xDF, 0xC0, 0x7F, 0xBF, 0x00, 0x7F, 0xFE, 0x00, 0xFF,
  0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF,
  0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0,
  0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80,
  0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0xFE, 0xFC, 0x01,
  0xFD, 0xFC, 0x07, 0xF9, 0xFE, 0x3F, 0xF3, 0xFF, 0xFF, 0xE3, 0xFF, 0xEF,
  0xC3, 0xFF, 0x9F, 0x83, 0xFE, 0x3F, 0x00, 0x40, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3F, 0x30, 0x00, 0xFE, 0x7C, 0x07, 0xF8, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x1F, 0x03, 0xF1,
  0xFF, 0x0F, 0xDF, 0xFF, 0x3E, 0xFF, 0xFC, 0xFB, 0xFF, 0xFB, 0xFF, 0x0F,
  0xEF, 0xF0, 0x1F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F,
  0x7B, 0xFF, 0xFF, 0xFF, 0xF7, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xE0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x07, 0xE8, 0xFE, 0xFF, 0xEF, 0xFC, 0xFF, 0xCF, 0xF8, 0x7E, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x3F, 0xBF, 0x00, 0x7E, 0x7E, 0x01, 0xF8, 0xFC, 0x07, 0xE1,
  0xF8, 0x1F, 0xC3, 0xF0, 0x3F, 0x07, 0xE0, 0xFC, 0x0F, 0xC3, 0xF0, 0x1F,
  0x87, 0xE0, 0x3F, 0x1F, 0x80, 0x7E, 0x7E, 0x00, 0xFC, 0xF8, 0x01, 0xFB,
  0xF0, 0x03, 0xEF, 0xE0, 0x07, 0xDF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xC0, 0x3F, 0xCF, 0xC0, 0x7F, 0x1F, 0x80, 0xFC, 0x1F, 0x81, 0xF8, 0x3F,
  0x03, 0xF0, 0x3F, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0xFC,
  0x3F, 0x00, 0xFC, 0x7E, 0x01, 0xF8, 0xFC, 0x01, 0xF9, 0xF8, 0x03, 0xF3,
  0xF0, 0x03, 0xF7, 0xE0, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0x00, 0x3F, 0x07, 0xC7, 0xFE, 0x07, 0xFE,
  0x3E, 0x7F, 0xF8, 0x7F, 0xF9, 0xF7, 0xFF, 0xE7, 0xFF, 0xCF, 0xBF, 0xFF,
  0x7F, 0xFF, 0x7F, 0xC3, 0xFF, 0xC3, 0xFB, 0xFC, 0x0F, 0xF8, 0x0F, 0xFF,
  0xC0, 0x3F, 0xC0, 0x3F, 0xFE, 0x01, 0xFC, 0x01, 0xFF, 0xE0, 0x07, 0xE0,
  0x0F, 0xFF, 0x00, 0x3F, 0x00, 0x7F, 0xF8, 0x01, 0xF8, 0x03, 0xFF, 0xC0,
  0x0F, 0xC0, 0x1F, 0xFE, 0x00, 0x7C, 0x00, 0xFF, 0xF0, 0x03, 0xE0, 0x07,
  0xFF, 0x80, 0x1F, 0x00, 0x3F, 0xFC, 0x00, 0xF8, 0x01, 0xFF, 0xE0, 0x07,
  0xC0, 0x0F, 0xFF, 0x00, 0x3E, 0x00, 0x7F, 0xF8, 0x01, 0xF0, 0x03, 0xFF,
  0xC0, 0x0F, 0x80, 0x1F, 0xFE, 0x00, 0x7C, 0x00, 0xFF, 0xF0, 0x03, 0xE0,
  0x07, 0xFF, 0x80, 0x1F, 0x00, 0x3F, 0xFC, 0x00, 0xF8, 0x01, 0xFF, 0xE0,
  0x07, 0xC0, 0x0F, 0xFF, 0x00, 0x3E, 0x00, 0x7F, 0xF8, 0x01, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0x80, 0x1F, 0xFE, 0x00, 0x7C, 0x00, 0xFF, 0xF0, 0x03,
  0xE0, 0x07, 0xFF, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x1F, 0x03, 0xE3, 0xFF,
  0x0F, 0x9F, 0xFF, 0x3E, 0xFF, 0xFC, 0xFB, 0xFF, 0xFB, 0xFF, 0x0F, 0xEF,
  0xF0, 0x1F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0x00,
  0xFE, 0x00, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF8, 0x3F, 0x83, 0xF8, 0x7F, 0x01, 0xFC, 0x7E, 0x00, 0xFC, 0x7E,
  0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC,
  0x00, 0x3E, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0x7E,
  0x00, 0x7C, 0x7E, 0x00, 0xFC, 0x3F, 0x01, 0xFC, 0x3F, 0xC7, 0xF8, 0x1F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00,
  0x10, 0x00, 0x00, 0x1F, 0x01, 0xF0, 0xFF, 0x83, 0xE7, 0xFF, 0x87, 0xCF,
  0xFF, 0x8F, 0xBF, 0xFF, 0x9F, 0xF0, 0x7F, 0xBF, 0xC0, 0x7F, 0x7F, 0x00,
  0x7E, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F,
  0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFE,
  0x00, 0xFD, 0xFC, 0x01, 0xFB, 0xFC, 0x07, 0xF7, 0xFF, 0x3F, 0xCF, 0xBF,
  0xFF, 0x9F, 0xBF, 0xFE, 0x3F, 0x3F, 0xF8, 0x7E, 0x3F, 0xE0, 0xFC, 0x0C,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xF8, 0x7C, 0x3F, 0xFC, 0xF8,
  0xFF, 0xF9, 0xF3, 0xFF, 0xFB, 0xE7, 0xF0, 0x7F, 0xDF, 0xC0, 0x7F, 0xBF,
  0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00,
  0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F,
  0xFE, 0x00, 0xFE, 0xFC, 0x01, 0xFD, 0xFC, 0x07, 0xF9, 0xFE, 0x3F, 0xF3,
  0xFF, 0xFB, 0xE3, 0xFF, 0xEF, 0xC3, 0xFF, 0x9F, 0x83, 0xFE, 0x3F, 0x00,
  0x40, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xF8, 0x7F, 0xF8, 0xFE, 0xF9, 0xFE,
  0xFB, 0xFE, 0xFB, 0xFE, 0xFF, 0xC0, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x01, 0xFF,
  0xF0, 0x7F, 0xFF, 0x1F, 0xFF, 0xE7, 0xFF, 0xF8, 0xFC, 0x07, 0x3F, 0x00,
  0x27, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x07, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xFF,
  0x00, 0x7F, 0xF0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0xFB, 0x80, 0x3F,
  0x7E, 0x1F, 0xEF, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0xC1, 0xFF, 0xE0,
  0x00, 0x80, 0x00, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE3, 0x0F,
  0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0x20, 0xFC, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF8, 0x0F, 0xF7, 0xFD, 0xFF, 0xDF,
  0xFF, 0xDF, 0x3F, 0xFE, 0x7C, 0x7F, 0xF1, 0xF0, 0xFF, 0x87, 0xC0, 0x30,
  0x00, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x1F, 0x9F, 0x80, 0x0F, 0xCF, 0xC0,
  0x07, 0xE3, 0xE0, 0x03, 0xF1, 0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x7E,
  0x00, 0xFC, 0x1F, 0x00, 0x7C, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x3F, 0x01,
  0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x7E, 0x0F, 0xC0, 0x1F, 0x07, 0xE0,
  0x0F, 0x83, 0xE0, 0x07, 0xE1, 0xF0, 0x03, 0xF1, 0xF8, 0x00, 0xF8, 0xF8,
  0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x7E, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xDF,
  0x00, 0x03, 0xEF, 0x80, 0x01, 0xF7, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xF0, 0x03, 0xFF,
  0xC0, 0x1F, 0xE0, 0x0F, 0xBF, 0x00, 0x7F, 0x80, 0x7E, 0x7C, 0x03, 0xFE,
  0x01, 0xF9, 0xF8, 0x0F, 0xF8, 0x07, 0xE7, 0xE0, 0x3D, 0xE0, 0x1F, 0x1F,
  0x80, 0xF7, 0xC0, 0x7C, 0x3E, 0x03, 0xDF, 0x03, 0xF0, 0xF8, 0x1F, 0x3C,
  0x0F, 0xC3, 0xF0, 0x7C, 0xF0, 0x3E, 0x0F, 0xC1, 0xF3, 0xE0, 0xF8, 0x1F,
  0x07, 0x8F, 0x87, 0xE0, 0x7C, 0x3E, 0x3E, 0x1F, 0x81, 0xF8, 0xF8, 0x78,
  0x7C, 0x07, 0xE3, 0xE1, 0xF1, 0xF0, 0x1F, 0x8F, 0x07, 0xC7, 0xC0, 0x3E,
  0x3C, 0x1F, 0x3F, 0x00, 0xF9, 0xF0, 0x7C, 0xFC, 0x03, 0xE7, 0xC0, 0xF3,
  0xE0, 0x0F, 0xDF, 0x03, 0xCF, 0x80, 0x1F, 0x78, 0x0F, 0xBE, 0x00, 0x7D,
  0xE0, 0x3F, 0xF8, 0x01, 0xF7, 0x80, 0xFF, 0xC0, 0x07, 0xFE, 0x01, 0xFF,
  0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x03, 0xF8,
  0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x7E, 0x7E, 0x00, 0xFC,
  0x3F, 0x00, 0xFC, 0x3F, 0x01, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x83, 0xF0,
  0x0F, 0xC3, 0xF0, 0x0F, 0xC7, 0xE0, 0x07, 0xE7, 0xE0, 0x07, 0xEF, 0xC0,
  0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x07, 0xEF, 0xC0, 0x07, 0xE7, 0xC0,
  0x0F, 0xC7, 0xE0, 0x0F, 0xC3, 0xF0, 0x1F, 0x83, 0xF0, 0x1F, 0x81, 0xF8,
  0x3F, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0xFE, 0x00, 0x7E,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x1F, 0x9F, 0x80, 0x0F,
  0xCF, 0xC0, 0x07, 0xE3, 0xE0, 0x03, 0xF1, 0xF8, 0x03, 0xF0, 0xFC, 0x01,
  0xF8, 0x3E, 0x00, 0xFC, 0x1F, 0x80, 0x7C, 0x0F, 0xC0, 0x7E, 0x03, 0xE0,
  0x3F, 0x01, 0xF0, 0x1F, 0x00, 0xFC, 0x0F, 0x80, 0x7E, 0x0F, 0xC0, 0x1F,
  0x07, 0xE0, 0x0F, 0xC3, 0xE0, 0x07, 0xE3, 0xF0, 0x01, 0xF1, 0xF8, 0x00,
  0xF8, 0xF8, 0x00, 0x7E, 0x7C, 0x00, 0x1F, 0x7E, 0x00, 0x0F, 0xBF, 0x00,
  0x07, 0xDF, 0x00, 0x01, 0xEF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x3F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0x00, 0x1F, 0x80,
  0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F,
  0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xC0,
  0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F,
  0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x80, 0x0F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF8, 0x0F, 0xE0, 0x0F,
  0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0xFF,
  0x80, 0xFF, 0x80, 0x7F, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x01, 0xFC, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0xC0,
  0x07, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x07, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x80, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x0F, 0xFC, 0x00, 0xFF,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x0F,
  0xE0, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x1F, 0xF0,
  0x1F, 0xE0, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x7F, 0x00, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x01, 0x3F, 0xE0, 0x01, 0x7F, 0xF8, 0x03, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0x1F, 0xFE, 0x80, 0x07,
  0xFC, 0x80, 0x00, 0xC0,
};

const GFXglyph NotoSans_Condensed_Medium58pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 7, 42, 15, 4, -41 },
  { 38, 17, 15, 24, 3, -41 },
  { 70, 28, 41, 30, 1, -41 },
  { 214, 22, 47, 28, 3, -44 },
  { 344, 39, 43, 43, 2, -42 },
  { 554, 31, 43, 33, 2, -42 },
  { 721, 7, 15, 13, 3, -41 },
  { 735, 13, 51, 18, 3, -42 },
  { 818, 13, 51, 18, 2, -42 },
  { 901, 22, 22, 26, 2, -44 },
  { 962, 24, 27, 28, 2, -34 },
  { 1043, 9, 15, 14, 2, -7 },
  { 1060, 13, 5, 17, 2, -18 },
  { 1069, 8, 9, 14, 3, -8 },
  { 1078, 21, 42, 22, 1, -42 },
  { 1189, 23, 43, 28, 2, -42 },
  { 1313, 15, 41, 28, 4, -41 },
  { 1390, 23, 42, 28, 2, -42 },
  { 1511, 23, 43, 28, 2, -42 },
  { 1635, 26, 42, 28, 1, -42 },
  { 1772, 22, 42, 28, 3, -41 },
  { 1888, 23, 43, 28, 2, -42 },
  { 2012, 24, 41, 28, 2, -41 },
  { 2135, 24, 43, 28, 2, -42 },
  { 2264, 23, 43, 28, 2, -42 },
  { 2388, 7, 33, 14, 4, -32 },
  { 2417, 9, 40, 14, 2, -32 },
  { 2462, 24, 27, 28, 2, -34 },
  { 2543, 24, 17, 28, 2, -29 },
  { 2594, 24, 27, 28, 2, -34 },
  { 2675, 19, 43, 21, 1, -42 },
  { 2778, 37, 47, 43, 3, -42 },
  { 2996, 31, 41, 31, 0, -41 },
  { 3155, 25, 41, 31, 4, -41 },
  { 3284, 25, 43, 30, 3, -42 },
  { 3419, 27, 41, 34, 4, -41 },
  { 3558, 18, 41, 26, 5, -41 },
  { 3651, 18, 41, 25, 5, -41 },
  { 3744, 28, 43, 35, 3, -42 },
  { 3895, 26, 41, 35, 5, -41 },
  { 4029, 14, 41, 18, 2, -41 },
  { 4101, 13, 52, 15, -3, -41 },
  { 4186, 25, 41, 30, 5, -41 },
  { 4315, 20, 41, 25, 4, -41 },
  { 4418, 36, 41, 46, 5, -41 },
  { 4603, 28, 41, 37, 5, -41 },
  { 4747, 31, 43, 36, 3, -42 },
  { 4914, 23, 41, 29, 4, -41 },
  { 5032, 31, 52, 36, 3, -42 },
  { 5234, 26, 41, 30, 4, -41 },
  { 5368, 22, 43, 26, 2, -42 },
  { 5487, 24, 41, 26, 1, -41 },
  { 5610, 26, 42, 35, 4, -41 },
  { 5747, 29, 41, 29, 0, -41 },
  { 5896, 46, 41, 46, 0, -41 },
  { 6132, 27, 41, 28, 0, -41 },
  { 6271, 27, 41, 27, 0, -41 },
  { 6410, 22, 41, 25, 2, -41 },
  { 6523, 13, 51, 18, 4, -42 },
  { 6606, 21, 42, 22, 1, -42 },
  { 6717, 12, 51, 18, 2, -42 },
  { 6794, 27, 24, 29, 1, -41 },
  { 6875, 25, 4, 25, 0, 5 },
  { 6888, 12, 9, 17, 2, -44 },
  { 6902, 22, 33, 27, 2, -32 },
  { 6993, 23, 45, 30, 4, -44 },
  { 7123, 19, 33, 23, 3, -32 },
  { 7202, 23, 45, 30, 3, -44 },
  { 7332, 22, 33, 27, 3, -32 },
  { 7423, 18, 44, 17, 1, -44 },
  { 7522, 23, 46, 30, 3, -32 },
  { 7655, 22, 44, 30, 4, -44 },
  { 7776, 6, 43, 14, 4, -43 },
  { 7809, 12, 57, 14, -2, -43 },
  { 7895, 23, 44, 27, 4, -44 },
  { 8022, 6, 44, 14, 4, -44 },
  { 8055, 37, 32, 45, 4, -32 },
  { 8203, 22, 32, 30, 4, -32 },
  { 8291, 24, 33, 29, 3, -32 },
  { 8390, 23, 46, 30, 4, -32 },
  { 8523, 23, 46, 30, 3, -32 },
  { 8656, 16, 32, 20, 4, -32 },
  { 8720, 19, 33, 23, 2, -32 },
  { 8799, 16, 39, 18, 1, -38 },
  { 8877, 22, 32, 30, 4, -31 },
  { 8965, 25, 31, 25, 0, -31 },
  { 9062, 38, 31, 40, 1, -31 },
  { 9210, 24, 31, 25, 1, -31 },
  { 9303, 25, 45, 25, 0, -31 },
  { 9444, 18, 31, 21, 2, -31 },
  { 9514, 17, 51, 21, 2, -42 },
  { 9623, 5, 58, 26, 11, -44 },
  { 9660, 17, 51, 21, 2, -42 },
  { 9769, 24, 9, 28, 2, -25 },
};

const GFXfont NotoSans_Condensed_Medium58pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Medium58pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Medium58pt7bGlyphs,
  0x20, 0x7E, 79
};

#endif // _NOTOSANS_CONDENSED_MEDIUM58PT7B_H_
