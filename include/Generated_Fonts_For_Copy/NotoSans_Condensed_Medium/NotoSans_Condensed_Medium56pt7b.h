#ifndef _NOTOSANS_CONDENSED_MEDIUM56PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUM56PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Medium.ttf
// Size: 56pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Medium56pt7bBitmaps[] PROGMEM = {
  0x00, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x3E, 0x3E, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x7E,
  0x7E, 0xFF, 0x7F, 0x7E, 0x7E, 0x18, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07,
  0xDF, 0x83, 0xE7, 0xC1, 0xF3, 0xE0, 0xF9, 0xF0, 0x7C, 0xF8, 0x3E, 0x7C,
  0x1F, 0x3E, 0x0F, 0x9F, 0x07, 0xCF, 0x83, 0xE7, 0x81, 0xF3, 0xC0, 0xF8,
  0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x83, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x3C,
  0x0F, 0x00, 0x07, 0x81, 0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x1E, 0x07, 0x80,
  0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x3C, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xC0,
  0xF0, 0x1F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xF8, 0x0F, 0x83, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x3C, 0x0F,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x1E, 0x0F, 0x80, 0x07,
  0xC1, 0xF0, 0x00, 0xF8, 0x3C, 0x00, 0x1E, 0x07, 0x80, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xE0, 0x7C,
  0x1E, 0x00, 0x0F, 0x03, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x3C, 0x0F, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x1E, 0x0F, 0x80, 0x07, 0xC1,
  0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xC0, 0xF0, 0x00,
  0x78, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0xFF, 0x80, 0x3F, 0xFF, 0x83, 0xFF, 0xFF,
  0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0xBF, 0x9C, 0x39, 0xF8, 0xE0, 0x2F, 0x87,
  0x00, 0x7C, 0x38, 0x03, 0xE1, 0xC0, 0x1F, 0x0E, 0x00, 0xF8, 0x70, 0x07,
  0xE3, 0x80, 0x3F, 0x9C, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xFE,
  0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80,
  0x1D, 0xFC, 0x00, 0xE3, 0xF0, 0x07, 0x0F, 0x80, 0x38, 0x7C, 0x01, 0xC3,
  0xE0, 0x0E, 0x1F, 0x00, 0x70, 0xFC, 0x03, 0x8F, 0xF8, 0x1C, 0xFF, 0xFC,
  0xFF, 0xEF, 0xFF, 0xFE, 0x7F, 0xFF, 0xE3, 0xFF, 0xFE, 0x03, 0xFF, 0x80,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x03,
  0xC0, 0x07, 0xFC, 0x00, 0x3E, 0x00, 0x7F, 0xF0, 0x01, 0xE0, 0x03, 0xEF,
  0xC0, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0xF0, 0x01, 0xE0, 0xF0, 0x07, 0x80,
  0x0F, 0x07, 0xC0, 0x7C, 0x00, 0xF8, 0x3E, 0x03, 0xC0, 0x07, 0xC1, 0xF0,
  0x3E, 0x00, 0x3E, 0x07, 0x81, 0xE0, 0x01, 0xF0, 0x3C, 0x1F, 0x00, 0x0F,
  0x81, 0xE0, 0xF8, 0x00, 0x7C, 0x0F, 0x07, 0x80, 0x03, 0xE0, 0x78, 0x7C,
  0x00, 0x1F, 0x07, 0xC3, 0xC0, 0x00, 0xF8, 0x3E, 0x3E, 0x06, 0x03, 0xC1,
  0xF1, 0xE1, 0xFC, 0x1E, 0x0F, 0x8F, 0x1F, 0xF8, 0xF0, 0x78, 0xF9, 0xFF,
  0xC7, 0xC7, 0xC7, 0x8F, 0xBF, 0x1F, 0x7E, 0x7C, 0x78, 0x78, 0xFF, 0xE3,
  0xC7, 0xC3, 0xE3, 0xFE, 0x3E, 0x3C, 0x1F, 0x0F, 0xE1, 0xF1, 0xE0, 0x78,
  0x08, 0x0F, 0x0F, 0x03, 0xC0, 0x00, 0xF8, 0x78, 0x1E, 0x00, 0x07, 0x83,
  0xC0, 0xF0, 0x00, 0x7C, 0x1E, 0x07, 0x80, 0x03, 0xC0, 0xF0, 0x3C, 0x00,
  0x1E, 0x07, 0x81, 0xE0, 0x01, 0xF0, 0x3C, 0x0F, 0x00, 0x0F, 0x01, 0xE0,
  0x78, 0x00, 0xF8, 0x0F, 0x03, 0xC0, 0x07, 0x80, 0x78, 0x3E, 0x00, 0x7C,
  0x03, 0xE1, 0xF0, 0x03, 0xE0, 0x0F, 0x0F, 0x00, 0x1E, 0x00, 0x7F, 0xF8,
  0x01, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0x00, 0x0F, 0xFC, 0x00, 0xF8, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x3F, 0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xC0, 0xFC,
  0x00, 0x1F, 0x01, 0xF0, 0x00, 0x7C, 0x07, 0xC0, 0x01, 0xF0, 0x3F, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x3E, 0x1F, 0x80, 0x00,
  0xFC, 0x7E, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xF8, 0x07, 0xC1, 0xFF, 0xF0, 0x3F, 0x0F, 0xEF, 0xC0,
  0xFC, 0x7F, 0x1F, 0x83, 0xF1, 0xF8, 0x3F, 0x0F, 0x8F, 0xC0, 0xFE, 0x3E,
  0x3F, 0x01, 0xF9, 0xF8, 0xFC, 0x03, 0xF7, 0xC3, 0xF0, 0x07, 0xFF, 0x0F,
  0xC0, 0x1F, 0xFC, 0x3F, 0x00, 0x3F, 0xE0, 0xFC, 0x00, 0x7F, 0x03, 0xF0,
  0x01, 0xFC, 0x0F, 0xE0, 0x0F, 0xF8, 0x1F, 0xC0, 0x7F, 0xF0, 0x7F, 0xCF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xDF, 0x83, 0xFF, 0xFE, 0x7F, 0x03, 0xFF, 0xF0,
  0xFE, 0x07, 0xFF, 0x01, 0xFC, 0x00, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x79, 0xE0, 0x01, 0xF0, 0x3E, 0x03,
  0xE0, 0x7C, 0x07, 0xC0, 0xF8, 0x1F, 0x81, 0xF0, 0x1F, 0x03, 0xF0, 0x3E,
  0x07, 0xE0, 0x7E, 0x07, 0xC0, 0x7C, 0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xFC, 0x0F, 0xC0, 0x7C,
  0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x3E, 0x03, 0xF0, 0x1F, 0x01, 0xF0, 0x0F,
  0x80, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0xFC, 0x01,
  0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x07,
  0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF8, 0x0F, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xF0,
  0x0F, 0x80, 0xFC, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x01, 0x01, 0xE0,
  0x2F, 0x0F, 0x0F, 0xFF, 0x77, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x0F, 0x78, 0x00, 0xFB, 0xE0,
  0x0F, 0xCF, 0x80, 0x7C, 0x7E, 0x07, 0xE1, 0xF8, 0x7E, 0x0F, 0x80, 0x70,
  0x38, 0x01, 0x01, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x9F,
  0x8F, 0xC7, 0xE3, 0xE1, 0xF1, 0xF8, 0xF8, 0x7C, 0x3E, 0x1E, 0x1F, 0x0F,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3C,
  0xFF, 0xFF, 0xFF, 0xEF, 0xDF, 0x8C, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x07, 0xFC, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0,
  0x7F, 0xBF, 0xC3, 0xF8, 0x3F, 0x0F, 0xC0, 0x7E, 0x3E, 0x01, 0xF9, 0xF8,
  0x03, 0xE7, 0xE0, 0x0F, 0x9F, 0x80, 0x3F, 0x7C, 0x00, 0xFD, 0xF0, 0x03,
  0xF7, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07,
  0xDF, 0x00, 0x1F, 0x7C, 0x00, 0xFD, 0xF0, 0x03, 0xF7, 0xE0, 0x0F, 0xDF,
  0x80, 0x3E, 0x7E, 0x00, 0xF8, 0xF8, 0x07, 0xE3, 0xF0, 0x1F, 0x8F, 0xE0,
  0xFC, 0x1F, 0xEF, 0xF0, 0x7F, 0xFF, 0x80, 0xFF, 0xFC, 0x01, 0xFF, 0xE0,
  0x01, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x7C, 0x03, 0xF0, 0x1F, 0xC0,
  0xFF, 0x07, 0xFC, 0x3F, 0xF1, 0xFF, 0xCF, 0xDF, 0x7E, 0x7F, 0xF1, 0xF7,
  0x87, 0xCC, 0x1F, 0x20, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x20, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE1, 0xFE, 0x7F, 0xC7, 0xC0, 0x3F, 0x8E,
  0x00, 0x7E, 0x10, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x60, 0x00,
  0x1F, 0xFC, 0x01, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF1, 0xFC,
  0x3F, 0xC3, 0x80, 0x3F, 0x8C, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x7F,
  0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xB8, 0x00, 0xFE,
  0xFC, 0x1F, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xE0, 0x3F,
  0xFF, 0x00, 0x01, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3D, 0xF0, 0x00, 0x3E, 0xF8,
  0x00, 0x1E, 0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0x1F, 0x00, 0x0F, 0x8F,
  0x80, 0x07, 0x87, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xC1, 0xF0, 0x03, 0xE0,
  0xF8, 0x01, 0xE0, 0x7C, 0x01, 0xF0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF8,
  0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x7C, 0x01, 0xF0, 0x3E,
  0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x3F, 0xFF,
  0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0xBF, 0x00, 0x7F, 0xFF, 0x03, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xC3, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03,
  0xF4, 0x00, 0x3F, 0xB0, 0x03, 0xFD, 0xF8, 0x7F, 0xCF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xC3, 0xFF, 0xFC, 0x07, 0xFF, 0x80, 0x00, 0x80, 0x00, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x7F, 0xC3,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x3F, 0xC0, 0x7C, 0xFF, 0xE0, 0xFB,
  0xFF, 0xE1, 0xFF, 0xFF, 0xC7, 0xFE, 0x3F, 0xCF, 0xF0, 0x1F, 0x9F, 0xC0,
  0x1F, 0xBF, 0x80, 0x3F, 0x7E, 0x00, 0x3E, 0xFC, 0x00, 0x7D, 0xF8, 0x00,
  0xFD, 0xF0, 0x01, 0xFB, 0xE0, 0x03, 0xF7, 0xC0, 0x07, 0xEF, 0x80, 0x0F,
  0x9F, 0x80, 0x1F, 0x3F, 0x00, 0x3E, 0x3E, 0x00, 0xFC, 0x7E, 0x01, 0xF8,
  0x7E, 0x07, 0xE0, 0xFF, 0x3F, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00,
  0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x30, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x07, 0xF0, 0x7F, 0x0F, 0xC0, 0x7E, 0x3F,
  0x00, 0x7C, 0x7E, 0x00, 0xFC, 0xF8, 0x01, 0xF9, 0xF0, 0x03, 0xF3, 0xF0,
  0x07, 0xE7, 0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0xC0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x1F, 0xC7, 0xF0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x0F, 0xE7, 0xF8,
  0x3F, 0x03, 0xF8, 0xFC, 0x03, 0xF1, 0xF8, 0x03, 0xF7, 0xE0, 0x07, 0xEF,
  0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x7F, 0xF8, 0x00, 0xFB, 0xF0, 0x03, 0xF3, 0xF0, 0x07, 0xE7, 0xF8,
  0x3F, 0x87, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x03, 0xFF,
  0x80, 0x00, 0x20, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC,
  0x07, 0xFF, 0xF8, 0x3F, 0xCF, 0xF0, 0xFC, 0x0F, 0xC7, 0xE0, 0x1F, 0x9F,
  0x80, 0x7E, 0x7C, 0x00, 0xFB, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0xFD, 0xF0, 0x03, 0xF7, 0xE0, 0x1F, 0xDF, 0xC0, 0xFF, 0x3F,
  0x87, 0xFC, 0xFF, 0xFD, 0xF1, 0xFF, 0xF7, 0xC3, 0xFF, 0x9F, 0x07, 0xFC,
  0x7C, 0x01, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFE, 0x0C, 0x1F, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xFC,
  0x03, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x03, 0x80, 0x00, 0x10, 0xFD, 0xFF,
  0xFF, 0xEF, 0xDF, 0x9E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0xFF, 0xFF, 0xFF, 0xEF, 0xDF,
  0x8C, 0x08, 0x3F, 0x3F, 0x7F, 0x7F, 0x3F, 0x3F, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x3F, 0x3F, 0x3F, 0x3E, 0x3E, 0x7E, 0x7C, 0x7C, 0x7C,
  0x78, 0xF8, 0xF8, 0x00, 0x00, 0x02, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF,
  0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x7C, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x80, 0x07, 0xFF, 0x07,
  0xFF, 0xE3, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0x9F, 0xF7, 0x00, 0xFD, 0x00,
  0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x07, 0xC0, 0x00, 0x40, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x01, 0xFC, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x0F, 0x81, 0xF0,
  0x00, 0x00, 0x7C, 0x3E, 0x00, 0x10, 0x03, 0xC3, 0xE0, 0x1F, 0xF8, 0x3E,
  0x3C, 0x07, 0xFF, 0xC3, 0xE7, 0xC0, 0xFF, 0xFC, 0x1E, 0x78, 0x1F, 0x87,
  0xC1, 0xE7, 0x81, 0xF0, 0x7C, 0x1F, 0xF8, 0x3E, 0x07, 0xC1, 0xFF, 0x83,
  0xE0, 0x7C, 0x1F, 0xF0, 0x3C, 0x07, 0xC1, 0xFF, 0x07, 0xC0, 0x78, 0x1F,
  0xF0, 0x7C, 0x07, 0x81, 0xFF, 0x07, 0xC0, 0x78, 0x1F, 0xF0, 0x7C, 0x07,
  0x81, 0xFF, 0x07, 0xC0, 0x78, 0x1F, 0xF0, 0x7C, 0x0F, 0x81, 0xEF, 0x07,
  0xC0, 0xF8, 0x1E, 0xF0, 0x7C, 0x0F, 0x81, 0xEF, 0x03, 0xC0, 0xF8, 0x3E,
  0xF0, 0x3E, 0x1F, 0xC3, 0xCF, 0x83, 0xF3, 0xDC, 0x7C, 0xF8, 0x1F, 0xF9,
  0xFF, 0x87, 0x81, 0xFF, 0x9F, 0xF8, 0x78, 0x0F, 0xF0, 0xFE, 0x07, 0xC0,
  0x3C, 0x03, 0xC0, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x06, 0x00, 0x07, 0xFC, 0x07, 0xE0, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00,
  0x7D, 0xF0, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x3E,
  0x3E, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x1F, 0x87,
  0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x0F, 0xC0, 0xF8,
  0x00, 0x3F, 0x03, 0xE0, 0x00, 0xF8, 0x0F, 0xC0, 0x07, 0xE0, 0x3F, 0x00,
  0x1F, 0x80, 0x7C, 0x00, 0x7E, 0x01, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xF0, 0x1F, 0x80, 0x0F, 0xC0, 0x7E, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0x7E, 0x0F, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0xFC, 0x7E, 0x00, 0x03, 0xF9,
  0xF8, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFC, 0xFC, 0x03, 0xFC, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0xFE, 0xFC,
  0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC,
  0x00, 0x7E, 0xFC, 0x00, 0x7C, 0xFC, 0x00, 0xFC, 0xFC, 0x01, 0xFC, 0xFC,
  0x07, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFC, 0x01, 0xFC, 0xFC, 0x00, 0xFE, 0xFC,
  0x00, 0x7E, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x7E, 0xFC, 0x00, 0xFE, 0xFC, 0x01, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07,
  0xFF, 0xFE, 0x0F, 0xFE, 0xFE, 0x0F, 0xE0, 0x0E, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xF0, 0x06, 0x0F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00,
  0x7F, 0xF8, 0x00, 0x03, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x3F, 0x01, 0xFF,
  0x0F, 0xC0, 0x1F, 0xE3, 0xF0, 0x01, 0xFC, 0xFC, 0x00, 0x7F, 0x3F, 0x00,
  0x0F, 0xEF, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0xBF,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7E,
  0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xEF, 0xC0, 0x03, 0xF3, 0xF0, 0x01,
  0xFC, 0xFC, 0x00, 0xFE, 0x3F, 0x00, 0x7F, 0x8F, 0xC0, 0x7F, 0xC3, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x03,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xFF, 0xFB, 0xFF, 0xFF,
  0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0xFF, 0x7F,
  0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0x7F, 0x83, 0xFC, 0x00,
  0xF0, 0xFF, 0x00, 0x04, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xF7,
  0xE0, 0x00, 0x3E, 0xFC, 0x00, 0x07, 0xDF, 0x80, 0x00, 0xF9, 0xF8, 0x00,
  0x1F, 0x3F, 0x00, 0x03, 0xE7, 0xF0, 0x00, 0x7C, 0x7F, 0x00, 0x0F, 0x87,
  0xF8, 0x01, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x30, 0x00, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFE, 0x1F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x7F, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x3F, 0x43, 0xFB, 0xFF, 0xDF,
  0xFC, 0xFF, 0xC7, 0xFC, 0x3F, 0xC0, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0xBF, 0x00, 0x1F, 0x9F, 0x80, 0x1F, 0x8F, 0xC0, 0x0F, 0xC7, 0xE0, 0x0F,
  0xC3, 0xF0, 0x0F, 0xE1, 0xF8, 0x07, 0xE0, 0xFC, 0x07, 0xE0, 0x7E, 0x07,
  0xF0, 0x3F, 0x03, 0xF0, 0x1F, 0x83, 0xF0, 0x0F, 0xC3, 0xF8, 0x07, 0xE1,
  0xF8, 0x03, 0xF1, 0xF8, 0x01, 0xF9, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0x7E,
  0xFC, 0x00, 0x3F, 0x7F, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x07,
  0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x01, 0xFE, 0x7E, 0x00, 0xFE, 0x1F, 0x80,
  0x7E, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0x7E,
  0x07, 0xE0, 0x3F, 0x83, 0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xF0, 0xFC, 0x01,
  0xF8, 0x7E, 0x00, 0xFE, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x1F, 0xCF, 0xC0,
  0x07, 0xE7, 0xE0, 0x03, 0xFB, 0xF0, 0x00, 0xFD, 0xF8, 0x00, 0x7F, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xBE, 0x00, 0x07, 0xDF, 0xFB, 0xE0,
  0x00, 0x7D, 0xFF, 0xBE, 0x00, 0x07, 0xFF, 0xFD, 0xF0, 0x00, 0x7B, 0xFF,
  0xDF, 0x00, 0x0F, 0xBF, 0xFD, 0xF0, 0x00, 0xFB, 0xFF, 0xDF, 0x80, 0x0F,
  0xBF, 0xFC, 0xF8, 0x01, 0xF3, 0xFF, 0xCF, 0x80, 0x1F, 0x3F, 0xFC, 0xF8,
  0x01, 0xF3, 0xFF, 0xC7, 0xC0, 0x3E, 0x3F, 0xFC, 0x7C, 0x03, 0xE3, 0xFF,
  0xC7, 0xC0, 0x3E, 0x3F, 0xFC, 0x3E, 0x03, 0xC3, 0xFF, 0xC3, 0xE0, 0x7C,
  0x3F, 0xFC, 0x3E, 0x07, 0xC3, 0xFF, 0xC3, 0xF0, 0x78, 0x3F, 0xFC, 0x1F,
  0x0F, 0x83, 0xFF, 0xC1, 0xF0, 0xF8, 0x3F, 0xFC, 0x1F, 0x0F, 0x03, 0xFF,
  0xC0, 0xF9, 0xF0, 0x3F, 0xFC, 0x0F, 0x9F, 0x03, 0xFF, 0xC0, 0xF9, 0xF0,
  0x3F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xFC, 0x07,
  0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0xFC, 0x03, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xC0, 0x3F, 0xFC, 0x03, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0x80,
  0x3F, 0xFC, 0x01, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0x00, 0x3F, 0xFE, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE,
  0x00, 0x3F, 0xFB, 0xE0, 0x03, 0xFF, 0xBF, 0x00, 0x3F, 0xF9, 0xF0, 0x03,
  0xFF, 0xDF, 0x80, 0x3F, 0xFC, 0xF8, 0x03, 0xFF, 0xCF, 0xC0, 0x3F, 0xFC,
  0xFC, 0x03, 0xFF, 0xC7, 0xE0, 0x3F, 0xFC, 0x7E, 0x03, 0xFF, 0xC3, 0xF0,
  0x3F, 0xFC, 0x3F, 0x03, 0xFF, 0xC1, 0xF8, 0x3F, 0xFC, 0x1F, 0x83, 0xFF,
  0xC0, 0xFC, 0x3F, 0xFC, 0x0F, 0xC3, 0xFF, 0xC0, 0x7E, 0x3F, 0xFC, 0x07,
  0xE3, 0xFF, 0xC0, 0x3F, 0x3F, 0xFC, 0x03, 0xF3, 0xFF, 0xC0, 0x1F, 0xBF,
  0xFC, 0x01, 0xF9, 0xFF, 0xC0, 0x0F, 0xDF, 0xFC, 0x00, 0xFD, 0xFF, 0xC0,
  0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x06, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0x80, 0x7F, 0x07, 0xF8, 0x01, 0xFC, 0x3F,
  0x80, 0x07, 0xE1, 0xF8, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0xFC, 0xFC, 0x00,
  0x07, 0xE7, 0xE0, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xF7,
  0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x0F, 0xCF, 0xE0,
  0x00, 0x7E, 0x3F, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x3F, 0x07, 0xF0, 0x03,
  0xF8, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x10, 0x00, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF3, 0xF0, 0x1F, 0xEF, 0xC0, 0x3F, 0xBF, 0x00,
  0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0x07, 0xEF, 0xC0, 0x3F, 0xBF, 0x03, 0xFC, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xC0, 0xFF, 0xF8, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xC0, 0x7F, 0x80, 0x7F, 0x07, 0xF8, 0x01, 0xFC, 0x3F, 0x80,
  0x07, 0xE1, 0xF8, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0xFC, 0xFC, 0x00, 0x07,
  0xE7, 0xE0, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xF7, 0xE0,
  0x00, 0x1F, 0xBF, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x0F, 0xCF, 0xE0, 0x00,
  0x7E, 0x3F, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x3F, 0x07, 0xF0, 0x03, 0xF8,
  0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0x07, 0xE0, 0x3F, 0xC3, 0xF0, 0x0F, 0xE1, 0xF8, 0x03, 0xF8, 0xFC,
  0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x1F, 0x8F,
  0xC0, 0x0F, 0xC7, 0xE0, 0x07, 0xE3, 0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xF8,
  0xFC, 0x01, 0xF8, 0x7E, 0x01, 0xFC, 0x3F, 0x01, 0xFC, 0x1F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE,
  0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x1F, 0x81,
  0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x0F, 0xC1, 0xF8,
  0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x1F,
  0x80, 0x1F, 0x8F, 0xC0, 0x07, 0xE7, 0xE0, 0x03, 0xF3, 0xF0, 0x00, 0xFD,
  0xF8, 0x00, 0x7F, 0x00, 0x18, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xFE, 0x3F,
  0xFF, 0xF1, 0xFF, 0xFF, 0x1F, 0xFF, 0xF9, 0xFE, 0x03, 0xCF, 0xC0, 0x02,
  0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xE0,
  0x0F, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0,
  0x3F, 0xFE, 0x00, 0x0A, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80,
  0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8,
  0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF,
  0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F,
  0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00,
  0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00,
  0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF0,
  0x00, 0x7E, 0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xBF, 0x80, 0x1F, 0x8F,
  0xE0, 0x1F, 0xC7, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x08, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0x7C, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3E,
  0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7E, 0x3E, 0x00, 0x07, 0xE3, 0xF0,
  0x00, 0x7C, 0x3F, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0xFC, 0x1F, 0x00, 0x0F,
  0x81, 0xF8, 0x00, 0xF8, 0x1F, 0x80, 0x1F, 0x80, 0xF8, 0x01, 0xF8, 0x0F,
  0xC0, 0x1F, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0x7C, 0x03,
  0xF0, 0x07, 0xE0, 0x3E, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xE0, 0x7E, 0x00,
  0x3E, 0x07, 0xC0, 0x03, 0xF0, 0x7C, 0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF0,
  0xFC, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF8, 0xF8, 0x00, 0x0F, 0x9F, 0x80,
  0x00, 0xF9, 0xF0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x07,
  0xDF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xFF,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF7, 0xE0,
  0x01, 0xFC, 0x00, 0x3E, 0x7E, 0x00, 0x3F, 0xC0, 0x07, 0xE7, 0xE0, 0x03,
  0xFC, 0x00, 0x7E, 0x3E, 0x00, 0x3F, 0xC0, 0x07, 0xE3, 0xE0, 0x03, 0xFC,
  0x00, 0x7E, 0x3F, 0x00, 0x3F, 0xE0, 0x07, 0xC3, 0xF0, 0x07, 0xFE, 0x00,
  0xFC, 0x3F, 0x00, 0x7D, 0xE0, 0x0F, 0xC1, 0xF0, 0x07, 0xDE, 0x00, 0xFC,
  0x1F, 0x00, 0x79, 0xF0, 0x0F, 0x81, 0xF8, 0x0F, 0x9F, 0x00, 0xF8, 0x1F,
  0x80, 0xF9, 0xF0, 0x1F, 0x80, 0xF8, 0x0F, 0x9F, 0x01, 0xF8, 0x0F, 0x80,
  0xF8, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0x0F, 0x81, 0xF0, 0x0F, 0xC1, 0xF0,
  0xF8, 0x1F, 0x00, 0xFC, 0x1F, 0x0F, 0x83, 0xF0, 0x07, 0xC1, 0xF0, 0x78,
  0x3F, 0x00, 0x7C, 0x1F, 0x07, 0xC3, 0xE0, 0x07, 0xE3, 0xE0, 0x7C, 0x3E,
  0x00, 0x7E, 0x3E, 0x07, 0xC7, 0xE0, 0x03, 0xE3, 0xE0, 0x7C, 0x7E, 0x00,
  0x3E, 0x3E, 0x03, 0xC7, 0xE0, 0x03, 0xE3, 0xC0, 0x3E, 0x7C, 0x00, 0x3F,
  0x7C, 0x03, 0xE7, 0xC0, 0x03, 0xF7, 0xC0, 0x3E, 0x7C, 0x00, 0x1F, 0x7C,
  0x01, 0xEF, 0xC0, 0x01, 0xF7, 0xC0, 0x1E, 0xF8, 0x00, 0x1F, 0x78, 0x01,
  0xFF, 0x80, 0x01, 0xF7, 0x80, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x7E, 0x00,
  0x0F, 0xC7, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0x81,
  0xF8, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x3E, 0x03,
  0xE0, 0x07, 0xE0, 0xFC, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0xC7, 0xE0, 0x00,
  0xF8, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x3F, 0xF8,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x3F,
  0x7E, 0x00, 0x07, 0xCF, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x1F, 0x80,
  0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x03, 0xF0, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x83,
  0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x1F, 0x80, 0x03, 0xF7, 0xF0, 0x00,
  0x7F, 0xFC, 0x00, 0x0F, 0xDF, 0x80, 0x03, 0xE7, 0xE0, 0x01, 0xF9, 0xF8,
  0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x03, 0xE0,
  0x7E, 0x01, 0xF8, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x0F,
  0xC0, 0x1F, 0x03, 0xE0, 0x07, 0xE1, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x3F,
  0x1F, 0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xF3, 0xE0, 0x00, 0x7F, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x7F,
  0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xDF, 0x00, 0x01,
  0xF3, 0xC0, 0x00, 0x7C, 0xF8, 0x00, 0x3E, 0x1E, 0x00, 0x0F, 0x87, 0xC0,
  0x07, 0xC0, 0xF0, 0x01, 0xF0, 0x3E, 0x00, 0xF8, 0x07, 0x80, 0x3E, 0x01,
  0xF0, 0x1F, 0x00, 0x7C, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x03, 0xE0, 0xF8,
  0x00, 0x7C, 0x7E, 0x00, 0x1F, 0x1F, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xE0,
  0x3F, 0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF,
  0x07, 0x01, 0xF8, 0x20, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x81, 0xFF, 0xFC,
  0x3F, 0xFF, 0xE3, 0xFF, 0xFF, 0x3F, 0xF1, 0xFB, 0xF8, 0x0F, 0xDF, 0x80,
  0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0x80, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0xDF, 0x83, 0xFE, 0xFF, 0xFD,
  0xF3, 0xFF, 0xCF, 0x9F, 0xFC, 0x7C, 0x3F, 0xC1, 0xE0, 0x20, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x81, 0xE0,
  0x1F, 0x1F, 0xF0, 0x3E, 0x7F, 0xF8, 0x7D, 0xFF, 0xF0, 0xFB, 0xFF, 0xF1,
  0xFF, 0x0F, 0xF3, 0xFC, 0x07, 0xE7, 0xF0, 0x0F, 0xCF, 0xC0, 0x0F, 0xDF,
  0x80, 0x1F, 0xBF, 0x00, 0x3F, 0x7E, 0x00, 0x3E, 0xF8, 0x00, 0x7D, 0xF0,
  0x00, 0xFB, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00,
  0x0F, 0xFE, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0xFC, 0x00, 0x7D, 0xF8, 0x01,
  0xFB, 0xF0, 0x03, 0xF7, 0xE0, 0x07, 0xEF, 0xE0, 0x1F, 0x9F, 0xE0, 0x3F,
  0x3F, 0xE1, 0xFC, 0x7F, 0xFF, 0xF8, 0xFB, 0xFF, 0xE1, 0xF3, 0xFF, 0x83,
  0xC3, 0xFE, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0xFF, 0xE0, 0xFF,
  0xFC, 0x7F, 0xFF, 0x3F, 0xFF, 0x8F, 0xE0, 0xE7, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x1F, 0xC0, 0x13, 0xFC, 0x3C, 0xFF, 0xFF, 0x1F, 0xFF, 0xC3,
  0xFF, 0xF0, 0x3F, 0xF0, 0x01, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x0F, 0x83, 0xE0, 0x7F, 0xC7, 0xC3, 0xFF,
  0xCF, 0x87, 0xFF, 0xDF, 0x1F, 0xFF, 0xBE, 0x7F, 0x87, 0xFC, 0xFC, 0x03,
  0xF9, 0xF8, 0x07, 0xF7, 0xE0, 0x07, 0xEF, 0xC0, 0x0F, 0xDF, 0x80, 0x1F,
  0xBE, 0x00, 0x3F, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF,
  0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xDF, 0x00, 0x0F, 0xBE,
  0x00, 0x1F, 0x7C, 0x00, 0x7E, 0xFC, 0x00, 0xFD, 0xF8, 0x01, 0xFB, 0xF0,
  0x03, 0xF3, 0xF0, 0x0F, 0xE7, 0xE0, 0x3F, 0xCF, 0xF0, 0xFF, 0x8F, 0xFF,
  0xDF, 0x0F, 0xFF, 0xBE, 0x0F, 0xFE, 0x7C, 0x0F, 0xF0, 0x78, 0x01, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83,
  0xFF, 0xFE, 0x1F, 0x83, 0xF1, 0xF8, 0x0F, 0xCF, 0x80, 0x3E, 0xFC, 0x01,
  0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x8F, 0xF0, 0x3C,
  0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x02,
  0x80, 0x00, 0x7E, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xF0,
  0x7F, 0x08, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x01, 0xFF, 0xF3, 0xFF, 0xF9, 0xFF, 0xFC, 0xFF,
  0xFE, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xFC, 0x7C, 0x1F, 0xFC, 0xF8, 0x7F, 0xFD, 0xF1, 0xFF, 0xFF, 0xE7,
  0xF8, 0x7F, 0xCF, 0xC0, 0x3F, 0x9F, 0x80, 0x7F, 0x7E, 0x00, 0x7E, 0xFC,
  0x00, 0xFD, 0xF8, 0x01, 0xFB, 0xE0, 0x03, 0xF7, 0xC0, 0x03, 0xEF, 0x80,
  0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00,
  0x7D, 0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xF7, 0xC0, 0x07, 0xEF, 0xC0, 0x0F,
  0xDF, 0x80, 0x1F, 0xBF, 0x00, 0x3F, 0x3F, 0x00, 0xFE, 0x7E, 0x03, 0xFC,
  0xFF, 0x0F, 0xF8, 0xFF, 0xFD, 0xF0, 0xFF, 0xFB, 0xE0, 0xFF, 0xE7, 0xC0,
  0xFF, 0x0F, 0x80, 0x10, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x8C, 0x00,
  0x7F, 0x1F, 0x87, 0xFC, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x00, 0x7F, 0xFC, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x81, 0xE0, 0x7C, 0x7F, 0xE3, 0xE7, 0xFF, 0x9F, 0x7F, 0xFE, 0xFF, 0xFF,
  0xF7, 0xFC, 0x3F, 0xBF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xFE,
  0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00,
  0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3E, 0x38, 0xF9, 0xFF,
  0xF7, 0xEF, 0x9F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xCF, 0x9F, 0x3E, 0x7C,
  0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F,
  0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF8, 0x01, 0xC0,
  0x3E, 0x03, 0xF0, 0x7F, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x7E, 0xCF, 0xEF, 0xFC, 0xFF, 0xCF, 0xF8, 0xFF, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x07, 0xEF,
  0x80, 0x3F, 0x3E, 0x01, 0xF8, 0xF8, 0x07, 0xE3, 0xE0, 0x3F, 0x0F, 0x81,
  0xF8, 0x3E, 0x0F, 0xC0, 0xF8, 0x3F, 0x03, 0xE1, 0xF8, 0x0F, 0x8F, 0xC0,
  0x3E, 0x3E, 0x00, 0xF9, 0xF8, 0x03, 0xEF, 0xC0, 0x0F, 0xBF, 0x80, 0x3F,
  0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xFD, 0xF8, 0x0F, 0xE7, 0xE0, 0x3F, 0x0F,
  0xC0, 0xF8, 0x3F, 0x03, 0xE0, 0x7E, 0x0F, 0x81, 0xF8, 0x3E, 0x03, 0xF0,
  0xF8, 0x0F, 0xC3, 0xE0, 0x1F, 0x8F, 0x80, 0x7E, 0x3E, 0x00, 0xFC, 0xF8,
  0x03, 0xFB, 0xE0, 0x07, 0xEF, 0x80, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x3E, 0x00, 0x7C, 0x0F, 0x0F, 0xF8, 0x1F, 0xF0, 0xF9, 0xFF, 0xC3, 0xFF,
  0x8F, 0xBF, 0xFE, 0x7F, 0xFC, 0xFF, 0xFF, 0xEF, 0xFF, 0xEF, 0xF8, 0x7F,
  0xF0, 0xFE, 0xFE, 0x03, 0xFC, 0x07, 0xEF, 0xE0, 0x3F, 0xC0, 0x3E, 0xFC,
  0x01, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0x80, 0x3F, 0xFC, 0x01, 0xF8, 0x03,
  0xFF, 0xC0, 0x1F, 0x80, 0x3F, 0xF8, 0x01, 0xF8, 0x03, 0xFF, 0x80, 0x1F,
  0x80, 0x3F, 0xF8, 0x01, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0x80, 0x3F, 0xF8,
  0x01, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0x80, 0x3F, 0xF8, 0x01, 0xF8, 0x03,
  0xFF, 0x80, 0x1F, 0x80, 0x3F, 0xF8, 0x01, 0xF8, 0x03, 0xFF, 0x80, 0x1F,
  0x80, 0x3F, 0xF8, 0x01, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0x80, 0x3F, 0xF8,
  0x01, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0x80, 0x3F, 0xF8, 0x01, 0xF8, 0x03,
  0xFF, 0x80, 0x1F, 0x80, 0x3F, 0xF8, 0x01, 0xF8, 0x03, 0xFF, 0x80, 0x1F,
  0x80, 0x3F, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x3E, 0x07, 0x87, 0xFE,
  0x3E, 0x7F, 0xF9, 0xF7, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xC3, 0xFF, 0xF8,
  0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F,
  0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00,
  0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x01, 0xFF, 0x80, 0x07,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xC1, 0xF8, 0x3F,
  0x00, 0xFC, 0x3F, 0x00, 0x7C, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E,
  0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7C,
  0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x3E, 0x7E, 0x00, 0x3E, 0x7E,
  0x00, 0x7E, 0x3E, 0x00, 0x7E, 0x3F, 0x00, 0xFC, 0x3F, 0x80, 0xFC, 0x1F,
  0xC3, 0xF8, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x01,
  0xFF, 0x80, 0x00, 0x18, 0x00, 0x00, 0x3E, 0x01, 0xE1, 0xFF, 0x03, 0xE7,
  0xFF, 0x87, 0xDF, 0xFF, 0x0F, 0xBF, 0xFF, 0x1F, 0xF0, 0x7F, 0x3F, 0x80,
  0x7E, 0x7F, 0x00, 0xFC, 0xFC, 0x00, 0xFD, 0xF8, 0x01, 0xFB, 0xF0, 0x03,
  0xF7, 0xE0, 0x03, 0xEF, 0x80, 0x07, 0xDF, 0x00, 0x0F, 0xBE, 0x00, 0x1F,
  0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xF7,
  0xE0, 0x03, 0xEF, 0xC0, 0x07, 0xDF, 0x80, 0x1F, 0xBF, 0x00, 0x3F, 0x7E,
  0x00, 0x7E, 0xFE, 0x01, 0xF9, 0xFE, 0x07, 0xF3, 0xFE, 0x1F, 0xC7, 0xDF,
  0xFF, 0x8F, 0xBF, 0xFE, 0x1F, 0x3F, 0xF8, 0x3E, 0x1F, 0xE0, 0x7C, 0x04,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xFC, 0x7C, 0x1F, 0xFC, 0xF8, 0x7F, 0xFD, 0xF1,
  0xFF, 0xFF, 0xE7, 0xF8, 0x7F, 0xCF, 0xC0, 0x3F, 0x9F, 0x80, 0x7F, 0x7E,
  0x00, 0x7E, 0xFC, 0x00, 0xFD, 0xF8, 0x01, 0xFB, 0xE0, 0x03, 0xF7, 0xC0,
  0x03, 0xEF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00,
  0x3F, 0xF8, 0x00, 0x7D, 0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xF7, 0xC0, 0x07,
  0xEF, 0xC0, 0x0F, 0xDF, 0x80, 0x1F, 0xBF, 0x00, 0x3F, 0x3F, 0x00, 0xFE,
  0x7E, 0x03, 0xFC, 0xFF, 0x0F, 0xF8, 0xFF, 0xFD, 0xF0, 0xFF, 0xFB, 0xE0,
  0xFF, 0xE7, 0xC0, 0xFF, 0x0F, 0x80, 0x10, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x3D, 0xE1, 0xFF, 0xC7,
  0xFF, 0xCF, 0xFF, 0xBF, 0xDF, 0xFF, 0xBF, 0xE0, 0x7F, 0x80, 0xFE, 0x01,
  0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x03, 0xFF, 0xC1, 0xFF,
  0xFC, 0xFF, 0xFE, 0x7F, 0xFF, 0xBF, 0x81, 0xCF, 0xC0, 0x13, 0xE0, 0x00,
  0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x80, 0x0F,
  0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x07,
  0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x80, 0x0F, 0xF0, 0x03, 0xFF, 0x83, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0x3F,
  0xFF, 0x83, 0xFF, 0x80, 0x07, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC2, 0x1F, 0xFC, 0x3F, 0xF8,
  0x3F, 0xF0, 0x3F, 0xE0, 0x06, 0x00, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80,
  0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x7F, 0xFE, 0x07, 0xFB,
  0xF8, 0xFF, 0xDF, 0xFF, 0xBE, 0x7F, 0xFD, 0xF3, 0xFF, 0xCF, 0x87, 0xFC,
  0x3C, 0x02, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7E, 0x00,
  0x3E, 0x7E, 0x00, 0x7E, 0x3E, 0x00, 0x7E, 0x3E, 0x00, 0x7C, 0x3F, 0x00,
  0x7C, 0x3F, 0x00, 0xFC, 0x1F, 0x00, 0xFC, 0x1F, 0x00, 0xF8, 0x1F, 0x81,
  0xF8, 0x0F, 0x81, 0xF8, 0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0xC3,
  0xF0, 0x07, 0xC3, 0xE0, 0x07, 0xC3, 0xE0, 0x07, 0xE3, 0xE0, 0x03, 0xE7,
  0xE0, 0x03, 0xE7, 0xC0, 0x03, 0xE7, 0xC0, 0x01, 0xE7, 0xC0, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFD, 0xF0, 0x03, 0xF8, 0x03, 0xE7, 0xE0, 0x1F, 0xE0, 0x0F,
  0x9F, 0x80, 0x7F, 0x80, 0x7E, 0x3E, 0x01, 0xFE, 0x01, 0xF8, 0xF8, 0x07,
  0xF8, 0x07, 0xC3, 0xF0, 0x3F, 0xF0, 0x1F, 0x0F, 0xC0, 0xFB, 0xC0, 0xFC,
  0x1F, 0x03, 0xCF, 0x03, 0xF0, 0x7C, 0x0F, 0x3C, 0x0F, 0x81, 0xF0, 0x3C,
  0xF8, 0x3E, 0x07, 0xE1, 0xF3, 0xE0, 0xF8, 0x1F, 0x87, 0xC7, 0x87, 0xE0,
  0x3E, 0x1E, 0x1E, 0x1F, 0x00, 0xF8, 0x78, 0x78, 0x7C, 0x03, 0xF3, 0xE1,
  0xF1, 0xF0, 0x0F, 0xCF, 0x87, 0xCF, 0xC0, 0x1F, 0x3E, 0x0F, 0x3E, 0x00,
  0x7C, 0xF0, 0x3C, 0xF8, 0x01, 0xF3, 0xC0, 0xF3, 0xE0, 0x07, 0xCF, 0x03,
  0xEF, 0x80, 0x0F, 0x7C, 0x0F, 0xBC, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0xFC,
  0xFC, 0x01, 0xF0, 0xF8, 0x07, 0xE1, 0xF8, 0x0F, 0x81, 0xF0, 0x3F, 0x03,
  0xF0, 0x7C, 0x03, 0xE1, 0xF8, 0x07, 0xE3, 0xE0, 0x07, 0xCF, 0xC0, 0x0F,
  0xDF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x0F, 0xFE, 0x00, 0x3F, 0x7C, 0x00, 0x7C, 0xFC, 0x01, 0xF8, 0xF8,
  0x03, 0xE1, 0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0x03, 0xF0, 0x7E, 0x07, 0xE0,
  0xF8, 0x07, 0xE3, 0xF0, 0x0F, 0xCF, 0xC0, 0x0F, 0xDF, 0x80, 0x1F, 0xC0,
  0xFC, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7E, 0x00, 0x3E, 0x7E, 0x00, 0x7E,
  0x3E, 0x00, 0x7E, 0x3F, 0x00, 0x7C, 0x3F, 0x00, 0x7C, 0x1F, 0x00, 0xFC,
  0x1F, 0x00, 0xFC, 0x1F, 0x80, 0xF8, 0x0F, 0x81, 0xF8, 0x0F, 0x81, 0xF8,
  0x0F, 0x81, 0xF0, 0x0F, 0xC1, 0xF0, 0x07, 0xC3, 0xF0, 0x07, 0xC3, 0xE0,
  0x07, 0xE3, 0xE0, 0x03, 0xE3, 0xE0, 0x03, 0xE7, 0xE0, 0x03, 0xE7, 0xC0,
  0x01, 0xF7, 0xC0, 0x01, 0xF7, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x47, 0xF0, 0x00, 0x7F, 0xF0, 0x00,
  0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8,
  0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x07,
  0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x1F, 0x00, 0x7F, 0x00, 0xFF, 0x01, 0xFF, 0x03, 0xFE, 0x03,
  0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0xFF, 0x80, 0xFF,
  0x00, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x00,
  0x7F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0x00, 0x3F, 0xE0, 0x1F, 0xF8, 0x03, 0xFC,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F,
  0xC0, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x1F, 0x80, 0x7F, 0xC0, 0x7F, 0xE0,
  0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x0F,
  0xFC, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFC, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x02, 0x7F, 0xC0, 0x05, 0xFF, 0xE0, 0x1F, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0x40, 0x03, 0xF8,
};

const GFXglyph NotoSans_Condensed_Medium56pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 8, 41, 14, 3, -40 },
  { 42, 17, 14, 23, 3, -40 },
  { 72, 27, 40, 29, 1, -40 },
  { 207, 21, 46, 27, 3, -43 },
  { 328, 37, 42, 42, 2, -41 },
  { 523, 30, 42, 32, 2, -41 },
  { 681, 6, 14, 12, 3, -40 },
  { 692, 12, 49, 17, 3, -40 },
  { 766, 13, 49, 17, 1, -40 },
  { 846, 21, 22, 25, 2, -43 },
  { 904, 23, 27, 27, 2, -33 },
  { 982, 9, 13, 14, 2, -6 },
  { 997, 13, 6, 17, 2, -18 },
  { 1007, 7, 8, 14, 3, -7 },
  { 1014, 20, 40, 21, 1, -40 },
  { 1114, 22, 42, 27, 2, -41 },
  { 1230, 14, 40, 27, 4, -40 },
  { 1300, 22, 41, 27, 2, -41 },
  { 1413, 22, 42, 27, 2, -41 },
  { 1529, 25, 40, 27, 1, -40 },
  { 1654, 21, 41, 27, 3, -40 },
  { 1762, 23, 41, 27, 2, -40 },
  { 1880, 23, 40, 27, 2, -40 },
  { 1995, 23, 42, 27, 2, -41 },
  { 2116, 22, 41, 27, 2, -40 },
  { 2229, 7, 32, 14, 3, -31 },
  { 2257, 8, 38, 14, 2, -31 },
  { 2295, 23, 26, 27, 2, -33 },
  { 2370, 23, 16, 27, 2, -28 },
  { 2416, 23, 26, 27, 2, -33 },
  { 2491, 18, 42, 21, 1, -41 },
  { 2586, 36, 45, 41, 3, -40 },
  { 2789, 30, 40, 30, 0, -40 },
  { 2939, 24, 40, 30, 4, -40 },
  { 3059, 24, 42, 29, 3, -41 },
  { 3185, 26, 40, 33, 4, -40 },
  { 3315, 19, 40, 25, 4, -40 },
  { 3410, 19, 40, 24, 4, -40 },
  { 3505, 27, 42, 34, 3, -41 },
  { 3647, 26, 40, 34, 4, -40 },
  { 3777, 14, 40, 17, 2, -40 },
  { 3847, 13, 51, 14, -3, -40 },
  { 3930, 25, 40, 29, 4, -40 },
  { 4055, 19, 40, 24, 4, -40 },
  { 4150, 36, 40, 44, 4, -40 },
  { 4330, 28, 40, 36, 4, -40 },
  { 4470, 29, 42, 35, 3, -41 },
  { 4623, 22, 40, 28, 4, -40 },
  { 4733, 29, 51, 35, 3, -41 },
  { 4918, 25, 40, 29, 4, -40 },
  { 5043, 21, 42, 26, 2, -41 },
  { 5154, 23, 40, 25, 1, -40 },
  { 5269, 25, 41, 33, 4, -40 },
  { 5398, 28, 40, 28, 0, -40 },
  { 5538, 44, 40, 44, 0, -40 },
  { 5758, 27, 40, 27, 0, -40 },
  { 5893, 26, 40, 26, 0, -40 },
  { 6023, 22, 40, 24, 1, -40 },
  { 6133, 12, 49, 18, 4, -40 },
  { 6207, 20, 40, 21, 1, -40 },
  { 6307, 12, 49, 18, 2, -40 },
  { 6381, 26, 23, 28, 1, -40 },
  { 6456, 24, 3, 24, 0, 5 },
  { 6465, 12, 9, 16, 2, -43 },
  { 6479, 21, 32, 26, 2, -31 },
  { 6563, 23, 44, 29, 4, -43 },
  { 6690, 18, 32, 22, 3, -31 },
  { 6762, 23, 44, 29, 2, -43 },
  { 6889, 21, 32, 26, 3, -31 },
  { 6973, 17, 43, 16, 1, -43 },
  { 7065, 23, 44, 29, 2, -31 },
  { 7192, 21, 43, 29, 4, -43 },
  { 7305, 7, 42, 13, 3, -42 },
  { 7342, 12, 55, 13, -2, -42 },
  { 7425, 22, 43, 26, 4, -43 },
  { 7544, 5, 43, 13, 4, -43 },
  { 7571, 36, 31, 43, 4, -31 },
  { 7711, 21, 31, 29, 4, -31 },
  { 7793, 24, 32, 28, 2, -31 },
  { 7889, 23, 44, 29, 4, -31 },
  { 8016, 23, 44, 29, 2, -31 },
  { 8143, 15, 31, 20, 4, -31 },
  { 8202, 18, 32, 22, 2, -31 },
  { 8274, 15, 38, 17, 1, -37 },
  { 8346, 21, 31, 29, 4, -30 },
  { 8428, 24, 30, 24, 0, -30 },
  { 8518, 38, 30, 38, 0, -30 },
  { 8661, 23, 30, 24, 1, -30 },
  { 8748, 24, 43, 24, 0, -30 },
  { 8877, 17, 30, 21, 2, -30 },
  { 8941, 16, 49, 20, 2, -40 },
  { 9039, 5, 56, 26, 10, -43 },
  { 9074, 17, 49, 20, 2, -40 },
  { 9179, 23, 8, 27, 2, -24 },
};

const GFXfont NotoSans_Condensed_Medium56pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Medium56pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Medium56pt7bGlyphs,
  0x20, 0x7E, 76
};

#endif // _NOTOSANS_CONDENSED_MEDIUM56PT7B_H_
