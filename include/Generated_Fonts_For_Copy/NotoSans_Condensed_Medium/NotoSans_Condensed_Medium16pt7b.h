#ifndef _NOTOSANS_CONDENSED_MEDIUM16PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUM16PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Medium.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Medium16pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0x3C, 0xDE, 0xA5, 0x20, 0x12, 0x12, 0x16, 0x7F, 0x34,
  0x24, 0xFF, 0xFF, 0x24, 0x2C, 0x68, 0x21, 0xEF, 0xE8, 0xA3, 0x83, 0x8B,
  0x26, 0xBF, 0x88, 0x20, 0x40, 0x38, 0xCB, 0x22, 0x58, 0x94, 0x2D, 0x6E,
  0xB5, 0x29, 0x1A, 0x44, 0x91, 0x34, 0x87, 0x30, 0x78, 0xC8, 0xC8, 0x58,
  0x70, 0x73, 0xDA, 0x8E, 0x8E, 0xCE, 0x7B, 0xFA, 0x6B, 0x69, 0x24, 0x9B,
  0x26, 0x40, 0xC2, 0x23, 0x31, 0x11, 0x33, 0x22, 0x6C, 0x20, 0x8F, 0xCC,
  0x53, 0x60, 0x20, 0x82, 0x3F, 0x20, 0x82, 0x00, 0xFA, 0xF0, 0xF0, 0x0C,
  0x21, 0x84, 0x10, 0xC2, 0x08, 0x61, 0x0C, 0x00, 0x31, 0xEC, 0xA3, 0x8E,
  0x38, 0xE3, 0x8F, 0x3C, 0x9E, 0x37, 0xD1, 0x11, 0x11, 0x11, 0x10, 0x23,
  0xE8, 0xC3, 0x0C, 0x21, 0x8C, 0x61, 0x0C, 0x3F, 0x23, 0xE8, 0xC3, 0x09,
  0xE7, 0x83, 0x0C, 0x39, 0xFE, 0x0C, 0x38, 0x51, 0xA2, 0x4C, 0x91, 0x7F,
  0xFE, 0x08, 0x10, 0xFB, 0x0C, 0x30, 0xFA, 0x70, 0xC3, 0x0E, 0x6F, 0x80,
  0x19, 0xE4, 0x30, 0x82, 0xEC, 0xE3, 0x8F, 0x3C, 0xDE, 0xFE, 0x0C, 0x10,
  0x60, 0xC1, 0x06, 0x0C, 0x10, 0x60, 0xC0, 0x33, 0xEC, 0xE3, 0xC9, 0xE7,
  0xB3, 0x8E, 0x3C, 0xDE, 0x23, 0xEC, 0xA3, 0x8E, 0x3F, 0xDF, 0x0C, 0x21,
  0xBC, 0xF8, 0x03, 0xC0, 0xF8, 0x03, 0xE8, 0x0C, 0xEE, 0x30, 0x70, 0x70,
  0x40, 0xFC, 0x00, 0x3F, 0xFC, 0x81, 0x81, 0x83, 0x3B, 0x88, 0x00, 0x33,
  0xE0, 0x83, 0x08, 0x63, 0x08, 0x20, 0x02, 0x18, 0x04, 0x0F, 0xC6, 0x09,
  0x03, 0x9E, 0x64, 0x99, 0x26, 0xC9, 0x96, 0x67, 0x6C, 0x01, 0x80, 0x3F,
  0x00, 0x18, 0x1C, 0x34, 0x34, 0x26, 0x26, 0x7E, 0x7E, 0x43, 0xC3, 0xC1,
  0xFD, 0x8F, 0x1E, 0x3F, 0xDF, 0xB1, 0xE3, 0xC7, 0x9F, 0xF0, 0x18, 0xFD,
  0x86, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x81, 0x89, 0xE0, 0xFC, 0xC6, 0xC6,
  0xC2, 0xC3, 0xC3, 0xC3, 0xC2, 0xC6, 0xCC, 0xF8, 0xFE, 0x31, 0x8F, 0xFF,
  0x18, 0xC6, 0x3E, 0xFE, 0x31, 0x8C, 0x7F, 0x18, 0xC6, 0x30, 0x0C, 0x3F,
  0x61, 0xC0, 0xC0, 0xC0, 0xCF, 0xC3, 0xC3, 0xC3, 0x63, 0x3F, 0xC3, 0x87,
  0x0E, 0x1F, 0xFF, 0xF0, 0xE1, 0xC3, 0x87, 0x08, 0xE9, 0x24, 0x92, 0x4B,
  0x80, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x3E, 0xC7, 0x9B, 0x26, 0xCF,
  0x1E, 0x36, 0x64, 0xCD, 0x8F, 0x18, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0F, 0xC0, 0xE0, 0xF8, 0x7E, 0x1F, 0xC5, 0xD1, 0x74, 0xDD, 0xA7,
  0x69, 0xCE, 0x73, 0x1C, 0xC4, 0xE1, 0xE1, 0xF1, 0xF1, 0xD9, 0xD9, 0xCD,
  0xCD, 0xC7, 0xC7, 0xC3, 0x18, 0x7E, 0x42, 0xC3, 0xC3, 0xC1, 0xC1, 0xC3,
  0xC3, 0xC3, 0x66, 0x3C, 0xFF, 0x3C, 0x71, 0xCF, 0xFF, 0x30, 0xC3, 0x0C,
  0x00, 0x18, 0x7E, 0x43, 0xC3, 0xC3, 0xC1, 0xC1, 0xC3, 0xC3, 0xC3, 0x66,
  0x3C, 0x04, 0x06, 0x03, 0xFD, 0x9B, 0x1E, 0x2C, 0xDF, 0x36, 0x64, 0xCD,
  0x8B, 0x18, 0x33, 0xFC, 0x20, 0xC3, 0x83, 0x86, 0x0C, 0x39, 0xBC, 0xFE,
  0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0xC3, 0x87, 0x0E,
  0x1C, 0x38, 0x70, 0xE1, 0xC2, 0xCD, 0xF0, 0xC3, 0x43, 0x42, 0x66, 0x66,
  0x24, 0x24, 0x3C, 0x3C, 0x18, 0x18, 0xC6, 0x1E, 0x38, 0x91, 0xCC, 0xCA,
  0x66, 0xD3, 0x36, 0x90, 0xA6, 0x85, 0x3C, 0x28, 0xE1, 0xC6, 0x0E, 0x30,
  0xC6, 0x64, 0x2C, 0x3C, 0x18, 0x18, 0x38, 0x2C, 0x64, 0x46, 0xC3, 0xC6,
  0x8D, 0x91, 0x63, 0x87, 0x06, 0x0C, 0x18, 0x30, 0x60, 0x7C, 0x18, 0x30,
  0xC1, 0x86, 0x0C, 0x10, 0x60, 0x83, 0xF8, 0xFC, 0xCC, 0xCC, 0xCC, 0xCC,
  0xCC, 0xFF, 0xC1, 0x06, 0x08, 0x30, 0xC1, 0x06, 0x08, 0x20, 0xC0, 0xF3,
  0x33, 0x33, 0x33, 0x33, 0x33, 0xFF, 0x18, 0x18, 0x2C, 0x24, 0x66, 0xC3,
  0xFE, 0xCC, 0x73, 0x60, 0x83, 0xFE, 0x38, 0xE7, 0xEC, 0xC1, 0x83, 0x06,
  0xCF, 0xD8, 0xB1, 0xE3, 0xC7, 0x8B, 0x35, 0xC0, 0x3F, 0xF1, 0x08, 0x43,
  0x19, 0x78, 0x04, 0x10, 0x5D, 0xFF, 0x38, 0x61, 0x87, 0x3C, 0xDD, 0x33,
  0xEC, 0xE3, 0xFE, 0x0C, 0x31, 0x7C, 0x3B, 0x18, 0xFF, 0xB1, 0x8C, 0x63,
  0x18, 0xC0, 0x77, 0xFC, 0xE1, 0x86, 0x1C, 0xF3, 0x74, 0x10, 0xFF, 0x70,
  0xC3, 0x0C, 0x36, 0xFF, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xF3, 0xFF, 0xFF,
  0x6C, 0x36, 0xDB, 0x6D, 0xB6, 0xF6, 0xC3, 0x0C, 0x33, 0xCB, 0x6F, 0x3C,
  0xDB, 0x6C, 0xF3, 0xFF, 0xFF, 0xFF, 0x99, 0xBF, 0xFC, 0xC7, 0x31, 0xCC,
  0x73, 0x1C, 0xC7, 0x31, 0xCC, 0x40, 0x9B, 0xFC, 0x71, 0xC7, 0x1C, 0x71,
  0xC4, 0x33, 0xFC, 0xE1, 0x86, 0x1C, 0x73, 0x78, 0x99, 0xFB, 0x16, 0x3C,
  0x78, 0xF1, 0x66, 0xF9, 0x83, 0x06, 0x0C, 0x00, 0x77, 0xFC, 0xE1, 0x86,
  0x1C, 0xF3, 0x74, 0x10, 0x41, 0x04, 0x9B, 0xCC, 0xCC, 0xCC, 0xC0, 0x7F,
  0xA1, 0x87, 0x18, 0x73, 0xF0, 0x23, 0x1F, 0xF6, 0x31, 0x8C, 0x63, 0x0E,
  0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0xF3, 0x74, 0xC7, 0x8D, 0x12, 0x66, 0xC5,
  0x0A, 0x1C, 0x30, 0xC4, 0x79, 0xC9, 0x29, 0x25, 0x66, 0xAC, 0xF5, 0x8C,
  0xE1, 0x8C, 0x31, 0x80, 0xC6, 0xD9, 0xB1, 0xC3, 0x07, 0x0A, 0x36, 0xC6,
  0xC7, 0x8D, 0x13, 0x66, 0xC5, 0x0A, 0x1C, 0x10, 0x20, 0xC7, 0x0E, 0x00,
  0x7B, 0xC6, 0x23, 0x11, 0x88, 0xF8, 0x19, 0x8C, 0x63, 0x1B, 0x06, 0x31,
  0x8C, 0x61, 0x84, 0xFF, 0xFF, 0xC6, 0x66, 0x66, 0x16, 0x66, 0x66, 0xC8,
  0xC7, 0xF0,
};

const GFXglyph NotoSans_Condensed_Medium16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 2, 11, 4, 1, -11 },
  { 4, 5, 4, 7, 1, -11 },
  { 7, 8, 11, 8, 0, -11 },
  { 18, 6, 13, 8, 1, -12 },
  { 28, 10, 12, 12, 1, -12 },
  { 43, 8, 12, 9, 1, -12 },
  { 55, 2, 4, 4, 1, -11 },
  { 56, 3, 14, 5, 1, -11 },
  { 62, 4, 14, 5, 0, -11 },
  { 69, 6, 6, 7, 1, -12 },
  { 74, 6, 7, 8, 1, -9 },
  { 80, 2, 4, 4, 1, -2 },
  { 81, 4, 1, 5, 0, -5 },
  { 82, 2, 2, 4, 1, -2 },
  { 83, 6, 11, 6, 0, -11 },
  { 92, 6, 12, 8, 1, -12 },
  { 101, 4, 11, 8, 1, -11 },
  { 107, 6, 12, 8, 1, -12 },
  { 116, 6, 12, 8, 1, -12 },
  { 125, 7, 11, 8, 0, -11 },
  { 135, 6, 11, 8, 1, -11 },
  { 144, 6, 12, 8, 1, -12 },
  { 153, 7, 11, 8, 0, -11 },
  { 163, 6, 12, 8, 1, -12 },
  { 172, 6, 12, 8, 1, -12 },
  { 181, 2, 9, 4, 1, -9 },
  { 184, 2, 11, 4, 1, -9 },
  { 187, 6, 7, 8, 1, -9 },
  { 193, 6, 5, 8, 1, -8 },
  { 197, 6, 7, 8, 1, -9 },
  { 203, 6, 12, 6, 0, -12 },
  { 212, 10, 13, 12, 1, -12 },
  { 229, 8, 11, 8, 0, -11 },
  { 240, 7, 11, 9, 1, -11 },
  { 250, 7, 12, 8, 1, -12 },
  { 261, 8, 11, 9, 1, -11 },
  { 272, 5, 11, 7, 1, -11 },
  { 279, 5, 11, 7, 1, -11 },
  { 286, 8, 12, 10, 1, -12 },
  { 298, 7, 11, 10, 1, -11 },
  { 308, 3, 11, 5, 1, -11 },
  { 313, 4, 14, 4, -1, -11 },
  { 320, 7, 11, 8, 1, -11 },
  { 330, 6, 11, 7, 1, -11 },
  { 339, 10, 11, 13, 1, -11 },
  { 353, 8, 11, 10, 1, -11 },
  { 364, 8, 12, 10, 1, -12 },
  { 376, 6, 11, 8, 1, -11 },
  { 385, 8, 15, 10, 1, -12 },
  { 400, 7, 11, 8, 1, -11 },
  { 410, 6, 12, 7, 1, -12 },
  { 419, 7, 11, 7, 0, -11 },
  { 429, 7, 11, 10, 1, -11 },
  { 439, 8, 11, 8, 0, -11 },
  { 450, 13, 11, 13, 0, -11 },
  { 468, 8, 11, 8, 0, -11 },
  { 479, 7, 11, 7, 0, -11 },
  { 489, 7, 11, 7, 0, -11 },
  { 499, 4, 14, 5, 1, -11 },
  { 506, 6, 11, 6, 0, -11 },
  { 515, 4, 14, 5, 0, -11 },
  { 522, 8, 6, 8, 0, -11 },
  { 528, 7, 1, 7, 0, 1 },
  { 529, 3, 2, 5, 1, -12 },
  { 530, 6, 9, 8, 1, -9 },
  { 537, 7, 12, 8, 1, -12 },
  { 548, 5, 9, 6, 1, -9 },
  { 554, 6, 12, 8, 1, -12 },
  { 563, 6, 9, 8, 1, -9 },
  { 570, 5, 12, 5, 0, -12 },
  { 578, 6, 13, 8, 1, -9 },
  { 588, 6, 12, 8, 1, -12 },
  { 597, 2, 12, 4, 1, -12 },
  { 600, 3, 16, 4, 0, -12 },
  { 606, 6, 12, 7, 1, -12 },
  { 615, 2, 12, 4, 1, -12 },
  { 618, 10, 9, 12, 1, -9 },
  { 630, 6, 9, 8, 1, -9 },
  { 637, 6, 9, 8, 1, -9 },
  { 644, 7, 13, 8, 1, -9 },
  { 656, 6, 13, 8, 1, -9 },
  { 666, 4, 9, 6, 1, -9 },
  { 671, 5, 9, 6, 1, -9 },
  { 677, 5, 11, 5, 0, -11 },
  { 684, 6, 9, 8, 1, -9 },
  { 691, 7, 9, 7, 0, -9 },
  { 699, 11, 9, 11, 0, -9 },
  { 712, 7, 9, 7, 0, -9 },
  { 720, 7, 13, 7, 0, -9 },
  { 732, 5, 9, 6, 0, -9 },
  { 738, 5, 14, 6, 0, -11 },
  { 747, 1, 16, 7, 3, -12 },
  { 749, 4, 14, 6, 1, -11 },
  { 756, 6, 2, 8, 1, -7 },
};

const GFXfont NotoSans_Condensed_Medium16pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Medium16pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Medium16pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _NOTOSANS_CONDENSED_MEDIUM16PT7B_H_
