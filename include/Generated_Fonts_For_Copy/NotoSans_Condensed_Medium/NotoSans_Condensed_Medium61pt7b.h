#ifndef _NOTOSANS_CONDENSED_MEDIUM61PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUM61PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Medium.ttf
// Size: 61pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Medium61pt7bBitmaps[] PROGMEM = {
  0x00, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C,
  0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x7E, 0xFE, 0xFE, 0xFF, 0xFE, 0xFE, 0x7E, 0x18, 0xFE, 0x0F,
  0xDF, 0x83, 0xF7, 0xE0, 0xFD, 0xF8, 0x3F, 0x7E, 0x0F, 0xDF, 0x83, 0xF7,
  0xE0, 0xFD, 0xF8, 0x3F, 0x7E, 0x0F, 0xDF, 0x83, 0xF7, 0xC0, 0xFD, 0xF0,
  0x1F, 0x7C, 0x07, 0xDF, 0x01, 0xF3, 0xC0, 0x78, 0xF0, 0x1E, 0x00, 0x1E,
  0x07, 0xC0, 0x00, 0xF8, 0x1F, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0x81,
  0xE0, 0x00, 0x3E, 0x07, 0x80, 0x00, 0xF0, 0x1E, 0x00, 0x03, 0xC0, 0xF8,
  0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x01, 0xF0, 0x3E, 0x00,
  0x07, 0xC0, 0xF0, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x78, 0x0F, 0x00, 0xFF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFC, 0x03, 0xE0, 0x78, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x3C, 0x0F,
  0x80, 0x00, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x03, 0xE0,
  0x00, 0x7C, 0x0F, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x1E, 0x07, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x00, 0xF8, 0x1E, 0x00, 0x03, 0xC0,
  0x78, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x3C, 0x0F, 0x80, 0x01, 0xF0, 0x3E,
  0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x7C, 0x0F, 0x00,
  0x01, 0xE0, 0x3C, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x1E, 0x07, 0xC0, 0x00,
  0xF8, 0x1F, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x03, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFC, 0x7F, 0x38, 0x38, 0xFE, 0x38, 0x08, 0xFC, 0x38, 0x00, 0xFC, 0x38,
  0x00, 0xF8, 0x38, 0x00, 0xF8, 0x38, 0x00, 0xFC, 0x38, 0x00, 0xFC, 0x38,
  0x00, 0xFE, 0x38, 0x00, 0x7F, 0xB8, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7F,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x39, 0xFE, 0x00, 0x38,
  0x7E, 0x00, 0x38, 0x3E, 0x00, 0x38, 0x3F, 0x00, 0x38, 0x3F, 0x00, 0x38,
  0x3F, 0x00, 0x38, 0x3E, 0x80, 0x38, 0x7E, 0xE0, 0x38, 0xFE, 0xFC, 0x3B,
  0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xC0, 0x07, 0xFE, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0x80, 0x07,
  0xFF, 0x00, 0x0F, 0x80, 0x07, 0xFF, 0xC0, 0x07, 0xC0, 0x03, 0xE3, 0xE0,
  0x03, 0xC0, 0x03, 0xE1, 0xF0, 0x03, 0xE0, 0x01, 0xF0, 0x7C, 0x01, 0xF0,
  0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x00, 0x7C, 0x1F, 0x00, 0xF8, 0x00, 0x3C,
  0x07, 0x80, 0xF8, 0x00, 0x3E, 0x03, 0xC0, 0x7C, 0x00, 0x1F, 0x01, 0xF0,
  0x3E, 0x00, 0x0F, 0x80, 0xF8, 0x3E, 0x00, 0x07, 0xC0, 0x7C, 0x1F, 0x00,
  0x03, 0xE0, 0x3E, 0x1F, 0x00, 0x01, 0xF0, 0x1F, 0x0F, 0x80, 0x00, 0xF8,
  0x0F, 0x07, 0x80, 0x00, 0x3C, 0x07, 0x87, 0xC0, 0xF0, 0x1F, 0x07, 0xC3,
  0xE1, 0xFE, 0x0F, 0x83, 0xE3, 0xE1, 0xFF, 0x87, 0xC1, 0xF1, 0xF1, 0xFF,
  0xE1, 0xE1, 0xF1, 0xF1, 0xFF, 0xF0, 0xF9, 0xF8, 0xF8, 0xF8, 0xFC, 0x7F,
  0xFC, 0x7C, 0x78, 0x3E, 0x1F, 0xFC, 0x7C, 0x7C, 0x1F, 0x07, 0xFC, 0x3E,
  0x3E, 0x07, 0x81, 0xF8, 0x3E, 0x1F, 0x03, 0xE0, 0x00, 0x1F, 0x0F, 0x81,
  0xF0, 0x00, 0x0F, 0x07, 0xC0, 0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x7C, 0x00,
  0x07, 0xC1, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0xF8, 0x1F, 0x00, 0x03, 0xE0,
  0x7C, 0x0F, 0x80, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x01, 0xF0, 0x1F, 0x03,
  0xE0, 0x00, 0xF8, 0x0F, 0x81, 0xF0, 0x00, 0xF8, 0x07, 0xC0, 0xF0, 0x00,
  0x7C, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x00,
  0x7C, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0x00, 0x0F, 0xFE,
  0x00, 0x0F, 0x80, 0x03, 0xFF, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x1F, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0xFC, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x03, 0xE0, 0x3F,
  0x00, 0x01, 0xF0, 0x1F, 0x80, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0x7E, 0x0F,
  0xC0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x07, 0xF7,
  0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F,
  0xFC, 0x01, 0xF8, 0x3F, 0xFF, 0x00, 0xFC, 0x1F, 0xDF, 0xC0, 0x7E, 0x1F,
  0xC7, 0xF0, 0x7F, 0x1F, 0xC3, 0xF8, 0x3F, 0x0F, 0xC0, 0xFE, 0x1F, 0x87,
  0xE0, 0x3F, 0x9F, 0xC7, 0xF0, 0x0F, 0xEF, 0xC3, 0xF0, 0x07, 0xF7, 0xE1,
  0xF8, 0x01, 0xFF, 0xF0, 0xFC, 0x00, 0x7F, 0xF0, 0x7E, 0x00, 0x1F, 0xF8,
  0x3F, 0x80, 0x0F, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x0F, 0xE0, 0x03, 0xFE,
  0x03, 0xF8, 0x03, 0xFF, 0x81, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFD, 0xFC, 0x0F, 0xFF, 0xF8, 0x7F, 0x03, 0xFF, 0xF8,
  0x3F, 0xC0, 0x7F, 0xF0, 0x0F, 0xF0, 0x03, 0x80, 0x00, 0x00, 0xFE, 0xFD,
  0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xF3, 0xE7, 0xCF, 0x8F, 0x1E,
  0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x80, 0x7C,
  0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x1F, 0x00, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x01, 0xF0,
  0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0xF8,
  0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x03,
  0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x1F,
  0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x60, 0x3C, 0x06, 0x7C, 0x3C, 0x3E, 0x7F, 0xBF,
  0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x00, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xEF, 0x80, 0x07, 0xE7,
  0xC0, 0x07, 0xC7, 0xE0, 0x0F, 0xC3, 0xF0, 0x1F, 0x83, 0xF8, 0x1F, 0x81,
  0xF0, 0x07, 0x01, 0xC0, 0x01, 0x00, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0xC7, 0xE1, 0xF8, 0xFE, 0x3F, 0x8F, 0xC3, 0xF0, 0xFC,
  0x3E, 0x1F, 0x87, 0xE1, 0xF0, 0x7C, 0x1E, 0x0F, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x39, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xBE, 0x38, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF8,
  0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0x1F, 0xE0, 0x7F, 0x03,
  0xF0, 0x7F, 0x01, 0xFC, 0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x0F, 0xC0,
  0x1F, 0x8F, 0xC0, 0x07, 0xE7, 0xE0, 0x03, 0xF3, 0xF0, 0x01, 0xF9, 0xF8,
  0x00, 0xFC, 0xFC, 0x00, 0x7E, 0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0x9F,
  0x80, 0x0F, 0xEF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF,
  0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0x7E, 0x00, 0x3F, 0xBF, 0x00, 0x1F,
  0xDF, 0x80, 0x0F, 0xEF, 0xC0, 0x07, 0xE7, 0xE0, 0x03, 0xF3, 0xF0, 0x01,
  0xF9, 0xF8, 0x00, 0xFC, 0xFC, 0x00, 0x7E, 0x7E, 0x00, 0x3F, 0x3F, 0x80,
  0x1F, 0x8F, 0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0xC3, 0xF8, 0x0F, 0xE0, 0xFC,
  0x07, 0xE0, 0x7F, 0x07, 0xF0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x03,
  0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0xFF, 0x01, 0xFF, 0x07, 0xFF,
  0x0F, 0xFF, 0x1F, 0xFF, 0x3F, 0xBF, 0x7F, 0x3F, 0xFE, 0x3F, 0x7C, 0x3F,
  0x38, 0x3F, 0x30, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x7F, 0x87, 0xFC, 0x3E, 0x01,
  0xFE, 0x18, 0x00, 0xFE, 0x10, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x7F, 0x03, 0xFC, 0x3C, 0x00,
  0xFE, 0x10, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xF0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x03, 0xFF,
  0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFE, 0xF0, 0x03,
  0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x01, 0x70, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0x7C, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7B, 0xF0, 0x00, 0x1F, 0x7E, 0x00,
  0x07, 0xCF, 0xC0, 0x00, 0xF9, 0xF8, 0x00, 0x3E, 0x3F, 0x00, 0x07, 0xC7,
  0xE0, 0x01, 0xF0, 0xFC, 0x00, 0x3E, 0x1F, 0x80, 0x0F, 0x83, 0xF0, 0x01,
  0xF0, 0x7E, 0x00, 0x7C, 0x0F, 0xC0, 0x0F, 0x81, 0xF8, 0x03, 0xE0, 0x3F,
  0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xF8,
  0x03, 0xF0, 0x3E, 0x00, 0x7E, 0x07, 0xC0, 0x0F, 0xC1, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0x0F, 0x03, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xD8, 0x00,
  0x7F, 0xBC, 0x01, 0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x00, 0x1D, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x07, 0xFF,
  0xF8, 0x0F, 0xF8, 0x08, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x1E,
  0x00, 0xFC, 0x7F, 0xC0, 0xFC, 0xFF, 0xF0, 0xFD, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF8, 0xFF, 0xF7, 0xFC, 0xFF, 0x81, 0xFC, 0xFF, 0x00, 0xFE, 0xFE, 0x00,
  0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7F, 0x00,
  0xFE, 0x3F, 0x00, 0xFC, 0x3F, 0x81, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x18,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0xF0, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC1, 0xFE,
  0x0F, 0xF0, 0xFE, 0x01, 0xF8, 0x7E, 0x00, 0xFE, 0x7E, 0x00, 0x3F, 0x3F,
  0x00, 0x1F, 0x9F, 0x80, 0x0F, 0xCF, 0xC0, 0x07, 0xE3, 0xE0, 0x03, 0xF1,
  0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x3F, 0x01, 0xFC, 0x1F, 0xC1, 0xFC,
  0x07, 0xF1, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x0F, 0xE7,
  0xF8, 0x0F, 0xE1, 0xFE, 0x0F, 0xE0, 0x3F, 0x8F, 0xE0, 0x0F, 0xE7, 0xE0,
  0x03, 0xF3, 0xF0, 0x01, 0xFB, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC,
  0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xF7,
  0xE0, 0x03, 0xFB, 0xF8, 0x01, 0xF9, 0xFE, 0x01, 0xFC, 0x7F, 0xE7, 0xFC,
  0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x02, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xC3, 0xFC, 0x3F, 0x81,
  0xFC, 0x7F, 0x00, 0xFE, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0x7E, 0x00,
  0x3F, 0x7E, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0xFF, 0x3F, 0x81,
  0xFF, 0x3F, 0xFF, 0xDF, 0x1F, 0xFF, 0xDF, 0x0F, 0xFF, 0xBF, 0x07, 0xFF,
  0x3F, 0x01, 0xFC, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xF0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x1F, 0xFF,
  0x00, 0x1F, 0xFC, 0x00, 0x03, 0x80, 0x00, 0x7D, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xBE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7B, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7C,
  0x30, 0x1F, 0x1F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE3, 0xF1, 0xF9, 0xFC, 0xFC,
  0x7E, 0x3F, 0x1F, 0x9F, 0x8F, 0xC7, 0xE3, 0xE1, 0xF1, 0xF0, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x03, 0xFF,
  0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xE1, 0xFE, 0x70,
  0x07, 0xF4, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3E, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x1F,
  0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00,
  0x03, 0xE0, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x00, 0x07, 0xC1,
  0xF0, 0x07, 0xFC, 0x07, 0xC7, 0xC0, 0x3F, 0xFE, 0x0F, 0x8F, 0x80, 0xFF,
  0xFC, 0x0F, 0x3E, 0x03, 0xFF, 0xF8, 0x1F, 0x7C, 0x0F, 0xC1, 0xF0, 0x3E,
  0xF8, 0x1F, 0x03, 0xE0, 0x7D, 0xF0, 0x7E, 0x07, 0xC0, 0xFF, 0xC0, 0xF8,
  0x0F, 0x81, 0xFF, 0x81, 0xF0, 0x1F, 0x01, 0xFF, 0x03, 0xE0, 0x3E, 0x03,
  0xFE, 0x0F, 0x80, 0x7C, 0x07, 0xFC, 0x1F, 0x00, 0xF8, 0x0F, 0xF8, 0x3E,
  0x01, 0xF0, 0x3F, 0xF0, 0x7C, 0x03, 0xE0, 0x7F, 0xE0, 0xF8, 0x07, 0xC0,
  0xFF, 0xC1, 0xF0, 0x0F, 0x81, 0xFF, 0x83, 0xE0, 0x3F, 0x03, 0xFF, 0x03,
  0xC0, 0x7E, 0x07, 0xBE, 0x07, 0xC0, 0xFC, 0x1F, 0x7C, 0x0F, 0x83, 0xF8,
  0x3E, 0xF8, 0x1F, 0x8F, 0x78, 0xF8, 0xF8, 0x1F, 0xFE, 0xFF, 0xF1, 0xF0,
  0x1F, 0xF8, 0xFF, 0xC3, 0xE0, 0x3F, 0xE1, 0xFF, 0x07, 0xC0, 0x1F, 0x80,
  0xF8, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x10, 0x00, 0x3F, 0xC0, 0x00, 0xE0, 0x00,
  0x3F, 0xE0, 0x0F, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0x7C, 0x00,
  0x00, 0x3E, 0x7C, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00,
  0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0xFC, 0x3F, 0x00,
  0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x01, 0xF8, 0x1F, 0x80,
  0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x80,
  0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0xC0,
  0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xF8,
  0x1F, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x80, 0x01, 0xFC,
  0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFE,
  0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E,
  0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xF3, 0xF0, 0x07, 0xFD, 0xF8, 0x01, 0xFE, 0xFC, 0x00, 0x7F,
  0x7E, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xDF, 0x80, 0x07, 0xEF, 0xC0, 0x03,
  0xF7, 0xE0, 0x01, 0xFB, 0xF0, 0x00, 0xFD, 0xF8, 0x00, 0xFE, 0xFC, 0x00,
  0x7E, 0x7E, 0x00, 0x7F, 0x3F, 0x01, 0xFF, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0xFC,
  0x01, 0xFE, 0x7E, 0x00, 0x3F, 0xBF, 0x00, 0x0F, 0xDF, 0x80, 0x07, 0xFF,
  0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07,
  0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x07, 0xFB, 0xF0, 0x1F, 0xFD, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFC, 0x3F, 0x03, 0xFE,
  0x00, 0x60, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x01, 0x03, 0xFF,
  0x00, 0xE0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1C, 0x00, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0xFC, 0x03, 0xFF, 0x0F, 0xC0,
  0x0F, 0xF8, 0xFC, 0x00, 0x7F, 0x8F, 0xC0, 0x03, 0xFC, 0xFC, 0x00, 0x1F,
  0xCF, 0xC0, 0x01, 0xFC, 0xFC, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0xFE, 0xFC,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7E,
  0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xEF, 0xC0,
  0x00, 0xFE, 0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xFC, 0xFC, 0x00, 0x3F,
  0xCF, 0xC0, 0x03, 0xF8, 0xFC, 0x00, 0x7F, 0x0F, 0xC0, 0x1F, 0xF0, 0xFC,
  0x3F, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFE, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFE, 0x1F, 0xE0, 0x7F,
  0xC0, 0x07, 0x03, 0xFC, 0x00, 0x04, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0x7E, 0x00, 0x00,
  0xFD, 0xF8, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x3F,
  0x3F, 0x00, 0x00, 0xFC, 0xFE, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x0F, 0xC7,
  0xF0, 0x00, 0x3F, 0x1F, 0xE0, 0x00, 0xFC, 0x3F, 0xC0, 0x03, 0xF0, 0xFF,
  0xC0, 0x1F, 0xC1, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0,
  0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F,
  0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0,
  0x00, 0x1F, 0xFE, 0x00, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF3, 0xFF, 0x81, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE,
  0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0xFC, 0x03, 0xFB, 0xFF, 0xF7, 0xFF, 0xCF, 0xFF, 0x9F, 0xFE, 0x3F, 0xF8,
  0x3F, 0xC0, 0xFC, 0x00, 0x1F, 0xDF, 0x80, 0x03, 0xFB, 0xF0, 0x00, 0xFE,
  0x7E, 0x00, 0x3F, 0x8F, 0xC0, 0x07, 0xF1, 0xF8, 0x01, 0xFC, 0x3F, 0x00,
  0x3F, 0x07, 0xE0, 0x0F, 0xE0, 0xFC, 0x03, 0xF8, 0x1F, 0x80, 0x7E, 0x03,
  0xF0, 0x1F, 0xC0, 0x7E, 0x07, 0xF0, 0x0F, 0xC0, 0xFC, 0x01, 0xF8, 0x3F,
  0x80, 0x3F, 0x0F, 0xE0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x7F, 0x00, 0x1F,
  0x8F, 0xC0, 0x03, 0xF3, 0xF8, 0x00, 0x7E, 0xFE, 0x00, 0x0F, 0xDF, 0xC0,
  0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0x00, 0x1F, 0xE7, 0xF0, 0x03, 0xF8, 0x7E, 0x00, 0x7E, 0x0F, 0xE0,
  0x0F, 0xC0, 0xFC, 0x01, 0xF8, 0x1F, 0xC0, 0x3F, 0x01, 0xFC, 0x07, 0xE0,
  0x3F, 0x80, 0xFC, 0x03, 0xF8, 0x1F, 0x80, 0x7F, 0x03, 0xF0, 0x07, 0xF0,
  0x7E, 0x00, 0xFE, 0x0F, 0xC0, 0x0F, 0xE1, 0xF8, 0x01, 0xFC, 0x3F, 0x00,
  0x1F, 0xC7, 0xE0, 0x03, 0xF8, 0xFC, 0x00, 0x3F, 0x9F, 0x80, 0x07, 0xF3,
  0xF0, 0x00, 0x7F, 0x7E, 0x00, 0x0F, 0xF0, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFB,
  0xE0, 0x00, 0x1F, 0x7F, 0xEF, 0x80, 0x00, 0x7D, 0xFF, 0xBF, 0x00, 0x01,
  0xF7, 0xFE, 0xFC, 0x00, 0x0F, 0xDF, 0xF9, 0xF0, 0x00, 0x3E, 0xFF, 0xE7,
  0xC0, 0x00, 0xFB, 0xFF, 0x9F, 0x80, 0x07, 0xEF, 0xFF, 0x3E, 0x00, 0x1F,
  0x3F, 0xFC, 0xF8, 0x00, 0x7C, 0xFF, 0xF3, 0xF0, 0x03, 0xF3, 0xFF, 0xC7,
  0xC0, 0x0F, 0x8F, 0xFF, 0x1F, 0x00, 0x3E, 0x3F, 0xFC, 0x7E, 0x01, 0xF8,
  0xFF, 0xF1, 0xF8, 0x07, 0xC3, 0xFF, 0xC3, 0xE0, 0x1F, 0x0F, 0xFF, 0x0F,
  0xC0, 0x7C, 0x3F, 0xFC, 0x3F, 0x03, 0xF0, 0xFF, 0xF0, 0x7C, 0x0F, 0x83,
  0xFF, 0xC1, 0xF0, 0x3E, 0x0F, 0xFF, 0x07, 0xE1, 0xF8, 0x3F, 0xFC, 0x0F,
  0x87, 0xC0, 0xFF, 0xF0, 0x3E, 0x1F, 0x03, 0xFF, 0xC0, 0xFC, 0xFC, 0x0F,
  0xFF, 0x03, 0xF3, 0xE0, 0x3F, 0xFC, 0x07, 0xCF, 0x80, 0xFF, 0xF0, 0x1F,
  0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F,
  0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0xF0, 0x07, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xC0, 0x0F, 0xFF, 0x00, 0x3F,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0x80, 0x07, 0xFE, 0xFC, 0x00, 0x3F, 0xF7, 0xF0, 0x01, 0xFF, 0x9F, 0x80,
  0x0F, 0xFC, 0xFE, 0x00, 0x7F, 0xE3, 0xF0, 0x03, 0xFF, 0x1F, 0xC0, 0x1F,
  0xFC, 0x7E, 0x00, 0xFF, 0xE3, 0xF8, 0x07, 0xFF, 0x0F, 0xC0, 0x3F, 0xF8,
  0x7F, 0x01, 0xFF, 0xC1, 0xF8, 0x0F, 0xFE, 0x0F, 0xE0, 0x7F, 0xF0, 0x3F,
  0x03, 0xFF, 0x81, 0xFC, 0x1F, 0xFC, 0x07, 0xE0, 0xFF, 0xE0, 0x3F, 0x07,
  0xFF, 0x00, 0xFC, 0x3F, 0xF8, 0x07, 0xE1, 0xFF, 0xC0, 0x1F, 0x8F, 0xFE,
  0x00, 0xFC, 0x7F, 0xF0, 0x07, 0xF3, 0xFF, 0x80, 0x1F, 0x9F, 0xFC, 0x00,
  0xFE, 0xFF, 0xE0, 0x03, 0xF7, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x80, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFE, 0x3F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x1F, 0xE0,
  0x03, 0xF8, 0x3F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80,
  0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x7E, 0x7F, 0x00,
  0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0x7E, 0x00,
  0x00, 0x7F, 0x7E, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x7E, 0x7F, 0x00,
  0x00, 0x7E, 0x7F, 0x00, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0xFE, 0x3F, 0x80,
  0x01, 0xFC, 0x3F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xE0,
  0x07, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x01, 0xA0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xBF,
  0x01, 0xFF, 0x7E, 0x00, 0xFE, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0,
  0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x1F, 0xDF, 0x80, 0xFF, 0xBF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFE, 0x3F,
  0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x1F, 0xE0, 0x03, 0xF8, 0x3F, 0xC0, 0x01,
  0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0xFE, 0x7F, 0x00, 0x00,
  0xFE, 0x7F, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00,
  0x7F, 0x7E, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00,
  0x7F, 0x7E, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00,
  0xFE, 0x3F, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0xC0, 0x01,
  0xFC, 0x1F, 0xC0, 0x03, 0xFC, 0x1F, 0xE0, 0x07, 0xF8, 0x0F, 0xF8, 0x1F,
  0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01,
  0xFE, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x0F, 0xC0, 0x7F, 0xC3,
  0xF0, 0x07, 0xF8, 0xFC, 0x00, 0xFE, 0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x07,
  0xE3, 0xF0, 0x01, 0xFC, 0xFC, 0x00, 0x7F, 0x3F, 0x00, 0x1F, 0xCF, 0xC0,
  0x07, 0xF3, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x8F,
  0xC0, 0x0F, 0xE3, 0xF0, 0x07, 0xF0, 0xFC, 0x07, 0xFC, 0x3F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xE0, 0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0x3F,
  0x03, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0xC0, 0xFC, 0x03, 0xF0,
  0x3F, 0x00, 0xFE, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x07, 0xF0, 0xFC, 0x00,
  0xFE, 0x3F, 0x00, 0x3F, 0x8F, 0xC0, 0x07, 0xF3, 0xF0, 0x01, 0xFC, 0xFC,
  0x00, 0x3F, 0xBF, 0x00, 0x0F, 0xEF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F,
  0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF1,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x8F, 0xE0, 0x0F, 0x3F, 0x80, 0x04, 0x7F,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x3F, 0xBF, 0x00, 0xFF, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0x80, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F,
  0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xF7,
  0xE0, 0x00, 0x7F, 0x7E, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x7E, 0x7F, 0x00,
  0x0F, 0xE3, 0xF8, 0x01, 0xFE, 0x3F, 0xE0, 0x3F, 0xC1, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x06, 0x80, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x01, 0xFD, 0xF8, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x07, 0xE7, 0xE0, 0x00,
  0x0F, 0xCF, 0xE0, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x00,
  0xFC, 0x3F, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x0F,
  0xC0, 0xFC, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0xFC,
  0x03, 0xF0, 0x01, 0xF8, 0x07, 0xE0, 0x03, 0xF0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00,
  0x7F, 0x01, 0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x01,
  0xF8, 0x0F, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x07,
  0xE0, 0xFC, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x1F,
  0x8F, 0xC0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x7C,
  0xFC, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x01, 0xF7,
  0xC0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7F, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x0F,
  0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x0F, 0xF0, 0x00, 0x7E, 0x7F, 0x00, 0x0F,
  0xF0, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xF8, 0x00, 0xFE, 0x3F, 0x00, 0x1F,
  0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0xF8, 0x00, 0xFC, 0x3F, 0x80, 0x1F,
  0xF8, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x3F,
  0x7C, 0x01, 0xF8, 0x1F, 0x80, 0x3E, 0x7C, 0x01, 0xF8, 0x1F, 0x80, 0x3E,
  0x7C, 0x01, 0xF8, 0x1F, 0xC0, 0x3E, 0x7C, 0x01, 0xF8, 0x0F, 0xC0, 0x3E,
  0x7E, 0x03, 0xF8, 0x0F, 0xC0, 0x7E, 0x3E, 0x03, 0xF0, 0x0F, 0xC0, 0x7C,
  0x3E, 0x03, 0xF0, 0x0F, 0xC0, 0x7C, 0x3E, 0x03, 0xF0, 0x07, 0xE0, 0x7C,
  0x3F, 0x03, 0xF0, 0x07, 0xE0, 0xFC, 0x3F, 0x07, 0xF0, 0x07, 0xE0, 0xFC,
  0x1F, 0x07, 0xE0, 0x07, 0xE0, 0xF8, 0x1F, 0x07, 0xE0, 0x07, 0xE0, 0xF8,
  0x1F, 0x07, 0xE0, 0x03, 0xF0, 0xF8, 0x1F, 0x87, 0xE0, 0x03, 0xF1, 0xF8,
  0x0F, 0x8F, 0xC0, 0x03, 0xF1, 0xF0, 0x0F, 0x8F, 0xC0, 0x03, 0xF1, 0xF0,
  0x0F, 0x8F, 0xC0, 0x01, 0xF1, 0xF0, 0x0F, 0x8F, 0xC0, 0x01, 0xF9, 0xF0,
  0x0F, 0xCF, 0xC0, 0x01, 0xFB, 0xF0, 0x07, 0xDF, 0x80, 0x01, 0xFB, 0xE0,
  0x07, 0xDF, 0x80, 0x01, 0xFB, 0xE0, 0x07, 0xDF, 0x80, 0x00, 0xFB, 0xE0,
  0x07, 0xDF, 0x80, 0x00, 0xFB, 0xE0, 0x03, 0xDF, 0x00, 0x00, 0xFB, 0xC0,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x03,
  0xF1, 0xF8, 0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0xC1,
  0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0xE0, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x03, 0xF0, 0x07, 0xE0, 0x3F, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0xFC, 0x1F,
  0xC0, 0x07, 0xF0, 0xFC, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0xFE, 0x7E, 0x00,
  0x03, 0xF7, 0xF0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x01,
  0xFB, 0xF0, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0xFC, 0x7E, 0x00, 0x07, 0xE3,
  0xF8, 0x00, 0x7F, 0x0F, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x81, 0xF8,
  0x01, 0xF8, 0x0F, 0xC0, 0x1F, 0xC0, 0x7F, 0x00, 0xFC, 0x01, 0xF8, 0x0F,
  0xE0, 0x0F, 0xE0, 0x7E, 0x00, 0x3F, 0x07, 0xF0, 0x01, 0xFC, 0x3F, 0x00,
  0x07, 0xE3, 0xF8, 0x00, 0x3F, 0x9F, 0xC0, 0x01, 0xFD, 0xFC, 0x00, 0x07,
  0xF0, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0x7E, 0x00, 0x07, 0xF7,
  0xF0, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0xFC, 0x3F, 0x80,
  0x0F, 0xC1, 0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x1F, 0x80, 0xFC, 0x03, 0xF8,
  0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0x7F,
  0x07, 0xE0, 0x03, 0xF0, 0xFE, 0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF8, 0xFC,
  0x00, 0x1F, 0x9F, 0x80, 0x01, 0xFD, 0xF8, 0x00, 0x0F, 0xDF, 0x80, 0x00,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0xF9, 0xF8,
  0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0, 0xFC, 0x00, 0x3E, 0x07, 0xC0, 0x03,
  0xE0, 0x7E, 0x00, 0x7C, 0x03, 0xE0, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x01,
  0xF0, 0x0F, 0x80, 0x1F, 0x81, 0xF8, 0x00, 0xF8, 0x1F, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x3E, 0x7C, 0x00,
  0x03, 0xEF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0x7F,
  0x01, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x01,
  0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFC,
  0x7F, 0xC1, 0xC0, 0x3F, 0x82, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE,
  0x7F, 0xC0, 0xFD, 0xFE, 0x01, 0xFB, 0xF8, 0x03, 0xF7, 0xE0, 0x07, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFC,
  0x01, 0xFF, 0xF8, 0x07, 0xFB, 0xF0, 0x1F, 0xF7, 0xF8, 0xFF, 0xEF, 0xFF,
  0xF7, 0xCF, 0xFF, 0xCF, 0x8F, 0xFF, 0x1F, 0x0F, 0xF8, 0x3E, 0x01, 0x80,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE1, 0xFE, 0x03, 0xF1, 0xFF, 0xC1,
  0xF9, 0xFF, 0xF0, 0xFD, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x3F, 0xF0, 0x7F,
  0x9F, 0xE0, 0x0F, 0xCF, 0xF0, 0x07, 0xF7, 0xF0, 0x01, 0xFB, 0xF8, 0x00,
  0xFD, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x00,
  0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0,
  0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF,
  0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xEF, 0xE0, 0x03, 0xF7, 0xF0, 0x01, 0xFB,
  0xFC, 0x01, 0xFD, 0xFE, 0x00, 0xFC, 0xFF, 0x80, 0xFE, 0x7F, 0xFB, 0xFE,
  0x3F, 0x7F, 0xFF, 0x1F, 0xBF, 0xFF, 0x0F, 0x8F, 0xFF, 0x07, 0xC1, 0xFF,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x18, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0xF0,
  0xFF, 0xFF, 0x1F, 0xFF, 0xE1, 0xFF, 0xFE, 0x3F, 0xC0, 0x43, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x63, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0xFF, 0xFE,
  0x07, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x20, 0x3F, 0x03,
  0xFE, 0x3F, 0x07, 0xFF, 0x3F, 0x0F, 0xFF, 0x9F, 0x1F, 0xFF, 0xDF, 0x3F,
  0xFF, 0xFF, 0x3F, 0x81, 0xFF, 0x7F, 0x00, 0xFF, 0x7E, 0x00, 0x7F, 0x7E,
  0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0x7E, 0x00, 0x7F, 0x7F, 0x00, 0xFF, 0x3F, 0x81, 0xFF, 0x3F,
  0xFF, 0xFF, 0x1F, 0xFF, 0xDF, 0x1F, 0xFF, 0x9F, 0x0F, 0xFF, 0x1F, 0x03,
  0xFE, 0x0F, 0x00, 0x70, 0x00, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x3F,
  0xFF, 0x80, 0xFF, 0xFF, 0x81, 0xFC, 0x7F, 0x87, 0xF0, 0x3F, 0x9F, 0xC0,
  0x3F, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x11, 0xFC,
  0x00, 0xE1, 0xFF, 0x1F, 0xC3, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x01, 0xFF,
  0xFE, 0x01, 0xFF, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x1F, 0xFC,
  0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xF7, 0x81, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0xC3, 0xFF, 0xF8, 0xFF, 0xFF, 0x1F,
  0xFF, 0xE3, 0xFF, 0xFC, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x00,
  0x20, 0x00, 0x03, 0xFE, 0x1F, 0x07, 0xFF, 0x1F, 0x0F, 0xFF, 0x9F, 0x1F,
  0xFF, 0xDF, 0x3F, 0xFF, 0xFF, 0x3F, 0x81, 0xFF, 0x7F, 0x00, 0xFF, 0x7F,
  0x00, 0x7F, 0x7E, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0x7E, 0x00, 0x7F, 0x7F, 0x00, 0xFF, 0x3F,
  0x81, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xDF, 0x1F, 0xFF, 0xBF, 0x0F,
  0xFF, 0x3F, 0x03, 0xFE, 0x3F, 0x00, 0x60, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x7F, 0x40, 0x00, 0xFE, 0x38, 0x01, 0xFE, 0x3F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x00,
  0x74, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x3F, 0xE0, 0xFC, 0xFF, 0xF0, 0xFD,
  0xFF, 0xF8, 0xFD, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xC1, 0xFE, 0xFF,
  0x00, 0xFE, 0xFF, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFE,
  0x00, 0x7E, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0x7D, 0xFB, 0xFF, 0xFF,
  0xFF, 0x9E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB,
  0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E,
  0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xC0,
  0x01, 0xF0, 0x1F, 0x80, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x03, 0xFB, 0xFF, 0xDF, 0xFC, 0xFF, 0xE7, 0xFE, 0x3F, 0xE0,
  0x70, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFC, 0xFC,
  0x01, 0xFC, 0xFC, 0x03, 0xF8, 0xFC, 0x03, 0xF0, 0xFC, 0x07, 0xF0, 0xFC,
  0x0F, 0xE0, 0xFC, 0x0F, 0xC0, 0xFC, 0x1F, 0x80, 0xFC, 0x3F, 0x80, 0xFC,
  0x3F, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFD,
  0xFC, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xBF, 0x00, 0xFF, 0x1F, 0x80, 0xFE, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0xE0, 0xFC, 0x07, 0xE0, 0xFC, 0x07, 0xF0, 0xFC, 0x03, 0xF0, 0xFC,
  0x03, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xFC, 0xFC, 0x00, 0xFC, 0xFC,
  0x00, 0xFE, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x04, 0x00, 0x07, 0x01,
  0xF0, 0x7F, 0x80, 0x7F, 0xC3, 0xE3, 0xFF, 0xC3, 0xFF, 0xC7, 0xCF, 0xFF,
  0xCF, 0xFF, 0xCF, 0xFF, 0xFF, 0x9F, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xBF, 0xE0, 0x7F, 0xF0, 0x7F, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xFF, 0x00,
  0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0xF8, 0x01, 0xF8, 0x01,
  0xFF, 0xF0, 0x03, 0xF0, 0x03, 0xFF, 0xC0, 0x07, 0xE0, 0x07, 0xFF, 0x80,
  0x0F, 0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0x80, 0x1F, 0xFE, 0x00, 0x3F, 0x00,
  0x3F, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0xF8, 0x00, 0xFC, 0x00, 0xFF, 0xF0,
  0x01, 0xF8, 0x01, 0xFF, 0xE0, 0x03, 0xF0, 0x03, 0xFF, 0xC0, 0x07, 0xE0,
  0x07, 0xFF, 0x80, 0x0F, 0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0x80, 0x1F, 0xFE,
  0x00, 0x3F, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0xF8, 0x00, 0xFC,
  0x00, 0xFF, 0xF0, 0x01, 0xF8, 0x01, 0xFF, 0xE0, 0x03, 0xF0, 0x03, 0xFF,
  0xC0, 0x07, 0xE0, 0x07, 0xFF, 0x80, 0x0F, 0xC0, 0x0F, 0xFF, 0x00, 0x1F,
  0x80, 0x1F, 0xFE, 0x00, 0x3F, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0x00, 0x7F,
  0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x06, 0x00, 0xF8, 0x3F, 0xE0, 0xF8,
  0xFF, 0xF0, 0xF9, 0xFF, 0xF8, 0xFD, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF,
  0xC1, 0xFE, 0xFF, 0x00, 0xFE, 0xFF, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFE,
  0x00, 0x7E, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0x00,
  0x18, 0x00, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0xFE, 0x03, 0xF8, 0xFE, 0x00, 0xFC,
  0x7E, 0x00, 0x7F, 0x3F, 0x00, 0x1F, 0xBF, 0x80, 0x0F, 0xDF, 0x80, 0x07,
  0xEF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00,
  0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8,
  0x00, 0x7E, 0xFE, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0x9F, 0x80, 0x1F, 0xC7,
  0xE0, 0x0F, 0xC3, 0xF8, 0x0F, 0xE0, 0xFF, 0xBF, 0xE0, 0x7F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x7C, 0x1F, 0xF0, 0x3E, 0x3F, 0xFC, 0x1F, 0x1F,
  0xFF, 0x0F, 0xDF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF3, 0xFE, 0x03, 0xF9, 0xFE,
  0x00, 0xFC, 0xFF, 0x00, 0x7F, 0x7F, 0x00, 0x1F, 0xBF, 0x80, 0x0F, 0xDF,
  0xC0, 0x07, 0xEF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07,
  0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00,
  0xFF, 0xFC, 0x00, 0x7E, 0xFE, 0x00, 0x3F, 0x7F, 0x00, 0x1F, 0xBF, 0xC0,
  0x1F, 0xDF, 0xE0, 0x0F, 0xCF, 0xF8, 0x0F, 0xE7, 0xFF, 0xFF, 0xE3, 0xF7,
  0xFF, 0xF1, 0xFB, 0xFF, 0xF0, 0xFC, 0xFF, 0xF0, 0x7E, 0x1F, 0xF0, 0x3F,
  0x01, 0xC0, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x03, 0xFE, 0x1F, 0x07, 0xFF, 0x1F, 0x0F, 0xFF, 0x9F, 0x1F,
  0xFF, 0xDF, 0x3F, 0xFF, 0xFF, 0x3F, 0x81, 0xFF, 0x7F, 0x00, 0xFF, 0x7E,
  0x00, 0x7F, 0x7E, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x7F, 0x00, 0xFF, 0x3F,
  0x81, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xDF, 0x1F, 0xFF, 0x9F, 0x0F,
  0xFF, 0x3F, 0x03, 0xFE, 0x3F, 0x00, 0x60, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x06, 0x7C, 0x1F, 0xFE, 0x1F, 0xDF, 0x1F, 0xEF, 0x9F,
  0xF7, 0xEF, 0xFB, 0xFF, 0xFD, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0x80, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x7F, 0xF8, 0x1F, 0xFF, 0xE3, 0xFF,
  0xFE, 0x3F, 0xFF, 0xE7, 0xFC, 0xFC, 0x7E, 0x00, 0xCF, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07,
  0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFE, 0x00, 0x07,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00,
  0x7E, 0xF0, 0x0F, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF,
  0xFF, 0x03, 0xFF, 0xE0, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0xFE,
  0x7F, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xE0, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x01, 0xFF, 0xF0,
  0xFF, 0xF8, 0x3F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0x30, 0x00, 0xFC,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07,
  0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF,
  0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xFC,
  0x01, 0xFF, 0xF8, 0x07, 0xFB, 0xF8, 0x1F, 0xF7, 0xFF, 0xFF, 0xE7, 0xFF,
  0xF7, 0xCF, 0xFF, 0xCF, 0x8F, 0xFF, 0x1F, 0x07, 0xFC, 0x3E, 0x03, 0xC0,
  0x00, 0xFE, 0x00, 0x0F, 0xDF, 0x80, 0x03, 0xF7, 0xE0, 0x01, 0xFD, 0xF8,
  0x00, 0x7E, 0x7F, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xE3, 0xF0, 0x03, 0xF0,
  0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x1F, 0x81, 0xF8, 0x07,
  0xE0, 0x3E, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x3F, 0x00, 0xFC,
  0x0F, 0xC0, 0x1F, 0x03, 0xF0, 0x07, 0xE0, 0xF8, 0x01, 0xF8, 0x7E, 0x00,
  0x3E, 0x1F, 0x80, 0x0F, 0x87, 0xC0, 0x03, 0xF1, 0xF0, 0x00, 0xFC, 0xFC,
  0x00, 0x1F, 0x3F, 0x00, 0x07, 0xCF, 0x80, 0x01, 0xFB, 0xE0, 0x00, 0x3F,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0x00, 0x3E, 0xFC, 0x00, 0xFF, 0x00, 0x7E, 0x7E, 0x01, 0xFF,
  0x00, 0x7E, 0x7E, 0x01, 0xFF, 0x00, 0x7E, 0x7E, 0x01, 0xFF, 0x80, 0x7C,
  0x7E, 0x01, 0xEF, 0x80, 0xFC, 0x3E, 0x03, 0xEF, 0x80, 0xFC, 0x3F, 0x03,
  0xEF, 0x80, 0xFC, 0x3F, 0x03, 0xE7, 0x80, 0xFC, 0x3F, 0x03, 0xE7, 0xC1,
  0xF8, 0x3F, 0x03, 0xC7, 0xC1, 0xF8, 0x1F, 0x87, 0xC7, 0xC1, 0xF8, 0x1F,
  0x87, 0xC7, 0xC1, 0xF8, 0x1F, 0x87, 0xC3, 0xE1, 0xF0, 0x1F, 0x87, 0xC3,
  0xE3, 0xF0, 0x0F, 0x8F, 0x83, 0xE3, 0xF0, 0x0F, 0xCF, 0x83, 0xE3, 0xF0,
  0x0F, 0xCF, 0x83, 0xE3, 0xE0, 0x0F, 0xCF, 0x81, 0xF3, 0xE0, 0x07, 0xCF,
  0x81, 0xF7, 0xE0, 0x07, 0xCF, 0x01, 0xF7, 0xE0, 0x07, 0xDF, 0x01, 0xF7,
  0xC0, 0x07, 0xFF, 0x01, 0xF7, 0xC0, 0x07, 0xFF, 0x00, 0xF7, 0xC0, 0x03,
  0xFE, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x7F, 0x80,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0xFE, 0x00,
  0x3F, 0x3F, 0x00, 0x3F, 0x8F, 0xC0, 0x1F, 0x87, 0xE0, 0x1F, 0xC1, 0xF8,
  0x0F, 0xC0, 0xFC, 0x0F, 0xE0, 0x3F, 0x07, 0xE0, 0x1F, 0x87, 0xF0, 0x07,
  0xE3, 0xF0, 0x03, 0xF3, 0xF0, 0x00, 0xFD, 0xF8, 0x00, 0x7F, 0xF8, 0x00,
  0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x1F, 0x9F, 0x80, 0x0F, 0xC7,
  0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xE0, 0xFC, 0x07, 0xE0, 0x7E, 0x03, 0xF0,
  0x1F, 0x83, 0xF0, 0x0F, 0xC1, 0xF8, 0x03, 0xF1, 0xF8, 0x01, 0xF8, 0xFC,
  0x00, 0x7E, 0xFC, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x0F, 0xDF, 0x80, 0x03,
  0xF7, 0xE0, 0x01, 0xFD, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x8F, 0xC0,
  0x0F, 0xE3, 0xF0, 0x03, 0xF0, 0xFE, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x07,
  0xE0, 0x1F, 0x81, 0xF8, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x07, 0xE0,
  0xF8, 0x00, 0xF8, 0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xC7, 0xE0, 0x01,
  0xF1, 0xF0, 0x00, 0x7C, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x07, 0xEF, 0x80,
  0x00, 0xFB, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xFF,
  0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x70, 0x00, 0x00, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF,
  0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0xC0, 0x07, 0xF0, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0xFF,
  0xC0, 0x7F, 0xC0, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x3F, 0xE0, 0x3F, 0xF0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x1F,
  0xC0, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x3F, 0x80, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x07,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x03,
  0xFC, 0x00, 0x7F, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xC0,
  0x1F, 0xE0, 0x3F, 0xF8, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFE, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x9F, 0xF8, 0x00, 0x5F, 0xFF, 0x00, 0x7F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x80, 0x7F, 0xFD,
  0x00, 0x0F, 0xFC, 0x80, 0x00, 0xF0, 0x00,
};

const GFXglyph NotoSans_Condensed_Medium61pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 8, 45, 15, 4, -44 },
  { 46, 18, 16, 25, 3, -44 },
  { 82, 30, 44, 32, 1, -44 },
  { 247, 24, 50, 29, 3, -46 },
  { 397, 41, 45, 45, 2, -44 },
  { 628, 33, 45, 35, 2, -44 },
  { 814, 7, 16, 14, 3, -44 },
  { 828, 14, 54, 18, 3, -44 },
  { 923, 14, 54, 18, 2, -44 },
  { 1018, 24, 23, 28, 2, -46 },
  { 1087, 25, 29, 29, 2, -36 },
  { 1178, 10, 15, 15, 2, -7 },
  { 1197, 14, 5, 18, 2, -19 },
  { 1206, 7, 9, 15, 4, -8 },
  { 1214, 22, 44, 23, 1, -44 },
  { 1335, 25, 45, 29, 2, -44 },
  { 1476, 16, 44, 29, 4, -44 },
  { 1564, 24, 44, 29, 2, -44 },
  { 1696, 24, 45, 29, 2, -44 },
  { 1831, 27, 44, 29, 1, -44 },
  { 1980, 23, 45, 29, 3, -44 },
  { 2110, 24, 45, 29, 3, -44 },
  { 2245, 25, 44, 29, 2, -44 },
  { 2383, 25, 45, 29, 2, -44 },
  { 2524, 24, 45, 29, 2, -44 },
  { 2659, 7, 34, 15, 4, -33 },
  { 2689, 9, 41, 15, 2, -33 },
  { 2736, 25, 29, 29, 2, -36 },
  { 2827, 25, 17, 29, 2, -30 },
  { 2881, 25, 29, 29, 2, -36 },
  { 2972, 20, 45, 22, 1, -44 },
  { 3085, 39, 49, 45, 3, -44 },
  { 3324, 32, 44, 32, 0, -44 },
  { 3500, 25, 44, 33, 5, -44 },
  { 3638, 27, 45, 31, 3, -44 },
  { 3790, 28, 44, 36, 5, -44 },
  { 3944, 20, 44, 28, 5, -44 },
  { 4054, 20, 44, 27, 5, -44 },
  { 4164, 30, 45, 37, 3, -44 },
  { 4333, 27, 44, 37, 5, -44 },
  { 4482, 15, 44, 19, 2, -44 },
  { 4565, 15, 56, 16, -4, -44 },
  { 4670, 27, 44, 32, 5, -44 },
  { 4819, 20, 44, 26, 5, -44 },
  { 4929, 38, 44, 48, 5, -44 },
  { 5138, 29, 44, 39, 5, -44 },
  { 5298, 32, 45, 38, 3, -44 },
  { 5478, 23, 44, 31, 5, -44 },
  { 5605, 32, 54, 38, 3, -44 },
  { 5821, 26, 44, 32, 5, -44 },
  { 5964, 23, 45, 28, 2, -44 },
  { 6094, 25, 44, 27, 1, -44 },
  { 6232, 28, 45, 36, 4, -44 },
  { 6390, 31, 44, 31, 0, -44 },
  { 6561, 48, 44, 48, 0, -44 },
  { 6825, 29, 44, 29, 0, -44 },
  { 6985, 28, 44, 28, 0, -44 },
  { 7139, 23, 44, 27, 2, -44 },
  { 7266, 14, 54, 19, 4, -44 },
  { 7361, 22, 44, 23, 1, -44 },
  { 7482, 13, 54, 19, 2, -44 },
  { 7570, 28, 26, 30, 1, -44 },
  { 7661, 26, 4, 26, 0, 5 },
  { 7674, 13, 10, 18, 2, -47 },
  { 7691, 23, 34, 29, 2, -33 },
  { 7789, 25, 47, 32, 4, -46 },
  { 7936, 20, 35, 24, 3, -34 },
  { 8024, 24, 47, 32, 3, -46 },
  { 8165, 23, 34, 29, 3, -33 },
  { 8263, 19, 47, 18, 1, -47 },
  { 8375, 24, 49, 32, 3, -34 },
  { 8522, 24, 46, 32, 4, -46 },
  { 8660, 7, 45, 14, 4, -45 },
  { 8700, 13, 60, 14, -2, -45 },
  { 8798, 24, 46, 28, 4, -46 },
  { 8936, 6, 46, 14, 4, -46 },
  { 8971, 39, 34, 47, 4, -34 },
  { 9137, 24, 34, 32, 4, -34 },
  { 9239, 25, 35, 31, 3, -34 },
  { 9349, 25, 49, 32, 4, -34 },
  { 9503, 24, 49, 32, 3, -34 },
  { 9650, 17, 34, 21, 4, -34 },
  { 9723, 20, 35, 24, 2, -34 },
  { 9811, 17, 41, 19, 1, -40 },
  { 9899, 23, 34, 32, 4, -33 },
  { 9997, 26, 33, 26, 0, -33 },
  { 10105, 40, 33, 42, 1, -33 },
  { 10270, 25, 33, 26, 1, -33 },
  { 10374, 26, 48, 26, 0, -33 },
  { 10530, 19, 33, 22, 2, -33 },
  { 10609, 18, 54, 22, 2, -44 },
  { 10731, 6, 60, 28, 11, -46 },
  { 10776, 18, 54, 22, 2, -44 },
  { 10898, 25, 9, 29, 2, -26 },
};

const GFXfont NotoSans_Condensed_Medium61pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Medium61pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Medium61pt7bGlyphs,
  0x20, 0x7E, 83
};

#endif // _NOTOSANS_CONDENSED_MEDIUM61PT7B_H_
