#ifndef _NOTOSANS_CONDENSED_MEDIUM18PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUM18PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Medium.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Medium18pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFD, 0x43, 0xC0, 0xDE, 0xF3, 0x9C, 0x80, 0x19, 0x0D, 0x84,
  0xC2, 0x47, 0xF8, 0x90, 0xC8, 0x6C, 0xFF, 0x93, 0x09, 0x04, 0x82, 0x40,
  0x10, 0x21, 0xFE, 0xAD, 0x1A, 0x3C, 0x1C, 0x1C, 0x2C, 0x5E, 0xEF, 0x82,
  0x04, 0x00, 0x61, 0x8D, 0x18, 0x91, 0x09, 0x30, 0x92, 0x09, 0x6C, 0xD5,
  0xA6, 0x53, 0x0D, 0x30, 0x93, 0x19, 0x31, 0x1A, 0x30, 0xE0, 0x38, 0x36,
  0x13, 0x09, 0x86, 0xC3, 0xC1, 0xC1, 0xB3, 0xCF, 0x47, 0xB1, 0x9D, 0xE7,
  0x98, 0xFF, 0xC0, 0x36, 0x64, 0xCC, 0xCC, 0xCC, 0xCC, 0x46, 0x63, 0xC3,
  0x08, 0x63, 0x08, 0x63, 0x18, 0xC4, 0x63, 0x11, 0x98, 0x30, 0x62, 0xD7,
  0xF3, 0x0F, 0x33, 0x00, 0x10, 0x20, 0x40, 0x8F, 0xE2, 0x04, 0x08, 0x10,
  0xFE, 0xFF, 0xF0, 0x06, 0x08, 0x30, 0x41, 0x83, 0x04, 0x18, 0x30, 0x41,
  0x82, 0x0C, 0x00, 0x38, 0xFB, 0x16, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F,
  0x13, 0x67, 0x80, 0x19, 0xDF, 0xB1, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x80,
  0x79, 0xFA, 0x10, 0x20, 0x41, 0x83, 0x0C, 0x30, 0xC1, 0x07, 0xFF, 0xE0,
  0x79, 0xF8, 0x10, 0x20, 0xC3, 0x9E, 0x06, 0x06, 0x0C, 0x1C, 0xEF, 0x80,
  0x06, 0x0E, 0x0E, 0x1E, 0x16, 0x36, 0x26, 0x66, 0xC6, 0xFF, 0x06, 0x06,
  0x06, 0xFD, 0xFB, 0x06, 0x0C, 0x1F, 0x3F, 0x03, 0x06, 0x0C, 0x1E, 0xEF,
  0x80, 0x3C, 0xF9, 0x86, 0x0C, 0x1F, 0xBB, 0x63, 0xC7, 0x8F, 0x1B, 0x67,
  0x80, 0xFF, 0xFC, 0x18, 0x60, 0xC1, 0x06, 0x0C, 0x10, 0x60, 0xC3, 0x06,
  0x00, 0x79, 0xDB, 0x1E, 0x3C, 0xCF, 0x8E, 0x76, 0xC7, 0x0E, 0x1E, 0x77,
  0xC0, 0x79, 0xFB, 0x16, 0x38, 0x78, 0xF3, 0xBF, 0x06, 0x08, 0x34, 0xCF,
  0x00, 0xF4, 0x00, 0xF0, 0xF4, 0x00, 0xFE, 0x02, 0x0C, 0x73, 0x8C, 0x1C,
  0x0F, 0x07, 0x02, 0xFF, 0xFC, 0x00, 0x0F, 0xE0, 0x81, 0x81, 0xC0, 0xE0,
  0x63, 0x9C, 0x60, 0x80, 0x7B, 0xF0, 0xC3, 0x0C, 0x61, 0x8C, 0x20, 0x00,
  0x0C, 0x30, 0x0F, 0x07, 0x39, 0x81, 0x20, 0x3C, 0xF3, 0xB2, 0x64, 0x4C,
  0x89, 0x93, 0x33, 0x6F, 0x33, 0x20, 0x06, 0x00, 0x7F, 0x01, 0x00, 0x0C,
  0x0E, 0x07, 0x02, 0xC3, 0x61, 0x90, 0xCC, 0x46, 0x7F, 0x30, 0x98, 0x78,
  0x3C, 0x18, 0xFC, 0xFE, 0xC3, 0xC3, 0xC2, 0xCE, 0xFC, 0xC7, 0xC3, 0xC3,
  0xC3, 0xFE, 0xFC, 0x1F, 0x7E, 0x60, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0x60, 0x72, 0x3E, 0xFC, 0x7F, 0x30, 0xD8, 0x6C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE1, 0xB0, 0xDF, 0xCF, 0xC0, 0xFF, 0xFC, 0x30, 0xC3, 0x0F,
  0xF0, 0xC3, 0x0C, 0x3F, 0xFC, 0xFF, 0xFC, 0x30, 0xC3, 0x0F, 0xFF, 0xC3,
  0x0C, 0x30, 0xC0, 0x1F, 0x9F, 0x98, 0x18, 0x0C, 0x06, 0x03, 0x1F, 0x8F,
  0xC1, 0xE0, 0xD8, 0x6E, 0x73, 0xF8, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1F,
  0xFF, 0xFF, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x18, 0xF6, 0x66, 0x66,
  0x66, 0x66, 0x66, 0xF0, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x3F,
  0xC0, 0xC3, 0xC6, 0xC6, 0xCC, 0xD8, 0xD8, 0xF8, 0xF8, 0xCC, 0xCC, 0xC6,
  0xC3, 0xC3, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x3F, 0xFC,
  0xE0, 0x7E, 0x07, 0xF0, 0xFF, 0x0F, 0xD0, 0xBD, 0x8B, 0xD9, 0xBC, 0x9B,
  0xCD, 0x3C, 0xF3, 0xCF, 0x3C, 0x63, 0xC6, 0x30, 0xE1, 0xF0, 0xFC, 0x7E,
  0x3D, 0x9E, 0xCF, 0x37, 0x9B, 0xC7, 0xE3, 0x70, 0xF8, 0x7C, 0x18, 0x3E,
  0x3F, 0x98, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xD8, 0x6E,
  0xE3, 0xE0, 0xF9, 0xFF, 0x1E, 0x3C, 0x38, 0xF3, 0xFE, 0xC1, 0x83, 0x06,
  0x0C, 0x00, 0x3E, 0x3F, 0x98, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xD8, 0x6E, 0xE3, 0xE0, 0x30, 0x0C, 0x07, 0xF8, 0xFE, 0xC6, 0xC2,
  0xC2, 0xC6, 0xFC, 0xF8, 0xCC, 0xC4, 0xC6, 0xC6, 0xC3, 0x7D, 0xFB, 0x06,
  0x0C, 0x1C, 0x1E, 0x0E, 0x0C, 0x0C, 0x36, 0xEF, 0x80, 0xFF, 0xFF, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0xC1, 0xC1,
  0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0x43, 0x77, 0x3E, 0xC1,
  0xE0, 0xD0, 0x4C, 0x66, 0x33, 0x18, 0xC8, 0x6C, 0x36, 0x0B, 0x05, 0x03,
  0x81, 0xC0, 0xC3, 0x0F, 0x0C, 0x34, 0x30, 0xD8, 0xE2, 0x67, 0x99, 0x9A,
  0x66, 0x49, 0x89, 0x36, 0x3C, 0xD0, 0xF1, 0xC3, 0xC7, 0x06, 0x1C, 0x18,
  0x60, 0xC3, 0x31, 0x99, 0x86, 0xC3, 0xC0, 0xE0, 0x60, 0x38, 0x34, 0x1B,
  0x19, 0x8C, 0x6C, 0x38, 0xC3, 0x43, 0x62, 0x66, 0x36, 0x3C, 0x1C, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x7E, 0xFC, 0x18, 0x60, 0xC3, 0x06, 0x18,
  0x30, 0x41, 0x83, 0xFF, 0xE0, 0xFF, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC,
  0xFF, 0xC0, 0x81, 0x83, 0x03, 0x06, 0x04, 0x0C, 0x18, 0x10, 0x30, 0x60,
  0x60, 0xFF, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0xFF, 0x08, 0x0E, 0x05,
  0x06, 0xC2, 0x63, 0x19, 0x8D, 0x83, 0xFF, 0xCC, 0x80, 0xF9, 0xF0, 0xC1,
  0x7F, 0x9C, 0x63, 0xCF, 0xD0, 0xC0, 0xC0, 0xC0, 0xC0, 0xDC, 0xFE, 0xC6,
  0xC2, 0xC3, 0xC3, 0xC2, 0xC6, 0xE6, 0xDC, 0x3D, 0xEC, 0x30, 0xC3, 0x0C,
  0x30, 0xE5, 0xF0, 0x06, 0x0C, 0x18, 0x37, 0x6F, 0xF1, 0xE3, 0xC7, 0x8F,
  0x1E, 0x3E, 0xEF, 0x40, 0x38, 0xFB, 0x16, 0x3F, 0xFF, 0xF0, 0x60, 0x64,
  0xF8, 0x1C, 0xF2, 0x08, 0x7B, 0xE6, 0x18, 0x61, 0x86, 0x18, 0x61, 0x80,
  0x32, 0xFF, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xEE, 0xFC, 0x18, 0x38, 0xFF,
  0x80, 0xC1, 0x83, 0x06, 0x0D, 0xDF, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C,
  0x78, 0xC0, 0xF3, 0xFF, 0xFF, 0xC0, 0x33, 0x03, 0x33, 0x33, 0x33, 0x33,
  0x33, 0x33, 0xE0, 0xC1, 0x83, 0x06, 0x0C, 0x79, 0xB2, 0x6C, 0xF1, 0xF3,
  0x26, 0x6C, 0x78, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0xDC, 0xEF, 0xFE, 0xC6,
  0x3C, 0x63, 0xC6, 0x3C, 0x63, 0xC6, 0x3C, 0x63, 0xC6, 0x3C, 0x63, 0xDD,
  0xFF, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8C, 0x38, 0xFB, 0x1E, 0x3C,
  0x78, 0xF1, 0xE3, 0x6E, 0xF8, 0xDC, 0xFE, 0xC6, 0xC2, 0xC3, 0xC3, 0xC2,
  0xC6, 0xE6, 0xDC, 0xC0, 0xC0, 0xC0, 0xC0, 0x32, 0xFF, 0x1E, 0x3C, 0x78,
  0xF1, 0xE3, 0xEE, 0xFC, 0x18, 0x30, 0x60, 0xC0, 0xDF, 0xF9, 0x8C, 0x63,
  0x18, 0xC6, 0x00, 0x7F, 0xE1, 0x8E, 0x1C, 0x61, 0x9F, 0xC0, 0x21, 0x1F,
  0xF6, 0x31, 0x8C, 0x63, 0x1E, 0x70, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1,
  0xE3, 0xEE, 0xF4, 0xC3, 0xC2, 0x46, 0x66, 0x64, 0x24, 0x3C, 0x3C, 0x38,
  0x18, 0xC6, 0x3C, 0x63, 0x47, 0x36, 0xF2, 0x6D, 0x66, 0x96, 0x29, 0x62,
  0x9C, 0x39, 0xC3, 0x8C, 0xC7, 0x66, 0x2C, 0x3C, 0x18, 0x18, 0x3C, 0x2C,
  0x66, 0xC7, 0xC3, 0xC2, 0x66, 0x66, 0x64, 0x24, 0x3C, 0x3C, 0x18, 0x18,
  0x18, 0x10, 0x30, 0xE0, 0x7D, 0xF0, 0xC6, 0x18, 0xC3, 0x18, 0x63, 0xF0,
  0x19, 0xD8, 0xC6, 0x31, 0x9C, 0xE3, 0x18, 0xC6, 0x30, 0xE3, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xC7, 0x18, 0xC6, 0x31, 0x87, 0x3B, 0x18, 0xC6, 0x33,
  0x98, 0x43, 0xFE, 0x70,
};

const GFXglyph NotoSans_Condensed_Medium18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 2, 13, 5, 1, -13 },
  { 5, 5, 5, 7, 1, -13 },
  { 9, 9, 13, 9, 0, -13 },
  { 24, 7, 15, 9, 1, -14 },
  { 38, 12, 13, 13, 1, -13 },
  { 58, 9, 13, 10, 1, -13 },
  { 73, 2, 5, 4, 1, -13 },
  { 75, 4, 16, 5, 1, -13 },
  { 83, 5, 16, 5, 0, -13 },
  { 93, 7, 7, 8, 1, -14 },
  { 100, 7, 9, 9, 1, -11 },
  { 108, 2, 4, 4, 1, -2 },
  { 109, 4, 2, 5, 1, -6 },
  { 110, 2, 2, 4, 1, -2 },
  { 111, 7, 13, 7, 0, -13 },
  { 123, 7, 13, 9, 1, -13 },
  { 135, 5, 13, 9, 1, -13 },
  { 144, 7, 13, 9, 1, -13 },
  { 156, 7, 13, 9, 1, -13 },
  { 168, 8, 13, 9, 0, -13 },
  { 181, 7, 13, 9, 1, -13 },
  { 193, 7, 13, 9, 1, -13 },
  { 205, 7, 13, 9, 1, -13 },
  { 217, 7, 13, 9, 1, -13 },
  { 229, 7, 13, 9, 1, -13 },
  { 241, 2, 10, 4, 1, -10 },
  { 244, 2, 12, 4, 1, -10 },
  { 247, 7, 9, 9, 1, -11 },
  { 255, 7, 5, 9, 1, -9 },
  { 260, 7, 9, 9, 1, -11 },
  { 268, 6, 13, 7, 0, -13 },
  { 278, 11, 15, 13, 1, -13 },
  { 299, 9, 13, 9, 0, -13 },
  { 314, 8, 13, 10, 1, -13 },
  { 327, 8, 13, 9, 1, -13 },
  { 340, 9, 13, 11, 1, -13 },
  { 355, 6, 13, 8, 1, -13 },
  { 365, 6, 13, 8, 1, -13 },
  { 375, 9, 13, 11, 1, -13 },
  { 390, 9, 13, 11, 1, -13 },
  { 405, 4, 13, 6, 1, -13 },
  { 412, 4, 17, 5, -1, -13 },
  { 421, 8, 13, 9, 1, -13 },
  { 434, 6, 13, 8, 1, -13 },
  { 444, 12, 13, 14, 1, -13 },
  { 464, 9, 13, 12, 1, -13 },
  { 479, 9, 13, 11, 1, -13 },
  { 494, 7, 13, 9, 1, -13 },
  { 506, 9, 16, 11, 1, -13 },
  { 524, 8, 13, 9, 1, -13 },
  { 537, 7, 13, 8, 1, -13 },
  { 549, 8, 13, 8, 0, -13 },
  { 562, 8, 13, 11, 1, -13 },
  { 575, 9, 13, 9, 0, -13 },
  { 590, 14, 13, 14, 0, -13 },
  { 613, 9, 13, 9, 0, -13 },
  { 628, 8, 13, 8, 0, -13 },
  { 641, 7, 13, 8, 0, -13 },
  { 653, 4, 16, 6, 1, -13 },
  { 661, 7, 13, 7, 0, -13 },
  { 673, 4, 16, 6, 0, -13 },
  { 681, 9, 8, 9, 0, -13 },
  { 690, 8, 1, 8, 0, 2 },
  { 691, 3, 3, 5, 1, -14 },
  { 693, 6, 10, 9, 1, -10 },
  { 701, 8, 14, 9, 1, -14 },
  { 715, 6, 10, 7, 1, -10 },
  { 723, 7, 14, 9, 1, -14 },
  { 736, 7, 10, 9, 1, -10 },
  { 745, 6, 14, 5, 0, -14 },
  { 756, 7, 14, 9, 1, -10 },
  { 769, 7, 14, 9, 1, -14 },
  { 782, 2, 13, 4, 1, -13 },
  { 786, 4, 17, 4, -1, -13 },
  { 795, 7, 14, 8, 1, -14 },
  { 808, 2, 14, 4, 1, -14 },
  { 812, 12, 10, 14, 1, -10 },
  { 827, 7, 10, 9, 1, -10 },
  { 836, 7, 10, 9, 1, -10 },
  { 845, 8, 14, 9, 1, -10 },
  { 859, 7, 14, 9, 1, -10 },
  { 872, 5, 10, 6, 1, -10 },
  { 879, 5, 10, 7, 1, -10 },
  { 886, 5, 12, 6, 0, -12 },
  { 894, 7, 10, 9, 1, -10 },
  { 903, 8, 10, 8, 0, -10 },
  { 913, 12, 10, 12, 0, -10 },
  { 928, 8, 10, 8, 0, -10 },
  { 938, 8, 14, 8, 0, -10 },
  { 952, 6, 10, 7, 0, -10 },
  { 960, 5, 16, 7, 1, -13 },
  { 970, 2, 18, 8, 3, -14 },
  { 975, 5, 16, 7, 1, -13 },
  { 985, 7, 3, 9, 1, -8 },
};

const GFXfont NotoSans_Condensed_Medium18pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Medium18pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Medium18pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _NOTOSANS_CONDENSED_MEDIUM18PT7B_H_
