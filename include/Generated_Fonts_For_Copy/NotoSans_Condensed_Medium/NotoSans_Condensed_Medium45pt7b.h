#ifndef _NOTOSANS_CONDENSED_MEDIUM45PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUM45PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Medium.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Medium45pt7bBitmaps[] PROGMEM = {
  0x00, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0x79, 0xE7,
  0x9E, 0x79, 0xE7, 0x9C, 0x71, 0xC7, 0x00, 0x00, 0x07, 0x3E, 0xFB, 0xFF,
  0xBE, 0x20, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0x78, 0x7B,
  0xC3, 0xDE, 0x1E, 0xF0, 0x77, 0x83, 0xBC, 0x1C, 0x01, 0xE1, 0xE0, 0x07,
  0x87, 0x80, 0x1E, 0x1C, 0x00, 0x70, 0x70, 0x01, 0xC1, 0xC0, 0x07, 0x07,
  0x00, 0x1C, 0x1C, 0x00, 0xF0, 0xF0, 0x03, 0xC3, 0xC1, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x03, 0x83, 0x80, 0x0E, 0x1E, 0x00, 0x78,
  0x78, 0x01, 0xE1, 0xE0, 0x07, 0x07, 0x00, 0x1C, 0x1C, 0x00, 0x70, 0x70,
  0x3F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x83,
  0x83, 0x80, 0x0E, 0x0E, 0x00, 0x38, 0x38, 0x00, 0xE0, 0xE0, 0x03, 0x87,
  0x80, 0x1E, 0x1E, 0x00, 0x78, 0x70, 0x01, 0xC1, 0xC0, 0x07, 0x07, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x0F, 0xFE, 0x07,
  0xFF, 0xE3, 0xFF, 0xF9, 0xFB, 0x3C, 0xF8, 0xC1, 0x3C, 0x30, 0x0F, 0x0C,
  0x03, 0xC3, 0x00, 0xF0, 0xC0, 0x3E, 0x30, 0x07, 0xEC, 0x01, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x80,
  0x33, 0xE0, 0x0C, 0x78, 0x03, 0x1F, 0x00, 0xC3, 0xC0, 0x31, 0xF8, 0x0C,
  0x7B, 0xC3, 0x7E, 0xFF, 0xFF, 0x3F, 0xFF, 0x87, 0xFF, 0xC0, 0x3F, 0x80,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x04, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x78, 0x03, 0xFC, 0x01, 0xE0, 0x1F,
  0xF0, 0x0F, 0x00, 0x71, 0xE0, 0x3C, 0x03, 0xC3, 0x80, 0xE0, 0x0F, 0x0E,
  0x07, 0x80, 0x38, 0x3C, 0x1C, 0x00, 0xE0, 0xF0, 0xF0, 0x03, 0x83, 0xC3,
  0xC0, 0x0E, 0x0F, 0x0E, 0x00, 0x38, 0x3C, 0x78, 0x00, 0xE0, 0xF1, 0xC0,
  0x03, 0x83, 0xCF, 0x0E, 0x0F, 0x0E, 0x3C, 0xFE, 0x3C, 0x39, 0xE7, 0xFC,
  0x71, 0xE7, 0x9E, 0xF1, 0xFF, 0x1C, 0xF1, 0xE3, 0xFC, 0xF3, 0xC3, 0x87,
  0xE3, 0x8F, 0x0E, 0x04, 0x1E, 0x38, 0x3C, 0x00, 0x78, 0xE0, 0xF0, 0x01,
  0xC3, 0x83, 0xC0, 0x0F, 0x0E, 0x0F, 0x00, 0x38, 0x38, 0x3C, 0x01, 0xE0,
  0xE0, 0xF0, 0x07, 0x03, 0x83, 0x80, 0x3C, 0x0F, 0x0E, 0x00, 0xF0, 0x3C,
  0x78, 0x03, 0x80, 0x71, 0xE0, 0x1E, 0x01, 0xFF, 0x00, 0x70, 0x03, 0xFC,
  0x03, 0xC0, 0x07, 0xE0, 0x00, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x1F, 0xFE, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x1E, 0x00, 0x3C, 0x1F,
  0x00, 0x3C, 0x1F, 0x00, 0x3C, 0x1E, 0x00, 0x3E, 0x1E, 0x00, 0x3E, 0x1E,
  0x00, 0x1E, 0x3E, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xF0, 0x3C, 0x7F, 0xF8,
  0x3C, 0x7C, 0xF8, 0x7C, 0xF8, 0x7C, 0x7C, 0xF8, 0x3E, 0x78, 0xF0, 0x3F,
  0xF8, 0xF0, 0x1F, 0xF8, 0xF0, 0x0F, 0xF0, 0xF0, 0x07, 0xF0, 0xF0, 0x07,
  0xE0, 0xF8, 0x07, 0xE0, 0xFC, 0x0F, 0xF0, 0x7F, 0xFF, 0xF8, 0x7F, 0xFE,
  0xFC, 0x3F, 0xFC, 0x7E, 0x0F, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x03, 0xC1, 0xE0, 0x78, 0x3C, 0x1F, 0x07, 0x81, 0xE0, 0xF0, 0x3C,
  0x1F, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x0F, 0x83, 0xE0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xE0, 0xF8, 0x1E, 0x07, 0x81, 0xE0,
  0x7C, 0x1F, 0x03, 0xC0, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x81,
  0xE0, 0x3C, 0xF8, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xE0, 0x3E, 0x03, 0xC0,
  0x78, 0x0F, 0x80, 0xF0, 0x1E, 0x03, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x03, 0xE0, 0x78, 0x0F, 0x03, 0xE0, 0x78, 0x0F, 0x03,
  0xE0, 0x78, 0x1F, 0x03, 0xC0, 0xF0, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x1C, 0x38, 0xE7, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x0F,
  0x3C, 0x07, 0xCF, 0x83, 0xE1, 0xF0, 0x38, 0x78, 0x04, 0x08, 0x00, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x3E, 0xF9, 0xF3, 0xE7, 0x8F, 0x1E, 0x78, 0xF1, 0xE3, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x77, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x1F,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78,
  0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0,
  0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x00, 0x80, 0x01, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F,
  0x7E, 0x1F, 0x07, 0xC7, 0xC0, 0xF1, 0xE0, 0x3E, 0x78, 0x0F, 0xBE, 0x01,
  0xEF, 0x80, 0x7B, 0xE0, 0x1E, 0xF8, 0x07, 0xBC, 0x01, 0xFF, 0x00, 0x7F,
  0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0,
  0x07, 0xFE, 0x01, 0xEF, 0x80, 0x7B, 0xE0, 0x1E, 0xF8, 0x07, 0x9E, 0x03,
  0xE7, 0x80, 0xF9, 0xF0, 0x3C, 0x3E, 0x1F, 0x0F, 0xFF, 0x81, 0xFF, 0xE0,
  0x7F, 0xF0, 0x07, 0xF8, 0x00, 0x01, 0xF0, 0x3F, 0x07, 0xF0, 0xFF, 0x1F,
  0xF3, 0xFF, 0x7D, 0xFF, 0x9F, 0x71, 0xF2, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x00, 0xC0, 0x0F, 0xFC, 0x0F, 0xFF, 0x1F,
  0xFF, 0xCF, 0xE7, 0xF3, 0x80, 0xF8, 0x80, 0x3C, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xC0, 0x0F, 0xFC, 0x1F, 0xFF, 0x1F, 0xFF,
  0xCF, 0xC7, 0xF3, 0x00, 0xF9, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x3F, 0xF0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF8, 0x01, 0xF7, 0xEF, 0xFB, 0xFF, 0xF9, 0xFF, 0xF8,
  0x7F, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xEF, 0x00, 0x1E, 0xF0, 0x01,
  0xCF, 0x00, 0x3C, 0xF0, 0x03, 0x8F, 0x00, 0x78, 0xF0, 0x07, 0x0F, 0x00,
  0xF0, 0xF0, 0x0E, 0x0F, 0x01, 0xE0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x78, 0x0F, 0x07, 0x80, 0xF0, 0xF0, 0x0F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x3F,
  0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE7, 0xC0, 0x03, 0xE0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0xFF, 0x03, 0xFF, 0xE1, 0xFF, 0xF8, 0xFF, 0xFE, 0x20, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xF8, 0x07, 0xEF, 0xDF,
  0xF7, 0xFF, 0xF3, 0xFF, 0xF0, 0xFF, 0xE0, 0x00, 0x08, 0x00, 0x7F, 0xC0,
  0x7F, 0xF0, 0x3F, 0xFC, 0x1F, 0xE3, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF0,
  0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00,
  0x3C, 0x7F, 0x0F, 0x3F, 0xE3, 0xDF, 0xFC, 0xFF, 0x3F, 0x3F, 0x03, 0xEF,
  0x80, 0xFB, 0xE0, 0x1E, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0xF8, 0x07, 0xDE, 0x01, 0xF7, 0x80, 0x79, 0xF0, 0x3E, 0x3E, 0x0F,
  0x8F, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x00, 0xC0, 0x03, 0xFE, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x7E,
  0x1F, 0x1F, 0x03, 0xE7, 0x80, 0xFB, 0xE0, 0x1E, 0xF8, 0x07, 0x9E, 0x01,
  0xE7, 0x80, 0xF9, 0xF0, 0x3C, 0x3E, 0x1F, 0x0F, 0xCF, 0x81, 0xFF, 0xC0,
  0x3F, 0xE0, 0x07, 0xF0, 0x07, 0xFF, 0x03, 0xF7, 0xE1, 0xF8, 0xFC, 0x7C,
  0x1F, 0xBE, 0x03, 0xEF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x03, 0xFC, 0x01,
  0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x0F, 0x9F, 0x87, 0xE7, 0xFF, 0xF0,
  0xFF, 0xF8, 0x0F, 0xF8, 0x00, 0x00, 0x80, 0x03, 0xFE, 0x01, 0xFF, 0xC0,
  0xFF, 0xF8, 0x7F, 0x7E, 0x1F, 0x07, 0xCF, 0x80, 0xF3, 0xE0, 0x3E, 0xF0,
  0x0F, 0xBC, 0x01, 0xEF, 0x00, 0x7B, 0xC0, 0x1E, 0xF0, 0x07, 0xBC, 0x01,
  0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0x7C, 0x1F, 0x9F, 0xDF, 0xE3, 0xFF, 0xF8,
  0xFF, 0xDE, 0x0F, 0xE7, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x18, 0xFF,
  0x07, 0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xC0, 0x00, 0x27, 0xFF, 0xFF, 0xFD,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xEF, 0xFF, 0xFF, 0xF9,
  0x00, 0x11, 0xF7, 0xDF, 0x7D, 0xF3, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7D, 0xF7, 0xDF, 0x79, 0xEF, 0xBC, 0xF3, 0xCE,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x3C, 0x00, 0x3F, 0x00, 0x3F,
  0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x0F, 0x00, 0x00,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x30, 0x00, 0x0F,
  0x00, 0x03, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x3F,
  0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x0F,
  0xC0, 0x03, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x1F, 0xF0, 0xFF,
  0xFC, 0x7F, 0xFC, 0x7E, 0xFE, 0x20, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x07,
  0x80, 0x02, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xC0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0x7C, 0x07, 0x80, 0x01,
  0xE0, 0x78, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x1E, 0x3C, 0x03, 0xC0, 0xF1,
  0xE0, 0xFF, 0xC3, 0x9E, 0x0F, 0xFE, 0x1E, 0xF0, 0x78, 0xF0, 0xF7, 0x07,
  0x87, 0x87, 0xB8, 0x38, 0x3C, 0x1F, 0xC3, 0xC1, 0xE0, 0xFE, 0x1E, 0x0F,
  0x07, 0xF0, 0xF0, 0x78, 0x3F, 0x87, 0x03, 0xC1, 0xFC, 0x38, 0x1E, 0x0F,
  0xE1, 0xC0, 0xF0, 0xFF, 0x0E, 0x07, 0x87, 0xF8, 0x78, 0x7C, 0x3B, 0xC3,
  0xC3, 0xE1, 0xDE, 0x0F, 0x3B, 0x9E, 0x70, 0x7F, 0xDF, 0xE3, 0xC1, 0xFC,
  0xFE, 0x1E, 0x07, 0xC1, 0xE0, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x80, 0x07,
  0xF8, 0x7C, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xEF, 0x00, 0x01,
  0xE7, 0x80, 0x01, 0xE7, 0x80, 0x03, 0xE7, 0x80, 0x03, 0xC7, 0xC0, 0x03,
  0xC7, 0xC0, 0x07, 0xC3, 0xC0, 0x07, 0xC3, 0xC0, 0x07, 0x83, 0xE0, 0x07,
  0x81, 0xE0, 0x0F, 0x81, 0xE0, 0x0F, 0x81, 0xF0, 0x0F, 0x01, 0xF0, 0x0F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x3E,
  0x00, 0x78, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3C, 0x00, 0x7C, 0x7C,
  0x00, 0x3C, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8,
  0x00, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xE3, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF,
  0x80, 0xFD, 0xF0, 0x0F, 0xBE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x0F, 0x7C, 0x03, 0xEF, 0x80, 0xF9, 0xFF, 0xFF, 0x3F,
  0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xFF, 0x9F, 0x03, 0xFB, 0xE0, 0x1F, 0x7C,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x07, 0xEF, 0xFF, 0xFD, 0xFF,
  0xFF, 0x3F, 0xFF, 0xC7, 0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x0F, 0xFC, 0x03,
  0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xF7, 0xE1, 0xF8, 0x04, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0x80,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x20, 0xFF, 0xFE, 0x07, 0xFF, 0xE0,
  0x3F, 0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x3F, 0xFF,
  0xE1, 0xFF, 0xFF, 0x8F, 0x81, 0xFC, 0x7C, 0x03, 0xF3, 0xE0, 0x0F, 0xDF,
  0x00, 0x3E, 0xF8, 0x01, 0xF7, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xDF, 0x00, 0x3E, 0xF8, 0x01, 0xF7, 0xC0,
  0x1F, 0x3E, 0x01, 0xF9, 0xF0, 0x3F, 0x8F, 0xFF, 0xF8, 0x7F, 0xFF, 0x83,
  0xFF, 0xF8, 0x1F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00,
  0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFD, 0xF8, 0x7F,
  0x00, 0x61, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80,
  0x7F, 0xFE, 0x01, 0xFF, 0x78, 0x00, 0x3D, 0xE0, 0x00, 0xF7, 0xC0, 0x03,
  0xDF, 0x00, 0x0F, 0x7C, 0x00, 0x3C, 0xF8, 0x00, 0xF3, 0xE0, 0x03, 0xC7,
  0xC0, 0x0F, 0x1F, 0xC0, 0x3C, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x00, 0xFF, 0xF0, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xFD, 0xFF, 0x8F, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x81, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF8, 0xFD, 0xFF,
  0xBF, 0xE7, 0xF8, 0x7C, 0x00, 0xF0, 0x03, 0xFE, 0x00, 0xFB, 0xC0, 0x3E,
  0x78, 0x07, 0xCF, 0x01, 0xF1, 0xE0, 0x7C, 0x3C, 0x0F, 0x87, 0x83, 0xE0,
  0xF0, 0xF8, 0x1E, 0x1F, 0x03, 0xC7, 0xC0, 0x78, 0xF0, 0x0F, 0x3E, 0x01,
  0xEF, 0x80, 0x3D, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x03,
  0xF7, 0xC0, 0x7C, 0x7C, 0x0F, 0x0F, 0x81, 0xE0, 0xF8, 0x3C, 0x1F, 0x07,
  0x81, 0xF0, 0xF0, 0x3E, 0x1E, 0x03, 0xE3, 0xC0, 0x7C, 0x78, 0x07, 0xCF,
  0x00, 0xFD, 0xE0, 0x0F, 0xBC, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0E, 0xFF, 0xF0, 0x01,
  0xEF, 0xF7, 0x80, 0x1E, 0xFF, 0x78, 0x01, 0xCF, 0xF7, 0x80, 0x3C, 0xFF,
  0x7C, 0x03, 0xCF, 0xF3, 0xC0, 0x3C, 0xFF, 0x3C, 0x07, 0x8F, 0xF3, 0xC0,
  0x78, 0xFF, 0x1E, 0x07, 0x8F, 0xF1, 0xE0, 0xF0, 0xFF, 0x1E, 0x0F, 0x0F,
  0xF0, 0xF0, 0xF0, 0xFF, 0x0F, 0x0E, 0x0F, 0xF0, 0xF1, 0xE0, 0xFF, 0x0F,
  0x9E, 0x0F, 0xF0, 0x79, 0xC0, 0xFF, 0x07, 0xBC, 0x0F, 0xF0, 0x7B, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0xFF, 0x03, 0xF8, 0x0F, 0xF0,
  0x1F, 0x80, 0xFF, 0x01, 0xF0, 0x0F, 0xF0, 0x1F, 0x00, 0xFF, 0x01, 0xF0,
  0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xF0, 0x0F, 0xF7, 0x80,
  0x7F, 0xBE, 0x03, 0xFC, 0xF0, 0x1F, 0xE7, 0xC0, 0xFF, 0x1E, 0x07, 0xF8,
  0xF8, 0x3F, 0xC7, 0xC1, 0xFE, 0x1F, 0x0F, 0xF0, 0xF8, 0x7F, 0x83, 0xE3,
  0xFC, 0x1F, 0x1F, 0xE0, 0x7C, 0xFF, 0x03, 0xE7, 0xF8, 0x0F, 0xBF, 0xC0,
  0x7D, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x1F, 0x00, 0x0C, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0x80, 0xF8, 0x3F, 0x00, 0x7C, 0x3E, 0x00,
  0x7C, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x1E, 0x7C, 0x00,
  0x1F, 0x78, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00,
  0x3E, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x3F, 0x00,
  0x7C, 0x1F, 0x81, 0xF8, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x03, 0xFF,
  0xE0, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF,
  0xFE, 0xF8, 0x1F, 0xBE, 0x03, 0xEF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x03, 0xEF,
  0x80, 0xFB, 0xE0, 0xFE, 0xFF, 0xFF, 0x3F, 0xFF, 0x8F, 0xFF, 0xC3, 0xFF,
  0x80, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0x00, 0x08, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0x80, 0xFC, 0x3F, 0x00,
  0x7C, 0x3E, 0x00, 0x7E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00,
  0x1E, 0x7C, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0x7C, 0x00,
  0x1F, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00,
  0x7C, 0x3F, 0x00, 0x7C, 0x1F, 0x81, 0xF8, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0xF8, 0x1F, 0x8F, 0x80, 0xFC, 0xF8, 0x07,
  0xCF, 0x80, 0x7C, 0xF8, 0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x07, 0xCF, 0x80,
  0x7C, 0xF8, 0x07, 0xCF, 0x80, 0xF8, 0xF8, 0x1F, 0x8F, 0xFF, 0xF0, 0xFF,
  0xFE, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0x87, 0xC0, 0xF8, 0x3C, 0x0F,
  0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x80, 0xF8,
  0xF8, 0x0F, 0x8F, 0x80, 0x7C, 0xF8, 0x07, 0xCF, 0x80, 0x3E, 0xF8, 0x03,
  0xEF, 0x80, 0x1F, 0x00, 0xC0, 0x07, 0xFF, 0x07, 0xFF, 0xE7, 0xFF, 0xE7,
  0xFF, 0xF3, 0xE0, 0x33, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x3F,
  0xC0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x03, 0xF0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xF0, 0x03, 0xEE, 0x03, 0xF7, 0xFF, 0xF3, 0xFF, 0xF9, 0xFF, 0xF0, 0x7F,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0x00, 0x1E, 0xF8, 0x00, 0xF3, 0xE0, 0x0F, 0x9F, 0x00,
  0x7C, 0xFC, 0x07, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00,
  0xFF, 0xC0, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x79, 0xE0, 0x01, 0xF3, 0xE0,
  0x03, 0xE7, 0xC0, 0x07, 0xC7, 0x80, 0x0F, 0x0F, 0x00, 0x3E, 0x1F, 0x00,
  0x7C, 0x3E, 0x00, 0xF0, 0x3C, 0x01, 0xE0, 0x78, 0x07, 0xC0, 0xF8, 0x0F,
  0x81, 0xF0, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0xF8, 0x07, 0xC1, 0xE0,
  0x07, 0x83, 0xC0, 0x0F, 0x07, 0x80, 0x1E, 0x1F, 0x00, 0x3E, 0x3C, 0x00,
  0x3C, 0x78, 0x00, 0x79, 0xF0, 0x00, 0xF3, 0xE0, 0x01, 0xF7, 0x80, 0x01,
  0xEF, 0x00, 0x03, 0xDE, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0xF8, 0x00,
  0xF0, 0x01, 0xFF, 0x80, 0x1F, 0x00, 0x1E, 0x78, 0x01, 0xF8, 0x03, 0xE7,
  0x80, 0x1F, 0x80, 0x3E, 0x7C, 0x01, 0xF8, 0x03, 0xC7, 0xC0, 0x3F, 0x80,
  0x3C, 0x3C, 0x03, 0xF8, 0x07, 0xC3, 0xC0, 0x3F, 0xC0, 0x7C, 0x3E, 0x03,
  0xBC, 0x07, 0xC3, 0xE0, 0x7B, 0xC0, 0x78, 0x3E, 0x07, 0xBC, 0x07, 0x81,
  0xE0, 0x79, 0xE0, 0xF8, 0x1E, 0x07, 0x9E, 0x0F, 0x81, 0xF0, 0x71, 0xE0,
  0xF8, 0x1F, 0x0F, 0x1E, 0x0F, 0x00, 0xF0, 0xF0, 0xE0, 0xF0, 0x0F, 0x0F,
  0x0F, 0x1F, 0x00, 0xF0, 0xF0, 0xF1, 0xF0, 0x0F, 0x9E, 0x0F, 0x1E, 0x00,
  0xF9, 0xE0, 0xF1, 0xE0, 0x07, 0x9E, 0x07, 0x9E, 0x00, 0x79, 0xE0, 0x7B,
  0xE0, 0x07, 0x9C, 0x07, 0xBE, 0x00, 0x7B, 0xC0, 0x7B, 0xC0, 0x03, 0xFC,
  0x03, 0xBC, 0x00, 0x3F, 0xC0, 0x3B, 0xC0, 0x03, 0xFC, 0x03, 0xFC, 0x00,
  0x3F, 0x80, 0x3F, 0x80, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x1F,
  0x80, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x7C, 0x00,
  0xF9, 0xF0, 0x0F, 0x8F, 0x80, 0x7C, 0x3C, 0x07, 0xC1, 0xF0, 0x3E, 0x07,
  0x83, 0xE0, 0x3E, 0x1F, 0x00, 0xF0, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0x78,
  0x00, 0xF7, 0xC0, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80,
  0x07, 0xFC, 0x00, 0x3D, 0xF0, 0x03, 0xE7, 0x80, 0x1E, 0x3E, 0x01, 0xF0,
  0xF0, 0x0F, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xC0, 0xF8, 0x7C, 0x07, 0xC3,
  0xE0, 0x1F, 0x3E, 0x00, 0xF9, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0xFB, 0xC0, 0x07, 0x9F, 0x00, 0x7C, 0xF8, 0x03, 0xC3, 0xE0, 0x3E, 0x1F,
  0x01, 0xF0, 0x78, 0x0F, 0x03, 0xE0, 0xF8, 0x0F, 0x07, 0x80, 0x7C, 0x7C,
  0x03, 0xE3, 0xE0, 0x0F, 0x1E, 0x00, 0x7D, 0xF0, 0x01, 0xEF, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0xFF, 0xFF,
  0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0,
  0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01,
  0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xDE, 0x00, 0x79, 0xE0,
  0x07, 0x8F, 0x00, 0xF0, 0xF0, 0x0F, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x03,
  0xC3, 0xC0, 0x3C, 0x3C, 0x03, 0xC7, 0x80, 0x1E, 0x78, 0x01, 0xEF, 0x80,
  0x0F, 0xF0, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xFC, 0x3E, 0x0F, 0x83, 0xC0, 0xF0, 0x3C, 0x0E, 0x03, 0xE0, 0x1F, 0xFC,
  0x3F, 0xFE, 0x3F, 0xFE, 0x18, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x01, 0xFF, 0x1F, 0xFF, 0x3F, 0xFF, 0x7F, 0x8F,
  0xFC, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF8, 0x3F, 0xFC, 0x7F, 0x7F, 0xFF, 0x7F, 0xE7, 0x3F, 0xC7, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x1C, 0x0F, 0x1F, 0xC3, 0xCF,
  0xF8, 0xF7, 0xFF, 0x3F, 0x87, 0xEF, 0xC0, 0xFB, 0xE0, 0x1F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0xFC, 0x07, 0xBF, 0x03, 0xEF, 0xF1, 0xFB, 0xDF, 0xFC, 0xF3, 0xFE,
  0x3C, 0x7F, 0x00, 0x00, 0xF0, 0x0F, 0xFC, 0x7F, 0xF8, 0xFF, 0xE3, 0xF0,
  0xCF, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x01, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x27, 0xF7, 0xCF, 0xFF, 0x8F, 0xFF,
  0x07, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0xE0,
  0xF0, 0xFF, 0x3C, 0x7F, 0xEF, 0x3F, 0xFF, 0xCF, 0x87, 0xF7, 0xC0, 0xFD,
  0xF0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00,
  0xFF, 0x80, 0x7D, 0xE0, 0x1F, 0x7C, 0x07, 0xDF, 0x03, 0xF3, 0xF3, 0xFC,
  0xFF, 0xEF, 0x1F, 0xFB, 0xC3, 0xF8, 0x70, 0x01, 0xC0, 0x03, 0xFC, 0x07,
  0xFF, 0x87, 0xFF, 0xC3, 0xE1, 0xF3, 0xE0, 0x79, 0xE0, 0x3E, 0xF0, 0x0F,
  0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F,
  0x80, 0x07, 0xE0, 0x11, 0xF8, 0x78, 0x7F, 0xFC, 0x1F, 0xFE, 0x07, 0xFE,
  0x00, 0x01, 0xFE, 0x0F, 0xF8, 0x1F, 0xF0, 0x7E, 0x60, 0xF8, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0xFF, 0xE7, 0xFF, 0xCF,
  0xFF, 0x81, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x03, 0xFC, 0xF1, 0xFF, 0xBC,
  0xFF, 0xFF, 0x3E, 0x1F, 0xDF, 0x03, 0xF7, 0xC0, 0x7F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xF7, 0x80, 0x7D,
  0xF0, 0x1F, 0x7C, 0x0F, 0xCF, 0xCF, 0xF3, 0xFF, 0xBC, 0x7F, 0xEF, 0x0F,
  0xE3, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01,
  0xF4, 0x00, 0xF9, 0xE0, 0x7E, 0x7F, 0xFF, 0x1F, 0xFF, 0x83, 0xFF, 0xC0,
  0x1F, 0x80, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x38, 0x3C,
  0xFF, 0x9E, 0xFF, 0xEF, 0x7F, 0xF7, 0xF8, 0xFF, 0xF0, 0x3F, 0xF8, 0x1F,
  0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0,
  0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07,
  0xFC, 0x03, 0xC0, 0x27, 0xBF, 0xFF, 0xB8, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x02, 0x07, 0x83, 0xE1, 0xF0, 0xF8, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E,
  0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3C, 0x1E, 0x1F, 0x7F,
  0xBF, 0x9F, 0xCF, 0x80, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0xFB, 0xE0, 0x7C, 0xF8, 0x3E, 0x3E, 0x0F, 0x8F,
  0x87, 0xC3, 0xE3, 0xE0, 0xF8, 0xF0, 0x3E, 0x7C, 0x0F, 0xBE, 0x03, 0xCF,
  0x00, 0xF7, 0xE0, 0x3F, 0xF8, 0x0F, 0xFF, 0x03, 0xF7, 0xC0, 0xF8, 0xF8,
  0x3E, 0x3E, 0x0F, 0x87, 0xC3, 0xE0, 0xF0, 0xF8, 0x3E, 0x3E, 0x07, 0x8F,
  0x81, 0xF3, 0xE0, 0x3C, 0xF8, 0x0F, 0xBE, 0x01, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x70, 0x0F, 0x07, 0x9F,
  0xE1, 0xFE, 0x3D, 0xFF, 0x9F, 0xF9, 0xEF, 0xFE, 0xFF, 0xEF, 0xE3, 0xFF,
  0x1F, 0x7E, 0x0F, 0xE0, 0x7F, 0xE0, 0x3F, 0x03, 0xFF, 0x01, 0xF0, 0x1F,
  0xF8, 0x0F, 0x80, 0xFF, 0xC0, 0x7C, 0x07, 0xFE, 0x03, 0xE0, 0x3F, 0xF0,
  0x1F, 0x01, 0xFF, 0x80, 0xF8, 0x0F, 0xFC, 0x07, 0xC0, 0x7F, 0xE0, 0x3E,
  0x03, 0xFF, 0x01, 0xF0, 0x1F, 0xF8, 0x0F, 0x80, 0xFF, 0xC0, 0x7C, 0x07,
  0xFE, 0x03, 0xE0, 0x3F, 0xF0, 0x1F, 0x01, 0xFF, 0x80, 0xF8, 0x0F, 0xFC,
  0x07, 0xC0, 0x7F, 0xE0, 0x3E, 0x03, 0xFF, 0x01, 0xF0, 0x1F, 0xF8, 0x0F,
  0x80, 0xF8, 0x00, 0x78, 0x79, 0xFF, 0x3D, 0xFF, 0xDE, 0xFF, 0xEF, 0xE1,
  0xFF, 0xE0, 0x7F, 0xE0, 0x3F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0,
  0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0x80, 0x00, 0xE0, 0x00, 0xFF,
  0x80, 0x7F, 0xF8, 0x1F, 0xFF, 0x83, 0xE1, 0xF8, 0xF8, 0x1F, 0x1F, 0x01,
  0xF3, 0xC0, 0x3E, 0xF8, 0x03, 0xDF, 0x00, 0x7B, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03,
  0xDF, 0x00, 0x79, 0xE0, 0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0xF8, 0x7E, 0x3F,
  0x07, 0xFF, 0xC0, 0x7F, 0xF0, 0x07, 0xFC, 0x00, 0x00, 0xF0, 0x3C, 0x7F,
  0x0F, 0x3F, 0xF3, 0xDF, 0xFC, 0xFE, 0x1F, 0xBF, 0x03, 0xEF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xF0, 0x1E, 0xFC, 0x0F, 0xBF, 0xEF, 0xEF, 0x7F, 0xF3,
  0xCF, 0xF8, 0xF1, 0xFC, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x03, 0xFC, 0xF1, 0xFF, 0xBC,
  0xFF, 0xFF, 0x3E, 0x1F, 0xDF, 0x03, 0xF7, 0xC0, 0x7F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xF7, 0x80, 0x7D,
  0xF0, 0x1F, 0x7C, 0x0F, 0xCF, 0xCF, 0xF3, 0xFF, 0xBC, 0x7F, 0xCF, 0x0F,
  0xE3, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0xFF, 0x1F, 0xF3, 0xFF, 0x7F, 0xF7, 0xFF, 0xE0, 0xFC,
  0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x00, 0x03, 0x80, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0xF8,
  0x3B, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x1F,
  0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF0,
  0x03, 0xC0, 0x0F, 0x80, 0x7F, 0xC7, 0xEF, 0xFF, 0xBF, 0xFC, 0x7F, 0xE0,
  0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x7F, 0xFF, 0xFF,
  0xFF, 0xF3, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x1F, 0x11, 0xFF, 0x0F, 0xF0, 0x7F, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xFC, 0x07, 0xFE,
  0x03, 0xFF, 0x03, 0xF7, 0xFF, 0xFB, 0xFF, 0xBC, 0xFF, 0xDE, 0x3F, 0x87,
  0xF8, 0x03, 0xEF, 0x00, 0x7D, 0xE0, 0x0F, 0xBE, 0x01, 0xE3, 0xC0, 0x7C,
  0x78, 0x0F, 0x8F, 0x81, 0xE1, 0xF0, 0x3C, 0x1E, 0x0F, 0x83, 0xC1, 0xE0,
  0x7C, 0x3C, 0x07, 0x87, 0x80, 0xF1, 0xF0, 0x1E, 0x3C, 0x03, 0xE7, 0x80,
  0x3C, 0xF0, 0x07, 0xBC, 0x00, 0xF7, 0x80, 0x0E, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0xF8, 0x07, 0xC0,
  0x3D, 0xE0, 0x3F, 0x01, 0xF7, 0x80, 0xFC, 0x07, 0xDF, 0x03, 0xF8, 0x1E,
  0x3C, 0x0F, 0xE0, 0x78, 0xF0, 0x3B, 0x81, 0xE3, 0xC1, 0xEE, 0x0F, 0x8F,
  0x87, 0xBC, 0x3C, 0x3E, 0x1C, 0xF0, 0xF0, 0x78, 0x73, 0xC3, 0xC1, 0xE3,
  0xC7, 0x1F, 0x07, 0x8F, 0x1C, 0x78, 0x1F, 0x3C, 0x79, 0xE0, 0x3C, 0xE1,
  0xE7, 0x80, 0xF3, 0x87, 0x9E, 0x03, 0xDE, 0x0E, 0xF0, 0x0F, 0x78, 0x3B,
  0xC0, 0x1D, 0xE0, 0xFF, 0x00, 0x7F, 0x03, 0xFC, 0x01, 0xFC, 0x0F, 0xF0,
  0x07, 0xF0, 0x1F, 0x80, 0x0F, 0xC0, 0x7E, 0x00, 0x3E, 0x01, 0xF8, 0x00,
  0xF8, 0x07, 0xE0, 0xF8, 0x07, 0xDF, 0x03, 0xE7, 0xC0, 0xF0, 0xF8, 0x7C,
  0x3E, 0x1E, 0x07, 0xCF, 0x81, 0xF3, 0xC0, 0x3F, 0xF0, 0x07, 0xF8, 0x01,
  0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x80, 0x3F, 0xF0, 0x1F, 0x3C, 0x07, 0xCF, 0x83, 0xE1, 0xE0, 0xF8, 0x7C,
  0x7C, 0x1F, 0x1F, 0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x1F, 0xF8, 0x03, 0xEF,
  0x00, 0x7D, 0xF0, 0x0F, 0xBE, 0x01, 0xE3, 0xC0, 0x7C, 0x78, 0x0F, 0x8F,
  0x81, 0xE0, 0xF0, 0x3C, 0x1E, 0x0F, 0x83, 0xE1, 0xE0, 0x3C, 0x3C, 0x07,
  0x87, 0x80, 0xF1, 0xF0, 0x1F, 0x3C, 0x01, 0xE7, 0x80, 0x3C, 0xF0, 0x07,
  0xBC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0xFD, 0xFF,
  0xF7, 0xFF, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x01,
  0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x07,
  0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x07, 0xF0, 0x3F, 0xC0, 0xFE, 0x07, 0xC0,
  0x1F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0xFE, 0x0F, 0xF0,
  0x3E, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1F, 0x00, 0x7C, 0x00, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x07, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0,
  0x07, 0xE0, 0x3F, 0x80, 0xFE, 0x01, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xF0, 0x0F, 0x80, 0x3F, 0x80, 0xFE, 0x01, 0xF0, 0x3F, 0x83, 0xF0, 0x3E,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC1, 0xFE, 0x0F, 0xE0, 0x7E,
  0x03, 0xC0, 0x00, 0x3E, 0x00, 0x7F, 0xF0, 0x3F, 0xFF, 0xBF, 0xFF, 0xFF,
  0xC1, 0xFF, 0xA0, 0x0F, 0xC0,
};

const GFXglyph NotoSans_Condensed_Medium45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 6, 33, 11, 3, -32 },
  { 26, 13, 11, 18, 3, -32 },
  { 44, 22, 32, 24, 1, -32 },
  { 132, 18, 37, 22, 2, -34 },
  { 216, 30, 33, 33, 2, -33 },
  { 340, 24, 33, 26, 2, -33 },
  { 439, 4, 11, 10, 3, -32 },
  { 445, 10, 39, 14, 2, -32 },
  { 494, 11, 39, 14, 1, -32 },
  { 548, 18, 17, 20, 1, -34 },
  { 587, 18, 22, 22, 2, -27 },
  { 637, 7, 11, 11, 2, -5 },
  { 647, 11, 4, 13, 1, -14 },
  { 653, 5, 7, 11, 3, -6 },
  { 658, 16, 32, 17, 1, -32 },
  { 722, 18, 33, 22, 2, -33 },
  { 797, 12, 32, 22, 3, -32 },
  { 845, 17, 33, 22, 2, -33 },
  { 916, 17, 33, 22, 2, -33 },
  { 987, 20, 32, 22, 1, -32 },
  { 1067, 17, 32, 22, 2, -32 },
  { 1135, 18, 33, 22, 2, -33 },
  { 1210, 19, 32, 22, 1, -32 },
  { 1286, 18, 33, 22, 2, -33 },
  { 1361, 18, 33, 22, 2, -33 },
  { 1436, 5, 26, 11, 3, -25 },
  { 1453, 6, 31, 11, 2, -25 },
  { 1477, 18, 21, 22, 2, -27 },
  { 1525, 18, 13, 22, 2, -22 },
  { 1555, 18, 21, 22, 2, -27 },
  { 1603, 16, 34, 17, 0, -33 },
  { 1671, 29, 36, 33, 2, -32 },
  { 1802, 24, 32, 24, 0, -32 },
  { 1898, 19, 32, 24, 3, -32 },
  { 1974, 20, 33, 23, 2, -33 },
  { 2057, 21, 32, 27, 3, -32 },
  { 2141, 14, 32, 20, 4, -32 },
  { 2197, 14, 32, 20, 4, -32 },
  { 2253, 22, 33, 27, 2, -33 },
  { 2344, 20, 32, 27, 4, -32 },
  { 2424, 11, 32, 14, 1, -32 },
  { 2468, 11, 41, 11, -3, -32 },
  { 2525, 19, 32, 23, 4, -32 },
  { 2601, 15, 32, 19, 3, -32 },
  { 2661, 28, 32, 36, 4, -32 },
  { 2773, 21, 32, 29, 4, -32 },
  { 2857, 24, 33, 28, 2, -33 },
  { 2956, 18, 32, 23, 3, -32 },
  { 3028, 24, 41, 28, 2, -33 },
  { 3151, 20, 32, 24, 3, -32 },
  { 3231, 17, 33, 21, 2, -33 },
  { 3302, 18, 32, 20, 1, -32 },
  { 3374, 21, 32, 27, 3, -32 },
  { 3458, 23, 32, 23, 0, -32 },
  { 3550, 36, 32, 36, 0, -32 },
  { 3694, 21, 32, 22, 0, -32 },
  { 3778, 21, 32, 21, 0, -32 },
  { 3862, 18, 32, 20, 1, -32 },
  { 3934, 10, 39, 14, 3, -32 },
  { 3983, 16, 32, 17, 1, -32 },
  { 4047, 10, 39, 14, 1, -32 },
  { 4096, 20, 19, 22, 1, -32 },
  { 4144, 19, 3, 19, 0, 4 },
  { 4152, 9, 7, 13, 2, -34 },
  { 4160, 16, 25, 21, 2, -25 },
  { 4210, 18, 34, 23, 3, -34 },
  { 4287, 15, 25, 18, 2, -25 },
  { 4334, 18, 34, 23, 2, -34 },
  { 4411, 17, 25, 21, 2, -25 },
  { 4465, 15, 34, 13, 0, -34 },
  { 4529, 18, 36, 23, 2, -25 },
  { 4610, 17, 34, 23, 3, -34 },
  { 4683, 5, 34, 11, 3, -34 },
  { 4705, 9, 45, 11, -1, -34 },
  { 4756, 18, 34, 21, 3, -34 },
  { 4833, 5, 34, 11, 3, -34 },
  { 4855, 29, 25, 35, 3, -25 },
  { 4946, 17, 25, 23, 3, -25 },
  { 5000, 19, 25, 23, 2, -25 },
  { 5060, 18, 36, 23, 3, -25 },
  { 5141, 18, 36, 23, 2, -25 },
  { 5222, 12, 25, 16, 3, -25 },
  { 5260, 14, 25, 18, 2, -25 },
  { 5304, 12, 30, 14, 1, -30 },
  { 5349, 17, 24, 23, 3, -24 },
  { 5400, 19, 24, 19, 0, -24 },
  { 5457, 30, 24, 31, 0, -24 },
  { 5547, 18, 24, 20, 1, -24 },
  { 5601, 19, 35, 19, 0, -24 },
  { 5685, 14, 24, 17, 1, -24 },
  { 5727, 14, 39, 16, 1, -32 },
  { 5796, 4, 45, 21, 8, -34 },
  { 5819, 13, 39, 16, 2, -32 },
  { 5883, 18, 6, 22, 2, -19 },
};

const GFXfont NotoSans_Condensed_Medium45pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Medium45pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Medium45pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _NOTOSANS_CONDENSED_MEDIUM45PT7B_H_
