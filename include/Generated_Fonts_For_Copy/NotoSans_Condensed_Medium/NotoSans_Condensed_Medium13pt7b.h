#ifndef _NOTOSANS_CONDENSED_MEDIUM13PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUM13PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Medium.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Medium13pt7bBitmaps[] PROGMEM = {
  0x00, 0xFD, 0x80, 0xBA, 0xA0, 0x24, 0x51, 0xF9, 0x42, 0x9F, 0x92, 0x24,
  0x50, 0x23, 0xED, 0x4C, 0x38, 0xE7, 0xF1, 0x08, 0x72, 0x2B, 0x35, 0x0A,
  0xA7, 0xA8, 0x54, 0x4A, 0x25, 0x33, 0x80, 0x78, 0x91, 0xA1, 0x87, 0x2B,
  0x73, 0x26, 0x7E, 0xE0, 0x7A, 0x49, 0x24, 0x99, 0x80, 0xCC, 0x92, 0x49,
  0x2B, 0x00, 0x35, 0x7E, 0x64, 0x80, 0x10, 0x41, 0x3F, 0x10, 0x40, 0x57,
  0xE0, 0xC0, 0x18, 0x84, 0x42, 0x31, 0x08, 0xC0, 0xF4, 0xA7, 0x39, 0xCE,
  0x72, 0x70, 0x7E, 0x92, 0x49, 0x20, 0x79, 0x20, 0x82, 0x18, 0xC2, 0x10,
  0xFC, 0xF8, 0x20, 0x86, 0x38, 0x20, 0xE2, 0xF8, 0x18, 0x62, 0x8A, 0x4B,
  0x2F, 0xC2, 0x08, 0xF4, 0x21, 0xCB, 0x0C, 0x72, 0xF0, 0x74, 0x21, 0xE9,
  0x4E, 0x72, 0x70, 0xFC, 0x20, 0x86, 0x10, 0x43, 0x08, 0x60, 0x79, 0x34,
  0x9E, 0x39, 0x2C, 0xD3, 0x78, 0x79, 0x2C, 0xD3, 0x7C, 0xB0, 0x86, 0x70,
  0xC6, 0x50, 0x15, 0xC0, 0x04, 0x77, 0x30, 0x30, 0x30, 0xFC, 0x0F, 0xC0,
  0x81, 0x81, 0x83, 0x33, 0x00, 0xF0, 0xC4, 0x22, 0x30, 0x0C, 0x60, 0x3C,
  0x42, 0x9D, 0xA5, 0xA5, 0xAD, 0xAD, 0x92, 0xC0, 0x7C, 0x30, 0x50, 0xA1,
  0x46, 0xCF, 0x91, 0x62, 0xC6, 0xFC, 0x63, 0x3F, 0xC6, 0x31, 0xF0, 0x7E,
  0x21, 0x08, 0x42, 0x18, 0x78, 0xFA, 0x28, 0xE1, 0x86, 0x18, 0xE6, 0xF0,
  0xF8, 0x88, 0xF8, 0x88, 0xF0, 0xF8, 0x88, 0xF8, 0x88, 0x80, 0x7F, 0x08,
  0x20, 0x9E, 0x18, 0x71, 0x7C, 0x86, 0x18, 0x61, 0xFE, 0x18, 0x61, 0x84,
  0xF6, 0x66, 0x66, 0x66, 0xF0, 0x24, 0x92, 0x49, 0x27, 0xE0, 0x8E, 0x6B,
  0x28, 0xE2, 0xC9, 0x26, 0x8C, 0x88, 0x88, 0x88, 0x88, 0xF0, 0xC3, 0xC3,
  0xA3, 0xA5, 0xA5, 0xB5, 0x99, 0x99, 0x99, 0xC7, 0x1A, 0x69, 0x96, 0x58,
  0xE3, 0x84, 0x79, 0x8A, 0x14, 0x28, 0x70, 0xA1, 0x66, 0x78, 0xF4, 0xE3,
  0x1F, 0x42, 0x10, 0x80, 0x79, 0x8A, 0x14, 0x28, 0x70, 0xA1, 0x66, 0x78,
  0x10, 0x30, 0xF2, 0x28, 0xA6, 0xF2, 0x49, 0x26, 0x8C, 0xF8, 0x8C, 0x71,
  0x19, 0xF0, 0xFC, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0x8E, 0x38, 0xE3,
  0x8E, 0x38, 0xF3, 0x78, 0xC7, 0x89, 0x12, 0x66, 0x85, 0x0E, 0x18, 0x30,
  0xCC, 0x73, 0x14, 0xCD, 0x3A, 0x5A, 0x9C, 0xA3, 0x28, 0xCE, 0x31, 0x00,
  0xCD, 0x23, 0x8C, 0x30, 0xE6, 0x92, 0xCC, 0xCD, 0x24, 0x8C, 0x30, 0xC3,
  0x0C, 0x30, 0xF8, 0xC4, 0x22, 0x11, 0x08, 0xF8, 0xF2, 0x49, 0x24, 0x93,
  0x80, 0xC2, 0x10, 0x42, 0x18, 0x42, 0x18, 0xE4, 0x92, 0x49, 0x27, 0x80,
  0x30, 0xC2, 0x92, 0xC4, 0xFC, 0x90, 0x78, 0x42, 0xF4, 0xE5, 0xE0, 0x84,
  0x21, 0xED, 0xC6, 0x31, 0xDF, 0x80, 0x78, 0x88, 0x88, 0x70, 0x08, 0x43,
  0xD9, 0xC6, 0x31, 0x9F, 0x40, 0x74, 0xA7, 0xF8, 0x41, 0xC0, 0x36, 0x4F,
  0x44, 0x44, 0x44, 0xEC, 0xE3, 0x18, 0xCF, 0xA1, 0x1F, 0x80, 0x84, 0x21,
  0xED, 0xC6, 0x31, 0x8C, 0x40, 0xDF, 0xC0, 0x51, 0x55, 0x55, 0xC0, 0x84,
  0x21, 0x3B, 0x53, 0x96, 0x94, 0xC0, 0xFF, 0xC0, 0xF7, 0x99, 0x99, 0x99,
  0x99, 0x99, 0x99, 0xF6, 0xE3, 0x18, 0xC6, 0x20, 0x74, 0xE3, 0x18, 0xCD,
  0xC0, 0xF6, 0xE3, 0x18, 0xEF, 0xD0, 0x84, 0x00, 0xEC, 0xE3, 0x18, 0xCF,
  0xA1, 0x08, 0x40, 0xBA, 0x49, 0x20, 0x7E, 0x10, 0xE1, 0xCF, 0xC0, 0x44,
  0xF4, 0x44, 0x44, 0x70, 0x8C, 0x63, 0x19, 0xCF, 0xA0, 0x8F, 0x24, 0x96,
  0x70, 0xC3, 0x00, 0xC9, 0xEC, 0x95, 0x4A, 0xA5, 0x73, 0xB0, 0x98, 0xC9,
  0x63, 0x0C, 0x71, 0x6C, 0xC0, 0xCD, 0x24, 0x96, 0x70, 0xC3, 0x08, 0x23,
  0x00, 0xF1, 0x32, 0x64, 0xF0, 0x32, 0x22, 0x2C, 0x22, 0x22, 0x30, 0xFF,
  0xFF, 0xFF, 0xC0, 0xE2, 0x22, 0x21, 0x22, 0x22, 0xC0, 0x07, 0xF0,
};

const GFXglyph NotoSans_Condensed_Medium13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 1, 9, 3, 1, -9 },
  { 3, 4, 3, 5, 1, -9 },
  { 5, 7, 9, 7, 0, -9 },
  { 13, 5, 11, 6, 1, -10 },
  { 20, 9, 9, 10, 0, -9 },
  { 31, 7, 9, 7, 0, -9 },
  { 39, 1, 3, 3, 1, -9 },
  { 40, 3, 11, 4, 1, -9 },
  { 45, 3, 11, 4, 0, -9 },
  { 50, 5, 5, 6, 0, -10 },
  { 54, 6, 6, 6, 0, -8 },
  { 59, 2, 4, 3, 0, -2 },
  { 60, 3, 1, 4, 0, -4 },
  { 61, 1, 2, 3, 1, -2 },
  { 62, 5, 9, 5, 0, -9 },
  { 68, 5, 9, 6, 1, -9 },
  { 74, 3, 9, 6, 1, -9 },
  { 78, 6, 9, 6, 0, -9 },
  { 85, 6, 9, 6, 0, -9 },
  { 92, 6, 9, 6, 0, -9 },
  { 99, 5, 9, 6, 1, -9 },
  { 105, 5, 9, 6, 1, -9 },
  { 111, 6, 9, 6, 0, -9 },
  { 118, 6, 9, 6, 0, -9 },
  { 125, 6, 9, 6, 0, -9 },
  { 132, 1, 7, 3, 1, -7 },
  { 133, 2, 9, 3, 0, -7 },
  { 136, 6, 6, 6, 0, -8 },
  { 141, 6, 3, 6, 0, -6 },
  { 144, 6, 6, 6, 0, -8 },
  { 149, 5, 9, 5, 0, -9 },
  { 155, 8, 10, 10, 1, -9 },
  { 165, 7, 9, 7, 0, -9 },
  { 173, 5, 9, 7, 1, -9 },
  { 179, 5, 9, 7, 1, -9 },
  { 185, 6, 9, 8, 1, -9 },
  { 192, 4, 9, 6, 1, -9 },
  { 197, 4, 9, 6, 1, -9 },
  { 202, 6, 9, 8, 1, -9 },
  { 209, 6, 9, 8, 1, -9 },
  { 216, 4, 9, 4, 0, -9 },
  { 221, 3, 12, 3, -1, -9 },
  { 226, 6, 9, 7, 1, -9 },
  { 233, 4, 9, 6, 1, -9 },
  { 238, 8, 9, 10, 1, -9 },
  { 247, 6, 9, 8, 1, -9 },
  { 254, 7, 9, 8, 1, -9 },
  { 262, 5, 9, 7, 1, -9 },
  { 268, 7, 11, 8, 1, -9 },
  { 278, 6, 9, 7, 1, -9 },
  { 285, 4, 9, 6, 1, -9 },
  { 290, 6, 9, 6, 0, -9 },
  { 297, 6, 9, 8, 1, -9 },
  { 304, 7, 9, 7, 0, -9 },
  { 312, 10, 9, 10, 0, -9 },
  { 324, 6, 9, 6, 0, -9 },
  { 331, 6, 9, 6, 0, -9 },
  { 338, 5, 9, 6, 0, -9 },
  { 344, 3, 11, 4, 1, -9 },
  { 349, 5, 9, 5, 0, -9 },
  { 355, 3, 11, 4, 0, -9 },
  { 360, 6, 5, 6, 0, -9 },
  { 364, 6, 1, 6, 0, 1 },
  { 365, 2, 2, 4, 1, -10 },
  { 366, 5, 7, 6, 0, -7 },
  { 371, 5, 10, 7, 1, -10 },
  { 378, 4, 7, 5, 1, -7 },
  { 382, 5, 10, 7, 1, -10 },
  { 389, 5, 7, 6, 1, -7 },
  { 394, 4, 10, 4, 0, -10 },
  { 399, 5, 10, 7, 1, -7 },
  { 406, 5, 10, 7, 1, -10 },
  { 413, 1, 10, 3, 1, -10 },
  { 415, 2, 13, 3, 0, -10 },
  { 419, 5, 10, 6, 1, -10 },
  { 426, 1, 10, 3, 1, -10 },
  { 428, 8, 7, 10, 1, -7 },
  { 435, 5, 7, 7, 1, -7 },
  { 440, 5, 7, 7, 1, -7 },
  { 445, 5, 10, 7, 1, -7 },
  { 452, 5, 10, 7, 1, -7 },
  { 459, 3, 7, 5, 1, -7 },
  { 462, 5, 7, 5, 0, -7 },
  { 467, 4, 9, 4, 0, -9 },
  { 472, 5, 7, 7, 1, -7 },
  { 477, 6, 7, 6, 0, -7 },
  { 483, 9, 7, 9, 0, -7 },
  { 491, 6, 7, 6, 0, -7 },
  { 497, 6, 10, 6, 0, -7 },
  { 505, 4, 7, 5, 0, -7 },
  { 509, 4, 11, 5, 0, -9 },
  { 515, 2, 13, 6, 2, -10 },
  { 519, 4, 11, 5, 0, -9 },
  { 525, 6, 2, 6, 0, -6 },
};

const GFXfont NotoSans_Condensed_Medium13pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Medium13pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Medium13pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _NOTOSANS_CONDENSED_MEDIUM13PT7B_H_
