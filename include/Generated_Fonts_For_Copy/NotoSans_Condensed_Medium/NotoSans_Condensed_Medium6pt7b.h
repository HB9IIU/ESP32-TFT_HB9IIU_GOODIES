#ifndef _NOTOSANS_CONDENSED_MEDIUM6PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUM6PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Medium.ttf
// Size: 6pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Medium6pt7bBitmaps[] PROGMEM = {
  0x00, 0xF0, 0xC0, 0x7B, 0xE0, 0x5F, 0x3C, 0xEF, 0x77, 0xEB, 0xF0, 0x80,
  0xEA, 0x40, 0x95, 0x80, 0x5F, 0x00, 0x5D, 0x00, 0xC0, 0xC0, 0x80, 0x5A,
  0xF6, 0xE0, 0xD5, 0xE5, 0x70, 0xE8, 0xE0, 0x5B, 0xA0, 0xD8, 0xE0, 0xDA,
  0xF0, 0xE9, 0x20, 0xEA, 0xF0, 0xF5, 0xE0, 0xA0, 0xB0, 0x39, 0x80, 0xFC,
  0x8F, 0x00, 0xDA, 0x7F, 0xF8, 0x60, 0x57, 0xD0, 0xFE, 0xF0, 0xF2, 0x30,
  0xF6, 0xF0, 0xFB, 0xFA, 0xF2, 0xB0, 0xBE, 0xD0, 0xEB, 0xF8, 0xBB, 0x50,
  0xAB, 0xDD, 0xFB, 0xFE, 0xD0, 0xF6, 0xB0, 0xF7, 0x40, 0xF6, 0xB2, 0xF7,
  0x50, 0xD8, 0xE0, 0xE9, 0x20, 0xB6, 0xB0, 0xB5, 0x20, 0xAF, 0x54, 0xA0,
  0xA9, 0x50, 0xA9, 0x20, 0xDB, 0xEA, 0xC0, 0x95, 0xF8, 0x54, 0xE0, 0x80,
  0xFC, 0x9A, 0xDE, 0xEC, 0x2E, 0xDE, 0xFF, 0x80, 0x6E, 0x80, 0xF6, 0xF0,
  0x9A, 0xDA, 0xF0, 0xF8, 0x97, 0x6A, 0xF8, 0xFB, 0xB0, 0xF6, 0x80, 0xF7,
  0x80, 0xF7, 0xC0, 0xF7, 0x90, 0xE8, 0xDC, 0xBB, 0xB7, 0x80, 0xB9, 0x00,
  0xBF, 0x60, 0xEB, 0x80, 0xA9, 0x60, 0xDC, 0x59, 0x40, 0xFC, 0xD5, 0x80,
  0xE0,
};

const GFXglyph NotoSans_Condensed_Medium6pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 1, 0, -1 },
  { 1, 1, 4, 2, 0, -4 },
  { 2, 2, 1, 2, 0, -4 },
  { 3, 3, 4, 3, 0, -4 },
  { 5, 3, 5, 3, 0, -5 },
  { 7, 4, 4, 4, 0, -4 },
  { 9, 3, 4, 3, 0, -4 },
  { 11, 1, 1, 1, 0, -4 },
  { 12, 2, 5, 2, 0, -4 },
  { 14, 2, 5, 2, 0, -4 },
  { 16, 3, 3, 3, 0, -5 },
  { 18, 3, 3, 3, 0, -4 },
  { 20, 1, 2, 1, 0, -1 },
  { 21, 2, 1, 2, 0, -2 },
  { 22, 1, 1, 1, 0, -1 },
  { 23, 2, 4, 2, 0, -4 },
  { 24, 3, 4, 3, 0, -4 },
  { 26, 2, 4, 3, 0, -4 },
  { 27, 3, 4, 3, 0, -4 },
  { 29, 3, 4, 3, 0, -4 },
  { 31, 3, 4, 3, 0, -4 },
  { 33, 3, 4, 3, 0, -4 },
  { 35, 3, 4, 3, 0, -4 },
  { 37, 3, 4, 3, 0, -4 },
  { 39, 3, 4, 3, 0, -4 },
  { 41, 3, 4, 3, 0, -4 },
  { 43, 1, 3, 1, 0, -3 },
  { 44, 1, 4, 1, 0, -3 },
  { 45, 3, 3, 3, 0, -4 },
  { 47, 3, 2, 3, 0, -3 },
  { 48, 3, 3, 3, 0, -4 },
  { 50, 2, 4, 2, 0, -4 },
  { 51, 4, 5, 4, 0, -4 },
  { 54, 3, 4, 3, 0, -4 },
  { 56, 3, 4, 3, 0, -4 },
  { 58, 3, 4, 3, 0, -4 },
  { 60, 3, 4, 4, 0, -4 },
  { 62, 2, 4, 3, 0, -4 },
  { 63, 2, 4, 3, 0, -4 },
  { 64, 3, 4, 4, 0, -4 },
  { 66, 3, 4, 4, 0, -4 },
  { 68, 2, 4, 2, 0, -4 },
  { 69, 1, 5, 2, 0, -4 },
  { 70, 3, 4, 3, 0, -4 },
  { 72, 2, 4, 3, 0, -4 },
  { 73, 4, 4, 5, 0, -4 },
  { 75, 3, 4, 4, 0, -4 },
  { 77, 3, 4, 4, 0, -4 },
  { 79, 3, 4, 3, 0, -4 },
  { 81, 3, 5, 4, 0, -4 },
  { 83, 3, 4, 3, 0, -4 },
  { 85, 3, 4, 3, 0, -4 },
  { 87, 3, 4, 3, 0, -4 },
  { 89, 3, 4, 4, 0, -4 },
  { 91, 3, 4, 3, 0, -4 },
  { 93, 5, 4, 5, 0, -4 },
  { 96, 3, 4, 3, 0, -4 },
  { 98, 3, 4, 3, 0, -4 },
  { 100, 2, 4, 3, 0, -4 },
  { 101, 2, 5, 2, 0, -4 },
  { 103, 2, 4, 2, 0, -4 },
  { 104, 1, 5, 2, 0, -4 },
  { 105, 3, 2, 3, 0, -4 },
  { 106, 3, 1, 3, 0, 0 },
  { 107, 1, 1, 2, 0, -5 },
  { 108, 2, 3, 3, 0, -3 },
  { 109, 3, 5, 3, 0, -5 },
  { 111, 2, 3, 2, 0, -3 },
  { 112, 3, 5, 3, 0, -5 },
  { 114, 3, 3, 3, 0, -3 },
  { 116, 2, 5, 2, 0, -5 },
  { 118, 3, 4, 3, 0, -3 },
  { 120, 3, 5, 3, 0, -5 },
  { 122, 1, 4, 1, 0, -4 },
  { 123, 1, 5, 1, 0, -4 },
  { 124, 3, 5, 3, 0, -5 },
  { 126, 1, 5, 1, 0, -5 },
  { 127, 4, 3, 5, 0, -3 },
  { 129, 3, 3, 3, 0, -3 },
  { 131, 3, 3, 3, 0, -3 },
  { 133, 3, 4, 3, 0, -3 },
  { 135, 3, 4, 3, 0, -3 },
  { 137, 2, 3, 2, 0, -3 },
  { 138, 2, 3, 2, 0, -3 },
  { 139, 2, 4, 2, 0, -4 },
  { 140, 3, 3, 3, 0, -3 },
  { 142, 3, 3, 3, 0, -3 },
  { 144, 4, 3, 4, 0, -3 },
  { 146, 3, 3, 3, 0, -3 },
  { 148, 3, 4, 3, 0, -3 },
  { 150, 2, 3, 2, 0, -3 },
  { 151, 2, 5, 2, 0, -4 },
  { 153, 1, 6, 3, 1, -5 },
  { 154, 2, 5, 2, 0, -4 },
  { 156, 3, 1, 3, 0, -3 },
};

const GFXfont NotoSans_Condensed_Medium6pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Medium6pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Medium6pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _NOTOSANS_CONDENSED_MEDIUM6PT7B_H_
