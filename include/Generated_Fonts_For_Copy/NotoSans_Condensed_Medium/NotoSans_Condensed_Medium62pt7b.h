#ifndef _NOTOSANS_CONDENSED_MEDIUM62PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUM62PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Medium.ttf
// Size: 62pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Medium62pt7bBitmaps[] PROGMEM = {
  0x00, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7C,
  0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x7E, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x7E, 0x18, 0xFC, 0x1F,
  0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x7E, 0xFC, 0x1F, 0xBF, 0x07, 0xEF,
  0xC1, 0xFB, 0xF0, 0x3E, 0xFC, 0x0F, 0xBF, 0x03, 0xEF, 0xC0, 0xFB, 0xE0,
  0x3E, 0xF8, 0x0F, 0x9E, 0x03, 0xE7, 0x80, 0xF9, 0xE0, 0x3E, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0xF8, 0x1F, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0x81,
  0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0xF8, 0x1E, 0x00, 0x03, 0xC0, 0x78,
  0x00, 0x0F, 0x01, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x01, 0xF0, 0x3E, 0x00,
  0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x03, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFC, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x3E, 0x07,
  0x80, 0x00, 0xF0, 0x1E, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x1F, 0x03, 0xE0,
  0x00, 0x7C, 0x0F, 0x80, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0x1F, 0x00, 0x03, 0xE0,
  0x78, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0xF0, 0x3E,
  0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x80,
  0x01, 0xF0, 0x3C, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x1E, 0x07, 0xC0, 0x00,
  0x78, 0x1F, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xFF,
  0xC0, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFC, 0x7F, 0xBC, 0xFC, 0xFE, 0x3C, 0x0C, 0xFC, 0x3C, 0x00, 0xFC, 0x3C,
  0x00, 0xFC, 0x3C, 0x00, 0xFC, 0x3C, 0x00, 0xFC, 0x3C, 0x00, 0xFC, 0x3C,
  0x00, 0xFE, 0x3C, 0x00, 0x7F, 0x3C, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3C,
  0xFE, 0x00, 0x3C, 0x7F, 0x00, 0x3C, 0x3F, 0x00, 0x3C, 0x3F, 0x00, 0x3C,
  0x3F, 0x00, 0x3C, 0x3F, 0x00, 0x3C, 0x3F, 0x80, 0x3C, 0x7F, 0xE0, 0x3C,
  0xFE, 0xFE, 0x3F, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x80, 0x03, 0xFE, 0x00,
  0x07, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x7C,
  0x00, 0x3F, 0x7E, 0x00, 0x3E, 0x00, 0x0F, 0x8F, 0xC0, 0x0F, 0x80, 0x07,
  0xC1, 0xF0, 0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x00, 0x7C, 0x0F,
  0x00, 0xF8, 0x00, 0x1F, 0x03, 0xE0, 0x3E, 0x00, 0x07, 0x80, 0xF8, 0x0F,
  0x80, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x00, 0xF8, 0x0F, 0x81, 0xF0, 0x00,
  0x3E, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x80, 0xF8, 0x3E, 0x00, 0x03, 0xE0,
  0x3E, 0x0F, 0x80, 0x00, 0xF8, 0x0F, 0x87, 0xC0, 0x00, 0x1E, 0x03, 0xE1,
  0xF0, 0x00, 0x07, 0xC0, 0xF8, 0xF8, 0x3F, 0x81, 0xF0, 0x3C, 0x3E, 0x1F,
  0xF0, 0x7C, 0x1F, 0x1F, 0x0F, 0xFE, 0x1F, 0x07, 0xC7, 0xC7, 0xFF, 0xC3,
  0xE3, 0xF1, 0xF1, 0xF3, 0xF0, 0xFF, 0xF8, 0xF8, 0xF8, 0x7C, 0x1F, 0xFE,
  0x3E, 0x3E, 0x0F, 0x87, 0xFF, 0x1F, 0x0F, 0x83, 0xE0, 0xFF, 0x87, 0xC7,
  0xC0, 0xF8, 0x0F, 0x81, 0xF1, 0xF0, 0x3E, 0x00, 0x00, 0xF8, 0x7C, 0x07,
  0xC0, 0x00, 0x3E, 0x1F, 0x01, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x7C, 0x00,
  0x07, 0xC1, 0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0x00, 0xF8,
  0x1F, 0x01, 0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x7C, 0x00, 0x1F, 0x01, 0xF0,
  0x3E, 0x00, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0x03, 0xE0, 0x0F, 0x83, 0xE0,
  0x00, 0xF8, 0x03, 0xE0, 0xF8, 0x00, 0x3C, 0x00, 0xF8, 0x3E, 0x00, 0x1F,
  0x00, 0x1F, 0x1F, 0x00, 0x07, 0xC0, 0x07, 0xFF, 0xC0, 0x03, 0xE0, 0x00,
  0xFF, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7C, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x1F,
  0x81, 0xF8, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x03,
  0xE0, 0x3F, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0xFC, 0x0F, 0xC0, 0x00,
  0x7E, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x0F, 0xC7, 0xF0, 0x00,
  0x07, 0xE3, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0xFE, 0x1F, 0xFF, 0xC0,
  0x7E, 0x1F, 0xEF, 0xE0, 0x3F, 0x0F, 0xE3, 0xF8, 0x1F, 0x8F, 0xE0, 0xFE,
  0x1F, 0xC7, 0xE0, 0x3F, 0x8F, 0xC3, 0xF0, 0x1F, 0xC7, 0xE3, 0xF8, 0x07,
  0xF7, 0xF1, 0xFC, 0x01, 0xFF, 0xF0, 0xFC, 0x00, 0x7F, 0xF8, 0x7E, 0x00,
  0x3F, 0xF8, 0x3F, 0x80, 0x0F, 0xFC, 0x1F, 0xC0, 0x03, 0xFC, 0x0F, 0xE0,
  0x01, 0xFE, 0x03, 0xF8, 0x01, 0xFF, 0x81, 0xFC, 0x01, 0xFF, 0xC0, 0xFF,
  0x83, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0xFF, 0x07,
  0xFF, 0xFE, 0x3F, 0xC1, 0xFF, 0xFC, 0x0F, 0xE0, 0x3F, 0xF8, 0x03, 0xF8,
  0x03, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xF9, 0xE7, 0x9E, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x07,
  0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x3F,
  0x00, 0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xF8, 0x01, 0xF0, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00,
  0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xF8,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x00,
  0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xE0, 0x1F, 0x80, 0xFC, 0x03,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3C, 0x00, 0x40, 0x3C, 0x02, 0x78,
  0x3C, 0x1E, 0x7F, 0x3C, 0xFE, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0x03, 0xE7, 0xC0, 0x07, 0xE7, 0xE0, 0x0F, 0xC3, 0xF0, 0x0F,
  0xC3, 0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0x81, 0xF0, 0x03, 0x00, 0xC0, 0x01,
  0x00, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0xC7, 0xE1, 0xF8, 0x7E, 0x3F, 0x8F, 0xC3, 0xF0, 0xFC, 0x3E, 0x1F,
  0x87, 0xE1, 0xF0, 0x7C, 0x1F, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7C, 0xFE, 0xFE, 0xFE, 0xFF, 0xFE,
  0xFE, 0x7E, 0x18, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xFF,
  0x80, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x01, 0xFC, 0x7F, 0x00, 0xFC, 0x7E, 0x00,
  0xFC, 0x7E, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFC, 0x00,
  0x7E, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7E, 0xFE, 0x00,
  0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0xFC, 0x7F, 0x00,
  0xFC, 0x3F, 0x01, 0xFC, 0x3F, 0xC3, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x38,
  0x00, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x07,
  0xFF, 0x0F, 0xFF, 0x1F, 0xFF, 0x3F, 0xBF, 0x7F, 0x3F, 0xFE, 0x3F, 0x7C,
  0x3F, 0x38, 0x3F, 0x10, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0xE0, 0x03,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE0,
  0xFC, 0x07, 0xF8, 0x78, 0x01, 0xFC, 0x18, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0x7F, 0xF0, 0xF8, 0x07, 0xF8,
  0x70, 0x01, 0xFC, 0x10, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xFB, 0x00, 0x03, 0xFD, 0xF0, 0x07, 0xFC, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xF7,
  0xE0, 0x00, 0x1F, 0x7E, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x3E, 0x7E, 0x00,
  0x07, 0xC7, 0xE0, 0x00, 0x7C, 0x7E, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0xF8,
  0x7E, 0x00, 0x1F, 0x07, 0xE0, 0x01, 0xF0, 0x7E, 0x00, 0x3E, 0x07, 0xE0,
  0x03, 0xE0, 0x7E, 0x00, 0x7C, 0x07, 0xE0, 0x0F, 0xC0, 0x7E, 0x00, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xE0, 0x3F, 0x00, 0x7E,
  0x03, 0xE0, 0x07, 0xE0, 0x7C, 0x00, 0x7E, 0x07, 0xC0, 0x07, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x10, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x10, 0x07,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0xC0, 0x01, 0xFC, 0xF8, 0x07,
  0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x07, 0xFF,
  0x3C, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x3F,
  0xC0, 0xFC, 0x7F, 0xE0, 0xFD, 0xFF, 0xF8, 0xFD, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFC, 0xFF, 0xC3, 0xFE, 0xFF, 0x00, 0xFE, 0xFE, 0x00, 0x7E, 0xFE, 0x00,
  0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x7E, 0x7F, 0x00,
  0x7E, 0x3F, 0x80, 0xFE, 0x3F, 0xC1, 0xFC, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF8, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x18,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF,
  0xF0, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0xFF,
  0x0F, 0xF0, 0xFE, 0x01, 0xFC, 0x7E, 0x00, 0xFE, 0x3F, 0x00, 0x3F, 0x3F,
  0x00, 0x1F, 0x9F, 0x80, 0x0F, 0xCF, 0xC0, 0x07, 0xE3, 0xE0, 0x03, 0xF1,
  0xF8, 0x01, 0xF8, 0xFC, 0x01, 0xFC, 0x7F, 0x00, 0xFC, 0x1F, 0xC0, 0xFE,
  0x0F, 0xF0, 0xFE, 0x03, 0xFD, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF8, 0x0F, 0xF1, 0xFE, 0x07, 0xF0, 0x7F, 0x87, 0xF0, 0x1F, 0xE7, 0xF0,
  0x07, 0xF3, 0xF0, 0x01, 0xFD, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC,
  0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF,
  0xE0, 0x01, 0xFB, 0xF0, 0x00, 0xFD, 0xFC, 0x00, 0xFE, 0xFF, 0x00, 0xFE,
  0x3F, 0xF7, 0xFF, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0x1F, 0xFE, 0x00, 0x01, 0x60, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFF,
  0xE0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xE0, 0xFE, 0x07, 0xF0, 0x7E, 0x01, 0xFC, 0x7F, 0x00, 0x7E, 0x3F,
  0x00, 0x3F, 0x9F, 0x80, 0x0F, 0xCF, 0xC0, 0x07, 0xEF, 0xE0, 0x03, 0xF7,
  0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F,
  0xFF, 0x00, 0x1F, 0xDF, 0x80, 0x0F, 0xEF, 0xC0, 0x07, 0xF7, 0xE0, 0x07,
  0xFB, 0xF8, 0x03, 0xFC, 0xFE, 0x03, 0xFE, 0x7F, 0xC7, 0xFF, 0x1F, 0xFF,
  0xDF, 0x8F, 0xFF, 0xEF, 0xC3, 0xFF, 0xE7, 0xE0, 0xFF, 0xE3, 0xE0, 0x0F,
  0xC3, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0,
  0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xE0,
  0x01, 0xFF, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x7E, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFE, 0x7E, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0xFE, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFE, 0x7E, 0x18, 0x0F, 0x07, 0xE3, 0xF8, 0xFF, 0x3F,
  0xCF, 0xF3, 0xF8, 0x7E, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x1F, 0x87, 0xE3, 0xF8, 0xFE, 0x3F, 0x0F,
  0xC3, 0xF0, 0xF8, 0x7E, 0x1F, 0x87, 0xC1, 0xF0, 0xF8, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F,
  0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F,
  0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0,
  0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xF0, 0x7F,
  0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFE, 0x78, 0x07, 0xF2,
  0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xE0, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x03, 0xF0, 0x00, 0x07, 0xF0, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x07, 0xC0,
  0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0x00,
  0x7C, 0x1F, 0x00, 0x0E, 0x00, 0x7C, 0x3F, 0x00, 0xFF, 0xF8, 0x3E, 0x3E,
  0x01, 0xFF, 0xF8, 0x3E, 0x3E, 0x03, 0xFF, 0xF8, 0x3E, 0x7C, 0x07, 0xF1,
  0xF8, 0x1E, 0x7C, 0x0F, 0xC0, 0xF8, 0x1F, 0x7C, 0x0F, 0x80, 0xF8, 0x1F,
  0x7C, 0x0F, 0x80, 0xF8, 0x1F, 0xF8, 0x1F, 0x00, 0xF8, 0x1F, 0xF8, 0x1F,
  0x01, 0xF8, 0x1F, 0xF8, 0x1F, 0x01, 0xF8, 0x1F, 0xF8, 0x1F, 0x01, 0xF0,
  0x1F, 0xF8, 0x1F, 0x01, 0xF0, 0x1F, 0xF8, 0x1E, 0x01, 0xF0, 0x1F, 0xF8,
  0x1E, 0x01, 0xF0, 0x1F, 0xF8, 0x1E, 0x01, 0xF0, 0x1F, 0xF8, 0x1F, 0x01,
  0xF0, 0x1E, 0xF8, 0x1F, 0x01, 0xF0, 0x1E, 0xF8, 0x1F, 0x03, 0xF0, 0x3E,
  0xF8, 0x1F, 0x03, 0xF0, 0x3E, 0xF8, 0x1F, 0x83, 0xF8, 0x7C, 0xF8, 0x0F,
  0xC7, 0xFC, 0xFC, 0x7C, 0x0F, 0xFF, 0x3F, 0xF8, 0x7C, 0x07, 0xFE, 0x3F,
  0xF0, 0x7C, 0x03, 0xFE, 0x1F, 0xE0, 0x7E, 0x00, 0xF8, 0x0F, 0xC0, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x02, 0x00, 0x07, 0xF8, 0x00, 0x0C, 0x00, 0x03, 0xFF,
  0x00, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0x3F, 0x7E, 0x00,
  0x00, 0x1F, 0x3F, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x0F, 0xC7, 0xC0,
  0x00, 0x07, 0xE3, 0xF0, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0xFE, 0x0F,
  0xC0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0xFC, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x07, 0xE0,
  0x0F, 0xC0, 0x07, 0xF0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0x80, 0x03, 0xF0, 0x1F,
  0xC0, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x7F, 0x07,
  0xF0, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x07, 0xF0,
  0xFC, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00, 0xFC, 0x7F, 0x00, 0x00, 0x7F,
  0x3F, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x07,
  0xF0, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x3F, 0x00, 0xFF, 0xCF, 0xC0, 0x0F, 0xF3,
  0xF0, 0x01, 0xFE, 0xFC, 0x00, 0x3F, 0xBF, 0x00, 0x0F, 0xEF, 0xC0, 0x03,
  0xFB, 0xF0, 0x00, 0xFE, 0xFC, 0x00, 0x3F, 0xBF, 0x00, 0x0F, 0xEF, 0xC0,
  0x03, 0xF3, 0xF0, 0x01, 0xFC, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x7F, 0x8F,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0xFC, 0x00, 0xFF, 0x3F, 0x00,
  0x1F, 0xEF, 0xC0, 0x03, 0xFB, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0xFF,
  0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F,
  0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0xFE, 0xFC, 0x00,
  0x3F, 0xBF, 0x00, 0x1F, 0xEF, 0xC0, 0x3F, 0xF3, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFE, 0x00, 0xE0,
  0x7F, 0x80, 0x04, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x10,
  0x7F, 0xE0, 0x1E, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0x80, 0x00,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x0F, 0xC0, 0xFF, 0xF0, 0xFC, 0x00, 0xFF,
  0x8F, 0xC0, 0x07, 0xF8, 0xFC, 0x00, 0x3F, 0xCF, 0xC0, 0x01, 0xFC, 0xFC,
  0x00, 0x0F, 0xEF, 0xC0, 0x00, 0xFE, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07,
  0xEF, 0xC0, 0x00, 0xFE, 0xFC, 0x00, 0x0F, 0xEF, 0xC0, 0x01, 0xFC, 0xFC,
  0x00, 0x1F, 0xCF, 0xC0, 0x03, 0xFC, 0xFC, 0x00, 0x7F, 0x8F, 0xC0, 0x1F,
  0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xEF, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0x01, 0xFF, 0x80, 0x3E, 0x07, 0xFC, 0x00, 0x08, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x07, 0xF7, 0xE0, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x1F, 0xDF, 0xC0,
  0x00, 0x3F, 0xBF, 0x80, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00,
  0x01, 0xFC, 0xFE, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x07, 0xF1, 0xFC, 0x00,
  0x0F, 0xE3, 0xFC, 0x00, 0x1F, 0xC3, 0xFE, 0x00, 0x3F, 0x83, 0xFF, 0x00,
  0xFF, 0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xF0, 0xFF, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F,
  0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8,
  0x0F, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x03, 0xFB, 0x9F, 0xF7, 0xFF, 0xEF,
  0xFF, 0x9F, 0xFE, 0x3F, 0xF8, 0x7F, 0xC0, 0xFC, 0x00, 0x1F, 0xFF, 0x80,
  0x03, 0xFB, 0xF0, 0x00, 0xFE, 0x7E, 0x00, 0x3F, 0x8F, 0xC0, 0x07, 0xF1,
  0xF8, 0x01, 0xFC, 0x3F, 0x00, 0x7F, 0x07, 0xE0, 0x0F, 0xE0, 0xFC, 0x03,
  0xF8, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x1F, 0xC0, 0x7E, 0x07, 0xF0, 0x0F,
  0xC0, 0xFC, 0x01, 0xF8, 0x3F, 0x80, 0x3F, 0x0F, 0xE0, 0x07, 0xE1, 0xFC,
  0x00, 0xFC, 0x7F, 0x00, 0x1F, 0x9F, 0xC0, 0x03, 0xF3, 0xF8, 0x00, 0x7E,
  0xFE, 0x00, 0x0F, 0xDF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0,
  0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xBF, 0x80, 0x1F, 0xE7, 0xF0, 0x03, 0xF8,
  0x7F, 0x00, 0x7E, 0x0F, 0xE0, 0x0F, 0xC0, 0xFE, 0x01, 0xF8, 0x1F, 0xE0,
  0x3F, 0x01, 0xFC, 0x07, 0xE0, 0x1F, 0xC0, 0xFC, 0x03, 0xF8, 0x1F, 0x80,
  0x3F, 0x83, 0xF0, 0x07, 0xF0, 0x7E, 0x00, 0x7F, 0x0F, 0xC0, 0x0F, 0xE1,
  0xF8, 0x00, 0xFE, 0x3F, 0x00, 0x1F, 0xC7, 0xE0, 0x01, 0xFC, 0xFC, 0x00,
  0x3F, 0x9F, 0x80, 0x03, 0xFB, 0xF0, 0x00, 0x7F, 0x7E, 0x00, 0x07, 0xF0,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFB, 0xE0, 0x00, 0x0F, 0xFF, 0xF7, 0xE0,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x7D, 0xFF, 0xEF, 0x80, 0x00, 0xFB,
  0xFF, 0xDF, 0x80, 0x03, 0xF7, 0xFF, 0xBF, 0x00, 0x07, 0xCF, 0xFF, 0x3E,
  0x00, 0x0F, 0x9F, 0xFE, 0x7E, 0x00, 0x3F, 0x3F, 0xFC, 0xFC, 0x00, 0x7C,
  0x7F, 0xF8, 0xF8, 0x00, 0xF8, 0xFF, 0xF1, 0xF0, 0x03, 0xF1, 0xFF, 0xE3,
  0xF0, 0x07, 0xC3, 0xFF, 0xC7, 0xE0, 0x0F, 0x87, 0xFF, 0x87, 0xC0, 0x1F,
  0x0F, 0xFF, 0x0F, 0xC0, 0x7E, 0x1F, 0xFE, 0x1F, 0x80, 0xF8, 0x3F, 0xFC,
  0x1F, 0x01, 0xF0, 0x7F, 0xF8, 0x3F, 0x07, 0xE0, 0xFF, 0xF0, 0x7E, 0x0F,
  0x81, 0xFF, 0xE0, 0x7C, 0x1F, 0x03, 0xFF, 0xC0, 0xF8, 0x7E, 0x07, 0xFF,
  0x81, 0xF8, 0xF8, 0x0F, 0xFF, 0x03, 0xF1, 0xF0, 0x1F, 0xFE, 0x03, 0xE7,
  0xE0, 0x3F, 0xFC, 0x07, 0xEF, 0x80, 0x7F, 0xF8, 0x0F, 0xDF, 0x00, 0xFF,
  0xF0, 0x0F, 0xBE, 0x01, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xC0, 0x1F,
  0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0xF8, 0x01,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xE0, 0x03,
  0xF0, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xEF,
  0xC0, 0x03, 0xFF, 0xBF, 0x80, 0x0F, 0xFE, 0x7E, 0x00, 0x3F, 0xFD, 0xFC,
  0x00, 0xFF, 0xF3, 0xF0, 0x03, 0xFF, 0xCF, 0xE0, 0x0F, 0xFF, 0x1F, 0x80,
  0x3F, 0xFC, 0x7F, 0x00, 0xFF, 0xF0, 0xFC, 0x03, 0xFF, 0xC3, 0xF8, 0x0F,
  0xFF, 0x07, 0xE0, 0x3F, 0xFC, 0x1F, 0xC0, 0xFF, 0xF0, 0x3F, 0x03, 0xFF,
  0xC0, 0xFE, 0x0F, 0xFF, 0x01, 0xF8, 0x3F, 0xFC, 0x07, 0xF0, 0xFF, 0xF0,
  0x0F, 0xC3, 0xFF, 0xC0, 0x3F, 0x8F, 0xFF, 0x00, 0x7E, 0x3F, 0xFC, 0x01,
  0xFC, 0xFF, 0xF0, 0x07, 0xF3, 0xFF, 0xC0, 0x0F, 0xEF, 0xFF, 0x00, 0x3F,
  0xBF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x3F,
  0xE0, 0x3F, 0xE0, 0x3F, 0xC0, 0x07, 0xF8, 0x1F, 0xC0, 0x01, 0xFC, 0x1F,
  0xE0, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x1F, 0xC7,
  0xF0, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x01, 0xFC,
  0xFC, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xF3, 0xF0, 0x00,
  0x01, 0xF9, 0xF8, 0x00, 0x00, 0xFC, 0xFE, 0x00, 0x00, 0xFE, 0x7F, 0x00,
  0x00, 0x7F, 0x1F, 0x80, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x3F, 0x87, 0xF0,
  0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x1F, 0xE0, 0x3F,
  0xC0, 0x1F, 0xE0, 0x1F, 0xF8, 0x3F, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFC,
  0x0F, 0xFC, 0xFC, 0x01, 0xFE, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0x7E, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x7E, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0xFE, 0xFC, 0x03, 0xFC, 0xFC,
  0x0F, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xE0, 0x3F,
  0xE0, 0x3F, 0xC0, 0x07, 0xF8, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0xE0, 0x00,
  0x7F, 0x0F, 0xE0, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x1F, 0xC7, 0xF0, 0x00,
  0x07, 0xF3, 0xF8, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x01, 0xFC, 0xFC, 0x00,
  0x00, 0x7E, 0x7E, 0x00, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x01, 0xF9,
  0xF8, 0x00, 0x00, 0xFC, 0xFE, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x7F,
  0x1F, 0x80, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x1F,
  0xC1, 0xFC, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x1F,
  0xE0, 0x1F, 0xF8, 0x3F, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xC1, 0xF8, 0x1F, 0xFC, 0x3F, 0x00, 0x7F, 0x87, 0xE0,
  0x07, 0xF0, 0xFC, 0x00, 0x7F, 0x1F, 0x80, 0x0F, 0xE3, 0xF0, 0x01, 0xFC,
  0x7E, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x7E, 0x3F, 0x00,
  0x1F, 0xC7, 0xE0, 0x03, 0xF8, 0xFC, 0x00, 0x7F, 0x1F, 0x80, 0x1F, 0xC3,
  0xF0, 0x03, 0xF8, 0x7E, 0x00, 0xFE, 0x0F, 0xC0, 0xFF, 0xC1, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xF0, 0x03, 0xF0, 0x7F, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xC0, 0xFE,
  0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x01, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xFC,
  0x03, 0xF8, 0x1F, 0x80, 0x3F, 0x83, 0xF0, 0x07, 0xF0, 0x7E, 0x00, 0x7F,
  0x0F, 0xC0, 0x0F, 0xE1, 0xF8, 0x00, 0xFE, 0x3F, 0x00, 0x1F, 0xC7, 0xE0,
  0x01, 0xFC, 0xFC, 0x00, 0x3F, 0x9F, 0x80, 0x03, 0xFB, 0xF0, 0x00, 0x7F,
  0x7E, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xF8, 0x07, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x3F, 0xC0,
  0x7C, 0x3F, 0x80, 0x0C, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x80, 0x00, 0xFE, 0xF0, 0x01,
  0xFE, 0xFE, 0x03, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x00, 0x70, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F,
  0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00,
  0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8,
  0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xF7, 0xF0,
  0x01, 0xFC, 0xFF, 0x00, 0x3F, 0x9F, 0xF0, 0x1F, 0xF1, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0xFD, 0xF8, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x0F,
  0xC7, 0xE0, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0x7F, 0x1F, 0x80, 0x00, 0xFC,
  0x3F, 0x80, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x0F, 0xC0,
  0xFC, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0xFE, 0x03,
  0xF0, 0x01, 0xF8, 0x07, 0xE0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x3F,
  0x00, 0xFC, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0xFC,
  0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x1F, 0x8F,
  0xC0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x7E, 0x7C,
  0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x01, 0xF7, 0xE0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0xBF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xDF, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xCF, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0xFF,
  0x80, 0x03, 0xF3, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xF8, 0xFC, 0x00, 0x3F,
  0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x0F,
  0x78, 0x00, 0x7E, 0x1F, 0xC0, 0x0F, 0xBE, 0x00, 0x7F, 0x07, 0xE0, 0x07,
  0xDF, 0x00, 0x3F, 0x83, 0xF0, 0x03, 0xEF, 0x80, 0x1F, 0x81, 0xF8, 0x01,
  0xF7, 0xC0, 0x0F, 0xC0, 0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xE0, 0x7F, 0x00,
  0xFD, 0xF8, 0x07, 0xF0, 0x1F, 0x80, 0x7C, 0x7C, 0x03, 0xF0, 0x0F, 0xC0,
  0x3E, 0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x1F, 0x00, 0xFC, 0x03, 0xF0,
  0x1F, 0x8F, 0xC0, 0x7E, 0x00, 0xFC, 0x0F, 0xC7, 0xE0, 0x7F, 0x00, 0x7E,
  0x07, 0xC1, 0xF0, 0x3F, 0x00, 0x3F, 0x03, 0xE0, 0xF8, 0x1F, 0x80, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0x03,
  0xF0, 0xF8, 0x0F, 0x87, 0xE0, 0x01, 0xF8, 0x7C, 0x07, 0xC3, 0xF0, 0x00,
  0xFC, 0x7E, 0x03, 0xE1, 0xF8, 0x00, 0x7E, 0x3F, 0x01, 0xF8, 0xFC, 0x00,
  0x3F, 0x1F, 0x80, 0x7C, 0xFE, 0x00, 0x0F, 0xCF, 0x80, 0x3E, 0x7E, 0x00,
  0x07, 0xE7, 0xC0, 0x1F, 0x3F, 0x00, 0x03, 0xF3, 0xE0, 0x0F, 0x9F, 0x80,
  0x01, 0xFB, 0xF0, 0x07, 0xEF, 0xC0, 0x00, 0x7D, 0xF0, 0x01, 0xF7, 0xE0,
  0x00, 0x3E, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0,
  0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x3F, 0x87, 0xE0, 0x01,
  0xF8, 0x3F, 0x80, 0x1F, 0xC0, 0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0xE0,
  0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xF0, 0x3F, 0x80, 0x1F,
  0x81, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0xCF,
  0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x0F, 0xCF, 0xC0, 0x00,
  0xFE, 0x7F, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x7F, 0x0F, 0xC0, 0x03, 0xF0,
  0x7F, 0x00, 0x3F, 0x81, 0xF8, 0x01, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x00, 0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x3F, 0x87,
  0xF0, 0x00, 0xFC, 0x3F, 0x80, 0x07, 0xF3, 0xF8, 0x00, 0x3F, 0x9F, 0xC0,
  0x00, 0xFF, 0xFC, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x03, 0xFB, 0xF0, 0x00,
  0x1F, 0x9F, 0xC0, 0x01, 0xFC, 0x7E, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0xFE,
  0x1F, 0xC0, 0x07, 0xF0, 0x7E, 0x00, 0x3F, 0x03, 0xF8, 0x03, 0xF8, 0x0F,
  0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x03, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0,
  0x7E, 0x00, 0x7F, 0x07, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x3F, 0x1F, 0x80, 0x01, 0xF8, 0xFC, 0x00, 0x0F, 0xEF, 0xE0, 0x00,
  0x3F, 0x7E, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFD,
  0xF0, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x7E, 0x3E, 0x00, 0x03, 0xE1, 0xF8,
  0x00, 0x3F, 0x07, 0xC0, 0x01, 0xF0, 0x3F, 0x00, 0x0F, 0x80, 0xF8, 0x00,
  0xF8, 0x07, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xE0,
  0x03, 0xE0, 0x3F, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x7C, 0x1F, 0x80, 0x03,
  0xF0, 0xF8, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x01, 0xF8,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x7F,
  0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC1, 0xF0, 0x3F, 0x81, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x3F, 0xFF,
  0x83, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0xFF, 0x01, 0xFB,
  0xFC, 0x03, 0xF7, 0xF0, 0x07, 0xEF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF,
  0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFB, 0xF0,
  0x0F, 0xF7, 0xF0, 0x3F, 0xEF, 0xF9, 0xF7, 0xCF, 0xFF, 0xEF, 0x9F, 0xFF,
  0x9F, 0x1F, 0xFE, 0x3E, 0x1F, 0xF0, 0x3C, 0x03, 0x80, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0xFE, 0x03, 0xF1, 0xFF, 0xC1, 0xF9, 0xFF, 0xF0,
  0xFD, 0xFF, 0xFC, 0x7E, 0xFF, 0xFF, 0x3F, 0xF8, 0x7F, 0x9F, 0xF0, 0x1F,
  0xEF, 0xF0, 0x07, 0xF7, 0xF8, 0x01, 0xFB, 0xF8, 0x00, 0xFF, 0xFC, 0x00,
  0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8,
  0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF,
  0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFD,
  0xFE, 0x00, 0x7E, 0xFF, 0x80, 0x7F, 0x7F, 0xE0, 0x7F, 0x3F, 0xFF, 0xFF,
  0x9F, 0xBF, 0xFF, 0x8F, 0xCF, 0xFF, 0x87, 0xC3, 0xFF, 0x83, 0xE0, 0xFF,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0xFF, 0x07, 0xFF, 0xF0,
  0xFF, 0xFF, 0x1F, 0xFF, 0xE3, 0xFE, 0x1E, 0x3F, 0x80, 0x27, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07,
  0xF8, 0x01, 0x3F, 0xC0, 0x33, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x07, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x0F, 0xE0, 0xFC, 0x1F, 0xFC, 0x7E, 0x1F, 0xFF, 0x3F, 0x1F, 0xFF,
  0xDF, 0x8F, 0xFF, 0xEF, 0xCF, 0xF0, 0xFF, 0xEF, 0xF0, 0x1F, 0xF7, 0xF0,
  0x07, 0xFB, 0xF0, 0x03, 0xFD, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03,
  0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFD, 0xF8, 0x00, 0xFE, 0xFE, 0x00,
  0xFF, 0x7F, 0x00, 0x7F, 0x9F, 0xC0, 0x7F, 0xCF, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFB, 0xF0, 0xFF, 0xFD, 0xF8, 0x3F, 0xFC, 0x7C, 0x0F, 0xF8, 0x3E, 0x00,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xC1, 0xFC, 0x3F, 0x00, 0xFC, 0x7F,
  0x00, 0xFE, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0x3E, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x02, 0x3F, 0xC0, 0x0C, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0x00, 0x00,
  0x7F, 0xE0, 0x3F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F,
  0xE0, 0x81, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x0F, 0xFF, 0xE7, 0xFF,
  0xFC, 0xFF, 0xFF, 0x9F, 0xFF, 0xF0, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFF, 0x87, 0xC3, 0xFF, 0xE7,
  0xE3, 0xFF, 0xFB, 0xF1, 0xFF, 0xFF, 0xF9, 0xFE, 0x1F, 0xFC, 0xFE, 0x03,
  0xFE, 0xFE, 0x00, 0xFF, 0x7E, 0x00, 0x7F, 0xBF, 0x00, 0x1F, 0xFF, 0x80,
  0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0,
  0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF,
  0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF,
  0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xBF, 0x00, 0x1F,
  0xDF, 0xC0, 0x1F, 0xEF, 0xE0, 0x0F, 0xF3, 0xF8, 0x0F, 0xF9, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0x7E, 0x1F, 0xFF, 0x3F, 0x07, 0xFF, 0x1F, 0x81, 0xFF,
  0x0F, 0xC0, 0x1C, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x20,
  0x00, 0x3F, 0x8C, 0x00, 0x3F, 0x87, 0xF1, 0xFF, 0xC3, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x01, 0xFE, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x1F, 0xC0, 0xFC, 0x7F, 0xF0, 0xFC, 0xFF,
  0xF8, 0xFD, 0xFF, 0xFC, 0xFD, 0xFF, 0xFE, 0xFF, 0xF3, 0xFE, 0xFF, 0x80,
  0xFE, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x7D, 0xFB,
  0xFF, 0xFF, 0xFF, 0x9F, 0x08, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xBF, 0x7E,
  0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF,
  0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7,
  0xEF, 0xDF, 0x80, 0x01, 0xF0, 0x1F, 0x80, 0xFE, 0x07, 0xF0, 0x3F, 0x81,
  0xF8, 0x07, 0xC0, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x1F, 0xDF, 0xFE, 0xFF, 0xE7,
  0xFF, 0x3F, 0xF1, 0xFF, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x0B, 0xF0, 0x01, 0xF9, 0xF8, 0x01, 0xFC, 0xFC, 0x01, 0xFC,
  0x7E, 0x01, 0xFC, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0xFE, 0x0F, 0xC0, 0xFE,
  0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x7F, 0x00, 0xFC, 0x7F,
  0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0x9F, 0x80, 0x0F, 0xDF,
  0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF,
  0xBF, 0x80, 0x7F, 0x8F, 0xC0, 0x3F, 0x87, 0xF0, 0x1F, 0x81, 0xF8, 0x0F,
  0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x83, 0xF0, 0x1F, 0xC1, 0xF8, 0x07, 0xF0,
  0xFC, 0x01, 0xF8, 0x7E, 0x00, 0xFE, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x1F,
  0xCF, 0xC0, 0x07, 0xE7, 0xE0, 0x03, 0xFB, 0xF0, 0x00, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F,
  0xC0, 0x1F, 0xE0, 0xF8, 0x7F, 0xF0, 0x3F, 0xF0, 0xF8, 0xFF, 0xF8, 0xFF,
  0xF8, 0xFD, 0xFF, 0xF8, 0xFF, 0xFC, 0xFF, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF,
  0xE3, 0xFF, 0xE3, 0xFE, 0xFF, 0x81, 0xFF, 0xC0, 0xFE, 0xFF, 0x00, 0xFF,
  0x80, 0x7F, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0xFE, 0x00,
  0x7E, 0x00, 0x3F, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0xC0, 0xF8, 0x7F, 0xF0, 0xF8, 0xFF, 0xF8, 0xFD, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFE, 0xFF, 0xE1, 0xFE, 0xFF, 0x80, 0xFE, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x0F, 0xF0,
  0x7F, 0x83, 0xF8, 0x0F, 0xE1, 0xFC, 0x01, 0xFC, 0x7E, 0x00, 0x3F, 0x1F,
  0x80, 0x0F, 0xEF, 0xE0, 0x01, 0xFB, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x1F,
  0xBF, 0x00, 0x07, 0xEF, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0x7E, 0xFC, 0x00,
  0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0x7E, 0xFC,
  0x00, 0x1F, 0xBF, 0x00, 0x07, 0xEF, 0xC0, 0x01, 0xFB, 0xF8, 0x00, 0x7E,
  0x7E, 0x00, 0x3F, 0x9F, 0x80, 0x0F, 0xC7, 0xF0, 0x03, 0xF0, 0xFC, 0x01,
  0xFC, 0x3F, 0x80, 0xFE, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x7C, 0x3F, 0xF8, 0x3F, 0x3F, 0xFE, 0x1F, 0xBF, 0xFF,
  0x8F, 0xDF, 0xFF, 0xE7, 0xFF, 0x0F, 0xF3, 0xFE, 0x03, 0xFD, 0xFE, 0x00,
  0xFE, 0xFF, 0x00, 0x3F, 0x7F, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0,
  0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8,
  0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F,
  0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xBF, 0xC0, 0x1F,
  0xDF, 0xF0, 0x0F, 0xEF, 0xFC, 0x0F, 0xE7, 0xFF, 0xFF, 0xF3, 0xF7, 0xFF,
  0xF1, 0xF9, 0xFF, 0xF0, 0xFC, 0x7F, 0xF0, 0x7E, 0x1F, 0xF0, 0x3F, 0x01,
  0xC0, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xFF, 0x87, 0xC3, 0xFF, 0xE7, 0xE3, 0xFF, 0xFB, 0xF1, 0xFF,
  0xFF, 0xF9, 0xFE, 0x1F, 0xFC, 0xFE, 0x03, 0xFE, 0xFE, 0x00, 0xFF, 0x7E,
  0x00, 0x7F, 0xBF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x07, 0xFF,
  0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00,
  0x7F, 0xFE, 0x00, 0x3F, 0xBF, 0x00, 0x1F, 0xDF, 0xC0, 0x1F, 0xEF, 0xE0,
  0x0F, 0xF3, 0xF8, 0x0F, 0xF9, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0x7E, 0x1F,
  0xFF, 0x3F, 0x07, 0xFF, 0x1F, 0x81, 0xFF, 0x0F, 0xC0, 0x18, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xFC, 0x1F,
  0xFE, 0x1F, 0xFF, 0x1F, 0xFF, 0xDF, 0xF7, 0xEF, 0xFB, 0xFF, 0x83, 0xFF,
  0x80, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xF0, 0x3C,
  0x7E, 0x00, 0x4F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xE0, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xF0, 0x0F, 0xEF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x83, 0xFF, 0xE0, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE,
  0x07, 0xFF, 0x01, 0xFF, 0x80, 0x1C, 0x00, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0xFF, 0x7E, 0x01, 0xFF, 0x7F, 0x03, 0xFF, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF,
  0xBF, 0x3F, 0xFF, 0x9F, 0x1F, 0xFF, 0x1F, 0x07, 0xFC, 0x1F, 0x00, 0x60,
  0x00, 0xFE, 0x00, 0x0F, 0xEF, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x7F, 0x3F,
  0x80, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x0F,
  0xE0, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x3F, 0x03, 0xF0, 0x07, 0xE0, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xFC,
  0x01, 0xF0, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0xFC,
  0x3F, 0x00, 0x0F, 0x87, 0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x1F, 0x00,
  0x03, 0xE7, 0xE0, 0x00, 0x7C, 0xFC, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0xFB,
  0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xFE, 0x00,
  0x7F, 0x80, 0x1F, 0xBF, 0x00, 0x3F, 0xC0, 0x0F, 0xDF, 0xC0, 0x1F, 0xE0,
  0x07, 0xE7, 0xE0, 0x0F, 0xF8, 0x03, 0xE3, 0xF0, 0x0F, 0xFC, 0x03, 0xF1,
  0xF8, 0x07, 0xFE, 0x01, 0xF8, 0xFC, 0x03, 0xFF, 0x00, 0xFC, 0x3F, 0x01,
  0xE7, 0xC0, 0x7E, 0x1F, 0x81, 0xF3, 0xE0, 0x7E, 0x0F, 0xC0, 0xF9, 0xF0,
  0x3F, 0x07, 0xE0, 0x7C, 0xF8, 0x1F, 0x81, 0xF8, 0x3E, 0x7C, 0x0F, 0xC0,
  0xFC, 0x3F, 0x1F, 0x07, 0xC0, 0x7E, 0x1F, 0x0F, 0x87, 0xE0, 0x3F, 0x0F,
  0x87, 0xC3, 0xF0, 0x0F, 0x87, 0xC3, 0xE1, 0xF8, 0x07, 0xE3, 0xE1, 0xF8,
  0xF8, 0x03, 0xF3, 0xE0, 0x7C, 0xFC, 0x01, 0xF9, 0xF0, 0x3E, 0x7E, 0x00,
  0xFC, 0xF8, 0x1F, 0x3F, 0x00, 0x3E, 0x7C, 0x0F, 0x9F, 0x00, 0x1F, 0x3E,
  0x07, 0xCF, 0x80, 0x0F, 0xDE, 0x01, 0xF7, 0xC0, 0x07, 0xFF, 0x00, 0xFF,
  0xE0, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x00,
  0x7F, 0xE0, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x0F, 0xF0,
  0x03, 0xFE, 0x00, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x3F, 0xBF, 0x80,
  0x3F, 0x8F, 0xC0, 0x1F, 0x87, 0xF0, 0x1F, 0xC1, 0xF8, 0x0F, 0xC0, 0xFE,
  0x0F, 0xE0, 0x3F, 0x07, 0xE0, 0x1F, 0xC7, 0xF0, 0x07, 0xE3, 0xF0, 0x03,
  0xFB, 0xF8, 0x00, 0xFD, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFE,
  0x00, 0x1F, 0xBF, 0x00, 0x1F, 0x9F, 0xC0, 0x0F, 0xC7, 0xE0, 0x0F, 0xE3,
  0xF8, 0x07, 0xE0, 0xFC, 0x07, 0xF0, 0x7F, 0x03, 0xF0, 0x1F, 0x83, 0xF8,
  0x0F, 0xE1, 0xF8, 0x03, 0xF1, 0xFC, 0x01, 0xFC, 0xFC, 0x00, 0x7E, 0xFE,
  0x00, 0x3F, 0x80, 0xFE, 0x00, 0x0F, 0xEF, 0xC0, 0x01, 0xF9, 0xF8, 0x00,
  0x7F, 0x3F, 0x80, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x0F,
  0xE0, 0x0F, 0xE0, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x3F, 0x03, 0xF0, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x0F,
  0x80, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xE0, 0xFC,
  0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xC7, 0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x1F,
  0x1F, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xDF, 0x80,
  0x00, 0xFB, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x01, 0xBF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x03,
  0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0xFF, 0xE0,
  0x3F, 0xE0, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x01,
  0xFF, 0x00, 0x1F, 0xC0, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00,
  0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xE0, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x3F, 0x80, 0x1F, 0xF0,
  0x07, 0xFE, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x1F,
  0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x4F, 0xFE, 0x00, 0x37, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xEC, 0x00, 0xFF,
  0xF2, 0x00, 0x0F, 0xF8, 0x80, 0x00, 0x00, 0x00,
};

const GFXglyph NotoSans_Condensed_Medium62pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 8, 45, 16, 4, -44 },
  { 46, 18, 16, 25, 4, -44 },
  { 82, 30, 44, 32, 1, -44 },
  { 247, 24, 51, 30, 3, -47 },
  { 400, 42, 46, 46, 2, -45 },
  { 642, 33, 46, 35, 2, -45 },
  { 832, 6, 16, 14, 4, -44 },
  { 844, 14, 54, 19, 3, -44 },
  { 939, 14, 54, 19, 2, -44 },
  { 1034, 24, 24, 28, 2, -47 },
  { 1106, 25, 30, 30, 2, -37 },
  { 1200, 10, 15, 15, 2, -7 },
  { 1219, 14, 6, 18, 2, -20 },
  { 1230, 8, 9, 15, 4, -8 },
  { 1239, 22, 45, 24, 1, -45 },
  { 1363, 24, 46, 30, 3, -45 },
  { 1501, 16, 44, 30, 4, -44 },
  { 1589, 25, 45, 30, 2, -45 },
  { 1730, 25, 46, 30, 2, -45 },
  { 1874, 28, 45, 30, 1, -45 },
  { 2032, 24, 45, 30, 3, -44 },
  { 2167, 24, 46, 30, 3, -45 },
  { 2305, 25, 44, 30, 2, -44 },
  { 2443, 25, 46, 30, 2, -45 },
  { 2587, 25, 46, 30, 2, -45 },
  { 2731, 8, 35, 15, 4, -34 },
  { 2766, 10, 42, 15, 2, -34 },
  { 2819, 26, 29, 30, 2, -37 },
  { 2914, 25, 18, 30, 2, -31 },
  { 2971, 26, 29, 30, 2, -37 },
  { 3066, 20, 46, 23, 1, -45 },
  { 3181, 40, 50, 46, 3, -45 },
  { 3431, 33, 44, 33, 0, -44 },
  { 3613, 26, 44, 33, 5, -44 },
  { 3756, 27, 46, 32, 3, -45 },
  { 3912, 28, 44, 37, 5, -44 },
  { 4066, 20, 44, 28, 5, -44 },
  { 4176, 20, 44, 27, 5, -44 },
  { 4286, 31, 46, 37, 3, -45 },
  { 4465, 28, 44, 38, 5, -44 },
  { 4619, 15, 44, 19, 2, -44 },
  { 4702, 15, 56, 16, -4, -44 },
  { 4807, 27, 44, 32, 5, -44 },
  { 4956, 20, 44, 26, 5, -44 },
  { 5066, 39, 44, 49, 5, -44 },
  { 5281, 30, 44, 40, 5, -44 },
  { 5446, 33, 46, 39, 3, -45 },
  { 5636, 24, 44, 31, 5, -44 },
  { 5768, 33, 56, 39, 3, -45 },
  { 5999, 27, 44, 32, 5, -44 },
  { 6148, 24, 46, 28, 2, -45 },
  { 6286, 26, 44, 28, 1, -44 },
  { 6429, 27, 45, 37, 5, -44 },
  { 6581, 31, 44, 31, 0, -44 },
  { 6752, 49, 44, 49, 0, -44 },
  { 7022, 29, 44, 30, 0, -44 },
  { 7182, 29, 44, 29, 0, -44 },
  { 7342, 24, 44, 27, 2, -44 },
  { 7474, 14, 54, 20, 4, -44 },
  { 7569, 22, 45, 24, 1, -45 },
  { 7693, 13, 54, 20, 2, -44 },
  { 7781, 29, 25, 31, 1, -44 },
  { 7872, 27, 4, 27, 0, 5 },
  { 7886, 13, 9, 18, 2, -47 },
  { 7901, 23, 35, 29, 2, -34 },
  { 8002, 25, 48, 32, 4, -47 },
  { 8152, 20, 35, 25, 3, -34 },
  { 8240, 25, 48, 32, 3, -47 },
  { 8390, 24, 35, 29, 3, -34 },
  { 8495, 19, 47, 18, 1, -47 },
  { 8607, 25, 49, 32, 3, -34 },
  { 8761, 24, 47, 32, 4, -47 },
  { 8902, 7, 46, 15, 4, -46 },
  { 8943, 13, 61, 15, -2, -46 },
  { 9043, 25, 47, 29, 4, -47 },
  { 9190, 6, 47, 15, 4, -47 },
  { 9226, 40, 34, 48, 4, -34 },
  { 9396, 24, 34, 32, 4, -34 },
  { 9498, 26, 35, 31, 3, -34 },
  { 9612, 25, 49, 32, 4, -34 },
  { 9766, 25, 49, 32, 3, -34 },
  { 9920, 17, 34, 22, 4, -34 },
  { 9993, 20, 35, 24, 2, -34 },
  { 10081, 17, 42, 19, 1, -41 },
  { 10171, 24, 34, 32, 4, -33 },
  { 10273, 27, 33, 27, 0, -33 },
  { 10385, 41, 33, 42, 1, -33 },
  { 10555, 25, 33, 27, 1, -33 },
  { 10659, 27, 48, 27, 0, -33 },
  { 10821, 19, 33, 23, 2, -33 },
  { 10900, 18, 54, 23, 2, -44 },
  { 11022, 6, 62, 28, 11, -47 },
  { 11069, 19, 54, 23, 2, -44 },
  { 11198, 26, 9, 30, 2, -26 },
};

const GFXfont NotoSans_Condensed_Medium62pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Medium62pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Medium62pt7bGlyphs,
  0x20, 0x7E, 84
};

#endif // _NOTOSANS_CONDENSED_MEDIUM62PT7B_H_
