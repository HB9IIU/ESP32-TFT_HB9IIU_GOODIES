#ifndef _NOTOSANS_CONDENSED_MEDIUM63PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUM63PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Medium.ttf
// Size: 63pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Medium63pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0x7C, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x18, 0xFC,
  0x1F, 0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0x03,
  0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xEF, 0xC0, 0xFB,
  0xF0, 0x3E, 0xFC, 0x0F, 0x9F, 0x03, 0xE7, 0x80, 0xF9, 0xE0, 0x3E, 0x00,
  0x1F, 0x03, 0xE0, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0x78, 0x0F, 0x00, 0x01,
  0xF0, 0x1E, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x0F,
  0x81, 0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x78,
  0x0F, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xC0,
  0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0x01, 0xF0, 0x3E, 0x00, 0x03, 0xE0, 0x7C,
  0x00, 0x07, 0xC0, 0xF8, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x1F, 0x03, 0xE0,
  0x00, 0x3C, 0x07, 0x80, 0x00, 0xF8, 0x0F, 0x00, 0x01, 0xF0, 0x3E, 0x00,
  0x03, 0xE0, 0x7C, 0x00, 0x07, 0xC0, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xFC, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x0F,
  0x81, 0xF0, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0xF8,
  0x1F, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xC0,
  0xF8, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x3C, 0x07,
  0x80, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7F, 0x80,
  0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFE, 0x7F, 0x3C, 0x1C, 0xFE, 0x3C, 0x04, 0xFC, 0x3C, 0x00,
  0xFC, 0x3C, 0x00, 0xFC, 0x3C, 0x00, 0xFC, 0x3C, 0x00, 0xFC, 0x3C, 0x00,
  0xFC, 0x3C, 0x00, 0xFE, 0x3C, 0x00, 0x7F, 0xBC, 0x00, 0x7F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0,
  0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3D, 0xFE,
  0x00, 0x3C, 0x7F, 0x00, 0x3C, 0x3F, 0x00, 0x3C, 0x3F, 0x00, 0x3C, 0x1F,
  0x00, 0x3C, 0x1F, 0x00, 0x3C, 0x1F, 0x00, 0x3C, 0x3F, 0x80, 0x3C, 0x3F,
  0xF0, 0x3C, 0x7F, 0xFF, 0x3F, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xF8, 0x00, 0x7F, 0xF8,
  0x00, 0x7C, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0x00, 0x0F, 0x8F, 0xC0, 0x0F,
  0x80, 0x07, 0xE1, 0xF0, 0x03, 0xE0, 0x01, 0xF0, 0x7C, 0x01, 0xF8, 0x00,
  0x7C, 0x0F, 0x80, 0x7C, 0x00, 0x1F, 0x03, 0xE0, 0x1F, 0x00, 0x07, 0xC0,
  0xF8, 0x0F, 0x80, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x00, 0xFC, 0x0F, 0x81,
  0xF0, 0x00, 0x3F, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0xC0, 0xF8, 0x1F, 0x00,
  0x03, 0xF0, 0x3E, 0x0F, 0x80, 0x00, 0x7C, 0x0F, 0x83, 0xE0, 0x00, 0x1F,
  0x03, 0xE1, 0xF0, 0x00, 0x07, 0xC0, 0xF8, 0x7C, 0x06, 0x01, 0xF0, 0x3E,
  0x3F, 0x0F, 0xF0, 0x7C, 0x0F, 0x8F, 0x87, 0xFE, 0x1F, 0x07, 0xC3, 0xE3,
  0xFF, 0xC3, 0xE1, 0xF1, 0xF1, 0xFF, 0xF0, 0xF8, 0xFC, 0x7C, 0x7C, 0x7E,
  0x3F, 0xFE, 0x3E, 0x1F, 0x0F, 0x87, 0xFF, 0x8F, 0x8F, 0x83, 0xF0, 0xFF,
  0xC3, 0xE3, 0xE0, 0x7C, 0x1F, 0xE1, 0xF0, 0xF8, 0x1F, 0x00, 0xC0, 0x7C,
  0x3E, 0x07, 0xC0, 0x00, 0x3E, 0x0F, 0x81, 0xF0, 0x00, 0x0F, 0x83, 0xE0,
  0x7C, 0x00, 0x07, 0xE0, 0xF8, 0x1F, 0x00, 0x01, 0xF0, 0x3E, 0x07, 0xC0,
  0x00, 0x7C, 0x0F, 0x81, 0xF0, 0x00, 0x3E, 0x03, 0xE0, 0x7C, 0x00, 0x0F,
  0x80, 0xF8, 0x1F, 0x00, 0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x01, 0xF0, 0x0F,
  0x81, 0xF0, 0x00, 0x7C, 0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x00, 0xF8, 0x3F,
  0x00, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC7, 0xE0, 0x01,
  0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3E, 0x00,
  0x07, 0xFE, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFE,
  0xFF, 0x00, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x7C, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0xFC, 0x07, 0xE0, 0x00,
  0x3F, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x03, 0xF0, 0x3F, 0x00,
  0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x07, 0xE3, 0xF8,
  0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0x07,
  0xFF, 0xF0, 0x0F, 0xC3, 0xFC, 0xFE, 0x07, 0xF0, 0xFE, 0x1F, 0xC1, 0xF8,
  0x7F, 0x07, 0xF0, 0x7E, 0x1F, 0x80, 0xFE, 0x1F, 0x87, 0xE0, 0x1F, 0xCF,
  0xE3, 0xF8, 0x03, 0xFB, 0xF0, 0xFE, 0x00, 0xFF, 0xFC, 0x3F, 0x80, 0x1F,
  0xFE, 0x0F, 0xE0, 0x03, 0xFF, 0x83, 0xF8, 0x00, 0xFF, 0xC0, 0xFE, 0x00,
  0x1F, 0xF0, 0x3F, 0x80, 0x03, 0xF8, 0x07, 0xF0, 0x01, 0xFF, 0x01, 0xFE,
  0x01, 0xFF, 0xE0, 0x7F, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xCF, 0xE0, 0x7F, 0xFF, 0xE1, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F,
  0x80, 0xFF, 0xF0, 0x0F, 0xF0, 0x01, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xF7, 0x9E, 0x00, 0xFC, 0x03,
  0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x0F,
  0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x1F,
  0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0xFC, 0x01,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0,
  0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x7F, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x1F, 0x80,
  0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x70, 0x3C, 0x06, 0x7E,
  0x3C, 0x3F, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x03,
  0xF7, 0xC0, 0x03, 0xE7, 0xE0, 0x07, 0xE3, 0xF0, 0x0F, 0xC3, 0xF0, 0x1F,
  0xC1, 0xF8, 0x1F, 0x81, 0xFC, 0x07, 0x80, 0xE0, 0x01, 0x00, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0xC7, 0xF1, 0xF8, 0x7E, 0x3F, 0x8F, 0xE3, 0xF0, 0xFC, 0x3F,
  0x0F, 0x87, 0xE1, 0xF8, 0x7C, 0x1F, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7C, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x7E, 0x18, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0x0F, 0xF0, 0x7F, 0x03, 0xF8, 0x3F, 0x00,
  0xFC, 0x3F, 0x80, 0x7F, 0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0x0F, 0xCF, 0xE0,
  0x07, 0xF7, 0xF0, 0x03, 0xFB, 0xF0, 0x00, 0xFD, 0xF8, 0x00, 0x7E, 0xFC,
  0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xDF, 0x80, 0x07, 0xEF,
  0xC0, 0x03, 0xF7, 0xE0, 0x01, 0xFB, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F,
  0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xDF, 0x80, 0x07,
  0xEF, 0xC0, 0x03, 0xF7, 0xE0, 0x01, 0xFB, 0xF0, 0x00, 0xFD, 0xF8, 0x00,
  0x7E, 0xFC, 0x00, 0x3F, 0x7F, 0x00, 0x3F, 0xBF, 0x80, 0x1F, 0xCF, 0xC0,
  0x0F, 0xC7, 0xE0, 0x07, 0xE3, 0xF8, 0x07, 0xF1, 0xFC, 0x03, 0xF0, 0x7F,
  0x03, 0xF8, 0x3F, 0xC3, 0xFC, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x01,
  0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF8, 0x3F,
  0xFC, 0x3F, 0xFE, 0x3F, 0xFF, 0x3F, 0xDF, 0xBF, 0xCF, 0xFF, 0xC7, 0xEF,
  0xC3, 0xF3, 0xC1, 0xF8, 0x81, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x00, 0x38, 0x00, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE1, 0xFE, 0x07, 0xF8, 0x7C, 0x01,
  0xFC, 0x18, 0x00, 0x7F, 0x08, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x1C, 0x00, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0xFC, 0x07, 0xF8, 0x78, 0x01,
  0xFE, 0x10, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFD, 0x80, 0x01, 0xFE, 0xF8, 0x03, 0xFE, 0x7F, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00,
  0x01, 0xD0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x01,
  0xF7, 0xE0, 0x00, 0x1F, 0x7E, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x3E, 0x7E,
  0x00, 0x07, 0xC7, 0xE0, 0x00, 0x7C, 0x7E, 0x00, 0x0F, 0x87, 0xE0, 0x00,
  0xF8, 0x7E, 0x00, 0x1F, 0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x3E, 0x07,
  0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7C, 0x07, 0xE0, 0x0F, 0xC0, 0x7E, 0x00,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xE0, 0x3E, 0x00,
  0x7E, 0x03, 0xE0, 0x07, 0xE0, 0x7C, 0x00, 0x7E, 0x07, 0xC0, 0x07, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0xFF, 0x00, 0x7F,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x3F,
  0xBF, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x80, 0x00, 0xFE, 0xC0,
  0x01, 0xFE, 0xF8, 0x07, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x80,
  0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x3F, 0xE0, 0x08, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7E, 0x07, 0x00, 0x3F, 0x0F, 0xF8, 0x1F, 0x9F,
  0xFE, 0x0F, 0xDF, 0xFF, 0x87, 0xEF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF9, 0xFF,
  0x03, 0xFC, 0xFF, 0x00, 0x7F, 0x7F, 0x00, 0x3F, 0xBF, 0x80, 0x0F, 0xDF,
  0x80, 0x07, 0xEF, 0xC0, 0x03, 0xF7, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF,
  0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x0F,
  0xCF, 0xC0, 0x07, 0xE7, 0xE0, 0x03, 0xF3, 0xF8, 0x03, 0xF8, 0xFC, 0x01,
  0xFC, 0x7F, 0x01, 0xFC, 0x3F, 0xC1, 0xFE, 0x0F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0x83, 0xFC, 0x0F, 0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0xC0,
  0x0F, 0xE7, 0xF0, 0x01, 0xF9, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x8F,
  0xC0, 0x0F, 0xE3, 0xF0, 0x03, 0xF0, 0xFE, 0x00, 0xFC, 0x1F, 0x80, 0x7E,
  0x07, 0xF0, 0x3F, 0x80, 0xFF, 0x1F, 0xC0, 0x1F, 0xFF, 0xE0, 0x03, 0xFF,
  0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x07,
  0xFF, 0xF0, 0x03, 0xFD, 0xFF, 0x01, 0xFE, 0x3F, 0xE0, 0xFF, 0x03, 0xFC,
  0x3F, 0x80, 0x7F, 0x1F, 0xC0, 0x0F, 0xE7, 0xE0, 0x03, 0xF9, 0xF8, 0x00,
  0x7E, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xF7, 0xE0, 0x01, 0xF9,
  0xFC, 0x00, 0xFE, 0x7F, 0x80, 0x7F, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0xD0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFF, 0x07, 0xF8,
  0x7F, 0x01, 0xFC, 0x7F, 0x00, 0x7E, 0x3F, 0x80, 0x3F, 0x9F, 0x80, 0x0F,
  0xCF, 0xC0, 0x07, 0xEF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00,
  0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80,
  0x07, 0xEF, 0xC0, 0x07, 0xF7, 0xE0, 0x03, 0xFB, 0xF8, 0x01, 0xFD, 0xFC,
  0x01, 0xFE, 0x7F, 0x01, 0xFF, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC3,
  0xFF, 0xF7, 0xE0, 0xFF, 0xF3, 0xF0, 0x3F, 0xF1, 0xF8, 0x01, 0xC0, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF8, 0x0F, 0xFF,
  0xF8, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0xFF,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x7E, 0x18, 0x1F, 0x0F, 0xE3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3,
  0xF8, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x1F, 0xC7, 0xE1, 0xF8, 0xFE, 0x3F, 0x8F, 0xC3, 0xF0,
  0xFC, 0x7E, 0x1F, 0x87, 0xC1, 0xF0, 0x7C, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00,
  0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F,
  0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0,
  0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x7F, 0xF0, 0x1F,
  0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF9, 0xF0, 0x3F,
  0xCE, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xF8, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC1,
  0xF0, 0x03, 0xFE, 0x03, 0xE1, 0xF8, 0x07, 0xFF, 0xC1, 0xF0, 0xF8, 0x07,
  0xFF, 0xE0, 0x7C, 0x7C, 0x07, 0xFF, 0xF0, 0x3E, 0x7C, 0x07, 0xE0, 0xF8,
  0x1F, 0x3E, 0x07, 0xE0, 0x7C, 0x0F, 0x9F, 0x03, 0xE0, 0x3E, 0x03, 0xCF,
  0x81, 0xF0, 0x1F, 0x01, 0xFF, 0x81, 0xF8, 0x0F, 0x80, 0xFF, 0xC0, 0xF8,
  0x07, 0xC0, 0x7F, 0xE0, 0x7C, 0x03, 0xE0, 0x3F, 0xF0, 0x3E, 0x01, 0xF0,
  0x1F, 0xF8, 0x1F, 0x00, 0xF8, 0x0F, 0xFC, 0x0F, 0x80, 0x7C, 0x07, 0xFE,
  0x07, 0xC0, 0x3E, 0x03, 0xDF, 0x03, 0xE0, 0x3F, 0x03, 0xEF, 0x81, 0xF0,
  0x1F, 0x81, 0xF7, 0xC0, 0xF8, 0x0F, 0xC0, 0xFB, 0xE0, 0x7C, 0x07, 0xE0,
  0x7D, 0xF0, 0x3F, 0x07, 0xF0, 0x7C, 0xF8, 0x0F, 0x83, 0xF8, 0x3E, 0x3E,
  0x07, 0xF3, 0xDF, 0x7E, 0x1F, 0x01, 0xFF, 0xCF, 0xFF, 0x0F, 0x80, 0xFF,
  0xE3, 0xFF, 0x07, 0xE0, 0x3F, 0xE0, 0xFF, 0x01, 0xF0, 0x07, 0xC0, 0x3E,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x40, 0x00, 0x7F, 0x80, 0x00, 0xE0,
  0x00, 0x1F, 0xF8, 0x03, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0x3E, 0xF8, 0x00,
  0x00, 0x3F, 0x7E, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x0F, 0xCF, 0x80,
  0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x03, 0xF1, 0xF8,
  0x00, 0x01, 0xF8, 0xFC, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x1F,
  0x80, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x3F, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x0F, 0xE0,
  0x1F, 0x80, 0x07, 0xE0, 0x0F, 0xC0, 0x03, 0xF0, 0x07, 0xE0, 0x03, 0xF8,
  0x03, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xC0, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0xFE, 0x07,
  0xF0, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x0F, 0xE1,
  0xFC, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0xFE,
  0x7F, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x0F,
  0xDF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xF8, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0x3F, 0x03, 0xFF, 0xCF, 0xC0, 0x0F, 0xFB, 0xF0, 0x01, 0xFE, 0xFC,
  0x00, 0x3F, 0xBF, 0x00, 0x0F, 0xEF, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0x7E,
  0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x07, 0xEF, 0xC0, 0x03, 0xFB, 0xF0, 0x00,
  0xFE, 0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0xCF, 0xC0, 0x1F, 0xE3, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xF8, 0xFC, 0x01, 0xFF, 0x3F, 0x00, 0x1F, 0xEF, 0xC0, 0x03,
  0xFB, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x0F,
  0xEF, 0xC0, 0x07, 0xFB, 0xF0, 0x1F, 0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0x81, 0xF0,
  0x7F, 0xC0, 0x06, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x02, 0x07, 0xFE, 0x03, 0xC0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x70, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0x83, 0xF0, 0x07, 0xFE, 0x1F, 0x80, 0x0F, 0xF8, 0xFC, 0x00, 0x3F, 0xC7,
  0xE0, 0x00, 0xFF, 0x3F, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x1F, 0xCF, 0xC0,
  0x00, 0x7F, 0x7E, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x1F, 0xDF, 0x80, 0x00,
  0x7E, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F,
  0x7E, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0xFE, 0xFC,
  0x00, 0x07, 0xF7, 0xE0, 0x00, 0x7F, 0x3F, 0x00, 0x03, 0xF9, 0xF8, 0x00,
  0x3F, 0x8F, 0xC0, 0x03, 0xFC, 0x7E, 0x00, 0x3F, 0xC3, 0xF0, 0x07, 0xFE,
  0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFE, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xC0, 0x7E,
  0x03, 0xFE, 0x00, 0x1C, 0x0F, 0xF0, 0x00, 0x08, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xF7, 0xE0, 0x00,
  0x07, 0xEF, 0xC0, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x1F, 0xBF, 0x80, 0x00,
  0x3F, 0x7F, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0xFC, 0xFE, 0x00, 0x01,
  0xF9, 0xFC, 0x00, 0x03, 0xF1, 0xFC, 0x00, 0x07, 0xE3, 0xFC, 0x00, 0x0F,
  0xC3, 0xFC, 0x00, 0x1F, 0x87, 0xFC, 0x00, 0x3F, 0x07, 0xFE, 0x01, 0xFE,
  0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0x80,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x1F, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0x00, 0xFE, 0x01,
  0xFC, 0x07, 0xF6, 0x1F, 0xEF, 0xFF, 0xDF, 0xFF, 0x3F, 0xFC, 0x7F, 0xF0,
  0xFF, 0xC0, 0xFC, 0x00, 0x0F, 0xEF, 0xC0, 0x01, 0xFC, 0xFC, 0x00, 0x1F,
  0xCF, 0xC0, 0x03, 0xF8, 0xFC, 0x00, 0x7F, 0x0F, 0xC0, 0x07, 0xF0, 0xFC,
  0x00, 0xFE, 0x0F, 0xC0, 0x1F, 0xC0, 0xFC, 0x01, 0xFC, 0x0F, 0xC0, 0x3F,
  0x80, 0xFC, 0x07, 0xF0, 0x0F, 0xC0, 0x7F, 0x00, 0xFC, 0x0F, 0xE0, 0x0F,
  0xC0, 0xFE, 0x00, 0xFC, 0x1F, 0xC0, 0x0F, 0xC3, 0xF8, 0x00, 0xFC, 0x3F,
  0x80, 0x0F, 0xC7, 0xF0, 0x00, 0xFC, 0xFE, 0x00, 0x0F, 0xCF, 0xE0, 0x00,
  0xFD, 0xFE, 0x00, 0x0F, 0xDF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFB, 0xF8, 0x00, 0xFF, 0x1F, 0xC0,
  0x0F, 0xE1, 0xFC, 0x00, 0xFC, 0x0F, 0xE0, 0x0F, 0xC0, 0xFE, 0x00, 0xFC,
  0x07, 0xF0, 0x0F, 0xC0, 0x7F, 0x80, 0xFC, 0x03, 0xF8, 0x0F, 0xC0, 0x3F,
  0xC0, 0xFC, 0x01, 0xFC, 0x0F, 0xC0, 0x0F, 0xE0, 0xFC, 0x00, 0xFE, 0x0F,
  0xC0, 0x07, 0xF0, 0xFC, 0x00, 0x7F, 0x0F, 0xC0, 0x03, 0xF8, 0xFC, 0x00,
  0x3F, 0x8F, 0xC0, 0x01, 0xFC, 0xFC, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0xFE,
  0xFC, 0x00, 0x0F, 0xF0, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0x00, 0x0F, 0xBF, 0xFD, 0xF0, 0x00, 0x0F, 0xBF, 0xFD, 0xF0,
  0x00, 0x1F, 0xBF, 0xFD, 0xF8, 0x00, 0x1F, 0x3F, 0xFD, 0xF8, 0x00, 0x1F,
  0x3F, 0xFC, 0xF8, 0x00, 0x3F, 0x3F, 0xFC, 0xFC, 0x00, 0x3E, 0x3F, 0xFC,
  0xFC, 0x00, 0x3E, 0x3F, 0xFC, 0x7C, 0x00, 0x7E, 0x3F, 0xFC, 0x7E, 0x00,
  0x7E, 0x3F, 0xFC, 0x7E, 0x00, 0x7C, 0x3F, 0xFC, 0x3E, 0x00, 0xFC, 0x3F,
  0xFC, 0x3E, 0x00, 0xFC, 0x3F, 0xFC, 0x3F, 0x00, 0xF8, 0x3F, 0xFC, 0x3F,
  0x00, 0xF8, 0x3F, 0xFC, 0x1F, 0x01, 0xF8, 0x3F, 0xFC, 0x1F, 0x81, 0xF0,
  0x3F, 0xFC, 0x1F, 0x81, 0xF0, 0x3F, 0xFC, 0x0F, 0x83, 0xF0, 0x3F, 0xFC,
  0x0F, 0xC3, 0xE0, 0x3F, 0xFC, 0x0F, 0xC3, 0xE0, 0x3F, 0xFC, 0x07, 0xC7,
  0xE0, 0x3F, 0xFC, 0x07, 0xE7, 0xE0, 0x3F, 0xFC, 0x07, 0xE7, 0xC0, 0x3F,
  0xFC, 0x07, 0xEF, 0xC0, 0x3F, 0xFC, 0x03, 0xEF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFE,
  0x00, 0x3F, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xEF, 0xC0, 0x03, 0xFF, 0xDF,
  0xC0, 0x07, 0xFF, 0x9F, 0x80, 0x0F, 0xFF, 0x3F, 0x80, 0x1F, 0xFE, 0x3F,
  0x00, 0x3F, 0xFC, 0x7F, 0x00, 0x7F, 0xF8, 0x7E, 0x00, 0xFF, 0xF0, 0xFE,
  0x01, 0xFF, 0xE0, 0xFC, 0x03, 0xFF, 0xC1, 0xFC, 0x07, 0xFF, 0x81, 0xF8,
  0x0F, 0xFF, 0x03, 0xF8, 0x1F, 0xFE, 0x03, 0xF0, 0x3F, 0xFC, 0x07, 0xF0,
  0x7F, 0xF8, 0x0F, 0xE0, 0xFF, 0xF0, 0x0F, 0xE1, 0xFF, 0xE0, 0x1F, 0xC3,
  0xFF, 0xC0, 0x1F, 0xC7, 0xFF, 0x80, 0x3F, 0x8F, 0xFF, 0x00, 0x3F, 0x9F,
  0xFE, 0x00, 0x7F, 0x3F, 0xFC, 0x00, 0x7F, 0x7F, 0xF8, 0x00, 0xFE, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xF0, 0x3F, 0xE0,
  0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x7F,
  0x0F, 0xE0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x07,
  0xF3, 0xF8, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0xFC, 0xFE, 0x00, 0x00,
  0x7F, 0x7E, 0x00, 0x00, 0x3F, 0xBF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x01, 0xFD, 0xF8,
  0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x3F, 0x3F,
  0x80, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x0F, 0xE3,
  0xF8, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x07, 0xF0,
  0x1F, 0xE0, 0x07, 0xF8, 0x0F, 0xFC, 0x1F, 0xF8, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFE, 0xFC, 0x03, 0xFE, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFE,
  0xFC, 0x03, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xF0, 0x3F, 0xE0, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x01,
  0xFC, 0x0F, 0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x3F, 0x87, 0xF0, 0x00,
  0x0F, 0xE3, 0xF0, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x03, 0xF9, 0xFC, 0x00,
  0x00, 0xFE, 0xFE, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x3F, 0xBF, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFB,
  0xF0, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x7F,
  0x7F, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x1F,
  0xC7, 0xF0, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x07,
  0xF0, 0x7F, 0x80, 0x07, 0xF0, 0x1F, 0xE0, 0x07, 0xF8, 0x0F, 0xFC, 0x1F,
  0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFC, 0x3F, 0x00, 0x7F, 0x87, 0xE0, 0x07, 0xF8, 0xFC,
  0x00, 0x7F, 0x1F, 0x80, 0x0F, 0xE3, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x1F,
  0x8F, 0xC0, 0x03, 0xF9, 0xF8, 0x00, 0x7F, 0x3F, 0x00, 0x0F, 0xC7, 0xE0,
  0x01, 0xF8, 0xFC, 0x00, 0x7F, 0x1F, 0x80, 0x0F, 0xE3, 0xF0, 0x01, 0xFC,
  0x7E, 0x00, 0x7F, 0x0F, 0xC0, 0x3F, 0xE1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xC0, 0xFE, 0x01, 0xF8, 0x0F,
  0xC0, 0x3F, 0x01, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xF8, 0x1F,
  0x80, 0x3F, 0x83, 0xF0, 0x07, 0xF0, 0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x0F,
  0xE1, 0xF8, 0x00, 0xFE, 0x3F, 0x00, 0x1F, 0xC7, 0xE0, 0x03, 0xFC, 0xFC,
  0x00, 0x3F, 0x9F, 0x80, 0x07, 0xFB, 0xF0, 0x00, 0x7F, 0x7E, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x3C, 0x00, 0x03, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x9F, 0xF8, 0x7F,
  0x3F, 0x80, 0x0C, 0xFE, 0x00, 0x09, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF,
  0xE0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x70, 0x01, 0xFE, 0xFE,
  0x0F, 0xFD, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFC, 0x07, 0xFF, 0xE0, 0x00, 0x38, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x7E, 0xFE, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0xFE,
  0x7F, 0x80, 0x1F, 0xC3, 0xFE, 0x07, 0xFC, 0x3F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F,
  0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE,
  0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x01, 0xFC,
  0x3F, 0x80, 0x01, 0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF8,
  0x1F, 0x80, 0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xF0,
  0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x0F, 0xE0,
  0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0xC0,
  0x03, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x80,
  0x01, 0xF8, 0x3F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x00,
  0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00,
  0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7C, 0x00,
  0x00, 0x3E, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xF9, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x9F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xF0,
  0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xFC, 0x00, 0x7F,
  0x0F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0xFF, 0xC0, 0x07,
  0xE0, 0x7E, 0x00, 0x7D, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x1F, 0x7E, 0x00,
  0x7E, 0x07, 0xE0, 0x07, 0xCF, 0x80, 0x3F, 0x81, 0xFC, 0x01, 0xF3, 0xE0,
  0x0F, 0xE0, 0x3F, 0x00, 0xFC, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x8F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE1,
  0xF0, 0x1F, 0xC0, 0x3F, 0x81, 0xF8, 0x7C, 0x07, 0xE0, 0x07, 0xE0, 0x7E,
  0x1F, 0x81, 0xF8, 0x01, 0xF8, 0x1F, 0x87, 0xE0, 0x7E, 0x00, 0x7E, 0x07,
  0xC1, 0xF8, 0x3F, 0x80, 0x1F, 0xC1, 0xF0, 0x3E, 0x0F, 0xE0, 0x03, 0xF0,
  0xFC, 0x0F, 0x83, 0xF0, 0x00, 0xFC, 0x3F, 0x03, 0xF0, 0xFC, 0x00, 0x3F,
  0x0F, 0x80, 0xFC, 0x3F, 0x00, 0x0F, 0xC3, 0xE0, 0x1F, 0x1F, 0xC0, 0x03,
  0xF9, 0xF8, 0x07, 0xC7, 0xE0, 0x00, 0x7E, 0x7E, 0x01, 0xF1, 0xF8, 0x00,
  0x1F, 0x9F, 0x80, 0x7E, 0x7E, 0x00, 0x07, 0xE7, 0xC0, 0x1F, 0x9F, 0x80,
  0x01, 0xF9, 0xF0, 0x03, 0xEF, 0xE0, 0x00, 0x3E, 0x7C, 0x00, 0xFB, 0xF0,
  0x00, 0x0F, 0xFF, 0x00, 0x3E, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x0F, 0xBF,
  0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0xFE, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x01,
  0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0x3F, 0x00, 0x3F, 0x80, 0xFE, 0x01, 0xFC,
  0x01, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x1F, 0x80, 0x0F, 0xC0, 0xFE, 0x00,
  0x3F, 0x83, 0xF0, 0x00, 0x7E, 0x1F, 0xC0, 0x01, 0xFC, 0x7E, 0x00, 0x03,
  0xF3, 0xF8, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x03,
  0xF3, 0xF8, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0x7E, 0x1F, 0x80, 0x03, 0xF8,
  0x7F, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x7F, 0x03, 0xF8, 0x01, 0xF8, 0x07,
  0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x01, 0xFC, 0x00, 0xFE,
  0x07, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x1F, 0xC7,
  0xF0, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0xFE, 0xFE, 0x00, 0x01, 0xFC, 0xFE,
  0x00, 0x03, 0xFB, 0xF0, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0xFC, 0xFE, 0x00,
  0x0F, 0xE3, 0xF8, 0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xF0, 0x7E, 0x00, 0x3F,
  0x83, 0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x1F, 0xC0, 0x7E, 0x00, 0xFC, 0x03,
  0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x7F, 0x00, 0x7F, 0x03, 0xF0, 0x01, 0xF8,
  0x3F, 0x80, 0x0F, 0xC1, 0xF8, 0x00, 0x7F, 0x0F, 0xC0, 0x01, 0xF8, 0xFE,
  0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x3F, 0x3F, 0x00, 0x01, 0xFB, 0xF0, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7D, 0xF0,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0x3E, 0x3E, 0x00, 0x03, 0xF1, 0xF8, 0x00,
  0x1F, 0x07, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0xFC,
  0x07, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x03,
  0xE0, 0x1F, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x7C, 0x0F, 0x80, 0x03, 0xF0,
  0xFC, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x7E, 0x7E, 0x00, 0x01, 0xF7, 0xE0,
  0x00, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0x07, 0xF8, 0x1F,
  0xC0, 0x7F, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x00, 0x1E, 0x00, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFC, 0x0F, 0xE7, 0xFC, 0x06, 0x00, 0xFE, 0x04, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0x01, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xC0,
  0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0xFF, 0x7E, 0x00, 0xFF, 0x7F, 0x03, 0xFF, 0x7F, 0xCF, 0xFF, 0x3F, 0xFF,
  0xBF, 0x3F, 0xFF, 0x3F, 0x1F, 0xFE, 0x1F, 0x0F, 0xFC, 0x1F, 0x00, 0xC0,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x81, 0xC0, 0x0F, 0xC3,
  0xFE, 0x03, 0xF1, 0xFF, 0xE0, 0xFC, 0xFF, 0xFC, 0x3F, 0x7F, 0xFF, 0x8F,
  0xFF, 0xFF, 0xE3, 0xFF, 0x03, 0xFC, 0xFF, 0x80, 0x7F, 0x3F, 0xC0, 0x0F,
  0xEF, 0xF0, 0x03, 0xFB, 0xF8, 0x00, 0x7E, 0xFE, 0x00, 0x1F, 0xBF, 0x80,
  0x07, 0xEF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F,
  0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00,
  0x1F, 0xBF, 0x80, 0x07, 0xEF, 0xE0, 0x01, 0xFB, 0xFC, 0x00, 0xFE, 0xFF,
  0x00, 0x3F, 0xBF, 0xE0, 0x1F, 0xCF, 0xFC, 0x0F, 0xF3, 0xFF, 0xFF, 0xF8,
  0xFD, 0xFF, 0xFE, 0x3F, 0x3F, 0xFF, 0x0F, 0xC7, 0xFF, 0x83, 0xE0, 0xFF,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x0F, 0xFF, 0x00, 0xFF,
  0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0xFF, 0x01, 0x87,
  0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x9F, 0xE0, 0x18,
  0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x7F,
  0xF8, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x03, 0xC0, 0xFC,
  0x0F, 0xF8, 0x7E, 0x0F, 0xFF, 0x3F, 0x0F, 0xFF, 0xDF, 0x8F, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xE7, 0xF8, 0x1F, 0xF7, 0xF8, 0x07, 0xFB, 0xF8, 0x03,
  0xFD, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x00,
  0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0,
  0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x01, 0xFF,
  0xF0, 0x00, 0xFF, 0xF8, 0x00, 0xFE, 0xFC, 0x00, 0x7F, 0x7F, 0x00, 0x3F,
  0xBF, 0x80, 0x3F, 0xCF, 0xE0, 0x3F, 0xE7, 0xFF, 0xFF, 0xF1, 0xFF, 0xFE,
  0xF8, 0x7F, 0xFE, 0x7C, 0x1F, 0xFE, 0x3E, 0x07, 0xFC, 0x1F, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xE7, 0xFC, 0x3F, 0x80, 0xFC, 0x3F,
  0x00, 0xFE, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x02, 0x3F, 0xC0, 0x0E, 0x1F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xF0, 0x00,
  0x1F, 0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xFC, 0x07, 0xFF, 0x81, 0xFF, 0xF0,
  0x7F, 0xFC, 0x0F, 0xE0, 0x81, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07,
  0xFF, 0xE3, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xFF, 0xF3, 0xFF, 0xFE, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0x30, 0x00, 0x01,
  0xFF, 0x07, 0xC1, 0xFF, 0xE3, 0xE1, 0xFF, 0xF9, 0xF1, 0xFF, 0xFE, 0xF9,
  0xFF, 0xFF, 0xFC, 0xFF, 0x03, 0xFE, 0xFF, 0x00, 0xFF, 0x7F, 0x00, 0x7F,
  0xBF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01,
  0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00,
  0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE,
  0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xDF, 0x80, 0x0F, 0xEF, 0xE0, 0x07, 0xF7,
  0xF0, 0x07, 0xF9, 0xFE, 0x07, 0xFC, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xBF,
  0x0F, 0xFF, 0xDF, 0x83, 0xFF, 0xCF, 0xC0, 0xFF, 0x87, 0xE0, 0x07, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xD0, 0x00, 0x1F, 0xC6, 0x00,
  0x1F, 0xE3, 0xF0, 0x3F, 0xE1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x07, 0x00, 0xFC, 0x3F, 0xF0, 0xFC, 0x7F, 0xF8, 0xFC, 0xFF, 0xFC,
  0xFD, 0xFF, 0xFE, 0xFD, 0xFF, 0xFE, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0x39, 0xFB, 0xFF,
  0xFF, 0xFF, 0xDF, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0xE0, 0x1F, 0x80, 0xFE, 0x07, 0xF0, 0x3F, 0x81,
  0xFC, 0x07, 0xC0, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0,
  0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0,
  0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x0F, 0xC0, 0xFE, 0x8F, 0xF7,
  0xFF, 0xBF, 0xF9, 0xFF, 0x8F, 0xF8, 0x7F, 0x80, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x01, 0xFD, 0xFC, 0x00, 0xFC, 0xFE, 0x00,
  0xFE, 0x7F, 0x00, 0xFE, 0x3F, 0x80, 0xFE, 0x1F, 0xC0, 0x7E, 0x0F, 0xE0,
  0x7F, 0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x3F, 0x01, 0xFC, 0x3F, 0x00, 0xFE,
  0x3F, 0x80, 0x7F, 0x3F, 0x80, 0x3F, 0x1F, 0x80, 0x1F, 0x9F, 0x80, 0x0F,
  0xCF, 0xE0, 0x07, 0xEF, 0xF0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x80, 0x7F, 0xCF, 0xC0, 0x3F, 0xC7, 0xF0, 0x1F, 0xC1, 0xF8,
  0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x3F, 0x03, 0xF8, 0x1F, 0xC1, 0xFC, 0x07,
  0xF0, 0xFE, 0x03, 0xF8, 0x7F, 0x00, 0xFE, 0x3F, 0x80, 0x7F, 0x1F, 0xC0,
  0x1F, 0xCF, 0xE0, 0x0F, 0xE7, 0xF0, 0x03, 0xFB, 0xF8, 0x01, 0xFD, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x7C, 0x1F, 0xF0, 0x0F, 0xF8, 0x3F, 0x1F, 0xFE, 0x1F, 0xFF, 0x1F,
  0x9F, 0xFF, 0x1F, 0xFF, 0xCF, 0xDF, 0xFF, 0xCF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0x07, 0xFF, 0x83, 0xFD, 0xFF, 0x01, 0xFF, 0x80,
  0xFE, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xFF,
  0x80, 0x1F, 0xC0, 0x0F, 0xFF, 0xC0, 0x0F, 0xE0, 0x07, 0xFF, 0xE0, 0x07,
  0xF0, 0x03, 0xFF, 0xF0, 0x03, 0xF8, 0x01, 0xFF, 0xF8, 0x01, 0xFC, 0x00,
  0xFF, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xFF,
  0x00, 0x3F, 0x80, 0x1F, 0xFF, 0x80, 0x1F, 0xC0, 0x0F, 0xFF, 0xC0, 0x0F,
  0xE0, 0x07, 0xFF, 0xE0, 0x07, 0xF0, 0x03, 0xFF, 0xF0, 0x03, 0xF8, 0x01,
  0xFF, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0x80, 0x1F, 0xFF, 0x80, 0x1F,
  0xC0, 0x0F, 0xFF, 0xC0, 0x0F, 0xE0, 0x07, 0xFF, 0xE0, 0x07, 0xF0, 0x03,
  0xFF, 0xF0, 0x03, 0xF8, 0x01, 0xFF, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xFF, 0x00, 0x3F,
  0x80, 0x1F, 0xFF, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0x07, 0x80, 0xF8,
  0x3F, 0xF0, 0xFC, 0x7F, 0xF8, 0xFC, 0xFF, 0xFC, 0xFD, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x7F, 0xFF,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0x00, 0x1E, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x83, 0xFC, 0x0F, 0xE0, 0xFE, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x1F, 0x80,
  0x0F, 0xE7, 0xE0, 0x01, 0xFB, 0xF8, 0x00, 0x7E, 0xFE, 0x00, 0x1F, 0xFF,
  0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE,
  0x00, 0x1F, 0x9F, 0x80, 0x07, 0xE7, 0xE0, 0x03, 0xF9, 0xFC, 0x00, 0xFC,
  0x3F, 0x80, 0x7F, 0x0F, 0xF0, 0x3F, 0xC1, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xF0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x07, 0x00, 0x3E, 0x0F, 0xFC, 0x0F, 0xC7, 0xFF, 0x83,
  0xF3, 0xFF, 0xF0, 0xFD, 0xFF, 0xFE, 0x3F, 0x7F, 0xFF, 0x8F, 0xFC, 0x0F,
  0xF3, 0xFE, 0x01, 0xFC, 0xFF, 0x00, 0x3F, 0xBF, 0xC0, 0x0F, 0xEF, 0xE0,
  0x01, 0xFB, 0xF8, 0x00, 0x7E, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF,
  0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07,
  0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7E, 0xFE, 0x00, 0x1F, 0xBF,
  0x80, 0x07, 0xEF, 0xF0, 0x03, 0xFB, 0xFC, 0x00, 0xFE, 0xFF, 0x80, 0x7F,
  0x3F, 0xF0, 0x3F, 0xCF, 0xFF, 0xFF, 0xE3, 0xF7, 0xFF, 0xF8, 0xFC, 0xFF,
  0xFC, 0x3F, 0x1F, 0xFE, 0x0F, 0xC3, 0xFE, 0x03, 0xF8, 0x1E, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xFF, 0x07, 0xC1, 0xFF, 0xE3, 0xE1, 0xFF, 0xF9, 0xF1, 0xFF, 0xFE,
  0xF9, 0xFF, 0xFF, 0xFC, 0xFF, 0x03, 0xFE, 0xFF, 0x00, 0xFF, 0x7F, 0x00,
  0x7F, 0xBF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0,
  0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC,
  0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x3F,
  0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xDF, 0x80, 0x0F, 0xEF, 0xE0, 0x07,
  0xF7, 0xF0, 0x07, 0xF9, 0xFE, 0x07, 0xFC, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xBF, 0x0F, 0xFF, 0xDF, 0x83, 0xFF, 0xCF, 0xC0, 0xFF, 0x87, 0xE0, 0x07,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0x7C, 0x1F, 0xFE, 0x1F, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0xF1, 0xFF, 0xFF, 0x3F,
  0xFF, 0xE7, 0xFE, 0xFE, 0x7F, 0x00, 0xEF, 0xE0, 0x02, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xE0, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0x80, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xC0,
  0x03, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF,
  0xFF, 0xF8, 0x3F, 0xFE, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x1F, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFE, 0x00, 0x7F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0x80, 0xFF,
  0xC0, 0x0E, 0x00, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF,
  0x7F, 0x00, 0xFF, 0x7F, 0x83, 0xFF, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xDF,
  0x1F, 0xFF, 0x9F, 0x1F, 0xFF, 0x1F, 0x07, 0xFC, 0x1F, 0x00, 0x60, 0x00,
  0xFE, 0x00, 0x0F, 0xEF, 0xC0, 0x01, 0xFD, 0xF8, 0x00, 0x3F, 0x3F, 0x80,
  0x07, 0xE3, 0xF0, 0x01, 0xFC, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE1,
  0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x83, 0xF0, 0x07, 0xE0, 0x7E, 0x00,
  0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x03,
  0xF0, 0x1F, 0x80, 0x3F, 0x07, 0xF0, 0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x1F,
  0x80, 0x0F, 0x83, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x1F, 0x80, 0x07,
  0xE3, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0xDF, 0x80, 0x01, 0xFB, 0xF0,
  0x00, 0x1F, 0x7E, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7D, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0xC0,
  0x1F, 0xF0, 0x07, 0xF7, 0xE0, 0x0F, 0xF8, 0x03, 0xF3, 0xF0, 0x07, 0xFC,
  0x01, 0xF9, 0xF8, 0x07, 0xDE, 0x00, 0xFC, 0xFC, 0x03, 0xEF, 0x80, 0x7E,
  0x3F, 0x01, 0xF7, 0xC0, 0x7E, 0x1F, 0x80, 0xFB, 0xE0, 0x3F, 0x0F, 0xC0,
  0x7D, 0xF0, 0x1F, 0x87, 0xE0, 0x7C, 0x7C, 0x0F, 0xC3, 0xF8, 0x3E, 0x3E,
  0x0F, 0xC0, 0xFC, 0x1F, 0x1F, 0x07, 0xE0, 0x7E, 0x0F, 0x8F, 0x83, 0xF0,
  0x3F, 0x0F, 0xC7, 0xC1, 0xF8, 0x1F, 0x87, 0xC3, 0xF0, 0xF8, 0x07, 0xE3,
  0xE0, 0xF8, 0xFC, 0x03, 0xF1, 0xF0, 0x7C, 0x7E, 0x01, 0xF8, 0xF8, 0x3E,
  0x3F, 0x00, 0xFC, 0xF8, 0x1F, 0x1F, 0x00, 0x3E, 0x7C, 0x07, 0xCF, 0x80,
  0x1F, 0x3E, 0x03, 0xEF, 0xC0, 0x0F, 0xDF, 0x01, 0xF7, 0xE0, 0x07, 0xEF,
  0x80, 0xFB, 0xE0, 0x01, 0xF7, 0x80, 0x7D, 0xF0, 0x00, 0xFF, 0xC0, 0x1E,
  0xF8, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00,
  0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x3F, 0x9F, 0xC0, 0x0F, 0xC3, 0xF0, 0x07, 0xF0,
  0xFE, 0x01, 0xF8, 0x1F, 0x80, 0xFE, 0x07, 0xF0, 0x3F, 0x00, 0xFC, 0x1F,
  0xC0, 0x3F, 0x87, 0xE0, 0x07, 0xE3, 0xF8, 0x01, 0xFC, 0xFC, 0x00, 0x3F,
  0x7F, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF,
  0xF8, 0x00, 0x3F, 0x7F, 0x00, 0x1F, 0xCF, 0xC0, 0x07, 0xE3, 0xF8, 0x03,
  0xF8, 0x7E, 0x00, 0xFC, 0x1F, 0xC0, 0x7F, 0x03, 0xF0, 0x1F, 0x80, 0xFE,
  0x0F, 0xE0, 0x1F, 0x83, 0xF0, 0x07, 0xF1, 0xFC, 0x00, 0xFC, 0x7E, 0x00,
  0x3F, 0xBF, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xEF, 0xC0, 0x01, 0xFD,
  0xF8, 0x00, 0x3F, 0x3F, 0x80, 0x07, 0xE3, 0xF0, 0x01, 0xFC, 0x7E, 0x00,
  0x3F, 0x0F, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x83,
  0xF0, 0x07, 0xE0, 0x7F, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x1F, 0x80, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x3F, 0x07, 0xF0, 0x07,
  0xE0, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0xFC,
  0x00, 0x1F, 0x1F, 0x80, 0x03, 0xF3, 0xF0, 0x00, 0x7E, 0x7C, 0x00, 0x07,
  0xDF, 0x80, 0x00, 0xFB, 0xF0, 0x00, 0x1F, 0x7E, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x21, 0xFE, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xE0, 0x03, 0xFC, 0x01, 0xFF, 0x80,
  0x7F, 0xF0, 0x0F, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x1F, 0xFC, 0x03, 0xFE, 0x00, 0x7E, 0x00, 0x0F, 0xF8,
  0x01, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xFC,
  0x00, 0x3F, 0xC0, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x3F,
  0xC0, 0x01, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFC, 0x00, 0x1F, 0xE0, 0x03,
  0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0x80,
  0x03, 0xF0, 0x03, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0x80, 0x0F, 0xE0, 0x01,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x07, 0xF0, 0x01, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFC,
  0x01, 0xFE, 0x00, 0x3F, 0x00, 0x00, 0x02, 0x00, 0x00, 0x47, 0xFC, 0x00,
  0x17, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFC, 0x80, 0x01, 0xFE, 0x00,
};

const GFXglyph NotoSans_Condensed_Medium63pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 8, 46, 16, 4, -45 },
  { 47, 18, 16, 26, 4, -45 },
  { 83, 31, 45, 33, 1, -45 },
  { 258, 24, 52, 30, 3, -48 },
  { 414, 42, 47, 47, 2, -46 },
  { 661, 34, 47, 36, 2, -46 },
  { 861, 6, 16, 14, 4, -45 },
  { 873, 14, 55, 19, 3, -45 },
  { 970, 14, 55, 19, 2, -45 },
  { 1067, 24, 24, 28, 2, -48 },
  { 1139, 26, 30, 30, 2, -37 },
  { 1237, 10, 15, 15, 2, -7 },
  { 1256, 15, 6, 19, 2, -20 },
  { 1268, 8, 9, 16, 4, -8 },
  { 1277, 22, 45, 24, 1, -45 },
  { 1401, 25, 47, 30, 3, -46 },
  { 1548, 17, 45, 30, 4, -45 },
  { 1644, 25, 46, 30, 2, -46 },
  { 1788, 25, 47, 30, 2, -46 },
  { 1935, 28, 45, 30, 1, -45 },
  { 2093, 24, 46, 30, 3, -45 },
  { 2231, 25, 47, 30, 3, -46 },
  { 2378, 26, 45, 30, 2, -45 },
  { 2525, 26, 47, 30, 2, -46 },
  { 2678, 25, 47, 30, 2, -46 },
  { 2825, 8, 35, 16, 4, -34 },
  { 2860, 10, 42, 16, 2, -34 },
  { 2913, 26, 29, 30, 2, -37 },
  { 3008, 26, 18, 30, 2, -31 },
  { 3067, 26, 29, 30, 2, -37 },
  { 3162, 21, 47, 23, 1, -46 },
  { 3286, 41, 50, 47, 3, -45 },
  { 3543, 33, 45, 33, 0, -45 },
  { 3729, 26, 45, 34, 5, -45 },
  { 3876, 27, 47, 32, 3, -46 },
  { 4035, 29, 45, 37, 5, -45 },
  { 4199, 21, 45, 29, 5, -45 },
  { 4318, 21, 45, 27, 5, -45 },
  { 4437, 31, 47, 38, 3, -46 },
  { 4620, 28, 45, 38, 5, -45 },
  { 4778, 15, 45, 20, 2, -45 },
  { 4863, 15, 57, 16, -4, -45 },
  { 4970, 28, 45, 33, 5, -45 },
  { 5128, 21, 45, 27, 5, -45 },
  { 5247, 40, 45, 50, 5, -45 },
  { 5472, 31, 45, 41, 5, -45 },
  { 5647, 33, 47, 40, 3, -46 },
  { 5841, 24, 45, 32, 5, -45 },
  { 5976, 33, 57, 40, 3, -46 },
  { 6212, 27, 45, 33, 5, -45 },
  { 6364, 23, 47, 29, 3, -46 },
  { 6500, 26, 45, 28, 1, -45 },
  { 6647, 28, 46, 38, 5, -45 },
  { 6808, 32, 45, 32, 0, -45 },
  { 6988, 50, 45, 50, 0, -45 },
  { 7270, 30, 45, 30, 0, -45 },
  { 7439, 29, 45, 29, 0, -45 },
  { 7603, 24, 45, 27, 2, -45 },
  { 7738, 14, 55, 20, 4, -45 },
  { 7835, 22, 45, 24, 1, -45 },
  { 7959, 14, 55, 20, 2, -45 },
  { 8056, 29, 26, 31, 1, -45 },
  { 8151, 27, 5, 27, 0, 5 },
  { 8168, 13, 10, 18, 3, -48 },
  { 8185, 24, 36, 30, 2, -35 },
  { 8293, 26, 49, 33, 4, -48 },
  { 8453, 21, 36, 25, 3, -35 },
  { 8548, 25, 49, 33, 3, -48 },
  { 8702, 24, 36, 30, 3, -35 },
  { 8810, 19, 48, 19, 1, -48 },
  { 8924, 25, 50, 33, 3, -35 },
  { 9081, 24, 48, 33, 4, -48 },
  { 9225, 7, 47, 15, 4, -47 },
  { 9267, 13, 62, 15, -2, -47 },
  { 9368, 25, 48, 29, 4, -48 },
  { 9518, 7, 48, 15, 4, -48 },
  { 9560, 41, 35, 49, 4, -35 },
  { 9740, 24, 35, 33, 4, -35 },
  { 9845, 26, 36, 32, 3, -35 },
  { 9962, 26, 50, 33, 4, -35 },
  { 10125, 25, 50, 33, 3, -35 },
  { 10282, 17, 35, 22, 4, -35 },
  { 10357, 20, 36, 25, 2, -35 },
  { 10447, 17, 43, 20, 1, -42 },
  { 10539, 24, 35, 33, 4, -34 },
  { 10644, 27, 34, 27, 0, -34 },
  { 10759, 41, 34, 43, 1, -34 },
  { 10934, 26, 34, 27, 1, -34 },
  { 11045, 27, 49, 27, 0, -34 },
  { 11211, 20, 34, 23, 2, -34 },
  { 11296, 19, 55, 23, 2, -45 },
  { 11427, 5, 63, 29, 12, -48 },
  { 11467, 19, 55, 23, 2, -45 },
  { 11598, 26, 9, 30, 2, -27 },
};

const GFXfont NotoSans_Condensed_Medium63pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Medium63pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Medium63pt7bGlyphs,
  0x20, 0x7E, 86
};

#endif // _NOTOSANS_CONDENSED_MEDIUM63PT7B_H_
