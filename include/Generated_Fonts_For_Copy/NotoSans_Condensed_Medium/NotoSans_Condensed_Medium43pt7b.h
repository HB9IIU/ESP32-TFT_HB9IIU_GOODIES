#ifndef _NOTOSANS_CONDENSED_MEDIUM43PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUM43PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Medium.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Medium43pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xEF, 0x7B, 0xCE, 0x73,
  0x9C, 0xE7, 0x38, 0x00, 0x01, 0x3F, 0xFF, 0xFF, 0xE0, 0xF8, 0xFB, 0xC7,
  0xDE, 0x1E, 0xF0, 0xF7, 0x87, 0xBC, 0x3D, 0xE1, 0xEF, 0x0F, 0x78, 0x7B,
  0xC3, 0x9C, 0x1C, 0x01, 0xC1, 0xC0, 0x0E, 0x0E, 0x00, 0x70, 0xF0, 0x03,
  0x87, 0x00, 0x3C, 0x38, 0x01, 0xE1, 0xC0, 0x0E, 0x0E, 0x00, 0x70, 0x70,
  0x03, 0x83, 0x83, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF0, 0x78,
  0x70, 0x03, 0x83, 0x80, 0x1C, 0x1C, 0x00, 0xE1, 0xE0, 0x07, 0x0F, 0x00,
  0x38, 0x70, 0x03, 0xC3, 0x81, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xF8, 0x38, 0x78, 0x01, 0xC3, 0xC0, 0x0E, 0x1C, 0x00, 0xF0, 0xE0, 0x07,
  0x87, 0x00, 0x38, 0x38, 0x01, 0xC1, 0xC0, 0x0E, 0x1E, 0x00, 0x70, 0xE0,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0xFF, 0xC0,
  0xFF, 0xF8, 0xFF, 0xFC, 0xFF, 0x7C, 0xF9, 0x82, 0x78, 0xC0, 0x3C, 0x60,
  0x1E, 0x30, 0x0F, 0x18, 0x07, 0xCC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x19, 0xF0, 0x0C, 0x78,
  0x06, 0x1E, 0x03, 0x0F, 0x01, 0x87, 0xC0, 0xC7, 0xB8, 0x67, 0xDF, 0xFF,
  0xCF, 0xFF, 0xE7, 0xFF, 0xC0, 0x3F, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x1F, 0x00, 0x1C, 0x03, 0xF8, 0x03,
  0xC0, 0x7F, 0xC0, 0x38, 0x07, 0x1C, 0x07, 0x80, 0xF1, 0xE0, 0x70, 0x0E,
  0x1E, 0x0F, 0x00, 0xE0, 0xE0, 0xF0, 0x0E, 0x0E, 0x0E, 0x00, 0xE0, 0xE1,
  0xE0, 0x0E, 0x0E, 0x1C, 0x00, 0xE0, 0xE3, 0xC0, 0x0E, 0x0E, 0x38, 0x00,
  0xE1, 0xE3, 0x87, 0x0E, 0x1E, 0x79, 0xFC, 0xF1, 0xC7, 0x3F, 0xE7, 0x1C,
  0xF3, 0xDE, 0x7F, 0xCE, 0x78, 0xF3, 0xF9, 0xE7, 0x8F, 0x1F, 0x1C, 0x70,
  0x70, 0x01, 0xC7, 0x07, 0x00, 0x3C, 0x70, 0x70, 0x03, 0x87, 0x07, 0x00,
  0x78, 0x70, 0x70, 0x07, 0x07, 0x07, 0x00, 0xF0, 0x70, 0x70, 0x0F, 0x07,
  0x8F, 0x00, 0xE0, 0x78, 0xF0, 0x1E, 0x03, 0x8E, 0x01, 0xC0, 0x3F, 0xE0,
  0x3C, 0x01, 0xFC, 0x03, 0x80, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xFE, 0x00, 0x1F, 0x3E, 0x00, 0x1E, 0x1F, 0x00, 0x1E, 0x0F,
  0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x1F, 0x00, 0x1E, 0x1E,
  0x00, 0x0F, 0x3E, 0x00, 0x0F, 0x3C, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x3C, 0x3E, 0xF8,
  0x3C, 0x7C, 0x7C, 0x7C, 0x7C, 0x3E, 0x78, 0x78, 0x3E, 0x78, 0x78, 0x1F,
  0xF8, 0xF8, 0x0F, 0xF0, 0xF8, 0x07, 0xF0, 0x78, 0x07, 0xE0, 0x78, 0x07,
  0xE0, 0x7C, 0x0F, 0xF0, 0x7F, 0x3F, 0xF8, 0x3F, 0xFF, 0x7C, 0x1F, 0xFE,
  0x7C, 0x0F, 0xF8, 0x3F, 0xFB, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDC, 0x03,
  0xC1, 0xE0, 0xF0, 0x3C, 0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x3C, 0x1E, 0x07,
  0x81, 0xE0, 0x78, 0x3E, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF8, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x0F,
  0x03, 0xC0, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0xF0,
  0x1E, 0x03, 0x80, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x3C, 0x0F, 0x01, 0xE0,
  0x78, 0x1E, 0x07, 0x81, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x07, 0xC1, 0xE0, 0x78, 0x1E, 0x07, 0x83,
  0xC0, 0xF0, 0x7C, 0x1E, 0x07, 0x83, 0xC0, 0xE0, 0x78, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x03, 0x0E, 0x19,
  0xFF, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xF0, 0x01, 0xFC, 0x00, 0xEF,
  0x00, 0xF7, 0x80, 0xF1, 0xE0, 0xF8, 0xF8, 0x18, 0x38, 0x04, 0x10, 0x00,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x7D, 0xF7, 0xDE,
  0x79, 0xEF, 0x3C, 0xF3, 0x8E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x27,
  0xFF, 0xFF, 0xF8, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80,
  0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0xE0, 0x07, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0x87, 0xC3,
  0xE3, 0xE0, 0xF1, 0xE0, 0x7D, 0xF0, 0x1E, 0xF8, 0x0F, 0x78, 0x07, 0xBC,
  0x03, 0xDE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F,
  0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0x7B, 0xE0, 0x3D, 0xF0, 0x1E, 0x78, 0x1F, 0x3C, 0x0F, 0x9F, 0x07, 0x87,
  0xEF, 0xC3, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0xC0, 0x01, 0xE0, 0x7C, 0x1F,
  0x87, 0xF1, 0xFE, 0x7F, 0xDF, 0x7F, 0xCF, 0x71, 0xE4, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0xE0, 0x1F, 0xFC, 0x1F, 0xFF, 0x1F, 0xFF, 0xC7,
  0x03, 0xE3, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1E, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xE0, 0x3F,
  0xFC, 0x3F, 0xFF, 0x1F, 0xFF, 0xC7, 0x03, 0xE2, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x07,
  0xC0, 0xFF, 0xC0, 0x7F, 0x80, 0x3F, 0xE0, 0x1F, 0xFC, 0x00, 0x3F, 0x00,
  0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x00, 0x0F, 0xA0, 0x0F, 0xDF, 0x1F, 0xCF, 0xFF, 0xE7, 0xFF,
  0xC1, 0xFF, 0xC0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0E, 0xF0, 0x01, 0xDE,
  0x00, 0x73, 0xC0, 0x1E, 0x78, 0x03, 0x8F, 0x00, 0xF1, 0xE0, 0x1C, 0x3C,
  0x07, 0x87, 0x80, 0xE0, 0xF0, 0x3C, 0x1E, 0x07, 0x03, 0xC1, 0xE0, 0x78,
  0x38, 0x0F, 0x0F, 0x01, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x3F, 0xFE, 0x1F, 0xFF, 0x1F, 0xFF, 0x8F,
  0xFF, 0xC7, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0xFF, 0x03, 0xFF, 0xC1, 0xFF,
  0xF0, 0xFF, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F,
  0xA0, 0x0F, 0x9F, 0x1F, 0xCF, 0xFF, 0xC7, 0xFF, 0xC1, 0xFF, 0x80, 0x00,
  0xFE, 0x01, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0xC1, 0xF0, 0x01, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x08,
  0x0F, 0x3F, 0x87, 0xBF, 0xF3, 0xFF, 0xF9, 0xFC, 0x7E, 0xFC, 0x1F, 0x7C,
  0x07, 0xBC, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F,
  0xF0, 0x1F, 0x78, 0x0F, 0xBC, 0x07, 0x9F, 0x07, 0xC7, 0xCF, 0xC1, 0xFF,
  0xE0, 0xFF, 0xE0, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0xCF, 0xC7,
  0x81, 0xF7, 0xC0, 0x7B, 0xE0, 0x3D, 0xF0, 0x1E, 0xF8, 0x0F, 0x3C, 0x07,
  0x9E, 0x07, 0xC7, 0x87, 0xC3, 0xF7, 0xC0, 0xFF, 0xC0, 0x3F, 0xC0, 0x1F,
  0xE0, 0x1F, 0xFC, 0x1F, 0x3F, 0x1F, 0x0F, 0xDF, 0x03, 0xEF, 0x00, 0xFF,
  0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xFE, 0x03,
  0xDF, 0x87, 0xE7, 0xFF, 0xE1, 0xFF, 0xE0, 0x3F, 0xE0, 0x07, 0xE0, 0x0F,
  0xFC, 0x0F, 0xFF, 0x0F, 0xFF, 0x87, 0xC3, 0xE7, 0xC0, 0xF3, 0xC0, 0x7D,
  0xE0, 0x1E, 0xF0, 0x0F, 0x78, 0x07, 0xBC, 0x03, 0xFE, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x7F, 0xE0, 0x7E, 0xF8, 0x7F, 0x7F, 0xF7, 0x9F, 0xFF, 0x87,
  0xFB, 0xC1, 0xF1, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x08, 0x3F, 0x07, 0xFF, 0x83, 0xFF,
  0x01, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xB0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0x3F, 0xFF, 0xFF, 0xC0, 0x3E, 0x7C, 0xF9, 0xF3, 0xE3, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF9, 0xF3,
  0xE7, 0x8F, 0x1E, 0x78, 0xF1, 0xE3, 0x8F, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0xF0, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00,
  0xF0, 0x00, 0x0C, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x00, 0x3C, 0x00, 0x0F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFE,
  0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x3E, 0x00, 0x0E,
  0x00, 0x02, 0x00, 0x00, 0x0F, 0xE0, 0xFF, 0xF3, 0xFF, 0xF3, 0xFF, 0xE3,
  0x03, 0xE0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00,
  0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF,
  0xFC, 0x00, 0x3E, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0xF0, 0x00, 0x78,
  0x1E, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x1C, 0x3C, 0x03, 0x81, 0xE3, 0x81,
  0xFF, 0x0E, 0x78, 0x3F, 0xF0, 0xE7, 0x07, 0x87, 0x0E, 0x70, 0xF0, 0xF0,
  0xFF, 0x0F, 0x0F, 0x0F, 0xF0, 0xE0, 0xF0, 0xFF, 0x0E, 0x0F, 0x0F, 0xE1,
  0xE0, 0xF0, 0xFE, 0x1E, 0x0F, 0x0F, 0xE1, 0xE0, 0xF0, 0xFF, 0x1E, 0x0F,
  0x0E, 0xE0, 0xE0, 0xF0, 0xEF, 0x0E, 0x1F, 0x0E, 0xF0, 0xF1, 0xB1, 0xEF,
  0x0F, 0xFB, 0xFC, 0x70, 0x7F, 0x3F, 0x87, 0x83, 0xE1, 0xF0, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x08, 0x00, 0x7F, 0x0F, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x16, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3D, 0xC0, 0x00,
  0x7B, 0xC0, 0x00, 0xF7, 0x80, 0x03, 0xCF, 0x00, 0x07, 0x9F, 0x00, 0x0F,
  0x1E, 0x00, 0x3E, 0x3C, 0x00, 0x78, 0x78, 0x00, 0xF0, 0xF8, 0x01, 0xE0,
  0xF0, 0x07, 0xC1, 0xE0, 0x0F, 0x03, 0xE0, 0x1E, 0x07, 0xC0, 0x3F, 0xFF,
  0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x0F, 0x80, 0x3C,
  0x1F, 0x00, 0x7C, 0x3C, 0x00, 0xF8, 0x78, 0x01, 0xF1, 0xF0, 0x01, 0xE3,
  0xE0, 0x03, 0xE7, 0x80, 0x07, 0xDF, 0x00, 0x07, 0xBE, 0x00, 0x0F, 0x80,
  0xFF, 0xC0, 0x3F, 0xFF, 0x0F, 0xFF, 0xF3, 0xFF, 0xFE, 0xF8, 0x1F, 0xBE,
  0x03, 0xEF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7B, 0xE0, 0x3E, 0xF8, 0x1F, 0x3F, 0xFF, 0x8F, 0xFF, 0xC3, 0xFF, 0xF8,
  0xFF, 0xFF, 0x3E, 0x03, 0xEF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x03, 0xFE,
  0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0x3F, 0xFF, 0x8F, 0xFF, 0x80, 0x00, 0xFF,
  0x00, 0x7F, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xE1, 0xF8, 0x0C, 0x7E, 0x00,
  0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x01, 0x0F, 0xFB, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0xE0,
  0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xF8, 0x3F,
  0x8F, 0x80, 0xFC, 0xF8, 0x07, 0xCF, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1E, 0xF8, 0x03, 0xEF, 0x80, 0x3E,
  0xF8, 0x07, 0xCF, 0x80, 0xFC, 0xF8, 0x1F, 0x8F, 0xFF, 0xF0, 0xFF, 0xFE,
  0x0F, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x0F,
  0xFF, 0x81, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xFC, 0x07, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x3F, 0xFF,
  0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0xF7, 0x80, 0x07, 0xBE, 0x00, 0x3D, 0xF0, 0x01, 0xEF, 0x80, 0x0F, 0x3E,
  0x00, 0x79, 0xF8, 0x03, 0xC7, 0xE0, 0x1E, 0x1F, 0xE7, 0xF0, 0xFF, 0xFF,
  0x81, 0xFF, 0xFC, 0x07, 0xFF, 0x80, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xC1, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x87, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x78, 0x1F, 0x6F, 0xEF, 0xF9, 0xFF, 0x3F,
  0xC0, 0x80, 0xF8, 0x03, 0xFF, 0x00, 0xFB, 0xE0, 0x1F, 0x7C, 0x07, 0xCF,
  0x80, 0xF1, 0xF0, 0x3E, 0x3E, 0x0F, 0x87, 0xC1, 0xE0, 0xF8, 0x7C, 0x1F,
  0x1F, 0x03, 0xE3, 0xC0, 0x7C, 0xF8, 0x0F, 0xBE, 0x01, 0xF7, 0x80, 0x3F,
  0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xF3, 0xE0, 0x7C,
  0x7C, 0x0F, 0x87, 0xC1, 0xF0, 0xF8, 0x3E, 0x0F, 0x87, 0xC1, 0xF0, 0xF8,
  0x1F, 0x1F, 0x01, 0xE3, 0xE0, 0x3E, 0x7C, 0x03, 0xCF, 0x80, 0x7D, 0xF0,
  0x07, 0xFE, 0x00, 0xF8, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0xF7, 0x00, 0x0E, 0xFF, 0x78, 0x01, 0xFF, 0xF7, 0x80, 0x1F, 0xFF, 0x78,
  0x01, 0xDF, 0xF3, 0xC0, 0x3D, 0xFF, 0x3C, 0x03, 0xDF, 0xF3, 0xC0, 0x39,
  0xFF, 0x1E, 0x07, 0x9F, 0xF1, 0xE0, 0x79, 0xFF, 0x1E, 0x07, 0x1F, 0xF0,
  0xE0, 0xF1, 0xFF, 0x0F, 0x0F, 0x1F, 0xF0, 0xF0, 0xF1, 0xFF, 0x0F, 0x0E,
  0x1F, 0xF0, 0x79, 0xE1, 0xFF, 0x07, 0x9E, 0x1F, 0xF0, 0x79, 0xC1, 0xFF,
  0x03, 0xFC, 0x1F, 0xF0, 0x3F, 0xC1, 0xFF, 0x03, 0xF8, 0x1F, 0xF0, 0x1F,
  0x81, 0xFF, 0x01, 0xF8, 0x1F, 0xF0, 0x1F, 0x01, 0xFF, 0x01, 0xF0, 0x1F,
  0xF0, 0x0F, 0x01, 0xF0, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x1F,
  0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x01, 0xFE, 0xF0,
  0x0F, 0xF7, 0xC0, 0x7F, 0x9E, 0x03, 0xFC, 0xF8, 0x1F, 0xE3, 0xC0, 0xFF,
  0x1F, 0x07, 0xF8, 0x78, 0x3F, 0xC3, 0xE1, 0xFE, 0x0F, 0x0F, 0xF0, 0x7C,
  0x7F, 0x81, 0xE3, 0xFC, 0x0F, 0x9F, 0xE0, 0x7C, 0xFF, 0x01, 0xF7, 0xF8,
  0x0F, 0xBF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F,
  0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0,
  0x03, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xFF,
  0xFF, 0x81, 0xF8, 0x1F, 0x07, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x3E, 0x00,
  0x3E, 0x7C, 0x00, 0x7C, 0xF0, 0x00, 0x79, 0xE0, 0x00, 0xF7, 0xC0, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xF7,
  0x80, 0x03, 0xCF, 0x00, 0x07, 0x9F, 0x00, 0x1F, 0x3E, 0x00, 0x3E, 0x3E,
  0x00, 0x78, 0x7C, 0x01, 0xF0, 0x7C, 0x07, 0xC0, 0xFF, 0x7F, 0x80, 0xFF,
  0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x7F, 0xFC,
  0x3F, 0xFF, 0x9F, 0xFF, 0xCF, 0x83, 0xF7, 0xC0, 0xFB, 0xE0, 0x3F, 0xF0,
  0x1F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0x7F, 0xE0, 0x7D, 0xF3, 0xFE, 0xFF, 0xFE, 0x7F, 0xFE, 0x3F, 0xFC,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFF,
  0xFF, 0x81, 0xF8, 0x1F, 0x07, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x3E, 0x00,
  0x3E, 0x7C, 0x00, 0x7C, 0xF0, 0x00, 0x79, 0xE0, 0x00, 0xF7, 0xC0, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xF7,
  0x80, 0x03, 0xEF, 0x00, 0x07, 0x9F, 0x00, 0x1F, 0x3E, 0x00, 0x3E, 0x3E,
  0x00, 0x78, 0x7C, 0x01, 0xF0, 0x7C, 0x07, 0xC0, 0xFF, 0x7F, 0x80, 0xFF,
  0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0xFF, 0xC0, 0x1F, 0xFF, 0x03, 0xFF, 0xF8, 0x7F,
  0xFF, 0x8F, 0x83, 0xF1, 0xF0, 0x3F, 0x3E, 0x03, 0xE7, 0xC0, 0x7C, 0xF8,
  0x07, 0x9F, 0x00, 0xF3, 0xE0, 0x1E, 0x7C, 0x07, 0xCF, 0x80, 0xF9, 0xF0,
  0x3E, 0x3E, 0x0F, 0xC7, 0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xFE, 0x03, 0xE3,
  0xE0, 0x7C, 0x3C, 0x0F, 0x87, 0xC1, 0xF0, 0x78, 0x3E, 0x0F, 0x87, 0xC0,
  0xF0, 0xF8, 0x1F, 0x1F, 0x01, 0xE3, 0xE0, 0x3E, 0x7C, 0x07, 0xCF, 0x80,
  0x7D, 0xF0, 0x0F, 0xBE, 0x00, 0xF8, 0x07, 0xF8, 0x1F, 0xFF, 0x3F, 0xFE,
  0x7F, 0xFE, 0x7C, 0x0E, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x1F, 0xE0,
  0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x3E,
  0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0x7F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xEF, 0x80, 0x1E, 0xF8, 0x01, 0xE7, 0xC0, 0x3E, 0x7C,
  0x07, 0xE3, 0xFF, 0xFC, 0x3F, 0xFF, 0x81, 0xFF, 0xF0, 0x07, 0xFE, 0x00,
  0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xE7, 0x80, 0x07, 0x9E, 0x00, 0x3E, 0x7C,
  0x00, 0xF9, 0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x0F, 0x00, 0x7C, 0x3E, 0x01,
  0xF0, 0x78, 0x07, 0x81, 0xE0, 0x1E, 0x07, 0x80, 0xF8, 0x1F, 0x03, 0xC0,
  0x3C, 0x0F, 0x00, 0xF0, 0x3C, 0x03, 0xC1, 0xF0, 0x0F, 0x87, 0x80, 0x1E,
  0x1E, 0x00, 0x78, 0x78, 0x01, 0xE3, 0xC0, 0x03, 0xCF, 0x00, 0x0F, 0x3C,
  0x00, 0x3C, 0xF0, 0x00, 0xF7, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xFE, 0x00, 0x78, 0x01, 0xF7, 0x80,
  0x3F, 0x00, 0x79, 0xE0, 0x0F, 0xC0, 0x1E, 0x78, 0x03, 0xF0, 0x07, 0x9F,
  0x00, 0xFC, 0x03, 0xE7, 0xC0, 0x3F, 0x00, 0xF8, 0xF0, 0x1F, 0xE0, 0x3C,
  0x3C, 0x07, 0xF8, 0x0F, 0x0F, 0x01, 0xFE, 0x03, 0xC3, 0xE0, 0x73, 0x81,
  0xF0, 0x78, 0x3C, 0xF0, 0x78, 0x1E, 0x0F, 0x3C, 0x1E, 0x07, 0x83, 0xCF,
  0x07, 0x81, 0xE0, 0xE3, 0xC3, 0xE0, 0x7C, 0x78, 0x70, 0xF8, 0x0F, 0x1E,
  0x1E, 0x3C, 0x03, 0xC7, 0x87, 0x8F, 0x00, 0xF1, 0xE1, 0xE3, 0xC0, 0x3C,
  0x70, 0x39, 0xF0, 0x07, 0xBC, 0x0F, 0x78, 0x01, 0xEF, 0x03, 0xDE, 0x00,
  0x7B, 0xC0, 0xF7, 0x80, 0x1E, 0xF0, 0x1D, 0xE0, 0x07, 0xB8, 0x07, 0x78,
  0x00, 0xEE, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x0F, 0xE0, 0x1F,
  0xC0, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x01, 0xF7, 0xC0, 0x1E, 0x3E, 0x03, 0xE3, 0xE0, 0x3C,
  0x1E, 0x07, 0xC1, 0xF0, 0x78, 0x0F, 0x0F, 0x80, 0xF8, 0xF8, 0x07, 0x8F,
  0x00, 0x7D, 0xF0, 0x03, 0xDE, 0x00, 0x3F, 0xE0, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03,
  0xFC, 0x00, 0x3D, 0xE0, 0x07, 0xDE, 0x00, 0x79, 0xF0, 0x0F, 0x8F, 0x00,
  0xF0, 0xF8, 0x1F, 0x07, 0x81, 0xE0, 0x7C, 0x3E, 0x03, 0xC3, 0xC0, 0x3E,
  0x7C, 0x03, 0xE7, 0xC0, 0x1F, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0x78, 0x01, 0xE7, 0xC0, 0x3E, 0x3C, 0x03, 0xC3, 0xE0, 0x7C, 0x1E,
  0x07, 0x81, 0xE0, 0x78, 0x1F, 0x0F, 0x80, 0xF0, 0xF0, 0x0F, 0x8F, 0x00,
  0x79, 0xE0, 0x07, 0x9E, 0x00, 0x7F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xE0, 0x01,
  0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0,
  0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8,
  0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFC, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xBC, 0x00, 0x79, 0xC0, 0x0F, 0x1E,
  0x00, 0xF0, 0xE0, 0x0E, 0x0F, 0x01, 0xE0, 0xF0, 0x1C, 0x07, 0x83, 0xC0,
  0x78, 0x38, 0x03, 0xC7, 0x80, 0x3C, 0x78, 0x01, 0xEF, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0x7C, 0x1F, 0x07, 0xC1,
  0xE0, 0x78, 0x1E, 0x00, 0xC0, 0x1F, 0xF8, 0x7F, 0xFC, 0x3F, 0xFE, 0x38,
  0x3E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F, 0x07,
  0xFF, 0x3F, 0xFF, 0x7F, 0xFF, 0xFC, 0x1F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x3F, 0xF8, 0x7F, 0xFF, 0xEF, 0x7F,
  0xCF, 0x3F, 0x8F, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x30,
  0x3C, 0xFF, 0x1E, 0xFF, 0xCF, 0xFF, 0xE7, 0xF0, 0xFB, 0xF0, 0x3D, 0xF0,
  0x1F, 0xF8, 0x0F, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xFC, 0x03, 0xFE, 0x03,
  0xFF, 0x01, 0xFF, 0xC0, 0xF7, 0xF1, 0xFB, 0xFF, 0xF9, 0xEF, 0xF8, 0xE3,
  0xF8, 0x00, 0x00, 0xC0, 0x3F, 0xF1, 0xFF, 0xCF, 0xFF, 0x3E, 0x19, 0xF0,
  0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0x80, 0x1F,
  0x01, 0x3F, 0x1C, 0xFF, 0xF1, 0xFF, 0xC1, 0xFE, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x81, 0x83, 0xC3, 0xF9, 0xE3, 0xFE, 0xF3, 0xFF, 0xFB,
  0xF0, 0xFD, 0xF0, 0x3E, 0xF0, 0x1F, 0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xFC, 0x03, 0xFE, 0x01, 0xEF, 0x01, 0xF7, 0xC0, 0xFB, 0xF1, 0xFC,
  0xFF, 0xFE, 0x3F, 0xE7, 0x0F, 0xE3, 0x80, 0x00, 0x80, 0x07, 0xFC, 0x07,
  0xFF, 0x07, 0xFF, 0xC3, 0xC1, 0xE3, 0xC0, 0xF9, 0xE0, 0x3D, 0xF0, 0x1E,
  0xF0, 0x0F, 0x78, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x80, 0x23, 0xF0, 0x71, 0xFF, 0xF8, 0x7F, 0xFC, 0x0F, 0xF8, 0x01, 0xF8,
  0x0F, 0xF0, 0x7F, 0x83, 0xFE, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x03, 0xFF, 0x3F, 0xFC, 0xFF, 0xF0, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x03, 0x80, 0x07, 0xF1,
  0xC7, 0xFD, 0xE7, 0xFF, 0xF7, 0xE1, 0xFB, 0xE0, 0x7D, 0xE0, 0x3F, 0xF0,
  0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xDE, 0x03,
  0xEF, 0x81, 0xF7, 0xE3, 0xF9, 0xFF, 0xFC, 0x7F, 0xDE, 0x1F, 0xCF, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xFA, 0x00, 0xF9,
  0xF1, 0xFC, 0xFF, 0xFC, 0x7F, 0xFC, 0x1F, 0xF8, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x60, 0xF3, 0xFC, 0xF7, 0xFE, 0xFF, 0xFE, 0xFE,
  0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0xBF, 0xFE, 0xFE,
  0xFC, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x07,
  0xDE, 0x03, 0xCF, 0x03, 0xC7, 0x83, 0xE3, 0xC3, 0xE1, 0xE1, 0xE0, 0xF1,
  0xE0, 0x79, 0xF0, 0x3C, 0xF0, 0x1E, 0xF8, 0x0F, 0xFC, 0x07, 0xFF, 0x03,
  0xF7, 0x81, 0xF3, 0xE0, 0xF8, 0xF0, 0x78, 0x7C, 0x3C, 0x1E, 0x1E, 0x0F,
  0x8F, 0x03, 0xC7, 0x81, 0xF3, 0xC0, 0x7D, 0xE0, 0x3E, 0xF0, 0x0F, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x60, 0x0E, 0x1C, 0x7F, 0x0F, 0xF3,
  0xDF, 0xF3, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0xE3, 0xFC, 0x3F, 0xF0, 0x3F,
  0x03, 0xFE, 0x07, 0xE0, 0x7F, 0xC0, 0xF8, 0x0F, 0xF0, 0x0F, 0x01, 0xFE,
  0x01, 0xE0, 0x3F, 0xC0, 0x3C, 0x07, 0xF8, 0x07, 0x80, 0xFF, 0x00, 0xF0,
  0x1F, 0xE0, 0x1E, 0x03, 0xFC, 0x03, 0xC0, 0x7F, 0x80, 0x78, 0x0F, 0xF0,
  0x0F, 0x01, 0xFE, 0x01, 0xE0, 0x3F, 0xC0, 0x3C, 0x07, 0xF8, 0x07, 0x80,
  0xFF, 0x00, 0xF0, 0x1F, 0xE0, 0x1E, 0x03, 0xFC, 0x03, 0xC0, 0x7F, 0x80,
  0x78, 0x0F, 0x00, 0xF0, 0xE3, 0xFC, 0xF7, 0xFE, 0xFF, 0xFE, 0xFE, 0x3F,
  0xFC, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0x00, 0xE0, 0x03, 0xFE, 0x01, 0xFF, 0xE0, 0xFF, 0xF8, 0x3E,
  0x1F, 0x1F, 0x03, 0xE7, 0x80, 0xFB, 0xE0, 0x1E, 0xF8, 0x07, 0xBC, 0x01,
  0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F,
  0xC0, 0x1F, 0xF8, 0x07, 0x9E, 0x01, 0xE7, 0x80, 0xF9, 0xF0, 0x3C, 0x3E,
  0x1F, 0x0F, 0xFF, 0x81, 0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0x60, 0x79, 0xFE,
  0x3D, 0xFF, 0x9F, 0xFF, 0xCF, 0xE1, 0xF7, 0xC0, 0x7B, 0xE0, 0x3F, 0xF0,
  0x1F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xFC, 0x07, 0xFE, 0x03,
  0xFF, 0x83, 0xEF, 0xE3, 0xF7, 0xFF, 0xF3, 0xDF, 0xF1, 0xE3, 0xF0, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x07,
  0xF1, 0xC7, 0xFD, 0xE7, 0xFF, 0xF7, 0xE1, 0xFB, 0xE0, 0x7D, 0xE0, 0x3F,
  0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xDE,
  0x03, 0xEF, 0x81, 0xF7, 0xE3, 0xF9, 0xFF, 0xFC, 0x7F, 0xDE, 0x1F, 0xCF,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xFE,
  0x3E, 0xE7, 0xEF, 0x7E, 0xFF, 0xEF, 0xE0, 0xFC, 0x0F, 0x80, 0xF8, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x03, 0x01,
  0xFF, 0x9F, 0xFF, 0xFF, 0xEF, 0x83, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF8,
  0x07, 0xE0, 0x1F, 0xC0, 0x7F, 0x81, 0xFE, 0x03, 0xF8, 0x07, 0xE0, 0x1F,
  0x00, 0x78, 0x03, 0xC0, 0x1F, 0x00, 0xFE, 0x1F, 0xFF, 0xFB, 0xFF, 0x9F,
  0xF8, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x3C, 0x07, 0xFE, 0xFF, 0xEF,
  0xFE, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xE0, 0x3F, 0x11, 0xFF, 0x1F, 0xF0, 0xFF, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0x7F,
  0xFF, 0x3F, 0xE7, 0x1F, 0xC7, 0xF8, 0x03, 0xDE, 0x00, 0xF7, 0x80, 0x7D,
  0xE0, 0x1E, 0x3C, 0x07, 0x8F, 0x01, 0xE3, 0xC0, 0xF8, 0xF8, 0x3C, 0x1E,
  0x0F, 0x07, 0x87, 0xC1, 0xE1, 0xE0, 0x3C, 0x78, 0x0F, 0x1E, 0x03, 0xCF,
  0x00, 0xF3, 0xC0, 0x1E, 0xF0, 0x07, 0xBC, 0x01, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0xF8, 0x0F, 0x80,
  0x7B, 0xC0, 0x7C, 0x07, 0x9E, 0x03, 0xF0, 0x3C, 0xF0, 0x3F, 0x81, 0xE7,
  0xC1, 0xFC, 0x0F, 0x1E, 0x0E, 0xE0, 0xF8, 0xF0, 0x77, 0x87, 0x87, 0x87,
  0xBC, 0x3C, 0x3E, 0x3C, 0xE1, 0xE0, 0xF1, 0xE7, 0x0F, 0x07, 0x8E, 0x38,
  0xF0, 0x3C, 0x71, 0xE7, 0x81, 0xE7, 0x8F, 0x3C, 0x07, 0xBC, 0x39, 0xE0,
  0x3D, 0xC1, 0xDE, 0x01, 0xEE, 0x0E, 0xF0, 0x0F, 0x70, 0x7F, 0x80, 0x3B,
  0x83, 0xFC, 0x01, 0xFC, 0x0F, 0xC0, 0x0F, 0xC0, 0x7E, 0x00, 0x7E, 0x03,
  0xF0, 0x03, 0xF0, 0x1F, 0x80, 0x0F, 0x80, 0xF8, 0x00, 0xF8, 0x0F, 0xBC,
  0x0F, 0x9F, 0x07, 0xC7, 0x87, 0xC3, 0xE3, 0xC0, 0xF1, 0xE0, 0x7D, 0xE0,
  0x1E, 0xF0, 0x0F, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x3F, 0xE0, 0x3E, 0xF0, 0x1E, 0x7C, 0x1F, 0x1E, 0x0F,
  0x0F, 0x8F, 0x83, 0xC7, 0x81, 0xF7, 0xC0, 0x7B, 0xC0, 0x3E, 0xF8, 0x03,
  0xDE, 0x00, 0xF7, 0x80, 0x7D, 0xF0, 0x1E, 0x3C, 0x07, 0x8F, 0x01, 0xE3,
  0xC0, 0xF8, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x87, 0xC1, 0xF1, 0xE0, 0x3C,
  0x78, 0x0F, 0x1E, 0x03, 0xCF, 0x00, 0x7B, 0xC0, 0x1E, 0xF0, 0x07, 0xBC,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F,
  0x00, 0x07, 0xC0, 0x17, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7E, 0x00,
  0x00, 0x7F, 0xF9, 0xFF, 0xE7, 0xFF, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xC0,
  0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80,
  0x3C, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x38, 0x0F, 0xC0, 0xFE, 0x07,
  0xF0, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x07, 0xF8, 0x3F,
  0x01, 0xF8, 0x0F, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3E, 0x00, 0xFE, 0x07, 0xF0, 0x1F, 0x80, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x0F, 0x80, 0xFE, 0x0F, 0xE0,
  0x1E, 0x01, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x80, 0x7F, 0x03, 0xF0, 0x1F,
  0x07, 0xF0, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xF0, 0xFE, 0x0F, 0xE0,
  0xFC, 0x0E, 0x00, 0x3F, 0x00, 0x5F, 0xF8, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF,
  0xC0, 0x7F, 0xA0, 0x07, 0x80,
};

const GFXglyph NotoSans_Condensed_Medium43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 5, 31, 11, 3, -31 },
  { 21, 13, 11, 18, 2, -31 },
  { 39, 21, 31, 23, 1, -31 },
  { 121, 17, 36, 21, 2, -33 },
  { 198, 28, 31, 32, 2, -31 },
  { 307, 24, 31, 25, 1, -31 },
  { 400, 5, 11, 10, 2, -31 },
  { 407, 10, 38, 13, 2, -31 },
  { 455, 10, 38, 13, 1, -31 },
  { 503, 17, 17, 19, 1, -33 },
  { 540, 18, 20, 21, 1, -25 },
  { 585, 6, 11, 10, 2, -5 },
  { 594, 10, 4, 13, 1, -14 },
  { 599, 5, 6, 11, 3, -6 },
  { 603, 15, 31, 16, 1, -31 },
  { 662, 17, 31, 21, 2, -31 },
  { 728, 11, 31, 21, 3, -31 },
  { 771, 17, 31, 21, 2, -31 },
  { 837, 17, 31, 21, 2, -31 },
  { 903, 19, 31, 21, 1, -31 },
  { 977, 17, 31, 21, 2, -31 },
  { 1043, 17, 31, 21, 2, -31 },
  { 1109, 18, 31, 21, 1, -31 },
  { 1179, 17, 31, 21, 2, -31 },
  { 1245, 17, 31, 21, 2, -31 },
  { 1311, 5, 23, 11, 3, -23 },
  { 1326, 7, 29, 11, 1, -23 },
  { 1352, 18, 20, 21, 1, -25 },
  { 1397, 17, 12, 21, 2, -21 },
  { 1423, 18, 20, 21, 1, -25 },
  { 1468, 15, 31, 16, 0, -31 },
  { 1527, 28, 35, 32, 2, -31 },
  { 1650, 23, 31, 23, 0, -31 },
  { 1740, 18, 31, 23, 3, -31 },
  { 1810, 19, 31, 22, 2, -31 },
  { 1884, 20, 31, 25, 3, -31 },
  { 1962, 14, 31, 20, 3, -31 },
  { 2017, 14, 31, 19, 3, -31 },
  { 2072, 21, 31, 26, 2, -31 },
  { 2154, 20, 31, 26, 3, -31 },
  { 2232, 11, 31, 13, 1, -31 },
  { 2275, 11, 40, 11, -3, -31 },
  { 2330, 19, 31, 22, 3, -31 },
  { 2404, 15, 31, 18, 3, -31 },
  { 2463, 28, 31, 34, 3, -31 },
  { 2572, 21, 31, 28, 3, -31 },
  { 2654, 23, 31, 27, 2, -31 },
  { 2744, 17, 31, 22, 3, -31 },
  { 2810, 23, 38, 27, 2, -31 },
  { 2920, 19, 31, 22, 3, -31 },
  { 2994, 16, 31, 20, 2, -31 },
  { 3056, 18, 31, 19, 1, -31 },
  { 3126, 20, 31, 26, 3, -31 },
  { 3204, 22, 31, 22, 0, -31 },
  { 3290, 34, 31, 34, 0, -31 },
  { 3422, 20, 31, 21, 0, -31 },
  { 3500, 20, 31, 20, 0, -31 },
  { 3578, 17, 31, 19, 1, -31 },
  { 3644, 9, 38, 14, 3, -31 },
  { 3687, 15, 31, 16, 1, -31 },
  { 3746, 10, 38, 14, 1, -31 },
  { 3794, 20, 18, 21, 1, -31 },
  { 3839, 19, 3, 18, 0, 4 },
  { 3847, 9, 7, 12, 2, -33 },
  { 3855, 16, 24, 20, 2, -24 },
  { 3903, 17, 33, 22, 3, -33 },
  { 3974, 14, 24, 17, 2, -24 },
  { 4016, 17, 33, 22, 2, -33 },
  { 4087, 17, 24, 20, 2, -24 },
  { 4138, 14, 33, 13, 0, -33 },
  { 4196, 17, 34, 22, 2, -24 },
  { 4269, 16, 33, 22, 3, -33 },
  { 4335, 4, 32, 10, 3, -32 },
  { 4351, 8, 42, 10, -1, -32 },
  { 4393, 17, 33, 20, 3, -33 },
  { 4464, 4, 33, 10, 3, -33 },
  { 4481, 27, 24, 33, 3, -24 },
  { 4562, 16, 24, 22, 3, -24 },
  { 4610, 18, 24, 22, 2, -24 },
  { 4664, 17, 34, 22, 3, -24 },
  { 4737, 17, 34, 22, 2, -24 },
  { 4810, 12, 24, 15, 3, -24 },
  { 4846, 13, 24, 17, 2, -24 },
  { 4885, 12, 28, 13, 1, -28 },
  { 4927, 16, 23, 22, 3, -23 },
  { 4973, 18, 23, 19, 0, -23 },
  { 5025, 29, 23, 29, 0, -23 },
  { 5109, 17, 23, 19, 1, -23 },
  { 5158, 18, 33, 19, 0, -23 },
  { 5233, 14, 23, 16, 1, -23 },
  { 5274, 13, 38, 16, 1, -31 },
  { 5336, 4, 43, 20, 8, -33 },
  { 5358, 12, 38, 16, 2, -31 },
  { 5415, 18, 6, 21, 1, -18 },
};

const GFXfont NotoSans_Condensed_Medium43pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Medium43pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Medium43pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _NOTOSANS_CONDENSED_MEDIUM43PT7B_H_
