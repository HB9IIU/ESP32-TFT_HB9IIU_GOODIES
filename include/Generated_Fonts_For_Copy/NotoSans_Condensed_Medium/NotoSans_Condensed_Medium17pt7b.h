#ifndef _NOTOSANS_CONDENSED_MEDIUM17PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUM17PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Medium.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Medium17pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0x0F, 0xDE, 0xF7, 0xB0, 0x1A, 0x09, 0x04, 0x8F, 0xF7,
  0xF9, 0xB0, 0xD9, 0xFE, 0x24, 0x12, 0x09, 0x0D, 0x80, 0x10, 0x4F, 0xF4,
  0x93, 0x47, 0x07, 0x14, 0x59, 0xFE, 0x10, 0x40, 0xE1, 0x92, 0x62, 0x48,
  0x49, 0x09, 0x61, 0x2B, 0xBB, 0x58, 0x59, 0x0B, 0x22, 0x24, 0x45, 0x98,
  0xE0, 0x78, 0x26, 0x13, 0x09, 0x07, 0x83, 0x83, 0x4D, 0xB6, 0x8F, 0x43,
  0x33, 0xCF, 0x70, 0xFF, 0x36, 0x4C, 0xCC, 0x88, 0x8C, 0xCC, 0x46, 0x30,
  0xC6, 0x23, 0x31, 0x11, 0x11, 0x33, 0x26, 0xC0, 0x30, 0xCE, 0xFF, 0x73,
  0x64, 0x80, 0x30, 0x60, 0xC7, 0xFF, 0xE6, 0x0C, 0x18, 0xFE, 0xE0, 0xF0,
  0x04, 0x30, 0x86, 0x18, 0x43, 0x08, 0x21, 0x84, 0x30, 0x7B, 0x3C, 0xF1,
  0x86, 0x18, 0x61, 0xC7, 0x3C, 0xDE, 0x3B, 0xF6, 0xB1, 0x8C, 0x63, 0x18,
  0xC6, 0x30, 0xFB, 0x30, 0xC3, 0x0C, 0x21, 0x8C, 0x61, 0x0F, 0xFF, 0xFA,
  0x30, 0xC3, 0x0D, 0xC3, 0xC3, 0x04, 0x39, 0xFE, 0x0E, 0x0E, 0x1E, 0x16,
  0x36, 0x26, 0x66, 0x46, 0xFF, 0x06, 0x06, 0x06, 0xFF, 0x0C, 0x30, 0xF3,
  0xF0, 0xC1, 0x04, 0x39, 0xFE, 0x3D, 0x8C, 0x30, 0x9A, 0xFC, 0xE1, 0xC7,
  0x1E, 0xDE, 0xFE, 0x08, 0x30, 0x60, 0x83, 0x06, 0x18, 0x30, 0x41, 0x83,
  0x00, 0x79, 0x9B, 0x16, 0x66, 0xCE, 0x1E, 0x66, 0x87, 0x0B, 0x33, 0xC0,
  0x7B, 0x38, 0xE1, 0x87, 0x3F, 0xC9, 0x0C, 0x31, 0xBC, 0xF0, 0x03, 0xC0,
  0xF0, 0x03, 0xF8, 0x06, 0x38, 0xC6, 0x0E, 0x07, 0x03, 0x81, 0xFE, 0x00,
  0x07, 0xF0, 0x81, 0xC0, 0xE0, 0x70, 0xCE, 0x30, 0x40, 0xF9, 0x30, 0xC3,
  0x08, 0x63, 0x08, 0x00, 0x03, 0x0C, 0x1F, 0x06, 0x11, 0x01, 0x67, 0xA9,
  0xB7, 0x26, 0xE4, 0xDC, 0x9B, 0x93, 0x5B, 0xBB, 0x00, 0x30, 0x03, 0xF0,
  0x1C, 0x0E, 0x05, 0x06, 0xC3, 0x61, 0xB0, 0x88, 0xFE, 0x63, 0x31, 0xB0,
  0x78, 0x30, 0xFD, 0x9F, 0x1E, 0x3C, 0x7F, 0xB3, 0xE3, 0xC3, 0x8F, 0x3F,
  0xE0, 0x3E, 0xC7, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0xC1, 0xC9, 0xF0,
  0xFC, 0xCE, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC6, 0xFE, 0xFC,
  0xFF, 0x0C, 0x30, 0xC3, 0xFC, 0x30, 0xC3, 0x0F, 0xFF, 0xFF, 0x0C, 0x30,
  0xC3, 0xFF, 0xF0, 0xC3, 0x0C, 0x30, 0x3F, 0x71, 0x60, 0xC0, 0xC0, 0xC7,
  0xC7, 0xC3, 0xC3, 0x63, 0x73, 0x3F, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xFF,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xF6, 0x66, 0x66, 0x66, 0x66, 0x6F,
  0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0xE0, 0xC7, 0xC6, 0xCC, 0xD8,
  0xD8, 0xF0, 0xF8, 0xC8, 0xCC, 0xC6, 0xC6, 0xC3, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0F, 0xFF, 0xE0, 0xFC, 0x1F, 0xC3, 0xF8, 0x7D, 0x1F,
  0xA2, 0xF6, 0x5E, 0x5B, 0xCA, 0x79, 0xCF, 0x39, 0xE3, 0x30, 0xE1, 0xF0,
  0xFC, 0x7E, 0x3D, 0x9E, 0xCF, 0x37, 0x9B, 0xC7, 0xE3, 0xF0, 0xF8, 0x70,
  0x3E, 0x31, 0xB0, 0xD8, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE1, 0x9D,
  0xC7, 0xC0, 0xFD, 0x9F, 0x1E, 0x3C, 0x79, 0xFF, 0x60, 0xC1, 0x83, 0x06,
  0x00, 0x3E, 0x31, 0xB0, 0xD8, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE1,
  0x9D, 0xC7, 0xC0, 0x60, 0x30, 0x0C, 0xFC, 0xCE, 0xC6, 0xC6, 0xC6, 0xCC,
  0xF8, 0xC8, 0xCC, 0xC4, 0xC6, 0xC3, 0x7F, 0x1C, 0x30, 0xC1, 0xC3, 0x83,
  0x0C, 0x39, 0xFE, 0xFE, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xC0, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0x66, 0x3E, 0xC1, 0xE1, 0x90, 0xCC, 0x66, 0x21, 0x30, 0x98, 0x6C, 0x34,
  0x0E, 0x07, 0x03, 0x00, 0xC3, 0x0E, 0x18, 0xD1, 0xC6, 0xCE, 0x36, 0x59,
  0x32, 0xD8, 0xB2, 0xC5, 0x96, 0x38, 0xB1, 0xC7, 0x0E, 0x38, 0x30, 0xC0,
  0xC3, 0x66, 0x26, 0x3C, 0x1C, 0x18, 0x18, 0x3C, 0x34, 0x66, 0x62, 0xC3,
  0xC3, 0x46, 0x66, 0x24, 0x3C, 0x3C, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x7E, 0x0C, 0x30, 0x61, 0x83, 0x0C, 0x18, 0x20, 0xC1, 0xFF, 0xF0, 0xFC,
  0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCF, 0xF0, 0xC1, 0x06, 0x08, 0x30, 0xC1,
  0x06, 0x18, 0x20, 0xC1, 0xF1, 0x11, 0x11, 0x11, 0x11, 0x11, 0x1F, 0xF0,
  0x18, 0x18, 0x3C, 0x24, 0x26, 0x62, 0xC3, 0xFF, 0xFC, 0xCC, 0x80, 0xFA,
  0x30, 0xCF, 0xFF, 0x38, 0xF7, 0xF4, 0xC1, 0x83, 0x06, 0x0F, 0xDC, 0xF1,
  0xE3, 0xC7, 0x8F, 0x1F, 0x7F, 0xC0, 0x7E, 0x71, 0x88, 0x63, 0x1D, 0x78,
  0x06, 0x0C, 0x18, 0x37, 0xF9, 0xF1, 0xE3, 0x87, 0x8F, 0x1E, 0x77, 0x60,
  0x7B, 0x3C, 0x61, 0xFE, 0x0C, 0x39, 0x7C, 0x3C, 0xE6, 0x18, 0xF9, 0x86,
  0x18, 0x61, 0x86, 0x18, 0x60, 0x7F, 0x9F, 0x1E, 0x38, 0x78, 0xF1, 0xE7,
  0x76, 0x0C, 0x16, 0x6F, 0x80, 0xC1, 0x83, 0x06, 0x0F, 0xDC, 0xF1, 0xE3,
  0xC7, 0x8F, 0x1E, 0x3C, 0x60, 0xF0, 0xFF, 0xFF, 0xC0, 0x33, 0x00, 0x33,
  0x33, 0x33, 0x33, 0x33, 0x3B, 0xE0, 0xC1, 0x83, 0x06, 0x1C, 0xD9, 0x36,
  0x78, 0xF1, 0xB3, 0x36, 0x6C, 0x60, 0xFF, 0xFF, 0xFF, 0xC0, 0xFD, 0xD9,
  0xCF, 0x19, 0xE2, 0x3C, 0x47, 0x88, 0xF1, 0x1E, 0x23, 0xC4, 0x60, 0xFD,
  0xCF, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC6, 0x7D, 0x9B, 0x1E, 0x38, 0x78,
  0xF1, 0xE6, 0x78, 0xFD, 0xCF, 0x1E, 0x3C, 0x78, 0xF1, 0xF6, 0xFD, 0x83,
  0x06, 0x0C, 0x00, 0x7F, 0x9F, 0x1E, 0x38, 0x78, 0xF1, 0xE7, 0x76, 0x0C,
  0x18, 0x30, 0x60, 0xFF, 0x31, 0x8C, 0x63, 0x18, 0xC0, 0xFC, 0x61, 0xC7,
  0x0C, 0x73, 0xF0, 0x23, 0x3E, 0xC6, 0x31, 0x8C, 0x63, 0x0E, 0xC7, 0x8F,
  0x1E, 0x3C, 0x78, 0xF1, 0xE7, 0x76, 0xC6, 0x8D, 0x1B, 0x26, 0xC5, 0x8A,
  0x1C, 0x18, 0xC6, 0x29, 0xCD, 0x39, 0xB5, 0xB6, 0xB4, 0xD2, 0x8E, 0x71,
  0xCE, 0x31, 0x80, 0xC6, 0xD8, 0xB1, 0xC1, 0x87, 0x0B, 0x32, 0xC6, 0xC6,
  0x8D, 0x9B, 0x22, 0xC5, 0x8E, 0x1C, 0x18, 0x20, 0xC5, 0x8E, 0x00, 0x7C,
  0x21, 0x84, 0x30, 0x86, 0x10, 0xFC, 0x1C, 0xC3, 0x0C, 0x30, 0xC7, 0x38,
  0x30, 0xC3, 0x0C, 0x30, 0x70, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC3,
  0x18, 0xC6, 0x30, 0xC7, 0x63, 0x18, 0xC6, 0x72, 0x00, 0xF3, 0x38,
};

const GFXglyph NotoSans_Condensed_Medium17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 2, 12, 4, 1, -12 },
  { 4, 5, 4, 7, 1, -12 },
  { 7, 9, 12, 9, 0, -12 },
  { 21, 6, 14, 8, 1, -13 },
  { 32, 11, 12, 13, 1, -12 },
  { 49, 9, 12, 10, 1, -12 },
  { 63, 2, 4, 4, 1, -12 },
  { 64, 4, 15, 5, 1, -12 },
  { 72, 4, 15, 5, 0, -12 },
  { 80, 6, 7, 8, 1, -13 },
  { 86, 7, 8, 8, 1, -10 },
  { 93, 2, 4, 4, 1, -2 },
  { 94, 3, 1, 5, 1, -5 },
  { 95, 2, 2, 4, 1, -2 },
  { 96, 6, 12, 7, 0, -12 },
  { 105, 6, 12, 8, 1, -12 },
  { 114, 5, 12, 8, 1, -12 },
  { 122, 6, 12, 8, 1, -12 },
  { 131, 6, 12, 8, 1, -12 },
  { 140, 8, 12, 8, 0, -12 },
  { 152, 6, 12, 8, 1, -12 },
  { 161, 6, 12, 8, 1, -12 },
  { 170, 7, 12, 8, 1, -12 },
  { 181, 7, 12, 8, 1, -12 },
  { 192, 6, 12, 8, 1, -12 },
  { 201, 2, 9, 4, 1, -9 },
  { 204, 2, 11, 4, 1, -9 },
  { 207, 7, 8, 8, 1, -10 },
  { 214, 7, 4, 8, 1, -8 },
  { 218, 7, 8, 8, 1, -10 },
  { 225, 6, 12, 6, 0, -12 },
  { 234, 11, 13, 13, 1, -12 },
  { 252, 9, 12, 9, 0, -12 },
  { 266, 7, 12, 9, 1, -12 },
  { 277, 7, 12, 9, 1, -12 },
  { 288, 8, 12, 10, 1, -12 },
  { 300, 6, 12, 8, 1, -12 },
  { 309, 6, 12, 7, 1, -12 },
  { 318, 8, 12, 10, 1, -12 },
  { 330, 8, 12, 10, 1, -12 },
  { 342, 4, 12, 5, 1, -12 },
  { 348, 4, 15, 4, -1, -12 },
  { 356, 8, 12, 9, 1, -12 },
  { 368, 6, 12, 7, 1, -12 },
  { 377, 11, 12, 13, 1, -12 },
  { 394, 9, 12, 11, 1, -12 },
  { 408, 9, 12, 11, 1, -12 },
  { 422, 7, 12, 9, 1, -12 },
  { 433, 9, 15, 11, 1, -12 },
  { 450, 8, 12, 9, 1, -12 },
  { 462, 6, 12, 8, 1, -12 },
  { 471, 7, 12, 8, 0, -12 },
  { 482, 8, 12, 10, 1, -12 },
  { 494, 9, 12, 9, 0, -12 },
  { 508, 13, 12, 13, 0, -12 },
  { 528, 8, 12, 8, 0, -12 },
  { 540, 8, 12, 8, 0, -12 },
  { 552, 7, 12, 7, 0, -12 },
  { 563, 4, 15, 5, 1, -12 },
  { 571, 6, 12, 7, 0, -12 },
  { 580, 4, 15, 5, 0, -12 },
  { 588, 8, 7, 8, 0, -12 },
  { 595, 7, 2, 7, 0, 1 },
  { 597, 3, 3, 5, 1, -13 },
  { 599, 6, 9, 8, 1, -9 },
  { 606, 7, 13, 9, 1, -13 },
  { 618, 5, 9, 7, 1, -9 },
  { 624, 7, 13, 9, 1, -13 },
  { 636, 6, 9, 8, 1, -9 },
  { 643, 6, 13, 5, 0, -13 },
  { 653, 7, 13, 9, 1, -9 },
  { 665, 7, 13, 9, 1, -13 },
  { 677, 2, 13, 4, 1, -13 },
  { 681, 4, 17, 4, -1, -13 },
  { 690, 7, 13, 8, 1, -13 },
  { 702, 2, 13, 4, 1, -13 },
  { 706, 11, 9, 13, 1, -9 },
  { 719, 7, 9, 9, 1, -9 },
  { 727, 7, 9, 9, 1, -9 },
  { 735, 7, 13, 9, 1, -9 },
  { 747, 7, 13, 9, 1, -9 },
  { 759, 5, 9, 6, 1, -9 },
  { 765, 5, 9, 7, 1, -9 },
  { 771, 5, 11, 5, 0, -11 },
  { 778, 7, 9, 9, 1, -9 },
  { 786, 7, 9, 7, 0, -9 },
  { 794, 11, 9, 12, 0, -9 },
  { 807, 7, 9, 7, 0, -9 },
  { 815, 7, 13, 7, 0, -9 },
  { 827, 6, 9, 6, 0, -9 },
  { 834, 6, 15, 6, 0, -12 },
  { 846, 2, 17, 8, 3, -13 },
  { 851, 5, 15, 6, 1, -12 },
  { 861, 7, 2, 8, 1, -7 },
};

const GFXfont NotoSans_Condensed_Medium17pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Medium17pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Medium17pt7bGlyphs,
  0x20, 0x7E, 23
};

#endif // _NOTOSANS_CONDENSED_MEDIUM17PT7B_H_
