#ifndef _NOTOSANS_CONDENSED_MEDIUM32PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUM32PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Medium.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Medium32pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0x66, 0x66, 0x66, 0x00, 0x0F, 0xFF,
  0xF0, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0x06, 0x18,
  0x0C, 0x30, 0x18, 0xE0, 0x31, 0xC0, 0xE3, 0x01, 0xC6, 0x03, 0x8C, 0x3F,
  0xFF, 0x7F, 0xFE, 0x18, 0xE0, 0x31, 0xC0, 0xE3, 0x01, 0xC6, 0x03, 0x8C,
  0x3F, 0xFF, 0x7F, 0xFE, 0x18, 0xE0, 0x31, 0xC0, 0xE3, 0x01, 0xC6, 0x03,
  0x0C, 0x06, 0x18, 0x0C, 0x70, 0x00, 0x03, 0x00, 0x18, 0x01, 0xE0, 0x3F,
  0xF7, 0xFF, 0x39, 0x99, 0xCC, 0x1C, 0x60, 0x73, 0x03, 0x98, 0x1F, 0xC0,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x0F, 0xC0, 0x6F, 0x03, 0x38, 0x19, 0xE0,
  0xCF, 0xE7, 0xEF, 0xFF, 0x3F, 0xE0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0x3E, 0x03, 0x81, 0xFC, 0x0C, 0x07, 0x70, 0x70, 0x18, 0xC1, 0xC0,
  0xE3, 0x86, 0x03, 0x8E, 0x38, 0x0E, 0x38, 0xC0, 0x38, 0xE7, 0x00, 0xE3,
  0x98, 0x03, 0x8E, 0xE7, 0x86, 0x33, 0xBF, 0x1D, 0xCC, 0xEE, 0x7F, 0x77,
  0x18, 0xF9, 0x9C, 0x60, 0x0E, 0x71, 0x80, 0x39, 0xC7, 0x01, 0xC7, 0x1C,
  0x07, 0x1C, 0x60, 0x18, 0x71, 0x80, 0xE1, 0xC6, 0x03, 0x03, 0x38, 0x1C,
  0x0F, 0xC0, 0x70, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xF0, 0x0F, 0x78, 0x07,
  0x1C, 0x03, 0x8E, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0x71, 0xC0, 0x1D, 0xC0,
  0x0F, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xF8, 0x73, 0xDE, 0x3B, 0xC7,
  0xBD, 0xE1, 0xDC, 0xE0, 0x7E, 0x70, 0x3E, 0x3C, 0x0F, 0x1E, 0x0F, 0xC7,
  0xFF, 0xE1, 0xFF, 0x78, 0x7F, 0x1E, 0xFF, 0xFF, 0xFF, 0x07, 0x0E, 0x1C,
  0x1C, 0x38, 0x38, 0x38, 0x70, 0x70, 0x70, 0x70, 0x70, 0x70, 0xF0, 0xF0,
  0xF0, 0x70, 0x70, 0x70, 0x70, 0x70, 0x38, 0x38, 0x38, 0x1C, 0x1C, 0x0E,
  0x07, 0xE0, 0xE1, 0xC1, 0xC3, 0x83, 0x87, 0x0E, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x71, 0xC3, 0x87, 0x1C, 0x38, 0xE1,
  0xC7, 0x00, 0x07, 0x00, 0x70, 0x06, 0x04, 0x63, 0xFF, 0xFF, 0xFF, 0x0F,
  0x00, 0xF8, 0x1D, 0xC3, 0x9C, 0x78, 0xE1, 0x08, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x3B, 0xDE, 0xE7,
  0x39, 0x9C, 0xFF, 0xFF, 0xF8, 0xEF, 0xFF, 0x00, 0x70, 0x0E, 0x00, 0xE0,
  0x0E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x70, 0x07, 0x00,
  0x70, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03,
  0x80, 0x70, 0x07, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0xFF, 0x0F, 0xF8, 0xF1,
  0xE7, 0x07, 0x38, 0x39, 0xC1, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F,
  0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0x70, 0x7B, 0x83, 0x9C,
  0x1C, 0xF1, 0xE3, 0xFE, 0x1F, 0xF0, 0x3F, 0x00, 0x07, 0x87, 0xC7, 0xE7,
  0xF7, 0xFF, 0xBD, 0x9E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x1F, 0x83,
  0xFF, 0x3F, 0xF8, 0xC1, 0xE4, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x3C, 0x01, 0xC0, 0x1C, 0x01, 0xE0,
  0x1E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1F, 0x83, 0xFF, 0x3F, 0xFC, 0xC1, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0xF0, 0x1F, 0x07, 0xE0, 0x3F, 0x81, 0xFE, 0x00, 0x78, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0x01, 0xEF, 0xBF, 0x7F, 0xF1,
  0xFE, 0x00, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x1F,
  0x80, 0xEE, 0x03, 0xB8, 0x1C, 0xE0, 0x63, 0x83, 0x8E, 0x0C, 0x38, 0x70,
  0xE1, 0x83, 0x8E, 0x0E, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x7F, 0xE7, 0xFE, 0x7F, 0xEE,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0xF8, 0xFF, 0xC7,
  0xFE, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xE8,
  0x1E, 0xF7, 0xEF, 0xFC, 0xFF, 0x00, 0x03, 0xF0, 0x7F, 0x87, 0xFC, 0x78,
  0x03, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x71, 0x03, 0xBF, 0x3B, 0xFD,
  0xF9, 0xEF, 0x07, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0x70, 0x3B, 0x81, 0xDC,
  0x1E, 0xF0, 0xE3, 0xFF, 0x0F, 0xF0, 0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x0F,
  0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00,
  0x78, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x00, 0x0F, 0xC1,
  0xFF, 0x1F, 0x7C, 0xE0, 0xE7, 0x07, 0xB8, 0x3D, 0xC1, 0xCE, 0x0E, 0x38,
  0xF1, 0xFF, 0x07, 0xF0, 0x3F, 0x83, 0xFE, 0x3C, 0x79, 0xC1, 0xFE, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xE0, 0xF7, 0x8F, 0x1F, 0xF8, 0x7F, 0x00,
  0x0F, 0x81, 0xFE, 0x1F, 0xF8, 0xE1, 0xE7, 0x07, 0x78, 0x3B, 0x81, 0xFC,
  0x07, 0xE0, 0x3F, 0x83, 0xDC, 0x1E, 0xF1, 0xF7, 0xFB, 0x9F, 0xDC, 0x38,
  0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x38, 0x03, 0xC6, 0x7C, 0x3F, 0xC1,
  0xFC, 0x00, 0xFF, 0xF6, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x7B,
  0xDE, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1D, 0xEF, 0x73, 0x9D, 0xCE,
  0x00, 0x00, 0x08, 0x01, 0xC0, 0x3E, 0x07, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x1E, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1C,
  0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x80, 0x07, 0x00, 0x3E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x00, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x80, 0x70, 0x02, 0x00, 0x00, 0x3F, 0x9F, 0xF9, 0xFF, 0x20, 0xF0,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xC0, 0x78, 0x1E, 0x07, 0x80, 0xE0,
  0x1C, 0x03, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0x01, 0xFC, 0x00, 0x7F, 0xF0, 0x0F, 0x07, 0x81, 0xC0, 0x1C,
  0x38, 0x00, 0xC7, 0x00, 0x0E, 0x70, 0xF8, 0x66, 0x1F, 0xC7, 0xE3, 0x8C,
  0x7E, 0x30, 0xC3, 0xC7, 0x0C, 0x3C, 0x70, 0xC3, 0xC7, 0x0C, 0x3C, 0x71,
  0xC3, 0xC7, 0x1C, 0x7C, 0x71, 0xC7, 0xC7, 0x1C, 0x6C, 0x3F, 0x7E, 0xE1,
  0xE7, 0xCE, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x02, 0x01,
  0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0xFC, 0x00, 0x77, 0x00, 0x3B, 0x80, 0x1D, 0xC0, 0x1C, 0xE0,
  0x0E, 0x38, 0x07, 0x1C, 0x03, 0x8E, 0x03, 0x87, 0x81, 0xC1, 0xC0, 0xFF,
  0xE0, 0xFF, 0xF0, 0x7F, 0xFC, 0x38, 0x0E, 0x1C, 0x07, 0x1E, 0x03, 0xCE,
  0x01, 0xE7, 0x00, 0x77, 0x80, 0x3B, 0xC0, 0x1E, 0xFF, 0x83, 0xFF, 0xCF,
  0xFF, 0xBC, 0x1E, 0xF0, 0x3B, 0xC0, 0xEF, 0x03, 0xBC, 0x0E, 0xF0, 0x7B,
  0xC3, 0xCF, 0xFE, 0x3F, 0xF8, 0xF1, 0xFB, 0xC0, 0xEF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x1E, 0xFF, 0xFB, 0xFF, 0xCF, 0xFC,
  0x00, 0x07, 0xF0, 0xFF, 0xCF, 0xFE, 0x78, 0x17, 0x80, 0x38, 0x03, 0xC0,
  0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x13, 0xFF, 0x8F,
  0xFC, 0x3F, 0xE0, 0xFF, 0x81, 0xFF, 0xC3, 0xFF, 0xC7, 0x87, 0xCF, 0x03,
  0xDE, 0x03, 0xBC, 0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3B, 0xC0, 0xF7, 0x83, 0xCF, 0xFF, 0x1F, 0xFC, 0x3F, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF8, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0xFF, 0xFF, 0xF8, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x00, 0x03, 0xF8, 0x1F,
  0xFC, 0x7F, 0xF9, 0xE0, 0x27, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8,
  0x03, 0xF0, 0x07, 0xF0, 0x0E, 0xE0, 0x1D, 0xE0, 0x3B, 0xE0, 0x73, 0xFF,
  0xE3, 0xFF, 0xC1, 0xFF, 0x00, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xC0, 0xFF, 0xFF,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0xFF, 0xFF, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0E, 0xFE,
  0xFE, 0xF8, 0xE0, 0x3B, 0x81, 0xEE, 0x0F, 0x38, 0x38, 0xE1, 0xE3, 0x8F,
  0x0E, 0x38, 0x39, 0xE0, 0xEF, 0x03, 0xB8, 0x0F, 0xE0, 0x3F, 0xC0, 0xFF,
  0x03, 0xDE, 0x0E, 0x78, 0x38, 0xF0, 0xE1, 0xC3, 0x87, 0x8E, 0x0E, 0x38,
  0x3C, 0xE0, 0x73, 0x81, 0xEE, 0x03, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0xFF,
  0xFF, 0xFF, 0xF8, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x80,
  0x3F, 0xD8, 0x03, 0xFD, 0xC0, 0x37, 0xDC, 0x07, 0x7D, 0xC0, 0x77, 0xEE,
  0x06, 0x7E, 0xE0, 0xE7, 0xEE, 0x0E, 0x7E, 0x70, 0xC7, 0xE7, 0x1C, 0x7E,
  0x71, 0xC7, 0xE3, 0x1C, 0x7E, 0x3B, 0x87, 0xE3, 0xB8, 0x7E, 0x3B, 0x87,
  0xE1, 0xF0, 0x7E, 0x1F, 0x07, 0xE1, 0xF0, 0x7E, 0x0E, 0x07, 0xE0, 0xE0,
  0x70, 0xF0, 0x0F, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0xC0, 0xFB, 0x81,
  0xF7, 0x83, 0xE7, 0x07, 0xEF, 0x0F, 0xCE, 0x1F, 0x9C, 0x3F, 0x1C, 0x7E,
  0x38, 0xFC, 0x39, 0xF8, 0x73, 0xF0, 0x77, 0xE0, 0xEF, 0xC0, 0xFF, 0x81,
  0xFF, 0x03, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x07, 0x80, 0x07, 0xE0, 0x0F,
  0xFC, 0x0F, 0xFF, 0x0F, 0x83, 0xC7, 0x80, 0xE7, 0x80, 0x7B, 0xC0, 0x3D,
  0xC0, 0x0E, 0xE0, 0x07, 0x70, 0x03, 0xB8, 0x01, 0xDC, 0x00, 0xFE, 0x00,
  0x77, 0x00, 0x3B, 0x80, 0x1D, 0xC0, 0x0E, 0xF0, 0x0F, 0x78, 0x07, 0x9E,
  0x03, 0x8F, 0x03, 0xC3, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0xC0, 0xFF, 0x07,
  0xFF, 0x3F, 0xFD, 0xE1, 0xEF, 0x07, 0xF8, 0x3F, 0xC0, 0xFE, 0x07, 0xF0,
  0x7F, 0x83, 0xFC, 0x3D, 0xEF, 0xEF, 0xFE, 0x7F, 0xE3, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x00,
  0x07, 0xF0, 0x0F, 0xFC, 0x0F, 0xFF, 0x0F, 0x83, 0xC7, 0x80, 0xE7, 0x80,
  0x7B, 0xC0, 0x3D, 0xC0, 0x0E, 0xE0, 0x07, 0x70, 0x03, 0xB8, 0x01, 0xDC,
  0x00, 0xFE, 0x00, 0x77, 0x00, 0x3B, 0x80, 0x1D, 0xC0, 0x0E, 0xF0, 0x0F,
  0x78, 0x07, 0x9E, 0x03, 0x8F, 0x03, 0xC3, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F,
  0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xE0,
  0xFF, 0x83, 0xFF, 0x8F, 0xFF, 0x3C, 0x3C, 0xF0, 0x7B, 0xC1, 0xEF, 0x03,
  0xBC, 0x0E, 0xF0, 0x7B, 0xC1, 0xEF, 0x0F, 0x3F, 0xF8, 0xFF, 0xC3, 0xFF,
  0x0F, 0x1C, 0x3C, 0x78, 0xF0, 0xE3, 0xC3, 0xCF, 0x07, 0x3C, 0x1E, 0xF0,
  0x3B, 0xC0, 0xFF, 0x03, 0xC0, 0x0F, 0xE3, 0xFF, 0x7F, 0xF7, 0x82, 0x70,
  0x0F, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x07, 0xC0, 0x3F, 0x01, 0xFC, 0x07,
  0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x7C, 0x0F, 0xFF,
  0xEF, 0xFC, 0x7F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3D, 0xC0, 0x73, 0xC1, 0xE7, 0xFF,
  0xC7, 0xFF, 0x03, 0xF8, 0x00, 0xE0, 0x07, 0xF0, 0x07, 0x70, 0x0F, 0x70,
  0x0E, 0x70, 0x0E, 0x78, 0x1E, 0x38, 0x1C, 0x38, 0x1C, 0x38, 0x1C, 0x1C,
  0x3C, 0x1C, 0x38, 0x1C, 0x38, 0x1E, 0x38, 0x0E, 0x78, 0x0E, 0x70, 0x0E,
  0x70, 0x0E, 0x70, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03,
  0xC0, 0x03, 0xC0, 0xE0, 0x1C, 0x03, 0xF8, 0x0E, 0x01, 0xDC, 0x07, 0x81,
  0xEE, 0x07, 0xC0, 0xF7, 0x03, 0xE0, 0x73, 0x81, 0xF0, 0x39, 0xE0, 0xDC,
  0x1C, 0x70, 0xEE, 0x1E, 0x38, 0x77, 0x0E, 0x1C, 0x3B, 0x87, 0x0F, 0x1C,
  0xE3, 0x83, 0x8C, 0x71, 0xC1, 0xCE, 0x39, 0xE0, 0xE7, 0x1C, 0xE0, 0x73,
  0x86, 0x70, 0x3D, 0x83, 0xB8, 0x0E, 0xC1, 0xDC, 0x07, 0xE0, 0xFC, 0x03,
  0xF0, 0x7E, 0x01, 0xF8, 0x1F, 0x00, 0x78, 0x0F, 0x80, 0x3C, 0x07, 0xC0,
  0x1E, 0x03, 0xC0, 0x70, 0x1E, 0xF0, 0x38, 0xE0, 0xF1, 0xE1, 0xC1, 0xC7,
  0x83, 0x8E, 0x03, 0x9C, 0x07, 0x70, 0x07, 0xE0, 0x0F, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x7C, 0x00, 0xFC, 0x03, 0xB8, 0x07, 0x78, 0x1E, 0x70, 0x38,
  0xF0, 0xF0, 0xE1, 0xC1, 0xE7, 0x81, 0xCE, 0x03, 0xBC, 0x07, 0x80, 0xF0,
  0x1E, 0xE0, 0x39, 0xC0, 0x73, 0xC1, 0xE3, 0x83, 0x87, 0x8F, 0x07, 0x1C,
  0x0E, 0x38, 0x1E, 0xE0, 0x1D, 0xC0, 0x3B, 0x80, 0x3E, 0x00, 0x7C, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x00,
  0xF0, 0x0E, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x70, 0x0F,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0E, 0x1C, 0x38,
  0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E,
  0x1C, 0x38, 0x70, 0xE1, 0xC3, 0xFF, 0xF0, 0xF0, 0x07, 0x00, 0x70, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x0E, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x03, 0x80, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xC0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0xFF, 0xFF, 0xF8, 0x70, 0xE1, 0xC3,
  0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0xC3, 0x87, 0x0E, 0x1F, 0xFF, 0xF0, 0x03, 0x00, 0x1C, 0x00, 0x78,
  0x03, 0xE0, 0x0F, 0xC0, 0x73, 0x01, 0xCE, 0x06, 0x18, 0x38, 0x70, 0xC0,
  0xC7, 0x03, 0x98, 0x0E, 0xE0, 0x1C, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0xF0,
  0xE0, 0xE0, 0xC0, 0xC0, 0x02, 0x03, 0xFC, 0x3F, 0xE3, 0x0F, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x0F, 0x1F, 0xF7, 0xFF, 0x70, 0x7F, 0x07, 0xE0, 0x7E,
  0x07, 0xF0, 0xF7, 0x1F, 0x7F, 0x73, 0xE3, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x84, 0x1C, 0xFC, 0xEF, 0xF7, 0xC7, 0xBC,
  0x1F, 0xE0, 0xFF, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xFC, 0x0F, 0xE0, 0xFF, 0x07, 0x7E, 0xFB, 0xBF, 0x9C, 0xF8, 0x03, 0x83,
  0xFC, 0xFF, 0x9E, 0x27, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1E, 0x01, 0xF7, 0x3F, 0xE1, 0xF8, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x10, 0xE3, 0xF7,
  0x3F, 0xFB, 0xE7, 0xDE, 0x1E, 0xE0, 0x77, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0x81, 0xDC, 0x0E, 0xE0, 0x77, 0x87, 0x9E, 0x7C, 0xFF,
  0x63, 0xF3, 0x02, 0x00, 0xFE, 0x0F, 0xF8, 0x71, 0xE7, 0x07, 0x38, 0x1D,
  0xC0, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xE0, 0x27, 0xCE, 0x1F, 0xF0, 0x7F, 0x80, 0x0F, 0xC7, 0xF1, 0xE4,
  0x70, 0x1C, 0x07, 0x01, 0xC1, 0xFE, 0xFF, 0x87, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x06, 0x00, 0xFC, 0xCF, 0xFE, 0xF9, 0xF7, 0x87, 0xB8, 0x1D,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x77, 0x03, 0xB8,
  0x1D, 0xE1, 0xE7, 0xBF, 0x3F, 0xF8, 0xFD, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1D, 0x83, 0xCF, 0xFE, 0x7F, 0xE0, 0x78, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE1, 0x0E, 0xFE, 0xEF, 0xFF, 0x8F,
  0xF0, 0x7F, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0x6E, 0xFE, 0x00,
  0x0E, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0x0C, 0x38, 0x78,
  0xE0, 0x00, 0x00, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C,
  0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xDF, 0xBE,
  0x30, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x1E, 0xE0, 0xE7, 0x0E, 0x38, 0xF1, 0xC7, 0x0E, 0x70, 0x77, 0x03,
  0xBC, 0x1F, 0xE0, 0xFF, 0x87, 0x9C, 0x38, 0xF1, 0xC3, 0x8E, 0x1E, 0x70,
  0x73, 0x83, 0xDC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x03, 0x81, 0x87, 0x7E, 0x3F, 0x3B, 0xFB, 0xFD, 0xF1, 0xF9, 0xEF,
  0x0F, 0x87, 0xF8, 0x38, 0x3F, 0xC1, 0xC0, 0xFC, 0x0E, 0x07, 0xE0, 0x70,
  0x3F, 0x03, 0x81, 0xF8, 0x1C, 0x0F, 0xC0, 0xE0, 0x7E, 0x07, 0x03, 0xF0,
  0x38, 0x1F, 0x81, 0xC0, 0xFC, 0x0E, 0x07, 0xE0, 0x70, 0x3F, 0x03, 0x81,
  0xC0, 0x01, 0x0E, 0xFE, 0xEF, 0xFF, 0x8F, 0xF0, 0x7F, 0x07, 0xF0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0x03, 0x00, 0x7F, 0x83, 0xFF, 0x0F, 0x1C, 0x78,
  0x39, 0xC0, 0xE7, 0x03, 0xBC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xDC,
  0x0F, 0x70, 0x39, 0xC0, 0xE7, 0x87, 0x8F, 0x3C, 0x1F, 0xE0, 0x3F, 0x00,
  0x01, 0x87, 0x3F, 0x3B, 0xFD, 0xF1, 0xEF, 0x07, 0xF8, 0x3F, 0xC0, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7F, 0x03, 0xF8, 0x3F, 0xC1,
  0xDF, 0xBE, 0xEF, 0xE7, 0x3E, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x06, 0x00, 0xFC, 0xCF, 0xFE,
  0xF1, 0xF7, 0x87, 0xB8, 0x1D, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC,
  0x0F, 0xE0, 0x77, 0x03, 0xB8, 0x1D, 0xE1, 0xE7, 0x9F, 0x3F, 0xF8, 0xFD,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x03, 0x73, 0xFB, 0xFF, 0xEF, 0x87, 0x83, 0xC1, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x00, 0x04,
  0x0F, 0xF7, 0xFF, 0xC2, 0xE0, 0x38, 0x0F, 0x01, 0xF0, 0x7E, 0x07, 0xE0,
  0x7C, 0x0F, 0x01, 0xC0, 0x78, 0x1F, 0xCF, 0xFF, 0x9F, 0xC0, 0x38, 0x38,
  0x38, 0x38, 0xFF, 0xFF, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78,
  0x78, 0x78, 0x78, 0x78, 0x3D, 0x3F, 0x1F, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7F, 0x0F, 0x7B, 0xF7, 0xFB, 0x3F, 0x30, 0xF0, 0x3D, 0xC0,
  0xE7, 0x03, 0x9C, 0x1E, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x38, 0x1C,
  0xE0, 0x73, 0x81, 0xCE, 0x03, 0x70, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x01,
  0xE0, 0x07, 0x80, 0xF0, 0x78, 0x3D, 0xC1, 0xE0, 0xE7, 0x07, 0x83, 0x9C,
  0x3F, 0x0E, 0x70, 0xFC, 0x70, 0xE3, 0x71, 0xC3, 0x8C, 0xC7, 0x0E, 0x73,
  0x1C, 0x39, 0xCE, 0xE0, 0x77, 0x3B, 0x81, 0xD8, 0xEE, 0x07, 0x61, 0xB8,
  0x1F, 0x86, 0xC0, 0x3E, 0x1B, 0x00, 0xF0, 0x7C, 0x03, 0xC1, 0xF0, 0x0F,
  0x03, 0xC0, 0x70, 0x38, 0xE1, 0xC3, 0x87, 0x07, 0x38, 0x1C, 0xE0, 0x3F,
  0x00, 0xFC, 0x01, 0xE0, 0x07, 0x80, 0x3F, 0x00, 0xFC, 0x07, 0x78, 0x1C,
  0xE0, 0xF3, 0xC3, 0x87, 0x1E, 0x1E, 0xF0, 0x3C, 0xF0, 0x3D, 0xC0, 0xE7,
  0x03, 0x9C, 0x1E, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x07, 0x38, 0x1C, 0xE0,
  0x73, 0x81, 0xCE, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x78, 0x07, 0xE0,
  0x1F, 0x00, 0x70, 0x00, 0xFF, 0xFF, 0xF0, 0x38, 0x0E, 0x07, 0x01, 0xC0,
  0xE0, 0x38, 0x1C, 0x07, 0x03, 0x80, 0xE0, 0x70, 0x1C, 0x0F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x01, 0x83, 0xC3, 0xE1, 0xC1, 0xE0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x83, 0xC7, 0xC3, 0xC0, 0xF8, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x0E, 0x07, 0xC3, 0xE0, 0x70, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3E,
  0x0F, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x78, 0x0F, 0x01, 0xF0, 0x7C, 0x3E, 0x1E, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x1F, 0x0F, 0x83, 0xC0, 0x10, 0x0B, 0xF0,
  0x7F, 0xFF, 0x8F, 0xF8, 0x0F, 0x00,
};

const GFXglyph NotoSans_Condensed_Medium32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 4, 23, 8, 2, -23 },
  { 13, 9, 8, 13, 2, -23 },
  { 22, 15, 23, 17, 1, -23 },
  { 66, 13, 26, 15, 1, -24 },
  { 109, 22, 23, 24, 1, -23 },
  { 173, 17, 23, 18, 1, -23 },
  { 222, 3, 8, 7, 2, -23 },
  { 225, 8, 28, 10, 1, -23 },
  { 253, 7, 28, 10, 1, -23 },
  { 278, 12, 12, 14, 1, -24 },
  { 296, 13, 15, 15, 1, -19 },
  { 321, 5, 8, 8, 1, -4 },
  { 326, 7, 3, 9, 1, -10 },
  { 329, 4, 4, 8, 2, -4 },
  { 331, 12, 23, 12, 0, -23 },
  { 366, 13, 23, 15, 1, -23 },
  { 404, 9, 23, 15, 2, -23 },
  { 430, 13, 23, 15, 1, -23 },
  { 468, 13, 23, 15, 1, -23 },
  { 506, 14, 23, 15, 1, -23 },
  { 547, 12, 23, 15, 2, -23 },
  { 582, 13, 23, 15, 1, -23 },
  { 620, 13, 23, 15, 1, -23 },
  { 658, 13, 23, 15, 1, -23 },
  { 696, 13, 23, 15, 1, -23 },
  { 734, 4, 17, 8, 2, -17 },
  { 743, 5, 21, 8, 1, -17 },
  { 757, 13, 15, 15, 1, -19 },
  { 782, 13, 9, 15, 1, -16 },
  { 797, 13, 15, 15, 1, -19 },
  { 822, 11, 23, 12, 0, -23 },
  { 854, 20, 26, 24, 2, -23 },
  { 919, 17, 23, 17, 0, -23 },
  { 968, 14, 23, 17, 2, -23 },
  { 1009, 13, 23, 16, 2, -23 },
  { 1047, 15, 23, 19, 2, -23 },
  { 1091, 10, 23, 15, 3, -23 },
  { 1120, 10, 23, 14, 3, -23 },
  { 1149, 15, 23, 19, 2, -23 },
  { 1193, 14, 23, 19, 3, -23 },
  { 1234, 8, 23, 10, 1, -23 },
  { 1257, 8, 29, 8, -2, -23 },
  { 1286, 14, 23, 17, 3, -23 },
  { 1327, 11, 23, 14, 2, -23 },
  { 1359, 20, 23, 25, 3, -23 },
  { 1417, 15, 23, 21, 3, -23 },
  { 1461, 17, 23, 20, 2, -23 },
  { 1510, 13, 23, 16, 2, -23 },
  { 1548, 17, 28, 20, 2, -23 },
  { 1608, 14, 23, 17, 2, -23 },
  { 1649, 12, 23, 15, 1, -23 },
  { 1684, 14, 23, 14, 0, -23 },
  { 1725, 15, 23, 19, 2, -23 },
  { 1769, 16, 23, 16, 0, -23 },
  { 1815, 25, 23, 25, 0, -23 },
  { 1887, 15, 23, 15, 0, -23 },
  { 1931, 15, 23, 15, 0, -23 },
  { 1975, 12, 23, 14, 1, -23 },
  { 2010, 7, 28, 10, 2, -23 },
  { 2035, 12, 23, 12, 0, -23 },
  { 2070, 7, 28, 10, 1, -23 },
  { 2095, 14, 13, 16, 1, -23 },
  { 2118, 14, 2, 14, 0, 3 },
  { 2122, 7, 6, 9, 1, -25 },
  { 2128, 12, 18, 15, 1, -18 },
  { 2155, 13, 24, 17, 2, -24 },
  { 2194, 11, 18, 13, 1, -18 },
  { 2219, 13, 24, 17, 1, -24 },
  { 2258, 13, 18, 15, 1, -18 },
  { 2288, 10, 24, 9, 0, -24 },
  { 2318, 13, 26, 17, 1, -18 },
  { 2361, 12, 24, 17, 2, -24 },
  { 2397, 4, 24, 8, 2, -24 },
  { 2409, 7, 32, 8, -1, -24 },
  { 2437, 13, 24, 15, 2, -24 },
  { 2476, 3, 24, 8, 2, -24 },
  { 2485, 21, 18, 25, 2, -18 },
  { 2533, 12, 18, 17, 2, -18 },
  { 2560, 14, 18, 16, 1, -18 },
  { 2592, 13, 26, 17, 2, -18 },
  { 2635, 13, 26, 17, 1, -18 },
  { 2678, 9, 18, 11, 2, -18 },
  { 2699, 10, 18, 12, 1, -18 },
  { 2722, 8, 21, 10, 1, -21 },
  { 2743, 12, 17, 17, 2, -17 },
  { 2769, 14, 17, 14, 0, -17 },
  { 2799, 22, 17, 22, 0, -17 },
  { 2846, 14, 17, 14, 0, -17 },
  { 2876, 14, 25, 14, 0, -17 },
  { 2920, 10, 17, 12, 1, -17 },
  { 2942, 9, 28, 12, 1, -23 },
  { 2974, 3, 32, 15, 6, -24 },
  { 2986, 10, 28, 12, 1, -23 },
  { 3021, 13, 5, 15, 1, -14 },
};

const GFXfont NotoSans_Condensed_Medium32pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Medium32pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Medium32pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _NOTOSANS_CONDENSED_MEDIUM32PT7B_H_
