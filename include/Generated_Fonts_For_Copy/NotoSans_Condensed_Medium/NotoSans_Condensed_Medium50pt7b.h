#ifndef _NOTOSANS_CONDENSED_MEDIUM50PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUM50PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Medium.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Medium50pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFD, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7,
  0xDF, 0x7D, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE0, 0x00, 0x00, 0x47,
  0xFF, 0xFF, 0xFF, 0xDF, 0x10, 0xF8, 0x7F, 0xF0, 0xFB, 0xE1, 0xF7, 0xC3,
  0xEF, 0x87, 0xDF, 0x0F, 0xBE, 0x0F, 0x7C, 0x1E, 0xF8, 0x3C, 0xF0, 0x79,
  0xE0, 0xF3, 0xC1, 0xE7, 0x03, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0x78,
  0x00, 0xF0, 0x78, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0x70, 0x00, 0xE0, 0x70,
  0x00, 0xE0, 0xF0, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0xF0,
  0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0x03, 0xC1, 0xE0, 0x03, 0xC1, 0xE0, 0x03, 0xC1, 0xE0, 0x03, 0xC1, 0xE0,
  0x03, 0xC1, 0xC0, 0x03, 0x83, 0xC0, 0x03, 0x83, 0xC0, 0x07, 0x83, 0xC0,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE,
  0x07, 0x07, 0x80, 0x0F, 0x07, 0x80, 0x0F, 0x07, 0x80, 0x0F, 0x07, 0x80,
  0x0F, 0x07, 0x80, 0x0F, 0x07, 0x00, 0x0F, 0x07, 0x00, 0x0E, 0x0F, 0x00,
  0x0E, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0xFC, 0x1F, 0xFF, 0xE3,
  0xFF, 0xFE, 0x7F, 0x67, 0xC7, 0xC6, 0x04, 0xF8, 0x60, 0x0F, 0x86, 0x00,
  0xF8, 0x60, 0x0F, 0x86, 0x00, 0xF8, 0x60, 0x07, 0xC6, 0x00, 0x7F, 0x60,
  0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0x7F, 0xC0, 0x06, 0x7E, 0x00, 0x63, 0xE0, 0x06, 0x1F, 0x00,
  0x61, 0xF0, 0x06, 0x1F, 0x00, 0x61, 0xF8, 0x06, 0x3E, 0xF0, 0x67, 0xEF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0x0E, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x0F, 0x80, 0x03, 0xC0, 0x1F, 0xF0, 0x03, 0xE0, 0x0F, 0xF8, 0x01,
  0xE0, 0x0F, 0xBE, 0x00, 0xF0, 0x07, 0x8F, 0x00, 0xF0, 0x07, 0x83, 0xC0,
  0x78, 0x03, 0xC1, 0xE0, 0x78, 0x01, 0xE0, 0xF0, 0x3C, 0x00, 0xF0, 0x78,
  0x1E, 0x00, 0x78, 0x3C, 0x1E, 0x00, 0x3C, 0x1E, 0x0F, 0x00, 0x1E, 0x0F,
  0x0F, 0x00, 0x0F, 0x07, 0x87, 0x80, 0x07, 0x83, 0xC7, 0x80, 0x03, 0xC1,
  0xE3, 0xC3, 0xE1, 0xE0, 0xF1, 0xE3, 0xF8, 0x70, 0x79, 0xE3, 0xFE, 0x3C,
  0x78, 0xF3, 0xFF, 0x9F, 0x7C, 0xF1, 0xE3, 0xC7, 0xFC, 0x78, 0xF1, 0xF1,
  0xFE, 0x3C, 0xF0, 0x78, 0x7C, 0x3C, 0x78, 0x3C, 0x00, 0x1E, 0x3C, 0x1E,
  0x00, 0x1E, 0x1E, 0x0F, 0x00, 0x0F, 0x0F, 0x07, 0x80, 0x0F, 0x07, 0x83,
  0xC0, 0x07, 0x83, 0xC1, 0xE0, 0x03, 0xC1, 0xE0, 0xF0, 0x03, 0xC0, 0xF0,
  0x78, 0x01, 0xE0, 0x78, 0x3C, 0x01, 0xE0, 0x3C, 0x1E, 0x00, 0xF0, 0x0F,
  0x1E, 0x00, 0xF8, 0x07, 0x9F, 0x00, 0x78, 0x01, 0xFF, 0x00, 0x3C, 0x00,
  0xFF, 0x80, 0x3C, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x3E,
  0x1F, 0x00, 0x07, 0x81, 0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x1E, 0x07, 0x80,
  0x03, 0xC0, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF9,
  0xF0, 0x00, 0x1F, 0x7E, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x3E, 0x1F, 0xFE,
  0x07, 0xC7, 0xE7, 0xE0, 0xF8, 0xF8, 0x7C, 0x3E, 0x3F, 0x0F, 0xC7, 0xC7,
  0xC0, 0xFC, 0xF8, 0xF8, 0x0F, 0xFF, 0x1F, 0x00, 0xFF, 0xC3, 0xE0, 0x1F,
  0xF8, 0x7C, 0x01, 0xFE, 0x0F, 0x80, 0x1F, 0xC1, 0xF0, 0x03, 0xF0, 0x3F,
  0x00, 0xFF, 0x03, 0xF0, 0x7F, 0xF0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xF3,
  0xF0, 0x7F, 0xFC, 0x7E, 0x07, 0xFE, 0x07, 0xF0, 0x08, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xDE, 0xF7, 0x00, 0x01, 0xF0, 0x3E, 0x03,
  0xC0, 0x7C, 0x07, 0x80, 0xF8, 0x0F, 0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x3E,
  0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x78,
  0x07, 0x80, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x3E,
  0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x3C, 0x03,
  0xE0, 0x1F, 0xF8, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x0F,
  0x80, 0xF8, 0x07, 0x80, 0x7C, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x3E, 0x01, 0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x3E, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x0F, 0x80, 0xF8, 0x1F,
  0x01, 0xF0, 0x3E, 0x03, 0xC0, 0x7C, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x01, 0x03, 0xC0, 0xBE, 0x38,
  0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xC0, 0x01, 0xFC,
  0x00, 0x7F, 0xC0, 0x1F, 0x78, 0x03, 0xCF, 0x80, 0xF8, 0xF8, 0x3E, 0x1F,
  0x83, 0xC1, 0xC0, 0x10, 0x30, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x3E, 0x7C, 0xF9, 0xF7, 0xCF, 0x9F,
  0x3E, 0x79, 0xF3, 0xC7, 0x8F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x11, 0xFF, 0xFF, 0xFF, 0xF7, 0xCC, 0x00, 0x07, 0xC0, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78,
  0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E,
  0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0xE0, 0x0F, 0xFF,
  0x01, 0xFF, 0xF8, 0x3F, 0x9F, 0x83, 0xE0, 0x7C, 0x7E, 0x07, 0xC7, 0xC0,
  0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xEF, 0x80, 0x3E, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0x7C, 0x03,
  0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xE0, 0x7C, 0x3E, 0x07, 0xC3, 0xF0,
  0xFC, 0x1F, 0xFF, 0x81, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x3F, 0xC0, 0x00,
  0x40, 0x00, 0x00, 0x7C, 0x03, 0xF0, 0x1F, 0xC0, 0xFF, 0x07, 0xFC, 0x3F,
  0xF1, 0xF7, 0xDF, 0x9F, 0xFC, 0x7D, 0xE1, 0xF3, 0x0F, 0xC8, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x07, 0xF8, 0x01, 0xFF, 0xE0, 0x7F, 0xFF,
  0x0F, 0xFF, 0xF8, 0x7E, 0x1F, 0xC7, 0x80, 0xFC, 0x20, 0x07, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07,
  0xFC, 0x03, 0xFF, 0xE0, 0x7F, 0xFF, 0x8F, 0xFF, 0xF8, 0x7C, 0x1F, 0xC7,
  0x00, 0x7C, 0x20, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0xFF,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0,
  0x00, 0x7E, 0x80, 0x07, 0xEE, 0x01, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8,
  0xFF, 0xFF, 0x07, 0xFF, 0xC0, 0x01, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xF7, 0xC0, 0x03, 0xDF, 0x00,
  0x1E, 0x7C, 0x00, 0x79, 0xF0, 0x03, 0xC7, 0xC0, 0x0F, 0x1F, 0x00, 0x78,
  0x7C, 0x01, 0xE1, 0xF0, 0x0F, 0x07, 0xC0, 0x3C, 0x1F, 0x01, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3C, 0x07, 0xC1, 0xF0, 0x1F, 0x07, 0x80, 0x7C, 0x3E,
  0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x7F,
  0xFF, 0x8F, 0xFF, 0xF1, 0xFF, 0xFE, 0x3F, 0xFF, 0xC7, 0xFF, 0xF8, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0xFE, 0x07, 0xFF,
  0xF0, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0x80, 0xFE, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0xA0, 0x07,
  0xE7, 0x01, 0xFC, 0xFF, 0xFF, 0x1F, 0xFF, 0xC3, 0xFF, 0xF0, 0x3F, 0xF8,
  0x00, 0x30, 0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x7F,
  0xFC, 0x0F, 0xE0, 0x41, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07,
  0x83, 0x80, 0xF9, 0xFF, 0x0F, 0xBF, 0xF8, 0xFB, 0xFF, 0xCF, 0xFF, 0xFC,
  0xFE, 0x07, 0xEF, 0xC0, 0x3E, 0xFC, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0x7C, 0x01, 0xF7, 0xC0,
  0x1F, 0x7C, 0x01, 0xF7, 0xE0, 0x3E, 0x3E, 0x03, 0xE3, 0xF0, 0x7C, 0x1F,
  0xFF, 0xC0, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x20, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x1F,
  0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0x0F, 0xC7, 0xC0, 0x7E, 0x7C, 0x03, 0xE7,
  0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E,
  0x3E, 0x07, 0xC3, 0xF0, 0xFC, 0x1F, 0x9F, 0x80, 0xFF, 0xF0, 0x07, 0xFE,
  0x00, 0x3F, 0xC0, 0x0F, 0xFE, 0x01, 0xFF, 0xF0, 0x3F, 0x1F, 0xC7, 0xE0,
  0xFC, 0x7C, 0x07, 0xEF, 0x80, 0x3E, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x03, 0xF7,
  0xE0, 0x7E, 0x7F, 0xFF, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0x7F, 0xE0,
  0x00, 0x60, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x03, 0xFF,
  0xF8, 0x7F, 0x1F, 0x87, 0xE0, 0xFC, 0x7C, 0x07, 0xCF, 0x80, 0x3E, 0xF8,
  0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x1E, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xF7, 0xC0, 0x7F,
  0x7F, 0x1F, 0xF3, 0xFF, 0xDF, 0x3F, 0xFD, 0xE1, 0xFF, 0x9E, 0x07, 0xE1,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x3F,
  0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFE, 0x00, 0x04, 0x00, 0x00,
  0x7B, 0xFF, 0xFF, 0xFD, 0xF3, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x11, 0xFF, 0xFF, 0xFF, 0xF7, 0xCC, 0x3C, 0xFD, 0xFB,
  0xF7, 0xE7, 0xC7, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xCF, 0x9F, 0x3E, 0xF9, 0xF3, 0xE7, 0x8F, 0x3E,
  0x78, 0xF1, 0xE0, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0xF0, 0x00,
  0x3F, 0x00, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F,
  0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x00, 0x00,
  0x30, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x00,
  0x03, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0xFE, 0x00, 0x0F, 0x00, 0x00,
  0xC0, 0x00, 0x08, 0x00, 0x00, 0x0F, 0xF8, 0x1F, 0xFE, 0x3F, 0xFF, 0x8F,
  0xFF, 0xE7, 0xC3, 0xF9, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x1F, 0x00, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x10, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x3F, 0xF7, 0xFC, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x07,
  0xC0, 0x1E, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00,
  0x1E, 0x0F, 0x00, 0x00, 0x0F, 0x0F, 0x80, 0xFF, 0x83, 0xC7, 0x81, 0xFF,
  0xE1, 0xE3, 0xC1, 0xFF, 0xF0, 0xF3, 0xC0, 0xF8, 0x78, 0x79, 0xE0, 0xF0,
  0x7C, 0x1C, 0xF0, 0x78, 0x3E, 0x0F, 0x78, 0x7C, 0x1E, 0x07, 0xBC, 0x3C,
  0x0F, 0x03, 0xDC, 0x1E, 0x07, 0x81, 0xFE, 0x0F, 0x03, 0xC0, 0xFF, 0x07,
  0x81, 0xE0, 0x7F, 0x83, 0xC0, 0xF0, 0x3B, 0xC1, 0xE0, 0x78, 0x3D, 0xE0,
  0xF0, 0x3C, 0x1E, 0x70, 0x78, 0x3E, 0x0F, 0x3C, 0x3E, 0x1F, 0x07, 0x1E,
  0x0F, 0x1D, 0xC7, 0x8F, 0x07, 0xFE, 0xFF, 0x87, 0x81, 0xFE, 0x3F, 0xC3,
  0xE0, 0x7E, 0x0F, 0xC0, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x30, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xEF, 0x00, 0x00,
  0xF3, 0xC0, 0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xC7, 0x80,
  0x01, 0xE1, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x83,
  0xC0, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x7C, 0x0F, 0x80, 0x1F,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xF0, 0x03,
  0xF0, 0xFC, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC3, 0xE0,
  0x01, 0xF9, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0x9F, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x3F,
  0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x7C, 0x03, 0xF3, 0xE0, 0x0F,
  0xDF, 0x00, 0x7E, 0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0x7D, 0xF0,
  0x03, 0xEF, 0x80, 0x3F, 0x7C, 0x01, 0xF3, 0xE0, 0x1F, 0x9F, 0xFF, 0xF8,
  0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0x80,
  0x7F, 0x7C, 0x01, 0xFB, 0xE0, 0x07, 0xDF, 0x00, 0x3F, 0xF8, 0x01, 0xFF,
  0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00,
  0xFB, 0xE0, 0x0F, 0xDF, 0x03, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFE, 0x3F,
  0xFF, 0xC1, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0xC1, 0xFF,
  0xFE, 0x1F, 0xFF, 0xE1, 0xFE, 0x0F, 0x0F, 0xC0, 0x18, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0xFE, 0x00, 0x23, 0xFC, 0x0E, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF,
  0xFC, 0x01, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFC,
  0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0x01, 0xFE,
  0x3E, 0x00, 0xFC, 0x7C, 0x00, 0xFC, 0xF8, 0x00, 0xF9, 0xF0, 0x01, 0xFB,
  0xE0, 0x01, 0xF7, 0xC0, 0x03, 0xEF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE,
  0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00,
  0x1F, 0xFC, 0x00, 0x3E, 0xF8, 0x00, 0x7D, 0xF0, 0x00, 0xFB, 0xE0, 0x03,
  0xF7, 0xC0, 0x07, 0xCF, 0x80, 0x1F, 0x9F, 0x00, 0x7E, 0x3E, 0x01, 0xFC,
  0x7C, 0x3F, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x07,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0x07, 0xFF, 0xFE, 0x0F, 0xF8, 0x7E, 0x1F, 0xC0, 0x0C, 0x3F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x07, 0xFF, 0xF8, 0x07, 0xFF,
  0xF8, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0x7C, 0x00, 0x1F,
  0x7E, 0x00, 0x1F, 0x7E, 0x00, 0x1F, 0x3F, 0x00, 0x1F, 0x3F, 0x80, 0x1F,
  0x1F, 0xE0, 0x3F, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x00, 0xFF, 0xF8, 0x00, 0x06, 0x00, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF,
  0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE,
  0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0,
  0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F,
  0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0,
  0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFE, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x3F, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x03, 0xF0, 0x3F, 0x07, 0xEF, 0xFE, 0xFF,
  0xCF, 0xFC, 0xFF, 0x87, 0xE0, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xEF, 0x80,
  0x1F, 0x3E, 0x00, 0xFC, 0xF8, 0x07, 0xE3, 0xE0, 0x1F, 0x0F, 0x80, 0xFC,
  0x3E, 0x07, 0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0xFC, 0x0F, 0x87, 0xE0, 0x3E,
  0x1F, 0x00, 0xF8, 0xFC, 0x03, 0xE3, 0xE0, 0x0F, 0x9F, 0x00, 0x3E, 0xFC,
  0x00, 0xFB, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00,
  0xFE, 0xFC, 0x03, 0xF1, 0xF0, 0x0F, 0x87, 0xE0, 0x3E, 0x0F, 0x80, 0xF8,
  0x3F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF8, 0x3E, 0x03, 0xE0, 0xF8, 0x0F,
  0xC3, 0xE0, 0x1F, 0x8F, 0x80, 0x7E, 0x3E, 0x00, 0xFC, 0xF8, 0x03, 0xF3,
  0xE0, 0x07, 0xEF, 0x80, 0x1F, 0xBE, 0x00, 0x3F, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xF7, 0x80, 0x03, 0xFF, 0xF7, 0xC0, 0x03, 0xDF, 0xFF, 0xC0, 0x03, 0xDF,
  0xFB, 0xC0, 0x07, 0xDF, 0xFB, 0xC0, 0x07, 0x9F, 0xFB, 0xE0, 0x07, 0x9F,
  0xF9, 0xE0, 0x0F, 0x9F, 0xF9, 0xE0, 0x0F, 0x1F, 0xF9, 0xF0, 0x0F, 0x1F,
  0xF9, 0xF0, 0x1F, 0x1F, 0xF8, 0xF0, 0x1E, 0x1F, 0xF8, 0xF8, 0x1E, 0x1F,
  0xF8, 0xF8, 0x3E, 0x1F, 0xF8, 0x78, 0x3E, 0x1F, 0xF8, 0x78, 0x3C, 0x1F,
  0xF8, 0x7C, 0x3C, 0x1F, 0xF8, 0x3C, 0x7C, 0x1F, 0xF8, 0x3C, 0x78, 0x1F,
  0xF8, 0x3E, 0x78, 0x1F, 0xF8, 0x3E, 0xF8, 0x1F, 0xF8, 0x1E, 0xF0, 0x1F,
  0xF8, 0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF8, 0x0F, 0xE0, 0x1F,
  0xF8, 0x0F, 0xE0, 0x1F, 0xF8, 0x0F, 0xE0, 0x1F, 0xF8, 0x07, 0xC0, 0x1F,
  0xF8, 0x07, 0xC0, 0x1F, 0xF8, 0x07, 0xC0, 0x1F, 0xFC, 0x00, 0x1F, 0xFE,
  0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF,
  0x80, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x1F, 0xF7, 0xC0, 0x1F, 0xF7,
  0xE0, 0x1F, 0xF3, 0xE0, 0x1F, 0xFB, 0xE0, 0x1F, 0xF9, 0xF0, 0x1F, 0xF9,
  0xF0, 0x1F, 0xF8, 0xF8, 0x1F, 0xF8, 0xF8, 0x1F, 0xF8, 0x7C, 0x1F, 0xF8,
  0x7C, 0x1F, 0xF8, 0x3E, 0x1F, 0xF8, 0x3E, 0x1F, 0xF8, 0x1F, 0x1F, 0xF8,
  0x1F, 0x0F, 0xF8, 0x0F, 0x8F, 0xF8, 0x0F, 0x8F, 0xF8, 0x07, 0xCF, 0xF8,
  0x07, 0xCF, 0xF8, 0x03, 0xEF, 0xF8, 0x03, 0xEF, 0xF8, 0x01, 0xFF, 0xF8,
  0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8,
  0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xF1, 0xFC,
  0x0F, 0xE0, 0x1F, 0x83, 0xF0, 0x03, 0xF1, 0xF8, 0x00, 0xFC, 0x7C, 0x00,
  0x1F, 0x1F, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFB, 0xF0, 0x00, 0x3E, 0xF8,
  0x00, 0x0F, 0xBE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xBF, 0x00, 0x03, 0xE7, 0xC0, 0x01, 0xF9,
  0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x1F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF8, 0x07,
  0xE0, 0x7F, 0x07, 0xF8, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x08, 0x00, 0x00, 0xFF, 0xE0, 0x1F,
  0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0xFF, 0xFD, 0xF0, 0x3F, 0xBE,
  0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF8,
  0x0F, 0xDF, 0x03, 0xFB, 0xFF, 0xFE, 0x7F, 0xFF, 0x8F, 0xFF, 0xE1, 0xFF,
  0xF0, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0,
  0x1F, 0xF1, 0xFE, 0x0F, 0xE0, 0x1F, 0x83, 0xF0, 0x03, 0xF1, 0xF8, 0x00,
  0xFC, 0x7C, 0x00, 0x1F, 0x9F, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFB, 0xF0,
  0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF,
  0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xBF, 0x00, 0x03, 0xE7,
  0xC0, 0x01, 0xF9, 0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x1F, 0x0F, 0xC0, 0x0F,
  0xC3, 0xF8, 0x07, 0xE0, 0x7F, 0x07, 0xF8, 0x0F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0B, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xE0, 0xFF, 0xFF, 0xC3, 0xE0, 0x3F, 0x8F, 0x80, 0x7E, 0x3E, 0x00, 0xF8,
  0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x3E, 0x3E, 0x00, 0xF8, 0xF8,
  0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x7E, 0x3E, 0x01, 0xF0, 0xF8, 0x1F,
  0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xFC, 0x03,
  0xE1, 0xF0, 0x0F, 0x83, 0xE0, 0x3E, 0x0F, 0x80, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF8, 0x3E, 0x03, 0xE0, 0xF8, 0x0F, 0xC3, 0xE0, 0x1F,
  0x0F, 0x80, 0x7E, 0x3E, 0x00, 0xF8, 0xF8, 0x03, 0xF3, 0xE0, 0x07, 0xCF,
  0x80, 0x1F, 0xBE, 0x00, 0x3F, 0x03, 0xFE, 0x01, 0xFF, 0xFC, 0x7F, 0xFF,
  0x1F, 0xFF, 0xE7, 0xFD, 0xFC, 0xFC, 0x03, 0x1F, 0x00, 0x07, 0xE0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xB0, 0x03, 0xF7, 0xC0, 0xFE, 0xFF, 0xFF, 0x9F,
  0xFF, 0xE3, 0xFF, 0xF8, 0x1F, 0xFC, 0x00, 0x18, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xF7, 0xE0, 0x1F, 0x9F, 0xC0, 0xFE,
  0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0x00,
  0x20, 0x00, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xEF,
  0x80, 0x03, 0xE7, 0xC0, 0x01, 0xF3, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x7C,
  0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x1F,
  0x83, 0xE0, 0x0F, 0x81, 0xF0, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x03, 0xE0, 0x7C, 0x01, 0xF0,
  0x7C, 0x00, 0xF8, 0x3E, 0x00, 0x3C, 0x1F, 0x00, 0x1F, 0x0F, 0x00, 0x0F,
  0x8F, 0x80, 0x07, 0xC7, 0xC0, 0x01, 0xE3, 0xE0, 0x00, 0xF9, 0xE0, 0x00,
  0x7D, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0x7C, 0x00, 0x07, 0xBC, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F,
  0xF8, 0x00, 0xF8, 0x00, 0x7D, 0xF0, 0x01, 0xF8, 0x00, 0xFB, 0xE0, 0x03,
  0xF0, 0x01, 0xF7, 0xC0, 0x0F, 0xE0, 0x07, 0xEF, 0x80, 0x1F, 0xC0, 0x0F,
  0x9F, 0x80, 0x3F, 0xC0, 0x1F, 0x1F, 0x00, 0x7F, 0x80, 0x3E, 0x3E, 0x00,
  0xFF, 0x00, 0x7C, 0x7C, 0x03, 0xDE, 0x01, 0xF0, 0xF8, 0x07, 0xBC, 0x03,
  0xE0, 0xF8, 0x0F, 0x7C, 0x07, 0xC1, 0xF0, 0x1E, 0x78, 0x0F, 0x83, 0xE0,
  0x7C, 0xF0, 0x1F, 0x07, 0xC0, 0xF9, 0xE0, 0x7C, 0x0F, 0x81, 0xE3, 0xE0,
  0xF8, 0x0F, 0x83, 0xC7, 0xC1, 0xF0, 0x1F, 0x0F, 0x87, 0x83, 0xE0, 0x3E,
  0x1F, 0x0F, 0x0F, 0x80, 0x7C, 0x3C, 0x1E, 0x1F, 0x00, 0x78, 0x78, 0x3E,
  0x3E, 0x00, 0xF8, 0xF0, 0x3C, 0x7C, 0x01, 0xF3, 0xE0, 0x78, 0xF8, 0x03,
  0xE7, 0xC0, 0xF3, 0xE0, 0x07, 0xCF, 0x01, 0xF7, 0xC0, 0x07, 0x9E, 0x03,
  0xEF, 0x80, 0x0F, 0xBC, 0x03, 0xDF, 0x00, 0x1F, 0xF8, 0x07, 0xBC, 0x00,
  0x3F, 0xE0, 0x0F, 0x78, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x00, 0x7F, 0x80,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3E, 0x3E, 0x00, 0x7E, 0x3E, 0x00, 0x7C,
  0x1F, 0x00, 0xFC, 0x1F, 0x00, 0xF8, 0x1F, 0x81, 0xF8, 0x0F, 0x81, 0xF0,
  0x0F, 0xC1, 0xF0, 0x07, 0xC3, 0xE0, 0x07, 0xC3, 0xE0, 0x03, 0xE7, 0xC0,
  0x03, 0xE7, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x03, 0xE7, 0xC0, 0x03, 0xE7, 0xC0, 0x07, 0xC3, 0xE0, 0x07, 0xC3, 0xE0,
  0x0F, 0xC3, 0xF0, 0x0F, 0x81, 0xF0, 0x1F, 0x81, 0xF8, 0x1F, 0x00, 0xF8,
  0x3F, 0x00, 0xFC, 0x3E, 0x00, 0x7C, 0x7E, 0x00, 0x7E, 0x7C, 0x00, 0x7E,
  0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0xFD, 0xF0, 0x01, 0xF3,
  0xF0, 0x03, 0xE3, 0xE0, 0x0F, 0xC7, 0xC0, 0x1F, 0x07, 0xC0, 0x3E, 0x0F,
  0x80, 0xF8, 0x1F, 0x81, 0xF0, 0x1F, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x3E,
  0x1F, 0x00, 0x7C, 0x7C, 0x00, 0xFC, 0xF8, 0x00, 0xFB, 0xE0, 0x01, 0xF7,
  0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x7F,
  0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x1E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01,
  0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0x78, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0,
  0x01, 0xF7, 0x80, 0x03, 0xCF, 0x80, 0x07, 0x8F, 0x00, 0x1E, 0x1F, 0x00,
  0x3C, 0x1E, 0x00, 0xF0, 0x3E, 0x01, 0xE0, 0x3C, 0x07, 0xC0, 0x7C, 0x0F,
  0x00, 0x78, 0x3E, 0x00, 0xF8, 0x78, 0x00, 0xF1, 0xF0, 0x01, 0xF3, 0xC0,
  0x01, 0xEF, 0x80, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0x83, 0xE0, 0x7C, 0x0F, 0x81, 0xE0,
  0x3C, 0x07, 0x07, 0xFE, 0x0F, 0xFF, 0xC3, 0xFF, 0xF8, 0x7F, 0xFE, 0x18,
  0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x1F, 0xFF, 0x1F, 0xFF, 0xCF, 0xFF, 0xF7, 0xF0, 0x7D,
  0xF0, 0x1F, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFE, 0x03, 0xFF, 0xC1, 0xFD, 0xFF, 0xFF, 0x7F, 0xFB, 0xCF, 0xFC,
  0xF1, 0xFE, 0x1C, 0x08, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF1, 0xFE,
  0x0F, 0x9F, 0xF8, 0x7D, 0xFF, 0xE3, 0xFF, 0xFF, 0x9F, 0xE0, 0xFC, 0xFE,
  0x03, 0xF7, 0xE0, 0x0F, 0xBF, 0x00, 0x7D, 0xF8, 0x03, 0xEF, 0xC0, 0x1F,
  0x7C, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0x7E, 0x00, 0xFB,
  0xF0, 0x07, 0xDF, 0x80, 0x3E, 0xFE, 0x03, 0xF7, 0xF8, 0x3F, 0x3F, 0xFF,
  0xF9, 0xF7, 0xFF, 0x8F, 0x9F, 0xF8, 0x78, 0x7F, 0x80, 0x00, 0x40, 0x00,
  0x00, 0x20, 0x01, 0xFF, 0x81, 0xFF, 0xE3, 0xFF, 0xE1, 0xFF, 0xF1, 0xF8,
  0x18, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0x7E, 0x02, 0x3F, 0xFF, 0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0x7F, 0xC0,
  0x02, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x20, 0x3E, 0x0F, 0xF1, 0xF0, 0xFF, 0xCF,
  0x8F, 0xFF, 0x7C, 0xFF, 0xFF, 0xE7, 0xE0, 0xFF, 0x7E, 0x03, 0xFB, 0xE0,
  0x0F, 0xDF, 0x00, 0x7E, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xBE, 0x00, 0xFD, 0xF0, 0x07, 0xEF,
  0x80, 0x3F, 0x7E, 0x03, 0xF9, 0xF8, 0x3F, 0xCF, 0xFF, 0xFE, 0x3F, 0xFD,
  0xF0, 0xFF, 0xCF, 0x83, 0xFC, 0x7C, 0x02, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0xFF, 0xF0, 0x1F, 0xFF, 0x81, 0xFF, 0xFC, 0x3E, 0x07, 0xC3, 0xE0, 0x3E,
  0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x01, 0xE7, 0x80, 0x1E, 0xF8, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x02, 0x3F, 0x00, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0,
  0x7F, 0xFC, 0x03, 0xFF, 0x80, 0x03, 0x00, 0x01, 0xFE, 0x0F, 0xFC, 0x1F,
  0xF8, 0x7F, 0xE0, 0xF8, 0x43, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x01, 0xFF, 0xCF, 0xFF, 0x9F, 0xFF, 0x3F, 0xFE, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x3F, 0xC7,
  0xC3, 0xFF, 0x3E, 0x3F, 0xFD, 0xF3, 0xFF, 0xFF, 0x9F, 0x83, 0xFD, 0xF8,
  0x0F, 0xEF, 0x80, 0x3F, 0x7C, 0x01, 0xFB, 0xE0, 0x0F, 0xFF, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00,
  0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7E, 0xF8, 0x03, 0xF7,
  0xC0, 0x1F, 0xBE, 0x00, 0xFD, 0xF8, 0x0F, 0xE7, 0xE0, 0xFF, 0x3F, 0xFE,
  0xF8, 0xFF, 0xF7, 0xC3, 0xFF, 0x3E, 0x0F, 0xF1, 0xF0, 0x08, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x88, 0x00, 0xF8, 0x7C, 0x3F, 0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0xFF,
  0xFC, 0x00, 0xFF, 0x80, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x8F, 0xF0, 0xF9, 0xFF,
  0x8F, 0xBF, 0xFC, 0xFF, 0xFF, 0xEF, 0xF0, 0x7E, 0xFE, 0x03, 0xEF, 0xC0,
  0x3E, 0xFC, 0x03, 0xEF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0x7B, 0xFF, 0xFF, 0xF9, 0xE0, 0x00, 0x00, 0x0F, 0xBE,
  0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE,
  0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xF8, 0x07, 0x83, 0xF0, 0xFC, 0x3F,
  0x0F, 0x81, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8,
  0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F,
  0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0xF8, 0x3E, 0x9F, 0xBF, 0xEF, 0xF3, 0xF8, 0xF8, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x3F, 0xF8, 0x07, 0xCF, 0x80, 0xFC, 0xF8, 0x0F, 0x8F, 0x81,
  0xF0, 0xF8, 0x3F, 0x0F, 0x83, 0xE0, 0xF8, 0x7C, 0x0F, 0x8F, 0x80, 0xF9,
  0xF8, 0x0F, 0x9F, 0x00, 0xFB, 0xF0, 0x0F, 0xBF, 0x00, 0xFF, 0xF8, 0x0F,
  0xFF, 0x80, 0xFE, 0x7C, 0x0F, 0xC7, 0xC0, 0xF8, 0x3E, 0x0F, 0x83, 0xF0,
  0xF8, 0x1F, 0x0F, 0x81, 0xF8, 0xF8, 0x0F, 0x8F, 0x80, 0xFC, 0xF8, 0x07,
  0xCF, 0x80, 0x7E, 0xF8, 0x03, 0xEF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x10, 0x00, 0x40,
  0xF0, 0xFF, 0x07, 0xF8, 0xF9, 0xFF, 0x8F, 0xFC, 0xFB, 0xFF, 0xDF, 0xFE,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x0F, 0xF8, 0x3F, 0xFE, 0x07, 0xF0, 0x1F,
  0xFC, 0x03, 0xF0, 0x1F, 0xFC, 0x03, 0xE0, 0x1F, 0xFC, 0x03, 0xE0, 0x1F,
  0xFC, 0x03, 0xE0, 0x0F, 0xF8, 0x03, 0xE0, 0x0F, 0xF8, 0x03, 0xE0, 0x0F,
  0xF8, 0x03, 0xE0, 0x0F, 0xF8, 0x03, 0xE0, 0x0F, 0xF8, 0x03, 0xE0, 0x0F,
  0xF8, 0x03, 0xE0, 0x0F, 0xF8, 0x03, 0xE0, 0x0F, 0xF8, 0x03, 0xE0, 0x0F,
  0xF8, 0x03, 0xE0, 0x0F, 0xF8, 0x03, 0xE0, 0x0F, 0xF8, 0x03, 0xE0, 0x0F,
  0xF8, 0x03, 0xE0, 0x0F, 0xF8, 0x03, 0xE0, 0x0F, 0xF8, 0x03, 0xE0, 0x0F,
  0xF8, 0x03, 0xE0, 0x0F, 0xF8, 0x03, 0xE0, 0x0F, 0xF8, 0x03, 0xE0, 0x0F,
  0x00, 0x10, 0x0F, 0x0F, 0xF0, 0xF9, 0xFF, 0x8F, 0xBF, 0xFC, 0xFF, 0xFF,
  0xEF, 0xF0, 0x7E, 0xFE, 0x03, 0xEF, 0xC0, 0x3E, 0xFC, 0x03, 0xEF, 0xC0,
  0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0x00, 0x20,
  0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x1F,
  0x83, 0xF0, 0xF8, 0x0F, 0xCF, 0x80, 0x3E, 0x7C, 0x01, 0xF3, 0xE0, 0x0F,
  0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x3E,
  0xF8, 0x03, 0xE7, 0xC0, 0x1F, 0x3E, 0x00, 0xF8, 0xF8, 0x0F, 0xC7, 0xE0,
  0xFC, 0x1F, 0xFF, 0xC0, 0x7F, 0xFE, 0x01, 0xFF, 0xE0, 0x07, 0xFC, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x10, 0x07, 0xC7, 0xF8, 0x3E, 0x7F, 0xE1, 0xF7,
  0xFF, 0x8F, 0xFF, 0xFE, 0x7F, 0x83, 0xF3, 0xF8, 0x0F, 0xDF, 0x80, 0x3E,
  0xFC, 0x01, 0xF7, 0xE0, 0x0F, 0xBF, 0x00, 0x7D, 0xF0, 0x03, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x7D, 0xF8, 0x03, 0xEF, 0xC0, 0x1F, 0x7E, 0x00,
  0xFB, 0xF8, 0x0F, 0x9F, 0xE0, 0xFC, 0xFF, 0xFF, 0xE7, 0xDF, 0xFE, 0x3E,
  0x7F, 0xE1, 0xF1, 0xFE, 0x0F, 0x81, 0x80, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x3F, 0xC7, 0xC3, 0xFF, 0x3E, 0x3F, 0xFD, 0xF3, 0xFF,
  0xFF, 0x9F, 0x83, 0xFD, 0xF8, 0x0F, 0xEF, 0x80, 0x3F, 0x7C, 0x01, 0xFB,
  0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x7E, 0xF8, 0x03, 0xF7, 0xC0, 0x1F, 0xBE, 0x00, 0xFD, 0xF8, 0x0F,
  0xE7, 0xE0, 0xFF, 0x3F, 0xFE, 0xF8, 0xFF, 0xF7, 0xC3, 0xFF, 0x3E, 0x0F,
  0xF1, 0xF0, 0x08, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x13, 0xC3,
  0xFF, 0x1F, 0xFE, 0xFF, 0xFB, 0xFB, 0xFF, 0xEF, 0xF0, 0x3F, 0x80, 0xFE,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x80,
  0x0F, 0xFC, 0x3F, 0xFF, 0x7F, 0xFE, 0x7F, 0xFE, 0xF8, 0x0C, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x7F, 0xC0,
  0x3F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x1F, 0xE0, 0x3E, 0xFF, 0xFE,
  0xFF, 0xFC, 0xFF, 0xF8, 0x7F, 0xF0, 0x03, 0x00, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xFF, 0xBF, 0xFE, 0xFF, 0xFB,
  0xFF, 0xE1, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7F,
  0xF0, 0xFF, 0xC3, 0xFF, 0x07, 0xFC, 0x03, 0x00, 0xF8, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x3E, 0xF8, 0x0F,
  0xDF, 0x83, 0xFB, 0xFF, 0xFF, 0x3F, 0xFD, 0xE3, 0xFF, 0x3C, 0x3F, 0xC7,
  0x80, 0x80, 0x00, 0xF8, 0x00, 0xFD, 0xF0, 0x03, 0xE7, 0xC0, 0x0F, 0x9F,
  0x00, 0x7C, 0x7C, 0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x80,
  0xF8, 0x1E, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3C, 0x03, 0xC1, 0xF0,
  0x0F, 0x87, 0xC0, 0x3E, 0x1F, 0x00, 0xF8, 0xF8, 0x01, 0xE3, 0xE0, 0x07,
  0xCF, 0x80, 0x1F, 0x3C, 0x00, 0x3D, 0xF0, 0x00, 0xF7, 0xC0, 0x03, 0xDE,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xDF, 0x00,
  0xFC, 0x03, 0xE7, 0xC0, 0x3F, 0x00, 0xF9, 0xF0, 0x1F, 0xE0, 0x3E, 0x3C,
  0x07, 0xF8, 0x0F, 0x8F, 0x81, 0xFE, 0x03, 0xC3, 0xE0, 0x7F, 0x81, 0xF0,
  0xF8, 0x1C, 0xE0, 0x7C, 0x3E, 0x0F, 0x3C, 0x1F, 0x07, 0x83, 0xCF, 0x07,
  0x81, 0xF0, 0xF3, 0xC3, 0xE0, 0x7C, 0x3C, 0xF0, 0xF8, 0x1F, 0x1F, 0x1E,
  0x3E, 0x03, 0xC7, 0x87, 0x8F, 0x00, 0xF9, 0xE1, 0xE3, 0xC0, 0x3E, 0x78,
  0x79, 0xF0, 0x0F, 0x9E, 0x1E, 0x7C, 0x01, 0xEF, 0x03, 0xDE, 0x00, 0x7B,
  0xC0, 0xF7, 0x80, 0x1E, 0xF0, 0x3D, 0xE0, 0x07, 0xFC, 0x0F, 0xF8, 0x01,
  0xFF, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x0F, 0xE0, 0x1F, 0xC0,
  0x03, 0xF8, 0x07, 0xF0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x1F, 0x00, 0x7E,
  0x00, 0xFC, 0x03, 0xF7, 0xC0, 0x3E, 0x7E, 0x07, 0xE3, 0xE0, 0x7C, 0x3F,
  0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x9F, 0x00, 0xF9, 0xF0, 0x0F, 0xBE, 0x00,
  0x7F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0x9F,
  0x00, 0xF9, 0xF0, 0x1F, 0x0F, 0x83, 0xF0, 0xF8, 0x3E, 0x07, 0xC7, 0xE0,
  0x7C, 0x7C, 0x03, 0xEF, 0xC0, 0x3E, 0xF8, 0x01, 0xF0, 0xF8, 0x00, 0xFD,
  0xF0, 0x03, 0xE7, 0xC0, 0x0F, 0x9F, 0x00, 0x7C, 0x3E, 0x01, 0xF0, 0xF8,
  0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3C, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x3E, 0x1F, 0x00,
  0x78, 0xF8, 0x01, 0xF3, 0xE0, 0x07, 0xCF, 0x80, 0x0F, 0x3C, 0x00, 0x3D,
  0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x04, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x7F,
  0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03,
  0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x3F,
  0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x0E, 0x00, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x3F,
  0x80, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0x80, 0x1F, 0x00, 0x7E, 0x0F, 0xF8, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0xC0,
  0x1F, 0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xFC, 0x01, 0xFE, 0x03, 0xFC, 0x01, 0xF8,
  0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE0, 0x01,
  0xF8, 0x03, 0xFC, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0x00,
  0x3F, 0xE0, 0x1F, 0xC0, 0x3F, 0x81, 0xFF, 0x03, 0xF0, 0x0F, 0x80, 0x1F,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x0F,
  0xC0, 0xFF, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0x80, 0x00, 0x3F, 0x00, 0x17,
  0xFE, 0x01, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xE1, 0xFF, 0xF8, 0x03, 0xFE,
  0x80, 0x0F, 0x80,
};

const GFXglyph NotoSans_Condensed_Medium50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 6, 37, 13, 3, -36 },
  { 29, 15, 13, 20, 3, -36 },
  { 54, 24, 36, 26, 1, -36 },
  { 162, 20, 41, 24, 2, -38 },
  { 265, 33, 36, 37, 2, -36 },
  { 414, 27, 37, 29, 2, -36 },
  { 539, 5, 13, 11, 3, -36 },
  { 548, 12, 44, 15, 2, -36 },
  { 614, 12, 44, 15, 1, -36 },
  { 680, 19, 19, 23, 2, -38 },
  { 726, 20, 24, 24, 2, -30 },
  { 786, 7, 13, 12, 2, -6 },
  { 798, 12, 5, 15, 1, -16 },
  { 806, 6, 8, 12, 3, -7 },
  { 812, 18, 36, 19, 1, -36 },
  { 893, 20, 37, 24, 2, -36 },
  { 986, 14, 36, 24, 3, -36 },
  { 1049, 20, 36, 24, 2, -36 },
  { 1139, 20, 37, 24, 2, -36 },
  { 1232, 22, 36, 24, 1, -36 },
  { 1331, 19, 37, 24, 3, -36 },
  { 1419, 20, 37, 24, 2, -36 },
  { 1512, 20, 36, 24, 2, -36 },
  { 1602, 20, 37, 24, 2, -36 },
  { 1695, 20, 37, 24, 2, -36 },
  { 1788, 6, 28, 12, 3, -27 },
  { 1809, 7, 34, 12, 2, -27 },
  { 1839, 20, 24, 24, 2, -30 },
  { 1899, 20, 15, 24, 2, -25 },
  { 1937, 20, 24, 24, 2, -30 },
  { 1997, 17, 37, 18, 0, -36 },
  { 2076, 33, 40, 37, 2, -36 },
  { 2241, 26, 36, 26, 0, -36 },
  { 2358, 21, 36, 27, 4, -36 },
  { 2453, 21, 37, 26, 3, -36 },
  { 2551, 23, 36, 29, 4, -36 },
  { 2655, 16, 36, 23, 4, -36 },
  { 2727, 16, 36, 22, 4, -36 },
  { 2799, 24, 37, 30, 3, -36 },
  { 2910, 23, 36, 30, 4, -36 },
  { 3014, 12, 36, 16, 2, -36 },
  { 3068, 12, 46, 13, -3, -36 },
  { 3137, 22, 36, 26, 4, -36 },
  { 3236, 16, 36, 21, 4, -36 },
  { 3308, 32, 36, 39, 4, -36 },
  { 3452, 24, 36, 32, 4, -36 },
  { 3560, 26, 37, 31, 3, -36 },
  { 3681, 19, 36, 25, 4, -36 },
  { 3767, 26, 45, 31, 3, -36 },
  { 3914, 22, 36, 26, 4, -36 },
  { 4013, 19, 37, 23, 2, -36 },
  { 4101, 21, 36, 22, 1, -36 },
  { 4196, 22, 37, 30, 4, -36 },
  { 4298, 25, 36, 25, 0, -36 },
  { 4411, 39, 36, 40, 0, -36 },
  { 4587, 24, 36, 24, 0, -36 },
  { 4695, 23, 36, 23, 0, -36 },
  { 4799, 20, 36, 22, 1, -36 },
  { 4889, 11, 44, 16, 3, -36 },
  { 4950, 18, 36, 19, 1, -36 },
  { 5031, 11, 44, 16, 1, -36 },
  { 5092, 23, 21, 25, 1, -36 },
  { 5153, 22, 4, 22, 0, 4 },
  { 5164, 10, 8, 14, 2, -38 },
  { 5174, 18, 28, 24, 2, -27 },
  { 5237, 21, 39, 26, 3, -38 },
  { 5340, 17, 29, 20, 2, -28 },
  { 5402, 21, 39, 26, 2, -38 },
  { 5505, 20, 28, 24, 2, -27 },
  { 5575, 15, 38, 15, 1, -38 },
  { 5647, 21, 40, 26, 2, -28 },
  { 5752, 20, 38, 26, 3, -38 },
  { 5847, 6, 37, 12, 3, -37 },
  { 5875, 10, 49, 12, -1, -37 },
  { 5937, 20, 38, 23, 3, -38 },
  { 6032, 5, 38, 12, 3, -38 },
  { 6056, 32, 28, 39, 3, -28 },
  { 6168, 20, 28, 26, 3, -28 },
  { 6238, 21, 29, 25, 2, -28 },
  { 6315, 21, 40, 26, 3, -28 },
  { 6420, 21, 40, 26, 2, -28 },
  { 6525, 14, 28, 17, 3, -28 },
  { 6574, 16, 29, 20, 2, -28 },
  { 6632, 14, 34, 16, 1, -33 },
  { 6692, 19, 28, 26, 3, -27 },
  { 6759, 22, 27, 22, 0, -27 },
  { 6834, 34, 27, 34, 0, -27 },
  { 6949, 20, 27, 22, 1, -27 },
  { 7017, 22, 39, 22, 0, -27 },
  { 7125, 16, 27, 18, 1, -27 },
  { 7179, 15, 44, 18, 1, -36 },
  { 7262, 5, 50, 23, 9, -38 },
  { 7294, 15, 44, 18, 2, -36 },
  { 7377, 20, 7, 24, 2, -21 },
};

const GFXfont NotoSans_Condensed_Medium50pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Medium50pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Medium50pt7bGlyphs,
  0x20, 0x7E, 68
};

#endif // _NOTOSANS_CONDENSED_MEDIUM50PT7B_H_
