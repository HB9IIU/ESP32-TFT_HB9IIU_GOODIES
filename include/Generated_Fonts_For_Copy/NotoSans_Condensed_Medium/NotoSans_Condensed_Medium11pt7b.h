#ifndef _NOTOSANS_CONDENSED_MEDIUM11PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUM11PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Medium.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Medium11pt7bBitmaps[] PROGMEM = {
  0x00, 0xFD, 0xB6, 0x80, 0x28, 0xA7, 0xCC, 0x53, 0xE5, 0x14, 0x23, 0xF8,
  0xC3, 0x17, 0xE4, 0x20, 0x64, 0xA4, 0xA8, 0xAE, 0x75, 0x15, 0x15, 0x26,
  0x71, 0x45, 0x08, 0x77, 0x7C, 0x9D, 0xE0, 0x29, 0x2C, 0x92, 0x44, 0xC9,
  0x12, 0x4A, 0x50, 0x27, 0xD4, 0xA0, 0x21, 0x09, 0xF2, 0x10, 0x70, 0xE0,
  0x80, 0x11, 0x22, 0x44, 0x48, 0x72, 0x93, 0x9C, 0xA5, 0x6E, 0x7E, 0x92,
  0x49, 0xF2, 0xC6, 0x23, 0x11, 0x1F, 0x74, 0xC6, 0xE1, 0x04, 0x7E, 0x11,
  0x8C, 0xA5, 0x7C, 0x42, 0xE8, 0x8E, 0x31, 0x3E, 0x32, 0x10, 0xEC, 0xA5,
  0x2E, 0xF8, 0x44, 0x23, 0x10, 0x88, 0x72, 0x56, 0xE5, 0x67, 0x2E, 0x72,
  0xB3, 0x97, 0x84, 0x4E, 0xC4, 0x50, 0x1C, 0x08, 0xD9, 0x83, 0x84, 0xF8,
  0x3E, 0x86, 0x0C, 0x36, 0x40, 0xE1, 0x12, 0x44, 0x04, 0x39, 0x8A, 0xF5,
  0x5C, 0xBB, 0xAF, 0x40, 0x78, 0x30, 0xC3, 0x16, 0x49, 0xEC, 0xA3, 0xF9,
  0x9F, 0x99, 0x9F, 0x78, 0x88, 0x88, 0x87, 0xE4, 0xA3, 0x18, 0xC6, 0x5E,
  0xF2, 0x79, 0x27, 0xF2, 0x4F, 0x24, 0x7E, 0x21, 0x09, 0xC6, 0x2F, 0x8C,
  0x63, 0xF8, 0xC6, 0x31, 0xE9, 0x24, 0x97, 0x24, 0x92, 0x49, 0x3C, 0x9C,
  0xA9, 0x8E, 0x52, 0x53, 0x92, 0x49, 0x27, 0xC7, 0x8F, 0x2E, 0x5A, 0xB5,
  0x6C, 0xC9, 0x8E, 0x73, 0x5A, 0xCE, 0x71, 0x74, 0x63, 0x18, 0xC6, 0x2E,
  0xE9, 0x99, 0xE8, 0x88, 0x74, 0x63, 0x18, 0xC6, 0x2E, 0x10, 0x40, 0xE4,
  0xA5, 0x2E, 0x52, 0x53, 0x7A, 0x30, 0xC3, 0x0C, 0x7E, 0xF9, 0x08, 0x42,
  0x10, 0x84, 0x8C, 0x63, 0x18, 0xC6, 0x7E, 0x8E, 0x24, 0x92, 0x51, 0xC3,
  0x0C, 0x89, 0xC4, 0x96, 0x4A, 0xA5, 0x52, 0xB9, 0x98, 0x44, 0xCA, 0x94,
  0x63, 0x29, 0x71, 0x8A, 0xD4, 0xA2, 0x10, 0x84, 0xF0, 0x84, 0x42, 0x21,
  0x1F, 0xEA, 0xAA, 0xB0, 0x84, 0x44, 0x22, 0x31, 0xE4, 0x92, 0x49, 0x3C,
  0x21, 0x94, 0x98, 0x80, 0xF8, 0xE0, 0x71, 0x35, 0xD7, 0x88, 0xF9, 0x99,
  0x9F, 0x74, 0x4C, 0x47, 0x08, 0x5E, 0x94, 0xE5, 0x2F, 0x72, 0x5F, 0x84,
  0x3C, 0x74, 0xE4, 0x44, 0x44, 0x7A, 0x53, 0x94, 0xBC, 0x2B, 0x70, 0x88,
  0xF9, 0x99, 0x99, 0xBF, 0x45, 0x55, 0x58, 0x88, 0xBA, 0xCA, 0xA9, 0xFF,
  0xED, 0x26, 0x4C, 0x99, 0x32, 0x40, 0xF9, 0x99, 0x99, 0x72, 0x72, 0x94,
  0xB8, 0xF9, 0x99, 0x9F, 0x88, 0x80, 0x7A, 0x53, 0x94, 0xBC, 0x21, 0x08,
  0xF2, 0x49, 0x00, 0x78, 0x43, 0x1F, 0x5D, 0x24, 0x98, 0x99, 0x99, 0x9F,
  0x9E, 0x94, 0xA6, 0x10, 0x93, 0x35, 0x6B, 0x56, 0xCC, 0x80, 0xDA, 0x98,
  0xC5, 0x6C, 0x9E, 0x94, 0xA6, 0x10, 0x88, 0xC0, 0xF2, 0x24, 0x4F, 0x32,
  0x22, 0xC4, 0x22, 0x23, 0xFF, 0xE0, 0xC4, 0x66, 0x32, 0x66, 0x4C, 0x4D,
  0xC0,
};

const GFXglyph NotoSans_Condensed_Medium11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 8, 3, 1, -8 },
  { 2, 3, 3, 4, 1, -8 },
  { 4, 6, 8, 6, 0, -8 },
  { 10, 5, 9, 5, 0, -8 },
  { 16, 8, 8, 8, 0, -8 },
  { 24, 6, 8, 6, 0, -8 },
  { 30, 1, 3, 2, 1, -8 },
  { 31, 3, 10, 3, 0, -8 },
  { 35, 3, 10, 3, 0, -8 },
  { 39, 5, 4, 5, 0, -8 },
  { 42, 5, 6, 5, 0, -7 },
  { 46, 2, 2, 3, 0, -1 },
  { 47, 3, 1, 3, 0, -3 },
  { 48, 1, 1, 3, 1, -1 },
  { 49, 4, 8, 4, 0, -8 },
  { 53, 5, 8, 5, 0, -8 },
  { 58, 3, 8, 5, 1, -8 },
  { 61, 5, 8, 5, 0, -8 },
  { 66, 5, 8, 5, 0, -8 },
  { 71, 5, 8, 5, 0, -8 },
  { 76, 4, 8, 5, 1, -8 },
  { 80, 5, 8, 5, 0, -8 },
  { 85, 5, 8, 5, 0, -8 },
  { 90, 5, 8, 5, 0, -8 },
  { 95, 5, 8, 5, 0, -8 },
  { 100, 1, 6, 3, 1, -6 },
  { 101, 2, 7, 3, 0, -6 },
  { 103, 5, 6, 5, 0, -7 },
  { 107, 5, 3, 5, 0, -5 },
  { 109, 5, 6, 5, 0, -7 },
  { 113, 4, 8, 4, 0, -8 },
  { 117, 7, 9, 8, 1, -8 },
  { 125, 6, 8, 6, 0, -8 },
  { 131, 4, 8, 6, 1, -8 },
  { 135, 4, 8, 6, 1, -8 },
  { 139, 5, 8, 6, 1, -8 },
  { 144, 3, 8, 5, 1, -8 },
  { 147, 3, 8, 5, 1, -8 },
  { 150, 5, 8, 7, 1, -8 },
  { 155, 5, 8, 7, 1, -8 },
  { 160, 3, 8, 3, 0, -8 },
  { 163, 3, 10, 3, -1, -8 },
  { 167, 5, 8, 6, 1, -8 },
  { 172, 3, 8, 5, 1, -8 },
  { 175, 7, 8, 9, 1, -8 },
  { 182, 5, 8, 7, 1, -8 },
  { 187, 5, 8, 7, 1, -8 },
  { 192, 4, 8, 6, 1, -8 },
  { 196, 5, 10, 7, 1, -8 },
  { 203, 5, 8, 6, 1, -8 },
  { 208, 5, 8, 5, 0, -8 },
  { 213, 5, 8, 5, 0, -8 },
  { 218, 5, 8, 7, 1, -8 },
  { 223, 6, 8, 6, 0, -8 },
  { 229, 9, 8, 9, 0, -8 },
  { 238, 5, 8, 5, 0, -8 },
  { 243, 5, 8, 5, 0, -8 },
  { 248, 5, 8, 5, 0, -8 },
  { 253, 2, 10, 3, 1, -8 },
  { 256, 4, 8, 4, 0, -8 },
  { 260, 3, 10, 3, 0, -8 },
  { 264, 5, 5, 5, 0, -8 },
  { 268, 5, 1, 5, 0, 1 },
  { 269, 3, 1, 3, 0, -8 },
  { 270, 4, 6, 5, 0, -6 },
  { 273, 4, 8, 6, 1, -8 },
  { 277, 4, 6, 4, 0, -6 },
  { 280, 5, 8, 6, 0, -8 },
  { 285, 5, 6, 5, 0, -6 },
  { 289, 4, 8, 3, 0, -8 },
  { 293, 5, 9, 6, 0, -6 },
  { 299, 4, 8, 6, 1, -8 },
  { 303, 1, 8, 3, 1, -8 },
  { 304, 2, 11, 3, 0, -8 },
  { 307, 4, 8, 5, 1, -8 },
  { 311, 1, 8, 3, 1, -8 },
  { 312, 7, 6, 9, 1, -6 },
  { 318, 4, 6, 6, 1, -6 },
  { 321, 5, 6, 6, 0, -6 },
  { 325, 4, 9, 6, 1, -6 },
  { 330, 5, 9, 6, 0, -6 },
  { 336, 3, 6, 4, 1, -6 },
  { 339, 4, 6, 4, 0, -6 },
  { 342, 3, 7, 3, 0, -7 },
  { 345, 4, 6, 6, 1, -6 },
  { 348, 5, 6, 5, 0, -6 },
  { 352, 7, 6, 7, 0, -6 },
  { 358, 5, 6, 5, 0, -6 },
  { 362, 5, 9, 5, 0, -6 },
  { 368, 4, 6, 4, 0, -6 },
  { 371, 4, 10, 4, 0, -8 },
  { 376, 1, 11, 5, 2, -8 },
  { 378, 4, 10, 4, 0, -8 },
  { 383, 5, 2, 5, 0, -5 },
};

const GFXfont NotoSans_Condensed_Medium11pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Medium11pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Medium11pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _NOTOSANS_CONDENSED_MEDIUM11PT7B_H_
