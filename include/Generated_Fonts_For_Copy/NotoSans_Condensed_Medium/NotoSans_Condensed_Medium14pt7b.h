#ifndef _NOTOSANS_CONDENSED_MEDIUM14PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUM14PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Medium.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Medium14pt7bBitmaps[] PROGMEM = {
  0x00, 0xFA, 0xA8, 0xB0, 0xBB, 0x99, 0x14, 0x48, 0x93, 0xF2, 0xC5, 0x3F,
  0x94, 0x48, 0x90, 0x21, 0x3F, 0x4A, 0x70, 0xE5, 0x2F, 0x88, 0x40, 0xE2,
  0x52, 0x29, 0x15, 0x0A, 0xB7, 0xE4, 0x52, 0x29, 0x24, 0x91, 0x80, 0x38,
  0x68, 0x68, 0x28, 0x30, 0x7B, 0x4A, 0xCE, 0x4E, 0x7B, 0xF0, 0x6B, 0x49,
  0x24, 0x99, 0x30, 0xC6, 0x22, 0x23, 0x32, 0x22, 0x6C, 0x30, 0x47, 0xEC,
  0x68, 0xA0, 0x10, 0x4F, 0xFF, 0x10, 0x40, 0x69, 0x60, 0xF0, 0xB0, 0x08,
  0xC4, 0x23, 0x10, 0x88, 0x46, 0x00, 0x76, 0xE7, 0x18, 0xC6, 0x31, 0xDB,
  0x80, 0x37, 0xB3, 0x33, 0x33, 0x33, 0xF4, 0xC6, 0x31, 0x19, 0x88, 0x87,
  0xC0, 0xF4, 0xC6, 0x37, 0x18, 0x61, 0x9F, 0x80, 0x08, 0x61, 0x8A, 0x69,
  0x2C, 0xBF, 0x08, 0x20, 0xF4, 0x21, 0x0F, 0x0C, 0x21, 0x9F, 0x80, 0x7E,
  0x21, 0x0F, 0xC6, 0x31, 0xDB, 0x80, 0xFC, 0x10, 0xC2, 0x08, 0x61, 0x0C,
  0x21, 0x80, 0x79, 0x34, 0x5B, 0x39, 0xE4, 0x71, 0x45, 0xE0, 0x74, 0xE3,
  0x19, 0xFC, 0x23, 0x17, 0x00, 0xB0, 0x0B, 0x4C, 0x00, 0x1A, 0x58, 0x04,
  0x66, 0x38, 0x18, 0x10, 0xFC, 0x00, 0x3F, 0xC0, 0xC0, 0xC3, 0x33, 0x00,
  0xF4, 0xC6, 0x33, 0x10, 0x80, 0x63, 0x00, 0x3E, 0x31, 0xB0, 0x53, 0xBA,
  0x4D, 0x26, 0x97, 0x7E, 0x80, 0x20, 0x0F, 0x80, 0x18, 0x70, 0xA1, 0x62,
  0xCC, 0x9F, 0x23, 0xC7, 0x84, 0xFB, 0x3C, 0xF3, 0xFB, 0x2C, 0xF3, 0xCF,
  0xE0, 0x7D, 0x1C, 0x20, 0x82, 0x08, 0x30, 0x45, 0xE0, 0xF9, 0x9B, 0x16,
  0x2C, 0x78, 0xF1, 0x62, 0xCD, 0xF0, 0xFE, 0x31, 0x8F, 0x63, 0x18, 0xC7,
  0xC0, 0xFE, 0x31, 0x8C, 0x7B, 0x18, 0xC6, 0x00, 0x3E, 0xCB, 0x04, 0x08,
  0x11, 0xE1, 0xE3, 0x46, 0xFC, 0xC7, 0x1C, 0x71, 0xFF, 0x1C, 0x71, 0xC7,
  0x10, 0xF6, 0x66, 0x66, 0x66, 0x6F, 0x24, 0x92, 0x49, 0x24, 0xFC, 0xCF,
  0x2D, 0xBC, 0xE3, 0xCD, 0x36, 0xCB, 0x30, 0xC6, 0x31, 0x8C, 0x63, 0x18,
  0xC7, 0xC0, 0xC1, 0xF1, 0xE8, 0xB4, 0x5A, 0x2C, 0xA6, 0x53, 0x29, 0x9C,
  0xC4, 0x40, 0xC3, 0xC6, 0x8D, 0x99, 0x33, 0x62, 0xC5, 0x8F, 0x0C, 0x79,
  0x8B, 0x1C, 0x38, 0x30, 0x61, 0xE3, 0xC4, 0xF0, 0xF3, 0x6C, 0xF3, 0xCB,
  0xEC, 0x30, 0xC3, 0x00, 0x79, 0x8B, 0x1C, 0x38, 0x30, 0x61, 0xE3, 0xC4,
  0xF0, 0x20, 0x70, 0xF3, 0x6C, 0xF3, 0xDB, 0xCD, 0x36, 0xCB, 0x30, 0x7C,
  0x61, 0x0E, 0x18, 0x63, 0x9F, 0x80, 0xFC, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC0, 0x86, 0x18, 0x61, 0x86, 0x18, 0x71, 0xCD, 0xE0, 0xC3, 0x8D,
  0x12, 0x26, 0xC5, 0x8A, 0x14, 0x38, 0x20, 0xC4, 0x38, 0xCD, 0x29, 0x25,
  0x24, 0xA4, 0xD5, 0x9E, 0xF1, 0x8C, 0x31, 0x86, 0x30, 0xC4, 0x99, 0xA1,
  0xC3, 0x07, 0x0A, 0x34, 0x4D, 0x8C, 0xC6, 0x99, 0x23, 0x43, 0x86, 0x04,
  0x08, 0x10, 0x20, 0xFC, 0x21, 0x84, 0x10, 0xC2, 0x18, 0x43, 0xF0, 0xF2,
  0x49, 0x24, 0x92, 0x70, 0xC2, 0x10, 0xC2, 0x18, 0x42, 0x18, 0x40, 0xE4,
  0x92, 0x49, 0x24, 0xF0, 0x10, 0x70, 0xA3, 0x64, 0x58, 0xC0, 0xFC, 0xB4,
  0x39, 0xA0, 0xC7, 0x6F, 0x34, 0xDD, 0x82, 0x08, 0x2C, 0xFB, 0x28, 0xE3,
  0x8F, 0x2B, 0x80, 0x7F, 0x88, 0x88, 0xC7, 0x08, 0x42, 0xDD, 0xC6, 0x31,
  0x8E, 0xDE, 0x66, 0xE3, 0xFF, 0xC3, 0x2F, 0x3B, 0x98, 0xEF, 0x31, 0x8C,
  0x63, 0x18, 0x6E, 0xE3, 0x18, 0xC7, 0x6F, 0x08, 0x7E, 0x84, 0x21, 0x6F,
  0xE6, 0x31, 0x8C, 0x62, 0xBF, 0xC0, 0x45, 0x55, 0x55, 0xC0, 0x84, 0x21,
  0x19, 0xDA, 0x9E, 0x94, 0xE2, 0xFF, 0xE0, 0xB3, 0x7F, 0xF2, 0x71, 0x18,
  0x8C, 0x46, 0x23, 0x11, 0xB7, 0xF3, 0x18, 0xC6, 0x31, 0x76, 0xE3, 0x18,
  0xC7, 0x2E, 0xB3, 0xEC, 0xA3, 0x8E, 0x3C, 0xAE, 0x82, 0x08, 0x00, 0x6E,
  0xE3, 0x18, 0xC7, 0x6F, 0x08, 0x42, 0xBF, 0xC8, 0x88, 0x88, 0x6B, 0x8C,
  0x61, 0x9E, 0x47, 0xF4, 0x44, 0x46, 0x70, 0x8C, 0x63, 0x18, 0xC7, 0x6F,
  0x87, 0x34, 0x92, 0x68, 0xE3, 0x0C, 0xCC, 0xE6, 0x53, 0x2A, 0xB5, 0x53,
  0x98, 0xCC, 0x66, 0xCD, 0x27, 0x8C, 0x31, 0xE4, 0xB3, 0xC7, 0x34, 0x92,
  0x78, 0xE3, 0x0C, 0x30, 0x8E, 0x00, 0x7B, 0xC4, 0x62, 0x31, 0x1F, 0x19,
  0x08, 0x42, 0x33, 0x84, 0x21, 0x08, 0x70, 0xFF, 0xFC, 0xC4, 0x44, 0x46,
  0x74, 0x44, 0x4C, 0x66, 0x70,
};

const GFXglyph NotoSans_Condensed_Medium14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 2, 10, 4, 1, -10 },
  { 4, 4, 4, 6, 1, -10 },
  { 6, 7, 10, 7, 0, -10 },
  { 15, 5, 12, 7, 1, -11 },
  { 23, 9, 10, 10, 1, -10 },
  { 35, 8, 10, 8, 0, -10 },
  { 45, 1, 4, 3, 1, -10 },
  { 46, 3, 12, 4, 1, -10 },
  { 51, 4, 12, 4, 0, -10 },
  { 57, 6, 6, 6, 0, -11 },
  { 62, 6, 6, 7, 0, -8 },
  { 67, 3, 4, 3, 0, -2 },
  { 69, 4, 1, 4, 0, -4 },
  { 70, 2, 2, 3, 1, -2 },
  { 71, 5, 10, 5, 0, -10 },
  { 78, 5, 10, 7, 1, -10 },
  { 85, 4, 10, 7, 1, -10 },
  { 90, 5, 10, 7, 1, -10 },
  { 97, 5, 10, 7, 1, -10 },
  { 104, 6, 10, 7, 0, -10 },
  { 112, 5, 10, 7, 1, -10 },
  { 119, 5, 10, 7, 1, -10 },
  { 126, 6, 10, 7, 0, -10 },
  { 134, 6, 10, 7, 0, -10 },
  { 142, 5, 10, 7, 1, -10 },
  { 149, 2, 8, 3, 1, -8 },
  { 151, 3, 10, 3, 0, -8 },
  { 155, 6, 6, 7, 0, -8 },
  { 160, 6, 4, 7, 0, -7 },
  { 163, 6, 6, 7, 0, -8 },
  { 168, 5, 10, 5, 0, -10 },
  { 175, 9, 11, 10, 1, -10 },
  { 188, 7, 10, 7, 0, -10 },
  { 197, 6, 10, 8, 1, -10 },
  { 205, 6, 10, 7, 1, -10 },
  { 213, 7, 10, 8, 1, -10 },
  { 222, 5, 10, 6, 1, -10 },
  { 229, 5, 10, 6, 1, -10 },
  { 236, 7, 10, 8, 1, -10 },
  { 245, 6, 10, 9, 1, -10 },
  { 253, 4, 10, 4, 0, -10 },
  { 258, 3, 13, 4, -1, -10 },
  { 263, 6, 10, 7, 1, -10 },
  { 271, 5, 10, 6, 1, -10 },
  { 278, 9, 10, 11, 1, -10 },
  { 290, 7, 10, 9, 1, -10 },
  { 299, 7, 10, 9, 1, -10 },
  { 308, 6, 10, 7, 1, -10 },
  { 316, 7, 12, 9, 1, -10 },
  { 327, 6, 10, 7, 1, -10 },
  { 335, 5, 10, 6, 1, -10 },
  { 342, 6, 10, 6, 0, -10 },
  { 350, 6, 10, 8, 1, -10 },
  { 358, 7, 10, 7, 0, -10 },
  { 367, 11, 10, 11, 0, -10 },
  { 381, 7, 10, 7, 0, -10 },
  { 390, 7, 10, 7, 0, -10 },
  { 399, 6, 10, 6, 0, -10 },
  { 407, 3, 12, 4, 1, -10 },
  { 412, 5, 10, 5, 0, -10 },
  { 419, 3, 12, 4, 0, -10 },
  { 424, 7, 6, 7, 0, -10 },
  { 430, 6, 1, 6, 0, 1 },
  { 431, 2, 3, 4, 1, -11 },
  { 432, 6, 8, 7, 0, -8 },
  { 438, 6, 11, 7, 1, -11 },
  { 447, 4, 8, 6, 1, -8 },
  { 451, 5, 11, 7, 1, -11 },
  { 458, 5, 8, 7, 1, -8 },
  { 463, 5, 11, 4, 0, -11 },
  { 470, 5, 11, 7, 1, -8 },
  { 477, 5, 11, 7, 1, -11 },
  { 484, 1, 10, 3, 1, -10 },
  { 486, 2, 13, 3, 0, -10 },
  { 490, 5, 11, 7, 1, -11 },
  { 497, 1, 11, 3, 1, -11 },
  { 499, 9, 8, 11, 1, -8 },
  { 508, 5, 8, 7, 1, -8 },
  { 513, 5, 8, 7, 1, -8 },
  { 518, 6, 11, 7, 1, -8 },
  { 527, 5, 11, 7, 1, -8 },
  { 534, 4, 8, 5, 1, -8 },
  { 538, 4, 8, 5, 1, -8 },
  { 542, 4, 9, 4, 0, -9 },
  { 547, 5, 8, 7, 1, -8 },
  { 552, 6, 8, 6, 0, -8 },
  { 558, 9, 8, 10, 0, -8 },
  { 567, 6, 8, 6, 0, -8 },
  { 573, 6, 11, 6, 0, -8 },
  { 582, 5, 8, 5, 0, -8 },
  { 587, 5, 12, 5, 0, -10 },
  { 595, 1, 14, 6, 3, -11 },
  { 597, 4, 12, 5, 1, -10 },
  { 603, 6, 2, 7, 0, -6 },
};

const GFXfont NotoSans_Condensed_Medium14pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Medium14pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Medium14pt7bGlyphs,
  0x20, 0x7E, 19
};

#endif // _NOTOSANS_CONDENSED_MEDIUM14PT7B_H_
