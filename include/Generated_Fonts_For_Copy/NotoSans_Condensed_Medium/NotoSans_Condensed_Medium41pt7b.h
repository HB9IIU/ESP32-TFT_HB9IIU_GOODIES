#ifndef _NOTOSANS_CONDENSED_MEDIUM41PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUM41PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Medium.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Medium41pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7,
  0x9C, 0xE0, 0x00, 0x00, 0xF7, 0xFF, 0xFF, 0x00, 0xF8, 0xFF, 0x8F, 0x78,
  0xF7, 0x8F, 0x70, 0xF7, 0x0F, 0x70, 0xF7, 0x0F, 0x70, 0x77, 0x07, 0x01,
  0xC3, 0x80, 0x3C, 0x38, 0x03, 0x83, 0x80, 0x38, 0x78, 0x03, 0x87, 0x00,
  0x38, 0x70, 0x03, 0x87, 0x00, 0x38, 0x70, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF,
  0x7F, 0xFF, 0xF0, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0x70, 0xE0, 0x07, 0x0E,
  0x00, 0xF0, 0xE0, 0x0E, 0x1E, 0x0F, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFE, 0x0E, 0x1C, 0x00, 0xE1, 0xC0, 0x1E, 0x1C, 0x01, 0xC3, 0xC0, 0x1C,
  0x38, 0x01, 0xC3, 0x80, 0x1C, 0x38, 0x01, 0xC3, 0x80, 0x1C, 0x38, 0x00,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x07, 0xE0, 0x1F, 0xFE, 0x3F, 0xFE,
  0x7F, 0xFE, 0xF9, 0x84, 0xF1, 0x80, 0xF1, 0x80, 0xF1, 0x80, 0xF1, 0x80,
  0xF9, 0x80, 0x7D, 0x80, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xF8, 0x01, 0xFC,
  0x01, 0xFE, 0x01, 0x9E, 0x01, 0x8F, 0x01, 0x8F, 0x01, 0x8F, 0x01, 0x8F,
  0xC1, 0x9E, 0xF9, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0x1F, 0xE0, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x07, 0xE0, 0x0F,
  0x01, 0xFE, 0x01, 0xC0, 0x39, 0xC0, 0x38, 0x0E, 0x1C, 0x0E, 0x01, 0xC3,
  0x81, 0xC0, 0x38, 0x70, 0x78, 0x07, 0x0E, 0x0E, 0x00, 0xE1, 0xC3, 0xC0,
  0x1C, 0x3C, 0x70, 0x03, 0x87, 0x0E, 0x00, 0x70, 0xE3, 0x80, 0x0E, 0x1C,
  0x71, 0xE1, 0xC3, 0x9E, 0x7F, 0x38, 0x73, 0x9F, 0xE3, 0x9C, 0xF3, 0x9E,
  0x7F, 0x9C, 0xF1, 0xC7, 0xE3, 0x9C, 0x3C, 0x30, 0xF3, 0x87, 0x80, 0x1C,
  0x70, 0xF0, 0x07, 0x8E, 0x0E, 0x00, 0xE1, 0xC1, 0xC0, 0x1C, 0x38, 0x78,
  0x07, 0x07, 0x0F, 0x00, 0xE0, 0xE1, 0xE0, 0x3C, 0x1E, 0x38, 0x07, 0x01,
  0xC7, 0x01, 0xE0, 0x3F, 0xE0, 0x38, 0x03, 0xF8, 0x0F, 0x00, 0x3E, 0x00,
  0x01, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1E,
  0x1E, 0x00, 0x78, 0x78, 0x01, 0xE1, 0xE0, 0x07, 0x87, 0x80, 0x1E, 0x1E,
  0x00, 0x78, 0x78, 0x01, 0xF3, 0xC0, 0x03, 0xDE, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF8, 0x1E, 0x3F, 0xF0, 0x78, 0xF3,
  0xE1, 0xE7, 0xC7, 0x8F, 0x9E, 0x0F, 0x3C, 0x78, 0x3E, 0xF3, 0xE0, 0x7F,
  0xCF, 0x80, 0xFE, 0x3E, 0x01, 0xF8, 0x78, 0x07, 0xC1, 0xF0, 0x3F, 0x87,
  0xE3, 0xFF, 0x0F, 0xFF, 0xBC, 0x1F, 0xFC, 0xF8, 0x3F, 0xC1, 0xF0, 0xFF,
  0xDE, 0xF7, 0x39, 0xCE, 0x73, 0x80, 0x07, 0x87, 0x83, 0xC3, 0xC1, 0xE1,
  0xE0, 0xF0, 0xF0, 0x78, 0x3C, 0x1E, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0x78, 0x3C, 0x1E,
  0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x3C, 0x0E, 0x07, 0x81, 0xE0, 0xF0, 0x1E,
  0x03, 0xC0, 0xF0, 0x1E, 0x07, 0x80, 0xE0, 0x3C, 0x0F, 0x01, 0xC0, 0x78,
  0x1E, 0x07, 0x81, 0xE0, 0x78, 0x0E, 0x03, 0x80, 0xF0, 0x38, 0x0E, 0x07,
  0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x0F, 0x07, 0x81,
  0xE0, 0xF0, 0x3C, 0x1E, 0x0F, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x41, 0xC3, 0x79, 0xDF, 0x7F, 0xFF, 0xFF, 0xFF, 0x03, 0xC0,
  0x07, 0xE0, 0x0F, 0xF0, 0x0E, 0x78, 0x1E, 0x3C, 0x3E, 0x3C, 0x0C, 0x18,
  0x04, 0x10, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x3E, 0x7C, 0xF1, 0xE3, 0xCF,
  0x1E, 0x3C, 0x71, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x79, 0xFF, 0xDF,
  0x78, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0,
  0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00,
  0x3C, 0x00, 0xF0, 0x00, 0x01, 0x80, 0x0F, 0xF0, 0x1F, 0xF8, 0x3F, 0xFC,
  0x7C, 0x7C, 0x78, 0x3E, 0x78, 0x1E, 0xF8, 0x1E, 0xF0, 0x1E, 0xF0, 0x1F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1E, 0xF8, 0x1E, 0x78, 0x1E, 0x78, 0x3C, 0x7E, 0x7C, 0x3F, 0xF8,
  0x1F, 0xF8, 0x0F, 0xE0, 0x03, 0xE0, 0xFC, 0x3F, 0x8F, 0xF3, 0xFE, 0xFB,
  0xFE, 0xFF, 0x9F, 0x63, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x03, 0x80, 0x3F, 0xF0,
  0x7F, 0xF8, 0xFF, 0xFC, 0xF0, 0x7C, 0x60, 0x3E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C,
  0x00, 0x78, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x78, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x80, 0x3F, 0xF0,
  0xFF, 0xF8, 0xFF, 0xFC, 0xF0, 0x7E, 0x40, 0x3E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0xF8, 0x1F, 0xF0,
  0x1F, 0xC0, 0x1F, 0xF0, 0x1F, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1E,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x80, 0x3E,
  0xE0, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0x7F, 0xE0, 0x00, 0x3E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x77, 0x80, 0x1D, 0xE0,
  0x0E, 0x78, 0x03, 0x9E, 0x01, 0xC7, 0x80, 0x71, 0xE0, 0x38, 0x78, 0x1E,
  0x1E, 0x07, 0x07, 0x83, 0xC1, 0xE0, 0xE0, 0x78, 0x78, 0x1E, 0x1C, 0x07,
  0x8F, 0x01, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00,
  0x7F, 0xE0, 0x7F, 0xF8, 0xFF, 0xFC, 0x31, 0xFE, 0x00, 0x3E, 0x00, 0x1E,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E,
  0x00, 0x1E, 0x80, 0x3E, 0xF0, 0xFC, 0xFF, 0xFC, 0xFF, 0xF0, 0x7F, 0xE0,
  0x00, 0x78, 0x03, 0xFC, 0x0F, 0xFC, 0x1F, 0xFC, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0xC0,
  0xF3, 0xF8, 0xF7, 0xFC, 0xFF, 0xFE, 0xFC, 0x3E, 0xF8, 0x1E, 0xF0, 0x1F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x0F,
  0x78, 0x1E, 0x7C, 0x1E, 0x3E, 0x3E, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01,
  0xF0, 0x00, 0x01, 0xE0, 0x07, 0xFC, 0x07, 0xFF, 0x87, 0xFF, 0xC3, 0xC1,
  0xF3, 0xE0, 0x79, 0xE0, 0x3C, 0xF0, 0x1E, 0x78, 0x0F, 0x1E, 0x07, 0x8F,
  0x07, 0xC7, 0xC3, 0xC1, 0xF7, 0xC0, 0x7F, 0xC0, 0x1F, 0xC0, 0x1F, 0xF0,
  0x1F, 0xFC, 0x1F, 0x1F, 0x0F, 0x07, 0xCF, 0x01, 0xF7, 0x80, 0x7B, 0xC0,
  0x3F, 0xC0, 0x1F, 0xF0, 0x0F, 0x78, 0x07, 0xBC, 0x07, 0xDF, 0x07, 0xC7,
  0xFF, 0xE1, 0xFF, 0xE0, 0x7F, 0xC0, 0x03, 0x80, 0x1F, 0xE0, 0x3F, 0xF8,
  0x7F, 0xF8, 0x7C, 0x7C, 0xF8, 0x3E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x3F,
  0x7C, 0x7F, 0x7F, 0xEF, 0x3F, 0xEF, 0x1F, 0xCE, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x41, 0xF8,
  0x7F, 0xF0, 0x7F, 0xE0, 0x7F, 0x80, 0x79, 0xFF, 0xDF, 0x78, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE7, 0xFF, 0x7D, 0xE0, 0x3C,
  0x7D, 0xF9, 0xF3, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0xF9, 0xE3, 0xC7, 0x9E, 0x3C, 0x78, 0xE3, 0xC0, 0x00,
  0x00, 0x80, 0x01, 0xC0, 0x03, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0x80,
  0x01, 0xC0, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xC0, 0x00, 0x78, 0x00, 0x3F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80,
  0x03, 0xC0, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01,
  0xFC, 0x00, 0xF8, 0x00, 0x70, 0x00, 0x20, 0x00, 0x00, 0x07, 0x00, 0xFF,
  0xCF, 0xFF, 0x9F, 0xFE, 0x70, 0x7D, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x00,
  0xF0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFF, 0x80,
  0x0F, 0xC3, 0xF0, 0x07, 0x80, 0x1E, 0x03, 0xC0, 0x03, 0xC1, 0xE0, 0x00,
  0x70, 0xF0, 0x00, 0x1E, 0x38, 0x06, 0x03, 0x9E, 0x0F, 0xF8, 0xF7, 0x07,
  0xFE, 0x1D, 0xC3, 0xC3, 0x87, 0x70, 0xE0, 0xE1, 0xFC, 0x38, 0x38, 0x7E,
  0x1E, 0x0E, 0x1F, 0x87, 0x07, 0x87, 0xE1, 0xC1, 0xE1, 0xF8, 0x70, 0x78,
  0x7E, 0x1C, 0x1E, 0x1F, 0x87, 0x07, 0x87, 0xE1, 0xC1, 0xE1, 0xF8, 0x78,
  0xF8, 0xEF, 0x0F, 0x77, 0x7B, 0xC3, 0xFD, 0xFC, 0x70, 0x7E, 0x3E, 0x1E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0xC0, 0x04, 0x00, 0xFF, 0x3F, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFE, 0x00, 0x07, 0x78, 0x00, 0x3D, 0xE0, 0x00, 0xF3, 0x80,
  0x03, 0xCF, 0x00, 0x1E, 0x3C, 0x00, 0x78, 0xF0, 0x01, 0xE1, 0xE0, 0x07,
  0x87, 0x80, 0x3C, 0x1E, 0x00, 0xF0, 0x78, 0x03, 0xC0, 0xF0, 0x0F, 0x03,
  0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0,
  0xF8, 0x07, 0x83, 0xC0, 0x1F, 0x0F, 0x00, 0x3C, 0x7C, 0x00, 0xF1, 0xE0,
  0x03, 0xE7, 0x80, 0x0F, 0xBE, 0x00, 0x1E, 0xF8, 0x00, 0x7C, 0xFF, 0xF8,
  0x7F, 0xFE, 0x3F, 0xFF, 0x9E, 0x07, 0xEF, 0x01, 0xF7, 0x80, 0x7F, 0xC0,
  0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xBC, 0x03, 0xDE, 0x07, 0xCF,
  0xFF, 0xC7, 0xFF, 0x83, 0xFF, 0xF1, 0xE1, 0xFE, 0xF0, 0x1F, 0x78, 0x07,
  0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0,
  0x1F, 0xF0, 0x0F, 0xFF, 0xFF, 0xBF, 0xFF, 0x9F, 0xFF, 0x8F, 0xFF, 0x00,
  0x00, 0x78, 0x00, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0xFE, 0x1F, 0x83, 0x8F,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x21, 0xFC,
  0x78, 0x3F, 0xFE, 0x07, 0xFF, 0x80, 0x7F, 0xC0, 0xFF, 0xF0, 0x1F, 0xFF,
  0x83, 0xFF, 0xF8, 0x78, 0x7F, 0x8F, 0x01, 0xF9, 0xE0, 0x1F, 0x3C, 0x01,
  0xF7, 0x80, 0x1E, 0xF0, 0x03, 0xDE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3D, 0xE0, 0x0F,
  0xBC, 0x01, 0xF7, 0x80, 0x7C, 0xF0, 0x1F, 0x1F, 0xFF, 0xE3, 0xFF, 0xF8,
  0x7F, 0xFC, 0x0F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE,
  0xFF, 0xFB, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x00,
  0x1C, 0x00, 0x1F, 0xFE, 0x07, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xC0, 0xE1,
  0xF0, 0x02, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x1F,
  0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x81, 0xFF, 0xF8, 0x00, 0xFF, 0x80,
  0x0F, 0x78, 0x00, 0xF7, 0x80, 0x0F, 0x7C, 0x00, 0xF7, 0xC0, 0x0F, 0x3E,
  0x00, 0xF3, 0xF0, 0x0F, 0x1F, 0xE1, 0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xF0,
  0x1F, 0xFC, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1E, 0xFF,
  0xFF, 0xF3, 0xF8, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81,
  0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78,
  0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x87, 0xFF, 0xFF, 0xFF, 0xC0,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x0F, 0xFF, 0xFF, 0xDF, 0xCF, 0xC0, 0xF0, 0x07, 0xFC, 0x03, 0xEF, 0x00,
  0xF3, 0xC0, 0x7C, 0xF0, 0x3E, 0x3C, 0x0F, 0x0F, 0x07, 0xC3, 0xC3, 0xE0,
  0xF0, 0xF0, 0x3C, 0x7C, 0x0F, 0x3E, 0x03, 0xCF, 0x00, 0xF7, 0xC0, 0x3D,
  0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFD, 0xF0, 0x3E, 0x3C, 0x0F, 0x0F,
  0x83, 0xC1, 0xE0, 0xF0, 0x7C, 0x3C, 0x0F, 0x0F, 0x03, 0xE3, 0xC0, 0x78,
  0xF0, 0x1F, 0x3C, 0x03, 0xCF, 0x00, 0xFB, 0xC0, 0x1F, 0xF0, 0x07, 0xC0,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x01,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0,
  0x03, 0xFF, 0xDC, 0x00, 0xEF, 0xF7, 0x80, 0x3B, 0xFD, 0xE0, 0x1E, 0xFF,
  0x38, 0x07, 0xBF, 0xCF, 0x01, 0xCF, 0xF3, 0xC0, 0xF3, 0xFC, 0x70, 0x3C,
  0xFF, 0x1E, 0x0E, 0x3F, 0xC7, 0x87, 0x8F, 0xF1, 0xE1, 0xE3, 0xFC, 0x38,
  0x70, 0xFF, 0x0F, 0x3C, 0x3F, 0xC3, 0xCF, 0x0F, 0xF0, 0x73, 0x83, 0xFC,
  0x1E, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC0, 0xFE, 0x0F, 0xF0, 0x3F, 0x03,
  0xFC, 0x0F, 0xC0, 0xFF, 0x03, 0xF0, 0x3F, 0xC0, 0x78, 0x0F, 0xF0, 0x1E,
  0x03, 0xC0, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0xFF, 0x78, 0x0F, 0xF7, 0xC0,
  0xFF, 0x3C, 0x0F, 0xF3, 0xE0, 0xFF, 0x1E, 0x0F, 0xF1, 0xE0, 0xFF, 0x0F,
  0x0F, 0xF0, 0xF0, 0xFF, 0x07, 0x8F, 0xF0, 0x78, 0xFF, 0x03, 0xCF, 0xF0,
  0x3C, 0xFF, 0x01, 0xEF, 0xF0, 0x1E, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0x7F,
  0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x00, 0x3F,
  0xF0, 0x01, 0xF0, 0x00, 0x30, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xF8, 0x07,
  0xFF, 0xF0, 0x1F, 0x87, 0xE0, 0xF8, 0x07, 0xC3, 0xC0, 0x0F, 0x1F, 0x00,
  0x3E, 0x78, 0x00, 0xF9, 0xE0, 0x01, 0xEF, 0x80, 0x07, 0xBE, 0x00, 0x1E,
  0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1E, 0x78, 0x00,
  0x79, 0xE0, 0x01, 0xE7, 0x80, 0x0F, 0x9F, 0x00, 0x3C, 0x3E, 0x01, 0xF0,
  0xFC, 0x0F, 0x81, 0xFC, 0xFE, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0xF0, 0xFF, 0xF8, 0xFF, 0xFC, 0xF0, 0xFE, 0xF0, 0x3E,
  0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x3E, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF0,
  0xFF, 0xC0, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0x00, 0x30, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x1F,
  0x87, 0xE0, 0xF8, 0x07, 0xC3, 0xC0, 0x0F, 0x1F, 0x00, 0x3E, 0x78, 0x00,
  0xF9, 0xE0, 0x01, 0xEF, 0x80, 0x07, 0xBE, 0x00, 0x1E, 0xF8, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1E, 0x78, 0x00, 0x79, 0xE0, 0x01,
  0xE7, 0x80, 0x0F, 0x9F, 0x00, 0x3C, 0x3E, 0x01, 0xF0, 0xFC, 0x0F, 0xC1,
  0xFC, 0xFE, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0xFF, 0xF0, 0x3F, 0xFF, 0x0F, 0xFF,
  0xE3, 0xC3, 0xF8, 0xF0, 0x1F, 0x3C, 0x07, 0xCF, 0x00, 0xF3, 0xC0, 0x3C,
  0xF0, 0x0F, 0x3C, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x7C, 0xF0, 0x3E, 0x3C,
  0x3F, 0x8F, 0xFF, 0xC3, 0xFF, 0xC0, 0xFF, 0xF0, 0x3C, 0x3C, 0x0F, 0x0F,
  0x83, 0xC1, 0xE0, 0xF0, 0x7C, 0x3C, 0x0F, 0x0F, 0x03, 0xE3, 0xC0, 0x78,
  0xF0, 0x1F, 0x3C, 0x03, 0xCF, 0x00, 0xFB, 0xC0, 0x1E, 0xF0, 0x07, 0xC0,
  0x03, 0xC0, 0x3F, 0xF8, 0xFF, 0xFB, 0xFF, 0xE7, 0xC1, 0xDF, 0x00, 0xBC,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xF0, 0x07, 0xF8, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0xF0,
  0x01, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3F, 0x00,
  0x7B, 0xE3, 0xF7, 0xFF, 0xCF, 0xFF, 0x0F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0x7C, 0x07, 0xDF,
  0xC7, 0xE3, 0xFF, 0xF0, 0x7F, 0xF8, 0x07, 0xFC, 0x00, 0xF0, 0x00, 0xFF,
  0xC0, 0x07, 0x9E, 0x00, 0x3C, 0xF0, 0x01, 0xE7, 0x80, 0x1E, 0x1E, 0x00,
  0xF0, 0xF0, 0x07, 0x87, 0x80, 0x7C, 0x3E, 0x03, 0xC0, 0xF0, 0x1E, 0x07,
  0x80, 0xF0, 0x3C, 0x0F, 0x80, 0xF0, 0x78, 0x07, 0x83, 0xC0, 0x3C, 0x1E,
  0x01, 0xE1, 0xE0, 0x07, 0x8F, 0x00, 0x3C, 0x78, 0x01, 0xE3, 0xC0, 0x0F,
  0x3C, 0x00, 0x3D, 0xE0, 0x01, 0xEF, 0x00, 0x0F, 0x70, 0x00, 0x3B, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0xF8, 0x03, 0xE0, 0x0F, 0x78, 0x03,
  0xE0, 0x0F, 0x78, 0x07, 0xE0, 0x1F, 0x78, 0x07, 0xE0, 0x1E, 0x7C, 0x07,
  0xE0, 0x1E, 0x3C, 0x07, 0xF0, 0x1E, 0x3C, 0x0F, 0xF0, 0x3E, 0x3C, 0x0F,
  0x70, 0x3C, 0x3C, 0x0F, 0x70, 0x3C, 0x3E, 0x0E, 0x78, 0x3C, 0x1E, 0x0E,
  0x78, 0x3C, 0x1E, 0x1E, 0x78, 0x7C, 0x1E, 0x1E, 0x38, 0x78, 0x1E, 0x1E,
  0x38, 0x78, 0x0F, 0x1C, 0x3C, 0x78, 0x0F, 0x3C, 0x3C, 0x78, 0x0F, 0x3C,
  0x1C, 0xF0, 0x0F, 0x3C, 0x1C, 0xF0, 0x0F, 0x38, 0x1E, 0xF0, 0x07, 0xB8,
  0x1E, 0xF0, 0x07, 0xF8, 0x1E, 0xF0, 0x07, 0xF8, 0x0F, 0xE0, 0x07, 0xF8,
  0x0F, 0xE0, 0x03, 0xF0, 0x0F, 0xE0, 0x03, 0xF0, 0x0F, 0xE0, 0x03, 0xF0,
  0x07, 0xC0, 0x03, 0xF0, 0x07, 0xC0, 0x03, 0xE0, 0x07, 0xC0, 0x7C, 0x03,
  0xE7, 0x80, 0x78, 0xF0, 0x1F, 0x0F, 0x03, 0xC1, 0xE0, 0xF8, 0x1E, 0x1E,
  0x03, 0xC3, 0xC0, 0x3C, 0xF0, 0x07, 0x9E, 0x00, 0xFF, 0x80, 0x0F, 0xF0,
  0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x1E, 0xF0, 0x03, 0xCF, 0x00, 0xF1, 0xE0,
  0x1E, 0x1E, 0x07, 0xC3, 0xC0, 0xF0, 0x7C, 0x3E, 0x07, 0x87, 0x80, 0xF9,
  0xF0, 0x0F, 0x3C, 0x01, 0xFF, 0x80, 0x1E, 0xF8, 0x03, 0xEF, 0x00, 0x79,
  0xF0, 0x0F, 0x1E, 0x03, 0xE3, 0xC0, 0x78, 0x7C, 0x1F, 0x07, 0x83, 0xC0,
  0xF0, 0x78, 0x0F, 0x1E, 0x01, 0xE3, 0xC0, 0x3E, 0x78, 0x03, 0xDE, 0x00,
  0x7B, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1E,
  0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0,
  0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80,
  0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00,
  0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x03, 0xC0, 0x07, 0x00,
  0x1E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x78,
  0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x01, 0xE0, 0x03,
  0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00,
  0x3C, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0xFF, 0xFF,
  0xFF, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x80, 0x0F, 0x70, 0x01, 0xCF, 0x00, 0x79, 0xE0, 0x0E, 0x1E,
  0x03, 0xC3, 0xC0, 0x70, 0x3C, 0x1E, 0x07, 0x83, 0xC0, 0x78, 0xF0, 0x0F,
  0x1E, 0x00, 0xE7, 0x80, 0x1E, 0xF0, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xF8, 0x78, 0x3C, 0x1E, 0x0E, 0x07, 0x00, 0x40, 0x0F, 0xF8, 0x3F,
  0xFC, 0x1F, 0xFE, 0x18, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x0F, 0xFF, 0x1F, 0xFF, 0x3F, 0x8F, 0x7C, 0x0F, 0x78,
  0x0F, 0x78, 0x0F, 0xF8, 0x1F, 0xF8, 0x1F, 0x78, 0x1F, 0x7C, 0x3F, 0x7F,
  0xFF, 0x3F, 0xEF, 0x1F, 0xC7, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x40, 0xF3,
  0xF8, 0xF7, 0xFC, 0xFF, 0xFE, 0xFC, 0x3E, 0xF8, 0x1F, 0xF8, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF8, 0x1E, 0xFC,
  0x3E, 0xFF, 0xFE, 0xE7, 0xFC, 0xE3, 0xF8, 0x00, 0x80, 0x7F, 0xC7, 0xFE,
  0x7F, 0xF7, 0xE1, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF8, 0x07, 0xC0,
  0x1F, 0x00, 0xFC, 0x33, 0xFF, 0x8F, 0xFC, 0x3F, 0xC0, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x02, 0x0F, 0x1F, 0xCF, 0x3F, 0xFF, 0x3F, 0xF7, 0x7C, 0x3F, 0x78,
  0x1F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8,
  0x0F, 0x78, 0x1F, 0x7C, 0x3F, 0x3F, 0xF7, 0x3F, 0xE7, 0x0F, 0xC7, 0x01,
  0x80, 0x0F, 0xF0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7C, 0x3C, 0x78, 0x1E, 0x78,
  0x1E, 0xF0, 0x0E, 0xF0, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78,
  0x02, 0x7E, 0x06, 0x3F, 0xFE, 0x1F, 0xFE, 0x07, 0xFC, 0x03, 0xF8, 0x3F,
  0xC3, 0xFE, 0x1F, 0x10, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x01,
  0xFF, 0xBF, 0xFD, 0xFF, 0xE1, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x00,
  0x01, 0x00, 0x0F, 0xC7, 0x3F, 0xF7, 0x3F, 0xF7, 0x7C, 0x3F, 0x78, 0x1F,
  0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x0F,
  0x78, 0x1F, 0x7C, 0x3F, 0x3F, 0xFF, 0x3F, 0xEF, 0x0F, 0xCF, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x60, 0x3E, 0x7F, 0xFE,
  0x7F, 0xFC, 0x7F, 0xF8, 0x0F, 0xE0, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x41, 0xE7,
  0xF3, 0xDF, 0xF7, 0xFF, 0xFF, 0xC3, 0xFF, 0x03, 0xFE, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01,
  0xFE, 0x03, 0xFC, 0x07, 0x80, 0x4F, 0xFF, 0xF4, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x04, 0x0F, 0x0F,
  0x0F, 0x0F, 0x04, 0x00, 0x00, 0x00, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x1F, 0xFE, 0xFE,
  0xFC, 0xF0, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x1E, 0xF0, 0x3C,
  0xF0, 0x7C, 0xF0, 0xF8, 0xF0, 0xF0, 0xF1, 0xE0, 0xF3, 0xE0, 0xF3, 0xC0,
  0xF7, 0x80, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0xF9, 0xE0, 0xF9, 0xE0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0x78, 0xF0, 0x7C, 0xF0, 0x3C, 0xF0, 0x3E,
  0xF0, 0x1E, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x40, 0x08, 0x38,
  0xFE, 0x1F, 0xCE, 0x7F, 0xDF, 0xFB, 0xBF, 0xF7, 0xFE, 0xFC, 0x3F, 0x87,
  0xFE, 0x0F, 0xC1, 0xFF, 0x01, 0xF0, 0x3F, 0xC0, 0x78, 0x0F, 0xF0, 0x1E,
  0x03, 0xFC, 0x07, 0x80, 0xFF, 0x01, 0xE0, 0x3F, 0xC0, 0x78, 0x0F, 0xF0,
  0x1E, 0x03, 0xFC, 0x07, 0x80, 0xFF, 0x01, 0xE0, 0x3F, 0xC0, 0x78, 0x0F,
  0xF0, 0x1E, 0x03, 0xFC, 0x07, 0x80, 0xFF, 0x01, 0xE0, 0x3F, 0xC0, 0x78,
  0x0F, 0xF0, 0x1E, 0x03, 0xFC, 0x07, 0x80, 0xFF, 0x01, 0xE0, 0x3C, 0x00,
  0x41, 0xC7, 0xF3, 0x9F, 0xF7, 0x7F, 0xFF, 0xC3, 0xFF, 0x03, 0xFE, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0x80, 0x01, 0x80, 0x07, 0xF8, 0x07,
  0xFF, 0x07, 0xFF, 0xC7, 0xC3, 0xE3, 0xC0, 0xFB, 0xE0, 0x3D, 0xE0, 0x1E,
  0xF0, 0x0F, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0x3C, 0x07, 0x9E, 0x07, 0xCF,
  0x87, 0xC3, 0xFF, 0xE0, 0xFF, 0xE0, 0x3F, 0xC0, 0x00, 0xC0, 0xE3, 0xF8,
  0xE7, 0xFC, 0xFF, 0xFE, 0xFC, 0x3E, 0xF8, 0x1F, 0xF8, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF8, 0x1E, 0xFC, 0x3E,
  0xFF, 0xFC, 0xF7, 0xFC, 0xF3, 0xF0, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x01, 0x00, 0x0F, 0xC7, 0x3F, 0xF7, 0x3F, 0xF7, 0x7C, 0x3F,
  0x78, 0x1F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF8, 0x0F, 0x78, 0x1F, 0x7C, 0x3F, 0x3F, 0xF7, 0x3F, 0xEF, 0x0F, 0xCF,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0xDC, 0x7F, 0x9F,
  0xF7, 0xFE, 0xFD, 0xF8, 0x3E, 0x07, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x00, 0x03, 0x01, 0xFF, 0x1F, 0xFD, 0xFF, 0xEF, 0x02,
  0x78, 0x03, 0x80, 0x1E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x7F, 0x81,
  0xFE, 0x03, 0xF8, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x3D, 0x83,
  0xEF, 0xFF, 0x7F, 0xF3, 0xFF, 0x00, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x03,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xF1, 0x1F, 0xE3, 0xFC, 0x3F, 0x80, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0xE1, 0xFB, 0xFF, 0x77, 0xFC, 0xE7,
  0xF1, 0xC0, 0xF0, 0x07, 0xDE, 0x01, 0xE7, 0x80, 0x79, 0xE0, 0x3E, 0x7C,
  0x0F, 0x0F, 0x03, 0xC3, 0xC0, 0xF0, 0xF0, 0x78, 0x1E, 0x1E, 0x07, 0x87,
  0x81, 0xE1, 0xC0, 0x38, 0xF0, 0x0F, 0x3C, 0x03, 0xCF, 0x00, 0xF3, 0x80,
  0x1D, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x0F, 0x01, 0xF7, 0x81, 0xF8, 0x1E, 0x78,
  0x1F, 0x81, 0xE7, 0x81, 0xF8, 0x1E, 0x78, 0x1F, 0x81, 0xC3, 0xC3, 0xFC,
  0x3C, 0x3C, 0x3B, 0xC3, 0xC3, 0xC3, 0x9C, 0x3C, 0x3C, 0x39, 0xC3, 0x81,
  0xE7, 0x9C, 0x78, 0x1E, 0x79, 0xE7, 0x81, 0xE7, 0x1E, 0x78, 0x1E, 0x70,
  0xE7, 0x80, 0xE7, 0x0E, 0x70, 0x0E, 0x70, 0xEF, 0x00, 0xFF, 0x0F, 0xF0,
  0x0F, 0xE0, 0xFF, 0x00, 0xFE, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7E,
  0x07, 0xE0, 0x07, 0xC0, 0x7E, 0x00, 0x7C, 0x03, 0xC0, 0x7C, 0x0F, 0x9E,
  0x07, 0x8F, 0x07, 0xC3, 0xC3, 0xC1, 0xE3, 0xE0, 0x79, 0xE0, 0x3D, 0xF0,
  0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x7F,
  0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x1E, 0x78, 0x1F, 0x3C, 0x0F, 0x0F, 0x0F,
  0x87, 0x87, 0x81, 0xE7, 0xC0, 0xFF, 0xC0, 0x3C, 0xF8, 0x07, 0xDE, 0x01,
  0xE7, 0x80, 0x79, 0xE0, 0x3E, 0x3C, 0x0F, 0x0F, 0x03, 0xC3, 0xC0, 0xF0,
  0xF0, 0x78, 0x1E, 0x1E, 0x07, 0x87, 0x81, 0xE1, 0xE0, 0x3C, 0xF0, 0x0F,
  0x3C, 0x03, 0xCF, 0x00, 0x73, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x7F,
  0x80, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7F, 0xFB, 0xFF, 0xDF,
  0xFE, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x3C,
  0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x03,
  0xC0, 0x1E, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF0, 0x3F, 0x07,
  0xF0, 0x7C, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07,
  0x80, 0x78, 0x07, 0x80, 0xF0, 0x0F, 0x01, 0xF0, 0xFE, 0x0F, 0x80, 0xFE,
  0x03, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07,
  0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x7C, 0x07, 0xF0, 0x3F, 0x01,
  0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xF0, 0x0F, 0xC0, 0xFE, 0x03, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xF0, 0x1F, 0x07, 0xF0, 0xFC,
  0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0xFE, 0x0F, 0xC0, 0xF8, 0x08, 0x00,
  0x3F, 0x00, 0xBF, 0xF0, 0xFF, 0xFF, 0xFC, 0x3F, 0xF8, 0x07, 0xF0,
};

const GFXglyph NotoSans_Condensed_Medium41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 5, 29, 10, 3, -29 },
  { 20, 12, 10, 17, 2, -29 },
  { 35, 20, 29, 21, 1, -29 },
  { 108, 16, 33, 20, 2, -31 },
  { 174, 27, 30, 30, 2, -30 },
  { 276, 22, 30, 23, 1, -30 },
  { 359, 5, 10, 9, 2, -29 },
  { 366, 9, 35, 12, 2, -29 },
  { 406, 10, 35, 12, 1, -29 },
  { 450, 16, 16, 19, 1, -31 },
  { 482, 17, 19, 20, 1, -24 },
  { 523, 7, 10, 10, 1, -5 },
  { 532, 10, 4, 12, 1, -13 },
  { 537, 6, 5, 10, 2, -5 },
  { 541, 14, 29, 16, 1, -29 },
  { 592, 16, 30, 20, 2, -30 },
  { 652, 11, 29, 20, 3, -29 },
  { 692, 16, 30, 20, 2, -30 },
  { 752, 16, 30, 20, 2, -30 },
  { 812, 18, 29, 20, 1, -29 },
  { 878, 16, 29, 20, 2, -29 },
  { 936, 16, 30, 20, 2, -30 },
  { 996, 17, 29, 20, 1, -29 },
  { 1058, 17, 30, 20, 1, -30 },
  { 1122, 16, 30, 20, 2, -30 },
  { 1182, 6, 22, 10, 2, -22 },
  { 1199, 7, 27, 10, 1, -22 },
  { 1223, 17, 19, 20, 1, -24 },
  { 1264, 17, 11, 20, 1, -20 },
  { 1288, 17, 19, 20, 1, -24 },
  { 1329, 14, 30, 15, 0, -30 },
  { 1382, 26, 33, 30, 2, -30 },
  { 1490, 22, 29, 22, 0, -29 },
  { 1570, 17, 29, 22, 3, -29 },
  { 1632, 18, 30, 21, 2, -30 },
  { 1700, 19, 29, 24, 3, -29 },
  { 1769, 14, 29, 19, 3, -29 },
  { 1820, 14, 29, 18, 3, -29 },
  { 1871, 20, 30, 25, 2, -30 },
  { 1946, 19, 29, 25, 3, -29 },
  { 2015, 10, 29, 13, 1, -29 },
  { 2052, 9, 37, 10, -2, -29 },
  { 2094, 18, 29, 21, 3, -29 },
  { 2160, 14, 29, 18, 3, -29 },
  { 2211, 26, 29, 32, 3, -29 },
  { 2306, 20, 29, 26, 3, -29 },
  { 2379, 22, 30, 26, 2, -30 },
  { 2462, 16, 29, 21, 3, -29 },
  { 2520, 22, 37, 26, 2, -30 },
  { 2622, 18, 29, 21, 3, -29 },
  { 2688, 15, 30, 19, 2, -30 },
  { 2745, 18, 29, 18, 0, -29 },
  { 2811, 18, 29, 24, 3, -29 },
  { 2877, 21, 29, 21, 0, -29 },
  { 2954, 32, 29, 32, 0, -29 },
  { 3070, 19, 29, 20, 0, -29 },
  { 3139, 19, 29, 19, 0, -29 },
  { 3208, 16, 29, 18, 1, -29 },
  { 3266, 9, 36, 13, 3, -29 },
  { 3307, 14, 29, 16, 1, -29 },
  { 3358, 9, 36, 13, 1, -29 },
  { 3399, 19, 17, 20, 1, -29 },
  { 3440, 18, 2, 18, 0, 4 },
  { 3445, 8, 6, 12, 2, -31 },
  { 3451, 16, 23, 19, 1, -23 },
  { 3497, 16, 31, 21, 3, -31 },
  { 3559, 13, 23, 16, 2, -23 },
  { 3597, 16, 31, 21, 2, -31 },
  { 3659, 16, 23, 19, 2, -23 },
  { 3705, 13, 31, 12, 0, -31 },
  { 3756, 16, 33, 21, 2, -23 },
  { 3822, 15, 31, 21, 3, -31 },
  { 3881, 4, 31, 10, 3, -31 },
  { 3897, 8, 41, 10, -1, -31 },
  { 3938, 16, 31, 19, 3, -31 },
  { 4000, 4, 31, 10, 3, -31 },
  { 4016, 26, 23, 32, 3, -23 },
  { 4091, 15, 23, 21, 3, -23 },
  { 4135, 17, 23, 21, 2, -23 },
  { 4184, 16, 33, 21, 3, -23 },
  { 4250, 16, 33, 21, 2, -23 },
  { 4316, 11, 23, 14, 3, -23 },
  { 4348, 13, 23, 16, 2, -23 },
  { 4386, 11, 27, 13, 1, -27 },
  { 4424, 15, 22, 21, 3, -22 },
  { 4466, 18, 22, 18, 0, -22 },
  { 4516, 28, 22, 28, 0, -22 },
  { 4593, 17, 22, 18, 0, -22 },
  { 4640, 18, 32, 18, 0, -22 },
  { 4712, 13, 22, 15, 1, -22 },
  { 4748, 12, 36, 15, 1, -29 },
  { 4802, 3, 41, 19, 8, -31 },
  { 4818, 12, 36, 15, 2, -29 },
  { 4872, 17, 5, 20, 1, -17 },
};

const GFXfont NotoSans_Condensed_Medium41pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Medium41pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Medium41pt7bGlyphs,
  0x20, 0x7E, 56
};

#endif // _NOTOSANS_CONDENSED_MEDIUM41PT7B_H_
