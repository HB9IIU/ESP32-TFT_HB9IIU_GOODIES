#ifndef _IBMPLEXMONO_ITALIC14PT7B_H_
#define _IBMPLEXMONO_ITALIC14PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Italic.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Italic14pt7bBitmaps[] PROGMEM = {
  0x00, 0x2D, 0x24, 0xA0, 0xD8, 0x59, 0x9A, 0x09, 0x05, 0x04, 0x8E, 0x71,
  0x41, 0x23, 0x9C, 0x50, 0x48, 0x24, 0x00, 0x04, 0x1E, 0x29, 0x68, 0x68,
  0x38, 0x0E, 0x0A, 0x12, 0xD2, 0x3C, 0x10, 0x38, 0xA4, 0x92, 0x89, 0x47,
  0x40, 0x30, 0xE4, 0x92, 0x49, 0x47, 0x00, 0x1C, 0x22, 0x22, 0x22, 0x34,
  0x58, 0x88, 0x89, 0x95, 0x76, 0x5A, 0x19, 0x08, 0x88, 0x42, 0x10, 0x84,
  0x20, 0x86, 0x00, 0x20, 0x84, 0x10, 0x84, 0x22, 0x10, 0x88, 0x88, 0x00,
  0x10, 0x22, 0x4B, 0xE3, 0x09, 0x22, 0x00, 0x10, 0x20, 0x47, 0xF1, 0x04,
  0x08, 0x00, 0x6B, 0x40, 0xF0, 0xF0, 0x01, 0x03, 0x02, 0x04, 0x04, 0x08,
  0x08, 0x10, 0x10, 0x20, 0x20, 0x40, 0xC0, 0x3C, 0xCD, 0x0C, 0x19, 0x32,
  0x61, 0xC2, 0x8C, 0xE0, 0x18, 0xAC, 0xA6, 0x10, 0x41, 0x04, 0x13, 0xF0,
  0x1E, 0x23, 0x61, 0x03, 0x02, 0x04, 0x08, 0x30, 0x40, 0xFE, 0x1E, 0x23,
  0x03, 0x02, 0x1C, 0x06, 0x02, 0x02, 0xC6, 0x78, 0x06, 0x06, 0x0A, 0x12,
  0x22, 0x26, 0x44, 0xFF, 0x04, 0x04, 0x3E, 0x81, 0x02, 0x07, 0xC8, 0xA1,
  0x02, 0x8C, 0xF0, 0x0C, 0x42, 0x10, 0xFF, 0x18, 0x61, 0x8D, 0xE0, 0x7E,
  0x85, 0x14, 0x20, 0x83, 0x04, 0x18, 0x20, 0x80, 0x3C, 0x85, 0x0A, 0x23,
  0x98, 0xA1, 0x42, 0x8C, 0xF0, 0x3C, 0x8F, 0x0C, 0x1C, 0x6F, 0x81, 0x04,
  0x10, 0xC0, 0x6C, 0x00, 0x36, 0x33, 0x00, 0x00, 0x64, 0xC8, 0x02, 0x18,
  0xC6, 0x0C, 0x06, 0x06, 0x02, 0xFE, 0x00, 0x07, 0xE0, 0x40, 0x81, 0x81,
  0x0C, 0xCE, 0x20, 0x7B, 0x38, 0x43, 0x18, 0x84, 0x00, 0x63, 0x00, 0x3C,
  0xCD, 0x0C, 0xDB, 0x74, 0xA9, 0x52, 0xBD, 0x02, 0x03, 0xC0, 0x0C, 0x18,
  0x50, 0xB3, 0x24, 0x5F, 0xA1, 0x43, 0x04, 0x7C, 0x85, 0x0A, 0x27, 0x90,
  0xA1, 0x42, 0x85, 0xF0, 0x1C, 0x45, 0x12, 0x0C, 0x10, 0x20, 0x42, 0xC4,
  0xF0, 0x7C, 0x8D, 0x0A, 0x14, 0x28, 0xE1, 0xC2, 0x8D, 0xF0, 0x7E, 0x81,
  0x02, 0x07, 0xD0, 0x20, 0x40, 0x81, 0xF8, 0x7E, 0x81, 0x02, 0x07, 0xD0,
  0x20, 0x40, 0x81, 0x00, 0x3C, 0xCD, 0x16, 0x08, 0x13, 0xE1, 0x42, 0xCC,
  0xE8, 0x42, 0x85, 0x0A, 0x3F, 0xF0, 0xA1, 0x42, 0x85, 0x18, 0x7E, 0x30,
  0x40, 0x81, 0x02, 0x04, 0x18, 0x21, 0xF8, 0x3E, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x46, 0x88, 0xE0, 0x43, 0x46, 0x4C, 0x58, 0x70, 0xF0, 0xC8, 0x88,
  0x84, 0x84, 0x21, 0x84, 0x10, 0x41, 0x04, 0x10, 0x83, 0xF0, 0x31, 0x33,
  0x33, 0x55, 0x59, 0x49, 0x52, 0x42, 0x42, 0x82, 0x62, 0xC5, 0x8A, 0x9D,
  0x72, 0xA5, 0x4A, 0x8D, 0x18, 0x3C, 0xCD, 0x0E, 0x18, 0x30, 0x61, 0xC2,
  0x8C, 0xE0, 0x7C, 0x85, 0x0A, 0x14, 0x7F, 0xA0, 0x40, 0x81, 0x00, 0x3C,
  0xCD, 0x0E, 0x18, 0x30, 0x61, 0xC2, 0x8C, 0xF0, 0xC0, 0xB0, 0x80, 0x7C,
  0x85, 0x0A, 0x14, 0x7F, 0xA4, 0x44, 0x89, 0x08, 0x1E, 0x21, 0x60, 0x20,
  0x38, 0x06, 0x02, 0x02, 0xC2, 0x3C, 0xFF, 0x18, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x30, 0x20, 0x20, 0x42, 0x85, 0x0A, 0x1C, 0x70, 0xA1, 0x42, 0x8C,
  0xF0, 0x87, 0x0A, 0x14, 0x48, 0x92, 0x24, 0x78, 0x60, 0xC0, 0xC1, 0x81,
  0x82, 0x92, 0xB2, 0xAA, 0xAC, 0xCC, 0xCC, 0xCC, 0x21, 0x98, 0x84, 0x82,
  0x80, 0x80, 0xC0, 0x50, 0x48, 0x42, 0x61, 0x00, 0xC3, 0x42, 0x44, 0x2C,
  0x28, 0x30, 0x10, 0x30, 0x20, 0x20, 0x3F, 0x80, 0x80, 0x80, 0x80, 0x80,
  0xC0, 0xC0, 0xC0, 0x40, 0x7F, 0x00, 0x3C, 0x82, 0x08, 0x21, 0x04, 0x10,
  0x41, 0x04, 0x20, 0xF0, 0x92, 0x48, 0x92, 0x48, 0x92, 0x3C, 0x10, 0x41,
  0x08, 0x20, 0x82, 0x08, 0x21, 0x04, 0xF0, 0x18, 0x38, 0x92, 0x2C, 0x30,
  0x80, 0xFE, 0x94, 0x7E, 0x8A, 0x14, 0x28, 0x51, 0xBD, 0x80, 0x60, 0x81,
  0x02, 0xE6, 0x48, 0x61, 0xC2, 0x8D, 0xF0, 0x39, 0x1C, 0x20, 0x87, 0x37,
  0x80, 0x02, 0x04, 0x09, 0xD4, 0x50, 0xA1, 0x42, 0x9C, 0xF8, 0x3D, 0x18,
  0x7E, 0x83, 0x17, 0x80, 0x07, 0x82, 0x01, 0x07, 0xE0, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x08, 0x24, 0x0A, 0x03, 0x00, 0x1F, 0x22, 0x42, 0x42, 0x42,
  0x4E, 0x3E, 0x04, 0x84, 0x78, 0x61, 0x04, 0x17, 0x65, 0x1C, 0x61, 0x86,
  0x30, 0x18, 0x30, 0x07, 0x81, 0x06, 0x08, 0x13, 0x28, 0x60, 0x04, 0x10,
  0x1F, 0x08, 0x20, 0x82, 0x08, 0x69, 0x14, 0x30, 0x60, 0x81, 0x02, 0xE6,
  0x48, 0xB6, 0x5A, 0x97, 0x30, 0x72, 0x41, 0x04, 0x20, 0x82, 0x09, 0x39,
  0xC0, 0x5B, 0x6D, 0x49, 0x49, 0x4A, 0x92, 0x92, 0x5D, 0x94, 0x71, 0x86,
  0x18, 0xC0, 0x38, 0x8A, 0x14, 0x38, 0x51, 0x9E, 0x00, 0x2E, 0x32, 0x21,
  0x43, 0x42, 0x46, 0x7C, 0x40, 0x40, 0x80, 0x3E, 0x8A, 0x14, 0x28, 0x53,
  0x9F, 0x04, 0x08, 0x10, 0xED, 0xC4, 0x10, 0x41, 0x0C, 0x00, 0x3D, 0x14,
  0x1E, 0x06, 0x17, 0x80, 0x10, 0x43, 0x3F, 0x20, 0x82, 0x09, 0x59, 0xC0,
  0x46, 0x89, 0x14, 0x28, 0x53, 0x9E, 0x00, 0xE4, 0x8D, 0x1A, 0x24, 0x4B,
  0x1C, 0x00, 0x93, 0x26, 0x4C, 0x99, 0x3E, 0xB6, 0x00, 0x33, 0x4D, 0x09,
  0x08, 0x98, 0x9B, 0xEC, 0x23, 0x22, 0x22, 0x42, 0x42, 0x6E, 0x3C, 0x04,
  0x84, 0x78, 0x7B, 0x18, 0x20, 0x86, 0x5C, 0xAF, 0x00, 0x1C, 0x82, 0x08,
  0x10, 0x4E, 0x08, 0x21, 0x04, 0x10, 0x70, 0x25, 0x24, 0x92, 0x92, 0x48,
  0x38, 0x20, 0x84, 0x20, 0x81, 0xCC, 0x20, 0x81, 0x08, 0xE0, 0x63, 0x2A,
  0x70,
};

const GFXglyph IBMPlexMono_Italic14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 3, 10, 8, 3, -10 },
  { 5, 4, 4, 8, 3, -10 },
  { 7, 9, 10, 8, 0, -10 },
  { 19, 8, 12, 8, 0, -11 },
  { 31, 9, 10, 8, 0, -10 },
  { 43, 8, 10, 8, 0, -10 },
  { 53, 2, 4, 8, 4, -10 },
  { 54, 5, 13, 8, 3, -11 },
  { 63, 5, 13, 8, 1, -11 },
  { 72, 7, 7, 8, 1, -8 },
  { 79, 7, 7, 8, 1, -8 },
  { 86, 3, 4, 8, 2, -2 },
  { 88, 4, 1, 8, 2, -5 },
  { 89, 2, 2, 8, 3, -2 },
  { 90, 8, 13, 8, 0, -11 },
  { 103, 7, 10, 8, 1, -10 },
  { 112, 6, 10, 8, 1, -10 },
  { 120, 8, 10, 8, 0, -10 },
  { 130, 8, 10, 8, 0, -10 },
  { 140, 8, 10, 8, 0, -10 },
  { 150, 7, 10, 8, 1, -10 },
  { 159, 6, 10, 8, 1, -10 },
  { 167, 7, 10, 8, 1, -10 },
  { 176, 7, 10, 8, 1, -10 },
  { 185, 7, 10, 8, 1, -10 },
  { 194, 3, 8, 8, 3, -8 },
  { 197, 4, 10, 8, 2, -8 },
  { 202, 7, 8, 8, 1, -8 },
  { 209, 7, 4, 8, 1, -6 },
  { 213, 6, 8, 8, 1, -8 },
  { 219, 6, 10, 8, 2, -10 },
  { 227, 7, 12, 8, 1, -10 },
  { 238, 7, 10, 8, 0, -10 },
  { 247, 7, 10, 8, 1, -10 },
  { 256, 7, 10, 8, 1, -10 },
  { 265, 7, 10, 8, 1, -10 },
  { 274, 7, 10, 8, 1, -10 },
  { 283, 7, 10, 8, 1, -10 },
  { 292, 7, 10, 8, 1, -10 },
  { 301, 7, 10, 8, 1, -10 },
  { 310, 7, 10, 8, 1, -10 },
  { 319, 7, 10, 8, 1, -10 },
  { 328, 8, 10, 8, 1, -10 },
  { 338, 6, 10, 8, 1, -10 },
  { 346, 8, 10, 8, 0, -10 },
  { 356, 7, 10, 8, 1, -10 },
  { 365, 7, 10, 8, 1, -10 },
  { 374, 7, 10, 8, 1, -10 },
  { 383, 7, 13, 8, 1, -10 },
  { 395, 7, 10, 8, 1, -10 },
  { 404, 8, 10, 8, 0, -10 },
  { 414, 8, 10, 8, 1, -10 },
  { 424, 7, 10, 8, 1, -10 },
  { 433, 7, 10, 8, 2, -10 },
  { 442, 8, 10, 8, 1, -10 },
  { 452, 9, 10, 8, 0, -10 },
  { 464, 8, 10, 8, 1, -10 },
  { 474, 9, 10, 8, 0, -10 },
  { 486, 6, 13, 8, 2, -11 },
  { 496, 3, 13, 8, 3, -11 },
  { 501, 6, 13, 8, 0, -11 },
  { 511, 7, 6, 8, 1, -10 },
  { 517, 7, 1, 8, 0, 1 },
  { 518, 2, 3, 8, 3, -11 },
  { 519, 7, 7, 8, 1, -7 },
  { 526, 7, 10, 8, 1, -10 },
  { 535, 6, 7, 8, 1, -7 },
  { 541, 7, 10, 8, 1, -10 },
  { 550, 6, 7, 8, 1, -7 },
  { 556, 9, 13, 8, 0, -10 },
  { 571, 8, 10, 8, 0, -7 },
  { 581, 6, 10, 8, 1, -10 },
  { 589, 7, 10, 8, 1, -10 },
  { 598, 6, 13, 8, 1, -10 },
  { 608, 7, 10, 8, 1, -10 },
  { 617, 6, 10, 8, 1, -10 },
  { 625, 8, 7, 8, 0, -7 },
  { 632, 6, 7, 8, 1, -7 },
  { 638, 7, 7, 8, 1, -7 },
  { 645, 8, 10, 8, 0, -7 },
  { 655, 7, 10, 8, 1, -7 },
  { 664, 6, 7, 8, 2, -7 },
  { 670, 6, 7, 8, 1, -7 },
  { 676, 6, 10, 8, 1, -10 },
  { 684, 7, 7, 8, 1, -7 },
  { 691, 7, 7, 8, 1, -7 },
  { 698, 7, 7, 8, 1, -7 },
  { 705, 8, 7, 8, 0, -7 },
  { 712, 8, 10, 8, 0, -7 },
  { 722, 7, 7, 8, 1, -7 },
  { 729, 6, 13, 8, 2, -11 },
  { 739, 3, 13, 8, 3, -11 },
  { 744, 6, 13, 8, 1, -11 },
  { 754, 7, 3, 8, 1, -6 },
};

const GFXfont IBMPlexMono_Italic14pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Italic14pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Italic14pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _IBMPLEXMONO_ITALIC14PT7B_H_
