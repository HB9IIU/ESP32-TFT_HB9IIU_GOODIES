#ifndef _IBMPLEXMONO_ITALIC30PT7B_H_
#define _IBMPLEXMONO_ITALIC30PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Italic.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Italic30pt7bBitmaps[] PROGMEM = {
  0x00, 0x0E, 0x18, 0x30, 0xE1, 0xC3, 0x86, 0x0C, 0x18, 0x30, 0x40, 0x83,
  0x04, 0x00, 0x00, 0x00, 0xE3, 0xC7, 0x8E, 0x00, 0x31, 0xB8, 0xDC, 0xEC,
  0x76, 0x33, 0x19, 0x8D, 0xC6, 0x00, 0x61, 0x80, 0x0C, 0x60, 0x03, 0x8C,
  0x00, 0x63, 0x80, 0x1C, 0x60, 0x03, 0x8C, 0x07, 0xE3, 0xF8, 0xFC, 0x7E,
  0x23, 0x0C, 0x00, 0x63, 0x80, 0x0C, 0x60, 0x03, 0x0C, 0x00, 0x63, 0x80,
  0xFC, 0x7F, 0x3F, 0x0F, 0xC0, 0x63, 0x80, 0x0C, 0x60, 0x03, 0x0C, 0x00,
  0x63, 0x80, 0x0C, 0x60, 0x03, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x10, 0x00,
  0x18, 0x00, 0x7F, 0x00, 0xFF, 0xE0, 0xF3, 0x78, 0x61, 0x0E, 0x70, 0x84,
  0x38, 0xC0, 0x1C, 0x60, 0x0E, 0x30, 0x03, 0x98, 0x00, 0xFC, 0x00, 0x3F,
  0xC0, 0x07, 0xF0, 0x03, 0x1C, 0x01, 0x8E, 0x00, 0xC7, 0x00, 0x43, 0x88,
  0x61, 0xCE, 0x31, 0xC7, 0x99, 0xE0, 0xFF, 0xC0, 0x1F, 0x80, 0x02, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0x03, 0xC0, 0x38, 0x3F, 0x03, 0x83, 0x0C,
  0x18, 0x30, 0x61, 0x81, 0x83, 0x1C, 0x0C, 0x18, 0xC0, 0x61, 0xCC, 0x03,
  0x0C, 0xC0, 0x0F, 0xC6, 0x00, 0x3C, 0x40, 0x00, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x39, 0xF8, 0x03, 0x98, 0x60, 0x19, 0xC3, 0x01, 0x8C, 0x18, 0x1C,
  0x60, 0xC0, 0xC3, 0x0E, 0x0C, 0x18, 0x60, 0xE0, 0x7E, 0x0E, 0x01, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0xFF, 0x00, 0x70, 0xC0, 0x18, 0x38, 0x0E, 0x06,
  0x03, 0x81, 0x80, 0x60, 0xE0, 0x18, 0x30, 0x07, 0x1C, 0x01, 0xCE, 0x03,
  0xFE, 0x01, 0xC6, 0x00, 0x61, 0xC0, 0x38, 0x30, 0x0E, 0x0E, 0x03, 0x81,
  0x82, 0xE0, 0x71, 0xF8, 0x2C, 0x67, 0x1B, 0xB1, 0xFC, 0x7C, 0x1E, 0x0E,
  0x00, 0x76, 0x66, 0x6E, 0xCC, 0x00, 0xE0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x18, 0x06, 0x01, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x30, 0x06, 0x01, 0xC0,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x18,
  0x01, 0x80, 0x38, 0x03, 0x00, 0x38, 0x00, 0x07, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x0C, 0x01, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xC0, 0x38,
  0x06, 0x01, 0x80, 0x70, 0x1C, 0x07, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x1C, 0x71, 0xFF, 0xFF, 0x8F, 0xF8,
  0x07, 0x80, 0x1F, 0x00, 0x77, 0x00, 0xC6, 0x03, 0x0E, 0x0C, 0x0C, 0x08,
  0x14, 0x00, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0E,
  0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x06,
  0x00, 0x18, 0x00, 0x1E, 0x38, 0xE1, 0xC7, 0x0E, 0x18, 0x60, 0xFF, 0xFF,
  0x80, 0x7F, 0xFE, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x00, 0x03, 0xF0, 0x0F, 0xF0, 0x78, 0x70, 0xC0, 0x73, 0x80, 0xE6, 0x00,
  0xDC, 0x01, 0xB0, 0x03, 0x63, 0x87, 0xC7, 0x1F, 0x8E, 0x3F, 0x1C, 0x7C,
  0x00, 0xD8, 0x01, 0xB0, 0x07, 0x60, 0x0C, 0xC0, 0x39, 0xC0, 0x61, 0xC3,
  0xC1, 0xFE, 0x01, 0xF8, 0x00, 0x00, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x7B,
  0x81, 0xC7, 0x07, 0x0C, 0x04, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x00, 0x06, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xF0, 0x07,
  0xFC, 0x0E, 0x1E, 0x1C, 0x0E, 0x38, 0x06, 0x10, 0x07, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x00, 0xFF,
  0xFC, 0xFF, 0xFC, 0x01, 0xF8, 0x07, 0xFC, 0x0E, 0x0E, 0x1C, 0x06, 0x08,
  0x06, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x07, 0xF0, 0x07,
  0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x40,
  0x1C, 0xE0, 0x18, 0xF0, 0x78, 0x7F, 0xE0, 0x1F, 0x80, 0x00, 0x0F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x06, 0xC0, 0x07, 0x60, 0x07, 0x30, 0x07, 0x18,
  0x03, 0x1C, 0x03, 0x0E, 0x03, 0x86, 0x03, 0x83, 0x03, 0x81, 0x81, 0x80,
  0xC1, 0x80, 0xE1, 0xC0, 0x70, 0xFF, 0xFF, 0x7F, 0xFF, 0x40, 0x0C, 0x00,
  0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x07, 0xFF, 0x0F, 0xFF, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x19, 0xF0,
  0x1F, 0xF8, 0x3C, 0x1C, 0x38, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x20, 0x0C, 0x60, 0x1C, 0xF8, 0x78, 0x3F, 0xF0, 0x0F, 0xC0,
  0x00, 0x78, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x01, 0x80,
  0x0E, 0x00, 0x73, 0xE1, 0xFF, 0xE7, 0x83, 0xBC, 0x07, 0xE0, 0x1F, 0x80,
  0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1B, 0x80, 0xE7, 0x07, 0x0F, 0xF8, 0x1F,
  0x80, 0x7F, 0xFE, 0xFF, 0xFD, 0x80, 0x3B, 0x00, 0xEE, 0x01, 0x98, 0x07,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00,
  0x38, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0xE0,
  0x01, 0xC0, 0x07, 0x00, 0x00, 0x01, 0xF8, 0x07, 0xFE, 0x0E, 0x0F, 0x1C,
  0x07, 0x18, 0x03, 0x18, 0x07, 0x18, 0x07, 0x18, 0x06, 0x1C, 0x1C, 0x07,
  0xF8, 0x0F, 0xF8, 0x3C, 0x1C, 0x70, 0x0E, 0x60, 0x0E, 0xE0, 0x0E, 0xE0,
  0x0E, 0xE0, 0x0E, 0xE0, 0x1C, 0x70, 0x3C, 0x3F, 0xF0, 0x1F, 0xC0, 0x07,
  0xE0, 0x7F, 0xC3, 0x83, 0x9C, 0x06, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x80, 0xEF, 0x0D, 0x9F, 0xEE, 0x3F, 0x70, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x00,
  0x1C, 0xF3, 0xCE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x73, 0xCF, 0x38,
  0x07, 0x0F, 0x0F, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0x1C, 0x38, 0x38, 0x70, 0x70, 0x60, 0xC0, 0x00, 0x04, 0x00, 0x70,
  0x07, 0xC0, 0x7C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x00, 0xC0, 0x03,
  0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1C,
  0x00, 0x20, 0x7F, 0xFE, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0x7F, 0xFE, 0x10, 0x00, 0x38, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x7C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0x30, 0x00, 0x80,
  0x00, 0x0F, 0xC1, 0xFF, 0x1C, 0x1D, 0xC0, 0x6C, 0x03, 0xA0, 0x1C, 0x00,
  0xE0, 0x0E, 0x00, 0x70, 0x0F, 0x03, 0xF0, 0x1E, 0x01, 0xC0, 0x0E, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0x80, 0x00,
  0x03, 0xF0, 0x1F, 0xF0, 0x70, 0x71, 0xC0, 0x73, 0x00, 0x66, 0x00, 0xD8,
  0x39, 0xB1, 0xFB, 0x63, 0x0F, 0xCE, 0x1B, 0x98, 0x36, 0x30, 0x6C, 0x60,
  0xD9, 0xC3, 0xB3, 0x86, 0x63, 0x1C, 0xC7, 0xF9, 0x87, 0xB3, 0x00, 0x06,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0F, 0xF8, 0x0F, 0xE0, 0x00, 0x78, 0x00,
  0x78, 0x00, 0xF8, 0x00, 0xD8, 0x01, 0xDC, 0x01, 0x9C, 0x01, 0x9C, 0x03,
  0x8C, 0x03, 0x0C, 0x07, 0x0C, 0x06, 0x0C, 0x0E, 0x0E, 0x0C, 0x0E, 0x1F,
  0xFE, 0x1F, 0xFE, 0x38, 0x06, 0x30, 0x06, 0x70, 0x06, 0x70, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0x0F, 0xF8, 0x0F, 0xFE, 0x1C, 0x0E, 0x1C, 0x07, 0x1C,
  0x07, 0x18, 0x07, 0x18, 0x06, 0x18, 0x0E, 0x38, 0x1C, 0x3F, 0xF8, 0x3F,
  0xF8, 0x30, 0x1C, 0x30, 0x0E, 0x30, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70,
  0x0E, 0x60, 0x1C, 0x60, 0x3C, 0x7F, 0xF8, 0xFF, 0xE0, 0x01, 0xF0, 0x0F,
  0xF8, 0x38, 0x38, 0xE0, 0x33, 0x80, 0x67, 0x00, 0x0C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x04, 0x60, 0x1C, 0xE0, 0x71, 0xE1, 0xC1, 0xFF, 0x00, 0xFC,
  0x00, 0x1F, 0xE0, 0x3F, 0xF0, 0x60, 0xF0, 0xC0, 0x63, 0x80, 0xE7, 0x01,
  0xCE, 0x03, 0x98, 0x07, 0x30, 0x0E, 0x60, 0x1D, 0xC0, 0x3B, 0x80, 0x77,
  0x00, 0xCC, 0x01, 0x98, 0x07, 0x30, 0x0E, 0xE0, 0x39, 0xC0, 0x63, 0x83,
  0xC7, 0xFF, 0x0F, 0xF8, 0x00, 0x0F, 0xFF, 0x87, 0xFF, 0xC7, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00,
  0x1F, 0xFF, 0x0F, 0xFF, 0x86, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0F, 0xFF, 0x8F,
  0xFF, 0x80, 0x0F, 0xFF, 0x87, 0xFF, 0xC7, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1F, 0xFF, 0x0F,
  0xFF, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0xF0, 0x0F, 0xF8, 0x38, 0x70, 0xE0, 0x73, 0x80, 0x66, 0x00, 0x1C, 0x00,
  0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x0F, 0xEE, 0x1F, 0xDC,
  0x03, 0xB8, 0x07, 0x70, 0x0C, 0xE0, 0x39, 0xC0, 0x71, 0xC3, 0xE1, 0xFD,
  0xC1, 0xF3, 0x80, 0x0C, 0x03, 0x8E, 0x01, 0xC7, 0x00, 0xC3, 0x80, 0x61,
  0x80, 0x30, 0xC0, 0x38, 0x60, 0x1C, 0x70, 0x0E, 0x38, 0x06, 0x1F, 0xFF,
  0x0F, 0xFF, 0x86, 0x01, 0xC3, 0x00, 0xE3, 0x80, 0x71, 0xC0, 0x30, 0xE0,
  0x18, 0x60, 0x1C, 0x30, 0x0E, 0x18, 0x07, 0x1C, 0x03, 0x8E, 0x01, 0x80,
  0x0F, 0xFF, 0x8F, 0xFF, 0x80, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xC0, 0x1F, 0xFF, 0x8F, 0xFF, 0x80, 0x0F, 0xFE, 0x1F,
  0xF8, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00,
  0x0C, 0x00, 0x38, 0xC0, 0x71, 0xC0, 0xC3, 0x83, 0x83, 0xFE, 0x01, 0xF0,
  0x00, 0x0C, 0x01, 0xC3, 0x00, 0xE1, 0xC0, 0x70, 0x70, 0x38, 0x1C, 0x1C,
  0x06, 0x0E, 0x01, 0x87, 0x00, 0x63, 0x80, 0x39, 0xC0, 0x0E, 0xF0, 0x03,
  0xFC, 0x00, 0xFB, 0x80, 0x3C, 0xE0, 0x0E, 0x1C, 0x07, 0x07, 0x01, 0xC0,
  0xC0, 0x70, 0x38, 0x18, 0x06, 0x06, 0x01, 0xC1, 0x80, 0x30, 0xE0, 0x0E,
  0x00, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x18, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x1C, 0x03, 0x8F, 0x03, 0xC7, 0x81, 0xE3, 0xC1, 0xF1, 0xE0, 0xF1, 0xD8,
  0xD8, 0xCC, 0xEC, 0x66, 0x66, 0x33, 0x67, 0x19, 0xB3, 0x8C, 0x71, 0x8E,
  0x38, 0xC6, 0x18, 0x63, 0x0C, 0x31, 0x84, 0x38, 0xC0, 0x1C, 0x60, 0x0C,
  0x70, 0x06, 0x30, 0x03, 0x18, 0x01, 0x8C, 0x01, 0xC0, 0x0E, 0x03, 0x8F,
  0x81, 0xC7, 0xC0, 0xC3, 0x60, 0x61, 0xB0, 0x30, 0xD8, 0x18, 0x6E, 0x1C,
  0x73, 0x0E, 0x39, 0x86, 0x18, 0xC3, 0x0C, 0x71, 0x86, 0x18, 0xC3, 0x0C,
  0xE3, 0x86, 0x71, 0xC3, 0x30, 0xC1, 0xD8, 0x60, 0x6C, 0x30, 0x36, 0x18,
  0x1F, 0x1C, 0x0F, 0x8E, 0x03, 0x80, 0x03, 0xF0, 0x1F, 0xF0, 0x78, 0x70,
  0xC0, 0x73, 0x80, 0xE6, 0x00, 0xDC, 0x01, 0xB0, 0x03, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xD8, 0x01, 0xB0, 0x07, 0x60, 0x0C,
  0xE0, 0x39, 0xC0, 0x61, 0xC3, 0xC1, 0xFE, 0x01, 0xF8, 0x00, 0x0F, 0xFC,
  0x07, 0xFF, 0x07, 0x01, 0xC3, 0x80, 0x61, 0xC0, 0x30, 0xC0, 0x1C, 0x60,
  0x0C, 0x30, 0x06, 0x38, 0x07, 0x1C, 0x07, 0x0F, 0xFF, 0x07, 0xFF, 0x03,
  0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xF0, 0x0F, 0xF0, 0x78,
  0x70, 0xC0, 0x73, 0x80, 0xE6, 0x00, 0xDC, 0x01, 0xB0, 0x03, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xD8, 0x01, 0xB0, 0x07, 0x60,
  0x0C, 0xE0, 0x39, 0xC0, 0x61, 0xC3, 0xC3, 0xFF, 0x01, 0xF8, 0x00, 0xE1,
  0x00, 0xE3, 0x00, 0xCC, 0x01, 0xF0, 0x01, 0xC0, 0x0F, 0xFC, 0x07, 0xFF,
  0x07, 0x01, 0xC3, 0x80, 0x61, 0xC0, 0x30, 0xC0, 0x1C, 0x60, 0x0C, 0x30,
  0x06, 0x38, 0x07, 0x1C, 0x07, 0x0F, 0xFF, 0x07, 0xFE, 0x03, 0x0C, 0x01,
  0x87, 0x01, 0xC1, 0x80, 0xE0, 0xE0, 0x70, 0x30, 0x30, 0x1C, 0x18, 0x0E,
  0x0C, 0x03, 0x0E, 0x01, 0xC0, 0x03, 0xF8, 0x0F, 0xFE, 0x1E, 0x0F, 0x18,
  0x03, 0x38, 0x02, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1F,
  0xC0, 0x07, 0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x40, 0x0E, 0xE0, 0x1C, 0xF0, 0x3C, 0x3F, 0xF0, 0x1F, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x07, 0x38, 0x07, 0x38, 0x06, 0x38,
  0x06, 0x30, 0x06, 0x30, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0C, 0x60,
  0x0C, 0x60, 0x0C, 0x60, 0x1C, 0xE0, 0x1C, 0xE0, 0x18, 0xE0, 0x18, 0xE0,
  0x18, 0xE0, 0x38, 0xE0, 0x30, 0x70, 0x70, 0x7F, 0xE0, 0x1F, 0x80, 0xE0,
  0x07, 0xE0, 0x06, 0x60, 0x0E, 0x60, 0x0C, 0x60, 0x1C, 0x60, 0x1C, 0x60,
  0x18, 0x70, 0x38, 0x70, 0x30, 0x30, 0x70, 0x30, 0x60, 0x30, 0xE0, 0x30,
  0xC0, 0x31, 0xC0, 0x31, 0x80, 0x3B, 0x80, 0x3B, 0x00, 0x1B, 0x00, 0x1F,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x30, 0x00, 0xCC, 0x00, 0x73, 0x00, 0x1C,
  0xC0, 0x06, 0x30, 0x01, 0x8C, 0x38, 0x63, 0x1E, 0x38, 0xC7, 0x8C, 0x71,
  0x63, 0x1C, 0xD8, 0xC6, 0x36, 0x71, 0x99, 0x98, 0x66, 0x66, 0x19, 0x99,
  0x86, 0xC6, 0xE1, 0xB1, 0xB0, 0x6C, 0x6C, 0x1E, 0x1B, 0x07, 0x87, 0xC3,
  0xE1, 0xE0, 0xF0, 0x78, 0x00, 0x1C, 0x00, 0xE1, 0xC0, 0x38, 0x18, 0x0E,
  0x03, 0x81, 0xC0, 0x30, 0x70, 0x07, 0x1C, 0x00, 0xE7, 0x00, 0x0E, 0xC0,
  0x01, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF8, 0x00, 0x3F, 0x00,
  0x06, 0x60, 0x01, 0xCE, 0x00, 0x70, 0xC0, 0x1C, 0x1C, 0x07, 0x01, 0x80,
  0xC0, 0x38, 0x38, 0x03, 0x0E, 0x00, 0x70, 0xE0, 0x07, 0xF0, 0x03, 0x98,
  0x03, 0x8E, 0x03, 0x83, 0x03, 0x81, 0xC1, 0xC0, 0xE1, 0xC0, 0x31, 0xC0,
  0x1D, 0xC0, 0x06, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x01, 0xC0, 0x00, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0xFF,
  0xFC, 0xFF, 0xFE, 0x00, 0x0F, 0xF8, 0x7F, 0x83, 0x00, 0x18, 0x00, 0xC0,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x07, 0xF8, 0x3F, 0xC0,
  0xC0, 0x60, 0x60, 0x60, 0x60, 0x30, 0x30, 0x30, 0x30, 0x10, 0x18, 0x18,
  0x18, 0x18, 0x0C, 0x0C, 0x0C, 0x0C, 0x04, 0x06, 0x06, 0x06, 0x06, 0x03,
  0x03, 0x03, 0x03, 0x07, 0xF8, 0x3F, 0xC2, 0x06, 0x00, 0x70, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x83, 0xFC, 0x3F, 0xE0, 0x00,
  0xE0, 0x03, 0xC0, 0x0F, 0xC0, 0x39, 0x80, 0x63, 0x01, 0xC3, 0x07, 0x06,
  0x0C, 0x0E, 0x30, 0x0C, 0xE0, 0x1B, 0x80, 0x1A, 0x00, 0x30, 0xFF, 0xFF,
  0xFF, 0xF8, 0x4C, 0x66, 0x63, 0x0F, 0x8C, 0x7F, 0xB3, 0x83, 0xDC, 0x07,
  0x60, 0x1B, 0x80, 0x6E, 0x01, 0xB0, 0x06, 0xC0, 0x3B, 0x00, 0xEC, 0x07,
  0x30, 0x1C, 0xE1, 0xB1, 0xFC, 0xF3, 0xE3, 0xC0, 0x1C, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x7C, 0x33, 0xF8,
  0xD8, 0x73, 0x80, 0xDC, 0x03, 0x70, 0x0D, 0x80, 0x36, 0x00, 0xD8, 0x07,
  0x60, 0x1F, 0x80, 0x6E, 0x03, 0xB4, 0x1C, 0xDF, 0xE3, 0x3F, 0x00, 0x03,
  0xE0, 0x3F, 0xC1, 0xC3, 0x8C, 0x07, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x4E, 0x01, 0x98, 0x0C, 0x70, 0xF0, 0xFF, 0x81,
  0xF8, 0x00, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0C, 0x0F, 0x8C, 0x1F, 0xEC, 0x38, 0x2C, 0x70, 0x1C,
  0x60, 0x1C, 0xE0, 0x18, 0xE0, 0x18, 0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x38,
  0xC0, 0x38, 0xC0, 0x70, 0xE1, 0xB0, 0x7F, 0x30, 0x3E, 0x70, 0x03, 0xE0,
  0x3F, 0xE1, 0xC1, 0xCC, 0x07, 0x70, 0x1D, 0x80, 0x7E, 0x0F, 0xBF, 0xFC,
  0xFF, 0x03, 0x80, 0x0E, 0x01, 0x18, 0x0E, 0x70, 0x70, 0xFF, 0x81, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x7F, 0xFE, 0x0F, 0xFF, 0xC0, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x01, 0x03, 0x00, 0x30, 0x60, 0x07, 0x0C, 0x00, 0x73, 0x80,
  0x07, 0x70, 0x00, 0x7C, 0x00, 0x07, 0x00, 0x00, 0x07, 0xC6, 0x1F, 0xEC,
  0x70, 0x59, 0xC0, 0x73, 0x00, 0xEE, 0x01, 0x9C, 0x03, 0x30, 0x06, 0x60,
  0x0C, 0xC0, 0x39, 0x80, 0x73, 0x81, 0xC7, 0x05, 0x87, 0xF3, 0x07, 0xC6,
  0x00, 0x1C, 0x00, 0x30, 0x80, 0xE3, 0x83, 0x87, 0xFE, 0x03, 0xF0, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80,
  0x0E, 0x7C, 0x3B, 0xF8, 0xD8, 0xE3, 0x81, 0xCE, 0x07, 0x70, 0x19, 0xC0,
  0x66, 0x01, 0x98, 0x06, 0x60, 0x39, 0x80, 0xEE, 0x03, 0x38, 0x0C, 0xC0,
  0x33, 0x01, 0xC0, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x7F, 0x02, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x07, 0x00, 0x18, 0x00, 0x60, 0x01, 0x82, 0x0E, 0x1C, 0x38, 0xE0, 0xC7,
  0x03, 0x78, 0x0F, 0x80, 0x1C, 0x00, 0x00, 0x18, 0x00, 0xF0, 0x03, 0xC0,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x01, 0xC0,
  0x07, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC1, 0x07, 0x0E, 0x1C, 0x1C, 0x60,
  0x39, 0x80, 0x76, 0x00, 0xF8, 0x01, 0xC0, 0x1C, 0x00, 0x38, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0xF8, 0x33, 0xF8,
  0x6C, 0x70, 0xE0, 0x71, 0xC0, 0xC7, 0x01, 0x8E, 0x06, 0x18, 0x78, 0x33,
  0x80, 0x67, 0x00, 0xC6, 0x0F, 0x8E, 0x3F, 0x0D, 0xCC, 0x1F, 0x18, 0x1C,
  0x00, 0xFF, 0x07, 0xF8, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x02, 0x18, 0x38, 0xC7, 0x0E, 0x70, 0x77, 0x03, 0xF0, 0x0E,
  0x00, 0x19, 0xC7, 0x0D, 0xEF, 0xC7, 0x3C, 0x67, 0x0C, 0x33, 0x8E, 0x19,
  0x87, 0x0C, 0xC3, 0x0E, 0x61, 0x86, 0x70, 0xC3, 0x38, 0x61, 0x98, 0x70,
  0xCC, 0x30, 0xE6, 0x18, 0x63, 0x0C, 0x33, 0x86, 0x18, 0x39, 0xF0, 0xCF,
  0xE3, 0x63, 0x8E, 0x07, 0x38, 0x1D, 0xC0, 0x67, 0x01, 0x98, 0x06, 0x60,
  0x19, 0x80, 0xE6, 0x03, 0xB8, 0x0C, 0xE0, 0x33, 0x00, 0xCC, 0x07, 0x00,
  0x07, 0xE0, 0x7F, 0xC3, 0xC3, 0x9C, 0x07, 0x60, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xB8, 0x0E, 0x70, 0xF0, 0xFF,
  0x81, 0xF8, 0x00, 0x1C, 0xF8, 0x33, 0xF8, 0x6C, 0x38, 0xE0, 0x33, 0x80,
  0x67, 0x00, 0xCC, 0x01, 0x98, 0x03, 0x30, 0x0E, 0x60, 0x1D, 0xC0, 0x33,
  0x80, 0xE6, 0x83, 0x8D, 0xFE, 0x19, 0xF8, 0x30, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x00, 0x0F, 0x8C, 0x7F, 0xB3, 0x82,
  0xDC, 0x07, 0x60, 0x1F, 0x80, 0x6E, 0x01, 0xB0, 0x06, 0xC0, 0x1B, 0x00,
  0xEC, 0x03, 0xB0, 0x1C, 0xE1, 0xB1, 0xFC, 0xC3, 0xE3, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xE0, 0xFE, 0x3F, 0xFD, 0xF8,
  0x3A, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0xF0, 0x1F, 0xF8, 0x70, 0x38, 0xC0, 0x41, 0x80, 0x03, 0x00,
  0x07, 0xE0, 0x07, 0xFC, 0x00, 0x7C, 0x00, 0x38, 0x00, 0x33, 0x00, 0xEF,
  0x03, 0x87, 0xFE, 0x03, 0xF0, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x1C, 0x07, 0xFF, 0xFF, 0xFF, 0x06, 0x00, 0x18, 0x00,
  0xE0, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x06, 0x1C, 0x3C,
  0x63, 0xC1, 0x9C, 0x07, 0xE0, 0x0E, 0x00, 0x38, 0x0C, 0xC0, 0x33, 0x01,
  0xCC, 0x07, 0x70, 0x1D, 0xC0, 0x66, 0x01, 0x98, 0x06, 0x60, 0x39, 0x80,
  0xEE, 0x07, 0x18, 0x1C, 0x71, 0xB1, 0xFC, 0xC3, 0xE7, 0x00, 0xFC, 0x1B,
  0xF0, 0x71, 0xC0, 0xC6, 0x03, 0x18, 0x0C, 0x60, 0x31, 0x80, 0xCE, 0x07,
  0x38, 0x18, 0xC0, 0xE3, 0x07, 0x0C, 0x38, 0x33, 0xC0, 0xFE, 0x03, 0xE0,
  0x00, 0x30, 0xC6, 0x30, 0xC3, 0x30, 0xC3, 0x30, 0xC3, 0x70, 0xC3, 0x61,
  0xC3, 0x61, 0x83, 0x61, 0x83, 0x61, 0x87, 0x61, 0x86, 0xE3, 0x86, 0xC3,
  0x8E, 0xE7, 0x9C, 0x7D, 0xF8, 0x78, 0xF0, 0x03, 0x87, 0x83, 0xE7, 0xE1,
  0xCD, 0x9D, 0xE3, 0xC3, 0x20, 0xE0, 0xC0, 0x38, 0x70, 0x0E, 0x00, 0x03,
  0x00, 0x01, 0xC0, 0x38, 0x70, 0x0C, 0x1C, 0x13, 0x0F, 0x1E, 0xE6, 0xCE,
  0x1F, 0x9F, 0x07, 0x87, 0x00, 0x1C, 0x06, 0x30, 0x0C, 0x60, 0x18, 0xC0,
  0x73, 0x80, 0xE7, 0x01, 0x8C, 0x03, 0x18, 0x06, 0x30, 0x1C, 0x60, 0x38,
  0xC0, 0xE1, 0x81, 0xC3, 0x8D, 0x87, 0xF3, 0x03, 0xCE, 0x00, 0x1C, 0x00,
  0x30, 0x80, 0xE3, 0x83, 0x87, 0xFE, 0x03, 0xF0, 0x00, 0x1F, 0x8E, 0x7F,
  0xDD, 0xC3, 0xF3, 0x00, 0xC6, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x0E, 0x00, 0x38, 0x30, 0xE0, 0x63, 0x80, 0xEF, 0xF8, 0xD9, 0xFF, 0xB0,
  0x7E, 0x00, 0x01, 0xFC, 0x0F, 0xF0, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x1C, 0x00, 0xE0, 0x7F,
  0x03, 0xF8, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xFF, 0x01,
  0xFC, 0x00, 0x0E, 0x18, 0x30, 0x60, 0xC1, 0x86, 0x0C, 0x18, 0x30, 0x60,
  0xC3, 0x06, 0x0C, 0x18, 0x30, 0x61, 0x83, 0x06, 0x0C, 0x18, 0x30, 0xC1,
  0x83, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x83, 0x00, 0x0C, 0x00, 0x30, 0x01,
  0x80, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xE0, 0x01,
  0xFC, 0x07, 0xF0, 0x30, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00,
  0xC0, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x01, 0xFC, 0x0F,
  0xE0, 0x00, 0x0E, 0x03, 0x3F, 0x03, 0x33, 0x86, 0x61, 0xCE, 0x60, 0xFC,
  0xC0, 0x78,
};

const GFXglyph IBMPlexMono_Italic30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 7, 21, 18, 6, -21 },
  { 20, 9, 8, 18, 6, -22 },
  { 29, 19, 21, 18, 0, -21 },
  { 79, 17, 27, 18, 1, -24 },
  { 137, 21, 21, 18, -1, -21 },
  { 193, 18, 21, 18, 0, -21 },
  { 241, 4, 8, 18, 9, -22 },
  { 245, 11, 27, 18, 6, -23 },
  { 283, 11, 27, 18, 1, -23 },
  { 321, 15, 15, 18, 2, -16 },
  { 350, 14, 14, 18, 2, -16 },
  { 375, 7, 8, 18, 4, -4 },
  { 382, 9, 2, 18, 5, -10 },
  { 385, 4, 4, 18, 6, -4 },
  { 387, 17, 27, 18, 1, -23 },
  { 445, 15, 21, 18, 2, -21 },
  { 485, 15, 21, 18, 1, -21 },
  { 525, 16, 21, 18, 1, -21 },
  { 567, 16, 21, 18, 1, -21 },
  { 609, 17, 21, 18, 0, -21 },
  { 654, 16, 21, 18, 1, -21 },
  { 696, 14, 21, 18, 2, -21 },
  { 733, 15, 21, 18, 3, -21 },
  { 773, 16, 21, 18, 1, -21 },
  { 815, 14, 21, 18, 3, -21 },
  { 852, 6, 16, 18, 6, -16 },
  { 864, 8, 20, 18, 4, -16 },
  { 884, 14, 17, 18, 3, -18 },
  { 914, 15, 8, 18, 2, -13 },
  { 929, 15, 17, 18, 1, -18 },
  { 961, 13, 21, 18, 4, -21 },
  { 996, 15, 24, 18, 2, -21 },
  { 1041, 16, 21, 18, 0, -21 },
  { 1083, 16, 21, 18, 1, -21 },
  { 1125, 15, 21, 18, 2, -21 },
  { 1165, 15, 21, 18, 2, -21 },
  { 1205, 17, 21, 18, 1, -21 },
  { 1250, 17, 21, 18, 1, -21 },
  { 1295, 15, 21, 18, 2, -21 },
  { 1335, 17, 21, 18, 1, -21 },
  { 1380, 17, 21, 18, 1, -21 },
  { 1425, 15, 21, 18, 2, -21 },
  { 1465, 18, 21, 18, 1, -21 },
  { 1513, 13, 21, 18, 2, -21 },
  { 1548, 17, 21, 18, 1, -21 },
  { 1593, 17, 21, 18, 1, -21 },
  { 1638, 15, 21, 18, 2, -21 },
  { 1678, 17, 21, 18, 1, -21 },
  { 1723, 15, 26, 18, 2, -21 },
  { 1772, 17, 21, 18, 1, -21 },
  { 1817, 16, 21, 18, 1, -21 },
  { 1859, 16, 21, 18, 3, -21 },
  { 1901, 16, 21, 18, 2, -21 },
  { 1943, 16, 21, 18, 3, -21 },
  { 1985, 18, 21, 18, 1, -21 },
  { 2033, 19, 21, 18, 0, -21 },
  { 2083, 17, 21, 18, 3, -21 },
  { 2128, 18, 21, 18, 0, -21 },
  { 2176, 13, 27, 18, 5, -23 },
  { 2220, 8, 27, 18, 5, -23 },
  { 2247, 13, 27, 18, 0, -23 },
  { 2291, 15, 12, 18, 2, -21 },
  { 2314, 15, 2, 18, 0, 3 },
  { 2318, 4, 6, 18, 7, -24 },
  { 2321, 14, 15, 18, 2, -15 },
  { 2348, 14, 22, 18, 2, -22 },
  { 2387, 14, 15, 18, 2, -15 },
  { 2414, 16, 22, 18, 2, -22 },
  { 2458, 14, 15, 18, 2, -15 },
  { 2485, 19, 28, 18, 0, -22 },
  { 2552, 15, 21, 18, 1, -15 },
  { 2592, 14, 22, 18, 2, -22 },
  { 2631, 14, 22, 18, 2, -22 },
  { 2670, 14, 28, 18, 2, -22 },
  { 2719, 15, 22, 18, 2, -22 },
  { 2761, 13, 22, 18, 3, -22 },
  { 2797, 17, 15, 18, 0, -15 },
  { 2829, 14, 15, 18, 2, -15 },
  { 2856, 14, 15, 18, 2, -15 },
  { 2883, 15, 21, 18, 1, -15 },
  { 2923, 14, 21, 18, 2, -15 },
  { 2960, 15, 15, 18, 3, -15 },
  { 2989, 15, 15, 18, 1, -15 },
  { 3018, 14, 21, 18, 2, -21 },
  { 3055, 14, 15, 18, 2, -15 },
  { 3082, 14, 15, 18, 2, -15 },
  { 3109, 16, 15, 18, 1, -15 },
  { 3139, 18, 15, 18, 0, -15 },
  { 3173, 15, 21, 18, 1, -15 },
  { 3213, 15, 15, 18, 2, -15 },
  { 3242, 14, 27, 18, 3, -23 },
  { 3290, 7, 27, 18, 6, -23 },
  { 3314, 14, 27, 18, 1, -23 },
  { 3362, 16, 6, 18, 1, -12 },
};

const GFXfont IBMPlexMono_Italic30pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Italic30pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Italic30pt7bGlyphs,
  0x20, 0x7E, 39
};

#endif // _IBMPLEXMONO_ITALIC30PT7B_H_
