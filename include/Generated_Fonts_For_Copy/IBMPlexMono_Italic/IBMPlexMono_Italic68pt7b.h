#ifndef _IBMPLEXMONO_ITALIC68PT7B_H_
#define _IBMPLEXMONO_ITALIC68PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Italic.ttf
// Size: 68pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Italic68pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x7F, 0xC0, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F,
  0xFC, 0x1F, 0xF8, 0x3F, 0xE0, 0x1F, 0x80, 0x1F, 0x81, 0xF1, 0xF0, 0x1F,
  0x1F, 0x01, 0xF1, 0xF0, 0x1F, 0x1F, 0x01, 0xF1, 0xF0, 0x3E, 0x3E, 0x03,
  0xE3, 0xE0, 0x3E, 0x3E, 0x03, 0xE3, 0xE0, 0x3E, 0x3E, 0x03, 0xE3, 0xE0,
  0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0x7C,
  0x07, 0xC7, 0xC0, 0xF8, 0xF8, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x1F, 0x00, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x1F, 0xFF, 0xC0, 0x7F, 0xFE,
  0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x83, 0xFF,
  0xF0, 0x1F, 0xFF, 0xC1, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x00, 0xF8, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x07,
  0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8,
  0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x00, 0x7C, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x00, 0x07, 0xC0,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0x8F, 0x3F, 0xF0, 0x07, 0xF8,
  0x3C, 0x1F, 0xE0, 0x1F, 0x80, 0xF0, 0x3F, 0x80, 0xFC, 0x03, 0xC0, 0x3F,
  0x03, 0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x80, 0x3C, 0x01, 0x00, 0x7E, 0x01,
  0xE0, 0x00, 0x01, 0xF8, 0x07, 0x80, 0x00, 0x07, 0xE0, 0x1E, 0x00, 0x00,
  0x1F, 0x80, 0x78, 0x00, 0x00, 0x7E, 0x01, 0xE0, 0x00, 0x01, 0xF8, 0x07,
  0x80, 0x00, 0x07, 0xF0, 0x3C, 0x00, 0x00, 0x0F, 0xE0, 0xF0, 0x00, 0x00,
  0x3F, 0xC3, 0xC0, 0x00, 0x00, 0x7F, 0xCF, 0x00, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x07, 0x9F, 0xF8, 0x00, 0x00, 0x1E, 0x1F, 0xE0, 0x00,
  0x00, 0xF0, 0x1F, 0xC0, 0x00, 0x03, 0xC0, 0x3F, 0x00, 0x00, 0x0F, 0x00,
  0xFC, 0x00, 0x00, 0x3C, 0x03, 0xF0, 0x00, 0x00, 0xF0, 0x07, 0xC0, 0x00,
  0x03, 0xC0, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x03,
  0xF0, 0x10, 0x01, 0xE0, 0x0F, 0xC0, 0xE0, 0x07, 0x80, 0x3F, 0x07, 0xC0,
  0x1E, 0x01, 0xF8, 0x3F, 0x80, 0x78, 0x0F, 0xE0, 0xFF, 0x03, 0xC0, 0x7F,
  0x01, 0xFE, 0x0F, 0x03, 0xFC, 0x03, 0xFF, 0x3C, 0x7F, 0xE0, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xFE, 0x00,
  0x01, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xC0, 0x07, 0xE0, 0xFC, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x01, 0xF0, 0x03, 0xE0, 0x0F,
  0x80, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x07, 0x80, 0x0F, 0x80, 0x7C,
  0x00, 0x1F, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x3E, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0xF0, 0x3E, 0x00,
  0x01, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0x03, 0xE0, 0x07, 0xC1, 0xF0, 0x00,
  0x03, 0xC0, 0x1F, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x7E, 0x0F, 0x00, 0x00,
  0x0F, 0xC1, 0xF8, 0x3E, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0x82, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3E, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0xF8, 0x3F, 0x07, 0xE0, 0x00, 0x01, 0xE0, 0xFC, 0x07, 0xC0, 0x00, 0x07,
  0xC1, 0xF0, 0x07, 0x80, 0x00, 0x1F, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0x7C,
  0x0F, 0x80, 0x1F, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x7C, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0xF8, 0x00, 0x1F, 0x01,
  0xF0, 0x01, 0xF0, 0x00, 0x7C, 0x03, 0xE0, 0x03, 0xC0, 0x01, 0xF0, 0x07,
  0xC0, 0x0F, 0x80, 0x03, 0xE0, 0x0F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x1F,
  0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x3C,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xC0, 0x00, 0xFF,
  0xFF, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x3E, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xE0,
  0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x0F, 0x80,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x00, 0x3E,
  0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x0F,
  0xC0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x00, 0x7F,
  0xE3, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x00, 0x0F, 0xE1, 0xFF, 0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x7C,
  0x00, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x08, 0xFC, 0x00, 0x0F, 0xC0,
  0x1C, 0xFC, 0x00, 0x0F, 0xC0, 0x1F, 0xFC, 0x00, 0x0F, 0xE0, 0x3E, 0xFC,
  0x00, 0x1B, 0xE0, 0x3E, 0xFC, 0x00, 0x1B, 0xF0, 0x7C, 0x7E, 0x00, 0x39,
  0xF0, 0xFC, 0x7F, 0x00, 0x79, 0xF8, 0xF8, 0x3F, 0x81, 0xF0, 0xFD, 0xF8,
  0x3F, 0xFF, 0xF0, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x7F, 0xF0, 0x0F, 0xFF,
  0xC0, 0x7F, 0xE0, 0x07, 0xFF, 0x80, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0x00, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E,
  0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0xF8, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x04, 0x00, 0x1F, 0x00, 0x05, 0xE0, 0x07, 0xC0, 0x0F, 0x7F, 0x01, 0xF0,
  0x1F, 0xFF, 0xF8, 0x7C, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xF9, 0xF8, 0x00,
  0x00, 0xFC, 0x3E, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x3F, 0x01, 0xF0,
  0x00, 0x1F, 0x80, 0x7E, 0x00, 0x0F, 0xC0, 0x0F, 0x80, 0x07, 0xE0, 0x03,
  0xF0, 0x03, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xFF, 0x01, 0xFE, 0x03,
  0xFC, 0x03, 0xFC, 0x03, 0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0x0F,
  0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x1F, 0x9F,
  0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0x01, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0xFC, 0x03,
  0xF8, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x1F,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x00, 0x7E, 0x1F, 0x00, 0x00,
  0x0F, 0xC7, 0xE0, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x3F, 0x1F, 0x00,
  0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x1F, 0x9F,
  0x80, 0x00, 0x03, 0xF3, 0xE0, 0x1F, 0x80, 0x7E, 0xFC, 0x07, 0xF8, 0x0F,
  0xDF, 0x80, 0xFF, 0x01, 0xF3, 0xF0, 0x3F, 0xE0, 0x7E, 0x7E, 0x07, 0xFC,
  0x0F, 0xCF, 0xC0, 0xFF, 0x01, 0xF9, 0xF0, 0x1F, 0xE0, 0x3F, 0x7E, 0x01,
  0xF8, 0x07, 0xEF, 0xC0, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x00, 0x3F, 0x3F,
  0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x1F,
  0x1F, 0x80, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00,
  0x1F, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x00, 0xF8, 0x1F, 0x00,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x03, 0xF8, 0x07,
  0xE0, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xF0, 0x1F, 0xE0,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xF7, 0xC0, 0x00,
  0x3F, 0xCF, 0xC0, 0x00, 0x7F, 0x8F, 0xC0, 0x00, 0xFF, 0x0F, 0xC0, 0x01,
  0xFE, 0x0F, 0x80, 0x03, 0xF8, 0x0F, 0x80, 0x07, 0xF0, 0x0F, 0x80, 0x0F,
  0xE0, 0x1F, 0x80, 0x0F, 0xC0, 0x1F, 0x80, 0x07, 0x80, 0x1F, 0x80, 0x02,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0xC0,
  0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x7E,
  0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x01, 0xF0,
  0x0E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0x80, 0xFF, 0x80, 0x3F, 0xC0, 0x07, 0xF8, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0xF8, 0x00, 0x07, 0xE0, 0x0E, 0x00, 0x00, 0xFC, 0x00, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x06,
  0x00, 0x00, 0x1F, 0xC3, 0xC0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0xFE,
  0x1F, 0xC0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x0F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x00, 0x7C,
  0xF8, 0x00, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00,
  0x07, 0xE3, 0xE0, 0x00, 0x00, 0x7E, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0xF8,
  0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x00, 0x3F,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x1F,
  0x80, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xF0,
  0x00, 0xF8, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0xFC, 0x00,
  0x07, 0xC0, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x07,
  0xC0, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x00, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0xFF, 0x80, 0x00, 0x3C, 0x3F, 0xFE, 0x00, 0x07, 0xC7, 0xFF, 0xF8,
  0x00, 0x7C, 0xFF, 0xFF, 0xC0, 0x07, 0xDF, 0xFF, 0xFE, 0x00, 0x7F, 0xC0,
  0x3F, 0xE0, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x07,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x80, 0x00, 0x07, 0xF0, 0x3C, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00,
  0x0F, 0xE0, 0xFF, 0x00, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x3F,
  0xE0, 0x1F, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0xFF, 0x00, 0x0F, 0xC3, 0xFF, 0xE0, 0x0F, 0x8F, 0xFF, 0xF0, 0x1F, 0x9F,
  0xFF, 0xF8, 0x1F, 0x3F, 0xFF, 0xFC, 0x3F, 0x7C, 0x03, 0xFE, 0x3E, 0xF0,
  0x00, 0xFE, 0x3F, 0xC0, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0x3F, 0x7F, 0x00,
  0x00, 0x3F, 0x7F, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0x7C, 0x00,
  0x00, 0xFC, 0x7E, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x03, 0xF8, 0x3F, 0x80,
  0x07, 0xF0, 0x3F, 0xE0, 0x3F, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x9F,
  0x00, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x00, 0xFC,
  0x7C, 0x00, 0x00, 0x7E, 0x1F, 0x00, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFC, 0x07,
  0xFE, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x7E, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x3F, 0x00, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x03, 0xF0,
  0x7E, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00,
  0x3E, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x00, 0x7E, 0x07, 0xE0,
  0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x1F, 0x80, 0x03, 0xF0, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFC, 0x03, 0xFE, 0x00,
  0xFE, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x3F, 0x00, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x00, 0xF8, 0x7C, 0x00,
  0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x00, 0x1F, 0x8F,
  0xC0, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x01,
  0xF8, 0xFC, 0x00, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0x03, 0xF0, 0xFE, 0x00,
  0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x03, 0xFE, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x07,
  0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x7E, 0x1F,
  0x80, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x3F, 0x7E,
  0x00, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x01, 0xFE, 0x7E,
  0x00, 0x03, 0xFE, 0x7F, 0x80, 0x07, 0x7C, 0x3F, 0xE0, 0x3F, 0xFC, 0x3F,
  0xFF, 0xFE, 0xF8, 0x1F, 0xFF, 0xF9, 0xF8, 0x0F, 0xFF, 0xF1, 0xF0, 0x03,
  0xFF, 0xE3, 0xF0, 0x00, 0xFF, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x07, 0xF8, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F,
  0xE0, 0xFF, 0x81, 0xFF, 0x03, 0xFC, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x3F,
  0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFE, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x07, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00,
  0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x0F, 0xF8, 0x1F,
  0xF0, 0xFE, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0xFE, 0x7E, 0x00, 0x03, 0xF7,
  0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7E, 0xF0, 0x00, 0x03, 0xF1, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F,
  0xE0, 0x3F, 0xC0, 0x1F, 0xC0, 0x03, 0xF8, 0x07, 0xE0, 0x00, 0x7E, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0x7C,
  0x1F, 0x00, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x01,
  0xF0, 0xF8, 0x01, 0xF8, 0x7C, 0x7C, 0x01, 0xFF, 0x1F, 0x1F, 0x00, 0xFF,
  0xE7, 0xC7, 0xC0, 0x7F, 0xFD, 0xF3, 0xE0, 0x3F, 0xFF, 0x7C, 0xF8, 0x0F,
  0xE0, 0xDE, 0x3E, 0x07, 0xE0, 0x1F, 0x8F, 0x81, 0xF0, 0x03, 0xE3, 0xE0,
  0xFC, 0x00, 0xF9, 0xF8, 0x3E, 0x00, 0x3E, 0x7C, 0x0F, 0x80, 0x0F, 0x9F,
  0x07, 0xE0, 0x03, 0xC7, 0xC1, 0xF8, 0x00, 0xF1, 0xF0, 0x7C, 0x00, 0x7C,
  0x7C, 0x1F, 0x00, 0x1F, 0x3E, 0x07, 0xC0, 0x07, 0xCF, 0x81, 0xF0, 0x01,
  0xF3, 0xE0, 0x7C, 0x00, 0xF8, 0xF8, 0x1F, 0x00, 0x3E, 0x3E, 0x07, 0xC0,
  0x0F, 0x8F, 0x81, 0xF0, 0x07, 0xE3, 0xE0, 0x7C, 0x03, 0xF8, 0xF8, 0x1F,
  0x81, 0xBE, 0x3E, 0x07, 0xF0, 0xEF, 0x0F, 0x80, 0xFF, 0xF7, 0xC3, 0xE0,
  0x3F, 0xFD, 0xF0, 0xF8, 0x07, 0xFE, 0x7C, 0x3E, 0x00, 0xFF, 0x1F, 0x0F,
  0x80, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x03, 0xE7, 0xC0,
  0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x0F,
  0x8F, 0xC0, 0x00, 0x00, 0xFC, 0x3E, 0x00, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0x00, 0x7E, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0x3F, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00,
  0xFC, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x00,
  0x7C, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x7E, 0x00,
  0x00, 0x3E, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x0F, 0xC1,
  0xF8, 0x00, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00,
  0x1F, 0x87, 0xE0, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x03, 0xE3, 0xF0,
  0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF8, 0x03,
  0xF0, 0x00, 0x7F, 0x80, 0x7C, 0x00, 0x03, 0xF0, 0x0F, 0x80, 0x00, 0x3E,
  0x01, 0xF0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00,
  0x1F, 0x81, 0xF8, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0x7E, 0x07, 0xC0,
  0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x00, 0xFC,
  0x03, 0xE0, 0x00, 0x7F, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xFC, 0x01, 0xF0, 0x00, 0x3F, 0xC0, 0x3E, 0x00, 0x01, 0xFC, 0x0F,
  0xC0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x3F,
  0x07, 0xC0, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00,
  0x1F, 0x87, 0xE0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x7E, 0x1F, 0x80,
  0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x00, 0x7E, 0x0F,
  0x80, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x01, 0xFE,
  0x0F, 0xC0, 0x00, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x0F, 0xE0,
  0x00, 0xFE, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0xF8, 0x1F,
  0x80, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x03, 0xD0, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1C, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x00,
  0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x3F, 0x00,
  0x01, 0xF8, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x0F,
  0xF8, 0x1F, 0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x7C, 0x00, 0xFF, 0xC0, 0x1F, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x00, 0xFE,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00,
  0xFC, 0x0F, 0x80, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x07, 0xC1, 0xF8, 0x00,
  0x01, 0xF0, 0x7E, 0x00, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x1F, 0x07, 0xE0,
  0x00, 0x07, 0xC1, 0xF0, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0x7C, 0x3F,
  0x00, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x03, 0xF0,
  0xF8, 0x00, 0x00, 0xFC, 0x3E, 0x00, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x0F,
  0xC7, 0xE0, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x00,
  0x7E, 0x1F, 0x00, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0x07, 0xE1, 0xF0, 0x00,
  0x01, 0xF8, 0xFC, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x3F, 0x0F, 0xC0,
  0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x01, 0xF8, 0x7E,
  0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x3F, 0x81,
  0xF8, 0x00, 0x1F, 0xC0, 0x7C, 0x00, 0x0F, 0xF0, 0x1F, 0x00, 0x1F, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF8,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xFC, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x7E, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x03,
  0xC0, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0xFF, 0x8F, 0xC0, 0x0F,
  0xFF, 0xE1, 0xF8, 0x01, 0xFF, 0xFC, 0x3F, 0x00, 0x3F, 0xFF, 0x87, 0xC0,
  0x07, 0xFF, 0xF0, 0xF8, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x0F, 0x87,
  0xE0, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x07,
  0xC1, 0xF0, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x3F, 0x07, 0xC0, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x03, 0xFC, 0x07, 0xE0, 0x00, 0xEF, 0x80,
  0xFE, 0x00, 0x3B, 0xF0, 0x0F, 0xF0, 0x1F, 0x7C, 0x01, 0xFF, 0xFF, 0xCF,
  0x80, 0x1F, 0xFF, 0xF1, 0xF0, 0x01, 0xFF, 0xFC, 0x3E, 0x00, 0x0F, 0xFF,
  0x07, 0xC0, 0x00, 0x7F, 0x01, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x00, 0xF8, 0x0F,
  0xC0, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x00, 0xF8, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x7E, 0x00, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0xFC, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x3E, 0x00, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x3F, 0x00, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0xFC, 0x00, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x3F,
  0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x7C, 0x00, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x3F, 0x00,
  0x00, 0x3F, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x7C, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x00,
  0x3F, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x7E,
  0x00, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x38, 0x00, 0x03, 0xE0,
  0x3F, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x3F,
  0x80, 0x7E, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x0F,
  0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x7C, 0x00, 0x00, 0x7F, 0x00, 0x7E, 0x00,
  0x00, 0x7F, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x00, 0x7F,
  0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0x00, 0x03,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00,
  0x7F, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0x00,
  0x00, 0x3E, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0x80, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x7F,
  0x00, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x00, 0x01, 0xF0, 0x7F, 0x00, 0x00,
  0x00, 0xF8, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x7F, 0x80, 0x00, 0x00, 0x7E,
  0x7F, 0xC0, 0x00, 0x00, 0x3F, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0x7F, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0x7E, 0x00, 0x00, 0x07, 0xFF, 0x3F, 0x00, 0x00,
  0x07, 0xFF, 0x0F, 0xC0, 0x00, 0x03, 0xFF, 0x07, 0xE0, 0x00, 0x01, 0xFF,
  0x01, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x3E,
  0x00, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x03,
  0xFC, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x1F,
  0xF0, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x03,
  0xFF, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x03, 0xEF, 0x80, 0x1F, 0x7C, 0x07,
  0xDF, 0x00, 0x7F, 0xF8, 0x0F, 0xBE, 0x00, 0xFB, 0xE0, 0x1F, 0x3C, 0x03,
  0xE7, 0xC0, 0x3E, 0x7C, 0x07, 0xCF, 0x80, 0xF8, 0xF8, 0x1F, 0x1F, 0x01,
  0xF1, 0xF0, 0x7E, 0x3E, 0x03, 0xE1, 0xE0, 0xF8, 0xFC, 0x07, 0xC3, 0xE3,
  0xE1, 0xF0, 0x0F, 0x87, 0xC7, 0xC3, 0xE0, 0x1F, 0x0F, 0x9F, 0x07, 0xC0,
  0x7C, 0x0F, 0x7C, 0x0F, 0x80, 0xF8, 0x1F, 0xF8, 0x1F, 0x01, 0xF0, 0x3F,
  0xE0, 0x7E, 0x03, 0xE0, 0x7F, 0xC0, 0xF8, 0x07, 0xC0, 0x7F, 0x01, 0xF0,
  0x0F, 0x80, 0xFC, 0x03, 0xE0, 0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x7C, 0x03,
  0xE0, 0x0F, 0x80, 0xF8, 0x03, 0xC0, 0x3F, 0x01, 0xF0, 0x07, 0x00, 0x7C,
  0x03, 0xE0, 0x0C, 0x00, 0xF8, 0x07, 0xC0, 0x18, 0x01, 0xF0, 0x1F, 0x00,
  0x20, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xF8, 0x0F, 0xF8,
  0x00, 0x07, 0xC0, 0x7F, 0xC0, 0x00, 0x3E, 0x03, 0xFE, 0x00, 0x03, 0xF0,
  0x1F, 0xF8, 0x00, 0x1F, 0x80, 0xFF, 0xC0, 0x00, 0xF8, 0x0F, 0xFE, 0x00,
  0x07, 0xC0, 0x7F, 0xF0, 0x00, 0x3E, 0x03, 0xE7, 0xC0, 0x01, 0xF0, 0x1F,
  0x3E, 0x00, 0x1F, 0x80, 0xF9, 0xF0, 0x00, 0xF8, 0x07, 0xCF, 0x80, 0x07,
  0xC0, 0x7E, 0x7E, 0x00, 0x3E, 0x03, 0xF1, 0xF0, 0x01, 0xF0, 0x1F, 0x0F,
  0x80, 0x0F, 0x80, 0xF8, 0x7C, 0x00, 0xFC, 0x07, 0xC3, 0xE0, 0x07, 0xC0,
  0x3E, 0x0F, 0x80, 0x3E, 0x03, 0xF0, 0x7C, 0x01, 0xF0, 0x1F, 0x03, 0xE0,
  0x0F, 0x80, 0xF8, 0x1F, 0x00, 0x7C, 0x07, 0xC0, 0xFC, 0x07, 0xE0, 0x3E,
  0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x1F, 0x03, 0xE0, 0x3E, 0x00,
  0xF8, 0x3F, 0x01, 0xF0, 0x07, 0xC1, 0xF0, 0x0F, 0x80, 0x3E, 0x0F, 0x80,
  0xFC, 0x00, 0xF8, 0x7C, 0x07, 0xC0, 0x07, 0xC3, 0xE0, 0x3E, 0x00, 0x3E,
  0x1F, 0x01, 0xF0, 0x01, 0xF1, 0xF8, 0x0F, 0x80, 0x0F, 0x8F, 0x80, 0x7C,
  0x00, 0x3E, 0x7C, 0x07, 0xE0, 0x01, 0xF3, 0xE0, 0x3E, 0x00, 0x0F, 0x9F,
  0x01, 0xF0, 0x00, 0x7C, 0xF8, 0x0F, 0x80, 0x01, 0xFF, 0xC0, 0x7C, 0x00,
  0x0F, 0xFC, 0x03, 0xE0, 0x00, 0x7F, 0xE0, 0x3F, 0x00, 0x03, 0xFF, 0x01,
  0xF0, 0x00, 0x1F, 0xF8, 0x0F, 0x80, 0x00, 0x7F, 0xC0, 0x7C, 0x00, 0x03,
  0xFE, 0x03, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x7E,
  0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0xFC, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x01,
  0xF8, 0xFC, 0x00, 0x00, 0x3F, 0x1F, 0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00,
  0x00, 0xFC, 0xFC, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x03, 0xF3, 0xF0,
  0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x03, 0xF3,
  0xF0, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x01,
  0xF9, 0xF8, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0x01, 0xF9, 0xF8, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0x07, 0xE3,
  0xF0, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0xF8, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x7E, 0x00, 0x03, 0xF8, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x1F, 0xF0, 0x1F, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xFC, 0x00, 0x07, 0xF8, 0x07, 0xE0,
  0x00, 0x1F, 0xC0, 0x3E, 0x00, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x0F, 0x80, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x3F, 0x00, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x00, 0xFC, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x3F, 0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x01, 0xF8, 0x0F, 0x80,
  0x00, 0x1F, 0xC0, 0x7C, 0x00, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x3F, 0xE0,
  0x3F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0x0F, 0xC0,
  0x7E, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0xFC, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x0F, 0xC7, 0xE0, 0x00,
  0x01, 0xF8, 0xFC, 0x00, 0x00, 0x3F, 0x1F, 0x00, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x03, 0xF3,
  0xF0, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x03,
  0xF3, 0xF0, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00,
  0x01, 0xF9, 0xF8, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x07, 0xE7,
  0xE0, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0x07,
  0xE3, 0xF0, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00,
  0x07, 0xE1, 0xF8, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xF0, 0x1F, 0xE0, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x18, 0x00, 0x03, 0xF0, 0x07, 0x80, 0x00, 0x3F, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x7F, 0x1F, 0x80, 0x00, 0x07, 0xE7,
  0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xFC,
  0x00, 0x07, 0xF8, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x3E, 0x00, 0x00, 0x7E,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0xFC, 0x00,
  0x00, 0x7E, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x1F, 0x81,
  0xF0, 0x00, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00,
  0x7E, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x1F, 0x81, 0xF8,
  0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x01, 0xFC,
  0x07, 0xE0, 0x00, 0x3F, 0xE0, 0x3F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x03, 0xE0,
  0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x03, 0xE0,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x7C, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x07, 0xC0,
  0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x7F,
  0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x03,
  0xC0, 0x7E, 0x00, 0x00, 0x04, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x40, 0x00, 0x00,
  0x3F, 0x03, 0x80, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0xFE,
  0x00, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x00, 0xFC, 0x1F,
  0x80, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x00, 0x7E,
  0x0F, 0x80, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x00,
  0x7E, 0x0F, 0xC0, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x01, 0xF8, 0x3E, 0x00,
  0x00, 0x3F, 0x07, 0xC0, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x00, 0xF8, 0x3F,
  0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x00, 0xFC,
  0x1F, 0x00, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x00,
  0x7C, 0x1F, 0x80, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x03, 0xF0, 0x7C, 0x00,
  0x00, 0x7E, 0x0F, 0x80, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x01, 0xF0, 0x7E,
  0x00, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x01, 0xF8,
  0x3E, 0x00, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x00,
  0xF8, 0x3F, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0xFC, 0x00,
  0x00, 0xFC, 0x1F, 0x80, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x7C,
  0x00, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x03, 0xE0,
  0x3F, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x07,
  0xE0, 0x0F, 0xE0, 0x03, 0xFC, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF7, 0xC0, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x07, 0xE7, 0xC0, 0x00,
  0x00, 0x7E, 0x7C, 0x00, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x00, 0xFC, 0x7E,
  0x00, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x00, 0x3F,
  0x03, 0xE0, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00,
  0x07, 0xE0, 0x3E, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x3F,
  0x00, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x1F, 0x00, 0x01, 0xF8,
  0x01, 0xF0, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x01, 0xF0, 0x00,
  0x7E, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x1F, 0x80,
  0x00, 0xF8, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x3F, 0x00, 0x00, 0xF8, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x0F,
  0xC0, 0xFC, 0x00, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0xF8, 0x00,
  0x00, 0x7C, 0x1F, 0x80, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x00, 0x7C, 0x3F,
  0x00, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x03,
  0xE7, 0xC0, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x03, 0xEF, 0x80, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x00, 0x3E,
  0x0F, 0x80, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x00,
  0x7C, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x1F, 0x00, 0xFE,
  0x00, 0xF8, 0x1F, 0x00, 0xFE, 0x00, 0xF8, 0x1F, 0x00, 0xFE, 0x01, 0xF0,
  0x1F, 0x01, 0xFF, 0x01, 0xF0, 0x1F, 0x01, 0xFF, 0x01, 0xF0, 0x1E, 0x03,
  0xFF, 0x01, 0xF0, 0x1E, 0x03, 0xFF, 0x01, 0xF0, 0x3E, 0x03, 0xCF, 0x03,
  0xE0, 0x3E, 0x07, 0xCF, 0x03, 0xE0, 0x3E, 0x07, 0x8F, 0x03, 0xE0, 0x3E,
  0x07, 0x8F, 0x03, 0xE0, 0x3E, 0x0F, 0x8F, 0x07, 0xC0, 0x3E, 0x0F, 0x0F,
  0x07, 0xC0, 0x3E, 0x1F, 0x0F, 0x07, 0xC0, 0x3E, 0x1F, 0x0F, 0x07, 0xC0,
  0x3E, 0x1E, 0x0F, 0x0F, 0x80, 0x3C, 0x3E, 0x0F, 0x0F, 0x80, 0x3C, 0x3C,
  0x0F, 0x0F, 0x80, 0x7C, 0x3C, 0x0F, 0x0F, 0x80, 0x7C, 0x7C, 0x0F, 0x1F,
  0x00, 0x7C, 0x78, 0x0F, 0x1F, 0x00, 0x7C, 0xF8, 0x0F, 0x1F, 0x00, 0x7C,
  0xF8, 0x0F, 0x1F, 0x00, 0x7C, 0xF0, 0x0F, 0xBE, 0x00, 0x7D, 0xF0, 0x0F,
  0xBE, 0x00, 0x7D, 0xF0, 0x0F, 0xBE, 0x00, 0x7D, 0xE0, 0x0F, 0xBE, 0x00,
  0x7B, 0xE0, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xC0,
  0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x0F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0xFE, 0x00,
  0x00, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x00,
  0x00, 0x1F, 0x87, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00, 0x00,
  0x03, 0xF7, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xC3, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x0F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0x03, 0xF1, 0xF8, 0x00,
  0x00, 0x0F, 0xE1, 0xF0, 0x00, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x00, 0x7E,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x0F, 0xC0,
  0x00, 0x1F, 0xC0, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x01, 0xFC,
  0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0xFE, 0x00, 0x00, 0x07, 0xE1, 0xF8,
  0x00, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x00,
  0x1F, 0xBF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF8, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xE7, 0xC0, 0x00,
  0x00, 0xFC, 0xF8, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x07, 0xC1, 0xF0,
  0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x1F, 0x80,
  0x7C, 0x00, 0x03, 0xE0, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x3F,
  0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0xF8, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0x1F, 0x0F, 0xC0, 0x00,
  0x03, 0xF1, 0xF0, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x07, 0xDF, 0x80,
  0x00, 0x00, 0x7C, 0x60, 0x00, 0x00, 0x0E, 0x08, 0x00, 0x00, 0x01, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x18, 0xF8, 0xF8,
  0xFC, 0x7C, 0x7C, 0x3E, 0x3E, 0x1E, 0x1E, 0x0F, 0x0F, 0x0C, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x0F, 0xC0, 0x3F, 0xFF, 0x87, 0xC0, 0x3F,
  0xFF, 0xE3, 0xE0, 0x3F, 0xFF, 0xF9, 0xF0, 0x3F, 0xE0, 0x3C, 0xF8, 0x3F,
  0xC0, 0x07, 0xFC, 0x1F, 0x80, 0x01, 0xFE, 0x1F, 0x80, 0x00, 0x7E, 0x0F,
  0xC0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x07, 0xC7,
  0xE0, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x01, 0xF0,
  0xF8, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00, 0x3E,
  0x3F, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x0F,
  0x87, 0xC0, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x03,
  0xF0, 0xF8, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x01, 0xFC, 0x3E, 0x00, 0x00,
  0xFC, 0x1F, 0x80, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0xDF, 0x03, 0xF0, 0x00,
  0xEF, 0x81, 0xFC, 0x00, 0xEF, 0xC0, 0xFF, 0x01, 0xE7, 0xFE, 0x3F, 0xFF,
  0xF3, 0xFF, 0x1F, 0xFF, 0xF0, 0xFF, 0x87, 0xFF, 0xF0, 0x7F, 0xC0, 0xFF,
  0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0xFF, 0x00, 0x0F, 0xC1, 0xFF,
  0xE0, 0x07, 0xE1, 0xFF, 0xF8, 0x03, 0xE1, 0xFF, 0xFE, 0x01, 0xF1, 0xFF,
  0xFF, 0x80, 0xF9, 0xF0, 0x3F, 0xC0, 0x7D, 0xE0, 0x07, 0xF0, 0x7E, 0xC0,
  0x01, 0xF8, 0x3F, 0xC0, 0x00, 0x7C, 0x1F, 0xC0, 0x00, 0x3F, 0x0F, 0xE0,
  0x00, 0x1F, 0x87, 0xE0, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x03, 0xE3, 0xF0,
  0x00, 0x01, 0xF1, 0xF8, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00, 0xFC, 0x7C,
  0x00, 0x00, 0x7E, 0x3E, 0x00, 0x00, 0x3F, 0x1F, 0x00, 0x00, 0x1F, 0x9F,
  0x80, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x07, 0xE3,
  0xE0, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x00, 0xF8,
  0xFC, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x7E,
  0x1F, 0x80, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x7F,
  0x07, 0xEF, 0x00, 0xFF, 0x83, 0xE7, 0xFF, 0xFF, 0x81, 0xF1, 0xFF, 0xFF,
  0x80, 0xF8, 0x7F, 0xFF, 0x80, 0x7C, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xF0, 0x1F,
  0xE0, 0x7F, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x7C,
  0x7E, 0x00, 0x01, 0xE3, 0xF0, 0x00, 0x04, 0x0F, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x10, 0xFC, 0x00, 0x00, 0x73,
  0xF0, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x1F, 0xDF, 0x00, 0x00, 0xFC, 0x7E,
  0x00, 0x07, 0xF1, 0xF8, 0x00, 0x3F, 0x83, 0xF8, 0x01, 0xFC, 0x0F, 0xF8,
  0x1F, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x0F, 0xF0, 0x0F, 0x80, 0x03, 0xFF, 0xC0, 0xF8, 0x00, 0xFF, 0xFF,
  0x0F, 0x80, 0x1F, 0xFF, 0xF9, 0xF8, 0x03, 0xFF, 0xFF, 0x9F, 0x80, 0x7F,
  0xC0, 0x7D, 0xF8, 0x0F, 0xF0, 0x00, 0xDF, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x1F, 0xC0, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00,
  0x3F, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x00, 0x3E, 0x07, 0xE0,
  0x00, 0x03, 0xE0, 0x7E, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x00,
  0x7C, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x00, 0x7C, 0x0F, 0x80,
  0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0xF8, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x03,
  0xF8, 0x0F, 0xC0, 0x00, 0x7F, 0x80, 0xFC, 0x00, 0x07, 0xF8, 0x07, 0xE0,
  0x01, 0xDF, 0x00, 0x7F, 0x00, 0x3D, 0xF0, 0x07, 0xFC, 0x0F, 0x9F, 0x00,
  0x3F, 0xFF, 0xF1, 0xF0, 0x01, 0xFF, 0xFE, 0x3F, 0x00, 0x1F, 0xFF, 0xC3,
  0xF0, 0x00, 0x7F, 0xF8, 0x3E, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xC0, 0x7F, 0x81, 0xFC,
  0x00, 0x3F, 0x87, 0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3E, 0x3F, 0x00,
  0x00, 0x7C, 0xFC, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x03, 0xF3, 0xE0, 0x00,
  0x07, 0xEF, 0xC0, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0xFE, 0x3E, 0x00, 0x0F,
  0xFC, 0xFC, 0x07, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x21,
  0xF8, 0x00, 0x00, 0xE3, 0xF0, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x07, 0xC7,
  0xE0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x7E, 0x0F, 0xE0, 0x03, 0xF8, 0x1F,
  0xF0, 0x1F, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xC0,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xFC, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x7C,
  0x00, 0x00, 0x00, 0x7F, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x1F, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xCF, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x7C, 0x00, 0xFF, 0xFF, 0x0F,
  0x80, 0x3F, 0xFF, 0xF3, 0xF0, 0x0F, 0xFF, 0xFE, 0x7E, 0x03, 0xFE, 0x03,
  0xEF, 0x80, 0xFF, 0x00, 0x0D, 0xF0, 0x1F, 0xC0, 0x00, 0xFE, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x3F, 0x07,
  0xE0, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0x1F,
  0x07, 0xE0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00,
  0x1F, 0x87, 0xE0, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x00, 0x7C, 0x1F, 0x80,
  0x00, 0x0F, 0x83, 0xE0, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0x7E, 0x0F,
  0x80, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0x7E,
  0x07, 0xE0, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x00,
  0xFF, 0x01, 0xF8, 0x00, 0x37, 0xE0, 0x3F, 0x80, 0x1E, 0xF8, 0x07, 0xFC,
  0x0F, 0x9F, 0x00, 0x7F, 0xFF, 0xE3, 0xE0, 0x07, 0xFF, 0xFC, 0x7C, 0x00,
  0x7F, 0xFE, 0x1F, 0x80, 0x07, 0xFF, 0x83, 0xF0, 0x00, 0x3F, 0xC0, 0x7C,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x02, 0x00,
  0x00, 0x7E, 0x00, 0x60, 0x00, 0x1F, 0x80, 0x1E, 0x00, 0x0F, 0xE0, 0x0F,
  0xF8, 0x07, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x0F, 0xE0,
  0x01, 0xF0, 0x7F, 0xF0, 0x03, 0xE1, 0xFF, 0xF8, 0x0F, 0xC7, 0xFF, 0xF0,
  0x1F, 0x9F, 0xFF, 0xF0, 0x3F, 0x7C, 0x0F, 0xF0, 0x7C, 0xE0, 0x0F, 0xE0,
  0xFB, 0x80, 0x0F, 0xC1, 0xF6, 0x00, 0x1F, 0x87, 0xF8, 0x00, 0x1F, 0x0F,
  0xE0, 0x00, 0x3E, 0x1F, 0xC0, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0xF8, 0x7E,
  0x00, 0x01, 0xF0, 0xF8, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x0F, 0xC7, 0xE0,
  0x00, 0x1F, 0x8F, 0x80, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x7C, 0x3E, 0x00,
  0x00, 0xF8, 0x7C, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x07, 0xE3, 0xF0, 0x00,
  0x0F, 0xC7, 0xC0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x3E, 0x1F, 0x00, 0x00,
  0x7C, 0x3E, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x07,
  0xE3, 0xE0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x3E,
  0x1F, 0x00, 0x00, 0x7C, 0x7E, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x03, 0xF1,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x03, 0x00, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x3F, 0x00,
  0x3E, 0x00, 0xFF, 0x00, 0xFC, 0x03, 0xF8, 0x01, 0xF0, 0x1F, 0xE0, 0x03,
  0xE0, 0x7F, 0x80, 0x07, 0xC1, 0xFE, 0x00, 0x0F, 0x87, 0xF8, 0x00, 0x3F,
  0x1F, 0xC0, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x10, 0x00, 0x7E, 0x00, 0x38, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x7F, 0x00,
  0x7C, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x0F, 0xE0,
  0xF8, 0x00, 0x07, 0xF0, 0xF8, 0x00, 0x03, 0xF8, 0xF8, 0x00, 0x01, 0xFC,
  0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0xF8, 0x07, 0xF0, 0x00, 0x1F, 0x07, 0xFF, 0x80, 0x03, 0xE1, 0xFF, 0xF8,
  0x00, 0xFC, 0x7F, 0xFF, 0x80, 0x1F, 0x9F, 0xFF, 0xF0, 0x03, 0xE7, 0xC0,
  0xFF, 0x00, 0x7C, 0xE0, 0x07, 0xE0, 0x0F, 0xB8, 0x00, 0xFC, 0x01, 0xF6,
  0x00, 0x0F, 0x80, 0x7F, 0x80, 0x01, 0xF0, 0x0F, 0xE0, 0x00, 0x3E, 0x01,
  0xFC, 0x00, 0x07, 0xC0, 0x3F, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x3E,
  0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x01,
  0xFC, 0x00, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0x00, 0x7F, 0x80, 0x03, 0xE0,
  0x3F, 0xE0, 0x00, 0x7C, 0x7F, 0xE0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x03,
  0xF0, 0xF8, 0x00, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0x41, 0xF0, 0x3F, 0x00, 0x1C, 0x3E, 0x03, 0xE0, 0x07, 0xCF, 0xC0, 0x7E,
  0x01, 0xFD, 0xF8, 0x07, 0xC0, 0x7E, 0x3E, 0x00, 0xFC, 0x1F, 0x87, 0xC0,
  0x0F, 0x8F, 0xE0, 0xF8, 0x01, 0xFB, 0xF8, 0x1F, 0x00, 0x3F, 0xFE, 0x07,
  0xE0, 0x03, 0xFF, 0x80, 0xFC, 0x00, 0x3F, 0xE0, 0x1F, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x10, 0x03, 0xE0, 0x01, 0xC0, 0x3F, 0x00, 0x1F, 0x01, 0xF8, 0x01, 0xFC,
  0x0F, 0x80, 0x1F, 0xC0, 0x7C, 0x03, 0xFC, 0x03, 0xE0, 0x3F, 0xC0, 0x1F,
  0x03, 0xF8, 0x01, 0xF8, 0x3F, 0x80, 0x0F, 0x83, 0xF8, 0x00, 0x7C, 0x3F,
  0x80, 0x03, 0xE7, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x9F, 0xE0, 0x7F, 0xC0, 0x7C, 0x7F, 0xC3,
  0xFF, 0x81, 0xF3, 0xFF, 0x9F, 0xFE, 0x07, 0xDF, 0xFE, 0xFF, 0xF8, 0x1F,
  0x61, 0xFB, 0xC7, 0xF0, 0x7F, 0x03, 0xFC, 0x0F, 0xC1, 0xF8, 0x0F, 0xE0,
  0x3F, 0x0F, 0xC0, 0x3F, 0x80, 0x7C, 0x3F, 0x00, 0xFC, 0x01, 0xE0, 0xF8,
  0x03, 0xF0, 0x0F, 0x83, 0xE0, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x3E, 0x00, 0xF8, 0x03, 0xE1, 0xF0, 0x03, 0xE0, 0x0F, 0x87, 0xC0,
  0x0F, 0x00, 0x3E, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x07,
  0xC1, 0xF0, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x3E, 0x00,
  0x7C, 0x01, 0xF0, 0xF8, 0x03, 0xE0, 0x07, 0xC3, 0xE0, 0x0F, 0x80, 0x3E,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0xF8, 0x03,
  0xE0, 0x0F, 0x87, 0xC0, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x00, 0xF8,
  0x7C, 0x01, 0xF0, 0x07, 0xC1, 0xF0, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x1E, 0x00, 0x7C, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0x07, 0xC3,
  0xE0, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x07, 0xC1, 0xFF, 0xC0, 0x0F, 0x87,
  0xFF, 0xE0, 0x3F, 0x1F, 0xFF, 0xC0, 0x7E, 0x7F, 0xFF, 0xC0, 0xF9, 0xF0,
  0x3F, 0xC1, 0xF3, 0x80, 0x3F, 0x83, 0xEE, 0x00, 0x3F, 0x07, 0xD8, 0x00,
  0x7E, 0x1F, 0xE0, 0x00, 0x7C, 0x3F, 0x80, 0x00, 0xF8, 0x7F, 0x00, 0x01,
  0xF0, 0xFC, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x0F,
  0x8F, 0xC0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x7E, 0x3E, 0x00, 0x00, 0xF8,
  0x7C, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x07, 0xC7,
  0xE0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x3F, 0x1F, 0x00, 0x00, 0x7C, 0x3E,
  0x00, 0x00, 0xF8, 0x7C, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x03, 0xE3, 0xF0,
  0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0x3E, 0x1F, 0x00,
  0x00, 0x7C, 0x3E, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x01, 0xF1, 0xF8, 0x00,
  0x07, 0xE3, 0xF0, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x3E, 0x1F, 0x80,
  0x00, 0x3F, 0x1F, 0x80, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0x1F, 0x3F, 0x00,
  0x00, 0x1F, 0x3E, 0x00, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x1F, 0x7E, 0x00,
  0x00, 0x1F, 0x7E, 0x00, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x1F, 0x7C, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00,
  0x00, 0x7E, 0x7C, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0xFC, 0x7C, 0x00,
  0x01, 0xFC, 0x7E, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x03, 0xF0, 0x3F, 0x80,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xC1, 0xFF, 0xE0, 0x00,
  0xFC, 0x3F, 0xFF, 0x00, 0x0F, 0x87, 0xFF, 0xF8, 0x00, 0xF8, 0xFF, 0xFF,
  0xC0, 0x0F, 0x9F, 0x03, 0xFC, 0x00, 0xFB, 0xC0, 0x0F, 0xE0, 0x1F, 0xB0,
  0x00, 0x7E, 0x01, 0xFE, 0x00, 0x03, 0xE0, 0x1F, 0xC0, 0x00, 0x3F, 0x01,
  0xFC, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x3F, 0x00, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x3E, 0x00,
  0x00, 0x3F, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0x3F, 0x03,
  0xE0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x7C, 0x00, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x7C, 0x00,
  0x00, 0x7E, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x00, 0xFC, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x3F,
  0x80, 0xFE, 0x00, 0x07, 0xF0, 0x0F, 0xF0, 0x00, 0xFE, 0x01, 0xFB, 0xC0,
  0x3F, 0xE0, 0x1F, 0x3F, 0xFF, 0xFC, 0x01, 0xF1, 0xFF, 0xFF, 0x80, 0x1F,
  0x0F, 0xFF, 0xF0, 0x01, 0xF0, 0x7F, 0xFC, 0x00, 0x1F, 0x00, 0xFE, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x07, 0xC0, 0x3F, 0xFF, 0xC3, 0xE0,
  0x3F, 0xFF, 0xF3, 0xF0, 0x3F, 0xFF, 0xF9, 0xF8, 0x3F, 0xE0, 0x3E, 0xF8,
  0x3F, 0xC0, 0x03, 0x7C, 0x1F, 0xC0, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x7F,
  0x0F, 0xC0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x07,
  0xC7, 0xE0, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x00,
  0xF8, 0xF8, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00,
  0x3E, 0x3F, 0x00, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0x0F, 0x8F, 0xC0, 0x00,
  0x07, 0xC7, 0xC0, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x03, 0xF1, 0xF0, 0x00,
  0x01, 0xF0, 0xF8, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x00, 0xFC, 0x3E, 0x00,
  0x00, 0xFE, 0x1F, 0x80, 0x00, 0xFF, 0x0F, 0xC0, 0x00, 0x7F, 0x83, 0xF0,
  0x00, 0xEF, 0x81, 0xFC, 0x00, 0xF7, 0xC0, 0xFF, 0x81, 0xF3, 0xE0, 0x3F,
  0xFF, 0xF1, 0xF0, 0x0F, 0xFF, 0xF1, 0xF8, 0x07, 0xFF, 0xF0, 0xFC, 0x00,
  0xFF, 0xF0, 0x7C, 0x00, 0x1F, 0xC0, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xBF, 0xFF, 0x81, 0xFF, 0xDF, 0xFF,
  0xC3, 0xFF, 0xEF, 0xFF, 0xE3, 0xFF, 0xEF, 0xFF, 0xF3, 0xFF, 0xF0, 0x01,
  0xF3, 0xE0, 0x00, 0x00, 0xF9, 0xC0, 0x00, 0x00, 0x7D, 0x80, 0x00, 0x00,
  0x3E, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xF0, 0x07, 0xFC, 0x0F, 0xE0, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x1C,
  0x07, 0xE0, 0x00, 0x04, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x81, 0x00, 0x00, 0x0F, 0xC3, 0xC0,
  0x00, 0x07, 0xC3, 0xF0, 0x00, 0x07, 0xE3, 0xFC, 0x00, 0x07, 0xF0, 0xFF,
  0xC0, 0x1F, 0xF0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x30,
  0x07, 0xE0, 0x00, 0xE0, 0x0F, 0xC0, 0x07, 0xE0, 0x1F, 0x00, 0x1F, 0xE0,
  0x3E, 0x00, 0xFF, 0x80, 0x7C, 0x03, 0xFC, 0x00, 0xF8, 0x1F, 0xF0, 0x03,
  0xF0, 0x7F, 0x80, 0x07, 0xE3, 0xFE, 0x00, 0x0F, 0xCF, 0xF8, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x3F, 0x00,
  0x00, 0xFC, 0x7C, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x03, 0xE1, 0xF0, 0x00,
  0x07, 0xC3, 0xE0, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x1F, 0x1F, 0x80, 0x00,
  0x7E, 0x3E, 0x00, 0x00, 0xFC, 0x7C, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x03,
  0xE1, 0xF0, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x3F,
  0x1F, 0x00, 0x00, 0x7E, 0x3E, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x01, 0xF0,
  0xF8, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x1F, 0x8F,
  0x80, 0x00, 0x3F, 0x1F, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF8, 0x7C,
  0x00, 0x03, 0xF0, 0xF8, 0x00, 0x0F, 0xE1, 0xF0, 0x00, 0x1F, 0xC3, 0xE0,
  0x00, 0x7F, 0x87, 0xE0, 0x01, 0xBE, 0x0F, 0xC0, 0x07, 0x7C, 0x1F, 0xC0,
  0x1C, 0xF8, 0x3F, 0xC0, 0xF3, 0xF0, 0x3F, 0xFF, 0xE7, 0xE0, 0x7F, 0xFF,
  0x8F, 0xC0, 0x7F, 0xFE, 0x1F, 0x00, 0x3F, 0xF8, 0x3E, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x3F, 0xFE, 0x00, 0x3F, 0x1F, 0xFF,
  0x00, 0x0F, 0xCF, 0xFF, 0x80, 0x07, 0xE7, 0xFF, 0x80, 0x01, 0xF3, 0xFF,
  0xC0, 0x00, 0xFA, 0x03, 0xE0, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x3F, 0x00,
  0xF8, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x07, 0xE0,
  0x3E, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0xFC,
  0x07, 0xC0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x1F,
  0x01, 0xF0, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x07,
  0xC0, 0x3E, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x03,
  0xF0, 0x0F, 0x80, 0x01, 0xF8, 0x07, 0xC0, 0x01, 0xF8, 0x03, 0xE0, 0x01,
  0xF8, 0x01, 0xF0, 0x01, 0xFC, 0x00, 0xF8, 0x01, 0xFC, 0x00, 0x7C, 0x01,
  0xFC, 0x00, 0x7E, 0x03, 0xFC, 0x00, 0x3E, 0x03, 0xFC, 0x00, 0x1F, 0x0F,
  0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x3E, 0x00, 0xC0, 0xF8, 0x03, 0xE0, 0x7C, 0x0F, 0x80, 0x3E, 0x03,
  0xE0, 0xF8, 0x03, 0xC0, 0x3E, 0x0F, 0x00, 0x3C, 0x03, 0xE1, 0xF0, 0x07,
  0xC0, 0x3E, 0x1F, 0x00, 0x7C, 0x01, 0xE1, 0xF0, 0x07, 0xC0, 0x1E, 0x1F,
  0x00, 0x7C, 0x01, 0xF1, 0xF0, 0x07, 0x80, 0x1F, 0x1E, 0x00, 0x78, 0x01,
  0xF3, 0xE0, 0x0F, 0x80, 0x1F, 0x3E, 0x00, 0xF8, 0x01, 0xF3, 0xE0, 0x0F,
  0x80, 0x1E, 0x3E, 0x00, 0xF8, 0x01, 0xE3, 0xE0, 0x0F, 0x00, 0x3E, 0x3C,
  0x00, 0xF0, 0x03, 0xE7, 0xC0, 0x1F, 0x00, 0x3E, 0x7C, 0x01, 0xF0, 0x03,
  0xE7, 0xC0, 0x1F, 0x00, 0x3E, 0x7C, 0x01, 0xF0, 0x07, 0xC7, 0xC0, 0x1F,
  0x00, 0x7C, 0x78, 0x03, 0xE0, 0x07, 0xCF, 0x80, 0x3E, 0x00, 0x7C, 0xF8,
  0x03, 0xE0, 0x0F, 0x8F, 0x80, 0x3E, 0x00, 0xF8, 0xF8, 0x07, 0xE0, 0x1F,
  0x8F, 0x80, 0x7E, 0x01, 0xF0, 0xF8, 0x0D, 0xE0, 0x3F, 0x0F, 0x81, 0xDE,
  0x07, 0xE0, 0xFC, 0x3D, 0xF0, 0xFE, 0x0F, 0xFF, 0x9F, 0xFF, 0xC0, 0xFF,
  0xF1, 0xFF, 0xF8, 0x07, 0xFF, 0x0F, 0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0xC0,
  0x01, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x03, 0xF0, 0x00, 0x0F,
  0xF0, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x3F,
  0xFE, 0x00, 0xFF, 0xFC, 0x7F, 0xFF, 0x01, 0xFE, 0x7C, 0x7C, 0x3F, 0x07,
  0xF8, 0x7C, 0xF8, 0x1F, 0x0F, 0xF0, 0x7C, 0xF0, 0x1F, 0x1F, 0xC0, 0x3C,
  0xE0, 0x1F, 0x0F, 0x00, 0x3D, 0xC0, 0x1F, 0x0E, 0x00, 0x3D, 0xC0, 0x1F,
  0x08, 0x00, 0x3D, 0x80, 0x1F, 0x00, 0x00, 0x3F, 0x80, 0x1F, 0x00, 0x00,
  0x3F, 0x80, 0x1E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3C, 0x00, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0xFE, 0x00, 0x00, 0x7C, 0x01,
  0xDE, 0x00, 0x30, 0xFC, 0x01, 0xDE, 0x00, 0x70, 0xFC, 0x03, 0xDE, 0x00,
  0xF8, 0xFC, 0x03, 0x9E, 0x03, 0xF8, 0x7C, 0x07, 0x9E, 0x07, 0xF0, 0x7C,
  0x0F, 0x1F, 0x1F, 0xE0, 0x7E, 0x1F, 0x1F, 0x3F, 0xC0, 0x7F, 0xFE, 0x1F,
  0xFF, 0x00, 0x7F, 0xFE, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x0F, 0xFC, 0x00,
  0x1F, 0xF0, 0x07, 0xF8, 0x00, 0x0F, 0xC0, 0x03, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xE0, 0x3F, 0x00, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x1F, 0x80,
  0xF8, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0xFC, 0x00, 0x01, 0xF0, 0x1F, 0x80, 0x00, 0x7E, 0x03, 0xE0, 0x00,
  0x0F, 0xC0, 0x7C, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x3E, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x7E, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0x01,
  0xF0, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0xF8, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x7C, 0x03, 0xE0,
  0x00, 0x1F, 0x80, 0x7C, 0x00, 0x03, 0xF0, 0x0F, 0x80, 0x00, 0xFE, 0x01,
  0xF0, 0x00, 0x3F, 0xC0, 0x3F, 0x00, 0x0D, 0xF0, 0x07, 0xE0, 0x03, 0xBE,
  0x00, 0xFE, 0x00, 0xE7, 0xC0, 0x0F, 0xE0, 0x7C, 0xF8, 0x01, 0xFF, 0xFF,
  0x3F, 0x00, 0x1F, 0xFF, 0xC7, 0xE0, 0x01, 0xFF, 0xF0, 0xF8, 0x00, 0x1F,
  0xFC, 0x1F, 0x00, 0x00, 0xFE, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x10, 0x00, 0x07, 0xE0, 0x07, 0x00, 0x01,
  0xFC, 0x01, 0xF0, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x0F, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x7C, 0x07, 0xFF, 0xF8, 0x1F, 0x81, 0xFF,
  0xFF, 0xC3, 0xF0, 0x3F, 0xFF, 0xFE, 0x7E, 0x0F, 0xE0, 0x7F, 0xFF, 0x81,
  0xF0, 0x01, 0xFF, 0xF0, 0x7C, 0x00, 0x0F, 0xFC, 0x0F, 0x80, 0x00, 0x7F,
  0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x3C, 0x00, 0x07, 0xF0, 0x07, 0x80, 0x01,
  0xFC, 0x00, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x08, 0x00, 0x0F, 0xC0,
  0x0F, 0x00, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x3F,
  0x00, 0x03, 0xC0, 0x1F, 0xC0, 0x00, 0x7C, 0x07, 0xF0, 0x00, 0x0F, 0x81,
  0xFF, 0x00, 0x01, 0xF0, 0x7F, 0xFE, 0x00, 0x1E, 0x1F, 0xFF, 0xFE, 0x03,
  0xE3, 0xF7, 0xFF, 0xFC, 0x7C, 0x7C, 0x1F, 0xFF, 0xFF, 0x0F, 0x80, 0x7F,
  0xFF, 0xE1, 0xF0, 0x01, 0xFF, 0xF8, 0x3E, 0x00, 0x0F, 0xFF, 0x08, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0x80, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x03,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00,
  0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x01, 0x80, 0x1F, 0xF0, 0x00, 0x1F,
  0x03, 0xFF, 0x80, 0x01, 0xE0, 0x7F, 0xFC, 0x00, 0x3E, 0x0F, 0xFF, 0xE0,
  0x03, 0xE0, 0xFC, 0x7E, 0x00, 0x7C, 0x1F, 0x03, 0xF0, 0x07, 0xC1, 0xF0,
  0x1F, 0x80, 0xF8, 0x3E, 0x00, 0xFC, 0x1F, 0x83, 0xC0, 0x0F, 0xE3, 0xF0,
  0x7C, 0x00, 0x7F, 0xFE, 0x07, 0xC0, 0x03, 0xFF, 0xE0, 0xF8, 0x00, 0x1F,
  0xFC, 0x0F, 0x80, 0x00, 0xFF, 0x80, 0x10, 0x00, 0x07, 0xE0, 0x00,
};

const GFXglyph IBMPlexMono_Italic68pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 41, 0, -1 },
  { 1, 15, 48, 41, 13, -47 },
  { 91, 20, 19, 41, 14, -50 },
  { 139, 41, 47, 41, 1, -47 },
  { 380, 38, 63, 41, 2, -55 },
  { 680, 47, 49, 41, -2, -48 },
  { 968, 40, 49, 41, 0, -48 },
  { 1213, 8, 19, 41, 20, -50 },
  { 1232, 25, 61, 41, 14, -52 },
  { 1423, 25, 61, 41, 3, -52 },
  { 1614, 34, 34, 41, 4, -37 },
  { 1759, 32, 33, 41, 5, -37 },
  { 1891, 16, 19, 41, 9, -9 },
  { 1929, 20, 5, 41, 11, -23 },
  { 1942, 10, 9, 41, 13, -8 },
  { 1954, 38, 61, 41, 2, -52 },
  { 2244, 35, 49, 41, 4, -48 },
  { 2459, 32, 47, 41, 3, -47 },
  { 2647, 35, 48, 41, 2, -48 },
  { 2857, 35, 49, 41, 2, -48 },
  { 3072, 37, 47, 41, 1, -47 },
  { 3290, 36, 48, 41, 3, -47 },
  { 3506, 32, 48, 41, 4, -47 },
  { 3698, 34, 47, 41, 7, -47 },
  { 3898, 36, 49, 41, 3, -48 },
  { 4119, 32, 48, 41, 6, -48 },
  { 4311, 15, 36, 41, 13, -35 },
  { 4379, 19, 45, 41, 9, -35 },
  { 4486, 33, 39, 41, 6, -40 },
  { 4647, 35, 18, 41, 3, -30 },
  { 4726, 33, 39, 41, 3, -40 },
  { 4887, 29, 49, 41, 9, -48 },
  { 5065, 34, 56, 41, 4, -48 },
  { 5303, 37, 47, 41, -1, -47 },
  { 5521, 35, 47, 41, 3, -47 },
  { 5727, 35, 49, 41, 5, -48 },
  { 5942, 34, 47, 41, 4, -47 },
  { 6142, 37, 47, 41, 3, -47 },
  { 6360, 38, 47, 41, 3, -47 },
  { 6584, 35, 49, 41, 4, -48 },
  { 6799, 37, 47, 41, 3, -47 },
  { 7017, 37, 47, 41, 3, -47 },
  { 7235, 34, 48, 41, 4, -47 },
  { 7439, 41, 47, 41, 3, -47 },
  { 7680, 29, 47, 41, 5, -47 },
  { 7851, 39, 47, 41, 2, -47 },
  { 8081, 37, 47, 41, 3, -47 },
  { 8299, 35, 49, 41, 4, -48 },
  { 8514, 37, 47, 41, 3, -47 },
  { 8732, 35, 61, 41, 4, -48 },
  { 8999, 37, 47, 41, 3, -47 },
  { 9217, 38, 49, 41, 2, -48 },
  { 9450, 38, 47, 41, 6, -47 },
  { 9674, 35, 48, 41, 5, -47 },
  { 9884, 36, 47, 41, 7, -47 },
  { 10096, 40, 47, 41, 3, -47 },
  { 10331, 45, 47, 41, -1, -47 },
  { 10596, 39, 47, 41, 6, -47 },
  { 10826, 41, 47, 41, 0, -47 },
  { 11067, 29, 61, 41, 11, -52 },
  { 11289, 18, 61, 41, 12, -52 },
  { 11427, 29, 61, 41, 1, -52 },
  { 11649, 35, 28, 41, 4, -47 },
  { 11772, 33, 5, 41, 0, 6 },
  { 11793, 8, 13, 41, 16, -53 },
  { 11806, 33, 37, 41, 4, -36 },
  { 11959, 33, 51, 41, 4, -50 },
  { 12170, 30, 37, 41, 5, -36 },
  { 12309, 36, 51, 41, 4, -50 },
  { 12539, 31, 37, 41, 5, -36 },
  { 12683, 45, 64, 41, -1, -50 },
  { 13043, 35, 50, 41, 2, -36 },
  { 13262, 31, 50, 41, 4, -50 },
  { 13456, 31, 52, 41, 6, -51 },
  { 13658, 32, 65, 41, 4, -51 },
  { 13918, 35, 51, 41, 4, -50 },
  { 14142, 29, 51, 41, 7, -50 },
  { 14327, 38, 36, 41, 1, -36 },
  { 14498, 31, 36, 41, 4, -36 },
  { 14638, 32, 37, 41, 4, -36 },
  { 14786, 36, 50, 41, 1, -36 },
  { 15011, 33, 50, 41, 4, -36 },
  { 15218, 33, 35, 41, 7, -35 },
  { 15363, 33, 37, 41, 3, -36 },
  { 15516, 31, 48, 41, 5, -47 },
  { 15702, 31, 36, 41, 6, -35 },
  { 15842, 33, 37, 41, 4, -36 },
  { 15995, 36, 36, 41, 3, -35 },
  { 16157, 40, 37, 41, 0, -36 },
  { 16342, 35, 49, 41, 2, -35 },
  { 16557, 35, 37, 41, 3, -36 },
  { 16719, 31, 61, 41, 8, -52 },
  { 16956, 14, 61, 41, 14, -52 },
  { 17063, 32, 61, 41, 3, -52 },
  { 17307, 36, 15, 41, 3, -28 },
};

const GFXfont IBMPlexMono_Italic68pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Italic68pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Italic68pt7bGlyphs,
  0x20, 0x7E, 88
};

#endif // _IBMPLEXMONO_ITALIC68PT7B_H_
