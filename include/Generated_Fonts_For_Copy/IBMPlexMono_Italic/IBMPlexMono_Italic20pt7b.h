#ifndef _IBMPLEXMONO_ITALIC20PT7B_H_
#define _IBMPLEXMONO_ITALIC20PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Italic.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Italic20pt7bBitmaps[] PROGMEM = {
  0x00, 0x13, 0x33, 0x22, 0x22, 0x40, 0x0E, 0xEC, 0x65, 0x34, 0xD3, 0xCB,
  0x20, 0x03, 0x20, 0x26, 0x06, 0x60, 0x44, 0x04, 0xC3, 0xCF, 0x08, 0x80,
  0x98, 0xF9, 0xE1, 0x10, 0x33, 0x03, 0x20, 0x22, 0x06, 0x60, 0x01, 0x00,
  0x10, 0x0F, 0xC1, 0x96, 0x33, 0x33, 0x20, 0x32, 0x03, 0x20, 0x1E, 0x00,
  0x3C, 0x06, 0x40, 0x46, 0x04, 0x64, 0x44, 0xE4, 0xC3, 0xF0, 0x0C, 0x00,
  0x80, 0x1C, 0x19, 0x10, 0x88, 0x88, 0xC4, 0xC6, 0x24, 0x33, 0x40, 0xF4,
  0x00, 0x38, 0x1A, 0x20, 0x91, 0x09, 0x88, 0xCC, 0x44, 0x26, 0x41, 0xE0,
  0x07, 0x80, 0x8C, 0x18, 0xC1, 0x8C, 0x18, 0xC1, 0x88, 0x19, 0x06, 0xE0,
  0xC6, 0x0C, 0x60, 0xC3, 0x2C, 0x53, 0xC5, 0xE7, 0x8C, 0x5F, 0xE0, 0x07,
  0x0C, 0x18, 0x30, 0x20, 0x60, 0x40, 0x40, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0x40, 0x60, 0x20, 0x18, 0x18, 0x18, 0x10, 0x30, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x18, 0x20, 0x41, 0x86, 0x08, 0x21, 0x80, 0x06, 0x01, 0x00,
  0x43, 0x11, 0x7F, 0xC3, 0x81, 0xE0, 0xC8, 0x63, 0x10, 0x80, 0x06, 0x01,
  0x00, 0x40, 0x10, 0xFF, 0xC3, 0x00, 0xC0, 0x20, 0x08, 0x00, 0x36, 0x64,
  0xC8, 0xFC, 0xFF, 0x00, 0x00, 0x30, 0x02, 0x00, 0x40, 0x0C, 0x00, 0x80,
  0x18, 0x01, 0x00, 0x30, 0x02, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x08, 0x01,
  0x00, 0x30, 0x02, 0x00, 0x60, 0x0C, 0x00, 0x0F, 0x86, 0x33, 0x05, 0x81,
  0x60, 0x50, 0x1C, 0xE7, 0x33, 0xC0, 0xF0, 0x3C, 0x09, 0x06, 0x63, 0x0F,
  0x00, 0x07, 0x0D, 0x8C, 0x8C, 0x40, 0x60, 0x30, 0x18, 0x0C, 0x04, 0x02,
  0x03, 0x01, 0x80, 0xC7, 0xFC, 0x1F, 0x0C, 0x66, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x03, 0x01, 0x80, 0xC0, 0x3F, 0xE0, 0x0F,
  0xC3, 0x0C, 0x41, 0x80, 0x30, 0x06, 0x01, 0x83, 0xC0, 0x04, 0x00, 0xC0,
  0x18, 0x03, 0x20, 0x6E, 0x18, 0x7C, 0x00, 0x00, 0xE0, 0x38, 0x0D, 0x01,
  0x60, 0x4C, 0x19, 0x86, 0x31, 0x84, 0x60, 0x88, 0x13, 0xFF, 0x80, 0xC0,
  0x18, 0x02, 0x00, 0x1F, 0xC4, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x06, 0xF1,
  0xC6, 0x00, 0xC0, 0x30, 0x09, 0x06, 0xC3, 0x0F, 0x80, 0x03, 0x81, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x06, 0xF1, 0xC6, 0xC0, 0xF0, 0x3C, 0x0F, 0x06,
  0x63, 0x0F, 0x80, 0x7F, 0xF0, 0x3C, 0x1B, 0x06, 0x03, 0x01, 0x80, 0x60,
  0x30, 0x0C, 0x06, 0x01, 0x00, 0xC0, 0x60, 0x18, 0x00, 0x0F, 0x8C, 0x32,
  0x05, 0x81, 0x60, 0xCC, 0x61, 0xE1, 0x86, 0xC0, 0xF0, 0x3C, 0x0F, 0x06,
  0xC3, 0x0F, 0x80, 0x1E, 0x30, 0xF0, 0x78, 0x18, 0x1E, 0x0F, 0x0E, 0xFB,
  0x03, 0x03, 0x03, 0x81, 0x83, 0x87, 0x00, 0x37, 0x70, 0x00, 0x00, 0xEE,
  0xC0, 0x19, 0xCE, 0x00, 0x00, 0x00, 0x33, 0x18, 0x8C, 0x40, 0x00, 0x81,
  0xC3, 0x83, 0x06, 0x04, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x80, 0x40, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x20, 0x0C, 0x01, 0xC0, 0x1C, 0x01,
  0x80, 0x30, 0x38, 0x38, 0x38, 0x38, 0x08, 0x00, 0x3C, 0xC3, 0x83, 0x03,
  0x03, 0x07, 0x1E, 0x38, 0x20, 0x20, 0x00, 0x60, 0x60, 0xE0, 0x0F, 0x04,
  0x32, 0x05, 0x81, 0x67, 0x53, 0x34, 0x8F, 0x63, 0xD8, 0xF6, 0x2D, 0x9B,
  0x3A, 0xC0, 0x10, 0x06, 0x00, 0xF8, 0x03, 0x80, 0x70, 0x1E, 0x02, 0x40,
  0xC8, 0x19, 0x06, 0x30, 0xC6, 0x30, 0xC7, 0xF9, 0x83, 0x30, 0x24, 0x05,
  0x80, 0xC0, 0x3F, 0x8C, 0x32, 0x0C, 0x83, 0x20, 0xD8, 0x67, 0xE1, 0x86,
  0x40, 0xD0, 0x34, 0x0F, 0x06, 0xC1, 0xBF, 0x80, 0x0F, 0x0C, 0x66, 0x0D,
  0x00, 0xC0, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x08, 0x13, 0x06, 0xC3,
  0x1F, 0x00, 0x3F, 0x0C, 0x63, 0x0C, 0x81, 0x20, 0x48, 0x16, 0x0D, 0x83,
  0x60, 0xD8, 0x34, 0x09, 0x06, 0xC3, 0x3F, 0x00, 0x3F, 0xE6, 0x00, 0x80,
  0x10, 0x02, 0x00, 0xC0, 0x1F, 0xF3, 0x00, 0x40, 0x08, 0x01, 0x00, 0x60,
  0x0C, 0x01, 0xFF, 0x00, 0x3F, 0xE6, 0x00, 0x80, 0x10, 0x02, 0x00, 0xC0,
  0x1F, 0xE3, 0x00, 0x40, 0x08, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x00,
  0x0F, 0x86, 0x33, 0x05, 0x80, 0x60, 0x18, 0x04, 0x03, 0x1F, 0xC0, 0xB0,
  0x2C, 0x19, 0x06, 0x63, 0x8F, 0x60, 0x30, 0x66, 0x0C, 0x81, 0x10, 0x26,
  0x0C, 0xC1, 0x9F, 0xF2, 0x06, 0x40, 0x88, 0x13, 0x06, 0x60, 0xCC, 0x19,
  0x03, 0x00, 0x3F, 0xE0, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x08, 0x01, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x00, 0x81, 0xFF, 0x00, 0x1F, 0xC0,
  0x30, 0x0C, 0x02, 0x00, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x40, 0x13,
  0x0C, 0xC2, 0x0F, 0x00, 0x30, 0x73, 0x0C, 0x21, 0x82, 0x30, 0x66, 0x06,
  0xC0, 0x7C, 0x07, 0x60, 0x66, 0x04, 0x30, 0xC3, 0x0C, 0x10, 0xC1, 0x8C,
  0x0C, 0x30, 0x20, 0x60, 0x60, 0x60, 0x60, 0x40, 0x40, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xFF, 0x30, 0x66, 0x1D, 0xC3, 0xBC, 0xB6, 0x94, 0x94, 0x93,
  0x92, 0x66, 0xCC, 0xD9, 0x1B, 0x02, 0x40, 0x48, 0x09, 0x03, 0x00, 0x38,
  0x67, 0x0C, 0xA1, 0x14, 0x26, 0x84, 0xD9, 0x9B, 0x32, 0x26, 0x44, 0x88,
  0xD3, 0x1A, 0x61, 0xCC, 0x39, 0x07, 0x00, 0x0F, 0x86, 0x33, 0x05, 0x81,
  0x60, 0x50, 0x1C, 0x07, 0x03, 0xC0, 0xF0, 0x3C, 0x09, 0x06, 0x63, 0x0F,
  0x00, 0x3F, 0x86, 0x08, 0x81, 0x90, 0x32, 0x06, 0xC0, 0x98, 0x33, 0xF8,
  0x40, 0x08, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x00, 0x0F, 0x86, 0x33,
  0x05, 0x81, 0x60, 0x50, 0x1C, 0x07, 0x03, 0xC0, 0xF0, 0x3C, 0x0B, 0x06,
  0x63, 0x0F, 0x80, 0xC8, 0x13, 0x03, 0x00, 0x3F, 0x86, 0x08, 0x81, 0x90,
  0x32, 0x06, 0xC0, 0x98, 0x33, 0xF8, 0x46, 0x08, 0xC1, 0x0C, 0x61, 0x8C,
  0x11, 0x83, 0x00, 0x0F, 0xC1, 0x86, 0x30, 0x33, 0x00, 0x30, 0x03, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0xC0, 0x06, 0x00, 0x64, 0x04, 0xE0, 0xC3, 0xF0,
  0xFF, 0xE1, 0x80, 0x30, 0x06, 0x00, 0x80, 0x10, 0x02, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x08, 0x01, 0x00, 0x60, 0x00, 0x30, 0x64, 0x0C, 0x81,
  0x30, 0x26, 0x0C, 0xC1, 0x98, 0x32, 0x06, 0x40, 0x88, 0x13, 0x06, 0x20,
  0xC6, 0x30, 0x7C, 0x00, 0xC0, 0x78, 0x19, 0x03, 0x20, 0xC4, 0x18, 0x82,
  0x18, 0xC3, 0x10, 0x66, 0x0C, 0x80, 0xB0, 0x14, 0x03, 0x80, 0x60, 0x00,
  0x60, 0x34, 0x02, 0x40, 0x24, 0x06, 0x46, 0x64, 0xE4, 0x4A, 0x4D, 0xAC,
  0xD2, 0xCD, 0x28, 0xF2, 0x8E, 0x28, 0xE3, 0x8E, 0x30, 0x30, 0x18, 0xC1,
  0x86, 0x18, 0x19, 0x80, 0xD8, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00,
  0xCC, 0x04, 0x60, 0x61, 0x06, 0x0C, 0x60, 0x30, 0xC0, 0x78, 0x19, 0x86,
  0x30, 0xC2, 0x30, 0x6C, 0x0D, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x08,
  0x01, 0x00, 0x60, 0x00, 0x1F, 0xF0, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x02, 0x00, 0x60, 0x0F,
  0xFC, 0x1F, 0x88, 0x04, 0x02, 0x03, 0x01, 0x80, 0x80, 0x40, 0x20, 0x10,
  0x18, 0x0C, 0x04, 0x02, 0x01, 0x00, 0x80, 0xC0, 0x7E, 0x00, 0x84, 0x21,
  0x84, 0x21, 0x0C, 0x21, 0x08, 0x43, 0x08, 0x42, 0x18, 0xC0, 0x1F, 0x80,
  0x80, 0x40, 0x20, 0x10, 0x18, 0x0C, 0x04, 0x02, 0x01, 0x00, 0x80, 0xC0,
  0x60, 0x20, 0x10, 0x08, 0x04, 0x7E, 0x00, 0x07, 0x01, 0xC0, 0xD0, 0x66,
  0x30, 0x88, 0x36, 0x0F, 0x01, 0xFF, 0xC0, 0xAD, 0x1E, 0xCC, 0x76, 0x09,
  0x02, 0xC1, 0xB0, 0x6C, 0x1B, 0x0E, 0x45, 0x1E, 0x70, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x20, 0x09, 0xE7, 0x89, 0x83, 0x60, 0xD8, 0x34, 0x0D, 0x02,
  0xC1, 0xB8, 0xCD, 0xE0, 0x0F, 0x18, 0xD8, 0x4C, 0x04, 0x02, 0x03, 0x04,
  0x83, 0x63, 0x1F, 0x00, 0x00, 0x60, 0x08, 0x01, 0x00, 0x20, 0x0C, 0x3D,
  0x8C, 0x73, 0x04, 0x40, 0x98, 0x13, 0x06, 0x60, 0xCC, 0x18, 0x86, 0x1F,
  0x40, 0x0F, 0x0C, 0x26, 0x0D, 0x82, 0x43, 0xBF, 0x8C, 0x01, 0x02, 0x61,
  0x0F, 0x80, 0x00, 0xF8, 0x08, 0x00, 0x40, 0x02, 0x00, 0x30, 0x0F, 0xF8,
  0x8C, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02,
  0x00, 0x10, 0x10, 0x80, 0x4C, 0x01, 0x60, 0x06, 0x00, 0x1E, 0xCC, 0x76,
  0x0D, 0x02, 0xC0, 0xB0, 0x6C, 0x1B, 0x06, 0x43, 0x1F, 0x40, 0x10, 0x0C,
  0x86, 0x3F, 0x00, 0x10, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x38, 0xA6, 0xE1,
  0x60, 0xB0, 0x58, 0x68, 0x34, 0x1E, 0x0B, 0x04, 0x0C, 0x06, 0x00, 0x00,
  0x0F, 0x80, 0xC0, 0x60, 0x20, 0x10, 0x18, 0x0C, 0x66, 0x43, 0xC1, 0xC0,
  0x01, 0xC0, 0x60, 0x00, 0x00, 0x1F, 0x08, 0x40, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x20, 0x08, 0x06, 0x01, 0x8C, 0x61, 0x90, 0x34, 0x07, 0x00, 0x10,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x09, 0xC2, 0x99, 0xC2, 0x60, 0x98, 0x46,
  0xE1, 0x70, 0x4C, 0x71, 0x6C, 0x70, 0xFC, 0x04, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x40, 0x20, 0x30, 0x18, 0x0C, 0x44, 0x72, 0x63, 0x60, 0xC0, 0x2E,
  0xE6, 0x64, 0x88, 0xB1, 0x16, 0x62, 0x8C, 0xD1, 0x1A, 0x22, 0xC4, 0x59,
  0x88, 0x27, 0x14, 0xDC, 0x2C, 0x16, 0x0B, 0x0D, 0x06, 0x83, 0xC1, 0x60,
  0x80, 0x1F, 0x0C, 0x66, 0x0D, 0x03, 0xC0, 0xF0, 0x3C, 0x09, 0x06, 0x63,
  0x0F, 0x80, 0x13, 0xC3, 0x88, 0xC1, 0x98, 0x33, 0x06, 0x40, 0xC8, 0x13,
  0x06, 0x71, 0x8D, 0xE1, 0x80, 0x20, 0x04, 0x01, 0x80, 0x00, 0x1E, 0xCC,
  0x76, 0x0D, 0x02, 0xC0, 0xB0, 0x6C, 0x1B, 0x06, 0x47, 0x1E, 0x40, 0x10,
  0x0C, 0x03, 0x00, 0xC0, 0xFB, 0xC7, 0x01, 0x80, 0x40, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x20, 0x08, 0x00, 0x1F, 0x0C, 0x36, 0x01, 0x80, 0x3C, 0x01,
  0xE0, 0x1A, 0x06, 0xC1, 0x0F, 0x80, 0x18, 0x0C, 0x06, 0x02, 0x0F, 0xF9,
  0x80, 0xC0, 0x60, 0x30, 0x10, 0x08, 0x4C, 0x56, 0xC1, 0x80, 0x41, 0xA0,
  0xF0, 0x58, 0x2C, 0x14, 0x1A, 0x0D, 0x0E, 0xCA, 0x39, 0x00, 0xF0, 0x8C,
  0x33, 0x0C, 0xC3, 0x30, 0xC8, 0x22, 0x18, 0x8C, 0x66, 0x0E, 0x00, 0x66,
  0xD1, 0x14, 0x45, 0x11, 0xCC, 0x73, 0x18, 0xCE, 0x22, 0x9D, 0xB9, 0xC0,
  0x1C, 0xE3, 0x53, 0x45, 0x30, 0x62, 0x06, 0x00, 0x60, 0xC6, 0x0C, 0xA2,
  0xCA, 0xC7, 0x38, 0x20, 0xC8, 0x36, 0x09, 0x82, 0x60, 0x90, 0x64, 0x19,
  0x06, 0x67, 0x0E, 0x40, 0x30, 0x0C, 0x86, 0x3F, 0x00, 0x3E, 0x58, 0xF4,
  0x18, 0x0C, 0x06, 0x02, 0x03, 0x19, 0x82, 0xFC, 0xB1, 0xE0, 0x07, 0xC2,
  0x00, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x40, 0x30, 0xF0, 0x02, 0x00, 0xC0,
  0x20, 0x18, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x0F, 0x80, 0x11, 0x13, 0x32,
  0x22, 0x26, 0x64, 0x44, 0x4C, 0xC8, 0x1F, 0x01, 0x80, 0xC0, 0x40, 0x60,
  0x60, 0x20, 0x10, 0x07, 0x86, 0x04, 0x03, 0x01, 0x80, 0x40, 0x30, 0x10,
  0x08, 0x7C, 0x00, 0x38, 0x53, 0x1C, 0x4A, 0x0C,
};

const GFXglyph IBMPlexMono_Italic20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 4, 14, 12, 4, -14 },
  { 8, 6, 6, 12, 4, -15 },
  { 13, 12, 14, 12, 0, -14 },
  { 34, 12, 18, 12, 0, -16 },
  { 61, 13, 14, 12, 0, -14 },
  { 84, 12, 14, 12, 0, -14 },
  { 105, 2, 6, 12, 6, -15 },
  { 107, 8, 18, 12, 4, -15 },
  { 125, 7, 18, 12, 1, -15 },
  { 141, 10, 10, 12, 1, -11 },
  { 154, 10, 9, 12, 1, -11 },
  { 166, 4, 6, 12, 3, -3 },
  { 169, 6, 1, 12, 3, -7 },
  { 170, 3, 3, 12, 4, -3 },
  { 172, 12, 18, 12, 0, -15 },
  { 199, 10, 14, 12, 1, -14 },
  { 217, 9, 14, 12, 1, -14 },
  { 233, 10, 14, 12, 1, -14 },
  { 251, 11, 14, 12, 0, -14 },
  { 271, 11, 14, 12, 0, -14 },
  { 291, 10, 14, 12, 1, -14 },
  { 309, 10, 14, 12, 1, -14 },
  { 327, 10, 14, 12, 2, -14 },
  { 345, 10, 14, 12, 1, -14 },
  { 363, 9, 14, 12, 2, -14 },
  { 379, 4, 11, 12, 4, -11 },
  { 385, 5, 14, 12, 3, -11 },
  { 394, 9, 11, 12, 2, -12 },
  { 407, 10, 5, 12, 1, -9 },
  { 414, 10, 11, 12, 1, -12 },
  { 428, 8, 14, 12, 3, -14 },
  { 442, 10, 16, 12, 1, -14 },
  { 462, 11, 14, 12, 0, -14 },
  { 482, 10, 14, 12, 1, -14 },
  { 500, 10, 14, 12, 2, -14 },
  { 518, 10, 14, 12, 1, -14 },
  { 536, 11, 14, 12, 1, -14 },
  { 556, 11, 14, 12, 1, -14 },
  { 576, 10, 14, 12, 1, -14 },
  { 594, 11, 14, 12, 1, -14 },
  { 614, 11, 14, 12, 1, -14 },
  { 634, 10, 14, 12, 1, -14 },
  { 652, 12, 14, 12, 1, -14 },
  { 673, 8, 14, 12, 2, -14 },
  { 687, 11, 14, 12, 1, -14 },
  { 707, 11, 14, 12, 1, -14 },
  { 727, 10, 14, 12, 1, -14 },
  { 745, 11, 14, 12, 1, -14 },
  { 765, 10, 17, 12, 1, -14 },
  { 787, 11, 14, 12, 1, -14 },
  { 807, 12, 14, 12, 0, -14 },
  { 828, 11, 14, 12, 2, -14 },
  { 848, 11, 14, 12, 1, -14 },
  { 868, 11, 14, 12, 2, -14 },
  { 888, 12, 14, 12, 1, -14 },
  { 909, 13, 14, 12, 0, -14 },
  { 932, 11, 14, 12, 2, -14 },
  { 952, 12, 14, 12, 0, -14 },
  { 973, 9, 18, 12, 3, -15 },
  { 994, 5, 18, 12, 4, -15 },
  { 1006, 9, 18, 12, 0, -15 },
  { 1027, 10, 8, 12, 1, -14 },
  { 1037, 10, 1, 12, 0, 2 },
  { 1039, 2, 4, 12, 5, -16 },
  { 1040, 10, 10, 12, 1, -10 },
  { 1053, 10, 15, 12, 1, -15 },
  { 1072, 9, 10, 12, 1, -10 },
  { 1084, 11, 15, 12, 1, -15 },
  { 1105, 10, 10, 12, 1, -10 },
  { 1118, 13, 19, 12, 0, -15 },
  { 1149, 10, 14, 12, 1, -10 },
  { 1167, 9, 15, 12, 1, -15 },
  { 1184, 9, 14, 12, 2, -14 },
  { 1200, 10, 18, 12, 1, -14 },
  { 1223, 10, 15, 12, 1, -15 },
  { 1242, 9, 15, 12, 2, -15 },
  { 1259, 11, 10, 12, 0, -10 },
  { 1273, 9, 10, 12, 1, -10 },
  { 1285, 10, 10, 12, 1, -10 },
  { 1298, 11, 14, 12, 0, -10 },
  { 1318, 10, 14, 12, 1, -10 },
  { 1336, 10, 10, 12, 2, -10 },
  { 1349, 10, 10, 12, 1, -10 },
  { 1362, 9, 14, 12, 2, -14 },
  { 1378, 9, 10, 12, 2, -10 },
  { 1390, 10, 10, 12, 1, -10 },
  { 1403, 10, 10, 12, 1, -10 },
  { 1416, 12, 10, 12, 0, -10 },
  { 1431, 10, 14, 12, 1, -10 },
  { 1449, 10, 10, 12, 1, -10 },
  { 1462, 10, 18, 12, 2, -15 },
  { 1485, 4, 18, 12, 4, -15 },
  { 1494, 9, 18, 12, 1, -15 },
  { 1515, 10, 4, 12, 1, -8 },
};

const GFXfont IBMPlexMono_Italic20pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Italic20pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Italic20pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _IBMPLEXMONO_ITALIC20PT7B_H_
