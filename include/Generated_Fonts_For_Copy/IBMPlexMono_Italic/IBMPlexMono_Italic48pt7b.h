#ifndef _IBMPLEXMONO_ITALIC48PT7B_H_
#define _IBMPLEXMONO_ITALIC48PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Italic.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Italic48pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xE0, 0x3C, 0x0F, 0x81, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x07, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x38, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x07, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x0F, 0x80,
  0x3C, 0x1C, 0xF0, 0xF3, 0x83, 0xCE, 0x0F, 0x38, 0x3D, 0xE0, 0xE7, 0x83,
  0x9E, 0x1E, 0x70, 0x79, 0xC1, 0xE7, 0x07, 0xBC, 0x1C, 0xF0, 0xF0, 0x00,
  0x03, 0x83, 0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x0E,
  0x0F, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x07, 0x03, 0x80, 0x00, 0x38, 0x3C,
  0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0xE0, 0xF0, 0x00,
  0x0F, 0x07, 0x80, 0x3F, 0xF0, 0x3F, 0xF1, 0xFF, 0x83, 0xFF, 0x0F, 0xFC,
  0x1F, 0xF8, 0x01, 0xC0, 0xE0, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0xF0, 0x78,
  0x00, 0x07, 0x03, 0x80, 0x00, 0x78, 0x3C, 0x00, 0x03, 0xC1, 0xC0, 0x0F,
  0xFC, 0x0F, 0xF8, 0x7F, 0xE0, 0xFF, 0xC3, 0xFF, 0x07, 0xFE, 0x00, 0x70,
  0x38, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x3C, 0x1C, 0x00, 0x01, 0xC0, 0xE0,
  0x00, 0x1E, 0x0F, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x07, 0x03, 0x80, 0x00,
  0x78, 0x3C, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x1C, 0x0E, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x7E, 0x3B,
  0xF8, 0x1F, 0x06, 0x1F, 0x83, 0xC1, 0xC0, 0xF0, 0xF0, 0x38, 0x08, 0x1E,
  0x07, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x78, 0x1C, 0x00, 0x0F, 0x03, 0x00,
  0x01, 0xF0, 0xE0, 0x00, 0x3F, 0x1C, 0x00, 0x03, 0xFB, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x0F, 0xFE, 0x00, 0x01, 0xC7, 0xE0, 0x00, 0x38, 0x3C, 0x00, 0x07,
  0x07, 0xC0, 0x00, 0xC0, 0x78, 0x00, 0x38, 0x0F, 0x00, 0x07, 0x03, 0xE1,
  0x00, 0xE0, 0x78, 0x70, 0x1C, 0x0F, 0x1F, 0x03, 0x83, 0xE1, 0xF0, 0x60,
  0xF8, 0x1F, 0x9C, 0x7F, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x01,
  0xFF, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x07, 0x00, 0xFF, 0x80, 0x0E, 0x01, 0xFF, 0xC0, 0x1E, 0x03,
  0xC3, 0xC0, 0x1C, 0x07, 0x81, 0xC0, 0x38, 0x07, 0x01, 0xE0, 0x78, 0x0F,
  0x01, 0xE0, 0xF0, 0x0F, 0x01, 0xE0, 0xE0, 0x0E, 0x01, 0xE1, 0xE0, 0x0E,
  0x01, 0xC3, 0xC0, 0x0E, 0x01, 0xC3, 0x80, 0x0E, 0x03, 0xC7, 0x00, 0x0E,
  0x03, 0x8F, 0x00, 0x07, 0x07, 0x8E, 0x00, 0x07, 0xFF, 0x10, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x78, 0xFF, 0xE0, 0x00,
  0x70, 0xF0, 0xF0, 0x00, 0xE1, 0xE0, 0x70, 0x01, 0xE1, 0xC0, 0x70, 0x03,
  0xC3, 0xC0, 0x70, 0x03, 0x83, 0x80, 0x70, 0x07, 0x83, 0x80, 0x70, 0x0F,
  0x03, 0x80, 0x70, 0x0E, 0x03, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0xE0, 0x3C,
  0x03, 0x81, 0xE0, 0x38, 0x03, 0xC3, 0xC0, 0x70, 0x01, 0xFF, 0xC0, 0xF0,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0x83, 0xE0, 0x00, 0xF0, 0x1E,
  0x00, 0x0E, 0x00, 0xF0, 0x01, 0xE0, 0x0F, 0x00, 0x1E, 0x00, 0xF0, 0x01,
  0xE0, 0x0F, 0x00, 0x1E, 0x00, 0xF0, 0x01, 0xE0, 0x0F, 0x00, 0x1E, 0x00,
  0xE0, 0x00, 0xF0, 0x1E, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x70, 0x3C, 0x00,
  0x07, 0x87, 0x80, 0x03, 0xF9, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x1E, 0x1C,
  0x00, 0x03, 0xC1, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x70, 0x0F, 0x00, 0x0F, 0x00, 0x78, 0x00, 0xF0, 0x07, 0x80, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x7F, 0x00, 0x3E, 0x0F, 0xF0, 0x02, 0xE0,
  0xEF, 0x80, 0x6F, 0x1E, 0x78, 0x0E, 0xF1, 0xC7, 0xC1, 0xC7, 0xBC, 0x3F,
  0xF8, 0x7F, 0x81, 0xFF, 0x83, 0xF0, 0x07, 0xE0, 0x1E, 0x00, 0x3C, 0xF3,
  0xCE, 0x38, 0xE7, 0x9E, 0x79, 0xC7, 0x1C, 0xF0, 0x00, 0x07, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E,
  0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00,
  0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00,
  0xF0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x40, 0x1C, 0x01, 0xF8, 0x1C,
  0x0F, 0xFF, 0x3C, 0xFF, 0x7F, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0x03, 0xFF,
  0x80, 0x00, 0x7C, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xCF,
  0x00, 0x07, 0x8F, 0x00, 0x0F, 0x87, 0x80, 0x1F, 0x07, 0x80, 0x3E, 0x03,
  0xC0, 0x7C, 0x01, 0xE0, 0x18, 0x01, 0x80, 0x10, 0x01, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0xC3, 0xF1, 0xF8, 0x7C, 0x1F, 0x0F,
  0x83, 0xE0, 0xF0, 0x78, 0x1E, 0x07, 0x03, 0xC0, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x07, 0xF0, 0x7E, 0x07, 0xC0,
  0x1E, 0x0F, 0x80, 0x0F, 0x1F, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x1E, 0x00,
  0x0F, 0x3C, 0x00, 0x07, 0x3C, 0x00, 0x07, 0x7C, 0x00, 0x0F, 0x78, 0x00,
  0x0F, 0x78, 0x00, 0x0F, 0x78, 0x3E, 0x0F, 0x78, 0x3E, 0x0F, 0xF8, 0x7E,
  0x0F, 0xF0, 0x7E, 0x0F, 0xF0, 0x7E, 0x1F, 0xF0, 0x3C, 0x1E, 0xF0, 0x00,
  0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x3C, 0xF0, 0x00,
  0x3C, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0xF8, 0x78, 0x00, 0xF0, 0x78, 0x01,
  0xF0, 0x7E, 0x07, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x0F, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x0F, 0xDC, 0x00, 0x3F, 0x78, 0x00, 0xF8, 0xF0,
  0x07, 0xE1, 0xE0, 0x1F, 0x83, 0xC0, 0x3E, 0x07, 0x80, 0x38, 0x0E, 0x00,
  0x40, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x1F, 0x83, 0xF8, 0x1F, 0x00,
  0x7C, 0x1F, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x80, 0x80,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xFE, 0x00,
  0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x1F, 0x81, 0xF8, 0x1F, 0x00, 0x7C,
  0x1F, 0x00, 0x1E, 0x03, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xE0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x08, 0x00, 0x07, 0x86, 0x00, 0x07, 0xCF, 0x80, 0x07, 0xC3,
  0xE0, 0x07, 0xE1, 0xFC, 0x0F, 0xE0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7B, 0xC0, 0x00, 0x3C, 0xE0, 0x00, 0x1E, 0x38, 0x00, 0x0F, 0x1E,
  0x00, 0x07, 0x87, 0x80, 0x01, 0xC1, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x78,
  0x1C, 0x00, 0x3C, 0x0F, 0x00, 0x1E, 0x03, 0xC0, 0x07, 0x00, 0xF0, 0x03,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x03, 0x80, 0x78, 0x01, 0xE0,
  0x1C, 0x00, 0x78, 0x0E, 0x00, 0x1E, 0x07, 0x00, 0x07, 0x83, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF8, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xF1, 0xFC, 0x00, 0x73, 0xFF, 0x80, 0x3B, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8,
  0x1F, 0xC0, 0xFC, 0x0F, 0x80, 0x1F, 0x03, 0x80, 0x0F, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x86, 0x00,
  0x07, 0x87, 0x80, 0x07, 0xC7, 0xE0, 0x07, 0xC1, 0xFC, 0x0F, 0xC0, 0x7F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE1,
  0xF8, 0x03, 0xCF, 0xFC, 0x0F, 0x3F, 0xFC, 0x1E, 0xFF, 0xFC, 0x3B, 0x81,
  0xFC, 0xFC, 0x00, 0xF9, 0xF0, 0x00, 0xF3, 0xC0, 0x01, 0xFF, 0x80, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3D,
  0xE0, 0x00, 0x7B, 0xC0, 0x00, 0xF7, 0x80, 0x03, 0xCF, 0x80, 0x0F, 0x8F,
  0x00, 0x3E, 0x1F, 0x81, 0xF8, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x1F,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x70, 0x00, 0x1E, 0x70, 0x00, 0x3C, 0x70,
  0x00, 0x3C, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0,
  0x7F, 0x01, 0xF8, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x1E, 0x1E, 0x00, 0x0F,
  0x0F, 0x00, 0x07, 0x87, 0x80, 0x03, 0xC3, 0xC0, 0x01, 0xE1, 0xE0, 0x01,
  0xE0, 0xF8, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x0F, 0xFF, 0xE0, 0x01, 0xFF,
  0xC0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x03, 0xE0, 0x3F, 0x03, 0xC0,
  0x07, 0xC3, 0xC0, 0x01, 0xE3, 0xC0, 0x00, 0xF1, 0xE0, 0x00, 0x3D, 0xE0,
  0x00, 0x1E, 0xF0, 0x00, 0x1F, 0x78, 0x00, 0x0F, 0xBC, 0x00, 0x07, 0x9E,
  0x00, 0x07, 0xCF, 0x80, 0x03, 0xE7, 0xE0, 0x03, 0xE1, 0xF8, 0x0F, 0xE0,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF,
  0xC1, 0xFC, 0x0F, 0xC7, 0xE0, 0x07, 0x8F, 0x00, 0x0F, 0x3E, 0x00, 0x0F,
  0x78, 0x00, 0x1E, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0x7C, 0x00, 0x3E, 0x7C,
  0x00, 0xFC, 0xFC, 0x07, 0x78, 0xFF, 0xFF, 0xE1, 0xFF, 0xF3, 0xC0, 0xFF,
  0xCF, 0x00, 0x7E, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xC1, 0xF8, 0x3F, 0x8F, 0xE1, 0xFC, 0x1F, 0x83,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x07, 0xE1, 0xFC, 0x3F, 0x87, 0xF0,
  0xFE, 0x0F, 0x80, 0x01, 0xF0, 0x1F, 0x80, 0xFE, 0x0F, 0xE0, 0x7F, 0x01,
  0xF8, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x07, 0xE0, 0x7E, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0x78,
  0x07, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x78, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x01, 0x00, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE0, 0x04,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x1F,
  0xFC, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0xC3, 0xF0, 0x3F, 0x1E, 0x00, 0xF9,
  0xE0, 0x03, 0xFF, 0x00, 0x1F, 0x70, 0x00, 0x78, 0x80, 0x07, 0xC0, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x03,
  0xE0, 0x7C, 0x07, 0x80, 0x1E, 0x0F, 0x00, 0x0E, 0x0E, 0x00, 0x0F, 0x1E,
  0x00, 0x0F, 0x1C, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x3C, 0x07, 0xC7, 0x38,
  0x1F, 0xEF, 0x38, 0x3F, 0xEF, 0x78, 0x3C, 0x3E, 0x78, 0x78, 0x1E, 0x78,
  0x78, 0x0E, 0x70, 0xF0, 0x0E, 0x70, 0xF0, 0x1E, 0xF0, 0xF0, 0x1E, 0xF0,
  0xE0, 0x1E, 0xF1, 0xE0, 0x1C, 0xF1, 0xE0, 0x1C, 0xE1, 0xE0, 0x1C, 0xE1,
  0xE0, 0x3C, 0xE1, 0xE0, 0x3C, 0xE1, 0xE0, 0x7C, 0xE0, 0xE0, 0xF8, 0xE0,
  0xFB, 0xB8, 0xE0, 0xFF, 0x38, 0xE0, 0x7F, 0x38, 0xE0, 0x08, 0x40, 0xF0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7B, 0x80, 0x00, 0x3D, 0xC0, 0x00, 0x3C, 0xF0, 0x00, 0x1E, 0x78,
  0x00, 0x1E, 0x3C, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x87,
  0x80, 0x03, 0x81, 0xC0, 0x03, 0xC0, 0xF0, 0x01, 0xE0, 0x78, 0x01, 0xE0,
  0x3C, 0x00, 0xF0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x78,
  0x03, 0xC0, 0x3C, 0x00, 0xE0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x07, 0x80, 0x07, 0x87, 0x80, 0x03, 0xC3,
  0xC0, 0x01, 0xE3, 0xC0, 0x00, 0xF9, 0xE0, 0x00, 0x3D, 0xF0, 0x00, 0x1E,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xC0, 0x03, 0xFF,
  0xF0, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x78,
  0x01, 0xF0, 0x3C, 0x00, 0x78, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x0F,
  0x00, 0x07, 0x87, 0x80, 0x07, 0xC3, 0xC0, 0x03, 0xC1, 0xE0, 0x01, 0xE0,
  0xF0, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0x78, 0x01, 0xF0, 0x3F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x07, 0x80, 0x1F, 0x03, 0x80, 0x03,
  0xC3, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0x78, 0x00,
  0x3C, 0x3C, 0x00, 0x1E, 0x1C, 0x00, 0x0F, 0x1E, 0x00, 0x07, 0x8F, 0x00,
  0x07, 0xC7, 0x80, 0x07, 0xC3, 0xC0, 0x0F, 0xE1, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xF0, 0x7E,
  0x0F, 0xC0, 0x1E, 0x0F, 0x80, 0x1E, 0x1F, 0x00, 0x0F, 0x1E, 0x00, 0x0E,
  0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x20,
  0xF0, 0x00, 0x38, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0xF0,
  0x7C, 0x01, 0xE0, 0x7E, 0x07, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80,
  0x0F, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xE0,
  0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x0F, 0x80, 0xFC, 0x0F, 0x00, 0x3E,
  0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x1F, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x0F,
  0x1F, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x1E, 0x00, 0x0F,
  0x1E, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x1C, 0x00, 0x0F, 0x3C, 0x00, 0x1F,
  0x3C, 0x00, 0x1F, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x1E,
  0x38, 0x00, 0x3E, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x7C,
  0x78, 0x00, 0x78, 0x78, 0x00, 0xF8, 0x70, 0x01, 0xF0, 0xF0, 0x0F, 0xE0,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xE0, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x03, 0xF0,
  0x7E, 0x07, 0xC0, 0x1F, 0x0F, 0x80, 0x0F, 0x0F, 0x00, 0x0F, 0x1F, 0x00,
  0x06, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x0F, 0xFE, 0xF8, 0x0F, 0xFE, 0xF8, 0x0F, 0xFC, 0xF0, 0x0F,
  0xFC, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x3C, 0xF0, 0x00,
  0x3C, 0xF0, 0x00, 0x38, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x78, 0x78, 0x00,
  0xF8, 0x78, 0x00, 0xF8, 0x3C, 0x03, 0x78, 0x3E, 0x07, 0x70, 0x1F, 0xFE,
  0x70, 0x0F, 0xFC, 0xF0, 0x03, 0xF0, 0x00, 0x07, 0x80, 0x03, 0xC1, 0xE0,
  0x00, 0xF0, 0x78, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xC1,
  0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x07,
  0x83, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x1E, 0x1E, 0x00,
  0x0F, 0x07, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0xF0, 0x00, 0x78,
  0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xE0, 0xF0, 0x00,
  0x78, 0x78, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xC1, 0xE0,
  0x00, 0xF0, 0x78, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x83,
  0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x0F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x70, 0x01, 0xE0, 0xF0, 0x01,
  0xE0, 0xF0, 0x03, 0xE0, 0xF8, 0x07, 0xC0, 0x7C, 0x0F, 0xC0, 0x7F, 0xFF,
  0x80, 0x3F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xC0,
  0x01, 0xF8, 0x3C, 0x00, 0x1F, 0x01, 0xE0, 0x01, 0xF0, 0x0F, 0x00, 0x1F,
  0x00, 0x78, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0xF8, 0x01,
  0xE0, 0x0F, 0x80, 0x0F, 0x00, 0xF8, 0x00, 0x78, 0x0F, 0x80, 0x03, 0xC0,
  0xF8, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0xF0, 0xF8, 0x00, 0x0F, 0x0F, 0x80,
  0x00, 0x78, 0xF8, 0x00, 0x03, 0xCF, 0xC0, 0x00, 0x1E, 0xFF, 0x00, 0x00,
  0xFF, 0x78, 0x00, 0x07, 0xF3, 0xC0, 0x00, 0x7F, 0x0F, 0x00, 0x03, 0xF0,
  0x78, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0xF0, 0x0F, 0x00, 0x07, 0x80, 0x3C,
  0x00, 0x3C, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00,
  0xF0, 0x01, 0xF0, 0x07, 0x80, 0x07, 0x80, 0x3C, 0x00, 0x3C, 0x01, 0xE0,
  0x00, 0xF0, 0x1E, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x3E, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x03, 0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x3F, 0x07, 0xE0,
  0x03, 0xF0, 0x7E, 0x00, 0x7E, 0x07, 0xF0, 0x07, 0xE0, 0x7F, 0x00, 0xFE,
  0x07, 0x70, 0x1F, 0xE0, 0x77, 0x01, 0xDE, 0x0F, 0x78, 0x3D, 0xE0, 0xF3,
  0x83, 0x9C, 0x0F, 0x38, 0x79, 0xC0, 0xF3, 0x87, 0x1C, 0x0E, 0x3C, 0xE3,
  0xC0, 0xE1, 0xCE, 0x3C, 0x1E, 0x1D, 0xC3, 0xC1, 0xE1, 0xDC, 0x3C, 0x1E,
  0x1F, 0x83, 0x81, 0xE1, 0xF8, 0x38, 0x1C, 0x0F, 0x07, 0x81, 0xC0, 0xF0,
  0x78, 0x3C, 0x0E, 0x07, 0x83, 0xC0, 0xC0, 0x78, 0x3C, 0x04, 0x07, 0x03,
  0xC0, 0x80, 0x70, 0x38, 0x00, 0x0F, 0x03, 0x80, 0x00, 0xF0, 0x78, 0x00,
  0x0F, 0x07, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x0E, 0x07, 0x80, 0x00, 0xE0,
  0x70, 0x00, 0x1E, 0x07, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x0F, 0x00,
  0x01, 0xE0, 0x07, 0xE0, 0x01, 0xC1, 0xFC, 0x00, 0xF0, 0x7F, 0x00, 0x3C,
  0x1F, 0xC0, 0x0F, 0x07, 0xF0, 0x03, 0xC1, 0xDC, 0x00, 0xF0, 0xF7, 0x80,
  0x38, 0x3D, 0xE0, 0x0E, 0x0F, 0x38, 0x07, 0x83, 0xCE, 0x01, 0xE0, 0xE3,
  0x80, 0x78, 0x38, 0xF0, 0x1E, 0x1E, 0x3C, 0x07, 0x07, 0x87, 0x01, 0xC1,
  0xE1, 0xC0, 0xF0, 0x78, 0x78, 0x3C, 0x1C, 0x1E, 0x0F, 0x07, 0x03, 0x83,
  0xC3, 0xC0, 0xE0, 0xE0, 0xF0, 0x38, 0x38, 0x3C, 0x0F, 0x1E, 0x0F, 0x03,
  0xC7, 0x83, 0x80, 0x71, 0xE0, 0xE0, 0x1C, 0x78, 0x78, 0x07, 0x9C, 0x1E,
  0x01, 0xE7, 0x07, 0x80, 0x7B, 0xC1, 0xE0, 0x0E, 0xF0, 0x70, 0x03, 0xBC,
  0x1C, 0x00, 0xFF, 0x0F, 0x00, 0x3F, 0x83, 0xC0, 0x07, 0xE0, 0xF0, 0x01,
  0xF8, 0x3C, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xF8, 0x01,
  0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x07, 0xF0, 0x7E, 0x07, 0xC0, 0x1E, 0x0F,
  0x80, 0x0F, 0x1F, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x3E, 0x00, 0x0F, 0x3C,
  0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x7C, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78,
  0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0,
  0x00, 0x1E, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x3C, 0xF0,
  0x00, 0x78, 0xF0, 0x00, 0xF8, 0x78, 0x00, 0xF0, 0x78, 0x01, 0xF0, 0x7E,
  0x07, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFE, 0x07, 0x80, 0x0F, 0x81, 0xE0, 0x01, 0xF0, 0x78, 0x00,
  0x3C, 0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF0, 0xF0,
  0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0xC3, 0xC0, 0x01, 0xE1,
  0xE0, 0x00, 0xF8, 0x78, 0x00, 0xFC, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x3E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xF8, 0x01,
  0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xF0, 0x7E, 0x07, 0xC0, 0x1E, 0x0F,
  0x80, 0x0F, 0x1F, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x3E, 0x00, 0x0F, 0x3C,
  0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x7C, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78,
  0x00, 0x0F, 0x78, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0,
  0x00, 0x3E, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x7C, 0xF0,
  0x00, 0x78, 0xF8, 0x00, 0xF8, 0x78, 0x01, 0xF0, 0x7E, 0x07, 0xE0, 0x3F,
  0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x78, 0x0C, 0x00, 0x3C, 0x1C, 0x00, 0x3E, 0x3E, 0x00,
  0x1E, 0x7C, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFE, 0x07, 0x80, 0x0F, 0x81, 0xE0, 0x01, 0xF0, 0x78, 0x00,
  0x3C, 0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF0, 0xF0,
  0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xE1,
  0xE0, 0x00, 0xF8, 0x78, 0x00, 0xFC, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x3E, 0x0F, 0x00, 0x0F, 0x01,
  0xE0, 0x03, 0xC0, 0x78, 0x00, 0xF0, 0x1F, 0x00, 0x3C, 0x03, 0xC0, 0x0F,
  0x00, 0xF0, 0x07, 0x80, 0x1E, 0x01, 0xE0, 0x07, 0x80, 0x78, 0x00, 0xF0,
  0x1E, 0x00, 0x3C, 0x07, 0x80, 0x0F, 0x81, 0xE0, 0x01, 0xE0, 0xF0, 0x00,
  0x78, 0x3C, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0x80,
  0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0x01, 0xFC, 0x0F, 0x80,
  0x0F, 0xC1, 0xE0, 0x00, 0x78, 0x7C, 0x00, 0x04, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x80, 0x00, 0x3C,
  0x38, 0x00, 0x07, 0x8F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x0F, 0xE0,
  0x3F, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x07, 0x87, 0x80, 0x03, 0xC3, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xF0,
  0xF0, 0x00, 0x78, 0xF0, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x1E,
  0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x03, 0xC7, 0x80, 0x01,
  0xE3, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0x78, 0x00,
  0x3C, 0x3C, 0x00, 0x1E, 0x1C, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x0F, 0x00,
  0x07, 0x87, 0x80, 0x03, 0xC3, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xF0, 0xF0,
  0x00, 0x78, 0x70, 0x00, 0x78, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x0F,
  0x00, 0x1F, 0x07, 0x80, 0x0F, 0x03, 0xC0, 0x0F, 0x81, 0xF8, 0x1F, 0x80,
  0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xDC, 0x00, 0x03, 0xCE, 0x00,
  0x01, 0xE7, 0x80, 0x01, 0xE3, 0xC0, 0x00, 0xF1, 0xE0, 0x00, 0xF8, 0xF0,
  0x00, 0x78, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x0E, 0x00, 0x1E, 0x07,
  0x00, 0x1E, 0x03, 0xC0, 0x0F, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80,
  0x78, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x07, 0x01, 0xE0,
  0x03, 0x80, 0xF0, 0x01, 0xE0, 0xF0, 0x00, 0xF0, 0x78, 0x00, 0x78, 0x78,
  0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x07, 0x1E, 0x00, 0x03, 0x8E,
  0x00, 0x01, 0xCF, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x03, 0x87, 0x00, 0x00, 0x3C, 0x38,
  0x00, 0x01, 0xE1, 0xC0, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x07, 0x87, 0x80, 0x00, 0x3C, 0x3C, 0x00, 0x01, 0xE1, 0xE0, 0x7C, 0x0E,
  0x0F, 0x07, 0xE0, 0x70, 0x78, 0x3F, 0x07, 0x83, 0x81, 0xF8, 0x3C, 0x1C,
  0x1F, 0xC1, 0xC0, 0xE0, 0xEE, 0x0E, 0x07, 0x07, 0x70, 0xF0, 0x38, 0x73,
  0x87, 0x81, 0xC3, 0x9C, 0x38, 0x0E, 0x1C, 0xE1, 0xC0, 0xF1, 0xC7, 0x1E,
  0x07, 0x8E, 0x38, 0xF0, 0x3C, 0xF1, 0xC7, 0x01, 0xE7, 0x0E, 0x38, 0x0E,
  0x38, 0x73, 0xC0, 0x73, 0x83, 0x9E, 0x03, 0x9C, 0x1C, 0xE0, 0x1C, 0xE0,
  0xE7, 0x00, 0xEE, 0x07, 0x38, 0x07, 0x70, 0x3F, 0xC0, 0x3F, 0x81, 0xFC,
  0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x07,
  0xE0, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x3E,
  0x00, 0xF0, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0,
  0x00, 0x78, 0x01, 0xF0, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x3C, 0x07, 0xC0,
  0x00, 0x3E, 0x07, 0x80, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x1E, 0x1F, 0x00,
  0x00, 0x0F, 0x3E, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1E, 0xF0, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x00, 0x7C, 0x78, 0x00,
  0x00, 0x78, 0x3C, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x01, 0xE0, 0x1E, 0x00,
  0x03, 0xE0, 0x1E, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x07, 0x80, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x3E, 0x00, 0x07, 0x80,
  0x7C, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x03, 0xEF,
  0x00, 0x00, 0x79, 0xE0, 0x00, 0x1F, 0x1E, 0x00, 0x07, 0xC3, 0xC0, 0x00,
  0xF0, 0x7C, 0x00, 0x3E, 0x07, 0x80, 0x0F, 0x80, 0xF0, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x01, 0xE0, 0x1F, 0x00, 0x3C, 0x07, 0xC0, 0x03, 0xC0, 0xF0,
  0x00, 0x78, 0x3C, 0x00, 0x07, 0x8F, 0x80, 0x00, 0xF1, 0xE0, 0x00, 0x1E,
  0x78, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x1F, 0xFF,
  0x03, 0xFF, 0xF0, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xFF,
  0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x3C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x38, 0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x7F, 0xFC, 0x03,
  0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x3D, 0xE0, 0x00, 0x3D, 0xE0, 0x00, 0x78, 0xE0, 0x00,
  0xF0, 0xF0, 0x00, 0xF0, 0x70, 0x01, 0xE0, 0x78, 0x03, 0xC0, 0x78, 0x07,
  0x80, 0x38, 0x07, 0x80, 0x3C, 0x0F, 0x00, 0x1C, 0x1E, 0x00, 0x1E, 0x3C,
  0x00, 0x1E, 0x3C, 0x00, 0x0E, 0x78, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0x70,
  0x00, 0x07, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x73, 0xC7, 0x1E, 0x38, 0xE3, 0xC7, 0x18, 0x00, 0xFC, 0x1E,
  0x07, 0xFE, 0x3C, 0x1F, 0xFE, 0x70, 0x7C, 0x0E, 0xE1, 0xF0, 0x07, 0xC7,
  0xC0, 0x0F, 0x8F, 0x00, 0x0F, 0x3C, 0x00, 0x1E, 0x78, 0x00, 0x3C, 0xF0,
  0x00, 0x73, 0xC0, 0x01, 0xE7, 0x80, 0x03, 0xCF, 0x00, 0x07, 0x9E, 0x00,
  0x0F, 0x3C, 0x00, 0x1E, 0x78, 0x00, 0x38, 0xE0, 0x00, 0xF1, 0xC0, 0x01,
  0xE3, 0xC0, 0x07, 0xC7, 0x80, 0x0F, 0x8F, 0x00, 0x2F, 0x1F, 0x00, 0xDC,
  0x1F, 0x07, 0x3F, 0x9F, 0xFC, 0x7E, 0x3F, 0xF0, 0x7C, 0x1F, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x7E, 0x01, 0xE3,
  0xFF, 0x03, 0xCF, 0xFF, 0x07, 0xBC, 0x1F, 0x0F, 0x60, 0x1E, 0x1F, 0x80,
  0x1E, 0x3E, 0x00, 0x3C, 0xF8, 0x00, 0x79, 0xF0, 0x00, 0xF3, 0xC0, 0x01,
  0xE7, 0x80, 0x03, 0xCF, 0x00, 0x07, 0x9C, 0x00, 0x0F, 0x78, 0x00, 0x1E,
  0xF0, 0x00, 0x3D, 0xE0, 0x00, 0xF3, 0xC0, 0x01, 0xE7, 0x80, 0x03, 0xCF,
  0x00, 0x0F, 0x3E, 0x00, 0x1E, 0x7C, 0x00, 0x78, 0xFC, 0x01, 0xF1, 0xEC,
  0x0F, 0xC3, 0xDF, 0xFF, 0x07, 0x1F, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0x03, 0xE1, 0xE0, 0x0F,
  0x9E, 0x00, 0x3C, 0xF0, 0x00, 0x8F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x03, 0x3C, 0x00,
  0x3D, 0xE0, 0x01, 0xEF, 0x00, 0x1E, 0x3C, 0x01, 0xE1, 0xF8, 0x3E, 0x07,
  0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x1F, 0xC3, 0xC0, 0x3F, 0xF1,
  0xE0, 0x3F, 0xFC, 0xF0, 0x3F, 0x07, 0x78, 0x3E, 0x00, 0xFC, 0x3E, 0x00,
  0x3C, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x87, 0x80,
  0x03, 0xC7, 0x80, 0x01, 0xE3, 0xC0, 0x00, 0xE1, 0xE0, 0x00, 0x70, 0xF0,
  0x00, 0x78, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x1C, 0x00, 0x0F, 0x0E,
  0x00, 0x0F, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x07, 0xC1, 0xE0, 0x07, 0xE0,
  0xF8, 0x06, 0xF0, 0x3E, 0x0F, 0x78, 0x0F, 0xFF, 0x38, 0x03, 0xFF, 0x3C,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xE0, 0x0F, 0xFF,
  0xE0, 0x3F, 0x03, 0xE0, 0xF8, 0x03, 0xC3, 0xC0, 0x03, 0x87, 0x80, 0x07,
  0x9E, 0x00, 0x0E, 0x3C, 0x00, 0x3C, 0xF0, 0x00, 0xF9, 0xE0, 0x07, 0xE3,
  0xC0, 0xFF, 0x87, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x78,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x41, 0xE0, 0x00, 0xE3, 0xC0,
  0x03, 0xE7, 0x80, 0x07, 0x87, 0x80, 0x3E, 0x0F, 0xC0, 0xF8, 0x0F, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x20, 0x0F, 0x00, 0x00, 0x70, 0x0F, 0x00, 0x00, 0xF8,
  0x0F, 0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x3E, 0x0E, 0x00, 0x00, 0x1F,
  0x1E, 0x00, 0x00, 0x0F, 0x9E, 0x00, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x3F, 0x87, 0x80, 0x7F, 0xE3, 0xC0, 0x7F, 0xF9, 0xE0, 0x7E, 0x0E, 0xF0,
  0x7C, 0x01, 0xF8, 0x7C, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x1E,
  0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x8F, 0x00, 0x03, 0xC7, 0x80, 0x01,
  0xC3, 0xC0, 0x00, 0xE1, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0x78, 0x00,
  0x3C, 0x3C, 0x00, 0x3E, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x1F, 0x07, 0x80,
  0x1F, 0x83, 0xE0, 0x1B, 0xC0, 0xF8, 0x3D, 0xE0, 0x3F, 0xFC, 0xF0, 0x0F,
  0xFC, 0x70, 0x03, 0xF8, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0F, 0x01, 0x00, 0x07, 0x80, 0xC0, 0x07, 0x80,
  0xF8, 0x0F, 0x80, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC3, 0xF0, 0x0F, 0x1F,
  0xF0, 0x38, 0xFF, 0xE1, 0xE7, 0xFF, 0x87, 0xB8, 0x3F, 0x1E, 0xC0, 0x7C,
  0x7E, 0x00, 0xF1, 0xF0, 0x03, 0xC7, 0x80, 0x0F, 0x3E, 0x00, 0x3C, 0xF0,
  0x00, 0xF3, 0xC0, 0x03, 0x8F, 0x00, 0x0E, 0x3C, 0x00, 0x78, 0xE0, 0x01,
  0xE7, 0x80, 0x07, 0x9E, 0x00, 0x1E, 0x78, 0x00, 0x71, 0xE0, 0x01, 0xC7,
  0x80, 0x0F, 0x1C, 0x00, 0x3C, 0xF0, 0x00, 0xF3, 0xC0, 0x03, 0xCF, 0x00,
  0x0E, 0x3C, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x40, 0x1C, 0x03, 0x80, 0xF0, 0x1F, 0x03, 0xC0, 0xF8,
  0x0F, 0x07, 0xC0, 0x3C, 0x3E, 0x00, 0xE1, 0xE0, 0x07, 0x8F, 0x00, 0x1E,
  0x78, 0x00, 0x7F, 0xC0, 0x00, 0xFE, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x1F, 0xFF,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x18, 0x03,
  0xC0, 0xF0, 0x0F, 0x03, 0xE0, 0x38, 0x07, 0xC1, 0xE0, 0x0F, 0x87, 0x80,
  0x1F, 0x1E, 0x00, 0x3E, 0x78, 0x00, 0x79, 0xC0, 0x00, 0xFF, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x0F, 0xC0, 0x0F, 0x1F, 0xF0, 0x0E, 0x7F, 0xF8, 0x1E,
  0x70, 0xF8, 0x1E, 0xC0, 0x7C, 0x1F, 0x80, 0x3C, 0x1F, 0x00, 0x3C, 0x1E,
  0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x3C, 0x00, 0xF0, 0x3C,
  0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x1F, 0x00, 0x38, 0xFC, 0x00, 0x78,
  0xF0, 0x00, 0x78, 0xF8, 0x00, 0x78, 0x78, 0x02, 0x78, 0x78, 0x07, 0x78,
  0x3C, 0x0F, 0x70, 0x3C, 0x1E, 0xF0, 0x1E, 0x7C, 0xF0, 0x1E, 0xF8, 0xF0,
  0x0F, 0xF0, 0xF0, 0x0F, 0xE0, 0x00, 0x07, 0x80, 0x7F, 0xF8, 0x0F, 0xFF,
  0x80, 0xFF, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x04, 0x0F, 0x00, 0x60, 0xF0, 0x0F, 0x0F, 0x03, 0xE0, 0xF0, 0x7C, 0x0F,
  0x0F, 0x80, 0xE1, 0xF0, 0x1E, 0x3E, 0x01, 0xE7, 0x80, 0x1F, 0xF0, 0x00,
  0xFE, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x3C, 0x0F, 0x07, 0x9F, 0x8F, 0xE1,
  0xEF, 0xF7, 0xFC, 0x7E, 0x3D, 0x8F, 0x1F, 0x07, 0xC1, 0xC7, 0x81, 0xE0,
  0x71, 0xE0, 0x78, 0x1C, 0xF0, 0x1C, 0x07, 0x3C, 0x0F, 0x03, 0xCF, 0x03,
  0xC0, 0xF3, 0xC0, 0xF0, 0x3C, 0xE0, 0x38, 0x0E, 0x38, 0x0E, 0x03, 0x9E,
  0x03, 0x80, 0xE7, 0x81, 0xE0, 0x79, 0xE0, 0x78, 0x1E, 0x70, 0x1E, 0x07,
  0x9C, 0x07, 0x01, 0xC7, 0x01, 0xC0, 0x73, 0xC0, 0x70, 0x1C, 0xF0, 0x3C,
  0x0F, 0x3C, 0x0F, 0x03, 0xCE, 0x03, 0x80, 0xE3, 0x80, 0xE0, 0x38, 0xE0,
  0x38, 0x0E, 0x00, 0x0F, 0x0F, 0xC0, 0x3C, 0x7F, 0xC0, 0xE3, 0xFF, 0x87,
  0x9C, 0x3E, 0x1E, 0xC0, 0x7C, 0x7A, 0x00, 0xF1, 0xF0, 0x03, 0xC7, 0x80,
  0x0F, 0x1E, 0x00, 0x3C, 0xF0, 0x00, 0xF3, 0xC0, 0x03, 0xCF, 0x00, 0x0E,
  0x3C, 0x00, 0x78, 0xF0, 0x01, 0xE3, 0x80, 0x07, 0x9E, 0x00, 0x1E, 0x78,
  0x00, 0x79, 0xE0, 0x01, 0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x3C, 0x70, 0x00,
  0xF3, 0xC0, 0x03, 0xCF, 0x00, 0x0F, 0x3C, 0x00, 0x38, 0xF0, 0x01, 0xE0,
  0x00, 0x3F, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x7E, 0x07, 0xC0,
  0xF0, 0x07, 0x83, 0xC0, 0x07, 0x8F, 0x00, 0x07, 0x1E, 0x00, 0x0E, 0x78,
  0x00, 0x1E, 0xF0, 0x00, 0x3D, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0x78, 0x00, 0x1E, 0xF0, 0x00,
  0x3D, 0xE0, 0x00, 0xFB, 0xC0, 0x01, 0xE3, 0x80, 0x03, 0xC7, 0x80, 0x0F,
  0x0F, 0x80, 0x3C, 0x0F, 0x81, 0xF0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0x83, 0xF0, 0x03, 0xC7, 0xFE, 0x01, 0xE7, 0xFF,
  0x80, 0xF7, 0x83, 0xE0, 0x7B, 0x00, 0xF0, 0x3F, 0x00, 0x3C, 0x1F, 0x00,
  0x1E, 0x1F, 0x00, 0x0F, 0x0F, 0x80, 0x07, 0x87, 0x80, 0x03, 0xC3, 0xC0,
  0x01, 0xE1, 0xE0, 0x00, 0xF0, 0xE0, 0x00, 0x78, 0xF0, 0x00, 0x3C, 0x78,
  0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x87,
  0x80, 0x07, 0x87, 0xC0, 0x03, 0xC3, 0xE0, 0x03, 0xC1, 0xF8, 0x03, 0xE0,
  0xF7, 0x07, 0xE0, 0x7B, 0xFF, 0xE0, 0x38, 0xFF, 0xE0, 0x3C, 0x1F, 0xC0,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x1E, 0x07, 0xFE, 0x3C, 0x1F,
  0xFE, 0x78, 0x7E, 0x0E, 0xF1, 0xF0, 0x07, 0xE7, 0xC0, 0x07, 0x8F, 0x00,
  0x0F, 0x3C, 0x00, 0x1E, 0x78, 0x00, 0x3C, 0xF0, 0x00, 0x7B, 0xC0, 0x00,
  0xF7, 0x80, 0x01, 0xCF, 0x00, 0x03, 0x9E, 0x00, 0x0F, 0x3C, 0x00, 0x1E,
  0x78, 0x00, 0x3C, 0xE0, 0x00, 0x79, 0xC0, 0x01, 0xE3, 0xC0, 0x03, 0xC7,
  0x80, 0x0F, 0x8F, 0x00, 0x3F, 0x1F, 0x00, 0xDE, 0x1F, 0x07, 0x3C, 0x1F,
  0xFE, 0x70, 0x1F, 0xF8, 0xE0, 0x1F, 0xC3, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x7F, 0xE0,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x9F, 0xF8, 0x0F, 0x7F, 0xF0, 0x1E, 0xE0,
  0x00, 0x3F, 0x00, 0x00, 0x74, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xE0, 0x7E, 0x0F, 0x80,
  0x1F, 0x0F, 0x00, 0x04, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x20, 0x00, 0x3C, 0x70, 0x00,
  0x38, 0xFC, 0x00, 0x78, 0x7F, 0x01, 0xF0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xC0, 0x03, 0xFE, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x01,
  0x81, 0xC0, 0x3E, 0x1E, 0x03, 0xE0, 0xF0, 0x3E, 0x07, 0x87, 0xC0, 0x3C,
  0x7C, 0x01, 0xEF, 0xC0, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x01, 0xF0, 0x00,
  0x1E, 0x00, 0x3C, 0x70, 0x00, 0xF3, 0xC0, 0x03, 0xCF, 0x00, 0x0F, 0x3C,
  0x00, 0x38, 0xF0, 0x01, 0xE3, 0x80, 0x07, 0x8E, 0x00, 0x1E, 0x78, 0x00,
  0x79, 0xE0, 0x01, 0xE7, 0x80, 0x07, 0x1E, 0x00, 0x3C, 0x78, 0x00, 0xF1,
  0xC0, 0x03, 0xCF, 0x00, 0x0F, 0x3C, 0x00, 0x3C, 0xF0, 0x01, 0xE3, 0xC0,
  0x07, 0x8F, 0x00, 0x3E, 0x3C, 0x00, 0xF8, 0xF0, 0x05, 0xE3, 0xE0, 0x37,
  0x87, 0xC3, 0x9C, 0x1F, 0xFC, 0xF0, 0x3F, 0xE3, 0xC0, 0x3F, 0x00, 0x00,
  0x7F, 0xC0, 0x0D, 0xFF, 0x00, 0x7B, 0xFE, 0x00, 0xF0, 0x3C, 0x00, 0xF0,
  0x78, 0x01, 0xE0, 0xF0, 0x03, 0xC1, 0xE0, 0x07, 0x83, 0xC0, 0x0F, 0x07,
  0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x78, 0x00, 0xE0, 0xF0,
  0x03, 0xC1, 0xE0, 0x07, 0x83, 0x80, 0x1E, 0x07, 0x00, 0x3C, 0x1E, 0x00,
  0xF0, 0x3C, 0x03, 0xE0, 0x78, 0x0F, 0x80, 0xF0, 0x3E, 0x01, 0xE0, 0xF8,
  0x03, 0x8F, 0xE0, 0x07, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0x1E, 0x07, 0x03, 0x0E, 0x03, 0x83, 0x87, 0x01, 0xC1, 0xE3, 0x81, 0xE0,
  0xF3, 0xC0, 0xF0, 0x39, 0xE0, 0x78, 0x1C, 0xE0, 0x38, 0x0E, 0x70, 0x1C,
  0x07, 0x38, 0x0E, 0x03, 0x9C, 0x0F, 0x01, 0xDE, 0x07, 0x80, 0xEF, 0x03,
  0xC0, 0x77, 0x81, 0xC0, 0x7B, 0x80, 0xE0, 0x3D, 0xC0, 0x70, 0x1C, 0xE0,
  0x78, 0x0E, 0xF0, 0x3C, 0x0F, 0x78, 0x1E, 0x07, 0xBC, 0x0E, 0x07, 0x9E,
  0x0F, 0x03, 0xCF, 0x0D, 0xC3, 0xC7, 0x8E, 0xE3, 0xC3, 0xFE, 0x7F, 0xE0,
  0xFE, 0x3F, 0xC0, 0x3E, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x0F,
  0xE1, 0xFE, 0x03, 0xFE, 0x3F, 0xF0, 0x7C, 0xE3, 0x8F, 0x1F, 0x8E, 0x70,
  0x73, 0xE0, 0xF6, 0x07, 0x18, 0x0F, 0xE0, 0x71, 0x00, 0x7C, 0x07, 0x00,
  0x07, 0xC0, 0x70, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0xF0, 0x1F,
  0x00, 0x8F, 0x03, 0x70, 0x1C, 0xF0, 0x37, 0x07, 0xCF, 0x07, 0x78, 0xF8,
  0x78, 0xE7, 0xBF, 0x07, 0xFC, 0x3F, 0xE0, 0x7F, 0x83, 0xF8, 0x01, 0xF0,
  0x1E, 0x00, 0x03, 0xC0, 0x07, 0x81, 0xC0, 0x03, 0xC1, 0xE0, 0x01, 0xE0,
  0xF0, 0x00, 0xF0, 0x78, 0x00, 0x70, 0x3C, 0x00, 0x78, 0x1C, 0x00, 0x3C,
  0x0E, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x03,
  0x81, 0xE0, 0x03, 0xC0, 0xF0, 0x01, 0xE0, 0x70, 0x00, 0xF0, 0x78, 0x00,
  0x78, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x0F, 0x00, 0x1E, 0x07, 0x80,
  0x1F, 0x03, 0xC0, 0x17, 0x81, 0xF0, 0x1B, 0xC0, 0x7C, 0x19, 0xE0, 0x3F,
  0xF8, 0xE0, 0x0F, 0xF8, 0xF0, 0x01, 0xF8, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x01, 0x00, 0x0F, 0x00,
  0xC0, 0x0F, 0x80, 0xF8, 0x1F, 0x80, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0x80,
  0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x07, 0x81, 0xFF, 0xC3, 0xC1, 0xFF,
  0xF9, 0xE1, 0xE0, 0xFF, 0xE1, 0xE0, 0x0F, 0xF0, 0xE0, 0x01, 0xF0, 0x70,
  0x01, 0xF0, 0x38, 0x01, 0xE0, 0x1C, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x20, 0x03, 0xC0, 0x78, 0x03, 0xC0, 0x1C, 0x03, 0xC0, 0x0E,
  0x03, 0xC0, 0x07, 0x87, 0xE0, 0x03, 0xC7, 0xFF, 0x80, 0xE3, 0xFF, 0xFC,
  0x71, 0xE7, 0xFF, 0xF8, 0xE0, 0x7F, 0xF8, 0xF0, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xE0, 0x07, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00,
  0x1F, 0xFC, 0x00, 0x01, 0xC0, 0x70, 0x3C, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x07, 0x81, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0xF0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x1E, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x03,
  0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x81, 0xE0, 0x78, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x3C, 0x0F, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x00, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xF0, 0x03, 0xFF,
  0xC0, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0xFF,
  0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xE0, 0x03, 0x03,
  0xF8, 0x01, 0xC3, 0xFE, 0x01, 0xE3, 0xC7, 0x80, 0xE3, 0xC1, 0xC0, 0xF1,
  0xC0, 0xF0, 0x71, 0xE0, 0x3C, 0x78, 0xE0, 0x0F, 0xF8, 0xF0, 0x07, 0xF8,
  0x30, 0x00, 0xF0, 0x00,
};

const GFXglyph IBMPlexMono_Italic48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 29, 0, -1 },
  { 1, 11, 34, 29, 9, -34 },
  { 48, 14, 13, 29, 10, -36 },
  { 71, 29, 34, 29, 1, -34 },
  { 195, 27, 45, 29, 1, -39 },
  { 347, 32, 35, 29, -1, -34 },
  { 487, 28, 35, 29, 0, -34 },
  { 610, 6, 13, 29, 14, -36 },
  { 620, 18, 43, 29, 10, -36 },
  { 717, 18, 43, 29, 2, -36 },
  { 814, 24, 24, 29, 3, -26 },
  { 886, 23, 23, 29, 3, -26 },
  { 953, 10, 13, 29, 7, -6 },
  { 970, 14, 4, 29, 8, -17 },
  { 977, 7, 7, 29, 9, -7 },
  { 984, 28, 43, 29, 1, -36 },
  { 1135, 24, 35, 29, 3, -34 },
  { 1240, 23, 34, 29, 2, -34 },
  { 1338, 25, 34, 29, 1, -34 },
  { 1445, 25, 35, 29, 1, -34 },
  { 1555, 26, 34, 29, 1, -34 },
  { 1666, 25, 35, 29, 2, -34 },
  { 1776, 23, 35, 29, 3, -34 },
  { 1877, 24, 34, 29, 5, -34 },
  { 1979, 25, 35, 29, 2, -34 },
  { 2089, 23, 34, 29, 4, -34 },
  { 2187, 11, 26, 29, 9, -26 },
  { 2223, 13, 33, 29, 7, -26 },
  { 2277, 23, 28, 29, 4, -29 },
  { 2358, 25, 13, 29, 2, -21 },
  { 2399, 23, 28, 29, 2, -29 },
  { 2480, 21, 34, 29, 6, -34 },
  { 2570, 24, 39, 29, 3, -34 },
  { 2687, 25, 34, 29, 0, -34 },
  { 2794, 25, 34, 29, 2, -34 },
  { 2901, 24, 35, 29, 4, -34 },
  { 3006, 24, 34, 29, 3, -34 },
  { 3108, 26, 34, 29, 2, -34 },
  { 3219, 27, 34, 29, 2, -34 },
  { 3334, 24, 35, 29, 3, -34 },
  { 3439, 26, 34, 29, 2, -34 },
  { 3550, 26, 34, 29, 2, -34 },
  { 3661, 24, 35, 29, 3, -34 },
  { 3766, 29, 34, 29, 2, -34 },
  { 3890, 20, 34, 29, 4, -34 },
  { 3975, 28, 34, 29, 1, -34 },
  { 4094, 26, 34, 29, 2, -34 },
  { 4205, 24, 35, 29, 3, -34 },
  { 4310, 26, 34, 29, 2, -34 },
  { 4421, 24, 43, 29, 3, -34 },
  { 4550, 26, 34, 29, 2, -34 },
  { 4661, 27, 35, 29, 1, -34 },
  { 4780, 27, 34, 29, 4, -34 },
  { 4895, 25, 35, 29, 3, -34 },
  { 5005, 25, 34, 29, 5, -34 },
  { 5112, 29, 34, 29, 2, -34 },
  { 5236, 32, 34, 29, -1, -34 },
  { 5372, 27, 34, 29, 4, -34 },
  { 5487, 29, 34, 29, 0, -34 },
  { 5611, 20, 43, 29, 8, -36 },
  { 5719, 12, 43, 29, 9, -36 },
  { 5784, 21, 43, 29, 0, -36 },
  { 5897, 24, 19, 29, 3, -34 },
  { 5954, 23, 4, 29, 0, 4 },
  { 5966, 6, 9, 29, 11, -37 },
  { 5973, 23, 26, 29, 3, -25 },
  { 6048, 23, 37, 29, 3, -36 },
  { 6155, 21, 26, 29, 4, -25 },
  { 6224, 25, 37, 29, 3, -36 },
  { 6340, 23, 26, 29, 3, -25 },
  { 6415, 32, 46, 29, -1, -36 },
  { 6599, 25, 35, 29, 1, -25 },
  { 6709, 22, 36, 29, 3, -36 },
  { 6808, 22, 37, 29, 4, -36 },
  { 6910, 22, 46, 29, 3, -36 },
  { 7037, 24, 37, 29, 3, -36 },
  { 7148, 20, 37, 29, 5, -36 },
  { 7241, 26, 25, 29, 1, -25 },
  { 7323, 22, 25, 29, 3, -25 },
  { 7392, 23, 26, 29, 3, -25 },
  { 7467, 25, 35, 29, 1, -25 },
  { 7577, 23, 35, 29, 3, -25 },
  { 7678, 23, 25, 29, 5, -25 },
  { 7750, 24, 26, 29, 2, -25 },
  { 7828, 21, 35, 29, 4, -34 },
  { 7920, 22, 26, 29, 4, -25 },
  { 7992, 23, 25, 29, 3, -25 },
  { 8064, 25, 25, 29, 2, -25 },
  { 8143, 28, 26, 29, 0, -25 },
  { 8234, 25, 35, 29, 1, -25 },
  { 8344, 25, 25, 29, 2, -25 },
  { 8423, 23, 43, 29, 5, -36 },
  { 8547, 10, 43, 29, 10, -36 },
  { 8601, 22, 43, 29, 2, -36 },
  { 8720, 25, 10, 29, 2, -20 },
};

const GFXfont IBMPlexMono_Italic48pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Italic48pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Italic48pt7bGlyphs,
  0x20, 0x7E, 62
};

#endif // _IBMPLEXMONO_ITALIC48PT7B_H_
