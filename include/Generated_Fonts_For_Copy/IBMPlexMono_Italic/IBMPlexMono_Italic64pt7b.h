#ifndef _IBMPLEXMONO_ITALIC64PT7B_H_
#define _IBMPLEXMONO_ITALIC64PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Italic.ttf
// Size: 64pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Italic64pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x0F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFC, 0x07,
  0xF8, 0x07, 0xC0, 0x00, 0x3E, 0x07, 0xCF, 0x81, 0xF3, 0xE0, 0x7C, 0xF8,
  0x1F, 0x3C, 0x07, 0xCF, 0x01, 0xE7, 0xC0, 0xF9, 0xF0, 0x3E, 0x7C, 0x0F,
  0x9F, 0x03, 0xE7, 0x80, 0xF9, 0xE0, 0x3C, 0xF8, 0x1F, 0x3E, 0x07, 0xCF,
  0x81, 0xF3, 0xE0, 0x7C, 0xF0, 0x1F, 0x3C, 0x07, 0x80, 0x00, 0x00, 0x3E,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x0F, 0x00,
  0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x00, 0x0F,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x07, 0x80,
  0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x78, 0x00, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x03, 0xC0,
  0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xFF,
  0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0x01, 0xFF,
  0xF8, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x78,
  0x00, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x1F, 0x00, 0x07, 0xFF, 0xE0, 0x3F,
  0xFE, 0x0F, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0xF8, 0x3F,
  0xFE, 0x03, 0xFF, 0xF0, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x00, 0xF0, 0x1F,
  0x00, 0x00, 0x01, 0xE0, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00,
  0x0F, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x07,
  0xC0, 0x00, 0x00, 0xF0, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x78, 0x00, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xF8, 0xF3, 0xFE, 0x01, 0xFE, 0x0F, 0x0F, 0xF0,
  0x1F, 0x80, 0xF0, 0x3F, 0x03, 0xF0, 0x0E, 0x01, 0xF0, 0x3F, 0x01, 0xE0,
  0x0C, 0x03, 0xE0, 0x1E, 0x00, 0x80, 0x3E, 0x01, 0xE0, 0x00, 0x03, 0xE0,
  0x1E, 0x00, 0x00, 0x3E, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x1C, 0x00, 0x00,
  0x3E, 0x03, 0xC0, 0x00, 0x03, 0xF0, 0x3C, 0x00, 0x00, 0x3F, 0x83, 0xC0,
  0x00, 0x01, 0xFE, 0x3C, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0x70, 0xFF, 0x00, 0x00, 0x0F, 0x03, 0xF0, 0x00, 0x00,
  0xF0, 0x1F, 0x80, 0x00, 0x0F, 0x01, 0xF8, 0x00, 0x00, 0xF0, 0x0F, 0x80,
  0x00, 0x0E, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x0F, 0x80, 0x00, 0x1E, 0x00,
  0xF8, 0x10, 0x01, 0xE0, 0x1F, 0x81, 0x80, 0x1E, 0x01, 0xF8, 0x3C, 0x01,
  0xE0, 0x1F, 0x07, 0xE0, 0x1C, 0x03, 0xF0, 0xFF, 0x03, 0xC0, 0x7E, 0x03,
  0xFC, 0x3C, 0x1F, 0xE0, 0x1F, 0xF3, 0xC7, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x3E, 0x00, 0x3F, 0xFF,
  0x00, 0x03, 0xC0, 0x07, 0xE1, 0xF0, 0x00, 0x7C, 0x00, 0x78, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xF0, 0x07, 0x80, 0x1E,
  0x00, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x01, 0xE0, 0x07, 0x80, 0x7C, 0x00,
  0x3E, 0x00, 0x78, 0x07, 0x80, 0x03, 0xE0, 0x07, 0x80, 0xF8, 0x00, 0x3E,
  0x00, 0x78, 0x1F, 0x00, 0x03, 0xC0, 0x07, 0x81, 0xE0, 0x00, 0x3C, 0x00,
  0xF8, 0x3E, 0x00, 0x03, 0xC0, 0x0F, 0x87, 0xC0, 0x00, 0x3C, 0x00, 0xF0,
  0x78, 0x00, 0x03, 0xE0, 0x1F, 0x0F, 0x80, 0x00, 0x1E, 0x03, 0xE1, 0xF0,
  0x00, 0x01, 0xF0, 0x7C, 0x3E, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xC3,
  0xF0, 0xF8, 0x00, 0x00, 0x78, 0x3C, 0x07, 0xC0, 0x00, 0x0F, 0x87, 0x80,
  0x3C, 0x00, 0x01, 0xF0, 0xF8, 0x03, 0xC0, 0x00, 0x1E, 0x0F, 0x00, 0x3C,
  0x00, 0x03, 0xE0, 0xF0, 0x03, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x3C, 0x00,
  0x0F, 0x81, 0xF0, 0x03, 0xC0, 0x00, 0xF0, 0x1F, 0x00, 0x3C, 0x00, 0x1F,
  0x01, 0xE0, 0x03, 0xC0, 0x03, 0xE0, 0x1E, 0x00, 0x7C, 0x00, 0x3C, 0x01,
  0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x00, 0xF8, 0x01, 0xE0,
  0x07, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0xF0, 0x01, 0xF0, 0x00, 0xF0, 0x1F,
  0x00, 0x3E, 0x00, 0x0F, 0x83, 0xE0, 0x07, 0xC0, 0x00, 0x7F, 0xFC, 0x00,
  0x78, 0x00, 0x03, 0xFF, 0x80, 0x08, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x0F,
  0xC0, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x03, 0xF0, 0x00, 0x0F,
  0x80, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x01, 0xF8,
  0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x00, 0x3F,
  0x83, 0xF0, 0x00, 0x07, 0xFF, 0x7F, 0x80, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x00, 0xFC, 0x0F,
  0xC0, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00,
  0x7C, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x07,
  0xC0, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x8F, 0x80, 0x01, 0xF8, 0x07, 0xBE, 0x00, 0x07,
  0xE0, 0x3F, 0xFC, 0x00, 0x3F, 0xC0, 0xFB, 0xF0, 0x00, 0xDF, 0x07, 0xC7,
  0xC0, 0x07, 0x7E, 0x1F, 0x1F, 0x80, 0x3C, 0xF8, 0xF8, 0x7F, 0x03, 0xE3,
  0xF7, 0xE0, 0xFF, 0xFF, 0x8F, 0xFF, 0x01, 0xFF, 0xFC, 0x1F, 0xFC, 0x03,
  0xFF, 0xE0, 0x3F, 0xE0, 0x07, 0xFF, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0xF8, 0x00, 0x1F, 0x1E, 0x1E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3C, 0x3C, 0x7C,
  0x7C, 0x7C, 0x7C, 0x78, 0x78, 0xF8, 0xF8, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x70, 0x03, 0xE0, 0x07, 0x7E, 0x03, 0xE0,
  0x3F, 0xFF, 0xC3, 0xE1, 0xFF, 0xFF, 0xFB, 0xDF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0xFD, 0xF8, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x01, 0xF0, 0x7C,
  0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x0F, 0xC0, 0x3E,
  0x00, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1E, 0x00, 0x0F,
  0x00, 0x0C, 0x00, 0x0E, 0x00, 0x08, 0x00, 0x08, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xFC,
  0x0F, 0xE0, 0x7F, 0x81, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xF0,
  0x1F, 0xC0, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xC0,
  0x1F, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0x0F, 0xE7, 0xFD, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF9, 0xFE, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0xFF, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x3E, 0x07,
  0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x1F, 0x0F,
  0x80, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x1F, 0x1F,
  0x00, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x1F, 0x3E,
  0x00, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x1F, 0x7E,
  0x03, 0xE0, 0x1F, 0x7C, 0x07, 0xF0, 0x1F, 0x7C, 0x0F, 0xF0, 0x3F, 0xFC,
  0x0F, 0xF0, 0x3F, 0xFC, 0x0F, 0xF0, 0x3F, 0xFC, 0x0F, 0xE0, 0x3E, 0xF8,
  0x07, 0xC0, 0x3E, 0xF8, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x7E, 0xF8,
  0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0xFC, 0xF8,
  0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x01, 0xF8, 0xF8,
  0x00, 0x01, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x07, 0xE0, 0x7E,
  0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x7F, 0x7C, 0x00, 0x07, 0xF9, 0xF0, 0x00, 0x3F, 0xC7,
  0xC0, 0x01, 0xFC, 0x1F, 0x00, 0x0F, 0xE0, 0x7C, 0x00, 0x7F, 0x03, 0xE0,
  0x03, 0xF0, 0x0F, 0x80, 0x1F, 0x80, 0x3E, 0x00, 0x1C, 0x00, 0xF8, 0x00,
  0x40, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFC, 0x0F, 0xF8, 0x07, 0xF0, 0x01,
  0xFC, 0x03, 0xF0, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x01, 0xF0, 0x04, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x07,
  0xFC, 0x07, 0xF8, 0x03, 0xF8, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x3F, 0x01,
  0xF0, 0x00, 0x1F, 0x80, 0x30, 0x00, 0x07, 0xC0, 0x10, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x3F, 0x02, 0x00, 0x00, 0x1F, 0x87, 0x80, 0x00, 0x1F, 0x87, 0xC0,
  0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x1F, 0xE0, 0x7F,
  0xC0, 0x3F, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00,
  0x1F, 0x1F, 0x00, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x07, 0xE3, 0xE0, 0x00,
  0x01, 0xF0, 0xF8, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x7C, 0x0F, 0x80,
  0x00, 0x3E, 0x03, 0xE0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x7C,
  0x00, 0x03, 0xE0, 0x1F, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0xF8, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0xF8, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x07, 0xC0, 0x1F,
  0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x1F, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3E, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x01, 0xF0, 0x7F, 0x80, 0x00, 0x7C, 0x7F, 0xF8, 0x00, 0x1E, 0x3F, 0xFF,
  0x80, 0x07, 0xBF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0x80,
  0x7F, 0x80, 0x3F, 0x80, 0x07, 0xF0, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x20, 0x00, 0x03, 0xF0, 0x38, 0x00, 0x01,
  0xF8, 0x1F, 0x00, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x3F, 0x01, 0xFC, 0x00,
  0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x07, 0xF0, 0x01,
  0xF8, 0xFF, 0xF8, 0x07, 0xC7, 0xFF, 0xF0, 0x1F, 0x3F, 0xFF, 0xE0, 0xFD,
  0xFF, 0xFF, 0xC3, 0xEF, 0x80, 0xFF, 0x9F, 0xF0, 0x00, 0xFE, 0x7F, 0x80,
  0x01, 0xFD, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x01, 0xF1, 0xF0,
  0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x7E, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0xC0,
  0x7F, 0xC0, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7C, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00,
  0xFC, 0x78, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x03,
  0xF0, 0xF8, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07, 0xE0, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x07, 0xF0,
  0x00, 0xFE, 0x07, 0xE0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x0F, 0x83, 0xF0,
  0x00, 0x07, 0xC1, 0xF0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x01, 0xF0, 0x7C,
  0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x7C, 0x0F,
  0x80, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x7F, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x07, 0xF8, 0x07, 0xF8, 0x07, 0xE0, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x3F,
  0x07, 0xC0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x01,
  0xF3, 0xF0, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00,
  0x3E, 0x7C, 0x00, 0x00, 0x3F, 0x3E, 0x00, 0x00, 0x1F, 0x9F, 0x00, 0x00,
  0x0F, 0xCF, 0x80, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x07, 0xE3, 0xF8, 0x00,
  0x07, 0xE1, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x3F, 0xF0, 0x1F, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xE0, 0x3F, 0xE0, 0x3F, 0xC1, 0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x00,
  0x7E, 0x3F, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0x7E, 0xFC, 0x00,
  0x03, 0xFB, 0xF0, 0x00, 0x1F, 0xEF, 0xE0, 0x01, 0xFF, 0x1F, 0xF0, 0x1F,
  0x7C, 0x3F, 0xFF, 0xFB, 0xE0, 0xFF, 0xFF, 0xCF, 0x81, 0xFF, 0xFE, 0x7C,
  0x01, 0xFF, 0xE1, 0xF0, 0x01, 0xFE, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x0F, 0xF0,
  0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0xFF, 0x81, 0xFE, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x03, 0xF8, 0x1F, 0xF0, 0x7F, 0xC3, 0xFF,
  0x0F, 0xFC, 0x3F, 0xE0, 0x7F, 0x80, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x3F,
  0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x07, 0xFC, 0x01,
  0xFE, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xC1, 0xFE, 0x03, 0xFC, 0x3F, 0x80, 0x0F, 0xE3, 0xF0, 0x00, 0x7E,
  0x7E, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3E, 0xFC, 0x00, 0x03, 0xF3, 0x80,
  0x00, 0x3E, 0x08, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xF8, 0x00,
  0x7C, 0x03, 0xF0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00,
  0x1F, 0x07, 0x80, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x1F, 0x0F, 0x00, 0x00,
  0x1F, 0x1F, 0x00, 0x00, 0x1F, 0x1F, 0x00, 0x3E, 0x1F, 0x1E, 0x00, 0xFF,
  0x9F, 0x3E, 0x01, 0xFF, 0xDF, 0x3E, 0x03, 0xFF, 0xDE, 0x3E, 0x07, 0xE0,
  0xDE, 0x3C, 0x0F, 0xC0, 0x7E, 0x3C, 0x0F, 0x80, 0x3E, 0x7C, 0x1F, 0x80,
  0x3E, 0x7C, 0x1F, 0x00, 0x3E, 0x7C, 0x1F, 0x00, 0x3E, 0x7C, 0x1F, 0x00,
  0x3C, 0x78, 0x3E, 0x00, 0x3C, 0xF8, 0x3E, 0x00, 0x3C, 0xF8, 0x3E, 0x00,
  0x7C, 0xF8, 0x3E, 0x00, 0x7C, 0xF8, 0x3E, 0x00, 0x7C, 0xF0, 0x3E, 0x00,
  0x78, 0xF0, 0x3C, 0x00, 0xF8, 0xF0, 0x3E, 0x00, 0xF8, 0xF0, 0x3E, 0x01,
  0xF8, 0xF0, 0x3E, 0x01, 0xF8, 0xF0, 0x3E, 0x02, 0xF8, 0xF0, 0x1F, 0x8E,
  0xF0, 0xF0, 0x1F, 0xFC, 0xF0, 0xF0, 0x0F, 0xFD, 0xF0, 0xF0, 0x07, 0xF9,
  0xF0, 0xF0, 0x01, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0x9E, 0x00,
  0x00, 0x01, 0xF3, 0xE0, 0x00, 0x00, 0x3C, 0x7C, 0x00, 0x00, 0x0F, 0x8F,
  0x80, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x0F,
  0x87, 0xC0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00,
  0x1F, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0xF8, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0xF8, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x01, 0xF8,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFC, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x01, 0xF0, 0x1F, 0x80,
  0x00, 0x3E, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x00, 0xFC, 0x1F,
  0x00, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x3E,
  0x1F, 0x00, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00,
  0x1F, 0x3F, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7E, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0x80, 0x07, 0xF8, 0x0F,
  0xC0, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x1F, 0x01,
  0xF0, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x03, 0xF0,
  0x7C, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0xFC,
  0x0F, 0x80, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x7E,
  0x03, 0xE0, 0x00, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xE0, 0x1F, 0x80, 0x03, 0xF8, 0x0F, 0x80, 0x00, 0x7E, 0x07, 0xC0, 0x00,
  0x1F, 0x03, 0xE0, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x03, 0xE0, 0xF8, 0x00,
  0x01, 0xF0, 0xFC, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0xFC, 0x3E, 0x00,
  0x00, 0x7E, 0x1F, 0x00, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x1F, 0x07, 0xC0,
  0x00, 0x1F, 0x87, 0xC0, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x0F, 0xC1, 0xF0,
  0x00, 0x0F, 0xE0, 0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0xFF, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x3E,
  0x07, 0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x1F,
  0x0F, 0x80, 0x00, 0x18, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x40, 0xF8, 0x00, 0x00, 0xF0, 0xFC, 0x00, 0x01, 0xF8,
  0xFC, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xE0,
  0x7E, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x1F, 0xC0, 0x3F, 0xE0, 0x7F, 0x80,
  0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xE0, 0x07, 0xFC, 0x03, 0xE0, 0x01, 0xFC,
  0x03, 0xE0, 0x00, 0xFE, 0x03, 0xE0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x3E,
  0x07, 0xE0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1F,
  0x07, 0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x1F,
  0x0F, 0xC0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x1F,
  0x0F, 0x80, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3F,
  0x1F, 0x80, 0x00, 0x3F, 0x1F, 0x00, 0x00, 0x3F, 0x1F, 0x00, 0x00, 0x3E,
  0x1F, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x7E,
  0x3F, 0x00, 0x00, 0x7E, 0x3E, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0xFC,
  0x3E, 0x00, 0x00, 0xFC, 0x3E, 0x00, 0x00, 0xF8, 0x7E, 0x00, 0x01, 0xF8,
  0x7C, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x07, 0xE0,
  0x7C, 0x00, 0x0F, 0xE0, 0x7C, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0x01, 0xFE,
  0x01, 0xFC, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x3F,
  0x07, 0xE0, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x08,
  0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0xFF, 0xFC,
  0x7C, 0x00, 0xFF, 0xFC, 0xFC, 0x00, 0xFF, 0xFC, 0xFC, 0x00, 0xFF, 0xFC,
  0xFC, 0x00, 0xFF, 0xFC, 0xFC, 0x01, 0x00, 0x78, 0xFC, 0x00, 0x00, 0x78,
  0xFC, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x00, 0xF8,
  0xFC, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x01, 0xF0,
  0x7E, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xF0,
  0x3F, 0x80, 0x1D, 0xF0, 0x3F, 0xC0, 0x79, 0xE0, 0x1F, 0xFF, 0xFB, 0xE0,
  0x0F, 0xFF, 0xF3, 0xE0, 0x0F, 0xFF, 0xE3, 0xE0, 0x03, 0xFF, 0x83, 0xE0,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00,
  0x3F, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x1F, 0x80, 0x00, 0x3E, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x07, 0xE0,
  0x1F, 0x00, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x3F, 0x00, 0x00,
  0x7C, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x7C, 0x03, 0xE0,
  0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x7E, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00,
  0xF8, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x03,
  0xF0, 0x0F, 0x80, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x1F, 0x00,
  0x00, 0x3E, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x7E, 0x01,
  0xF0, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x07,
  0xC0, 0x3E, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x3E, 0x00,
  0x00, 0x7C, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x00, 0xFC, 0x07,
  0xE0, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x7C, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x60, 0x00, 0x3F, 0x07,
  0xC0, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x3F,
  0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x3F, 0x80, 0x7F, 0x81, 0xFF, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xFC,
  0x07, 0xC0, 0x00, 0x0F, 0xE0, 0x1F, 0x00, 0x00, 0x7F, 0x00, 0x7C, 0x00,
  0x03, 0xF8, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x0F, 0xC0, 0x00, 0xFE, 0x00,
  0x3E, 0x00, 0x07, 0xF0, 0x00, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xE0, 0x01,
  0xFC, 0x00, 0x0F, 0x80, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x01,
  0xF8, 0x03, 0xF8, 0x00, 0x07, 0xC0, 0x1F, 0xC0, 0x00, 0x1F, 0x00, 0xFE,
  0x00, 0x00, 0x7C, 0x07, 0xF0, 0x00, 0x01, 0xF0, 0x3F, 0x80, 0x00, 0x0F,
  0xC1, 0xFC, 0x00, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x00, 0xF8, 0x7F, 0x00,
  0x00, 0x03, 0xE3, 0xF8, 0x00, 0x00, 0x0F, 0x8F, 0xF0, 0x00, 0x00, 0x3E,
  0x7F, 0xC0, 0x00, 0x01, 0xFB, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xBE, 0x00,
  0x00, 0x1F, 0xFC, 0xFC, 0x00, 0x00, 0x7F, 0xE1, 0xF0, 0x00, 0x01, 0xFF,
  0x07, 0xE0, 0x00, 0x07, 0xF8, 0x1F, 0x80, 0x00, 0x3F, 0xC0, 0x3E, 0x00,
  0x00, 0xFE, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x07, 0xE0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x7C, 0x00,
  0x07, 0xE0, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x07, 0xC0, 0x00, 0x3F, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00,
  0x03, 0xE0, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x00, 0x3F, 0x00,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x7F,
  0x00, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x3F, 0xE0, 0x01, 0xFF,
  0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0xC0,
  0x07, 0xFC, 0x03, 0xDF, 0x00, 0x7D, 0xE0, 0x1E, 0xF8, 0x03, 0xDF, 0x01,
  0xF3, 0xC0, 0x3E, 0xF8, 0x0F, 0x9E, 0x03, 0xE7, 0xC0, 0x7C, 0xF8, 0x1F,
  0x3E, 0x03, 0xE7, 0xC1, 0xF1, 0xE0, 0x1E, 0x1E, 0x0F, 0x0F, 0x00, 0xF0,
  0xF0, 0xF8, 0xF8, 0x0F, 0x87, 0x87, 0x87, 0xC0, 0x7C, 0x3E, 0x7C, 0x3E,
  0x03, 0xE0, 0xF7, 0xC1, 0xF0, 0x1F, 0x07, 0xBC, 0x0F, 0x00, 0xF0, 0x3F,
  0xE0, 0x78, 0x07, 0x81, 0xFE, 0x07, 0xC0, 0x7C, 0x07, 0xF0, 0x3E, 0x03,
  0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x01, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0x78, 0x07, 0xC0, 0x38, 0x03, 0xC0, 0x3C, 0x01, 0xC0, 0x3E, 0x03, 0xE0,
  0x0C, 0x01, 0xF0, 0x1F, 0x00, 0x60, 0x0F, 0x80, 0xF8, 0x02, 0x00, 0x7C,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00,
  0x01, 0xF0, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0x7C, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x00,
  0xF0, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0x7C, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xF0, 0x0F,
  0xF0, 0x00, 0x1F, 0x00, 0xFF, 0x00, 0x01, 0xE0, 0x1F, 0xF0, 0x00, 0x3E,
  0x01, 0xFF, 0x80, 0x03, 0xE0, 0x1F, 0xF8, 0x00, 0x3E, 0x01, 0xFF, 0x80,
  0x03, 0xE0, 0x1F, 0x78, 0x00, 0x3E, 0x01, 0xE7, 0x80, 0x03, 0xC0, 0x3E,
  0x7C, 0x00, 0x7C, 0x03, 0xE7, 0xC0, 0x07, 0xC0, 0x3E, 0x7C, 0x00, 0x7C,
  0x03, 0xE3, 0xC0, 0x07, 0xC0, 0x3E, 0x3E, 0x00, 0x7C, 0x03, 0xC3, 0xE0,
  0x07, 0x80, 0x7C, 0x3E, 0x00, 0xF8, 0x07, 0xC1, 0xE0, 0x0F, 0x80, 0x7C,
  0x1E, 0x00, 0xF8, 0x07, 0xC1, 0xF0, 0x0F, 0x80, 0x7C, 0x1F, 0x00, 0xF8,
  0x07, 0x81, 0xF0, 0x0F, 0x80, 0xF8, 0x0F, 0x01, 0xF0, 0x0F, 0x80, 0xF8,
  0x1F, 0x00, 0xF8, 0x0F, 0x81, 0xF0, 0x0F, 0x80, 0xF8, 0x1F, 0x00, 0xF8,
  0x07, 0x81, 0xF0, 0x0F, 0x00, 0x78, 0x1F, 0x01, 0xF0, 0x07, 0xC3, 0xE0,
  0x1F, 0x00, 0x7C, 0x3E, 0x01, 0xF0, 0x07, 0xC3, 0xE0, 0x1F, 0x00, 0x3C,
  0x3E, 0x01, 0xF0, 0x03, 0xC3, 0xE0, 0x1E, 0x00, 0x3E, 0x3E, 0x03, 0xE0,
  0x03, 0xE7, 0xC0, 0x3E, 0x00, 0x3E, 0x7C, 0x03, 0xE0, 0x01, 0xE7, 0xC0,
  0x3E, 0x00, 0x1F, 0x7C, 0x03, 0xE0, 0x01, 0xF7, 0xC0, 0x3C, 0x00, 0x1F,
  0x7C, 0x07, 0xC0, 0x00, 0xFF, 0x80, 0x7C, 0x00, 0x0F, 0xF8, 0x07, 0xC0,
  0x00, 0xFF, 0x80, 0x7C, 0x00, 0x0F, 0xF8, 0x07, 0xC0, 0x00, 0xFF, 0x80,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0xFF, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x7E, 0x03, 0xF0, 0x00,
  0x3E, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x1F, 0x0F, 0xC0, 0x00,
  0x1F, 0x0F, 0x80, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0x1F, 0x1F, 0x00, 0x00,
  0x1F, 0x1F, 0x00, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00,
  0x1F, 0x3E, 0x00, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x1F, 0x7E, 0x00, 0x00,
  0x1F, 0x7E, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3E, 0xFC, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00,
  0x7E, 0xF8, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00,
  0xFC, 0xF8, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x01,
  0xF8, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x07,
  0xE0, 0x7E, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7C, 0x00, 0x0F, 0xE0, 0x3F,
  0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0xF8, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x1F,
  0x07, 0xE0, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00,
  0xFC, 0x1F, 0x00, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x0F, 0xC1, 0xF0, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x00, 0xFC, 0x0F, 0x80,
  0x00, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0x01, 0xFC, 0x01, 0xFC, 0x00,
  0x7E, 0x03, 0xF0, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00,
  0x1F, 0x0F, 0xC0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x1F, 0x1F, 0x80, 0x00,
  0x1F, 0x1F, 0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x1F, 0x3F, 0x00, 0x00,
  0x1F, 0x3E, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x1F, 0x7E, 0x00, 0x00,
  0x1F, 0x7E, 0x00, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00,
  0x3F, 0x7C, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00,
  0x7E, 0xF8, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00,
  0x7C, 0xF8, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x00,
  0xF8, 0xF8, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03,
  0xF0, 0x7C, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x1F,
  0xC0, 0x3F, 0xC0, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0x10, 0x00, 0x0F, 0xC0, 0x18, 0x00, 0x0F, 0xC0,
  0x3C, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x03, 0xF1, 0xFC, 0x00, 0x03, 0xFB,
  0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7C, 0x00, 0x0F, 0xE0, 0x3F,
  0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0xF8, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x1F,
  0x07, 0xE0, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00,
  0xFC, 0x1F, 0x00, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x0F, 0xC1, 0xF0, 0x00,
  0x03, 0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x00, 0xFC, 0x0F, 0x80,
  0x00, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x01,
  0xF0, 0x0F, 0x80, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x1F, 0x80, 0x03, 0xF0, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF8, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x1F, 0x80,
  0x03, 0xF0, 0x07, 0xC0, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x7C,
  0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x03,
  0xC0, 0xFC, 0x00, 0x00, 0x30, 0x1F, 0x00, 0x00, 0x04, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x18, 0x00, 0x00, 0x1F, 0x87, 0x80,
  0x00, 0x07, 0xE1, 0xF8, 0x00, 0x00, 0xFC, 0x3F, 0x80, 0x00, 0x3F, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x83, 0xE0,
  0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x03, 0xE0, 0xF8,
  0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x7C, 0x1F,
  0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x1F, 0x07,
  0xC0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x03, 0xE0,
  0xF8, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0xF8,
  0x3E, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x1F,
  0x07, 0xC0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x07,
  0xC1, 0xF0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00,
  0xF8, 0x3E, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00,
  0x3E, 0x0F, 0x80, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x0F, 0x83, 0xE0, 0x00,
  0x0F, 0xC1, 0xF0, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x03, 0xE0, 0x7C, 0x00,
  0x01, 0xF0, 0x3E, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x00, 0xFC, 0x0F, 0x80,
  0x00, 0x7C, 0x07, 0xC0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x7E, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07,
  0xEF, 0x80, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00,
  0x3F, 0x1F, 0x00, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x07, 0xE1, 0xF0, 0x00,
  0x01, 0xF0, 0x7C, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0x3E, 0x07, 0xC0,
  0x00, 0x1F, 0x81, 0xF0, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x01, 0xF0, 0x0F,
  0x80, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x1F, 0x80,
  0x3E, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x03, 0xF0, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x78, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x07,
  0xC0, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x00, 0x3C,
  0x03, 0xE0, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00,
  0xF8, 0x1F, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x0F, 0x83, 0xE0, 0x00,
  0x03, 0xE1, 0xF0, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0x1E, 0x3E, 0x00,
  0x00, 0x07, 0xCF, 0x80, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x00, 0x7D, 0xF0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x00, 0x3E, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x00,
  0x1F, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x7C,
  0x00, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x00,
  0xF8, 0x1E, 0x00, 0xFC, 0x03, 0xE0, 0x78, 0x07, 0xF0, 0x0F, 0x01, 0xE0,
  0x1F, 0xC0, 0x3C, 0x0F, 0x80, 0xFF, 0x01, 0xF0, 0x3E, 0x03, 0xFC, 0x07,
  0xC0, 0xF8, 0x0F, 0xF0, 0x1F, 0x03, 0xE0, 0x7B, 0xC0, 0x78, 0x0F, 0x81,
  0xEF, 0x03, 0xE0, 0x3E, 0x07, 0xBC, 0x0F, 0x80, 0xF8, 0x3C, 0xF0, 0x3E,
  0x03, 0xC0, 0xF3, 0xC0, 0xF0, 0x0F, 0x07, 0xCF, 0x07, 0xC0, 0x3C, 0x1E,
  0x3C, 0x1F, 0x00, 0xF0, 0x78, 0xF0, 0x7C, 0x03, 0xC3, 0xE3, 0xC1, 0xE0,
  0x1F, 0x0F, 0x0F, 0x8F, 0x80, 0x7C, 0x3C, 0x3E, 0x3E, 0x01, 0xF1, 0xE0,
  0x78, 0xF8, 0x07, 0xC7, 0x81, 0xE3, 0xC0, 0x1F, 0x3E, 0x07, 0x8F, 0x00,
  0x7C, 0xF0, 0x1E, 0x7C, 0x01, 0xE3, 0xC0, 0x79, 0xF0, 0x07, 0x9F, 0x01,
  0xE7, 0x80, 0x1E, 0x78, 0x07, 0x9E, 0x00, 0x79, 0xE0, 0x1E, 0xF8, 0x01,
  0xEF, 0x00, 0x7B, 0xE0, 0x0F, 0xBC, 0x01, 0xEF, 0x00, 0x3F, 0xF0, 0x07,
  0xBC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F,
  0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x07,
  0xE0, 0x00, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0x80, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x00,
  0x7C, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x00, 0x03, 0xE3,
  0xF0, 0x00, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xCF, 0x80, 0x00, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x01, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x00, 0x0F,
  0xC7, 0xE0, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x00, 0x3F, 0x83, 0xF0, 0x00,
  0x03, 0xF0, 0x3F, 0x00, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0x03, 0xE0, 0x1F, 0x80, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x03,
  0xF0, 0x3F, 0x00, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0xFC, 0x00,
  0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7F,
  0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x7F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x3F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x3F,
  0x7C, 0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x1F,
  0x07, 0xC0, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x0F,
  0x80, 0x3E, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x07, 0xC0, 0x01, 0xF0, 0x07, 0xE0, 0x00, 0x7C, 0x03,
  0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x07, 0xC3,
  0xF0, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x00, 0x7D,
  0xF8, 0x00, 0x00, 0x3E, 0x38, 0x00, 0x00, 0x0F, 0x88, 0x00, 0x00, 0x04,
  0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x38, 0xF8, 0xF8,
  0x7C, 0x7C, 0x3C, 0x3C, 0x3E, 0x1E, 0x1E, 0x0F, 0x0C, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFF, 0xF0, 0xFC, 0x07, 0xFF, 0xF1, 0xF0, 0x1F, 0xFF, 0xF3,
  0xE0, 0x7F, 0xFF, 0xE7, 0xC1, 0xFF, 0x01, 0xEF, 0x83, 0xF8, 0x00, 0xDF,
  0x0F, 0xC0, 0x00, 0xFC, 0x1F, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x01, 0xF0,
  0xF8, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x0F, 0x8F,
  0x80, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00, 0xF8, 0xF8,
  0x00, 0x01, 0xF1, 0xF0, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x07, 0xC7, 0xC0,
  0x00, 0x1F, 0x0F, 0x80, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x7C, 0x3E, 0x00,
  0x01, 0xF8, 0x7C, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x0F, 0xE1, 0xF0, 0x00,
  0x1F, 0x83, 0xE0, 0x00, 0x7F, 0x07, 0xE0, 0x01, 0xBE, 0x0F, 0xE0, 0x07,
  0x7C, 0x0F, 0xE0, 0x7C, 0xFF, 0x9F, 0xFF, 0xF1, 0xFF, 0x1F, 0xFF, 0xE3,
  0xFE, 0x1F, 0xFF, 0x83, 0xFC, 0x1F, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x3F, 0x80, 0x03, 0xE0, 0xFF,
  0xE0, 0x03, 0xE3, 0xFF, 0xF0, 0x03, 0xE7, 0xFF, 0xF8, 0x07, 0xC7, 0xFF,
  0xFC, 0x07, 0xCF, 0x81, 0xFE, 0x07, 0xDE, 0x00, 0xFE, 0x07, 0xD8, 0x00,
  0x7E, 0x07, 0xF0, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x3F, 0x0F, 0xE0, 0x00,
  0x1F, 0x0F, 0xC0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x1F, 0x0F, 0x80, 0x00,
  0x1F, 0x0F, 0x80, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x3F, 0x1F, 0x00, 0x00,
  0x3F, 0x1F, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00,
  0x3E, 0x1F, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x7E, 0x3E, 0x00, 0x00,
  0x7C, 0x3E, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0xFC, 0x3E, 0x00, 0x00,
  0xF8, 0x3E, 0x00, 0x01, 0xF8, 0x7F, 0x00, 0x03, 0xF0, 0x7D, 0x80, 0x07,
  0xF0, 0x7D, 0xE0, 0x3F, 0xE0, 0x7C, 0xFF, 0xFF, 0xC0, 0x7C, 0xFF, 0xFF,
  0x80, 0x7C, 0x7F, 0xFF, 0x00, 0xF8, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0x80, 0xFE, 0x0F, 0xE0,
  0x03, 0xF1, 0xFC, 0x00, 0x1F, 0x1F, 0x80, 0x01, 0xF3, 0xF0, 0x00, 0x0C,
  0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x01, 0x8F, 0x80, 0x00,
  0x1E, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7E, 0x7C, 0x00, 0x0F, 0xC7,
  0xE0, 0x01, 0xF8, 0x7F, 0x00, 0x3F, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0xFF,
  0x01, 0xF0, 0x01, 0xFF, 0xE0, 0xF8, 0x03, 0xFF, 0xF8, 0x7C, 0x03, 0xFF,
  0xFE, 0x3E, 0x03, 0xFF, 0xFF, 0xBF, 0x03, 0xFE, 0x03, 0xDF, 0x01, 0xFC,
  0x00, 0x7F, 0x81, 0xF8, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x07, 0xE0, 0xFC,
  0x00, 0x03, 0xF0, 0x7C, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x00, 0xF8, 0x3E,
  0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x1F, 0x0F,
  0xC0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x07, 0xC1,
  0xF0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0xF8,
  0x3E, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x7E,
  0x07, 0xC0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x3F, 0x81, 0xF0, 0x00, 0x37,
  0xC0, 0xFC, 0x00, 0x3B, 0xE0, 0x7F, 0x00, 0x3B, 0xE0, 0x1F, 0xE0, 0x7D,
  0xF0, 0x0F, 0xFF, 0xFC, 0xF8, 0x03, 0xFF, 0xFC, 0x7C, 0x00, 0xFF, 0xFC,
  0x3E, 0x00, 0x3F, 0xFC, 0x1F, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0x03, 0xFE, 0x03, 0xF8, 0x3F, 0x80, 0x07, 0xE3,
  0xF8, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0xF9, 0xF8, 0x00, 0x07, 0xCF, 0x80,
  0x00, 0x3E, 0xFC, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1F, 0x3E, 0x00, 0x01,
  0xFB, 0xF0, 0x00, 0x3F, 0x9F, 0x80, 0x07, 0xF8, 0xF8, 0x0F, 0xFF, 0x07,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x10, 0xF8, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x1F, 0xBF, 0x00, 0x01, 0xF8,
  0xFC, 0x00, 0x1F, 0x87, 0xF0, 0x01, 0xFC, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xE0, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x7E, 0x00, 0x00, 0x07, 0xF0, 0x1F, 0x00, 0x00, 0x00, 0xFE, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0xC1, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x7C, 0x00, 0x00,
  0x00, 0x7F, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xEF, 0x80, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x07, 0xC0, 0x1F,
  0xFF, 0xC3, 0xE0, 0x1F, 0xFF, 0xF1, 0xF0, 0x1F, 0xFF, 0xFD, 0xF0, 0x1F,
  0xF0, 0x1E, 0xF8, 0x0F, 0xE0, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0xFE, 0x07,
  0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x0F, 0x83,
  0xF0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x01, 0xF0,
  0xFC, 0x00, 0x00, 0xF8, 0x7E, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x7C,
  0x1F, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x0F,
  0x83, 0xE0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x03,
  0xE0, 0x7C, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x03,
  0xFC, 0x0F, 0xC0, 0x03, 0xBE, 0x03, 0xF0, 0x03, 0xDF, 0x01, 0xFE, 0x07,
  0xDF, 0x00, 0xFF, 0xFF, 0xCF, 0x80, 0x3F, 0xFF, 0xC7, 0xC0, 0x0F, 0xFF,
  0xC3, 0xE0, 0x03, 0xFF, 0xC1, 0xF0, 0x00, 0x7F, 0x80, 0xF8, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x30,
  0x00, 0x1F, 0xC0, 0x3E, 0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x1F,
  0x07, 0xFF, 0x00, 0xF8, 0x7F, 0xFC, 0x07, 0xC7, 0xFF, 0xF0, 0x3E, 0x7F,
  0xFF, 0x81, 0xF7, 0xC1, 0xFE, 0x1F, 0xB8, 0x03, 0xF0, 0xFB, 0x80, 0x1F,
  0x87, 0xD8, 0x00, 0x7C, 0x3F, 0x80, 0x03, 0xE1, 0xF8, 0x00, 0x1F, 0x0F,
  0xC0, 0x00, 0xF8, 0xFC, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x3E, 0x3E, 0x00,
  0x01, 0xF1, 0xF0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x07,
  0xC7, 0xC0, 0x00, 0x3E, 0x3E, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x0F, 0x8F,
  0x80, 0x00, 0x7C, 0x7C, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3E, 0x3E, 0x00,
  0x01, 0xF1, 0xF0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x7C, 0x7C, 0x00, 0x03,
  0xE3, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x0F, 0x8F,
  0x80, 0x00, 0x7C, 0x7C, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x20, 0x01, 0xF0, 0x01, 0xC0, 0x07, 0xC0, 0x0F, 0x00, 0x1F,
  0x00, 0x7E, 0x00, 0x7C, 0x03, 0xFC, 0x03, 0xE0, 0x3F, 0xC0, 0x0F, 0x81,
  0xFC, 0x00, 0x3E, 0x0F, 0xE0, 0x00, 0xF8, 0x7F, 0x00, 0x03, 0xE3, 0xF8,
  0x00, 0x0F, 0xBF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x80, 0x03, 0xE0, 0x03, 0x00, 0x0F, 0x80, 0x1E, 0x00, 0x3E, 0x00, 0xFC,
  0x00, 0xF8, 0x03, 0xF8, 0x07, 0xC0, 0x07, 0xF0, 0x1F, 0x00, 0x0F, 0xE0,
  0x7C, 0x00, 0x1F, 0xC1, 0xF0, 0x00, 0x3F, 0x87, 0xC0, 0x00, 0x7F, 0x1F,
  0x00, 0x00, 0xFE, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x7F, 0x00, 0x07, 0xC1, 0xFF, 0xC0,
  0x07, 0xC3, 0xFF, 0xE0, 0x07, 0xC7, 0xFF, 0xF0, 0x07, 0xCF, 0xFF, 0xF0,
  0x07, 0xDF, 0x07, 0xF8, 0x0F, 0x9C, 0x01, 0xF8, 0x0F, 0xB8, 0x00, 0xF8,
  0x0F, 0xB0, 0x00, 0xF8, 0x0F, 0xE0, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0xF8,
  0x0F, 0xC0, 0x00, 0xF8, 0x1F, 0x80, 0x01, 0xF0, 0x1F, 0x80, 0x01, 0xF0,
  0x1F, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x3F, 0x80,
  0x1F, 0x00, 0xFF, 0x00, 0x3E, 0x07, 0xFC, 0x00, 0x3E, 0x3F, 0xF0, 0x00,
  0x3E, 0x1F, 0x80, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x04,
  0x3E, 0x0F, 0x80, 0x0E, 0x7C, 0x07, 0xC0, 0x1E, 0x7C, 0x07, 0xC0, 0x3F,
  0x7C, 0x07, 0xE0, 0x7F, 0x7C, 0x03, 0xE0, 0xFE, 0x7C, 0x03, 0xF1, 0xFC,
  0x7C, 0x01, 0xF3, 0xF8, 0xF8, 0x01, 0xFF, 0xF0, 0xF8, 0x00, 0xFF, 0xE0,
  0xF8, 0x00, 0xFF, 0xC0, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x01, 0x00, 0x7C, 0x00, 0x70, 0x0F, 0x80, 0x1F, 0x03, 0xE0,
  0x07, 0xF0, 0x7C, 0x03, 0xFC, 0x0F, 0x80, 0xFE, 0x01, 0xF0, 0x3F, 0x80,
  0x3E, 0x0F, 0xE0, 0x07, 0x83, 0xF8, 0x01, 0xF1, 0xFE, 0x00, 0x3E, 0x7F,
  0x80, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0xF9,
  0xFE, 0x0F, 0xF8, 0x1F, 0x7F, 0xE3, 0xFF, 0x83, 0xCF, 0xFC, 0x7F, 0xF0,
  0x7B, 0xFF, 0x9F, 0xFE, 0x1F, 0x71, 0xFF, 0x8F, 0xC3, 0xF8, 0x1F, 0xE0,
  0xF8, 0x7E, 0x03, 0xF8, 0x0F, 0x0F, 0xC0, 0x7E, 0x01, 0xE1, 0xF0, 0x0F,
  0x80, 0x3C, 0x3E, 0x01, 0xF0, 0x0F, 0x8F, 0x80, 0x3E, 0x01, 0xF1, 0xF0,
  0x07, 0x80, 0x3E, 0x3E, 0x00, 0xF0, 0x07, 0x87, 0xC0, 0x3E, 0x00, 0xF0,
  0xF8, 0x07, 0xC0, 0x1E, 0x1E, 0x00, 0xF8, 0x07, 0xC7, 0xC0, 0x1F, 0x00,
  0xF8, 0xF8, 0x03, 0xC0, 0x1F, 0x1F, 0x00, 0x78, 0x03, 0xC3, 0xE0, 0x1F,
  0x00, 0x78, 0x7C, 0x03, 0xE0, 0x0F, 0x0F, 0x00, 0x7C, 0x03, 0xE3, 0xE0,
  0x0F, 0x80, 0x7C, 0x7C, 0x01, 0xE0, 0x0F, 0x8F, 0x80, 0x3C, 0x01, 0xE1,
  0xF0, 0x0F, 0x80, 0x3C, 0x3E, 0x01, 0xF0, 0x07, 0x87, 0x80, 0x3E, 0x01,
  0xF1, 0xF0, 0x07, 0xC0, 0x3E, 0x3E, 0x00, 0xF0, 0x07, 0xC7, 0xC0, 0x1E,
  0x00, 0xF0, 0xF8, 0x07, 0xC0, 0x1E, 0x1E, 0x00, 0xF8, 0x07, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x3E, 0x0F, 0xFE, 0x01, 0xF0, 0xFF, 0xF8, 0x0F, 0x8F,
  0xFF, 0xE0, 0x7C, 0xFF, 0xFF, 0x03, 0xEF, 0x83, 0xFC, 0x3E, 0x70, 0x07,
  0xE1, 0xF7, 0x00, 0x3F, 0x0F, 0xB0, 0x00, 0xF8, 0x7F, 0x00, 0x07, 0xC3,
  0xF0, 0x00, 0x3E, 0x1F, 0x80, 0x01, 0xF1, 0xF8, 0x00, 0x0F, 0x8F, 0xC0,
  0x00, 0x7C, 0x7C, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x1F, 0x1F, 0x00, 0x01,
  0xF0, 0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x7C, 0x7C, 0x00, 0x03, 0xE3,
  0xE0, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0x87, 0xC0,
  0x00, 0x7C, 0x7C, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x1F, 0x1F, 0x00, 0x00,
  0xF8, 0xF8, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x03, 0xE3,
  0xE0, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x07, 0xC7, 0xC0,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xF0,
  0x1F, 0xC0, 0xFE, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x3E, 0x1F, 0x80, 0x00,
  0xFC, 0x7C, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x1F,
  0x7E, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x07, 0xDF,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x03, 0xEF, 0x80, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x01,
  0xF1, 0xF0, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x03, 0xF8,
  0x3F, 0x00, 0x1F, 0xC0, 0xFF, 0x01, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3E, 0x0F, 0xFE, 0x00,
  0x0F, 0x8F, 0xFF, 0xC0, 0x07, 0xE7, 0xFF, 0xF8, 0x01, 0xF1, 0xFF, 0xFF,
  0x00, 0x7C, 0xF8, 0x1F, 0xE0, 0x1F, 0x78, 0x03, 0xF8, 0x07, 0xD8, 0x00,
  0x7E, 0x01, 0xFC, 0x00, 0x0F, 0x80, 0xFE, 0x00, 0x03, 0xF0, 0x3F, 0x80,
  0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0xF8,
  0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x3F, 0x07,
  0xC0, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0xF8,
  0x1F, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x07,
  0xE0, 0xF8, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00,
  0x3F, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x07, 0xE0, 0x7F, 0x00,
  0x03, 0xF0, 0x1F, 0x60, 0x01, 0xFC, 0x07, 0xDE, 0x03, 0xFE, 0x01, 0xF3,
  0xFF, 0xFF, 0x00, 0x7C, 0xFF, 0xFF, 0x80, 0x1F, 0x1F, 0xFF, 0xC0, 0x0F,
  0x83, 0xFF, 0xC0, 0x03, 0xE0, 0x1F, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x7C, 0x07, 0xFF, 0xF0, 0xF8, 0x1F,
  0xFF, 0xF1, 0xF0, 0x7F, 0xFF, 0xF7, 0xC1, 0xFF, 0x01, 0xEF, 0x83, 0xF8,
  0x00, 0xFF, 0x0F, 0xC0, 0x00, 0xFE, 0x1F, 0x80, 0x00, 0xFC, 0x7E, 0x00,
  0x01, 0xF8, 0xF8, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x07, 0xC7, 0xC0, 0x00,
  0x0F, 0x8F, 0x80, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00,
  0x7C, 0xF8, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x07,
  0xC7, 0xC0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x7E,
  0x3E, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x07, 0xE1,
  0xF0, 0x00, 0x1F, 0xC3, 0xE0, 0x00, 0x6F, 0x87, 0xE0, 0x01, 0xDF, 0x0F,
  0xE0, 0x07, 0x7C, 0x0F, 0xF0, 0x3E, 0xF8, 0x1F, 0xFF, 0xF9, 0xF0, 0x1F,
  0xFF, 0xE3, 0xE0, 0x1F, 0xFF, 0x87, 0xC0, 0x1F, 0xFE, 0x0F, 0x80, 0x0F,
  0xF0, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x1F, 0xFB, 0xFF, 0xF8,
  0xFF, 0xF7, 0xFF, 0xE3, 0xFF, 0xEF, 0xFF, 0xCF, 0xFF, 0xC0, 0x0F, 0x9E,
  0x00, 0x00, 0x1F, 0x70, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0x80, 0x3F, 0xC0, 0xFC, 0x00,
  0x1F, 0x03, 0xE0, 0x00, 0x0C, 0x07, 0xC0, 0x00, 0x10, 0x0F, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x20,
  0x00, 0x01, 0xF0, 0x60, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x0F, 0x8F, 0xF0,
  0x00, 0x7F, 0x0F, 0xF8, 0x03, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x60, 0x0F, 0x80, 0x0F, 0x00, 0xFC, 0x00, 0xFC, 0x07, 0xC0, 0x1F,
  0xF0, 0x3E, 0x01, 0xFE, 0x01, 0xF0, 0x3F, 0xE0, 0x0F, 0x83, 0xFC, 0x00,
  0x7C, 0x7F, 0xC0, 0x03, 0xE7, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x3E, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x0F,
  0x87, 0xC0, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x03, 0xE1,
  0xF0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x7E, 0x1F, 0x00, 0x01, 0xF0, 0xF8,
  0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x7C, 0x3E, 0x00,
  0x01, 0xF0, 0xF8, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x00,
  0xF8, 0x7C, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x3E,
  0x1F, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x1F, 0x0F,
  0x80, 0x00, 0xFC, 0x3E, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x1F, 0xC3, 0xF0,
  0x00, 0xFF, 0x0F, 0xC0, 0x06, 0xF8, 0x1F, 0x80, 0x3B, 0xE0, 0x7F, 0x03,
  0xCF, 0x81, 0xFF, 0xFE, 0x3E, 0x03, 0xFF, 0xF8, 0xF8, 0x07, 0xFF, 0xC7,
  0xE0, 0x0F, 0xFE, 0x1F, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x18, 0xFF, 0xF0, 0x01, 0xF1, 0xFF, 0xC0, 0x03, 0xF7, 0xFF, 0x80, 0x03,
  0xEF, 0xFF, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x1F,
  0x00, 0xF8, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x7E, 0x03, 0xC0, 0x00, 0xFC,
  0x0F, 0x80, 0x01, 0xF8, 0x1F, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x07, 0xC0,
  0x7C, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x3E, 0x03,
  0xC0, 0x00, 0xFC, 0x0F, 0x80, 0x01, 0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x3E,
  0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x7E, 0x01, 0xF0,
  0x00, 0xF8, 0x07, 0xC0, 0x03, 0xF0, 0x0F, 0x80, 0x0F, 0xC0, 0x1F, 0x00,
  0x3F, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x7C, 0x07, 0xF0, 0x00, 0xF8, 0x1F,
  0xC0, 0x01, 0xF1, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x7C,
  0x03, 0x07, 0x80, 0x3C, 0x0F, 0x87, 0xC0, 0x1E, 0x03, 0xC3, 0xE0, 0x0F,
  0x01, 0xF1, 0xF0, 0x0F, 0x80, 0xF8, 0xF0, 0x07, 0xC0, 0x7C, 0x78, 0x03,
  0xC0, 0x1E, 0x3C, 0x01, 0xE0, 0x0F, 0x1E, 0x00, 0xF0, 0x07, 0x9F, 0x00,
  0xF8, 0x03, 0xCF, 0x80, 0x7C, 0x01, 0xE7, 0xC0, 0x3E, 0x00, 0xF3, 0xC0,
  0x1E, 0x00, 0x79, 0xE0, 0x0F, 0x00, 0x3C, 0xF0, 0x07, 0x80, 0x3E, 0xF8,
  0x07, 0xC0, 0x1F, 0x7C, 0x03, 0xE0, 0x0F, 0xBE, 0x01, 0xF0, 0x07, 0xDE,
  0x00, 0xF0, 0x03, 0xCF, 0x00, 0x78, 0x03, 0xE7, 0x80, 0x3C, 0x01, 0xF7,
  0xC0, 0x3E, 0x00, 0xFB, 0xE0, 0x1F, 0x00, 0xF9, 0xF0, 0x0F, 0x80, 0x7C,
  0xF0, 0x0F, 0xC0, 0x3E, 0x78, 0x07, 0xE0, 0x3E, 0x3C, 0x07, 0xF0, 0x3F,
  0x1F, 0x07, 0x78, 0x1F, 0x0F, 0xC7, 0xBE, 0x3F, 0x87, 0xFF, 0x9F, 0xFF,
  0x83, 0xFF, 0xCF, 0xFF, 0x80, 0xFF, 0xC3, 0xFF, 0x80, 0x7F, 0xC1, 0xFF,
  0x80, 0x0F, 0x80, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x00,
  0x7F, 0x80, 0x7F, 0xC0, 0x03, 0xFF, 0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x3F,
  0xFE, 0x00, 0xFF, 0xF0, 0xFF, 0xF8, 0x0F, 0xF3, 0xE7, 0xC3, 0xF0, 0x7F,
  0x0F, 0x9E, 0x07, 0xC3, 0xF8, 0x3E, 0xF0, 0x1F, 0x1F, 0x80, 0x7B, 0x80,
  0x7C, 0x3C, 0x01, 0xEE, 0x01, 0xF0, 0xC0, 0x07, 0xF0, 0x07, 0xC0, 0x00,
  0x1F, 0xC0, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0x80, 0x1F, 0xC0, 0x00, 0x1E, 0x00, 0x7F, 0x00, 0x20,
  0xF8, 0x03, 0xBC, 0x00, 0xC3, 0xE0, 0x0E, 0xF0, 0x0F, 0x8F, 0x80, 0x73,
  0xC0, 0x7E, 0x3E, 0x03, 0xCF, 0x07, 0xF0, 0x7C, 0x0F, 0x3C, 0x3F, 0x81,
  0xF0, 0xF8, 0xFB, 0xFC, 0x07, 0xFF, 0xE3, 0xFF, 0xE0, 0x1F, 0xFF, 0x0F,
  0xFE, 0x00, 0x3F, 0xF8, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x00,
  0xFC, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0xF8, 0x00,
  0x0F, 0xC0, 0x7C, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x03, 0xE0, 0x3E, 0x00,
  0x01, 0xF0, 0x1F, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x7C, 0x07, 0xC0,
  0x00, 0x7E, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x1F, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0xF8, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x03, 0xE0, 0x3E,
  0x00, 0x03, 0xF0, 0x1F, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0xF8, 0x0F,
  0x80, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3F, 0x01,
  0xF0, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x0F, 0xC0,
  0x7E, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x05, 0xF0, 0x1F, 0x80, 0x07, 0xF8,
  0x07, 0xC0, 0x06, 0xFC, 0x03, 0xF0, 0x07, 0x7C, 0x01, 0xFE, 0x0F, 0x3E,
  0x00, 0xFF, 0xFF, 0x9F, 0x00, 0x3F, 0xFF, 0x8F, 0x80, 0x0F, 0xFF, 0x87,
  0xC0, 0x03, 0xFF, 0x87, 0xE0, 0x00, 0x7F, 0x03, 0xE0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x60, 0x00,
  0x3F, 0x00, 0x78, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0xF8, 0x07, 0xC0, 0xFF, 0xFF, 0x07, 0xE0, 0x7F, 0xFF, 0xE3, 0xE0,
  0x7F, 0xFF, 0xF9, 0xF0, 0x7F, 0x03, 0xFF, 0xF8, 0x3E, 0x00, 0x3F, 0xFC,
  0x1E, 0x00, 0x07, 0xFC, 0x0F, 0x00, 0x00, 0xFC, 0x07, 0x80, 0x00, 0xFC,
  0x03, 0xC0, 0x01, 0xF8, 0x01, 0xE0, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x03, 0x00, 0x03, 0xF0,
  0x07, 0x80, 0x03, 0xF0, 0x01, 0xE0, 0x03, 0xF0, 0x00, 0xF0, 0x07, 0xE0,
  0x00, 0x7C, 0x07, 0xE0, 0x00, 0x3E, 0x07, 0xF0, 0x00, 0x1F, 0x07, 0xFF,
  0x80, 0x07, 0x87, 0xFF, 0xFE, 0x03, 0xC3, 0xFF, 0xFF, 0xF1, 0xF1, 0xF1,
  0xFF, 0xFF, 0xF0, 0xF8, 0x1F, 0xFF, 0xF8, 0xFC, 0x01, 0xFF, 0xF8, 0x7C,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03,
  0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF0, 0x03, 0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0x80, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x06, 0x00, 0xFF,
  0x00, 0x03, 0xC0, 0xFF, 0xC0, 0x01, 0xE0, 0xFF, 0xF0, 0x01, 0xF0, 0xFF,
  0xFC, 0x00, 0xF0, 0xFC, 0x7E, 0x00, 0xF8, 0x7C, 0x1F, 0x80, 0x7C, 0x7C,
  0x07, 0xC0, 0x7C, 0x3C, 0x01, 0xF0, 0x3E, 0x3E, 0x00, 0xFC, 0x7E, 0x1F,
  0x00, 0x3F, 0xFE, 0x0F, 0x00, 0x1F, 0xFF, 0x0F, 0x80, 0x07, 0xFF, 0x07,
  0x80, 0x01, 0xFF, 0x00, 0xC0, 0x00, 0x3E, 0x00,
};

const GFXglyph IBMPlexMono_Italic64pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 38, 0, -1 },
  { 1, 15, 46, 38, 12, -45 },
  { 88, 18, 18, 38, 14, -47 },
  { 129, 39, 45, 38, 1, -45 },
  { 349, 36, 58, 38, 1, -51 },
  { 610, 44, 46, 38, -2, -45 },
  { 863, 38, 46, 38, 0, -45 },
  { 1082, 8, 18, 38, 19, -47 },
  { 1100, 24, 58, 38, 13, -49 },
  { 1274, 23, 58, 38, 3, -49 },
  { 1441, 32, 32, 38, 4, -35 },
  { 1569, 31, 31, 38, 4, -35 },
  { 1690, 14, 18, 38, 9, -9 },
  { 1722, 19, 5, 38, 10, -22 },
  { 1734, 10, 9, 38, 12, -8 },
  { 1746, 36, 58, 38, 2, -49 },
  { 2007, 32, 46, 38, 4, -45 },
  { 2191, 30, 45, 38, 3, -45 },
  { 2360, 33, 45, 38, 2, -45 },
  { 2546, 33, 46, 38, 2, -45 },
  { 2736, 34, 45, 38, 1, -45 },
  { 2928, 34, 46, 38, 3, -45 },
  { 3124, 30, 46, 38, 4, -45 },
  { 3297, 32, 45, 38, 7, -45 },
  { 3477, 33, 46, 38, 3, -45 },
  { 3667, 30, 45, 38, 6, -45 },
  { 3836, 14, 34, 38, 12, -33 },
  { 3896, 17, 42, 38, 9, -33 },
  { 3986, 30, 37, 38, 6, -38 },
  { 4125, 33, 17, 38, 3, -28 },
  { 4196, 31, 37, 38, 3, -38 },
  { 4340, 28, 46, 38, 8, -45 },
  { 4501, 32, 52, 38, 4, -45 },
  { 4709, 35, 45, 38, -1, -45 },
  { 4906, 33, 45, 38, 3, -45 },
  { 5092, 32, 46, 38, 5, -45 },
  { 5276, 32, 45, 38, 4, -45 },
  { 5456, 35, 45, 38, 3, -45 },
  { 5653, 36, 45, 38, 3, -45 },
  { 5856, 32, 46, 38, 4, -45 },
  { 6040, 36, 45, 38, 2, -45 },
  { 6243, 35, 45, 38, 3, -45 },
  { 6440, 31, 46, 38, 4, -45 },
  { 6619, 38, 45, 38, 3, -45 },
  { 6833, 27, 45, 38, 5, -45 },
  { 6985, 37, 45, 38, 2, -45 },
  { 7194, 36, 45, 38, 2, -45 },
  { 7397, 32, 46, 38, 4, -45 },
  { 7581, 34, 45, 38, 3, -45 },
  { 7773, 32, 57, 38, 4, -45 },
  { 8001, 34, 45, 38, 3, -45 },
  { 8193, 35, 46, 38, 2, -45 },
  { 8395, 36, 45, 38, 6, -45 },
  { 8598, 33, 46, 38, 5, -45 },
  { 8788, 34, 45, 38, 7, -45 },
  { 8980, 38, 45, 38, 3, -45 },
  { 9194, 42, 45, 38, -1, -45 },
  { 9431, 36, 45, 38, 6, -45 },
  { 9634, 39, 45, 38, 0, -45 },
  { 9854, 28, 58, 38, 10, -49 },
  { 10057, 16, 58, 38, 12, -49 },
  { 10173, 27, 58, 38, 1, -49 },
  { 10369, 33, 26, 38, 4, -45 },
  { 10477, 31, 5, 38, 0, 6 },
  { 10497, 8, 12, 38, 15, -49 },
  { 10509, 31, 35, 38, 4, -34 },
  { 10645, 32, 48, 38, 3, -47 },
  { 10837, 28, 35, 38, 5, -34 },
  { 10960, 33, 48, 38, 4, -47 },
  { 11158, 29, 35, 38, 5, -34 },
  { 11285, 42, 61, 38, -1, -47 },
  { 11606, 33, 48, 38, 2, -34 },
  { 11804, 29, 47, 38, 4, -47 },
  { 11975, 30, 48, 38, 5, -47 },
  { 12155, 30, 61, 38, 4, -47 },
  { 12384, 32, 48, 38, 4, -47 },
  { 12576, 27, 48, 38, 7, -47 },
  { 12738, 35, 34, 38, 1, -34 },
  { 12887, 29, 34, 38, 4, -34 },
  { 13011, 30, 35, 38, 4, -34 },
  { 13143, 34, 47, 38, 1, -34 },
  { 13343, 31, 47, 38, 4, -34 },
  { 13526, 31, 33, 38, 7, -33 },
  { 13654, 31, 35, 38, 3, -34 },
  { 13790, 29, 46, 38, 5, -45 },
  { 13957, 30, 34, 38, 5, -33 },
  { 14085, 31, 34, 38, 4, -33 },
  { 14217, 33, 34, 38, 3, -33 },
  { 14358, 38, 35, 38, 0, -34 },
  { 14525, 33, 47, 38, 2, -33 },
  { 14719, 33, 35, 38, 3, -34 },
  { 14864, 30, 58, 38, 7, -49 },
  { 15082, 14, 58, 38, 13, -49 },
  { 15184, 30, 58, 38, 3, -49 },
  { 15402, 33, 15, 38, 3, -27 },
};

const GFXfont IBMPlexMono_Italic64pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Italic64pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Italic64pt7bGlyphs,
  0x20, 0x7E, 83
};

#endif // _IBMPLEXMONO_ITALIC64PT7B_H_
